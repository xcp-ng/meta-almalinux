# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sssd"
PV = "2.12.0"
PR = "3.el10_2.1"
PACKAGES = " \
 libipa_hbac \
 libsss_autofs \
 libsss_certmap \
 libsss_idmap \
 libsss_nss_idmap \
 libsss_nss_idmap-devel \
 libsss_sudo \
 python3-libipa_hbac \
 python3-libsss_nss_idmap \
 python3-sss \
 python3-sss-murmur \
 python3-sssdconfig \
 sssd \
 sssd-ad \
 sssd-client \
 sssd-common \
 sssd-common-pac \
 sssd-dbus \
 sssd-idp \
 sssd-ipa \
 sssd-kcm \
 sssd-krb5 \
 sssd-krb5-common \
 sssd-ldap \
 sssd-nfs-idmap \
 sssd-passkey \
 sssd-proxy \
 sssd-tools \
 sssd-winbind-idmap \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/sssd-2.12.0-3.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b78d9da2eef1c4b02a17400fb165513d294c5d5b860e63dcd0ba45a7fffa38e2"

URI_x86_64_v2_libipa_hbac = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libipa_hbac-2.12.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_libipa_hbac;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libipa_hbac}"
SRC_URI[x86_64_v2_libipa_hbac.sha256sum] = "6e69dfa3d4363e2ea1fd3f3f872fc39cee6a1e19b0b25e0c1e2d1d401d8b8abe"

URI_x86_64_v2_libsss_autofs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsss_autofs-2.12.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_libsss_autofs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsss_autofs}"
SRC_URI[x86_64_v2_libsss_autofs.sha256sum] = "8551bebdb46ad9ac995cc4c415151f374d29812033b0d28e0912af97f74315e9"

URI_x86_64_v2_libsss_certmap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsss_certmap-2.12.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_libsss_certmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsss_certmap}"
SRC_URI[x86_64_v2_libsss_certmap.sha256sum] = "6f779093bcba6af846e515dd68b967f73c445c554227797bbe4da3f5318c4f98"

URI_x86_64_v2_libsss_idmap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsss_idmap-2.12.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_libsss_idmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsss_idmap}"
SRC_URI[x86_64_v2_libsss_idmap.sha256sum] = "f47a80d439ea0a08f4c1096ca3fd9dba6a7c59a93b2ba09934608d00aeee75f6"

URI_x86_64_v2_libsss_nss_idmap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsss_nss_idmap-2.12.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_libsss_nss_idmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsss_nss_idmap}"
SRC_URI[x86_64_v2_libsss_nss_idmap.sha256sum] = "9b48dc407466287940ef35e17f0b64cc373bb7dd5b2ff03b17d3ab710935c7d1"

URI_x86_64_v2_libsss_nss_idmap-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsss_nss_idmap-devel-2.12.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_libsss_nss_idmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsss_nss_idmap-devel}"
SRC_URI[x86_64_v2_libsss_nss_idmap-devel.sha256sum] = "42aa3d411b8d2e7a52ce9e65d86ee0b2f4ba796374f4dd886998c68d48bf67a0"

URI_x86_64_v2_libsss_sudo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsss_sudo-2.12.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_libsss_sudo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsss_sudo}"
SRC_URI[x86_64_v2_libsss_sudo.sha256sum] = "c8d0b4662811857805ba948601999ca64fbac0de8dadd1eb5df287c8a0f59f96"

URI_x86_64_v2_python3-libipa_hbac = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-libipa_hbac-2.12.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_python3-libipa_hbac;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libipa_hbac}"
SRC_URI[x86_64_v2_python3-libipa_hbac.sha256sum] = "d10163f467bdbf32e8adbe0518395d21f2cbec95195723e33f601bb20165abfb"

URI_x86_64_v2_python3-libsss_nss_idmap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-libsss_nss_idmap-2.12.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_python3-libsss_nss_idmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libsss_nss_idmap}"
SRC_URI[x86_64_v2_python3-libsss_nss_idmap.sha256sum] = "da89a4cbd0880a86d596c9d6c7c7e6cb6a814b9042ab162e8b31d88202582bc3"

URI_x86_64_v2_python3-sss = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-sss-2.12.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_python3-sss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sss}"
SRC_URI[x86_64_v2_python3-sss.sha256sum] = "48f1492b62186c8bad89848510e4290f43d63909cf829b5faea0d02f383dfb66"

URI_x86_64_v2_python3-sss-murmur = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-sss-murmur-2.12.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_python3-sss-murmur;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sss-murmur}"
SRC_URI[x86_64_v2_python3-sss-murmur.sha256sum] = "67610dae5fb575992749a92e5d26c5d1c7e1bfe463efb2f47802263d50d36bb5"

URI_x86_64_v2_python3-sssdconfig = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-sssdconfig-2.12.0-3.el10_2.1.noarch.rpm;name=x86_64_v2_python3-sssdconfig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sssdconfig}"
SRC_URI[x86_64_v2_python3-sssdconfig.sha256sum] = "97aa0de44b32e63e88a236df6854bf5957705d52ff85b53e0fe22b205f23188a"

URI_x86_64_v2_sssd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-2.12.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_sssd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd}"
SRC_URI[x86_64_v2_sssd.sha256sum] = "03e283db823512990d6edf06de38064049c950c8db79eadc9d9002c995ffbe7d"

URI_x86_64_v2_sssd-ad = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-ad-2.12.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_sssd-ad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-ad}"
SRC_URI[x86_64_v2_sssd-ad.sha256sum] = "37978c9c65ee40dd1ca52419946c953d93e47075fcaa155fa57f0d59a944baf1"

URI_x86_64_v2_sssd-client = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-client-2.12.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_sssd-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-client}"
SRC_URI[x86_64_v2_sssd-client.sha256sum] = "add26586c707b463384d41b60989276509ec2357d037858c3e62fc3325aad4e0"

URI_x86_64_v2_sssd-common = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-common-2.12.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_sssd-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-common}"
SRC_URI[x86_64_v2_sssd-common.sha256sum] = "7dc69f7d3ab63114723b302d6673facb37fe8806e6e3a1f5338164bcf9c0df73"

URI_x86_64_v2_sssd-common-pac = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-common-pac-2.12.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_sssd-common-pac;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-common-pac}"
SRC_URI[x86_64_v2_sssd-common-pac.sha256sum] = "7ff76ef3f3a4b6be2b17b8676d9c78fbcb29385e5abf4de623074b016b2f0db6"

URI_x86_64_v2_sssd-dbus = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-dbus-2.12.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_sssd-dbus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-dbus}"
SRC_URI[x86_64_v2_sssd-dbus.sha256sum] = "6fbe415d605ba80e3242f081bb482fbc7280e083d30946d8a8d477c19486d933"

URI_x86_64_v2_sssd-idp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sssd-idp-2.12.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_sssd-idp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-idp}"
SRC_URI[x86_64_v2_sssd-idp.sha256sum] = "0a14e8e926cbd609f179ef9a3358eecc5a26ccfc3456ccf74d4aa148f3e2ef21"

URI_x86_64_v2_sssd-ipa = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-ipa-2.12.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_sssd-ipa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-ipa}"
SRC_URI[x86_64_v2_sssd-ipa.sha256sum] = "1a5cd2e32e3c5b933597e90fef74f666532367624167669a338b5b37abc3744d"

URI_x86_64_v2_sssd-kcm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-kcm-2.12.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_sssd-kcm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-kcm}"
SRC_URI[x86_64_v2_sssd-kcm.sha256sum] = "6ba1c1d34e440695b436c205582fe6be55990e875492327b2a10a11a38f2d6e8"

URI_x86_64_v2_sssd-krb5 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-krb5-2.12.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_sssd-krb5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-krb5}"
SRC_URI[x86_64_v2_sssd-krb5.sha256sum] = "5db59e56db2a0d77638de8c1cd911df0cb3709253975bdcb8b24ab8e2457d0b1"

URI_x86_64_v2_sssd-krb5-common = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-krb5-common-2.12.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_sssd-krb5-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-krb5-common}"
SRC_URI[x86_64_v2_sssd-krb5-common.sha256sum] = "038ed23484387cfd7626184e30601f5fe8f8a5395f42bf630956d1fdba4ddcb0"

URI_x86_64_v2_sssd-ldap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-ldap-2.12.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_sssd-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-ldap}"
SRC_URI[x86_64_v2_sssd-ldap.sha256sum] = "465d4b74b466a119854bda5af281112c0f4ba7093a8fe7c85805f8f5da5aa143"

URI_x86_64_v2_sssd-nfs-idmap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-nfs-idmap-2.12.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_sssd-nfs-idmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-nfs-idmap}"
SRC_URI[x86_64_v2_sssd-nfs-idmap.sha256sum] = "91f0d672829d32862bb1ada8bdff9ea01a9f964645b75332b270dfc06688e2dc"

URI_x86_64_v2_sssd-passkey = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-passkey-2.12.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_sssd-passkey;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-passkey}"
SRC_URI[x86_64_v2_sssd-passkey.sha256sum] = "4b328fddda4daae690df3dc2058ad077317ba3b0721d6deed8f5ba35d655b85e"

URI_x86_64_v2_sssd-proxy = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-proxy-2.12.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_sssd-proxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-proxy}"
SRC_URI[x86_64_v2_sssd-proxy.sha256sum] = "d156521052cac2d067f8a1c89b75049d2aa24af1d049ed32befa47e3a33ff9c5"

URI_x86_64_v2_sssd-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-tools-2.12.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_sssd-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-tools}"
SRC_URI[x86_64_v2_sssd-tools.sha256sum] = "b398258ea9fff7314043ae67ace25010091fdd1dc5cde2ca9428534a74ac2d55"

URI_x86_64_v2_sssd-winbind-idmap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-winbind-idmap-2.12.0-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_sssd-winbind-idmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-winbind-idmap}"
SRC_URI[x86_64_v2_sssd-winbind-idmap.sha256sum] = "8ed770c72a96a641a5e50533b5daff77da06351b93f5b40fdacc19183bb6c3b8"

URI_aarch64_libipa_hbac = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libipa_hbac-2.12.0-3.el10_2.1.aarch64.rpm;name=aarch64_libipa_hbac;unpack=0"
SRC_URI:append = " ${URI_aarch64_libipa_hbac}"
SRC_URI[aarch64_libipa_hbac.sha256sum] = "afc16958e8afb978a3b340762d541eac3611b9c0c2dfd813c2829ac44c40a0ed"

URI_aarch64_libsss_autofs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsss_autofs-2.12.0-3.el10_2.1.aarch64.rpm;name=aarch64_libsss_autofs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsss_autofs}"
SRC_URI[aarch64_libsss_autofs.sha256sum] = "90bed68a847f7bbd2051a2c955259fa90b508833a8d82d503d962ef171cc4930"

URI_aarch64_libsss_certmap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsss_certmap-2.12.0-3.el10_2.1.aarch64.rpm;name=aarch64_libsss_certmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsss_certmap}"
SRC_URI[aarch64_libsss_certmap.sha256sum] = "7a20af02fd37a565dcd725a3bc7aaf526db63d43ca39c1c56894cb95ebccaab6"

URI_aarch64_libsss_idmap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsss_idmap-2.12.0-3.el10_2.1.aarch64.rpm;name=aarch64_libsss_idmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsss_idmap}"
SRC_URI[aarch64_libsss_idmap.sha256sum] = "768139778d487d5d3dd9f7bddfdf9a249fc434e4b003d2e4ae3787aa9472e821"

URI_aarch64_libsss_nss_idmap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsss_nss_idmap-2.12.0-3.el10_2.1.aarch64.rpm;name=aarch64_libsss_nss_idmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsss_nss_idmap}"
SRC_URI[aarch64_libsss_nss_idmap.sha256sum] = "242e953c506cabaad6ff38f870006b4682f7b0f012160ad167b6e4b93bacabb0"

URI_aarch64_libsss_nss_idmap-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsss_nss_idmap-devel-2.12.0-3.el10_2.1.aarch64.rpm;name=aarch64_libsss_nss_idmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsss_nss_idmap-devel}"
SRC_URI[aarch64_libsss_nss_idmap-devel.sha256sum] = "058c81ca4b39907b7a204f71bbb276db0e8b0cf32bf36c02349215b01d6d0dc2"

URI_aarch64_libsss_sudo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsss_sudo-2.12.0-3.el10_2.1.aarch64.rpm;name=aarch64_libsss_sudo;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsss_sudo}"
SRC_URI[aarch64_libsss_sudo.sha256sum] = "6aed5261e7ddb28bb4a421c299cc9cd876b2ce67bc73756a70200345218cc96e"

URI_aarch64_python3-libipa_hbac = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-libipa_hbac-2.12.0-3.el10_2.1.aarch64.rpm;name=aarch64_python3-libipa_hbac;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libipa_hbac}"
SRC_URI[aarch64_python3-libipa_hbac.sha256sum] = "c2fb4cf9cd604d001690ee238fb479ae0e90bd1e159c3a01e9ff0a5ddb39cd6f"

URI_aarch64_python3-libsss_nss_idmap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-libsss_nss_idmap-2.12.0-3.el10_2.1.aarch64.rpm;name=aarch64_python3-libsss_nss_idmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libsss_nss_idmap}"
SRC_URI[aarch64_python3-libsss_nss_idmap.sha256sum] = "84acfb6fa4f571f68d8611da2aec4fed292b6ef6e2bb0b3d6ca1e62d75d77549"

URI_aarch64_python3-sss = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-sss-2.12.0-3.el10_2.1.aarch64.rpm;name=aarch64_python3-sss;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sss}"
SRC_URI[aarch64_python3-sss.sha256sum] = "b0a9b9cf9db5f6b7ba5c4eabe2f5071d579d28d314c90faf50d37490b36d86b9"

URI_aarch64_python3-sss-murmur = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-sss-murmur-2.12.0-3.el10_2.1.aarch64.rpm;name=aarch64_python3-sss-murmur;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sss-murmur}"
SRC_URI[aarch64_python3-sss-murmur.sha256sum] = "7738a3f2b356568012f8e186fc88ab45c4ee77e4d063a8570e96d78e4ddee54d"

URI_aarch64_python3-sssdconfig = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-sssdconfig-2.12.0-3.el10_2.1.noarch.rpm;name=aarch64_python3-sssdconfig;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sssdconfig}"
SRC_URI[aarch64_python3-sssdconfig.sha256sum] = "97aa0de44b32e63e88a236df6854bf5957705d52ff85b53e0fe22b205f23188a"

URI_aarch64_sssd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-2.12.0-3.el10_2.1.aarch64.rpm;name=aarch64_sssd;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd}"
SRC_URI[aarch64_sssd.sha256sum] = "00eee42d415e778dff060bf8f86002bdf0fdbb23b5f52c6b42c363c5f1842c62"

URI_aarch64_sssd-ad = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-ad-2.12.0-3.el10_2.1.aarch64.rpm;name=aarch64_sssd-ad;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-ad}"
SRC_URI[aarch64_sssd-ad.sha256sum] = "fd59a8157cb2c0dd9185896111d33780fd48689af8eb20405d06c4c721c869dd"

URI_aarch64_sssd-client = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-client-2.12.0-3.el10_2.1.aarch64.rpm;name=aarch64_sssd-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-client}"
SRC_URI[aarch64_sssd-client.sha256sum] = "785d9f7ab1b54c45ce7226fe0cacd0c29aed0ef82ee82c21640adcda3d6de49f"

URI_aarch64_sssd-common = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-common-2.12.0-3.el10_2.1.aarch64.rpm;name=aarch64_sssd-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-common}"
SRC_URI[aarch64_sssd-common.sha256sum] = "89134e87fef44217656e20b6b737af4594290f8dd5435ba230a13adc3dc48bee"

URI_aarch64_sssd-common-pac = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-common-pac-2.12.0-3.el10_2.1.aarch64.rpm;name=aarch64_sssd-common-pac;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-common-pac}"
SRC_URI[aarch64_sssd-common-pac.sha256sum] = "7827641498159345c3dbedcef5285f8c30046248f395cf403e438d1935a51d0a"

URI_aarch64_sssd-dbus = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-dbus-2.12.0-3.el10_2.1.aarch64.rpm;name=aarch64_sssd-dbus;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-dbus}"
SRC_URI[aarch64_sssd-dbus.sha256sum] = "7e9acf09cc3b30cf8b682828b8eee10ebffa6ce2946699e39f98b4ce07585bfe"

URI_aarch64_sssd-idp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sssd-idp-2.12.0-3.el10_2.1.aarch64.rpm;name=aarch64_sssd-idp;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-idp}"
SRC_URI[aarch64_sssd-idp.sha256sum] = "fe01b23630989fb7fdbd7deb9c9fd7392135a60c9dce430c1e799e3b6b7403ac"

URI_aarch64_sssd-ipa = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-ipa-2.12.0-3.el10_2.1.aarch64.rpm;name=aarch64_sssd-ipa;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-ipa}"
SRC_URI[aarch64_sssd-ipa.sha256sum] = "486c05da1d2106ae14db47f8fd048d633edd58b6412b3dca2b9e9111e123c72b"

URI_aarch64_sssd-kcm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-kcm-2.12.0-3.el10_2.1.aarch64.rpm;name=aarch64_sssd-kcm;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-kcm}"
SRC_URI[aarch64_sssd-kcm.sha256sum] = "9b7cab15d4c6dde73ce1ae992d4ee1ab3ece6c9f0730fbc16a55d9ef0873c2d4"

URI_aarch64_sssd-krb5 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-krb5-2.12.0-3.el10_2.1.aarch64.rpm;name=aarch64_sssd-krb5;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-krb5}"
SRC_URI[aarch64_sssd-krb5.sha256sum] = "fbf950df00612329637306c30b4ef5006e8cb0f7142da60ebfbb4b2208cc73c5"

URI_aarch64_sssd-krb5-common = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-krb5-common-2.12.0-3.el10_2.1.aarch64.rpm;name=aarch64_sssd-krb5-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-krb5-common}"
SRC_URI[aarch64_sssd-krb5-common.sha256sum] = "65764f8963b6b7c3a4073bce87e546062032bc831156f2fda27e115b26a2bae6"

URI_aarch64_sssd-ldap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-ldap-2.12.0-3.el10_2.1.aarch64.rpm;name=aarch64_sssd-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-ldap}"
SRC_URI[aarch64_sssd-ldap.sha256sum] = "cf17de1d802f4bf4105b28b97c1b2d49234aab40a464c1ea33d6fe325e9e19b7"

URI_aarch64_sssd-nfs-idmap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-nfs-idmap-2.12.0-3.el10_2.1.aarch64.rpm;name=aarch64_sssd-nfs-idmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-nfs-idmap}"
SRC_URI[aarch64_sssd-nfs-idmap.sha256sum] = "c979ab5267e5537a2ad7eb3e455bf3d8de7439e1d0d6ce1547d1d2ae431f3951"

URI_aarch64_sssd-passkey = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-passkey-2.12.0-3.el10_2.1.aarch64.rpm;name=aarch64_sssd-passkey;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-passkey}"
SRC_URI[aarch64_sssd-passkey.sha256sum] = "be3e07f83adc1ff1c8498285c5ae1a9a0b96d36b867e34a4221e1379b6120074"

URI_aarch64_sssd-proxy = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-proxy-2.12.0-3.el10_2.1.aarch64.rpm;name=aarch64_sssd-proxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-proxy}"
SRC_URI[aarch64_sssd-proxy.sha256sum] = "37f089c7fe8ff562c765cb3505ef6403b12f5e3898f9550f73ea280fad632c26"

URI_aarch64_sssd-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-tools-2.12.0-3.el10_2.1.aarch64.rpm;name=aarch64_sssd-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-tools}"
SRC_URI[aarch64_sssd-tools.sha256sum] = "979ac328452274713621b7bb814c94f554c209f87a16670d4bfa2722123db0b7"

URI_aarch64_sssd-winbind-idmap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-winbind-idmap-2.12.0-3.el10_2.1.aarch64.rpm;name=aarch64_sssd-winbind-idmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-winbind-idmap}"
SRC_URI[aarch64_sssd-winbind-idmap.sha256sum] = "9411291a233fdb1a02590cb564d032606f06c225f5c1fc7480714c4309037c22"

RDEPENDS:libipa_hbac = " \
 glibc \
 libunistring \
 "
RDEPENDS:libsss_autofs = " \
 glibc \
 "
RDEPENDS:libsss_certmap = " \
 glibc \
 libtalloc \
 openssl-libs \
 "
RDEPENDS:libsss_idmap = " \
 glibc \
 libunistring \
 "
RDEPENDS:libsss_nss_idmap = " \
 glibc \
 "
RDEPENDS:libsss_nss_idmap-devel = " \
 libsss_nss_idmap \
 pkgconf-pkg-config \
 "
RDEPENDS:libsss_sudo = " \
 glibc \
 "
RDEPENDS:python3-libipa_hbac = " \
 glibc \
 libipa_hbac \
 libunistring \
 python3 \
 "
RDEPENDS:python3-libsss_nss_idmap = " \
 glibc \
 libsss_nss_idmap \
 python3 \
 "
RDEPENDS:python3-sss = " \
 dbus-libs \
 glibc \
 libbasicobjects \
 libcap \
 libcollection \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openssl-libs \
 pcre2 \
 popt \
 python3 \
 sssd-common \
 systemd-libs \
 "
RDEPENDS:python3-sss-murmur = " \
 glibc \
 python3 \
 "
RDEPENDS:python3-sssdconfig = " \
 python3 \
 "
RDEPENDS:sssd = " \
 shadow-utils \
 sssd-ad \
 sssd-common \
 sssd-ipa \
 sssd-krb5 \
 sssd-ldap \
 sssd-proxy \
 "
RDEPENDS:sssd-ad = " \
 cyrus-sasl-lib \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcap \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libsmbclient \
 libsss_certmap \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openldap \
 openssl-libs \
 pcre2 \
 popt \
 samba-client-libs \
 sssd-common \
 sssd-common-pac \
 sssd-krb5-common \
 systemd-libs \
 "
RDEPENDS:sssd-client = " \
 alternatives \
 bash \
 glibc \
 krb5-libs \
 libcom_err \
 libsss_idmap \
 libsss_nss_idmap \
 libunistring \
 pam-libs \
 "
RDEPENDS:sssd-common = " \
 bash \
 c-ares \
 dbus-libs \
 glibc \
 jansson \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcap \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libldb \
 libnl3 \
 libref_array \
 libselinux \
 libsss_autofs \
 libsss_certmap \
 libsss_idmap \
 libsss_sudo \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openldap \
 openssl-libs \
 p11-kit \
 pam-libs \
 pcre2 \
 popt \
 shadow-utils \
 sssd-client \
 sssd-nfs-idmap \
 systemd \
 systemd-libs \
 virtual/coreutils \
 "
RDEPENDS:sssd-common-pac = " \
 glibc \
 libldb \
 libselinux \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 popt \
 samba-client-libs \
 sssd-common \
 systemd-libs \
 "
RDEPENDS:sssd-dbus = " \
 bash \
 dbus-libs \
 glibc \
 libdhash \
 libldb \
 libselinux \
 libtalloc \
 libtdb \
 libtevent \
 popt \
 sssd-common \
 systemd \
 systemd-libs \
 "
RDEPENDS:sssd-idp = " \
 dbus-libs \
 glibc \
 jansson \
 krb5-libs \
 libbasicobjects \
 libcap \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libjose \
 libldb \
 libref_array \
 libselinux \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openssl-libs \
 pcre2 \
 popt \
 sssd-common \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:sssd-ipa = " \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcap \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libipa_hbac \
 libldb \
 libref_array \
 libselinux \
 libsemanage \
 libsss_certmap \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openldap \
 openssl-libs \
 pcre2 \
 popt \
 samba-client-libs \
 sssd-common \
 sssd-common-pac \
 sssd-krb5-common \
 systemd-libs \
 "
RDEPENDS:sssd-kcm = " \
 bash \
 glibc \
 krb5-libs \
 libdhash \
 libldb \
 libselinux \
 libtalloc \
 libtevent \
 libuuid \
 popt \
 sssd-common \
 sssd-krb5-common \
 systemd \
 systemd-libs \
 "
RDEPENDS:sssd-krb5 = " \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcap \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openssl-libs \
 pcre2 \
 popt \
 sssd-common \
 sssd-krb5-common \
 systemd-libs \
 "
RDEPENDS:sssd-krb5-common = " \
 cyrus-sasl-gssapi \
 glibc \
 jansson \
 krb5-libs \
 libcap \
 libtalloc \
 popt \
 sssd-common \
 systemd-libs \
 "
RDEPENDS:sssd-ldap = " \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcap \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libsss_certmap \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openldap \
 openssl-libs \
 pcre2 \
 popt \
 sssd-common \
 sssd-krb5-common \
 systemd-libs \
 "
RDEPENDS:sssd-nfs-idmap = " \
 glibc \
 libnfsidmap \
 "
RDEPENDS:sssd-passkey = " \
 acl \
 glibc \
 jansson \
 krb5-libs \
 libcom_err \
 libfido2 \
 libtalloc \
 openssl-libs \
 popt \
 sssd-common \
 "
RDEPENDS:sssd-proxy = " \
 dbus-libs \
 glibc \
 libbasicobjects \
 libcap \
 libcollection \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libsss_certmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openssl-libs \
 pam-libs \
 pcre2 \
 popt \
 sssd-common \
 systemd-libs \
 "
RDEPENDS:sssd-tools = " \
 bash \
 glibc \
 libdhash \
 libldb \
 libref_array \
 libsss_certmap \
 libtalloc \
 pam-libs \
 popt \
 python3 \
 python3-sss \
 python3-sssdconfig \
 python3-systemd \
 sssd-common \
 sssd-dbus \
 "
RDEPENDS:sssd-winbind-idmap = " \
 glibc \
 libsss_idmap \
 libsss_nss_idmap \
 libtalloc \
 libunistring \
 "
