# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdeedu-data"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kdeedu-data \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdeedu-data-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3108dfbc2e233ee23b11d5716b1e2bfb60eedb38dcb6bcdb7609856d07db155a"

URI_x86_64_v2_kdeedu-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdeedu-data-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kdeedu-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdeedu-data}"
SRC_URI[x86_64_v2_kdeedu-data.sha256sum] = "1ffd3432338928369cfff3686b3201be30284d407bc07c4cf50289b04d11b832"

URI_aarch64_kdeedu-data = "${EPEL_MIRROR}/aarch64/Packages/k/kdeedu-data-24.12.3-1.el10_0.noarch.rpm;name=aarch64_kdeedu-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdeedu-data}"
SRC_URI[aarch64_kdeedu-data.sha256sum] = "ae0149a99e42591f894643399f885bf41dabefb84828c652d066518a739c6259"

RDEPENDS:kdeedu-data = " \
 hicolor-icon-theme \
 "
