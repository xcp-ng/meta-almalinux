# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "atop"
PV = "2.11.1"
PR = "1.el10_1"
PACKAGES = " \
 atop \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/atop-2.11.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1101dff1b0c62946cf54f793a8fc26cd1c762d52d4dfb007a8e57ce8030710a9"

URI_x86_64_v2_atop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/atop-2.11.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_atop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_atop}"
SRC_URI[x86_64_v2_atop.sha256sum] = "91a4b9b635279e2fedf4e0c94dfc1a8a2e561d09d5e2972e349ee6e83ea909a9"

URI_aarch64_atop = "${EPEL_MIRROR}/aarch64/Packages/a/atop-2.11.1-1.el10_1.aarch64.rpm;name=aarch64_atop;unpack=0"
SRC_URI:append = " ${URI_aarch64_atop}"
SRC_URI[aarch64_atop.sha256sum] = "fe7a658e9552e47c2a271313f031a7eb3d6776a646486cb951f19ccf22ee66b6"

RDEPENDS:atop = " \
 bash \
 glib2 \
 glibc \
 ncurses-libs \
 systemd \
 zlib-ng-compat \
 "
