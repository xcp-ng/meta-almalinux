# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-digest"
PV = "0.11.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-digest+alloc-devel \
 rust-digest+blobby-devel \
 rust-digest+block-api-devel \
 rust-digest+default-devel \
 rust-digest+dev-devel \
 rust-digest+getrandom-devel \
 rust-digest+mac-devel \
 rust-digest+oid-devel \
 rust-digest+rand_core-devel \
 rust-digest+zeroize-devel \
 rust-digest-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-digest-0.11.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25d6d6eb304e29560556c34deb56a892eb1e00304ee7468c6014f63cfc365230"

URI_x86_64_v2_rust-digest+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest+alloc-devel-0.11.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest+alloc-devel}"
SRC_URI[x86_64_v2_rust-digest+alloc-devel.sha256sum] = "45d65c565cf897cb286bb555eef1b9387bf7b5f99884305381735186ea672f93"

URI_x86_64_v2_rust-digest+blobby-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest+blobby-devel-0.11.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest+blobby-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest+blobby-devel}"
SRC_URI[x86_64_v2_rust-digest+blobby-devel.sha256sum] = "411f0bf5b4d820128c012875206e4f0a36f1b40b36667a1e2e75980ce7636ffb"

URI_x86_64_v2_rust-digest+block-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest+block-api-devel-0.11.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest+block-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest+block-api-devel}"
SRC_URI[x86_64_v2_rust-digest+block-api-devel.sha256sum] = "5a0dac84a7e8e8a83803ba8994c2a3a990e14cb1c6bd0b30ed157231c4c456ee"

URI_x86_64_v2_rust-digest+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest+default-devel-0.11.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest+default-devel}"
SRC_URI[x86_64_v2_rust-digest+default-devel.sha256sum] = "c65930b3fda096f35df729b9651660d72469fbffe4b8769e2be0ab031d296443"

URI_x86_64_v2_rust-digest+dev-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest+dev-devel-0.11.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest+dev-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest+dev-devel}"
SRC_URI[x86_64_v2_rust-digest+dev-devel.sha256sum] = "36fb195ab79fe5186bb6c37834b329a239e7fc98a2f92d0fb83945039fe23d2f"

URI_x86_64_v2_rust-digest+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest+getrandom-devel-0.11.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest+getrandom-devel}"
SRC_URI[x86_64_v2_rust-digest+getrandom-devel.sha256sum] = "79d1a844e4a5d26b4ac10350a8eb4b8bf4af03ba840bea39ddeeabd363e17a35"

URI_x86_64_v2_rust-digest+mac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest+mac-devel-0.11.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest+mac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest+mac-devel}"
SRC_URI[x86_64_v2_rust-digest+mac-devel.sha256sum] = "3ab75d6fcb14e067886b8fd8b6e34f69b1b0c4c5f02b6b82d41506dcdceef6c1"

URI_x86_64_v2_rust-digest+oid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest+oid-devel-0.11.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest+oid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest+oid-devel}"
SRC_URI[x86_64_v2_rust-digest+oid-devel.sha256sum] = "32040732158e3ced3170e80846531432b464c58d90494b85f29a800f1fb56ac9"

URI_x86_64_v2_rust-digest+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest+rand_core-devel-0.11.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest+rand_core-devel}"
SRC_URI[x86_64_v2_rust-digest+rand_core-devel.sha256sum] = "05eba848be6280d469bc5ed8853eb755eb90417da62df660792d41cdec4467b9"

URI_x86_64_v2_rust-digest+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest+zeroize-devel-0.11.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest+zeroize-devel}"
SRC_URI[x86_64_v2_rust-digest+zeroize-devel.sha256sum] = "01186a33e5bf5b7020710907be32d72bd705de5e995b4e7364079f4fc1a38630"

URI_x86_64_v2_rust-digest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest-devel-0.11.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest-devel}"
SRC_URI[x86_64_v2_rust-digest-devel.sha256sum] = "fbed9479e33952134ac3a26d1cc58efb5036e8a988954ca7313f51cb7a341926"

URI_aarch64_rust-digest+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest+alloc-devel-0.11.3-1.el10_3.noarch.rpm;name=aarch64_rust-digest+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest+alloc-devel}"
SRC_URI[aarch64_rust-digest+alloc-devel.sha256sum] = "eb937db0c74d9bb141c8c6fe4896c8b39f5128b8ac556cbf18001cad331fd353"

URI_aarch64_rust-digest+blobby-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest+blobby-devel-0.11.3-1.el10_3.noarch.rpm;name=aarch64_rust-digest+blobby-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest+blobby-devel}"
SRC_URI[aarch64_rust-digest+blobby-devel.sha256sum] = "1cf8e1dc714faf38d4eda80a952d6041649b9fa162c62df18e10ebfeb453b8c6"

URI_aarch64_rust-digest+block-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest+block-api-devel-0.11.3-1.el10_3.noarch.rpm;name=aarch64_rust-digest+block-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest+block-api-devel}"
SRC_URI[aarch64_rust-digest+block-api-devel.sha256sum] = "b475f56fe25f7106a9b98ca52dc375406b73b4571b649c1d856f31820e7746ff"

URI_aarch64_rust-digest+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest+default-devel-0.11.3-1.el10_3.noarch.rpm;name=aarch64_rust-digest+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest+default-devel}"
SRC_URI[aarch64_rust-digest+default-devel.sha256sum] = "187a0ee5b8015969b5bbeb9a0400108092bdce2dae370eefb3b4ae06b67f2f9b"

URI_aarch64_rust-digest+dev-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest+dev-devel-0.11.3-1.el10_3.noarch.rpm;name=aarch64_rust-digest+dev-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest+dev-devel}"
SRC_URI[aarch64_rust-digest+dev-devel.sha256sum] = "9d1bbe48ad4e192dfc80bff84c2a2b399d2b2a65a7e832e020272a020c46f528"

URI_aarch64_rust-digest+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest+getrandom-devel-0.11.3-1.el10_3.noarch.rpm;name=aarch64_rust-digest+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest+getrandom-devel}"
SRC_URI[aarch64_rust-digest+getrandom-devel.sha256sum] = "0cc321fadab88db2ee083f17b1855fd127acf8946608a50f97628e88dc4c5411"

URI_aarch64_rust-digest+mac-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest+mac-devel-0.11.3-1.el10_3.noarch.rpm;name=aarch64_rust-digest+mac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest+mac-devel}"
SRC_URI[aarch64_rust-digest+mac-devel.sha256sum] = "d86668ee7a4a568b81002ebb30439b71b5cbd17bcda874b1bb324c7c7e1122ae"

URI_aarch64_rust-digest+oid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest+oid-devel-0.11.3-1.el10_3.noarch.rpm;name=aarch64_rust-digest+oid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest+oid-devel}"
SRC_URI[aarch64_rust-digest+oid-devel.sha256sum] = "74425875315ef8bf430dc0ababea85a98e30f5dc1f1ca43e4871fb010d9fef52"

URI_aarch64_rust-digest+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest+rand_core-devel-0.11.3-1.el10_3.noarch.rpm;name=aarch64_rust-digest+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest+rand_core-devel}"
SRC_URI[aarch64_rust-digest+rand_core-devel.sha256sum] = "eb70c3c2beaf0400d2a1c47e32a537544785dcd9300fec07cf0c8c59061f4339"

URI_aarch64_rust-digest+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest+zeroize-devel-0.11.3-1.el10_3.noarch.rpm;name=aarch64_rust-digest+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest+zeroize-devel}"
SRC_URI[aarch64_rust-digest+zeroize-devel.sha256sum] = "a3d19c0a32525f9c269cf66866ececc274228ee881fae93ae16b545662c9f5b7"

URI_aarch64_rust-digest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest-devel-0.11.3-1.el10_3.noarch.rpm;name=aarch64_rust-digest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest-devel}"
SRC_URI[aarch64_rust-digest-devel.sha256sum] = "4aa62397c4cd4835ded9b8b7ede0f7ced8d27b0ba216818d0a664d2fbd1b4842"

RDEPENDS:rust-digest+alloc-devel = " \
 cargo \
 rust-digest-devel \
 "
RDEPENDS:rust-digest+blobby-devel = " \
 cargo \
 rust-blobby+default-devel \
 rust-digest-devel \
 "
RDEPENDS:rust-digest+block-api-devel = " \
 cargo \
 rust-block-buffer+default-devel \
 rust-digest-devel \
 "
RDEPENDS:rust-digest+default-devel = " \
 cargo \
 rust-digest+block-api-devel \
 rust-digest-devel \
 "
RDEPENDS:rust-digest+dev-devel = " \
 cargo \
 rust-digest+blobby-devel \
 rust-digest-devel \
 "
RDEPENDS:rust-digest+getrandom-devel = " \
 cargo \
 rust-crypto-common+getrandom-devel \
 rust-digest+rand_core-devel \
 rust-digest-devel \
 "
RDEPENDS:rust-digest+mac-devel = " \
 cargo \
 rust-ctutils+default-devel \
 rust-digest-devel \
 "
RDEPENDS:rust-digest+oid-devel = " \
 cargo \
 rust-const-oid+default-devel \
 rust-digest-devel \
 "
RDEPENDS:rust-digest+rand_core-devel = " \
 cargo \
 rust-crypto-common+rand_core-devel \
 rust-digest-devel \
 "
RDEPENDS:rust-digest+zeroize-devel = " \
 cargo \
 rust-block-buffer+default-devel \
 rust-block-buffer+zeroize-devel \
 rust-digest-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-digest-devel = " \
 cargo \
 rust \
 rust-crypto-common+default-devel \
 "
