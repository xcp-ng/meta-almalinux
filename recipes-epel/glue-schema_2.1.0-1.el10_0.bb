# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glue-schema"
PV = "2.1.0"
PR = "1.el10_0"
PACKAGES = " \
 glue-schema \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/glue-schema-2.1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63c13cb0fa7302168c4c3cdc00f35b5edfd7f7c970363ff4b28b1a489de8c0cf"

URI_x86_64_v2_glue-schema = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glue-schema-2.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_glue-schema;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glue-schema}"
SRC_URI[x86_64_v2_glue-schema.sha256sum] = "9e877e222b1941e68bbafbc19ad427fdd015f8e4000b33d0a3264ad469303f51"

URI_aarch64_glue-schema = "${EPEL_MIRROR}/aarch64/Packages/g/glue-schema-2.1.0-1.el10_0.noarch.rpm;name=aarch64_glue-schema;unpack=0"
SRC_URI:append = " ${URI_aarch64_glue-schema}"
SRC_URI[aarch64_glue-schema.sha256sum] = "6763c3c627907c8f908b80ef767a0f66268591ff5f8f8201278240ca78d1cd1d"

RDEPENDS:glue-schema = " \
 "
