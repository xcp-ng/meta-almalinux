# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-elasticlunr-rs"
PV = "3.0.3"
PR = "3.el10_3"
PACKAGES = " \
 rust-elasticlunr-rs+ar-devel \
 rust-elasticlunr-rs+da-devel \
 rust-elasticlunr-rs+de-devel \
 rust-elasticlunr-rs+default-devel \
 rust-elasticlunr-rs+du-devel \
 rust-elasticlunr-rs+es-devel \
 rust-elasticlunr-rs+fi-devel \
 rust-elasticlunr-rs+fr-devel \
 rust-elasticlunr-rs+hu-devel \
 rust-elasticlunr-rs+it-devel \
 rust-elasticlunr-rs+ko-devel \
 rust-elasticlunr-rs+languages-devel \
 rust-elasticlunr-rs+no-devel \
 rust-elasticlunr-rs+pt-devel \
 rust-elasticlunr-rs+ro-devel \
 rust-elasticlunr-rs+ru-devel \
 rust-elasticlunr-rs+rust-stemmers-devel \
 rust-elasticlunr-rs+sv-devel \
 rust-elasticlunr-rs+tr-devel \
 rust-elasticlunr-rs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-elasticlunr-rs-3.0.3-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6541218ae1b7d2b2c2f0a5d826fb6fe2f03cb7f9a696d0b9b626bf957fdfdd75"

URI_x86_64_v2_rust-elasticlunr-rs+ar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-elasticlunr-rs+ar-devel-3.0.3-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-elasticlunr-rs+ar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-elasticlunr-rs+ar-devel}"
SRC_URI[x86_64_v2_rust-elasticlunr-rs+ar-devel.sha256sum] = "fca64a480102c2e9aa4ae2635b21317e0af7b582e525e5d4a43e5a011f9c30a6"

URI_x86_64_v2_rust-elasticlunr-rs+da-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-elasticlunr-rs+da-devel-3.0.3-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-elasticlunr-rs+da-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-elasticlunr-rs+da-devel}"
SRC_URI[x86_64_v2_rust-elasticlunr-rs+da-devel.sha256sum] = "6d2a7b48c87cf361729094280c14f081133a02e61818cd807c8cadb7e30965c1"

URI_x86_64_v2_rust-elasticlunr-rs+de-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-elasticlunr-rs+de-devel-3.0.3-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-elasticlunr-rs+de-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-elasticlunr-rs+de-devel}"
SRC_URI[x86_64_v2_rust-elasticlunr-rs+de-devel.sha256sum] = "dfcbabb2e8d817a2ba32c126cd76d2825fd5e37c2246e4becbb558f267ef65f9"

URI_x86_64_v2_rust-elasticlunr-rs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-elasticlunr-rs+default-devel-3.0.3-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-elasticlunr-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-elasticlunr-rs+default-devel}"
SRC_URI[x86_64_v2_rust-elasticlunr-rs+default-devel.sha256sum] = "db7fd0f6e8a5facd4a74e4977eb83b295c5005cfd6aeccc9ea9d36fc76fdb936"

URI_x86_64_v2_rust-elasticlunr-rs+du-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-elasticlunr-rs+du-devel-3.0.3-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-elasticlunr-rs+du-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-elasticlunr-rs+du-devel}"
SRC_URI[x86_64_v2_rust-elasticlunr-rs+du-devel.sha256sum] = "da7e8692f335c8d2a569a11c1273896cda18b96f3b6aa75d2ac9bbcca857243b"

URI_x86_64_v2_rust-elasticlunr-rs+es-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-elasticlunr-rs+es-devel-3.0.3-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-elasticlunr-rs+es-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-elasticlunr-rs+es-devel}"
SRC_URI[x86_64_v2_rust-elasticlunr-rs+es-devel.sha256sum] = "9ae643e7aeaf0c361a4894e8c737fa778c1f2afe72106cad29664c1e032a478d"

URI_x86_64_v2_rust-elasticlunr-rs+fi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-elasticlunr-rs+fi-devel-3.0.3-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-elasticlunr-rs+fi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-elasticlunr-rs+fi-devel}"
SRC_URI[x86_64_v2_rust-elasticlunr-rs+fi-devel.sha256sum] = "d8637439b848e2e09af58059911d21610f23318b5cfeff42a4ac88754bef99ca"

URI_x86_64_v2_rust-elasticlunr-rs+fr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-elasticlunr-rs+fr-devel-3.0.3-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-elasticlunr-rs+fr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-elasticlunr-rs+fr-devel}"
SRC_URI[x86_64_v2_rust-elasticlunr-rs+fr-devel.sha256sum] = "eebcb23ae5a323750eb555d96b9d58b466214dbf445a8fe5f77bef88ffa3a856"

URI_x86_64_v2_rust-elasticlunr-rs+hu-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-elasticlunr-rs+hu-devel-3.0.3-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-elasticlunr-rs+hu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-elasticlunr-rs+hu-devel}"
SRC_URI[x86_64_v2_rust-elasticlunr-rs+hu-devel.sha256sum] = "21c91122180fe3a060a24ce9ed9b75aaae2d5715affa2cd2e67ac57f3f1613fe"

URI_x86_64_v2_rust-elasticlunr-rs+it-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-elasticlunr-rs+it-devel-3.0.3-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-elasticlunr-rs+it-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-elasticlunr-rs+it-devel}"
SRC_URI[x86_64_v2_rust-elasticlunr-rs+it-devel.sha256sum] = "81660e86323dafd669b0d1014f9f05f19ac79d119f1dc3b7c5f38e9a757f9ef9"

URI_x86_64_v2_rust-elasticlunr-rs+ko-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-elasticlunr-rs+ko-devel-3.0.3-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-elasticlunr-rs+ko-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-elasticlunr-rs+ko-devel}"
SRC_URI[x86_64_v2_rust-elasticlunr-rs+ko-devel.sha256sum] = "db340dc29784e3f8cbf55c38d10bb1dd1e4208d5b2fedef2aeda15d06ea18e5b"

URI_x86_64_v2_rust-elasticlunr-rs+languages-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-elasticlunr-rs+languages-devel-3.0.3-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-elasticlunr-rs+languages-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-elasticlunr-rs+languages-devel}"
SRC_URI[x86_64_v2_rust-elasticlunr-rs+languages-devel.sha256sum] = "6789d0804a1dcddbfc8a674387cfc4ae802bb4589669436f512255c1d91d33e0"

URI_x86_64_v2_rust-elasticlunr-rs+no-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-elasticlunr-rs+no-devel-3.0.3-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-elasticlunr-rs+no-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-elasticlunr-rs+no-devel}"
SRC_URI[x86_64_v2_rust-elasticlunr-rs+no-devel.sha256sum] = "e9293595013b4227638312b800682d2a5a69cdf432c7dc092ac98e1469a7189c"

URI_x86_64_v2_rust-elasticlunr-rs+pt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-elasticlunr-rs+pt-devel-3.0.3-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-elasticlunr-rs+pt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-elasticlunr-rs+pt-devel}"
SRC_URI[x86_64_v2_rust-elasticlunr-rs+pt-devel.sha256sum] = "4746beb716c8e8b405eb14d6c8689e07a8daaa0edf5a60c1b4f381c9d80a6da2"

URI_x86_64_v2_rust-elasticlunr-rs+ro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-elasticlunr-rs+ro-devel-3.0.3-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-elasticlunr-rs+ro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-elasticlunr-rs+ro-devel}"
SRC_URI[x86_64_v2_rust-elasticlunr-rs+ro-devel.sha256sum] = "0a238ccf42167da5fc15c91181b7284942cdff6539a2830962cd976d21b183b0"

URI_x86_64_v2_rust-elasticlunr-rs+ru-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-elasticlunr-rs+ru-devel-3.0.3-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-elasticlunr-rs+ru-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-elasticlunr-rs+ru-devel}"
SRC_URI[x86_64_v2_rust-elasticlunr-rs+ru-devel.sha256sum] = "e17b0ee3c7b8a93c7ba2761ff568b1a64e9aa6ac12b6d338227ad35221a8d111"

URI_x86_64_v2_rust-elasticlunr-rs+rust-stemmers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-elasticlunr-rs+rust-stemmers-devel-3.0.3-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-elasticlunr-rs+rust-stemmers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-elasticlunr-rs+rust-stemmers-devel}"
SRC_URI[x86_64_v2_rust-elasticlunr-rs+rust-stemmers-devel.sha256sum] = "489c6782d077dece1d13047be0dbe447e111b71814d439dda01f8ad392364ff9"

URI_x86_64_v2_rust-elasticlunr-rs+sv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-elasticlunr-rs+sv-devel-3.0.3-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-elasticlunr-rs+sv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-elasticlunr-rs+sv-devel}"
SRC_URI[x86_64_v2_rust-elasticlunr-rs+sv-devel.sha256sum] = "23b2c32ccb524d04a845aab83a32411209bd354899aa0073462435bac1428a62"

URI_x86_64_v2_rust-elasticlunr-rs+tr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-elasticlunr-rs+tr-devel-3.0.3-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-elasticlunr-rs+tr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-elasticlunr-rs+tr-devel}"
SRC_URI[x86_64_v2_rust-elasticlunr-rs+tr-devel.sha256sum] = "ba9bb9490eccc021faa4701bce742ac0dd29fa9b12eb4c34f1461409c71355e6"

URI_x86_64_v2_rust-elasticlunr-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-elasticlunr-rs-devel-3.0.3-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-elasticlunr-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-elasticlunr-rs-devel}"
SRC_URI[x86_64_v2_rust-elasticlunr-rs-devel.sha256sum] = "2b9a6b58bd094c3e39a300202f47ad10f62a1bde9a2279d95b5785f1a9ac1dde"

URI_aarch64_rust-elasticlunr-rs+ar-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-elasticlunr-rs+ar-devel-3.0.3-3.el10_3.noarch.rpm;name=aarch64_rust-elasticlunr-rs+ar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-elasticlunr-rs+ar-devel}"
SRC_URI[aarch64_rust-elasticlunr-rs+ar-devel.sha256sum] = "b283e650c906187ef8540b9bf9b802835b38de2de3a6fb07e0e3777144f0bf2f"

URI_aarch64_rust-elasticlunr-rs+da-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-elasticlunr-rs+da-devel-3.0.3-3.el10_3.noarch.rpm;name=aarch64_rust-elasticlunr-rs+da-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-elasticlunr-rs+da-devel}"
SRC_URI[aarch64_rust-elasticlunr-rs+da-devel.sha256sum] = "7edad1d5f288e8220b9be78925488ec805d7e41a1410636f9293c642995e4967"

URI_aarch64_rust-elasticlunr-rs+de-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-elasticlunr-rs+de-devel-3.0.3-3.el10_3.noarch.rpm;name=aarch64_rust-elasticlunr-rs+de-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-elasticlunr-rs+de-devel}"
SRC_URI[aarch64_rust-elasticlunr-rs+de-devel.sha256sum] = "b752456b13d5c3ec2bcd56283b806db93b1ada74ea4918fb616b6c0322cc4d1e"

URI_aarch64_rust-elasticlunr-rs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-elasticlunr-rs+default-devel-3.0.3-3.el10_3.noarch.rpm;name=aarch64_rust-elasticlunr-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-elasticlunr-rs+default-devel}"
SRC_URI[aarch64_rust-elasticlunr-rs+default-devel.sha256sum] = "04ef5e52cda18edfb3449f0e65b4ebcf1cd2d1fd41555c80cce66ce8a06fcec9"

URI_aarch64_rust-elasticlunr-rs+du-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-elasticlunr-rs+du-devel-3.0.3-3.el10_3.noarch.rpm;name=aarch64_rust-elasticlunr-rs+du-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-elasticlunr-rs+du-devel}"
SRC_URI[aarch64_rust-elasticlunr-rs+du-devel.sha256sum] = "94edd96888c70066e29ac8b1493cd5c512eef9abebc8ea1df349f15cb8d67cab"

URI_aarch64_rust-elasticlunr-rs+es-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-elasticlunr-rs+es-devel-3.0.3-3.el10_3.noarch.rpm;name=aarch64_rust-elasticlunr-rs+es-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-elasticlunr-rs+es-devel}"
SRC_URI[aarch64_rust-elasticlunr-rs+es-devel.sha256sum] = "b2d5c3d2e482f8620377dc9266bc47becdd199e04b82d287b59bef4d0b4150b8"

URI_aarch64_rust-elasticlunr-rs+fi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-elasticlunr-rs+fi-devel-3.0.3-3.el10_3.noarch.rpm;name=aarch64_rust-elasticlunr-rs+fi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-elasticlunr-rs+fi-devel}"
SRC_URI[aarch64_rust-elasticlunr-rs+fi-devel.sha256sum] = "a13a2cde61d8b2d8141385181c3154c8e33373514850625f80b851ec0d7fcba5"

URI_aarch64_rust-elasticlunr-rs+fr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-elasticlunr-rs+fr-devel-3.0.3-3.el10_3.noarch.rpm;name=aarch64_rust-elasticlunr-rs+fr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-elasticlunr-rs+fr-devel}"
SRC_URI[aarch64_rust-elasticlunr-rs+fr-devel.sha256sum] = "7f24e7f7906f59778a4d09ce61c93bfda9bae098dd6549720303001063a6f776"

URI_aarch64_rust-elasticlunr-rs+hu-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-elasticlunr-rs+hu-devel-3.0.3-3.el10_3.noarch.rpm;name=aarch64_rust-elasticlunr-rs+hu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-elasticlunr-rs+hu-devel}"
SRC_URI[aarch64_rust-elasticlunr-rs+hu-devel.sha256sum] = "c379015a45dd4a75dbec55f9af89ad6e450e258bb15f9fd3be26cfd0b2536855"

URI_aarch64_rust-elasticlunr-rs+it-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-elasticlunr-rs+it-devel-3.0.3-3.el10_3.noarch.rpm;name=aarch64_rust-elasticlunr-rs+it-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-elasticlunr-rs+it-devel}"
SRC_URI[aarch64_rust-elasticlunr-rs+it-devel.sha256sum] = "72c194801f0f1f0d90ee9456cbf71d7630bee5b0d7f1b4c8c50bd0b02a1f0030"

URI_aarch64_rust-elasticlunr-rs+ko-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-elasticlunr-rs+ko-devel-3.0.3-3.el10_3.noarch.rpm;name=aarch64_rust-elasticlunr-rs+ko-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-elasticlunr-rs+ko-devel}"
SRC_URI[aarch64_rust-elasticlunr-rs+ko-devel.sha256sum] = "7893160510ac9dca5925c0d6552bc5d2a93431e1de82991dbd372eac67488d62"

URI_aarch64_rust-elasticlunr-rs+languages-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-elasticlunr-rs+languages-devel-3.0.3-3.el10_3.noarch.rpm;name=aarch64_rust-elasticlunr-rs+languages-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-elasticlunr-rs+languages-devel}"
SRC_URI[aarch64_rust-elasticlunr-rs+languages-devel.sha256sum] = "611a2428e63d0bec74b7a4f6e13506229a37efb50e117f287dbe64e235b5958b"

URI_aarch64_rust-elasticlunr-rs+no-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-elasticlunr-rs+no-devel-3.0.3-3.el10_3.noarch.rpm;name=aarch64_rust-elasticlunr-rs+no-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-elasticlunr-rs+no-devel}"
SRC_URI[aarch64_rust-elasticlunr-rs+no-devel.sha256sum] = "82bead0a1439e4244c21cab2f8d838bf6059eaf043e1da44a834df4d097667c2"

URI_aarch64_rust-elasticlunr-rs+pt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-elasticlunr-rs+pt-devel-3.0.3-3.el10_3.noarch.rpm;name=aarch64_rust-elasticlunr-rs+pt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-elasticlunr-rs+pt-devel}"
SRC_URI[aarch64_rust-elasticlunr-rs+pt-devel.sha256sum] = "cabad004236900377f7d6406cb8cedba574b29ccb477ffc1b3d4ce6954bc755b"

URI_aarch64_rust-elasticlunr-rs+ro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-elasticlunr-rs+ro-devel-3.0.3-3.el10_3.noarch.rpm;name=aarch64_rust-elasticlunr-rs+ro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-elasticlunr-rs+ro-devel}"
SRC_URI[aarch64_rust-elasticlunr-rs+ro-devel.sha256sum] = "6233d8a21bdff4d64fd70ec390a57139e8b099eae48b464f4eb2f27feeca8dba"

URI_aarch64_rust-elasticlunr-rs+ru-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-elasticlunr-rs+ru-devel-3.0.3-3.el10_3.noarch.rpm;name=aarch64_rust-elasticlunr-rs+ru-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-elasticlunr-rs+ru-devel}"
SRC_URI[aarch64_rust-elasticlunr-rs+ru-devel.sha256sum] = "e2ff297d6c27a3b032ceffec741fff067b48a1a8122ee235c48b6b585a36baf1"

URI_aarch64_rust-elasticlunr-rs+rust-stemmers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-elasticlunr-rs+rust-stemmers-devel-3.0.3-3.el10_3.noarch.rpm;name=aarch64_rust-elasticlunr-rs+rust-stemmers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-elasticlunr-rs+rust-stemmers-devel}"
SRC_URI[aarch64_rust-elasticlunr-rs+rust-stemmers-devel.sha256sum] = "08ed0b000f226e9ce51737079a8a44ed155341d4d0d3ad4436f335ddc63b5d23"

URI_aarch64_rust-elasticlunr-rs+sv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-elasticlunr-rs+sv-devel-3.0.3-3.el10_3.noarch.rpm;name=aarch64_rust-elasticlunr-rs+sv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-elasticlunr-rs+sv-devel}"
SRC_URI[aarch64_rust-elasticlunr-rs+sv-devel.sha256sum] = "b0b6c516bf43ef5e82922cf9c9080c663045b889340d72ca4f1b67bd3632d8e6"

URI_aarch64_rust-elasticlunr-rs+tr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-elasticlunr-rs+tr-devel-3.0.3-3.el10_3.noarch.rpm;name=aarch64_rust-elasticlunr-rs+tr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-elasticlunr-rs+tr-devel}"
SRC_URI[aarch64_rust-elasticlunr-rs+tr-devel.sha256sum] = "f416e6500ad6b2f983da79e575b7cd61e4ee220df165b210bd9f553935291cc6"

URI_aarch64_rust-elasticlunr-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-elasticlunr-rs-devel-3.0.3-3.el10_3.noarch.rpm;name=aarch64_rust-elasticlunr-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-elasticlunr-rs-devel}"
SRC_URI[aarch64_rust-elasticlunr-rs-devel.sha256sum] = "2f695cbca523f83ee507e92bb34d3fa5826ce6e95a00ded457fac42e61154d77"

RDEPENDS:rust-elasticlunr-rs+ar-devel = " \
 cargo \
 rust-elasticlunr-rs-devel \
 "
RDEPENDS:rust-elasticlunr-rs+da-devel = " \
 cargo \
 rust-elasticlunr-rs+rust-stemmers-devel \
 rust-elasticlunr-rs-devel \
 "
RDEPENDS:rust-elasticlunr-rs+de-devel = " \
 cargo \
 rust-elasticlunr-rs+rust-stemmers-devel \
 rust-elasticlunr-rs-devel \
 "
RDEPENDS:rust-elasticlunr-rs+default-devel = " \
 cargo \
 rust-elasticlunr-rs-devel \
 "
RDEPENDS:rust-elasticlunr-rs+du-devel = " \
 cargo \
 rust-elasticlunr-rs+rust-stemmers-devel \
 rust-elasticlunr-rs-devel \
 "
RDEPENDS:rust-elasticlunr-rs+es-devel = " \
 cargo \
 rust-elasticlunr-rs+rust-stemmers-devel \
 rust-elasticlunr-rs-devel \
 "
RDEPENDS:rust-elasticlunr-rs+fi-devel = " \
 cargo \
 rust-elasticlunr-rs+rust-stemmers-devel \
 rust-elasticlunr-rs-devel \
 "
RDEPENDS:rust-elasticlunr-rs+fr-devel = " \
 cargo \
 rust-elasticlunr-rs+rust-stemmers-devel \
 rust-elasticlunr-rs-devel \
 "
RDEPENDS:rust-elasticlunr-rs+hu-devel = " \
 cargo \
 rust-elasticlunr-rs+rust-stemmers-devel \
 rust-elasticlunr-rs-devel \
 "
RDEPENDS:rust-elasticlunr-rs+it-devel = " \
 cargo \
 rust-elasticlunr-rs+rust-stemmers-devel \
 rust-elasticlunr-rs-devel \
 "
RDEPENDS:rust-elasticlunr-rs+ko-devel = " \
 cargo \
 rust-elasticlunr-rs-devel \
 "
RDEPENDS:rust-elasticlunr-rs+languages-devel = " \
 cargo \
 rust-elasticlunr-rs+ar-devel \
 rust-elasticlunr-rs+da-devel \
 rust-elasticlunr-rs+de-devel \
 rust-elasticlunr-rs+du-devel \
 rust-elasticlunr-rs+es-devel \
 rust-elasticlunr-rs+fi-devel \
 rust-elasticlunr-rs+fr-devel \
 rust-elasticlunr-rs+hu-devel \
 rust-elasticlunr-rs+it-devel \
 rust-elasticlunr-rs+ko-devel \
 rust-elasticlunr-rs+no-devel \
 rust-elasticlunr-rs+pt-devel \
 rust-elasticlunr-rs+ro-devel \
 rust-elasticlunr-rs+ru-devel \
 rust-elasticlunr-rs+sv-devel \
 rust-elasticlunr-rs+tr-devel \
 rust-elasticlunr-rs-devel \
 "
RDEPENDS:rust-elasticlunr-rs+no-devel = " \
 cargo \
 rust-elasticlunr-rs+rust-stemmers-devel \
 rust-elasticlunr-rs-devel \
 "
RDEPENDS:rust-elasticlunr-rs+pt-devel = " \
 cargo \
 rust-elasticlunr-rs+rust-stemmers-devel \
 rust-elasticlunr-rs-devel \
 "
RDEPENDS:rust-elasticlunr-rs+ro-devel = " \
 cargo \
 rust-elasticlunr-rs+rust-stemmers-devel \
 rust-elasticlunr-rs-devel \
 "
RDEPENDS:rust-elasticlunr-rs+ru-devel = " \
 cargo \
 rust-elasticlunr-rs+rust-stemmers-devel \
 rust-elasticlunr-rs-devel \
 "
RDEPENDS:rust-elasticlunr-rs+rust-stemmers-devel = " \
 cargo \
 rust-elasticlunr-rs-devel \
 rust-rust-stemmers+default-devel \
 "
RDEPENDS:rust-elasticlunr-rs+sv-devel = " \
 cargo \
 rust-elasticlunr-rs+rust-stemmers-devel \
 rust-elasticlunr-rs-devel \
 "
RDEPENDS:rust-elasticlunr-rs+tr-devel = " \
 cargo \
 rust-elasticlunr-rs+rust-stemmers-devel \
 rust-elasticlunr-rs-devel \
 "
RDEPENDS:rust-elasticlunr-rs-devel = " \
 cargo \
 rust \
 rust-regex+default-devel \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 rust-serde_json+default-devel \
 "
