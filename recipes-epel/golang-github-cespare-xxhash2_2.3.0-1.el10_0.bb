# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-cespare-xxhash2"
PV = "2.3.0"
PR = "1.el10_0"
PACKAGES = " \
 golang-github-cespare-xxhash2 \
 golang-github-cespare-xxhash2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-cespare-xxhash2-2.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e1bde33b8047b6980daf36f489e46fa1578639f958fdb1c403289c4089934f2"

URI_x86_64_v2_golang-github-cespare-xxhash2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-cespare-xxhash2-2.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_golang-github-cespare-xxhash2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-cespare-xxhash2}"
SRC_URI[x86_64_v2_golang-github-cespare-xxhash2.sha256sum] = "2328f64861a41cb6eeca5827095f18a7298436e086084f2a915a0eed0050315e"

URI_x86_64_v2_golang-github-cespare-xxhash2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-cespare-xxhash2-devel-2.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-cespare-xxhash2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-cespare-xxhash2-devel}"
SRC_URI[x86_64_v2_golang-github-cespare-xxhash2-devel.sha256sum] = "9acc5a58b7ee1d56eda2d180a272092684395609d71bb06ba2b1fa76323f8728"

URI_aarch64_golang-github-cespare-xxhash2 = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-cespare-xxhash2-2.3.0-1.el10_0.aarch64.rpm;name=aarch64_golang-github-cespare-xxhash2;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-cespare-xxhash2}"
SRC_URI[aarch64_golang-github-cespare-xxhash2.sha256sum] = "dec13d73c8a2fafa3acda2322d7c9853f8dc7333617bc0a7a6da49ce53589768"

URI_aarch64_golang-github-cespare-xxhash2-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-cespare-xxhash2-devel-2.3.0-1.el10_0.noarch.rpm;name=aarch64_golang-github-cespare-xxhash2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-cespare-xxhash2-devel}"
SRC_URI[aarch64_golang-github-cespare-xxhash2-devel.sha256sum] = "fb93f4f01d58ba194e204b3a8513a427d00636c423292834f60dd966f330104a"

RDEPENDS:golang-github-cespare-xxhash2 = " \
 glibc \
 "
RDEPENDS:golang-github-cespare-xxhash2-devel = " \
 go-filesystem \
 "
