# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdegraphics-thumbnailers"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kdegraphics-thumbnailers \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kdegraphics-thumbnailers-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b6e6f1588e0857a7d20e1c7f6815096f7f279f7a7b0c009b6395d5a53a012ceb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdegraphics-thumbnailers-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdegraphics-thumbnailers;unpack=0"
SRC_URI[x86_64_v2_kdegraphics-thumbnailers.sha256sum] = "95aef677be391cd668bc8121cce9173e5ab1d12dd00ae1293a559f8e2d72af93"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kdegraphics-thumbnailers-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kdegraphics-thumbnailers;unpack=0"
SRC_URI[aarch64_kdegraphics-thumbnailers.sha256sum] = "b21b99e1207bb7fd4e80955186e7cf00219078e98aa1412dd1f26db9acacf2ac"

RDEPENDS:kdegraphics-thumbnailers = " \
 glibc \
 kdegraphics-mobipocket \
 kf6-karchive \
 kf6-kcoreaddons \
 kf6-kio-gui \
 libkdcraw \
 libkexiv2-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
