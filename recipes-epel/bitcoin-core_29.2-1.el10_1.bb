# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bitcoin-core"
PV = "29.2"
PR = "1.el10_1"
PACKAGES = " \
 bitcoin-core-desktop \
 bitcoin-core-devel \
 bitcoin-core-server \
 bitcoin-core-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bitcoin-core-29.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2300cf9a766b21824af0740f996403ad9b6582c286bb4804f9da3736017abd34"

URI_x86_64_v2_bitcoin-core-desktop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bitcoin-core-desktop-29.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bitcoin-core-desktop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bitcoin-core-desktop}"
SRC_URI[x86_64_v2_bitcoin-core-desktop.sha256sum] = "1b250c0bc9c7b36e4fb78ec3a30127158b49dd636d007a82c06ba26000dbd56b"

URI_x86_64_v2_bitcoin-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bitcoin-core-devel-29.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bitcoin-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bitcoin-core-devel}"
SRC_URI[x86_64_v2_bitcoin-core-devel.sha256sum] = "587362f61d0bfa0f83cdd0826478095b5964f984a88e04c4b2b80373863c3859"

URI_x86_64_v2_bitcoin-core-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bitcoin-core-server-29.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bitcoin-core-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bitcoin-core-server}"
SRC_URI[x86_64_v2_bitcoin-core-server.sha256sum] = "9e3324a836287bd921dcea2546b8a481e7775fbc68f0a88f6d0c0ac8d697eb72"

URI_x86_64_v2_bitcoin-core-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bitcoin-core-utils-29.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bitcoin-core-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bitcoin-core-utils}"
SRC_URI[x86_64_v2_bitcoin-core-utils.sha256sum] = "a48aecf4ddecbb61e72342e38df626e2bb965c5ed1e643c341454210f23df912"

URI_aarch64_bitcoin-core-desktop = "${EPEL_MIRROR}/aarch64/Packages/b/bitcoin-core-desktop-29.2-1.el10_1.aarch64.rpm;name=aarch64_bitcoin-core-desktop;unpack=0"
SRC_URI:append = " ${URI_aarch64_bitcoin-core-desktop}"
SRC_URI[aarch64_bitcoin-core-desktop.sha256sum] = "fcf8d32bb30b79689572ad4baff3c49ea2a3ccb0fe426c011036918d85976e5d"

URI_aarch64_bitcoin-core-devel = "${EPEL_MIRROR}/aarch64/Packages/b/bitcoin-core-devel-29.2-1.el10_1.aarch64.rpm;name=aarch64_bitcoin-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_bitcoin-core-devel}"
SRC_URI[aarch64_bitcoin-core-devel.sha256sum] = "28b8eee8e89517b83cd210d73a5aafbfdbacff95c7f863d082d65faed5bb47a6"

URI_aarch64_bitcoin-core-server = "${EPEL_MIRROR}/aarch64/Packages/b/bitcoin-core-server-29.2-1.el10_1.aarch64.rpm;name=aarch64_bitcoin-core-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_bitcoin-core-server}"
SRC_URI[aarch64_bitcoin-core-server.sha256sum] = "69f62b3af366fe109df62b183d8970571ecf52a835eb91f017b0c862a07286c6"

URI_aarch64_bitcoin-core-utils = "${EPEL_MIRROR}/aarch64/Packages/b/bitcoin-core-utils-29.2-1.el10_1.aarch64.rpm;name=aarch64_bitcoin-core-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_bitcoin-core-utils}"
SRC_URI[aarch64_bitcoin-core-utils.sha256sum] = "ffac6a89bab476df71e42059810c621d2001083c738f522fcc2169a65194ec97"

RDEPENDS:bitcoin-core-desktop = " \
 glibc \
 libevent \
 libgcc \
 libstdc++ \
 qrencode-libs \
 qt5-qtbase \
 qt5-qtbase-gui \
 sqlite-libs \
 zeromq \
 "
RDEPENDS:bitcoin-core-devel = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:bitcoin-core-server = " \
 bash \
 bitcoin-core-selinux \
 glibc \
 libevent \
 libgcc \
 libstdc++ \
 shadow-utils \
 sqlite-libs \
 zeromq \
 "
RDEPENDS:bitcoin-core-utils = " \
 glibc \
 libevent \
 libgcc \
 libstdc++ \
 sqlite-libs \
 "
