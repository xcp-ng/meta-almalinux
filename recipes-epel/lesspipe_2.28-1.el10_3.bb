# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lesspipe"
PV = "2.28"
PR = "1.el10_3"
PACKAGES = " \
 lesspipe \
 lesspipe-profile \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/lesspipe-2.28-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c7c66830f4e33025ee9486a0f01e2499ba84c4cd0b5b251fadc3a023b3c7fe58"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lesspipe-2.28-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_lesspipe;unpack=0"
SRC_URI[x86_64_v2_lesspipe.sha256sum] = "1e5d15b8736f083ef38fedb35a7c55ef485473efbd514a8f455dab9754e832bd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lesspipe-profile-2.28-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_lesspipe-profile;unpack=0"
SRC_URI[x86_64_v2_lesspipe-profile.sha256sum] = "4ee4cb5159aae4362aea3417f117cbed526833d7ec6f915e68e7a994e5eb4979"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lesspipe-2.28-1.el10_3.noarch.rpm;name=aarch64_lesspipe;unpack=0"
SRC_URI[aarch64_lesspipe.sha256sum] = "b72d7cf4346ebb31fc4aa1d5b395b06c1092b7ef5b79d64ca1ac4c4640b8c505"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lesspipe-profile-2.28-1.el10_3.noarch.rpm;name=aarch64_lesspipe-profile;unpack=0"
SRC_URI[aarch64_lesspipe-profile.sha256sum] = "05851dadd0772c99d4bc32abd3173679ff634e78d8f4b6c296a3b3370888a6b4"

RDEPENDS:lesspipe = " \
 bash \
 file \
 glibc-common \
 procps-ng \
 virtual//usr/bin/head \
 "
RDEPENDS:lesspipe-profile = " \
 lesspipe \
 setup \
 "
