# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libjpeg-turbo"
PV = "3.0.2"
PR = "4.el10"
PACKAGES = " \
 libjpeg-turbo \
 libjpeg-turbo-devel \
 libjpeg-turbo-utils \
 turbojpeg \
 turbojpeg-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libjpeg-turbo-3.0.2-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b5b86c33d06259116ccf3e39d365ad98320f93fe4b7f3cd051fe5accbefcfb9c"

URI_x86_64_v2_libjpeg-turbo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libjpeg-turbo-3.0.2-4.el10.x86_64_v2.rpm;name=x86_64_v2_libjpeg-turbo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libjpeg-turbo}"
SRC_URI[x86_64_v2_libjpeg-turbo.sha256sum] = "728508ad184277169cd63265cdcbf67bbe0f5bde3b0965172eae70edb4d5917e"

URI_x86_64_v2_libjpeg-turbo-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libjpeg-turbo-devel-3.0.2-4.el10.x86_64_v2.rpm;name=x86_64_v2_libjpeg-turbo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libjpeg-turbo-devel}"
SRC_URI[x86_64_v2_libjpeg-turbo-devel.sha256sum] = "357d103110c330c358a6840620e61e1352f54aff7007025d4ae4ad12f421c872"

URI_x86_64_v2_libjpeg-turbo-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libjpeg-turbo-utils-3.0.2-4.el10.x86_64_v2.rpm;name=x86_64_v2_libjpeg-turbo-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libjpeg-turbo-utils}"
SRC_URI[x86_64_v2_libjpeg-turbo-utils.sha256sum] = "f6e61cd3995c7a30269705527cc3b901b509c192af4fc5135d84fa14a12b3e99"

URI_x86_64_v2_turbojpeg = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/turbojpeg-3.0.2-4.el10.x86_64_v2.rpm;name=x86_64_v2_turbojpeg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_turbojpeg}"
SRC_URI[x86_64_v2_turbojpeg.sha256sum] = "57757803c80e56f744c5e5035f861c6f906bc1e431d795f4fa010bbbecec6de6"

URI_x86_64_v2_turbojpeg-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/turbojpeg-devel-3.0.2-4.el10.x86_64_v2.rpm;name=x86_64_v2_turbojpeg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_turbojpeg-devel}"
SRC_URI[x86_64_v2_turbojpeg-devel.sha256sum] = "b47c738218b01bc45927b882d6ced19a5f9247ffe49475347a738479e0cbf4f8"

URI_aarch64_libjpeg-turbo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libjpeg-turbo-3.0.2-4.el10.aarch64.rpm;name=aarch64_libjpeg-turbo;unpack=0"
SRC_URI:append = " ${URI_aarch64_libjpeg-turbo}"
SRC_URI[aarch64_libjpeg-turbo.sha256sum] = "2feaff518e78e3395767c576a927386ecd057cb7dd407bab47e5402fb922b5a7"

URI_aarch64_libjpeg-turbo-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libjpeg-turbo-devel-3.0.2-4.el10.aarch64.rpm;name=aarch64_libjpeg-turbo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libjpeg-turbo-devel}"
SRC_URI[aarch64_libjpeg-turbo-devel.sha256sum] = "b6e7c31784fe3d8d7cb320bfa0784d040637fafbbeb729fb5736f3648f3f36ea"

URI_aarch64_libjpeg-turbo-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libjpeg-turbo-utils-3.0.2-4.el10.aarch64.rpm;name=aarch64_libjpeg-turbo-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libjpeg-turbo-utils}"
SRC_URI[aarch64_libjpeg-turbo-utils.sha256sum] = "2707d7ce316fa1453a89a7b3929d154df8543bcce0cb4cef65b6ac3b59c12e06"

URI_aarch64_turbojpeg = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/turbojpeg-3.0.2-4.el10.aarch64.rpm;name=aarch64_turbojpeg;unpack=0"
SRC_URI:append = " ${URI_aarch64_turbojpeg}"
SRC_URI[aarch64_turbojpeg.sha256sum] = "7757d72c3d98e41bfc6ba364b68539743c94f5d7cc99774ad1dad34c798b1394"

URI_aarch64_turbojpeg-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/turbojpeg-devel-3.0.2-4.el10.aarch64.rpm;name=aarch64_turbojpeg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_turbojpeg-devel}"
SRC_URI[aarch64_turbojpeg-devel.sha256sum] = "25a17e87ae2d0e166e06c3b970e1558155c148bc6ec27311f2cdf1ac8392edb0"

RDEPENDS:libjpeg-turbo = " \
 glibc \
 "
RDEPENDS:libjpeg-turbo-devel = " \
 cmake-filesystem \
 libjpeg-turbo \
 pkgconf-pkg-config \
 "
RDEPENDS:libjpeg-turbo-utils = " \
 glibc \
 libjpeg-turbo \
 "
RDEPENDS:turbojpeg = " \
 glibc \
 "
RDEPENDS:turbojpeg-devel = " \
 pkgconf-pkg-config \
 turbojpeg \
 "
