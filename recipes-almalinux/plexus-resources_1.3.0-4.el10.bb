# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plexus-resources"
PV = "1.3.0"
PR = "4.el10"
PACKAGES = " \
 plexus-resources \
 plexus-resources-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/plexus-resources-1.3.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09219eb43105901be0e25830472472bbe23574136f7b50921f47001267ff09d4"

URI_x86_64_v2_plexus-resources = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/plexus-resources-1.3.0-4.el10.noarch.rpm;name=x86_64_v2_plexus-resources;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plexus-resources}"
SRC_URI[x86_64_v2_plexus-resources.sha256sum] = "daf65359a0cbea75354e576a96f033d9047151a6fef34551d453862c29ab5654"

URI_x86_64_v2_plexus-resources-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/plexus-resources-javadoc-1.3.0-4.el10.noarch.rpm;name=x86_64_v2_plexus-resources-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plexus-resources-javadoc}"
SRC_URI[x86_64_v2_plexus-resources-javadoc.sha256sum] = "24796859c68962fa7c18b2181262c68be1fc1dfd9732d1a5c1db9dd193f30359"

URI_aarch64_plexus-resources = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/plexus-resources-1.3.0-4.el10.noarch.rpm;name=aarch64_plexus-resources;unpack=0"
SRC_URI:append = " ${URI_aarch64_plexus-resources}"
SRC_URI[aarch64_plexus-resources.sha256sum] = "daf65359a0cbea75354e576a96f033d9047151a6fef34551d453862c29ab5654"

URI_aarch64_plexus-resources-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/plexus-resources-javadoc-1.3.0-4.el10.noarch.rpm;name=aarch64_plexus-resources-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_plexus-resources-javadoc}"
SRC_URI[aarch64_plexus-resources-javadoc.sha256sum] = "24796859c68962fa7c18b2181262c68be1fc1dfd9732d1a5c1db9dd193f30359"

RDEPENDS:plexus-resources = " \
 atinject \
 javapackages-filesystem \
 plexus-utils \
 plexus-xml \
 slf4j \
 "
RDEPENDS:plexus-resources-javadoc = " \
 javapackages-filesystem \
 "
