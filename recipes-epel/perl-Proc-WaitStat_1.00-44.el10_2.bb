# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Proc-WaitStat"
PV = "1.00"
PR = "44.el10_2"
PACKAGES = " \
 perl-Proc-WaitStat \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Proc-WaitStat-1.00-44.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d29eeaeacb2770952c4f075a3da9294ae36dacdb2fc6b62e6a40e9c132509a68"

URI_x86_64_v2_perl-Proc-WaitStat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Proc-WaitStat-1.00-44.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Proc-WaitStat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Proc-WaitStat}"
SRC_URI[x86_64_v2_perl-Proc-WaitStat.sha256sum] = "b30ebf79f260c4c95fbe27571af414b875459ba90f735b84bf564c766d669af5"

URI_aarch64_perl-Proc-WaitStat = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Proc-WaitStat-1.00-44.el10_2.noarch.rpm;name=aarch64_perl-Proc-WaitStat;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Proc-WaitStat}"
SRC_URI[aarch64_perl-Proc-WaitStat.sha256sum] = "7d46f144aa15bab7744f84755e37487ff9cd0f07d2b07c4c89df117838ff8669"

RDEPENDS:perl-Proc-WaitStat = " \
 perl-Carp \
 perl-Exporter \
 perl-IPC-Signal \
 perl-POSIX \
 perl-libs \
 perl-vars \
 "
