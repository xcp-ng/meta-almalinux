# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "liblas"
PV = "1.8.2"
PR = "0.28.git0756b73.el10_2"
PACKAGES = " \
 liblas \
 liblas-devel \
 liblas-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/liblas-1.8.2-0.28.git0756b73.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b758721692c9efbd19b739e2579d63863cdb837e5ef2bd9b0b8e3575ad082b7b"

URI_x86_64_v2_liblas = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liblas-1.8.2-0.28.git0756b73.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liblas;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liblas}"
SRC_URI[x86_64_v2_liblas.sha256sum] = "186e074c396ec28090dd2a097281d2f80c15bbb64063df055d514ba1bb74f32f"

URI_x86_64_v2_liblas-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liblas-devel-1.8.2-0.28.git0756b73.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liblas-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liblas-devel}"
SRC_URI[x86_64_v2_liblas-devel.sha256sum] = "da5cdbb0a59b09d31551cddd5f66d0734508677dcd1983b7eae500a33b21aba7"

URI_x86_64_v2_liblas-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liblas-tools-1.8.2-0.28.git0756b73.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liblas-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liblas-tools}"
SRC_URI[x86_64_v2_liblas-tools.sha256sum] = "50221920bec89f0ccfe241c41e863ceded030f4b1e0d45af63373fd59b3272fd"

URI_aarch64_liblas = "${EPEL_MIRROR}/aarch64/Packages/l/liblas-1.8.2-0.28.git0756b73.el10_2.aarch64.rpm;name=aarch64_liblas;unpack=0"
SRC_URI:append = " ${URI_aarch64_liblas}"
SRC_URI[aarch64_liblas.sha256sum] = "722f1a38a14c34f8f1f8498ee5bab5ba1346d64540e6708c5bd44157771c33b9"

URI_aarch64_liblas-devel = "${EPEL_MIRROR}/aarch64/Packages/l/liblas-devel-1.8.2-0.28.git0756b73.el10_2.aarch64.rpm;name=aarch64_liblas-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_liblas-devel}"
SRC_URI[aarch64_liblas-devel.sha256sum] = "bd8650e20b3b87d88a4c579cd0c83d374ccc6f41c1ddbf9eb0f7ecc18e3d50f4"

URI_aarch64_liblas-tools = "${EPEL_MIRROR}/aarch64/Packages/l/liblas-tools-1.8.2-0.28.git0756b73.el10_2.aarch64.rpm;name=aarch64_liblas-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_liblas-tools}"
SRC_URI[aarch64_liblas-tools.sha256sum] = "b43804060c53176f6edf23ad56e9090ea4a293bee637f1a23fc345fe4fd01ccf"

RDEPENDS:liblas = " \
 boost-thread \
 gdal-libs \
 glibc \
 laszip \
 libgcc \
 libgeotiff \
 libstdc++ \
 libtiff \
 "
RDEPENDS:liblas-devel = " \
 boost-devel \
 cmake-filesystem \
 gdal-devel \
 laszip-devel \
 libgeotiff-devel \
 liblas \
 pkgconf-pkg-config \
 "
RDEPENDS:liblas-tools = " \
 boost-program-options \
 gdal-libs \
 glibc \
 libgcc \
 libgeotiff \
 liblas \
 libstdc++ \
 "
