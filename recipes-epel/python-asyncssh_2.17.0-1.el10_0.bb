# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-asyncssh"
PV = "2.17.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-asyncssh \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-asyncssh-2.17.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a66e583d918efaef38951c7db9f58f56888d4e10e6299ac1ee0fcc4dcfb1818"

URI_x86_64_v2_python3-asyncssh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-asyncssh-2.17.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-asyncssh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-asyncssh}"
SRC_URI[x86_64_v2_python3-asyncssh.sha256sum] = "c4b6c917eb915df33175a3a351d5cd57d73dff1abbb4e8cceb3422331e32eb47"

URI_aarch64_python3-asyncssh = "${EPEL_MIRROR}/aarch64/Packages/p/python3-asyncssh-2.17.0-1.el10_0.noarch.rpm;name=aarch64_python3-asyncssh;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-asyncssh}"
SRC_URI[aarch64_python3-asyncssh.sha256sum] = "03dcf0348a789e77813300f6b7ac4d8edef6efedec4264db5f46b5fcc53dc797"

RDEPENDS:python3-asyncssh = " \
 python3 \
 python3-cryptography \
 python3-typing-extensions \
 "
