# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hicolor-icon-theme"
PV = "0.17"
PR = "20.el10"
PACKAGES = " \
 hicolor-icon-theme \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hicolor-icon-theme-0.17-20.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "19d8bbd683db7b72acce1446d2cc0c2039040dc80c17b75f503ff04ae1863c6c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hicolor-icon-theme-0.17-20.el10.noarch.rpm;name=x86_64_v2_hicolor-icon-theme;unpack=0"
SRC_URI[x86_64_v2_hicolor-icon-theme.sha256sum] = "950e9f48cde713dc829d476516323e5b9f3ce2404ddd6bb01460e238583f8c98"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hicolor-icon-theme-0.17-20.el10.noarch.rpm;name=aarch64_hicolor-icon-theme;unpack=0"
SRC_URI[aarch64_hicolor-icon-theme.sha256sum] = "950e9f48cde713dc829d476516323e5b9f3ce2404ddd6bb01460e238583f8c98"

RDEPENDS:hicolor-icon-theme = " \
 bash \
 "
