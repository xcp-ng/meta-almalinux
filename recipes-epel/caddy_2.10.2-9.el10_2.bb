# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "caddy"
PV = "2.10.2"
PR = "9.el10_2"
PACKAGES = " \
 caddy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/caddy-2.10.2-9.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed42a2f4b071126ee5ac18a964f8c0fa40ec8e42c875d854559ee5a8be694352"

URI_x86_64_v2_caddy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/caddy-2.10.2-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_caddy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_caddy}"
SRC_URI[x86_64_v2_caddy.sha256sum] = "70d248f1bfc68109276dc348656d101badb50acb381a6447e68d4d0d26cdaec7"
RPROVIDES:caddy:x86_64_v2 = "virtual/webserver"

URI_aarch64_caddy = "${EPEL_MIRROR}/aarch64/Packages/c/caddy-2.10.2-9.el10_2.aarch64.rpm;name=aarch64_caddy;unpack=0"
SRC_URI:append = " ${URI_aarch64_caddy}"
SRC_URI[aarch64_caddy.sha256sum] = "ec90529a823f58d17d65b84260fa9c1683021845a7bec29d531e419493357b70"
RPROVIDES:caddy:aarch64 = "virtual/webserver"

RDEPENDS:caddy = " \
 almalinux-logos-httpd \
 bash \
 glibc \
 shadow-utils \
 systemd \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/webserver"

PROVIDES:append:aarch64 = " rpm/virtual/webserver"
