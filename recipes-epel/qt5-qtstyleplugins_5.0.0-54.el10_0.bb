# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtstyleplugins"
PV = "5.0.0"
PR = "54.el10_0"
PACKAGES = " \
 qt5-qtstyleplugins \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtstyleplugins-5.0.0-54.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0d86b7a19031ffb19ba8b74631c2e5ea98a4e4d3e754cb82667b8f3b4c52a8fa"

URI_x86_64_v2_qt5-qtstyleplugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtstyleplugins-5.0.0-54.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtstyleplugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtstyleplugins}"
SRC_URI[x86_64_v2_qt5-qtstyleplugins.sha256sum] = "a49d86761b6a0623a0ef9e8b9b5abe1117056d2317cc2c08091668c76fae455e"

URI_aarch64_qt5-qtstyleplugins = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtstyleplugins-5.0.0-54.el10_0.aarch64.rpm;name=aarch64_qt5-qtstyleplugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtstyleplugins}"
SRC_URI[aarch64_qt5-qtstyleplugins.sha256sum] = "9bef854c8fdae2d4d371156d6585b9f502dd592d0288d925e026c0aa9c128b19"

RDEPENDS:qt5-qtstyleplugins = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
