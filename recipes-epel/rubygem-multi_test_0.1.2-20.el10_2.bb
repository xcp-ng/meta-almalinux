# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-multi_test"
PV = "0.1.2"
PR = "20.el10_2"
PACKAGES = " \
 rubygem-multi_test \
 rubygem-multi_test-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-multi_test-0.1.2-20.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac80a7718fa09dfa12137f6257cf95c046a481f81d8909810edb497379a123b8"

URI_x86_64_v2_rubygem-multi_test = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-multi_test-0.1.2-20.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-multi_test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-multi_test}"
SRC_URI[x86_64_v2_rubygem-multi_test.sha256sum] = "bbd44daeb47e66e14751dfe48aaed11549918b3384d002464a61b67d8065f163"

URI_x86_64_v2_rubygem-multi_test-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-multi_test-doc-0.1.2-20.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-multi_test-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-multi_test-doc}"
SRC_URI[x86_64_v2_rubygem-multi_test-doc.sha256sum] = "9151688df49eccb9d855e28ce43e9fedfe8281ebe4c65788f51deef4286d1a19"

URI_aarch64_rubygem-multi_test = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-multi_test-0.1.2-20.el10_2.noarch.rpm;name=aarch64_rubygem-multi_test;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-multi_test}"
SRC_URI[aarch64_rubygem-multi_test.sha256sum] = "80c3056365a9a480c8f95d1ae4b06beb8ac3d328070676bddf1e1d1ce1e8a46a"

URI_aarch64_rubygem-multi_test-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-multi_test-doc-0.1.2-20.el10_2.noarch.rpm;name=aarch64_rubygem-multi_test-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-multi_test-doc}"
SRC_URI[aarch64_rubygem-multi_test-doc.sha256sum] = "0c77a2228f73a7f2eef8bc7259dff67efb75133af1b3e004563dd9d3e4b8f3e9"

RDEPENDS:rubygem-multi_test = " \
 rubygems \
 "
RDEPENDS:rubygem-multi_test-doc = " \
 bash \
 rubygem-multi_test \
 "
