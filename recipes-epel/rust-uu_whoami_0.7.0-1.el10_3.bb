# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_whoami"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_whoami+default-devel \
 rust-uu_whoami-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_whoami-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "294d4a19fdd97bce9f1811f608fc2294bc00e8aab7630b1bb78bd9b774940d0c"

URI_x86_64_v2_rust-uu_whoami+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_whoami+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_whoami+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_whoami+default-devel}"
SRC_URI[x86_64_v2_rust-uu_whoami+default-devel.sha256sum] = "94ce5ea9479f2986a05e57a77a0a7ceadf0a156e2cade866a046fbc421748719"

URI_x86_64_v2_rust-uu_whoami-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_whoami-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_whoami-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_whoami-devel}"
SRC_URI[x86_64_v2_rust-uu_whoami-devel.sha256sum] = "b5df68a4e189ff2dd625ac65976209e86956f2413b57a987c4880201a7808029"

URI_aarch64_rust-uu_whoami+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_whoami+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_whoami+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_whoami+default-devel}"
SRC_URI[aarch64_rust-uu_whoami+default-devel.sha256sum] = "d8f6abbf7a34c4e3b9b139c0aee2cb0ced52f87d47ecdd58c397c13f69a9cdf9"

URI_aarch64_rust-uu_whoami-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_whoami-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_whoami-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_whoami-devel}"
SRC_URI[aarch64_rust-uu_whoami-devel.sha256sum] = "545211da4938ac01fe4cfa7da5f9bc4a8171489ecd5a84f4579b253c7907f4b0"

RDEPENDS:rust-uu_whoami+default-devel = " \
 cargo \
 rust-uu_whoami-devel \
 "
RDEPENDS:rust-uu_whoami-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uucore+default-devel \
 rust-uucore+entries-devel \
 rust-uucore+process-devel \
 "
