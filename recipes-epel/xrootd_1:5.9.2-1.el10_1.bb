# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xrootd"
PE = "1"
PV = "5.9.2"
PR = "1.el10_1"
PACKAGES = " \
 python3-xrootd \
 xrdcl-http \
 xrootd \
 xrootd-client \
 xrootd-client-devel \
 xrootd-client-libs \
 xrootd-devel \
 xrootd-doc \
 xrootd-fuse \
 xrootd-libs \
 xrootd-private-devel \
 xrootd-scitokens \
 xrootd-selinux \
 xrootd-server \
 xrootd-server-devel \
 xrootd-server-libs \
 xrootd-voms \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xrootd-5.9.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4daf8729e324102ced94f3b17ad63a782ed5f6df3b77ebe55962133a875abbe6"

URI_x86_64_v2_python3-xrootd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-xrootd-5.9.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-xrootd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-xrootd}"
SRC_URI[x86_64_v2_python3-xrootd.sha256sum] = "a4fbadf47fedf48f99bbb155b6abbe6d5de216650768871c9f07a2df30353e93"

URI_x86_64_v2_xrdcl-http = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrdcl-http-5.9.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrdcl-http;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrdcl-http}"
SRC_URI[x86_64_v2_xrdcl-http.sha256sum] = "47e99ecccb859b105723e76a8b4e45e3ca4428fb5046b623b711d96639fccbde"

URI_x86_64_v2_xrootd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-5.9.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrootd}"
SRC_URI[x86_64_v2_xrootd.sha256sum] = "c2acbd40f0134201ac605372dd37b00d2863b6129112fbe3e1b0977682ebad8e"

URI_x86_64_v2_xrootd-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-client-5.9.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrootd-client}"
SRC_URI[x86_64_v2_xrootd-client.sha256sum] = "98756aab84cd9db33080511ea7f40ee09237c70bc4077b405d73ff61b1348754"

URI_x86_64_v2_xrootd-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-client-devel-5.9.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrootd-client-devel}"
SRC_URI[x86_64_v2_xrootd-client-devel.sha256sum] = "2382b7a9474703dbd986f0a7028ae2079d98ae5e96391052f710e13b162660dc"

URI_x86_64_v2_xrootd-client-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-client-libs-5.9.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-client-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrootd-client-libs}"
SRC_URI[x86_64_v2_xrootd-client-libs.sha256sum] = "60e4e2cef3fe644d2e0871e9ba0edee4f717d141802617fae9bfdcc97585bbeb"

URI_x86_64_v2_xrootd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-devel-5.9.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrootd-devel}"
SRC_URI[x86_64_v2_xrootd-devel.sha256sum] = "4e02ab4c58354b517cba21d616eccf1ada6199da7965c32208cdf83731ab064f"

URI_x86_64_v2_xrootd-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-doc-5.9.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_xrootd-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrootd-doc}"
SRC_URI[x86_64_v2_xrootd-doc.sha256sum] = "4ded97087b20909bc637d856fa2fa2e4fb0b4d22d0b7ac5ef4789a86b6172cee"

URI_x86_64_v2_xrootd-fuse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-fuse-5.9.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-fuse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrootd-fuse}"
SRC_URI[x86_64_v2_xrootd-fuse.sha256sum] = "51a49bce1fcbfefa1c8ef3c419ab79500f454b764d558b64d99740dbeccf2e01"

URI_x86_64_v2_xrootd-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-libs-5.9.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrootd-libs}"
SRC_URI[x86_64_v2_xrootd-libs.sha256sum] = "6e21173fb810508e30b0847ad2a96e713e48b84cda3c243cfe3ff6625093fe0b"

URI_x86_64_v2_xrootd-private-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-private-devel-5.9.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-private-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrootd-private-devel}"
SRC_URI[x86_64_v2_xrootd-private-devel.sha256sum] = "aabc20b5d6830dcdee29cbd60c022137e7c1f9002cb9e83d66f4bb5967183372"

URI_x86_64_v2_xrootd-scitokens = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-scitokens-5.9.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-scitokens;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrootd-scitokens}"
SRC_URI[x86_64_v2_xrootd-scitokens.sha256sum] = "826e6b9e73ca40a9098f769336d5b933ce822b370a45769bd43a73af6c1d1bc2"

URI_x86_64_v2_xrootd-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-selinux-5.9.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_xrootd-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrootd-selinux}"
SRC_URI[x86_64_v2_xrootd-selinux.sha256sum] = "a7fa6742fc3bb813ee8b7ed97a5dede4a0d85af7a9b5364072ba2f43a67605ae"

URI_x86_64_v2_xrootd-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-server-5.9.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrootd-server}"
SRC_URI[x86_64_v2_xrootd-server.sha256sum] = "d6e970891e7521d3592795f32997146f3f51e76c725310a6b2d2c7d099e759f1"

URI_x86_64_v2_xrootd-server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-server-devel-5.9.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrootd-server-devel}"
SRC_URI[x86_64_v2_xrootd-server-devel.sha256sum] = "1e87080f81e49d880fa50c1140ee8d1214b68d72f855e10b1fe721d1da3b6b4d"

URI_x86_64_v2_xrootd-server-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-server-libs-5.9.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-server-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrootd-server-libs}"
SRC_URI[x86_64_v2_xrootd-server-libs.sha256sum] = "d407f63df828c0dea2e6e9131ffc99ddb83557231a8598a69b852291dc7857f6"

URI_x86_64_v2_xrootd-voms = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-voms-5.9.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-voms;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xrootd-voms}"
SRC_URI[x86_64_v2_xrootd-voms.sha256sum] = "b50f15c9b4b035584ca0ac1055b183f09e2831ba764d60b2e40568c88a96cbf5"

URI_aarch64_python3-xrootd = "${EPEL_MIRROR}/aarch64/Packages/p/python3-xrootd-5.9.2-1.el10_1.aarch64.rpm;name=aarch64_python3-xrootd;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-xrootd}"
SRC_URI[aarch64_python3-xrootd.sha256sum] = "91d2b7eaf14187b1360064760ae32d5067d554d6623083e2ff15cf95174ccb0b"

URI_aarch64_xrdcl-http = "${EPEL_MIRROR}/aarch64/Packages/x/xrdcl-http-5.9.2-1.el10_1.aarch64.rpm;name=aarch64_xrdcl-http;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrdcl-http}"
SRC_URI[aarch64_xrdcl-http.sha256sum] = "9f7059cea76146521242c5ecf1e0227592c910604973ca6f578303f9adf3ecc6"

URI_aarch64_xrootd = "${EPEL_MIRROR}/aarch64/Packages/x/xrootd-5.9.2-1.el10_1.aarch64.rpm;name=aarch64_xrootd;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrootd}"
SRC_URI[aarch64_xrootd.sha256sum] = "af2879c1084fa5c10f81a53e235b4b1b28d7abb4bbefea9f12beaf2dcb5d8956"

URI_aarch64_xrootd-client = "${EPEL_MIRROR}/aarch64/Packages/x/xrootd-client-5.9.2-1.el10_1.aarch64.rpm;name=aarch64_xrootd-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrootd-client}"
SRC_URI[aarch64_xrootd-client.sha256sum] = "372ff3b667e91a7e496267ab9ad610e023f926096ce25f0a61579fcd06b658cc"

URI_aarch64_xrootd-client-devel = "${EPEL_MIRROR}/aarch64/Packages/x/xrootd-client-devel-5.9.2-1.el10_1.aarch64.rpm;name=aarch64_xrootd-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrootd-client-devel}"
SRC_URI[aarch64_xrootd-client-devel.sha256sum] = "d9d05d6d9c06e865da722379b6e6c090392f50e87fc3d18bab2d158576163106"

URI_aarch64_xrootd-client-libs = "${EPEL_MIRROR}/aarch64/Packages/x/xrootd-client-libs-5.9.2-1.el10_1.aarch64.rpm;name=aarch64_xrootd-client-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrootd-client-libs}"
SRC_URI[aarch64_xrootd-client-libs.sha256sum] = "1e021877a2fc27285a35be94202fca74a06a1ffa9366cd7d17352056845c3d29"

URI_aarch64_xrootd-devel = "${EPEL_MIRROR}/aarch64/Packages/x/xrootd-devel-5.9.2-1.el10_1.aarch64.rpm;name=aarch64_xrootd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrootd-devel}"
SRC_URI[aarch64_xrootd-devel.sha256sum] = "0c3a7cf045d288561e2aeaf79a290601938644f6891ffdc4a23c6e7b349b03d8"

URI_aarch64_xrootd-doc = "${EPEL_MIRROR}/aarch64/Packages/x/xrootd-doc-5.9.2-1.el10_1.noarch.rpm;name=aarch64_xrootd-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrootd-doc}"
SRC_URI[aarch64_xrootd-doc.sha256sum] = "3ab405273813f19a31194e07a7ff08cfaaf11059dc1504d7f7075fb9e9c0b75e"

URI_aarch64_xrootd-fuse = "${EPEL_MIRROR}/aarch64/Packages/x/xrootd-fuse-5.9.2-1.el10_1.aarch64.rpm;name=aarch64_xrootd-fuse;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrootd-fuse}"
SRC_URI[aarch64_xrootd-fuse.sha256sum] = "0ebffb26ae4721111a1169ae3a57fe959e36658dddc7409fc3db357956f838ea"

URI_aarch64_xrootd-libs = "${EPEL_MIRROR}/aarch64/Packages/x/xrootd-libs-5.9.2-1.el10_1.aarch64.rpm;name=aarch64_xrootd-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrootd-libs}"
SRC_URI[aarch64_xrootd-libs.sha256sum] = "eecf72185f41066bba5da513e27b11b578f461a820bbe3237c9818d177736726"

URI_aarch64_xrootd-private-devel = "${EPEL_MIRROR}/aarch64/Packages/x/xrootd-private-devel-5.9.2-1.el10_1.aarch64.rpm;name=aarch64_xrootd-private-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrootd-private-devel}"
SRC_URI[aarch64_xrootd-private-devel.sha256sum] = "f8b03558edc5bae7012cd7e499c483fb0e4e7414db653aeec84e959568b44054"

URI_aarch64_xrootd-scitokens = "${EPEL_MIRROR}/aarch64/Packages/x/xrootd-scitokens-5.9.2-1.el10_1.aarch64.rpm;name=aarch64_xrootd-scitokens;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrootd-scitokens}"
SRC_URI[aarch64_xrootd-scitokens.sha256sum] = "69df53520a3930bfaf42a05d037dd1f83fc21c6b2b1ae64702e74e102dfbce0e"

URI_aarch64_xrootd-selinux = "${EPEL_MIRROR}/aarch64/Packages/x/xrootd-selinux-5.9.2-1.el10_1.noarch.rpm;name=aarch64_xrootd-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrootd-selinux}"
SRC_URI[aarch64_xrootd-selinux.sha256sum] = "f54af754a87b94535e606bad080e15111c92f4a2022c3a9136dab3f12e87ac09"

URI_aarch64_xrootd-server = "${EPEL_MIRROR}/aarch64/Packages/x/xrootd-server-5.9.2-1.el10_1.aarch64.rpm;name=aarch64_xrootd-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrootd-server}"
SRC_URI[aarch64_xrootd-server.sha256sum] = "86b858be55b389cd282b2ce9b77bb5e972ce680443925c901f0ef31b9f3ed927"

URI_aarch64_xrootd-server-devel = "${EPEL_MIRROR}/aarch64/Packages/x/xrootd-server-devel-5.9.2-1.el10_1.aarch64.rpm;name=aarch64_xrootd-server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrootd-server-devel}"
SRC_URI[aarch64_xrootd-server-devel.sha256sum] = "c07bcaf75405de2cebccec8fe9ccea4f129206e97087305c5cee28fd6a44cca8"

URI_aarch64_xrootd-server-libs = "${EPEL_MIRROR}/aarch64/Packages/x/xrootd-server-libs-5.9.2-1.el10_1.aarch64.rpm;name=aarch64_xrootd-server-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrootd-server-libs}"
SRC_URI[aarch64_xrootd-server-libs.sha256sum] = "2b8961d8fff8d0fdc4daf794fc99661cb344c81961a87535949258df29912e4e"

URI_aarch64_xrootd-voms = "${EPEL_MIRROR}/aarch64/Packages/x/xrootd-voms-5.9.2-1.el10_1.aarch64.rpm;name=aarch64_xrootd-voms;unpack=0"
SRC_URI:append = " ${URI_aarch64_xrootd-voms}"
SRC_URI[aarch64_xrootd-voms.sha256sum] = "c8806b8dc8c83530cf4593b2fcdd3724d923e74f44f2bed4b7105f5e444b04fa"

RDEPENDS:python3-xrootd = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 xrootd-client-libs \
 xrootd-libs \
 "
RDEPENDS:xrdcl-http = " \
 davix-libs \
 glibc \
 libgcc \
 libstdc++ \
 xrootd-client-libs \
 xrootd-libs \
 "
RDEPENDS:xrootd = " \
 xrootd-selinux \
 xrootd-server \
 "
RDEPENDS:xrootd-client = " \
 glibc \
 libgcc \
 libstdc++ \
 readline \
 xrootd-client-libs \
 xrootd-libs \
 zlib-ng-compat \
 "
RDEPENDS:xrootd-client-devel = " \
 xrootd-client-libs \
 xrootd-devel \
 "
RDEPENDS:xrootd-client-libs = " \
 glibc \
 isa-l \
 libgcc \
 libstdc++ \
 libuuid \
 xrootd-libs \
 zlib-ng-compat \
 "
RDEPENDS:xrootd-devel = " \
 bash \
 cmake-filesystem \
 xrootd-libs \
 "
RDEPENDS:xrootd-doc = " \
 "
RDEPENDS:xrootd-fuse = " \
 fuse \
 fuse-libs \
 glibc \
 libgcc \
 libstdc++ \
 xrootd-client-libs \
 xrootd-libs \
 "
RDEPENDS:xrootd-libs = " \
 glibc \
 krb5-libs \
 libcom_err \
 libgcc \
 libstdc++ \
 libxcrypt \
 libxml2 \
 openssl-libs \
 systemd-libs \
 tinyxml \
 zlib-ng-compat \
 "
RDEPENDS:xrootd-private-devel = " \
 xrootd-client-devel \
 xrootd-client-libs \
 xrootd-devel \
 xrootd-server-devel \
 "
RDEPENDS:xrootd-scitokens = " \
 glibc \
 libgcc \
 libstdc++ \
 scitokens-cpp \
 xrootd-libs \
 xrootd-server \
 "
RDEPENDS:xrootd-selinux = " \
 bash \
 policycoreutils \
 selinux-policy \
 "
RDEPENDS:xrootd-server = " \
 bash \
 expect \
 glibc \
 libgcc \
 libstdc++ \
 logrotate \
 perl-Exporter \
 perl-IO \
 perl-IPC-Open3 \
 perl-PathTools \
 perl-Socket \
 perl-interpreter \
 readline \
 shadow-utils \
 systemd \
 xrootd-client-libs \
 xrootd-libs \
 xrootd-server-libs \
 "
RDEPENDS:xrootd-server-devel = " \
 xrootd-client-devel \
 xrootd-devel \
 xrootd-server-libs \
 "
RDEPENDS:xrootd-server-libs = " \
 glibc \
 json-c \
 libgcc \
 libmacaroons \
 libstdc++ \
 libuuid \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 xrootd-client-libs \
 xrootd-libs \
 "
RDEPENDS:xrootd-voms = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 voms \
 xrootd-libs \
 "
