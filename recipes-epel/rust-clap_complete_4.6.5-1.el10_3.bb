# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap_complete"
PV = "4.6.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-clap_complete+debug-devel \
 rust-clap_complete+default-devel \
 rust-clap_complete+unstable-doc-devel \
 rust-clap_complete+unstable-dynamic-devel \
 rust-clap_complete-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap_complete-4.6.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c93c0c4f45ca81914a7854ff81157c68d0d6487d684bef011bd98408c3c0b3df"

URI_x86_64_v2_rust-clap_complete+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete+debug-devel-4.6.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete+debug-devel}"
SRC_URI[x86_64_v2_rust-clap_complete+debug-devel.sha256sum] = "b81cbab5b07614d07fc60a494d6411037cddf65c6484510c9227bae8c077437e"

URI_x86_64_v2_rust-clap_complete+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete+default-devel-4.6.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete+default-devel}"
SRC_URI[x86_64_v2_rust-clap_complete+default-devel.sha256sum] = "07fa8a66baecc407642a3b11039dc9747bdbe30dce3f1702dd6082da3796bf77"

URI_x86_64_v2_rust-clap_complete+unstable-doc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete+unstable-doc-devel-4.6.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete+unstable-doc-devel}"
SRC_URI[x86_64_v2_rust-clap_complete+unstable-doc-devel.sha256sum] = "62acfdc7b0402e4e05b2de20bb031c94fee695c4223c89b79b2e513193b2a7cc"

URI_x86_64_v2_rust-clap_complete+unstable-dynamic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete+unstable-dynamic-devel-4.6.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete+unstable-dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete+unstable-dynamic-devel}"
SRC_URI[x86_64_v2_rust-clap_complete+unstable-dynamic-devel.sha256sum] = "316f5a8ae6c836c224c8d2ec07145513fd36407d5c5e259e758891c2f94db2c4"

URI_x86_64_v2_rust-clap_complete-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete-devel-4.6.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete-devel}"
SRC_URI[x86_64_v2_rust-clap_complete-devel.sha256sum] = "3324c0e2c7b69ebf0ed1fdeda309e1db51de229df7b2daad45a7931769714b3d"

URI_aarch64_rust-clap_complete+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete+debug-devel-4.6.5-1.el10_3.noarch.rpm;name=aarch64_rust-clap_complete+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete+debug-devel}"
SRC_URI[aarch64_rust-clap_complete+debug-devel.sha256sum] = "b111ebfd6dbe20f072cb16ea93fe6c805fa06dfdc34999e20a3a2d8edc548758"

URI_aarch64_rust-clap_complete+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete+default-devel-4.6.5-1.el10_3.noarch.rpm;name=aarch64_rust-clap_complete+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete+default-devel}"
SRC_URI[aarch64_rust-clap_complete+default-devel.sha256sum] = "1976346a42bc2985616fb96130b1ea0b16ad2f978351208efe2ce9919fa3ac51"

URI_aarch64_rust-clap_complete+unstable-doc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete+unstable-doc-devel-4.6.5-1.el10_3.noarch.rpm;name=aarch64_rust-clap_complete+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete+unstable-doc-devel}"
SRC_URI[aarch64_rust-clap_complete+unstable-doc-devel.sha256sum] = "6d949505a7322ec5ff639df0dabcbbff929210a52b21587af688e5b87c85ded5"

URI_aarch64_rust-clap_complete+unstable-dynamic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete+unstable-dynamic-devel-4.6.5-1.el10_3.noarch.rpm;name=aarch64_rust-clap_complete+unstable-dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete+unstable-dynamic-devel}"
SRC_URI[aarch64_rust-clap_complete+unstable-dynamic-devel.sha256sum] = "e0dd0c923833e36c3aed85cdb5524fd94fca9fd07b82759f51b9788ccb427f47"

URI_aarch64_rust-clap_complete-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete-devel-4.6.5-1.el10_3.noarch.rpm;name=aarch64_rust-clap_complete-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete-devel}"
SRC_URI[aarch64_rust-clap_complete-devel.sha256sum] = "9645feea55c3dcc32ee53effaebd35c2e52c22a721889c766f5ea21268eaa290"

RDEPENDS:rust-clap_complete+debug-devel = " \
 cargo \
 rust-clap+debug-devel \
 rust-clap_complete-devel \
 "
RDEPENDS:rust-clap_complete+default-devel = " \
 cargo \
 rust-clap_complete-devel \
 "
RDEPENDS:rust-clap_complete+unstable-doc-devel = " \
 cargo \
 rust-clap_complete+unstable-dynamic-devel \
 rust-clap_complete-devel \
 "
RDEPENDS:rust-clap_complete+unstable-dynamic-devel = " \
 cargo \
 rust-clap+unstable-ext-devel \
 rust-clap_complete-devel \
 rust-clap_lex+default-devel \
 rust-is_executable+default-devel \
 rust-shlex+default-devel \
 "
RDEPENDS:rust-clap_complete-devel = " \
 cargo \
 rust \
 rust-clap+std-devel \
 rust-clap-devel \
 "
