# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Dist-CheckConflicts"
PV = "0.11"
PR = "27.el10_0"
PACKAGES = " \
 perl-Dist-CheckConflicts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Dist-CheckConflicts-0.11-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0198024afe22fc060cddc2585468f3e4cad3d32182c8c868b7ed40761ef84778"

URI_x86_64_v2_perl-Dist-CheckConflicts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Dist-CheckConflicts-0.11-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Dist-CheckConflicts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Dist-CheckConflicts}"
SRC_URI[x86_64_v2_perl-Dist-CheckConflicts.sha256sum] = "e8f2ed7c8f9f768ff377c904ad7cd504e770c1f0205176bb388a9ff0e795da37"

URI_aarch64_perl-Dist-CheckConflicts = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Dist-CheckConflicts-0.11-27.el10_0.noarch.rpm;name=aarch64_perl-Dist-CheckConflicts;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Dist-CheckConflicts}"
SRC_URI[aarch64_perl-Dist-CheckConflicts.sha256sum] = "d1dbf0a69c8c92590fd0ad9c1add3c62235b3bb6fa0595b4b85debe3ed970315"

RDEPENDS:perl-Dist-CheckConflicts = " \
 perl-Carp \
 perl-Exporter \
 perl-Module-Runtime \
 perl-base \
 perl-libs \
 "
