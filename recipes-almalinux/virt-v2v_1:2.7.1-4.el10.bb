# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "virt-v2v"
PE = "1"
PV = "2.7.1"
PR = "4.el10"
PACKAGES:x86_64_v2 = " \
 virt-v2v \
 virt-v2v-bash-completion \
 virt-v2v-man-pages-ja \
 virt-v2v-man-pages-uk \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/virt-v2v-2.7.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f32cdc61ac39a01db3aaa2a205ec282ae0922befce465e3c4a9d5804e71661b5"

URI_x86_64_v2_virt-v2v = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/virt-v2v-2.7.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_virt-v2v;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virt-v2v}"
SRC_URI[x86_64_v2_virt-v2v.sha256sum] = "eb8ab52c8e8d947ec95dc70cf49655ce1eef17e688578f7e2757cbf6ceb43bf8"

URI_x86_64_v2_virt-v2v-bash-completion = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/virt-v2v-bash-completion-2.7.1-4.el10.noarch.rpm;name=x86_64_v2_virt-v2v-bash-completion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virt-v2v-bash-completion}"
SRC_URI[x86_64_v2_virt-v2v-bash-completion.sha256sum] = "f4050780f96334a159f9352800f64850fa51646201edeec922ebfdb894d839a5"

URI_x86_64_v2_virt-v2v-man-pages-ja = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/virt-v2v-man-pages-ja-2.7.1-4.el10.noarch.rpm;name=x86_64_v2_virt-v2v-man-pages-ja;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virt-v2v-man-pages-ja}"
SRC_URI[x86_64_v2_virt-v2v-man-pages-ja.sha256sum] = "212c16714284cd8ab95372659475b6fcdddf91937798f0ee96c9b3084e5029e3"

URI_x86_64_v2_virt-v2v-man-pages-uk = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/virt-v2v-man-pages-uk-2.7.1-4.el10.noarch.rpm;name=x86_64_v2_virt-v2v-man-pages-uk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virt-v2v-man-pages-uk}"
SRC_URI[x86_64_v2_virt-v2v-man-pages-uk.sha256sum] = "66334ead4ea97d9a070c0b2d5de8639e380f0f24c1e3ae86cab2f7973b59cf4a"

RDEPENDS:virt-v2v = " \
 curl \
 edk2-ovmf \
 gawk \
 glib2 \
 glibc \
 guestfs-tools \
 gzip \
 json-c \
 libgcc \
 libguestfs \
 libguestfs-winsupport \
 libguestfs-xfs \
 libnbd \
 libosinfo \
 libvirt-client \
 libvirt-libs \
 libxcrypt \
 libxml2 \
 mingw-srvany-redistributable \
 nbdkit-basic-filters \
 nbdkit-basic-plugins \
 nbdkit-curl-plugin \
 nbdkit-nbd-plugin \
 nbdkit-server \
 nbdkit-ssh-plugin \
 nbdkit-vddk-plugin \
 openssh-clients \
 pcre2 \
 qemu-img \
 unzip \
 "
RDEPENDS:virt-v2v-bash-completion = " \
 bash-completion \
 virt-v2v \
 "
RDEPENDS:virt-v2v-man-pages-ja = " \
 virt-v2v \
 "
RDEPENDS:virt-v2v-man-pages-uk = " \
 virt-v2v \
 "
