# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnutls"
PV = "3.8.10"
PR = "4.el10"
PACKAGES = " \
 gnutls \
 gnutls-c++ \
 gnutls-dane \
 gnutls-devel \
 gnutls-fips \
 gnutls-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/gnutls-3.8.10-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5020f7b0deed3eeb5bfec2493928201e26685aba55b2df5637d7cc41a3d46db6"

URI_x86_64_v2_gnutls = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/gnutls-3.8.10-4.el10.x86_64_v2.rpm;name=x86_64_v2_gnutls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnutls}"
SRC_URI[x86_64_v2_gnutls.sha256sum] = "c7624ef8aa7000c74218d573ad9d53447fa433c1bdb3dcbb5960db908478bf61"

URI_x86_64_v2_gnutls-c++ = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnutls-c++-3.8.10-4.el10.x86_64_v2.rpm;name=x86_64_v2_gnutls-c++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnutls-c++}"
SRC_URI[x86_64_v2_gnutls-c++.sha256sum] = "5753e85e358077188b97b017d746b0ba949b9020f32bca1c4818dde6121d80bb"

URI_x86_64_v2_gnutls-dane = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnutls-dane-3.8.10-4.el10.x86_64_v2.rpm;name=x86_64_v2_gnutls-dane;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnutls-dane}"
SRC_URI[x86_64_v2_gnutls-dane.sha256sum] = "7df96aa7dce04658309cd91499b6478ceed5fbbdf0240f3c758d122212bfc14b"

URI_x86_64_v2_gnutls-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnutls-devel-3.8.10-4.el10.x86_64_v2.rpm;name=x86_64_v2_gnutls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnutls-devel}"
SRC_URI[x86_64_v2_gnutls-devel.sha256sum] = "9df1d3c08fbeb1947172c915df789ae3efb4ae1a4019d83b3ad5c097dbd0b424"

URI_x86_64_v2_gnutls-fips = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnutls-fips-3.8.10-4.el10.x86_64_v2.rpm;name=x86_64_v2_gnutls-fips;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnutls-fips}"
SRC_URI[x86_64_v2_gnutls-fips.sha256sum] = "ecd5041312b3d4b6cfb98191cec258710c877cfec017b5f575ec83ec4dcc2086"

URI_x86_64_v2_gnutls-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnutls-utils-3.8.10-4.el10.x86_64_v2.rpm;name=x86_64_v2_gnutls-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnutls-utils}"
SRC_URI[x86_64_v2_gnutls-utils.sha256sum] = "eb202cf3fbcfbef98324ab210bf5213b4e504837908cde72c815f3ba6c3d12ca"

URI_aarch64_gnutls = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/gnutls-3.8.10-4.el10.aarch64.rpm;name=aarch64_gnutls;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnutls}"
SRC_URI[aarch64_gnutls.sha256sum] = "d1b43e95a3cda7474ceb5b1df9661c99f65f3a435f1cf8d8912c8082c3d84da5"

URI_aarch64_gnutls-c++ = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnutls-c++-3.8.10-4.el10.aarch64.rpm;name=aarch64_gnutls-c++;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnutls-c++}"
SRC_URI[aarch64_gnutls-c++.sha256sum] = "2bbaae3e8e76dc014ed873181cfc83e5d5845e8cbe47e67420c1b8a0d15feda4"

URI_aarch64_gnutls-dane = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnutls-dane-3.8.10-4.el10.aarch64.rpm;name=aarch64_gnutls-dane;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnutls-dane}"
SRC_URI[aarch64_gnutls-dane.sha256sum] = "0dc6321c5e73e7e5866e3af03829c81cc4497022fbee0d1e61d31e8e165fbd68"

URI_aarch64_gnutls-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnutls-devel-3.8.10-4.el10.aarch64.rpm;name=aarch64_gnutls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnutls-devel}"
SRC_URI[aarch64_gnutls-devel.sha256sum] = "37c0fd0d23b55f90f1870fbbbf52c6aa4299d2f0ac81ec32a5be8f59413e16c0"

URI_aarch64_gnutls-fips = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnutls-fips-3.8.10-4.el10.aarch64.rpm;name=aarch64_gnutls-fips;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnutls-fips}"
SRC_URI[aarch64_gnutls-fips.sha256sum] = "379dfcf31c33ff7f8a6835388146dd3129ad5230af649728c71b147abca5c509"

URI_aarch64_gnutls-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnutls-utils-3.8.10-4.el10.aarch64.rpm;name=aarch64_gnutls-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnutls-utils}"
SRC_URI[aarch64_gnutls-utils.sha256sum] = "7c7f449be6e8a3bc4dbb6650b792be4b23fd6babffa91975c804098f3fac807d"

RDEPENDS:gnutls = " \
 crypto-policies \
 glibc \
 libidn2 \
 libtasn1 \
 libunistring \
 p11-kit \
 p11-kit-trust \
 "
RDEPENDS:gnutls-c++ = " \
 glibc \
 gnutls \
 libgcc \
 libidn2 \
 libstdc++ \
 libtasn1 \
 libunistring \
 p11-kit \
 "
RDEPENDS:gnutls-dane = " \
 glibc \
 gnutls \
 libidn2 \
 libtasn1 \
 libunistring \
 p11-kit \
 unbound-libs \
 "
RDEPENDS:gnutls-devel = " \
 gnutls \
 gnutls-c++ \
 gnutls-dane \
 gnutls-devel \
 libidn2-devel \
 libtasn1-devel \
 p11-kit-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:gnutls-fips = " \
 gnutls \
 "
RDEPENDS:gnutls-utils = " \
 glibc \
 gnutls \
 gnutls-dane \
 libtasn1 \
 "
