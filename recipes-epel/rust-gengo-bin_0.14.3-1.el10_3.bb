# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gengo-bin"
PV = "0.14.3"
PR = "1.el10_3"
PACKAGES = " \
 gengo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gengo-bin-0.14.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6585dec88776b067cca721a9854b8fe6054670a63e8d4c330646549e62d41a8b"

URI_x86_64_v2_gengo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gengo-0.14.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gengo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gengo}"
SRC_URI[x86_64_v2_gengo.sha256sum] = "1f0049a5a93bbee92a09eac5550cd8e0002bbdeadadaf53e81ac2073ab4de8a9"

URI_aarch64_gengo = "${EPEL_MIRROR}/aarch64/Packages/g/gengo-0.14.3-1.el10_3.aarch64.rpm;name=aarch64_gengo;unpack=0"
SRC_URI:append = " ${URI_aarch64_gengo}"
SRC_URI[aarch64_gengo.sha256sum] = "c84f1ba414fc12285fa078eee622f7d5adbbc125312ed3f649eb99a2c415a759"

RDEPENDS:gengo = " \
 glibc \
 libgcc \
 "
