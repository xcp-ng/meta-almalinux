# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sos"
PV = "4.10.2"
PR = "2.el10_1"
PACKAGES = " \
 sos \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/sos-4.10.2-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36d38d6452b210737b76a718d60e480da894e0c4243643ec78a6b11bf1c7522b"

URI_x86_64_v2_sos = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sos-4.10.2-2.el10_1.noarch.rpm;name=x86_64_v2_sos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sos}"
SRC_URI[x86_64_v2_sos.sha256sum] = "f9363224bac558eb9f63dc4d6cf10033ef8943e1612a30c9323d88c713c76f98"

URI_aarch64_sos = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sos-4.10.2-2.el10_1.noarch.rpm;name=aarch64_sos;unpack=0"
SRC_URI:append = " ${URI_aarch64_sos}"
SRC_URI[aarch64_sos.sha256sum] = "f9363224bac558eb9f63dc4d6cf10033ef8943e1612a30c9323d88c713c76f98"

RDEPENDS:sos = " \
 python3 \
 python3-packaging \
 python3-pexpect \
 python3-pyyaml \
 python3-requests \
 python3-setuptools \
 "
