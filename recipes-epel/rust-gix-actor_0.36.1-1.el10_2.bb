# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-actor"
PV = "0.36.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-actor+default-devel \
 rust-gix-actor+document-features-devel \
 rust-gix-actor+serde-devel \
 rust-gix-actor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-actor-0.36.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4168255dea2587ef81d0bbd6f0f75bb69dbe3a39fa7b9e86e33378ced7c007cf"

URI_x86_64_v2_rust-gix-actor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-actor+default-devel-0.36.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-actor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-actor+default-devel}"
SRC_URI[x86_64_v2_rust-gix-actor+default-devel.sha256sum] = "24ba39de9d4071ce11359a84bba1f01c944686608c2479c032ffb33dcf2b9690"

URI_x86_64_v2_rust-gix-actor+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-actor+document-features-devel-0.36.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-actor+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-actor+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-actor+document-features-devel.sha256sum] = "ca6ec5d8871c7260010e2ff5b1b36f0a71acf2720f3d4fe62a94a4bd6630029b"

URI_x86_64_v2_rust-gix-actor+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-actor+serde-devel-0.36.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-actor+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-actor+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-actor+serde-devel.sha256sum] = "365f3d79d9b3f3b4ce7c4319fe2071459ed5121eea097d5d9720b5a26c060187"

URI_x86_64_v2_rust-gix-actor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-actor-devel-0.36.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-actor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-actor-devel}"
SRC_URI[x86_64_v2_rust-gix-actor-devel.sha256sum] = "c5a5e7c82ccf9da769ffabf35a4574d09281c8c4f0c0dff13f4a1c039cdd95e6"

URI_aarch64_rust-gix-actor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-actor+default-devel-0.36.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-actor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-actor+default-devel}"
SRC_URI[aarch64_rust-gix-actor+default-devel.sha256sum] = "30226bad899fcf34fbb1e113ecc4d2cd2da3408fe2b43945e68d6592dddbd6fd"

URI_aarch64_rust-gix-actor+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-actor+document-features-devel-0.36.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-actor+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-actor+document-features-devel}"
SRC_URI[aarch64_rust-gix-actor+document-features-devel.sha256sum] = "732a6b8458e8bc15b3fff54e838b2f73ffd4e8b5e5f0b3e2cd5111924f1f63b6"

URI_aarch64_rust-gix-actor+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-actor+serde-devel-0.36.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-actor+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-actor+serde-devel}"
SRC_URI[aarch64_rust-gix-actor+serde-devel.sha256sum] = "ac7cc5fa133773e46e7c273d653e621a2c22e055e51b8bbc76e468b69eef434a"

URI_aarch64_rust-gix-actor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-actor-devel-0.36.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-actor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-actor-devel}"
SRC_URI[aarch64_rust-gix-actor-devel.sha256sum] = "5676769a747a0f0ddfb07afff1eb412d201f69780e3860757c958182921e6681"

RDEPENDS:rust-gix-actor+default-devel = " \
 cargo \
 rust-gix-actor-devel \
 "
RDEPENDS:rust-gix-actor+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-actor-devel \
 "
RDEPENDS:rust-gix-actor+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-actor-devel \
 rust-gix-date+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-actor-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-date+default-devel \
 rust-gix-utils+default-devel \
 rust-itoa+default-devel \
 rust-thiserror+default-devel \
 rust-winnow+default-devel \
 rust-winnow+simd-devel \
 "
