# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kconfigwidgets"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kconfigwidgets \
 kf6-kconfigwidgets-devel \
 kf6-kconfigwidgets-doc \
 kf6-kconfigwidgets-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kconfigwidgets-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f29b2775e7b2dd6792eed44ee59896834d5a0aa771ef1d3d184e46ed4eca45b2"

URI_x86_64_v2_kf6-kconfigwidgets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfigwidgets-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kconfigwidgets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kconfigwidgets}"
SRC_URI[x86_64_v2_kf6-kconfigwidgets.sha256sum] = "f04ddf599cd0a0d97c946ebfca687c6a73c680e3c86a762897ae5ac97b425f5f"

URI_x86_64_v2_kf6-kconfigwidgets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfigwidgets-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kconfigwidgets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kconfigwidgets-devel}"
SRC_URI[x86_64_v2_kf6-kconfigwidgets-devel.sha256sum] = "cf3460124d5921fb57de5fecfb77affdb01d6dec891ee095b29d808f82ab7e67"

URI_x86_64_v2_kf6-kconfigwidgets-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfigwidgets-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kconfigwidgets-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kconfigwidgets-doc}"
SRC_URI[x86_64_v2_kf6-kconfigwidgets-doc.sha256sum] = "b98c319ba2eac5d957b7096d3ec024a41dbb4e3390d54831ca72c7c16151b7be"

URI_x86_64_v2_kf6-kconfigwidgets-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfigwidgets-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kconfigwidgets-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kconfigwidgets-html}"
SRC_URI[x86_64_v2_kf6-kconfigwidgets-html.sha256sum] = "6a08815bd4a859821e2efeba7b7b594ed5890881b49a8168cbb1e62dd9238186"

URI_aarch64_kf6-kconfigwidgets = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfigwidgets-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kconfigwidgets;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kconfigwidgets}"
SRC_URI[aarch64_kf6-kconfigwidgets.sha256sum] = "cfaa7da7b414f5bdb578cc23137f3a4b5a768e08417fdceb4173b6a677a9819c"

URI_aarch64_kf6-kconfigwidgets-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfigwidgets-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kconfigwidgets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kconfigwidgets-devel}"
SRC_URI[aarch64_kf6-kconfigwidgets-devel.sha256sum] = "22a4a07214e96e54f122ca9f721e1ad88eada6b9d64a30c15e9c6de8f7af7ab6"

URI_aarch64_kf6-kconfigwidgets-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfigwidgets-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kconfigwidgets-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kconfigwidgets-doc}"
SRC_URI[aarch64_kf6-kconfigwidgets-doc.sha256sum] = "c9179514dbd4588c8ad9842f6f9827a8b9aeca4aca179b9ea071ed80e2de6a27"

URI_aarch64_kf6-kconfigwidgets-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfigwidgets-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kconfigwidgets-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kconfigwidgets-html}"
SRC_URI[aarch64_kf6-kconfigwidgets-html.sha256sum] = "eec014623abde40b8e5860d3825d70c1dcb9e495d08de50a8ba206c1e6e07d19"

RDEPENDS:kf6-kconfigwidgets = " \
 glibc \
 kf6-filesystem \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kconfigwidgets-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kauth-devel \
 kf6-kcodecs-devel \
 kf6-kcolorscheme-devel \
 kf6-kconfig-devel \
 kf6-kconfigwidgets \
 kf6-kwidgetsaddons-devel \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kconfigwidgets-doc = " \
 "
RDEPENDS:kf6-kconfigwidgets-html = " \
 "
