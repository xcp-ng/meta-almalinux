# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pandoc-cli"
PV = "3.1.11.1"
PR = "34.el10_0"
PACKAGES:x86_64_v2 = " \
 ghc-hslua-cli \
 ghc-hslua-cli-devel \
 ghc-hslua-cli-doc \
 ghc-hslua-list \
 ghc-hslua-list-devel \
 ghc-hslua-list-doc \
 ghc-hslua-module-doclayout \
 ghc-hslua-module-doclayout-devel \
 ghc-hslua-module-doclayout-doc \
 ghc-hslua-module-path \
 ghc-hslua-module-path-devel \
 ghc-hslua-module-path-doc \
 ghc-hslua-module-system \
 ghc-hslua-module-system-devel \
 ghc-hslua-module-system-doc \
 ghc-hslua-module-version \
 ghc-hslua-module-version-devel \
 ghc-hslua-module-version-doc \
 ghc-hslua-module-zip \
 ghc-hslua-module-zip-devel \
 ghc-hslua-module-zip-doc \
 ghc-hslua-repl \
 ghc-hslua-repl-devel \
 ghc-hslua-repl-doc \
 ghc-lpeg \
 ghc-lpeg-devel \
 ghc-lpeg-doc \
 ghc-pandoc-lua-engine \
 ghc-pandoc-lua-engine-devel \
 ghc-pandoc-lua-engine-doc \
 ghc-pandoc-lua-marshal \
 ghc-pandoc-lua-marshal-devel \
 ghc-pandoc-lua-marshal-doc \
 pandoc \
 pandoc-pdf \
"
PACKAGES:aarch64 = " \
 ghc-hslua-cli \
 ghc-hslua-cli-devel \
 ghc-hslua-cli-doc \
 ghc-hslua-cli-prof \
 ghc-hslua-list \
 ghc-hslua-list-devel \
 ghc-hslua-list-doc \
 ghc-hslua-list-prof \
 ghc-hslua-module-doclayout \
 ghc-hslua-module-doclayout-devel \
 ghc-hslua-module-doclayout-doc \
 ghc-hslua-module-doclayout-prof \
 ghc-hslua-module-path \
 ghc-hslua-module-path-devel \
 ghc-hslua-module-path-doc \
 ghc-hslua-module-path-prof \
 ghc-hslua-module-system \
 ghc-hslua-module-system-devel \
 ghc-hslua-module-system-doc \
 ghc-hslua-module-system-prof \
 ghc-hslua-module-version \
 ghc-hslua-module-version-devel \
 ghc-hslua-module-version-doc \
 ghc-hslua-module-version-prof \
 ghc-hslua-module-zip \
 ghc-hslua-module-zip-devel \
 ghc-hslua-module-zip-doc \
 ghc-hslua-module-zip-prof \
 ghc-hslua-repl \
 ghc-hslua-repl-devel \
 ghc-hslua-repl-doc \
 ghc-hslua-repl-prof \
 ghc-lpeg \
 ghc-lpeg-devel \
 ghc-lpeg-doc \
 ghc-lpeg-prof \
 ghc-pandoc-lua-engine \
 ghc-pandoc-lua-engine-devel \
 ghc-pandoc-lua-engine-doc \
 ghc-pandoc-lua-engine-prof \
 ghc-pandoc-lua-marshal \
 ghc-pandoc-lua-marshal-devel \
 ghc-pandoc-lua-marshal-doc \
 ghc-pandoc-lua-marshal-prof \
 pandoc \
 pandoc-pdf \
"

URI_src = "${EPELSRC_MIRROR}/Packages/p/pandoc-cli-3.1.11.1-34.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a78a4b5bcbcbabddc92b1dda207e2d8563ee2747e199eeda54f561dcd81d2647"

URI_x86_64_v2_ghc-hslua-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-cli-1.4.3-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-cli}"
SRC_URI[x86_64_v2_ghc-hslua-cli.sha256sum] = "0be97d197a61146375649161c1d0b8f9f1c700d62c8098e2bc80a68dbd441f34"

URI_x86_64_v2_ghc-hslua-cli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-cli-devel-1.4.3-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-cli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-cli-devel}"
SRC_URI[x86_64_v2_ghc-hslua-cli-devel.sha256sum] = "e97a94cbcfc6db7a7edef558c60ad4c443a848b938ba903328dd0772fc1cd898"

URI_x86_64_v2_ghc-hslua-cli-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-cli-doc-1.4.3-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hslua-cli-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-cli-doc}"
SRC_URI[x86_64_v2_ghc-hslua-cli-doc.sha256sum] = "7e32c4ce4276bb35ee99d6ad2e33f21a9807174b0def2fc13202bc7ad74d745e"

URI_x86_64_v2_ghc-hslua-list = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-list-1.1.1-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-list;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-list}"
SRC_URI[x86_64_v2_ghc-hslua-list.sha256sum] = "c0482a07199523adc2d45fef04767d4e5c1bc1cf5a96b6d0d67271565fd335a2"

URI_x86_64_v2_ghc-hslua-list-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-list-devel-1.1.1-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-list-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-list-devel}"
SRC_URI[x86_64_v2_ghc-hslua-list-devel.sha256sum] = "9c7f6efabd81d24ac603f2acc54a9853b975d5aab6480d9dee7c57e65c586c73"

URI_x86_64_v2_ghc-hslua-list-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-list-doc-1.1.1-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hslua-list-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-list-doc}"
SRC_URI[x86_64_v2_ghc-hslua-list-doc.sha256sum] = "e872b29a30e92346aeea17c916e9ca6c407aadb6788e98465426e63ff0947ca8"

URI_x86_64_v2_ghc-hslua-module-doclayout = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-doclayout-1.1.1.2-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-module-doclayout;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-doclayout}"
SRC_URI[x86_64_v2_ghc-hslua-module-doclayout.sha256sum] = "0d419860aa5801e2608e49d1991abe0e3804011a6b68face370a1d49823197fd"

URI_x86_64_v2_ghc-hslua-module-doclayout-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-doclayout-devel-1.1.1.2-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-module-doclayout-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-doclayout-devel}"
SRC_URI[x86_64_v2_ghc-hslua-module-doclayout-devel.sha256sum] = "2530d755fea30492e46b4eb6695c6555f407356f41879aeaa5f59188a5cada66"

URI_x86_64_v2_ghc-hslua-module-doclayout-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-doclayout-doc-1.1.1.2-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hslua-module-doclayout-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-doclayout-doc}"
SRC_URI[x86_64_v2_ghc-hslua-module-doclayout-doc.sha256sum] = "7c5053f35cb528db9af288b8c3882f2efff597087830e43124f61c8bef72f34c"

URI_x86_64_v2_ghc-hslua-module-path = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-path-1.1.1-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-module-path;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-path}"
SRC_URI[x86_64_v2_ghc-hslua-module-path.sha256sum] = "17aa824b7072d553df16de54e91fb6ccb453a95ea1e42aa4051f85412b995f80"

URI_x86_64_v2_ghc-hslua-module-path-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-path-devel-1.1.1-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-module-path-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-path-devel}"
SRC_URI[x86_64_v2_ghc-hslua-module-path-devel.sha256sum] = "6ff5615635642a393902fc49f6d93194c67c4abf820ba2933454e737dc68be49"

URI_x86_64_v2_ghc-hslua-module-path-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-path-doc-1.1.1-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hslua-module-path-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-path-doc}"
SRC_URI[x86_64_v2_ghc-hslua-module-path-doc.sha256sum] = "60fb70b6e8f652aac40715cbd6f43fb9b7e6187053bc3a7301f748d5775948ae"

URI_x86_64_v2_ghc-hslua-module-system = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-system-1.1.2-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-module-system;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-system}"
SRC_URI[x86_64_v2_ghc-hslua-module-system.sha256sum] = "c5dd42d0b54efec6512c2381fe58d31c285ca553e15c9424b6cfcecd92d24ead"

URI_x86_64_v2_ghc-hslua-module-system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-system-devel-1.1.2-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-module-system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-system-devel}"
SRC_URI[x86_64_v2_ghc-hslua-module-system-devel.sha256sum] = "f0c7f64993ce25690429a97215ab24b19224f4698a071b13414e9b9bb52c4b20"

URI_x86_64_v2_ghc-hslua-module-system-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-system-doc-1.1.2-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hslua-module-system-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-system-doc}"
SRC_URI[x86_64_v2_ghc-hslua-module-system-doc.sha256sum] = "cf185f5c5b045597a7e1e80243b5029921ebb4276776b5fb78d756692e50dc66"

URI_x86_64_v2_ghc-hslua-module-version = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-version-1.1.1-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-module-version;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-version}"
SRC_URI[x86_64_v2_ghc-hslua-module-version.sha256sum] = "222fddb92ed0625e6b59d5ffcc0926762bd5c661706498ca1178c434def28062"

URI_x86_64_v2_ghc-hslua-module-version-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-version-devel-1.1.1-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-module-version-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-version-devel}"
SRC_URI[x86_64_v2_ghc-hslua-module-version-devel.sha256sum] = "b624f6231d2d6dc933a9c090d7d2c475d24f135fa43e29cb5626056987083e52"

URI_x86_64_v2_ghc-hslua-module-version-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-version-doc-1.1.1-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hslua-module-version-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-version-doc}"
SRC_URI[x86_64_v2_ghc-hslua-module-version-doc.sha256sum] = "83963bc612d97cda471f06c41267f217913c15d0528a44e4aa05969f2b11c046"

URI_x86_64_v2_ghc-hslua-module-zip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-zip-1.1.3-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-module-zip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-zip}"
SRC_URI[x86_64_v2_ghc-hslua-module-zip.sha256sum] = "97c932fbeb69292afe503a7b7969644b2224d5ee222f471d0b7d842e9cb5464b"

URI_x86_64_v2_ghc-hslua-module-zip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-zip-devel-1.1.3-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-module-zip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-zip-devel}"
SRC_URI[x86_64_v2_ghc-hslua-module-zip-devel.sha256sum] = "ca8379b2f3cdad0798ec4452f7e1a5b135df4211f6df27840ebdeef4a2077822"

URI_x86_64_v2_ghc-hslua-module-zip-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-zip-doc-1.1.3-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hslua-module-zip-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-zip-doc}"
SRC_URI[x86_64_v2_ghc-hslua-module-zip-doc.sha256sum] = "b9fd2468a76b1c1a81860898b65de6b8c324f333998eb7b728be97c1a8dd951a"

URI_x86_64_v2_ghc-hslua-repl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-repl-0.1.2-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-repl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-repl}"
SRC_URI[x86_64_v2_ghc-hslua-repl.sha256sum] = "f7cfccdcbbeb949e862c4315965496f3d22e38224361f760471202cf23111494"

URI_x86_64_v2_ghc-hslua-repl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-repl-devel-0.1.2-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-repl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-repl-devel}"
SRC_URI[x86_64_v2_ghc-hslua-repl-devel.sha256sum] = "f9994ec97624874b89c2eb9ef113b202dbfadc9491e513f88fa37df9efe377c9"

URI_x86_64_v2_ghc-hslua-repl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-repl-doc-0.1.2-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hslua-repl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-repl-doc}"
SRC_URI[x86_64_v2_ghc-hslua-repl-doc.sha256sum] = "428ae918d1a996f96ed31af59eb3130d93268a15f272b27977185357b0d233a8"

URI_x86_64_v2_ghc-lpeg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-lpeg-1.0.4-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-lpeg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-lpeg}"
SRC_URI[x86_64_v2_ghc-lpeg.sha256sum] = "3201f047e04aca4b734d5e03b79b22437ab51b37a761fc062a37747d416b3857"

URI_x86_64_v2_ghc-lpeg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-lpeg-devel-1.0.4-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-lpeg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-lpeg-devel}"
SRC_URI[x86_64_v2_ghc-lpeg-devel.sha256sum] = "330af3dd1b3233ca9ac6ca91b4b33a5f77891c16f06263f45493dfa1f2024ed5"

URI_x86_64_v2_ghc-lpeg-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-lpeg-doc-1.0.4-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-lpeg-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-lpeg-doc}"
SRC_URI[x86_64_v2_ghc-lpeg-doc.sha256sum] = "024a15cc5cdfdfdbbfbe488a7ac4738380851d6e92926cd99f16147ffd6cf505"

URI_x86_64_v2_ghc-pandoc-lua-engine = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pandoc-lua-engine-0.2.1.2-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pandoc-lua-engine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pandoc-lua-engine}"
SRC_URI[x86_64_v2_ghc-pandoc-lua-engine.sha256sum] = "82d8c61da1cca786b960ad2438b6e9c41f341b6f835ddce61b1d60a39b8438d4"

URI_x86_64_v2_ghc-pandoc-lua-engine-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pandoc-lua-engine-devel-0.2.1.2-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pandoc-lua-engine-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pandoc-lua-engine-devel}"
SRC_URI[x86_64_v2_ghc-pandoc-lua-engine-devel.sha256sum] = "3fe79fd8f605d69158c1bc7801bf012ad8277edfcf965701a506dffbf8e9901e"

URI_x86_64_v2_ghc-pandoc-lua-engine-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pandoc-lua-engine-doc-0.2.1.2-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-pandoc-lua-engine-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pandoc-lua-engine-doc}"
SRC_URI[x86_64_v2_ghc-pandoc-lua-engine-doc.sha256sum] = "967c6b94c60c05fea49a56446d21218f04265c5dac9c53e5b91c397b36004d4d"

URI_x86_64_v2_ghc-pandoc-lua-marshal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pandoc-lua-marshal-0.2.7.1-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pandoc-lua-marshal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pandoc-lua-marshal}"
SRC_URI[x86_64_v2_ghc-pandoc-lua-marshal.sha256sum] = "c8ffb04bc6d8421ad09351b12b6a7035bf66ae31bf07cafc69918e993bf3b90d"

URI_x86_64_v2_ghc-pandoc-lua-marshal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pandoc-lua-marshal-devel-0.2.7.1-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pandoc-lua-marshal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pandoc-lua-marshal-devel}"
SRC_URI[x86_64_v2_ghc-pandoc-lua-marshal-devel.sha256sum] = "e5de18308dc2d198079a916e53be7b3f2e3b26c7dcb5964712bdd0f09a6c311b"

URI_x86_64_v2_ghc-pandoc-lua-marshal-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pandoc-lua-marshal-doc-0.2.7.1-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-pandoc-lua-marshal-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pandoc-lua-marshal-doc}"
SRC_URI[x86_64_v2_ghc-pandoc-lua-marshal-doc.sha256sum] = "7f72657eb54dafeabdfcf929d088ae261c91a5ef3fe687a3b614b713e2d802e0"

URI_x86_64_v2_pandoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pandoc-3.1.11.1-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pandoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pandoc}"
SRC_URI[x86_64_v2_pandoc.sha256sum] = "e3eb1ededf86896b3dcd1bf4daf3b4ac9d847cf66bd1f6f4a41986d83fffa7a3"

URI_x86_64_v2_pandoc-pdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pandoc-pdf-3.1.11.1-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pandoc-pdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pandoc-pdf}"
SRC_URI[x86_64_v2_pandoc-pdf.sha256sum] = "050ac3bd1da13fd75c47221842b6493ba044c94da30fe2503006be610dbcd33d"

URI_aarch64_ghc-hslua-cli = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-cli-1.4.3-34.el10_0.aarch64.rpm;name=aarch64_ghc-hslua-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-cli}"
SRC_URI[aarch64_ghc-hslua-cli.sha256sum] = "a6b50eed8ef9b9bf67984838516a4a2106e3a6814c0ce1c4a6e6d9cc953ddf6a"

URI_aarch64_ghc-hslua-cli-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-cli-devel-1.4.3-34.el10_0.aarch64.rpm;name=aarch64_ghc-hslua-cli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-cli-devel}"
SRC_URI[aarch64_ghc-hslua-cli-devel.sha256sum] = "efae58425b5285d3c866203fb852b02767dadae334ca39a9ffe65a9660efc70d"

URI_aarch64_ghc-hslua-cli-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-cli-doc-1.4.3-34.el10_0.noarch.rpm;name=aarch64_ghc-hslua-cli-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-cli-doc}"
SRC_URI[aarch64_ghc-hslua-cli-doc.sha256sum] = "6045b26dcb88d6394dd0ea0fa016511de688f090560adf2b745df48f777768a5"

URI_aarch64_ghc-hslua-cli-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-cli-prof-1.4.3-34.el10_0.aarch64.rpm;name=aarch64_ghc-hslua-cli-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-cli-prof}"
SRC_URI[aarch64_ghc-hslua-cli-prof.sha256sum] = "848e84b6f99d387263be2c283e17f116962c6312f9141ee692a5ea78caa16ac7"

URI_aarch64_ghc-hslua-list = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-list-1.1.1-34.el10_0.aarch64.rpm;name=aarch64_ghc-hslua-list;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-list}"
SRC_URI[aarch64_ghc-hslua-list.sha256sum] = "73d33c5a9bd3a314ff8bebfe90082c8d0e566f9b569e001a20b1059e392b889e"

URI_aarch64_ghc-hslua-list-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-list-devel-1.1.1-34.el10_0.aarch64.rpm;name=aarch64_ghc-hslua-list-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-list-devel}"
SRC_URI[aarch64_ghc-hslua-list-devel.sha256sum] = "63a73ae945f3615355e4a668e6871ce8d43eb9a482ae450f579bbcca553b6959"

URI_aarch64_ghc-hslua-list-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-list-doc-1.1.1-34.el10_0.noarch.rpm;name=aarch64_ghc-hslua-list-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-list-doc}"
SRC_URI[aarch64_ghc-hslua-list-doc.sha256sum] = "03520ef15f717ffdf4963800da57b537e49c095ec41baf46c68d1fd565181cc4"

URI_aarch64_ghc-hslua-list-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-list-prof-1.1.1-34.el10_0.aarch64.rpm;name=aarch64_ghc-hslua-list-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-list-prof}"
SRC_URI[aarch64_ghc-hslua-list-prof.sha256sum] = "866f9be755979b389533d6380d92f85913863ee35b21a5c54e7318057e791cf9"

URI_aarch64_ghc-hslua-module-doclayout = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-doclayout-1.1.1.2-34.el10_0.aarch64.rpm;name=aarch64_ghc-hslua-module-doclayout;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-doclayout}"
SRC_URI[aarch64_ghc-hslua-module-doclayout.sha256sum] = "2d973c62f24fa38f76a104b4939afec59c33388fc557c9147c97bc57584b95d1"

URI_aarch64_ghc-hslua-module-doclayout-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-doclayout-devel-1.1.1.2-34.el10_0.aarch64.rpm;name=aarch64_ghc-hslua-module-doclayout-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-doclayout-devel}"
SRC_URI[aarch64_ghc-hslua-module-doclayout-devel.sha256sum] = "ffa617c92fc02d70b8a2e819ec445db9a97698543ce8fb01ae3a43bae6e37cdb"

URI_aarch64_ghc-hslua-module-doclayout-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-doclayout-doc-1.1.1.2-34.el10_0.noarch.rpm;name=aarch64_ghc-hslua-module-doclayout-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-doclayout-doc}"
SRC_URI[aarch64_ghc-hslua-module-doclayout-doc.sha256sum] = "dafff8a6f7dce0cec9bcf950d67edc5893126f53fd0eb7c53de9c76fe173ec5d"

URI_aarch64_ghc-hslua-module-doclayout-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-doclayout-prof-1.1.1.2-34.el10_0.aarch64.rpm;name=aarch64_ghc-hslua-module-doclayout-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-doclayout-prof}"
SRC_URI[aarch64_ghc-hslua-module-doclayout-prof.sha256sum] = "475a3d6ccf640a43c06e55684bbb46f04c75b1e8ef5845dce69145140b004ff3"

URI_aarch64_ghc-hslua-module-path = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-path-1.1.1-34.el10_0.aarch64.rpm;name=aarch64_ghc-hslua-module-path;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-path}"
SRC_URI[aarch64_ghc-hslua-module-path.sha256sum] = "4cae20600522a36f89c4ba204fdcf3d064e44460445c3cc5228c6eefb2bdb404"

URI_aarch64_ghc-hslua-module-path-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-path-devel-1.1.1-34.el10_0.aarch64.rpm;name=aarch64_ghc-hslua-module-path-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-path-devel}"
SRC_URI[aarch64_ghc-hslua-module-path-devel.sha256sum] = "5c42a437ae133043bf81030762718b9199dbb5f82cd0fe471a66c1158da33ba6"

URI_aarch64_ghc-hslua-module-path-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-path-doc-1.1.1-34.el10_0.noarch.rpm;name=aarch64_ghc-hslua-module-path-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-path-doc}"
SRC_URI[aarch64_ghc-hslua-module-path-doc.sha256sum] = "8ddf21df81ca3a61912ce3cf097979f158a1b11c39870e7f66760f38b73bebc2"

URI_aarch64_ghc-hslua-module-path-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-path-prof-1.1.1-34.el10_0.aarch64.rpm;name=aarch64_ghc-hslua-module-path-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-path-prof}"
SRC_URI[aarch64_ghc-hslua-module-path-prof.sha256sum] = "f3a9ec444210f2b898781e707469d4fa80d21001bbb296d1a5ef26042770da73"

URI_aarch64_ghc-hslua-module-system = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-system-1.1.2-34.el10_0.aarch64.rpm;name=aarch64_ghc-hslua-module-system;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-system}"
SRC_URI[aarch64_ghc-hslua-module-system.sha256sum] = "de77e12eaffd9ebfa0feecfcd0986e82efc406fd53ee02fa69261b2d0eb8a5d0"

URI_aarch64_ghc-hslua-module-system-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-system-devel-1.1.2-34.el10_0.aarch64.rpm;name=aarch64_ghc-hslua-module-system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-system-devel}"
SRC_URI[aarch64_ghc-hslua-module-system-devel.sha256sum] = "5e56d54a0bd4f3f13cbcba7e40e7a337a2ac840370c4dddc4037a4dd1bead0b4"

URI_aarch64_ghc-hslua-module-system-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-system-doc-1.1.2-34.el10_0.noarch.rpm;name=aarch64_ghc-hslua-module-system-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-system-doc}"
SRC_URI[aarch64_ghc-hslua-module-system-doc.sha256sum] = "bde22823f4e9e3e8dfde065e4c725d4ee14fbdb72df0a57ee0918069a5a47a56"

URI_aarch64_ghc-hslua-module-system-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-system-prof-1.1.2-34.el10_0.aarch64.rpm;name=aarch64_ghc-hslua-module-system-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-system-prof}"
SRC_URI[aarch64_ghc-hslua-module-system-prof.sha256sum] = "2cea7e5aa9ff3aabcf758b1947376ed25e1bb0bf51d0ebb44ae9b7bf7648a389"

URI_aarch64_ghc-hslua-module-version = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-version-1.1.1-34.el10_0.aarch64.rpm;name=aarch64_ghc-hslua-module-version;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-version}"
SRC_URI[aarch64_ghc-hslua-module-version.sha256sum] = "42a86ba2fdb3ad3da5651fa3ef0e31b5699731a43271aa788e296b7a7ad10d8b"

URI_aarch64_ghc-hslua-module-version-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-version-devel-1.1.1-34.el10_0.aarch64.rpm;name=aarch64_ghc-hslua-module-version-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-version-devel}"
SRC_URI[aarch64_ghc-hslua-module-version-devel.sha256sum] = "efbe69f7591ab98621d9256f3536abd99a445e9a05e87b390a13a8e7e6536fdb"

URI_aarch64_ghc-hslua-module-version-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-version-doc-1.1.1-34.el10_0.noarch.rpm;name=aarch64_ghc-hslua-module-version-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-version-doc}"
SRC_URI[aarch64_ghc-hslua-module-version-doc.sha256sum] = "04419d66bc269d230cc748d602555bc4f94a54ceae1141a493df6bcee223b47d"

URI_aarch64_ghc-hslua-module-version-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-version-prof-1.1.1-34.el10_0.aarch64.rpm;name=aarch64_ghc-hslua-module-version-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-version-prof}"
SRC_URI[aarch64_ghc-hslua-module-version-prof.sha256sum] = "e2656a121db8b513142868ada9d168c5bbd23d5b2641dbca692f2bae1f5314cd"

URI_aarch64_ghc-hslua-module-zip = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-zip-1.1.3-34.el10_0.aarch64.rpm;name=aarch64_ghc-hslua-module-zip;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-zip}"
SRC_URI[aarch64_ghc-hslua-module-zip.sha256sum] = "b05bd149c938e8dea48a1456a42c7078791e4fad13a6876531549dfd4e578e9d"

URI_aarch64_ghc-hslua-module-zip-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-zip-devel-1.1.3-34.el10_0.aarch64.rpm;name=aarch64_ghc-hslua-module-zip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-zip-devel}"
SRC_URI[aarch64_ghc-hslua-module-zip-devel.sha256sum] = "50b830233fe46bd3159239dac89f9dac26187951c319d1821525ebcc320ddc20"

URI_aarch64_ghc-hslua-module-zip-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-zip-doc-1.1.3-34.el10_0.noarch.rpm;name=aarch64_ghc-hslua-module-zip-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-zip-doc}"
SRC_URI[aarch64_ghc-hslua-module-zip-doc.sha256sum] = "f59089549733d8fabebf76b11efb594eca2f1827c2ba3cb49ac7df9da65c27e1"

URI_aarch64_ghc-hslua-module-zip-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-zip-prof-1.1.3-34.el10_0.aarch64.rpm;name=aarch64_ghc-hslua-module-zip-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-zip-prof}"
SRC_URI[aarch64_ghc-hslua-module-zip-prof.sha256sum] = "793e72b2302577f310ea777f2f4467ac8129f51645c85d286be8770a8047ff4d"

URI_aarch64_ghc-hslua-repl = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-repl-0.1.2-34.el10_0.aarch64.rpm;name=aarch64_ghc-hslua-repl;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-repl}"
SRC_URI[aarch64_ghc-hslua-repl.sha256sum] = "1b6d513645779c036c58185701aa8b8aaca63ebeb6a66c8936c3f3a1163ffc7e"

URI_aarch64_ghc-hslua-repl-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-repl-devel-0.1.2-34.el10_0.aarch64.rpm;name=aarch64_ghc-hslua-repl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-repl-devel}"
SRC_URI[aarch64_ghc-hslua-repl-devel.sha256sum] = "38090b89e664e1d1c838749546b02ee7ad100abb6b4dc82806b970799d5a7006"

URI_aarch64_ghc-hslua-repl-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-repl-doc-0.1.2-34.el10_0.noarch.rpm;name=aarch64_ghc-hslua-repl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-repl-doc}"
SRC_URI[aarch64_ghc-hslua-repl-doc.sha256sum] = "4c38e7ec1ef1e653f8e29bc4fdc4dc6895dfaef472133b83ac614a824a770d04"

URI_aarch64_ghc-hslua-repl-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-repl-prof-0.1.2-34.el10_0.aarch64.rpm;name=aarch64_ghc-hslua-repl-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-repl-prof}"
SRC_URI[aarch64_ghc-hslua-repl-prof.sha256sum] = "58a7a93d2c31ddbf9c7df57af29328bc009ba330c8fa6268e4734d6ca011c20f"

URI_aarch64_ghc-lpeg = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-lpeg-1.0.4-34.el10_0.aarch64.rpm;name=aarch64_ghc-lpeg;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-lpeg}"
SRC_URI[aarch64_ghc-lpeg.sha256sum] = "3a4b61218204ed8bdb24f4e569bc24c271f384ef9c97346811133172aa71d0f1"

URI_aarch64_ghc-lpeg-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-lpeg-devel-1.0.4-34.el10_0.aarch64.rpm;name=aarch64_ghc-lpeg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-lpeg-devel}"
SRC_URI[aarch64_ghc-lpeg-devel.sha256sum] = "3467f00030f2124988dc47548b918b693bc007ca210b8ffa766d719d11556d3a"

URI_aarch64_ghc-lpeg-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-lpeg-doc-1.0.4-34.el10_0.noarch.rpm;name=aarch64_ghc-lpeg-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-lpeg-doc}"
SRC_URI[aarch64_ghc-lpeg-doc.sha256sum] = "d4bc0342f45a1ed8b836bd149d186d1ddea71e608d07135233db53a04f6a2fb6"

URI_aarch64_ghc-lpeg-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-lpeg-prof-1.0.4-34.el10_0.aarch64.rpm;name=aarch64_ghc-lpeg-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-lpeg-prof}"
SRC_URI[aarch64_ghc-lpeg-prof.sha256sum] = "90499e0dabea04a282cb4f137ef2e5592ee22a4fdb64b6007b3a299c6a6f8477"

URI_aarch64_ghc-pandoc-lua-engine = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pandoc-lua-engine-0.2.1.2-34.el10_0.aarch64.rpm;name=aarch64_ghc-pandoc-lua-engine;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pandoc-lua-engine}"
SRC_URI[aarch64_ghc-pandoc-lua-engine.sha256sum] = "117a10a35267c5a2217c7abc7844371b6b6fd5a74e81023d56578180c07f44d5"

URI_aarch64_ghc-pandoc-lua-engine-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pandoc-lua-engine-devel-0.2.1.2-34.el10_0.aarch64.rpm;name=aarch64_ghc-pandoc-lua-engine-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pandoc-lua-engine-devel}"
SRC_URI[aarch64_ghc-pandoc-lua-engine-devel.sha256sum] = "1424bdad2af6b52aa47dea1049ece5e34a2dc42111a66d2a037a4b25fa690c57"

URI_aarch64_ghc-pandoc-lua-engine-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pandoc-lua-engine-doc-0.2.1.2-34.el10_0.noarch.rpm;name=aarch64_ghc-pandoc-lua-engine-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pandoc-lua-engine-doc}"
SRC_URI[aarch64_ghc-pandoc-lua-engine-doc.sha256sum] = "c452ab187248ee946cdbe8462e97311f3e3fb13753135ee7676275110db108f6"

URI_aarch64_ghc-pandoc-lua-engine-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pandoc-lua-engine-prof-0.2.1.2-34.el10_0.aarch64.rpm;name=aarch64_ghc-pandoc-lua-engine-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pandoc-lua-engine-prof}"
SRC_URI[aarch64_ghc-pandoc-lua-engine-prof.sha256sum] = "aa15bbb06fc7dc9f05fdb8ef2f069ed6592765990632ba3dd94aaf69a542e485"

URI_aarch64_ghc-pandoc-lua-marshal = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pandoc-lua-marshal-0.2.7.1-34.el10_0.aarch64.rpm;name=aarch64_ghc-pandoc-lua-marshal;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pandoc-lua-marshal}"
SRC_URI[aarch64_ghc-pandoc-lua-marshal.sha256sum] = "2977055715f64519466f7768670386e765f4edbc1658866bcee286cf6c9beed1"

URI_aarch64_ghc-pandoc-lua-marshal-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pandoc-lua-marshal-devel-0.2.7.1-34.el10_0.aarch64.rpm;name=aarch64_ghc-pandoc-lua-marshal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pandoc-lua-marshal-devel}"
SRC_URI[aarch64_ghc-pandoc-lua-marshal-devel.sha256sum] = "206cb301ceca50cdd181ea9154769807eb324dfcd65eb2d44c216ed794a42832"

URI_aarch64_ghc-pandoc-lua-marshal-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pandoc-lua-marshal-doc-0.2.7.1-34.el10_0.noarch.rpm;name=aarch64_ghc-pandoc-lua-marshal-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pandoc-lua-marshal-doc}"
SRC_URI[aarch64_ghc-pandoc-lua-marshal-doc.sha256sum] = "46a081269fdda13e7d9266217d8aa70de5e5845df1b87e1169f5341b6b4b373b"

URI_aarch64_ghc-pandoc-lua-marshal-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pandoc-lua-marshal-prof-0.2.7.1-34.el10_0.aarch64.rpm;name=aarch64_ghc-pandoc-lua-marshal-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pandoc-lua-marshal-prof}"
SRC_URI[aarch64_ghc-pandoc-lua-marshal-prof.sha256sum] = "9c58f73b6a66dbd6f2c4dbe97eea602455bb3c5790c74f7e805f46e934bf1a79"

URI_aarch64_pandoc = "${EPEL_MIRROR}/aarch64/Packages/p/pandoc-3.1.11.1-34.el10_0.aarch64.rpm;name=aarch64_pandoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pandoc}"
SRC_URI[aarch64_pandoc.sha256sum] = "a88b30fb9124602b416bcb2d422c9e835cbe6fe63f97fa9a66517c6a6a7733e1"

URI_aarch64_pandoc-pdf = "${EPEL_MIRROR}/aarch64/Packages/p/pandoc-pdf-3.1.11.1-34.el10_0.aarch64.rpm;name=aarch64_pandoc-pdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_pandoc-pdf}"
SRC_URI[aarch64_pandoc-pdf.sha256sum] = "c39b0dee9bed04b75a8680e52c518644274736eb1b5f567a51349ffa0c34b9cc"

RDEPENDS:ghc-hslua-cli = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hslua-core \
 ghc-hslua-marshalling \
 ghc-hslua-repl \
 ghc-isocline \
 ghc-lua \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hslua-cli-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-hslua-cli \
 ghc-hslua-core-devel \
 ghc-hslua-marshalling-devel \
 ghc-hslua-repl-devel \
 ghc-lua-devel \
 ghc-text-devel \
 ghc-unix-devel \
 "
RDEPENDS:ghc-hslua-cli-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hslua-list = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hslua-core \
 ghc-lua \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hslua-list-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-hslua-core-devel \
 ghc-hslua-list \
 "
RDEPENDS:ghc-hslua-list-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hslua-module-doclayout = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-array \
 ghc-assoc \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-bifunctors \
 ghc-binary \
 ghc-bytestring \
 ghc-comonad \
 ghc-containers \
 ghc-contravariant \
 ghc-data-fix \
 ghc-deepseq \
 ghc-distributive \
 ghc-dlist \
 ghc-doclayout \
 ghc-emojis \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hslua \
 ghc-hslua-aeson \
 ghc-hslua-classes \
 ghc-hslua-core \
 ghc-hslua-marshalling \
 ghc-hslua-objectorientation \
 ghc-hslua-packaging \
 ghc-hslua-typing \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-lua \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-random \
 ghc-safe \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-splitmix \
 ghc-stm \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-stream \
 ghc-witherable \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hslua-module-doclayout-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-doclayout-devel \
 ghc-hslua-devel \
 ghc-hslua-module-doclayout \
 ghc-text-devel \
 "
RDEPENDS:ghc-hslua-module-doclayout-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hslua-module-path = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hslua-core \
 ghc-hslua-marshalling \
 ghc-hslua-objectorientation \
 ghc-hslua-packaging \
 ghc-hslua-typing \
 ghc-lua \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hslua-module-path-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-filepath-devel \
 ghc-hslua-core-devel \
 ghc-hslua-marshalling-devel \
 ghc-hslua-module-path \
 ghc-hslua-packaging-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-hslua-module-path-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hslua-module-system = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hslua-core \
 ghc-hslua-marshalling \
 ghc-hslua-objectorientation \
 ghc-hslua-packaging \
 ghc-hslua-typing \
 ghc-lua \
 ghc-mtl \
 ghc-pretty \
 ghc-random \
 ghc-splitmix \
 ghc-stm \
 ghc-template-haskell \
 ghc-temporary \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hslua-module-system-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-directory-devel \
 ghc-exceptions-devel \
 ghc-hslua-core-devel \
 ghc-hslua-marshalling-devel \
 ghc-hslua-module-system \
 ghc-hslua-packaging-devel \
 ghc-temporary-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-hslua-module-system-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hslua-module-version = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hslua-core \
 ghc-hslua-marshalling \
 ghc-hslua-objectorientation \
 ghc-hslua-packaging \
 ghc-hslua-typing \
 ghc-lua \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hslua-module-version-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-filepath-devel \
 ghc-hslua-core-devel \
 ghc-hslua-marshalling-devel \
 ghc-hslua-module-version \
 ghc-hslua-packaging-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-hslua-module-version-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hslua-module-zip = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-digest \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hslua-core \
 ghc-hslua-list \
 ghc-hslua-marshalling \
 ghc-hslua-objectorientation \
 ghc-hslua-packaging \
 ghc-hslua-typing \
 ghc-lua \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 ghc-zip-archive \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-hslua-module-zip-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-filepath-devel \
 ghc-hslua-core-devel \
 ghc-hslua-list-devel \
 ghc-hslua-marshalling-devel \
 ghc-hslua-module-zip \
 ghc-hslua-packaging-devel \
 ghc-hslua-typing-devel \
 ghc-text-devel \
 ghc-time-devel \
 ghc-zip-archive-devel \
 "
RDEPENDS:ghc-hslua-module-zip-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hslua-repl = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hslua-core \
 ghc-isocline \
 ghc-lua \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hslua-repl-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-hslua-core-devel \
 ghc-hslua-repl \
 ghc-isocline-devel \
 ghc-lua-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-hslua-repl-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-lpeg = " \
 ghc-base \
 ghc-ghc-bignum \
 ghc-lua \
 glibc \
 gmp \
 "
RDEPENDS:ghc-lpeg-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-lpeg \
 ghc-lua-devel \
 "
RDEPENDS:ghc-lpeg-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-pandoc-lua-engine = " \
 ghc-Glob \
 ghc-JuicyPixels \
 ghc-OneTuple \
 ghc-Only \
 ghc-QuickCheck \
 ghc-SHA \
 ghc-StateVar \
 ghc-aeson \
 ghc-aeson-pretty \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-appar \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base16-bytestring \
 ghc-base64-bytestring \
 ghc-basement \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-byteorder \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-cassava \
 ghc-cereal \
 ghc-citeproc \
 ghc-colour \
 ghc-commonmark \
 ghc-commonmark-extensions \
 ghc-commonmark-pandoc \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-crypton \
 ghc-crypton-connection \
 ghc-crypton-x509 \
 ghc-crypton-x509-store \
 ghc-crypton-x509-system \
 ghc-crypton-x509-validation \
 ghc-data-default \
 ghc-data-default-class \
 ghc-data-default-instances-containers \
 ghc-data-default-instances-dlist \
 ghc-data-default-instances-old-locale \
 ghc-data-fix \
 ghc-deepseq \
 ghc-digest \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-doclayout \
 ghc-doctemplates \
 ghc-emojis \
 ghc-exceptions \
 ghc-file-embed \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-gridtables \
 ghc-haddock-library \
 ghc-hashable \
 ghc-haskell-lexer \
 ghc-hourglass \
 ghc-hslua \
 ghc-hslua-aeson \
 ghc-hslua-classes \
 ghc-hslua-core \
 ghc-hslua-list \
 ghc-hslua-marshalling \
 ghc-hslua-module-doclayout \
 ghc-hslua-module-path \
 ghc-hslua-module-system \
 ghc-hslua-module-text \
 ghc-hslua-module-version \
 ghc-hslua-module-zip \
 ghc-hslua-objectorientation \
 ghc-hslua-packaging \
 ghc-hslua-repl \
 ghc-hslua-typing \
 ghc-http-client \
 ghc-http-client-tls \
 ghc-http-types \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-iproute \
 ghc-ipynb \
 ghc-isocline \
 ghc-jira-wiki-markup \
 ghc-libyaml \
 ghc-lpeg \
 ghc-lua \
 ghc-memory \
 ghc-mime-types \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-network-uri \
 ghc-old-locale \
 ghc-old-time \
 ghc-ordered-containers \
 ghc-os-string \
 ghc-pandoc \
 ghc-pandoc-lua-marshal \
 ghc-pandoc-types \
 ghc-parsec \
 ghc-pem \
 ghc-pretty \
 ghc-pretty-show \
 ghc-prettyprinter \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-regex-base \
 ghc-regex-tdfa \
 ghc-resourcet \
 ghc-safe \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-skylighting \
 ghc-skylighting-core \
 ghc-skylighting-format-ansi \
 ghc-skylighting-format-blaze-html \
 ghc-skylighting-format-context \
 ghc-skylighting-format-latex \
 ghc-socks \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-syb \
 ghc-tagged \
 ghc-tagsoup \
 ghc-template-haskell \
 ghc-temporary \
 ghc-texmath \
 ghc-text \
 ghc-text-conversions \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-compat \
 ghc-th-lift \
 ghc-th-lift-instances \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-tls \
 ghc-toml-parser \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-typst \
 ghc-typst-symbols \
 ghc-unicode-collation \
 ghc-unicode-data \
 ghc-unicode-transforms \
 ghc-uniplate \
 ghc-unix \
 ghc-unix-time \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-utf8-string \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-witherable \
 ghc-xml \
 ghc-xml-conduit \
 ghc-xml-types \
 ghc-yaml \
 ghc-zip-archive \
 ghc-zlib \
 glibc \
 gmp \
 libyaml \
 zlib-ng-compat \
 "
RDEPENDS:ghc-pandoc-lua-engine-devel = " \
 ghc-SHA-devel \
 ghc-aeson-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-citeproc-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-data-default-devel \
 ghc-doclayout-devel \
 ghc-doctemplates-devel \
 ghc-exceptions-devel \
 ghc-hslua-devel \
 ghc-hslua-module-doclayout-devel \
 ghc-hslua-module-path-devel \
 ghc-hslua-module-system-devel \
 ghc-hslua-module-text-devel \
 ghc-hslua-module-version-devel \
 ghc-hslua-module-zip-devel \
 ghc-hslua-repl-devel \
 ghc-lpeg-devel \
 ghc-mtl-devel \
 ghc-pandoc-devel \
 ghc-pandoc-lua-engine \
 ghc-pandoc-lua-marshal-devel \
 ghc-pandoc-types-devel \
 ghc-parsec-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-pandoc-lua-engine-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-pandoc-lua-marshal = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-array \
 ghc-assoc \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-bifunctors \
 ghc-binary \
 ghc-bytestring \
 ghc-comonad \
 ghc-containers \
 ghc-contravariant \
 ghc-data-fix \
 ghc-deepseq \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hslua \
 ghc-hslua-aeson \
 ghc-hslua-classes \
 ghc-hslua-core \
 ghc-hslua-list \
 ghc-hslua-marshalling \
 ghc-hslua-objectorientation \
 ghc-hslua-packaging \
 ghc-hslua-typing \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-lua \
 ghc-mtl \
 ghc-os-string \
 ghc-pandoc-types \
 ghc-pretty \
 ghc-primitive \
 ghc-random \
 ghc-safe \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-splitmix \
 ghc-stm \
 ghc-strict \
 ghc-syb \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-stream \
 ghc-witherable \
 glibc \
 gmp \
 "
RDEPENDS:ghc-pandoc-lua-marshal-devel = " \
 ghc-aeson-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-exceptions-devel \
 ghc-hslua-devel \
 ghc-hslua-list-devel \
 ghc-hslua-marshalling-devel \
 ghc-pandoc-lua-marshal \
 ghc-pandoc-types-devel \
 ghc-safe-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-pandoc-lua-marshal-doc = " \
 ghc-filesystem \
 "
RDEPENDS:pandoc = " \
 glibc \
 gmp \
 libffi \
 libyaml \
 pandoc-common \
 zlib-ng-compat \
 "
RDEPENDS:pandoc-pdf = " \
 pandoc \
 texlive-collection-latex \
 texlive-ec \
 "
RDEPENDS:ghc-hslua-cli-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-hslua-cli-devel \
 ghc-hslua-core-prof \
 ghc-hslua-marshalling-prof \
 ghc-hslua-repl-prof \
 ghc-lua-prof \
 ghc-text-prof \
 ghc-unix-prof \
 "
RDEPENDS:ghc-hslua-list-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-hslua-core-prof \
 ghc-hslua-list-devel \
 "
RDEPENDS:ghc-hslua-module-doclayout-prof = " \
 ghc-base-prof \
 ghc-doclayout-prof \
 ghc-hslua-module-doclayout-devel \
 ghc-hslua-prof \
 ghc-text-prof \
 "
RDEPENDS:ghc-hslua-module-path-prof = " \
 ghc-base-prof \
 ghc-filepath-prof \
 ghc-hslua-core-prof \
 ghc-hslua-marshalling-prof \
 ghc-hslua-module-path-devel \
 ghc-hslua-packaging-prof \
 ghc-text-prof \
 "
RDEPENDS:ghc-hslua-module-system-prof = " \
 ghc-base-prof \
 ghc-directory-prof \
 ghc-exceptions-prof \
 ghc-hslua-core-prof \
 ghc-hslua-marshalling-prof \
 ghc-hslua-module-system-devel \
 ghc-hslua-packaging-prof \
 ghc-temporary-prof \
 ghc-text-prof \
 "
RDEPENDS:ghc-hslua-module-version-prof = " \
 ghc-base-prof \
 ghc-filepath-prof \
 ghc-hslua-core-prof \
 ghc-hslua-marshalling-prof \
 ghc-hslua-module-version-devel \
 ghc-hslua-packaging-prof \
 ghc-text-prof \
 "
RDEPENDS:ghc-hslua-module-zip-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-filepath-prof \
 ghc-hslua-core-prof \
 ghc-hslua-list-prof \
 ghc-hslua-marshalling-prof \
 ghc-hslua-module-zip-devel \
 ghc-hslua-packaging-prof \
 ghc-hslua-typing-prof \
 ghc-text-prof \
 ghc-time-prof \
 ghc-zip-archive-prof \
 "
RDEPENDS:ghc-hslua-repl-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-hslua-core-prof \
 ghc-hslua-repl-devel \
 ghc-isocline-prof \
 ghc-lua-prof \
 ghc-text-prof \
 "
RDEPENDS:ghc-lpeg-prof = " \
 ghc-base-prof \
 ghc-lpeg-devel \
 ghc-lua-prof \
 "
RDEPENDS:ghc-pandoc-lua-engine-prof = " \
 ghc-SHA-prof \
 ghc-aeson-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-citeproc-prof \
 ghc-containers-prof \
 ghc-data-default-prof \
 ghc-doclayout-prof \
 ghc-doctemplates-prof \
 ghc-exceptions-prof \
 ghc-hslua-module-doclayout-prof \
 ghc-hslua-module-path-prof \
 ghc-hslua-module-system-prof \
 ghc-hslua-module-text-prof \
 ghc-hslua-module-version-prof \
 ghc-hslua-module-zip-prof \
 ghc-hslua-prof \
 ghc-hslua-repl-prof \
 ghc-lpeg-prof \
 ghc-mtl-prof \
 ghc-pandoc-lua-engine-devel \
 ghc-pandoc-lua-marshal-prof \
 ghc-pandoc-prof \
 ghc-pandoc-types-prof \
 ghc-parsec-prof \
 ghc-text-prof \
 "
RDEPENDS:ghc-pandoc-lua-marshal-prof = " \
 ghc-aeson-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-exceptions-prof \
 ghc-hslua-list-prof \
 ghc-hslua-marshalling-prof \
 ghc-hslua-prof \
 ghc-pandoc-lua-marshal-devel \
 ghc-pandoc-types-prof \
 ghc-safe-prof \
 ghc-text-prof \
 "
