# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-DateTime-Calendar-Julian"
PV = "0.107"
PR = "9.el10_2"
PACKAGES = " \
 perl-DateTime-Calendar-Julian \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-DateTime-Calendar-Julian-0.107-9.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ffdfe82cc9bf7e6cccec138d4df3be025d787fd961a403fc5838eb6ef7eadbfe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DateTime-Calendar-Julian-0.107-9.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-DateTime-Calendar-Julian;unpack=0"
SRC_URI[x86_64_v2_perl-DateTime-Calendar-Julian.sha256sum] = "2b4dd8b1a6857de0c7d0bb4cfeb6aa3e407a1c1cc3c3a021ac55a8154d000340"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-DateTime-Calendar-Julian-0.107-9.el10_2.noarch.rpm;name=aarch64_perl-DateTime-Calendar-Julian;unpack=0"
SRC_URI[aarch64_perl-DateTime-Calendar-Julian.sha256sum] = "f116c126f5ad9ed0c0d5680e901e36998ebdd0927ab9da94deae7af4598c30d7"

RDEPENDS:perl-DateTime-Calendar-Julian = " \
 perl-DateTime \
 perl-libs \
 perl-vars \
 "
