# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fcgi"
PV = "2.4.0"
PR = "50.el10_0"
PACKAGES = " \
 fcgi \
 fcgi-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fcgi-2.4.0-50.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "663ef1b30089d39c7521bf87a9614c35e8383bae918a35a14c85ed77266099e9"

URI_x86_64_v2_fcgi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fcgi-2.4.0-50.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fcgi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fcgi}"
SRC_URI[x86_64_v2_fcgi.sha256sum] = "b81bb56ec39dd167bca9f3d02c70204df0a06c15d5e4b261209ae0edb8902ec0"

URI_x86_64_v2_fcgi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fcgi-devel-2.4.0-50.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fcgi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fcgi-devel}"
SRC_URI[x86_64_v2_fcgi-devel.sha256sum] = "020113e24f196bfa81276bd7fd447e2ecbf50bf252080c1ae3fd1e3df41eb41b"

URI_aarch64_fcgi = "${EPEL_MIRROR}/aarch64/Packages/f/fcgi-2.4.0-50.el10_0.aarch64.rpm;name=aarch64_fcgi;unpack=0"
SRC_URI:append = " ${URI_aarch64_fcgi}"
SRC_URI[aarch64_fcgi.sha256sum] = "8db6488f5a26441aa3f8133434097a2be4e602d950ddc2ed32365fc084928364"

URI_aarch64_fcgi-devel = "${EPEL_MIRROR}/aarch64/Packages/f/fcgi-devel-2.4.0-50.el10_0.aarch64.rpm;name=aarch64_fcgi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_fcgi-devel}"
SRC_URI[aarch64_fcgi-devel.sha256sum] = "a3080e53d5f79d43778bbbfb0a0037a09de369bcc95a3d4b3ec2d62944bddfd9"

RDEPENDS:fcgi = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:fcgi-devel = " \
 fcgi \
 "
