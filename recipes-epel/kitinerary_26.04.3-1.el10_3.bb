# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kitinerary"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kitinerary \
 kitinerary-devel \
 kitinerary-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kitinerary-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c854d20573b9cddac297a3b7b3a9822f45ee32249785c8b57013090b73cedf3"

URI_x86_64_v2_kitinerary = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kitinerary-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kitinerary;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kitinerary}"
SRC_URI[x86_64_v2_kitinerary.sha256sum] = "3ba21e86d8ad29ae42ab505b6e1a0a4d34b8173cd3441282a44c428b8503a4ff"

URI_x86_64_v2_kitinerary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kitinerary-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kitinerary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kitinerary-devel}"
SRC_URI[x86_64_v2_kitinerary-devel.sha256sum] = "d16f86e41f98a542bb0ee4020c64c595d70167ff7d2dc3bb372179b11ceb7408"

URI_x86_64_v2_kitinerary-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kitinerary-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kitinerary-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kitinerary-doc}"
SRC_URI[x86_64_v2_kitinerary-doc.sha256sum] = "4ab1386e233029ff9cb1505a3e8af27ea1e880f4b1f5647d1dd1e3541bf4f939"

URI_aarch64_kitinerary = "${EPEL_MIRROR}/aarch64/Packages/k/kitinerary-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kitinerary;unpack=0"
SRC_URI:append = " ${URI_aarch64_kitinerary}"
SRC_URI[aarch64_kitinerary.sha256sum] = "e04e11151ce4fe4988cfb23856e01ea88dfcef3007dfe6a5a44aeb820acd341c"

URI_aarch64_kitinerary-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kitinerary-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kitinerary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kitinerary-devel}"
SRC_URI[aarch64_kitinerary-devel.sha256sum] = "6a44e4dc98411cc9cc1e756f53d8f4b517833b56dd98b22f124f6b7979d30427"

URI_aarch64_kitinerary-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kitinerary-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_kitinerary-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kitinerary-doc}"
SRC_URI[aarch64_kitinerary-doc.sha256sum] = "3536af8afec6614c86cbdc8c4a81f9ad77024199452678977c25a10fa750ebc2"

RDEPENDS:kitinerary = " \
 glibc \
 kf6-karchive \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kcontacts \
 kf6-ki18n \
 kmime \
 kpkpass \
 libgcc \
 libstdc++ \
 libxml2 \
 openssl-libs \
 poppler \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 zlib-ng-compat \
 zxing-cpp \
 "
RDEPENDS:kitinerary-devel = " \
 cmake-filesystem \
 kf6-kcalendarcore-devel \
 kf6-kcontacts-devel \
 kitinerary \
 kmime-devel \
 kpkpass-devel \
 "
RDEPENDS:kitinerary-doc = " \
 "
