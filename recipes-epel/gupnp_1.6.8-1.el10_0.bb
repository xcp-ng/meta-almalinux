# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gupnp"
PV = "1.6.8"
PR = "1.el10_0"
PACKAGES = " \
 gupnp \
 gupnp-devel \
 gupnp-docs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gupnp-1.6.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e77a8e0cda8d4b0137d602cf9897812aceda4fdb6f41f85d4fad76a72fc2e66c"

URI_x86_64_v2_gupnp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gupnp-1.6.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gupnp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gupnp}"
SRC_URI[x86_64_v2_gupnp.sha256sum] = "1bbeca93a174616bef0dc63b3ae4c5b08b0984aa428097a276b2d0851b8c4b46"

URI_x86_64_v2_gupnp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gupnp-devel-1.6.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gupnp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gupnp-devel}"
SRC_URI[x86_64_v2_gupnp-devel.sha256sum] = "8773f4cadeaffb5e7682e86a364cbe93f9571cb22457b2d26f3bb166305f1a0b"

URI_x86_64_v2_gupnp-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gupnp-docs-1.6.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gupnp-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gupnp-docs}"
SRC_URI[x86_64_v2_gupnp-docs.sha256sum] = "17af8d127cd4ac4b23985e7fed64d36975a48741883c1ff99b19a6c7b5ea4da9"

URI_aarch64_gupnp = "${EPEL_MIRROR}/aarch64/Packages/g/gupnp-1.6.8-1.el10_0.aarch64.rpm;name=aarch64_gupnp;unpack=0"
SRC_URI:append = " ${URI_aarch64_gupnp}"
SRC_URI[aarch64_gupnp.sha256sum] = "0f4ae7ff4f4b2824a40c576df6981dbb67d6990b40699bf064294de95abf2e0c"

URI_aarch64_gupnp-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gupnp-devel-1.6.8-1.el10_0.aarch64.rpm;name=aarch64_gupnp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gupnp-devel}"
SRC_URI[aarch64_gupnp-devel.sha256sum] = "f24a142bd89fc7c3bd1e86b607a21ec817b882fbbc638e79d452f6e7f63c22c0"

URI_aarch64_gupnp-docs = "${EPEL_MIRROR}/aarch64/Packages/g/gupnp-docs-1.6.8-1.el10_0.noarch.rpm;name=aarch64_gupnp-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gupnp-docs}"
SRC_URI[aarch64_gupnp-docs.sha256sum] = "be8754a8b04b9ade39ceb52c8fbb6b392c4b6dc24c4e4aff529019d362824a1f"

RDEPENDS:gupnp = " \
 dbus \
 glib2 \
 glibc \
 gssdp \
 libgcc \
 libsoup3 \
 libxml2 \
 "
RDEPENDS:gupnp-devel = " \
 glib2-devel \
 gssdp-devel \
 gupnp \
 libsoup3-devel \
 libxml2-devel \
 pkgconf-pkg-config \
 python3 \
 "
RDEPENDS:gupnp-docs = " \
 gupnp \
 "
