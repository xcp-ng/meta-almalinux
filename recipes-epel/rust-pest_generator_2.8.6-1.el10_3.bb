# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pest_generator"
PV = "2.8.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-pest_generator+default-devel \
 rust-pest_generator+export-internal-devel \
 rust-pest_generator+grammar-extras-devel \
 rust-pest_generator+std-devel \
 rust-pest_generator-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pest_generator-2.8.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a85d3df1420503cb9abd2c548c6830641fc58b0beb697ac42332a1660321399"

URI_x86_64_v2_rust-pest_generator+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_generator+default-devel-2.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_generator+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_generator+default-devel}"
SRC_URI[x86_64_v2_rust-pest_generator+default-devel.sha256sum] = "c69f6747c3279832c2ca7d42130ea2a34ad9641286d9105b0c24e57323965ca4"

URI_x86_64_v2_rust-pest_generator+export-internal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_generator+export-internal-devel-2.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_generator+export-internal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_generator+export-internal-devel}"
SRC_URI[x86_64_v2_rust-pest_generator+export-internal-devel.sha256sum] = "41fe3539f58eb3ad3e17d8bd2d37743da8e8bb186cb61d5223f9a18d95c69284"

URI_x86_64_v2_rust-pest_generator+grammar-extras-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_generator+grammar-extras-devel-2.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_generator+grammar-extras-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_generator+grammar-extras-devel}"
SRC_URI[x86_64_v2_rust-pest_generator+grammar-extras-devel.sha256sum] = "81b9aa78a2c002a2eb9a256c5080a36fee59ce001caa900a85981da0193267ea"

URI_x86_64_v2_rust-pest_generator+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_generator+std-devel-2.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_generator+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_generator+std-devel}"
SRC_URI[x86_64_v2_rust-pest_generator+std-devel.sha256sum] = "189650f67c43635240c027dd46ea3b78ac407b5812be6e07ff621ad47a5688f1"

URI_x86_64_v2_rust-pest_generator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_generator-devel-2.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_generator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_generator-devel}"
SRC_URI[x86_64_v2_rust-pest_generator-devel.sha256sum] = "6e5e84b85e01a99a8ef48fd501f78ffba34889b43aa33f99d1de941dfd55a739"

URI_aarch64_rust-pest_generator+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_generator+default-devel-2.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-pest_generator+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_generator+default-devel}"
SRC_URI[aarch64_rust-pest_generator+default-devel.sha256sum] = "6152cfd1097e6d336eca3a12b74161b844fe1e105d8e8c571bf56a7fb76df934"

URI_aarch64_rust-pest_generator+export-internal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_generator+export-internal-devel-2.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-pest_generator+export-internal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_generator+export-internal-devel}"
SRC_URI[aarch64_rust-pest_generator+export-internal-devel.sha256sum] = "b5e5897e03365220c18a354c1617c666579857da6712747a5a746b4f03d4d982"

URI_aarch64_rust-pest_generator+grammar-extras-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_generator+grammar-extras-devel-2.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-pest_generator+grammar-extras-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_generator+grammar-extras-devel}"
SRC_URI[aarch64_rust-pest_generator+grammar-extras-devel.sha256sum] = "597f6a5f9105f65591d393b093f3fc6a00d1740461a09a280711889a931b9119"

URI_aarch64_rust-pest_generator+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_generator+std-devel-2.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-pest_generator+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_generator+std-devel}"
SRC_URI[aarch64_rust-pest_generator+std-devel.sha256sum] = "ffeab2637a361facc5678239f2caadf6fd053c884602b6b761b1bb4897280c70"

URI_aarch64_rust-pest_generator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_generator-devel-2.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-pest_generator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_generator-devel}"
SRC_URI[aarch64_rust-pest_generator-devel.sha256sum] = "4ea1cfc6ec0f546ecf252c15e252523e0d9bc74ab841590d3bcb3c1041d529ab"

RDEPENDS:rust-pest_generator+default-devel = " \
 cargo \
 rust-pest_generator+std-devel \
 rust-pest_generator-devel \
 "
RDEPENDS:rust-pest_generator+export-internal-devel = " \
 cargo \
 rust-pest_generator-devel \
 "
RDEPENDS:rust-pest_generator+grammar-extras-devel = " \
 cargo \
 rust-pest_generator-devel \
 rust-pest_meta+grammar-extras-devel \
 "
RDEPENDS:rust-pest_generator+std-devel = " \
 cargo \
 rust-pest+std-devel \
 rust-pest_generator-devel \
 "
RDEPENDS:rust-pest_generator-devel = " \
 cargo \
 rust \
 rust-pest-devel \
 rust-pest_meta+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 "
