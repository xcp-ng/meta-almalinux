# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmongocrypt"
PV = "1.20.4"
PR = "1.el10_3"
PACKAGES = " \
 libmongocrypt \
 libmongocrypt-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libmongocrypt-1.20.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "20da63536a6cb13a6f5f8615830fe9f9964ce79a44f3eaf7b04412ec9b401be6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmongocrypt-1.20.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmongocrypt;unpack=0"
SRC_URI[x86_64_v2_libmongocrypt.sha256sum] = "dbc332bacde60df27c718650c2aeb70aff9dfa7fbac546fc07abd84c5436ccaa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmongocrypt-devel-1.20.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmongocrypt-devel;unpack=0"
SRC_URI[x86_64_v2_libmongocrypt-devel.sha256sum] = "9ffb8b89354d27a4bbf15256fbd21fda769eebc0e3687520361f070bddb82205"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libmongocrypt-1.20.4-1.el10_3.aarch64.rpm;name=aarch64_libmongocrypt;unpack=0"
SRC_URI[aarch64_libmongocrypt.sha256sum] = "2c5ed01fe9062f8cee2726d512238867725e432b16f477f684d8daa344a36eb6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libmongocrypt-devel-1.20.4-1.el10_3.aarch64.rpm;name=aarch64_libmongocrypt-devel;unpack=0"
SRC_URI[aarch64_libmongocrypt-devel.sha256sum] = "06e2a12fc366bc117bad47c24fb5c2ed086823bcb0c4610ede2d8627a2415cd6"

RDEPENDS:libmongocrypt = " \
 glibc \
 libbson \
 openssl-libs \
 "
RDEPENDS:libmongocrypt-devel = " \
 cmake-filesystem \
 libbson-devel \
 libmongocrypt \
 pkgconf-pkg-config \
 "
