# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-keyboard"
PE = "1"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 kcm-plasma-keyboard \
 plasma-keyboard \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-keyboard-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9b2baff430c49f8a5494ed8c680540ece2f902c241c5fc7319b5a49267c413d7"

URI_x86_64_v2_kcm-plasma-keyboard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcm-plasma-keyboard-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcm-plasma-keyboard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcm-plasma-keyboard}"
SRC_URI[x86_64_v2_kcm-plasma-keyboard.sha256sum] = "6c3dece68cd000c79d2d195d9ba2c250f1b7c40e64c287b0445cc4c4905a624d"

URI_x86_64_v2_plasma-keyboard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-keyboard-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-keyboard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-keyboard}"
SRC_URI[x86_64_v2_plasma-keyboard.sha256sum] = "ae0b723e63165b30bba4f7ec09f297031cbe1971c3ff1f8e174c1bd1d05f088f"

URI_aarch64_kcm-plasma-keyboard = "${EPEL_MIRROR}/aarch64/Packages/k/kcm-plasma-keyboard-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_kcm-plasma-keyboard;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcm-plasma-keyboard}"
SRC_URI[aarch64_kcm-plasma-keyboard.sha256sum] = "7cb9a3cc35ddde101a5732618b3288153b38e038708d09b0095615344763c5d1"

URI_aarch64_plasma-keyboard = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-keyboard-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-keyboard;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-keyboard}"
SRC_URI[aarch64_plasma-keyboard.sha256sum] = "05b6a3ea860b8fbd52309f1d203bb6a6ba501188ff7b601c46b613295a20a7d9"

RDEPENDS:kcm-plasma-keyboard = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 libstdc++ \
 plasma-keyboard \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:plasma-keyboard = " \
 glibc \
 kcm-plasma-keyboard \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 libstdc++ \
 libwayland-client \
 libxkbcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtvirtualkeyboard \
 "
