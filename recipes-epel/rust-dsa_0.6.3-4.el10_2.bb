# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dsa"
PV = "0.6.3"
PR = "4.el10_2"
PACKAGES = " \
 rust-dsa+default-devel \
 rust-dsa+std-devel \
 rust-dsa-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dsa-0.6.3-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2721195d122e77b0266468364a943fb5b2a2d3b6c93025a6981cf1408bb9d1f7"

URI_x86_64_v2_rust-dsa+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dsa+default-devel-0.6.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dsa+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dsa+default-devel}"
SRC_URI[x86_64_v2_rust-dsa+default-devel.sha256sum] = "71842636b92b324aa01e4179099a4f1f5348c9beb905127ac965c3d195110e94"

URI_x86_64_v2_rust-dsa+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dsa+std-devel-0.6.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dsa+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dsa+std-devel}"
SRC_URI[x86_64_v2_rust-dsa+std-devel.sha256sum] = "4316cbc0c31698b2595d03fb8610b40bfa31652b97899d3a690ddd847473c749"

URI_x86_64_v2_rust-dsa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dsa-devel-0.6.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dsa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dsa-devel}"
SRC_URI[x86_64_v2_rust-dsa-devel.sha256sum] = "1d2e4c676456238c4955d89384e0e89fd639842213daad8c22f34ec454f0112b"

URI_aarch64_rust-dsa+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dsa+default-devel-0.6.3-4.el10_2.noarch.rpm;name=aarch64_rust-dsa+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dsa+default-devel}"
SRC_URI[aarch64_rust-dsa+default-devel.sha256sum] = "a6e98c0fc13e19ce88b7db0a137bbb0ee1108ee7ed5a34ebdf50d1a110c68891"

URI_aarch64_rust-dsa+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dsa+std-devel-0.6.3-4.el10_2.noarch.rpm;name=aarch64_rust-dsa+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dsa+std-devel}"
SRC_URI[aarch64_rust-dsa+std-devel.sha256sum] = "13ab8f47454614b2908e43c4cd001c32620637fc606a094f5ee4481c3f43adb2"

URI_aarch64_rust-dsa-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dsa-devel-0.6.3-4.el10_2.noarch.rpm;name=aarch64_rust-dsa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dsa-devel}"
SRC_URI[aarch64_rust-dsa-devel.sha256sum] = "dde584dd8c1fc3d5cc686ce678064e479beb62fdf16fdf33ebdc8af8caa01608"

RDEPENDS:rust-dsa+default-devel = " \
 cargo \
 rust-dsa-devel \
 "
RDEPENDS:rust-dsa+std-devel = " \
 cargo \
 rust-dsa-devel \
 "
RDEPENDS:rust-dsa-devel = " \
 cargo \
 rust \
 rust-digest+default-devel \
 rust-num-bigint-dig+prime-devel \
 rust-num-bigint-dig+rand-devel \
 rust-num-bigint-dig+zeroize-devel \
 rust-num-bigint-dig-devel \
 rust-num-traits-devel \
 rust-pkcs8+alloc-devel \
 rust-pkcs8-devel \
 rust-rfc6979+default-devel \
 rust-sha2-devel \
 rust-signature+alloc-devel \
 rust-signature+digest-devel \
 rust-signature+rand_core-devel \
 rust-signature-devel \
 rust-zeroize-devel \
 "
