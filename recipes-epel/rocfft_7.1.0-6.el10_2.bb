# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocfft"
PV = "7.1.0"
PR = "6.el10_2"
PACKAGES:x86_64_v2 = " \
 rocfft \
 rocfft-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocfft-7.1.0-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a23dae1740082f91f85e525a9821c94a8fd3bf8b7be81acb048e3ef80c5463ec"

URI_x86_64_v2_rocfft = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocfft-7.1.0-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocfft;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocfft}"
SRC_URI[x86_64_v2_rocfft.sha256sum] = "d1a1833b1396ee3a74235fd2f0c03042deadfdb4722938a4bf192c05f1d90e57"

URI_x86_64_v2_rocfft-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocfft-devel-7.1.0-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocfft-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocfft-devel}"
SRC_URI[x86_64_v2_rocfft-devel.sha256sum] = "bcc4c4caf9aa399ebfc223a8d87851544835ac04a0633df19c1102a7e6cd1100"

RDEPENDS:rocfft = " \
 glibc \
 libgcc \
 libstdc++ \
 rocm-hip \
 sqlite-libs \
 "
RDEPENDS:rocfft-devel = " \
 cmake-filesystem \
 rocfft \
 rocm-hip-devel \
 "
