# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-prost"
PV = "0.14.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-prost+default-devel \
 rust-prost+derive-devel \
 rust-prost+no-recursion-limit-devel \
 rust-prost+std-devel \
 rust-prost-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-prost-0.14.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e8d53293634a9dc8d77ce546384e9391ce4212437bfee5a6ec77317ecebf7d2"

URI_x86_64_v2_rust-prost+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prost+default-devel-0.14.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prost+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prost+default-devel}"
SRC_URI[x86_64_v2_rust-prost+default-devel.sha256sum] = "7933c6ed5b2ec4e41e866e25ca06420d47d9d9d37c4ee2c8fac54f3bfd7f469a"

URI_x86_64_v2_rust-prost+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prost+derive-devel-0.14.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prost+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prost+derive-devel}"
SRC_URI[x86_64_v2_rust-prost+derive-devel.sha256sum] = "53799e57cbd45c477902d5d426f090b398738d3d4d060cc56d789f2533af4516"

URI_x86_64_v2_rust-prost+no-recursion-limit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prost+no-recursion-limit-devel-0.14.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prost+no-recursion-limit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prost+no-recursion-limit-devel}"
SRC_URI[x86_64_v2_rust-prost+no-recursion-limit-devel.sha256sum] = "865892daf5b441ac683c2397d64af041054d69b5daf5adec1798715eb4679220"

URI_x86_64_v2_rust-prost+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prost+std-devel-0.14.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prost+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prost+std-devel}"
SRC_URI[x86_64_v2_rust-prost+std-devel.sha256sum] = "efbe2917ac97e99db53e87ff71ad1fa0a37a34c34c5156ff0c8f265dcd2cfe28"

URI_x86_64_v2_rust-prost-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prost-devel-0.14.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prost-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prost-devel}"
SRC_URI[x86_64_v2_rust-prost-devel.sha256sum] = "4eae73b8cbe5263987f5fa092e323756c465c5a7515e1737cfb4079c3f4f7fb4"

URI_aarch64_rust-prost+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prost+default-devel-0.14.3-1.el10_3.noarch.rpm;name=aarch64_rust-prost+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prost+default-devel}"
SRC_URI[aarch64_rust-prost+default-devel.sha256sum] = "9265defede35c0a7167ba291faf13f7f94618a10f119c880beb4a087884a037d"

URI_aarch64_rust-prost+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prost+derive-devel-0.14.3-1.el10_3.noarch.rpm;name=aarch64_rust-prost+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prost+derive-devel}"
SRC_URI[aarch64_rust-prost+derive-devel.sha256sum] = "56826572282cc83b1a5a2ea314b5056a3097e0fbd9de0bb8879e5d9c22924526"

URI_aarch64_rust-prost+no-recursion-limit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prost+no-recursion-limit-devel-0.14.3-1.el10_3.noarch.rpm;name=aarch64_rust-prost+no-recursion-limit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prost+no-recursion-limit-devel}"
SRC_URI[aarch64_rust-prost+no-recursion-limit-devel.sha256sum] = "db02517dc293eb12494469ece2dbf87588ee14b0718abebfc71a8e05c7cd6f67"

URI_aarch64_rust-prost+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prost+std-devel-0.14.3-1.el10_3.noarch.rpm;name=aarch64_rust-prost+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prost+std-devel}"
SRC_URI[aarch64_rust-prost+std-devel.sha256sum] = "33bc6aa5f9bef18d21c639a913c79da38714c7fd18be906fc5ab8e768d3da1b3"

URI_aarch64_rust-prost-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prost-devel-0.14.3-1.el10_3.noarch.rpm;name=aarch64_rust-prost-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prost-devel}"
SRC_URI[aarch64_rust-prost-devel.sha256sum] = "e823040994a6705c75085826d8ccae20e0c9477ab8c652c193ceb133db37fb88"

RDEPENDS:rust-prost+default-devel = " \
 cargo \
 rust-prost+derive-devel \
 rust-prost+std-devel \
 rust-prost-devel \
 "
RDEPENDS:rust-prost+derive-devel = " \
 cargo \
 rust-prost-derive+default-devel \
 rust-prost-devel \
 "
RDEPENDS:rust-prost+no-recursion-limit-devel = " \
 cargo \
 rust-prost-devel \
 "
RDEPENDS:rust-prost+std-devel = " \
 cargo \
 rust-prost-devel \
 "
RDEPENDS:rust-prost-devel = " \
 cargo \
 rust \
 rust-bytes-devel \
 "
