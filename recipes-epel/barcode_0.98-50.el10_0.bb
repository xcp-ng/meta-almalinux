# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "barcode"
PV = "0.98"
PR = "50.el10_0"
PACKAGES = " \
 barcode \
 barcode-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/barcode-0.98-50.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f2f0e67bfe910066419ac9960b054c154bbc840fd3fc9801fecf681792fc1b4f"

URI_x86_64_v2_barcode = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/barcode-0.98-50.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_barcode;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_barcode}"
SRC_URI[x86_64_v2_barcode.sha256sum] = "42d5fc14dde8ea78c8fc4e1e26212b6017a9e552d2302c50e9792e023b39774e"

URI_x86_64_v2_barcode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/barcode-devel-0.98-50.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_barcode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_barcode-devel}"
SRC_URI[x86_64_v2_barcode-devel.sha256sum] = "254c0ce6461d1b9a4da45af1d651525b009b07525696660a635b36b82a2003b3"

URI_aarch64_barcode = "${EPEL_MIRROR}/aarch64/Packages/b/barcode-0.98-50.el10_0.aarch64.rpm;name=aarch64_barcode;unpack=0"
SRC_URI:append = " ${URI_aarch64_barcode}"
SRC_URI[aarch64_barcode.sha256sum] = "c5cb510e78b95b196fccea6af2a5583281ddbf31ddb80e55a334182afe406860"

URI_aarch64_barcode-devel = "${EPEL_MIRROR}/aarch64/Packages/b/barcode-devel-0.98-50.el10_0.aarch64.rpm;name=aarch64_barcode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_barcode-devel}"
SRC_URI[aarch64_barcode-devel.sha256sum] = "b126e77a91b395c4769e23d877167ba2626bab74c04867a3c40ff788795d2ab5"

RDEPENDS:barcode = " \
 glibc \
 "
RDEPENDS:barcode-devel = " \
 barcode \
 "
