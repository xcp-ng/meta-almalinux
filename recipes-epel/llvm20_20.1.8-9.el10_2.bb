# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "llvm20"
PV = "20.1.8"
PR = "9.el10_2"
PACKAGES = " \
 clang20 \
 clang20-analyzer \
 clang20-devel \
 clang20-libs \
 clang20-resource-filesystem \
 clang20-tools-extra \
 clang20-tools-extra-devel \
 compiler-rt20 \
 git-clang-format20 \
 libomp20 \
 libomp20-devel \
 lld20 \
 lld20-devel \
 lld20-libs \
 lldb20 \
 lldb20-devel \
 llvm20 \
 llvm20-cmake-utils \
 llvm20-devel \
 llvm20-doc \
 llvm20-filesystem \
 llvm20-googletest \
 llvm20-libs \
 llvm20-static \
 llvm20-test \
 llvm20-toolset \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/llvm20-20.1.8-9.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "01be4f1c9039cd2930ab16960519c56bc68cd46e240e2e50f22f228580266814"

URI_x86_64_v2_clang20 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clang20-20.1.8-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clang20;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang20}"
SRC_URI[x86_64_v2_clang20.sha256sum] = "7866475a72c180ea178e95caf05a2e8d7698570ea8e704681a38f9b5055028ec"

URI_x86_64_v2_clang20-analyzer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clang20-analyzer-20.1.8-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clang20-analyzer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang20-analyzer}"
SRC_URI[x86_64_v2_clang20-analyzer.sha256sum] = "d205e318a7323e415956d73018c12a443a88c1d13a22992bbc414974ecb8810f"

URI_x86_64_v2_clang20-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clang20-devel-20.1.8-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clang20-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang20-devel}"
SRC_URI[x86_64_v2_clang20-devel.sha256sum] = "7445fcd58d9b575b74e4a709363cc56cd9ad615af08afa12d6076fa46c1ad25f"

URI_x86_64_v2_clang20-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clang20-libs-20.1.8-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clang20-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang20-libs}"
SRC_URI[x86_64_v2_clang20-libs.sha256sum] = "5d7e9ceca9abc62c5c8259a2ddecf7658ba0d16e6661dd348471caddad563d48"

URI_x86_64_v2_clang20-resource-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clang20-resource-filesystem-20.1.8-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clang20-resource-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang20-resource-filesystem}"
SRC_URI[x86_64_v2_clang20-resource-filesystem.sha256sum] = "ddb8df87b0941df8b3b6f29f5ef50bf7c4c20a6558375fbfc197a297300464fd"

URI_x86_64_v2_clang20-tools-extra = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clang20-tools-extra-20.1.8-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clang20-tools-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang20-tools-extra}"
SRC_URI[x86_64_v2_clang20-tools-extra.sha256sum] = "cb500891ac5a5cb58f2d2fe42dce9691576b795ed6c7b2e431ce449f0df0d9c0"

URI_x86_64_v2_clang20-tools-extra-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clang20-tools-extra-devel-20.1.8-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clang20-tools-extra-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang20-tools-extra-devel}"
SRC_URI[x86_64_v2_clang20-tools-extra-devel.sha256sum] = "b5f94d9e12f1b5127fd52b94e1abae0e27e505a1e251615359d19a59b8a954ff"

URI_x86_64_v2_compiler-rt20 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/compiler-rt20-20.1.8-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_compiler-rt20;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_compiler-rt20}"
SRC_URI[x86_64_v2_compiler-rt20.sha256sum] = "c5c280aea23b7e60364f58089a6ba255633bbd08e9868530cb5305b99f99ac66"

URI_x86_64_v2_git-clang-format20 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/git-clang-format20-20.1.8-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_git-clang-format20;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-clang-format20}"
SRC_URI[x86_64_v2_git-clang-format20.sha256sum] = "eeb331a51f2c8a96ab186835c0c96f27984cc81a992fb24c4b91ea6a9973dd32"

URI_x86_64_v2_libomp20 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libomp20-20.1.8-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libomp20;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libomp20}"
SRC_URI[x86_64_v2_libomp20.sha256sum] = "97c953e10374316c7445aeecda4110ebb889a346c0ddc3d520d98585f611b4f4"
RPROVIDES:libomp20:x86_64_v2 = "virtual/libomp.so_VERSION__64bit_ virtual/libomp.so___64bit_"

URI_x86_64_v2_libomp20-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libomp20-devel-20.1.8-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libomp20-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libomp20-devel}"
SRC_URI[x86_64_v2_libomp20-devel.sha256sum] = "ca6f68b9a3b124c4acc0e8c6d085619e8e50d26bf59f562071f87b53738f69a8"

URI_x86_64_v2_lld20 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lld20-20.1.8-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lld20;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lld20}"
SRC_URI[x86_64_v2_lld20.sha256sum] = "be599390bc17a21e2118dc8c222dd99be63fb782fca5abe83a81d5c117a18739"

URI_x86_64_v2_lld20-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lld20-devel-20.1.8-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lld20-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lld20-devel}"
SRC_URI[x86_64_v2_lld20-devel.sha256sum] = "894600645094898b8e45f252f04e872e2b04b4634fdd1dac7009a4f87f1087e0"

URI_x86_64_v2_lld20-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lld20-libs-20.1.8-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lld20-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lld20-libs}"
SRC_URI[x86_64_v2_lld20-libs.sha256sum] = "8201acbba90bffeda7d583663ee94bc0497b6ed9f520502dbf3e84ffa6201886"

URI_x86_64_v2_lldb20 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lldb20-20.1.8-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lldb20;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lldb20}"
SRC_URI[x86_64_v2_lldb20.sha256sum] = "2e8c9066c8d412059e0d36217e991cdda4d9920908d5bfd69b07ac440ee91cd2"

URI_x86_64_v2_lldb20-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lldb20-devel-20.1.8-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lldb20-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lldb20-devel}"
SRC_URI[x86_64_v2_lldb20-devel.sha256sum] = "f39e927a1b4aaf514a76e34d82c93b9d92e604f9d25d94c90fd5783ddaff5e0c"

URI_x86_64_v2_llvm20 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm20-20.1.8-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm20;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm20}"
SRC_URI[x86_64_v2_llvm20.sha256sum] = "e219e31b1c0a700aa19d9a2309d25d79764dc13209958c529346a9d08eb3bfb1"

URI_x86_64_v2_llvm20-cmake-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm20-cmake-utils-20.1.8-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm20-cmake-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm20-cmake-utils}"
SRC_URI[x86_64_v2_llvm20-cmake-utils.sha256sum] = "e8a02c81e94b6f56e49e84f170fb0ee66ae3b50614037cba937fd60cf7140f79"

URI_x86_64_v2_llvm20-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm20-devel-20.1.8-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm20-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm20-devel}"
SRC_URI[x86_64_v2_llvm20-devel.sha256sum] = "c2d48e5f4349526e1b8be7326a2bb87c77e61743b3bcf97e023958fcdc6dbd4c"

URI_x86_64_v2_llvm20-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm20-doc-20.1.8-9.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_llvm20-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm20-doc}"
SRC_URI[x86_64_v2_llvm20-doc.sha256sum] = "71fb6294508fce22ddd42d106c710948d5cd42be8f5aaf33add51953c2abb6a8"

URI_x86_64_v2_llvm20-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm20-filesystem-20.1.8-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm20-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm20-filesystem}"
SRC_URI[x86_64_v2_llvm20-filesystem.sha256sum] = "d3f7b53f26442bb40a3b6d247b9ed8570e2d4c0650c0a7deb8ab687396054d39"

URI_x86_64_v2_llvm20-googletest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm20-googletest-20.1.8-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm20-googletest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm20-googletest}"
SRC_URI[x86_64_v2_llvm20-googletest.sha256sum] = "dba2f1f260f8a4cd59f45aac6b4abb12a905fbad2ffb201292371721714c12ec"

URI_x86_64_v2_llvm20-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm20-libs-20.1.8-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm20-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm20-libs}"
SRC_URI[x86_64_v2_llvm20-libs.sha256sum] = "d584a5708e77f30ec0c02bda365b3896ac27d0040db13ba556f4819587c98ec0"

URI_x86_64_v2_llvm20-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm20-static-20.1.8-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm20-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm20-static}"
SRC_URI[x86_64_v2_llvm20-static.sha256sum] = "ad52c3c768a95dc42b9428e35228bb8b5588ed4066302adaa53cf59f51d64c10"

URI_x86_64_v2_llvm20-test = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm20-test-20.1.8-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm20-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm20-test}"
SRC_URI[x86_64_v2_llvm20-test.sha256sum] = "06b0f41dd66f0fea1f021f4b6d0ecc4fc9597128cf178249f923684a2edae911"

URI_x86_64_v2_llvm20-toolset = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm20-toolset-20.1.8-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm20-toolset;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm20-toolset}"
SRC_URI[x86_64_v2_llvm20-toolset.sha256sum] = "8845a85da9e2b80cc6a1344a439c07cc5498690606120543008c8fbc81214582"

URI_aarch64_clang20 = "${EPEL_MIRROR}/aarch64/Packages/c/clang20-20.1.8-9.el10_2.aarch64.rpm;name=aarch64_clang20;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang20}"
SRC_URI[aarch64_clang20.sha256sum] = "1bc76fb607ce5faba98450cb77a15c3fe469c7ec18a7ac8fb4540bad6b62de20"

URI_aarch64_clang20-analyzer = "${EPEL_MIRROR}/aarch64/Packages/c/clang20-analyzer-20.1.8-9.el10_2.aarch64.rpm;name=aarch64_clang20-analyzer;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang20-analyzer}"
SRC_URI[aarch64_clang20-analyzer.sha256sum] = "d1ffd59922413510b3c9cfff18f8568b146b847adbcfb1f5254dfca93dd44aa9"

URI_aarch64_clang20-devel = "${EPEL_MIRROR}/aarch64/Packages/c/clang20-devel-20.1.8-9.el10_2.aarch64.rpm;name=aarch64_clang20-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang20-devel}"
SRC_URI[aarch64_clang20-devel.sha256sum] = "f75f166f83728878f3db6f956904d8315c6ee48784e6cb41bcb205c619c32d94"

URI_aarch64_clang20-libs = "${EPEL_MIRROR}/aarch64/Packages/c/clang20-libs-20.1.8-9.el10_2.aarch64.rpm;name=aarch64_clang20-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang20-libs}"
SRC_URI[aarch64_clang20-libs.sha256sum] = "babc13d1b331e38c7066f599a5dc7ef1b0117ca887fd703c8ab8abed782a929e"

URI_aarch64_clang20-resource-filesystem = "${EPEL_MIRROR}/aarch64/Packages/c/clang20-resource-filesystem-20.1.8-9.el10_2.aarch64.rpm;name=aarch64_clang20-resource-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang20-resource-filesystem}"
SRC_URI[aarch64_clang20-resource-filesystem.sha256sum] = "957a77a77068dd1e23eb7fceecad98bc0e3769657b7d53dd1dd788fcaae727db"

URI_aarch64_clang20-tools-extra = "${EPEL_MIRROR}/aarch64/Packages/c/clang20-tools-extra-20.1.8-9.el10_2.aarch64.rpm;name=aarch64_clang20-tools-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang20-tools-extra}"
SRC_URI[aarch64_clang20-tools-extra.sha256sum] = "87e1136ffbb0c227909238de488c8c5b736c3ec2639f7d580f908243cd50a469"

URI_aarch64_clang20-tools-extra-devel = "${EPEL_MIRROR}/aarch64/Packages/c/clang20-tools-extra-devel-20.1.8-9.el10_2.aarch64.rpm;name=aarch64_clang20-tools-extra-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang20-tools-extra-devel}"
SRC_URI[aarch64_clang20-tools-extra-devel.sha256sum] = "168e0e476b6c1f50f4cc32d0285da58cba0de802e6a288060443a36849e105aa"

URI_aarch64_compiler-rt20 = "${EPEL_MIRROR}/aarch64/Packages/c/compiler-rt20-20.1.8-9.el10_2.aarch64.rpm;name=aarch64_compiler-rt20;unpack=0"
SRC_URI:append = " ${URI_aarch64_compiler-rt20}"
SRC_URI[aarch64_compiler-rt20.sha256sum] = "297572138d3fcd374834669946ad2a7d908ee6975ea5e58ac44299071bf60b16"

URI_aarch64_git-clang-format20 = "${EPEL_MIRROR}/aarch64/Packages/g/git-clang-format20-20.1.8-9.el10_2.aarch64.rpm;name=aarch64_git-clang-format20;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-clang-format20}"
SRC_URI[aarch64_git-clang-format20.sha256sum] = "ece3ffaebf5213ed9f7853216add342a119ee82716e932bf3ab88257d8cfcfc1"

URI_aarch64_libomp20 = "${EPEL_MIRROR}/aarch64/Packages/l/libomp20-20.1.8-9.el10_2.aarch64.rpm;name=aarch64_libomp20;unpack=0"
SRC_URI:append = " ${URI_aarch64_libomp20}"
SRC_URI[aarch64_libomp20.sha256sum] = "823dcf988db0fecbc37aeef521729a31ec1cc5d12febd8e6c9d31f98cdab36e6"

URI_aarch64_libomp20-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libomp20-devel-20.1.8-9.el10_2.aarch64.rpm;name=aarch64_libomp20-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libomp20-devel}"
SRC_URI[aarch64_libomp20-devel.sha256sum] = "855f9657f9fab6da098cb79367c14ee8866b2bb7c6ca46b0dacc8d860bc3bfe5"

URI_aarch64_lld20 = "${EPEL_MIRROR}/aarch64/Packages/l/lld20-20.1.8-9.el10_2.aarch64.rpm;name=aarch64_lld20;unpack=0"
SRC_URI:append = " ${URI_aarch64_lld20}"
SRC_URI[aarch64_lld20.sha256sum] = "87f8a06867967607c2f547a34057eea83aa78314c4ac4b82af7c29d797996fb8"

URI_aarch64_lld20-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lld20-devel-20.1.8-9.el10_2.aarch64.rpm;name=aarch64_lld20-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lld20-devel}"
SRC_URI[aarch64_lld20-devel.sha256sum] = "ce269e73d05f6e6afe7e5c3273bec5cad3462859f59b720437bfd8aa898b9425"

URI_aarch64_lld20-libs = "${EPEL_MIRROR}/aarch64/Packages/l/lld20-libs-20.1.8-9.el10_2.aarch64.rpm;name=aarch64_lld20-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_lld20-libs}"
SRC_URI[aarch64_lld20-libs.sha256sum] = "623a360d85ef1b11b40c8289fe246b9d0301e8bd711e79b151eb7b38b28c74d3"

URI_aarch64_lldb20 = "${EPEL_MIRROR}/aarch64/Packages/l/lldb20-20.1.8-9.el10_2.aarch64.rpm;name=aarch64_lldb20;unpack=0"
SRC_URI:append = " ${URI_aarch64_lldb20}"
SRC_URI[aarch64_lldb20.sha256sum] = "9abf5e614459f12faecabedff18de5fb9f890ccd75122160b2599c05fafb9718"

URI_aarch64_lldb20-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lldb20-devel-20.1.8-9.el10_2.aarch64.rpm;name=aarch64_lldb20-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lldb20-devel}"
SRC_URI[aarch64_lldb20-devel.sha256sum] = "fb9bb3e6a1c8cee1bce8d8d9bd35586273151f310f398aaa1073eb3b92dca063"

URI_aarch64_llvm20 = "${EPEL_MIRROR}/aarch64/Packages/l/llvm20-20.1.8-9.el10_2.aarch64.rpm;name=aarch64_llvm20;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm20}"
SRC_URI[aarch64_llvm20.sha256sum] = "f5a82696003ba49ffdba2e3df895f2174846bb666eacdd034a12b4895701500a"

URI_aarch64_llvm20-cmake-utils = "${EPEL_MIRROR}/aarch64/Packages/l/llvm20-cmake-utils-20.1.8-9.el10_2.aarch64.rpm;name=aarch64_llvm20-cmake-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm20-cmake-utils}"
SRC_URI[aarch64_llvm20-cmake-utils.sha256sum] = "0866e38e3aa33d9442a0d1292f32a8871a8c778baa8e7396ace38617762e361d"

URI_aarch64_llvm20-devel = "${EPEL_MIRROR}/aarch64/Packages/l/llvm20-devel-20.1.8-9.el10_2.aarch64.rpm;name=aarch64_llvm20-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm20-devel}"
SRC_URI[aarch64_llvm20-devel.sha256sum] = "4916e582678c488f34a311d0564f745d2500ef5801b3d2dfe9eb328fd744f344"

URI_aarch64_llvm20-doc = "${EPEL_MIRROR}/aarch64/Packages/l/llvm20-doc-20.1.8-9.el10_2.noarch.rpm;name=aarch64_llvm20-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm20-doc}"
SRC_URI[aarch64_llvm20-doc.sha256sum] = "801117052d62de8b99f83c0509a951a7d84f0d80ace46d7603e509f241c79b33"

URI_aarch64_llvm20-filesystem = "${EPEL_MIRROR}/aarch64/Packages/l/llvm20-filesystem-20.1.8-9.el10_2.aarch64.rpm;name=aarch64_llvm20-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm20-filesystem}"
SRC_URI[aarch64_llvm20-filesystem.sha256sum] = "72da6e5e5ce5533e18397b70910543f90aa09fb6ffe12be77fdb715ee029d6cf"

URI_aarch64_llvm20-googletest = "${EPEL_MIRROR}/aarch64/Packages/l/llvm20-googletest-20.1.8-9.el10_2.aarch64.rpm;name=aarch64_llvm20-googletest;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm20-googletest}"
SRC_URI[aarch64_llvm20-googletest.sha256sum] = "c51a1f14b72790dfeba5123def0caec9e53c9b99f54c4e245467ca51562192b6"

URI_aarch64_llvm20-libs = "${EPEL_MIRROR}/aarch64/Packages/l/llvm20-libs-20.1.8-9.el10_2.aarch64.rpm;name=aarch64_llvm20-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm20-libs}"
SRC_URI[aarch64_llvm20-libs.sha256sum] = "bd7363cafe8859ba45bec789c0619de39ce26a4f27e574e008c2b6b2e8ebe160"

URI_aarch64_llvm20-static = "${EPEL_MIRROR}/aarch64/Packages/l/llvm20-static-20.1.8-9.el10_2.aarch64.rpm;name=aarch64_llvm20-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm20-static}"
SRC_URI[aarch64_llvm20-static.sha256sum] = "e64c0672e2e50f6a99a1f87150aedbe7ffab781696b309b288d996b467468169"

URI_aarch64_llvm20-test = "${EPEL_MIRROR}/aarch64/Packages/l/llvm20-test-20.1.8-9.el10_2.aarch64.rpm;name=aarch64_llvm20-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm20-test}"
SRC_URI[aarch64_llvm20-test.sha256sum] = "5572c7dcb4e5b23eb63faa21e50b44a56ba81182c29e7cc4948030ac88237560"

URI_aarch64_llvm20-toolset = "${EPEL_MIRROR}/aarch64/Packages/l/llvm20-toolset-20.1.8-9.el10_2.aarch64.rpm;name=aarch64_llvm20-toolset;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm20-toolset}"
SRC_URI[aarch64_llvm20-toolset.sha256sum] = "6cfcc37bc4a33edec8ca19f174b6fcfe9ea96529f14dbe1440b6372e322c15d9"

RDEPENDS:clang20 = " \
 clang20-libs \
 gcc-c++ \
 glibc \
 libgcc \
 libstdc++ \
 libstdc++-devel \
 llvm20-libs \
 "
RDEPENDS:clang20-analyzer = " \
 clang20 \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-FindBin \
 perl-Hash-Util \
 perl-PathTools \
 perl-Sys-Hostname \
 perl-Term-ANSIColor \
 perl-Text-ParseWords \
 perl-interpreter \
 perl-lib \
 perl-libs \
 python3 \
 "
RDEPENDS:clang20-devel = " \
 clang20 \
 clang20-libs \
 clang20-tools-extra \
 glibc \
 libgcc \
 libstdc++ \
 llvm20-devel \
 "
RDEPENDS:clang20-libs = " \
 clang20-resource-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 llvm20-libs \
 "
RDEPENDS:clang20-resource-filesystem = " \
 "
RDEPENDS:clang20-tools-extra = " \
 clang20-libs \
 emacs-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 libxml2 \
 llvm20-libs \
 python3 \
 "
RDEPENDS:clang20-tools-extra-devel = " \
 clang20-tools-extra \
 "
RDEPENDS:compiler-rt20 = " \
 clang20-resource-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
RDEPENDS:git-clang-format20 = " \
 clang20-tools-extra \
 git \
 python3 \
 "
RDEPENDS:libomp20 = " \
 elfutils-libelf \
 glibc \
 libffi \
 libgcc \
 libstdc++ \
 llvm20-libs \
 "
RDEPENDS:libomp20-devel = " \
 clang20-resource-filesystem \
 libomp20 \
 "
RDEPENDS:lld20 = " \
 alternatives \
 glibc \
 libgcc \
 libstdc++ \
 lld20-libs \
 llvm20-libs \
 "
RDEPENDS:lld20-devel = " \
 lld20-libs \
 "
RDEPENDS:lld20-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 llvm20-libs \
 zlib-ng-compat \
 "
RDEPENDS:lldb20 = " \
 clang20-libs \
 glibc \
 libedit \
 libgcc \
 libstdc++ \
 libxml2 \
 llvm20-libs \
 ncurses-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:lldb20-devel = " \
 lldb20 \
 "
RDEPENDS:llvm20 = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 llvm20-libs \
 python3 \
 zlib-ng-compat \
 "
RDEPENDS:llvm20-cmake-utils = " \
 llvm20-filesystem \
 "
RDEPENDS:llvm20-devel = " \
 alternatives \
 bash \
 glibc \
 libedit-devel \
 libgcc \
 libstdc++ \
 libzstd-devel \
 llvm20 \
 llvm20-googletest \
 llvm20-libs \
 llvm20-static \
 llvm20-test \
 "
RDEPENDS:llvm20-doc = " \
 llvm20 \
 "
RDEPENDS:llvm20-filesystem = " \
 "
RDEPENDS:llvm20-googletest = " \
 llvm20-filesystem \
 "
RDEPENDS:llvm20-libs = " \
 glibc \
 libedit \
 libffi \
 libgcc \
 libstdc++ \
 libxml2 \
 libzstd \
 llvm20-filesystem \
 zlib-ng-compat \
 "
RDEPENDS:llvm20-static = " \
 llvm20-filesystem \
 "
RDEPENDS:llvm20-test = " \
 glibc \
 libgcc \
 libstdc++ \
 llvm20 \
 llvm20-libs \
 "
RDEPENDS:llvm20-toolset = " \
 clang20 \
 lld20 \
 llvm20 \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/libomp.so_VERSION__64bit_ rpm/virtual/libomp.so___64bit_"
