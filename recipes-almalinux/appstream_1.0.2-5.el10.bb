# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "appstream"
PV = "1.0.2"
PR = "5.el10"
PACKAGES = " \
 appstream \
 appstream-compose \
 appstream-compose-devel \
 appstream-devel \
 appstream-qt \
 appstream-qt-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/appstream-1.0.2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "929196f6966d16e479f345efd49b743a7cb08db17493bf3f3c1ab60779ac9ea5"

URI_x86_64_v2_appstream = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/appstream-1.0.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_appstream;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_appstream}"
SRC_URI[x86_64_v2_appstream.sha256sum] = "ac602732606ff9b21b1acdb0d7b6739233f9520f281c4ceb4762400616f92984"

URI_x86_64_v2_appstream-compose = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/appstream-compose-1.0.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_appstream-compose;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_appstream-compose}"
SRC_URI[x86_64_v2_appstream-compose.sha256sum] = "92759f47ab7136393e582dedf67056ccf7e4e985fc3a9eed1d57bed2a16db614"

URI_x86_64_v2_appstream-compose-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/appstream-compose-devel-1.0.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_appstream-compose-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_appstream-compose-devel}"
SRC_URI[x86_64_v2_appstream-compose-devel.sha256sum] = "43557bee25350bbb60f4fd0a8184cb305ac663c769966a6e829acccdbb40f17b"

URI_x86_64_v2_appstream-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/appstream-devel-1.0.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_appstream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_appstream-devel}"
SRC_URI[x86_64_v2_appstream-devel.sha256sum] = "df1cad6f5fda100ad55cadb438eac6d52c1ade487a9aefd6d8484302e45b9c68"

URI_x86_64_v2_appstream-qt = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/appstream-qt-1.0.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_appstream-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_appstream-qt}"
SRC_URI[x86_64_v2_appstream-qt.sha256sum] = "ecbce5a887ec0cc1d53516c8f063e4a6e4b87d79da8d0d5d4c5a7d6c53b5d2a6"

URI_x86_64_v2_appstream-qt-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/appstream-qt-devel-1.0.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_appstream-qt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_appstream-qt-devel}"
SRC_URI[x86_64_v2_appstream-qt-devel.sha256sum] = "c6d232d37a0e27b983652d4d7f7d0c5f574bf7a8ae75af412dd2f9dcdb08e174"

URI_aarch64_appstream = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/appstream-1.0.2-5.el10.aarch64.rpm;name=aarch64_appstream;unpack=0"
SRC_URI:append = " ${URI_aarch64_appstream}"
SRC_URI[aarch64_appstream.sha256sum] = "7086abce3c2a335af91fcbe195dd398edccca8d004c4ac10f52c2f2e6d32d8c8"

URI_aarch64_appstream-compose = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/appstream-compose-1.0.2-5.el10.aarch64.rpm;name=aarch64_appstream-compose;unpack=0"
SRC_URI:append = " ${URI_aarch64_appstream-compose}"
SRC_URI[aarch64_appstream-compose.sha256sum] = "5ba5685bfce52d887d682595e3f5ec6b4a69bf5576b009bd3209732d8fbc6549"

URI_aarch64_appstream-compose-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/appstream-compose-devel-1.0.2-5.el10.aarch64.rpm;name=aarch64_appstream-compose-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_appstream-compose-devel}"
SRC_URI[aarch64_appstream-compose-devel.sha256sum] = "3599de474c7bad56c141359b7db49a65718872631b2a81d3bfdd2217070e311d"

URI_aarch64_appstream-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/appstream-devel-1.0.2-5.el10.aarch64.rpm;name=aarch64_appstream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_appstream-devel}"
SRC_URI[aarch64_appstream-devel.sha256sum] = "cdf87c8321469f0838fe070462997a5a3de6f3435bd113b584bd9ccfffcd3a75"

URI_aarch64_appstream-qt = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/appstream-qt-1.0.2-5.el10.aarch64.rpm;name=aarch64_appstream-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_appstream-qt}"
SRC_URI[aarch64_appstream-qt.sha256sum] = "0b2a3bd57d4618abdefccb28127c835b74aa56a1ba4afa9f32fe0480c6cedef8"

URI_aarch64_appstream-qt-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/appstream-qt-devel-1.0.2-5.el10.aarch64.rpm;name=aarch64_appstream-qt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_appstream-qt-devel}"
SRC_URI[aarch64_appstream-qt-devel.sha256sum] = "fbe231bf9ba484c7a576288f42472450b838a598c3c467cde4330aa35f47dc2c"

RDEPENDS:appstream = " \
 appstream-data \
 bash \
 glib2 \
 glibc \
 libgcc \
 libxml2 \
 libxmlb \
 libyaml \
 libzstd \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:appstream-compose = " \
 appstream \
 cairo \
 fontconfig \
 freetype \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 libgcc \
 librsvg2 \
 libyaml \
 pango \
 "
RDEPENDS:appstream-compose-devel = " \
 appstream-compose \
 appstream-devel \
 gdk-pixbuf2-devel \
 glib2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:appstream-devel = " \
 appstream \
 glib2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:appstream-qt = " \
 appstream \
 glib2 \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:appstream-qt-devel = " \
 appstream-qt \
 cmake-filesystem \
 qt6-qtbase-devel \
 "
