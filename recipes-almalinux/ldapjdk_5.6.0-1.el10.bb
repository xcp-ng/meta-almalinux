# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ldapjdk"
PV = "5.6.0"
PR = "1.el10"
PACKAGES = " \
 idm-ldapjdk \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ldapjdk-5.6.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "955be772d27dc392d5fd96aee28b4c65498f2b25267a0e716a198c7b16be26b9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-ldapjdk-5.6.0-1.el10.noarch.rpm;name=x86_64_v2_idm-ldapjdk;unpack=0"
SRC_URI[x86_64_v2_idm-ldapjdk.sha256sum] = "f07e9c3936f447f299361e8f8fb499fbebe5dfa764bcdb1405896bd7ac60477f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-ldapjdk-5.6.0-1.el10.noarch.rpm;name=aarch64_idm-ldapjdk;unpack=0"
SRC_URI[aarch64_idm-ldapjdk.sha256sum] = "f07e9c3936f447f299361e8f8fb499fbebe5dfa764bcdb1405896bd7ac60477f"

RDEPENDS:idm-ldapjdk = " \
 idm-jss \
 java-21-openjdk-headless \
 javapackages-filesystem \
 slf4j \
 slf4j-jdk14 \
 "
