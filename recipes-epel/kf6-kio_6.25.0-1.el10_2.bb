# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kio"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kio \
 kf6-kio-core \
 kf6-kio-core-libs \
 kf6-kio-devel \
 kf6-kio-doc \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-html \
 kf6-kio-qch-doc \
 kf6-kio-widgets \
 kf6-kio-widgets-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kio-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f3f3173f0af6c144d728591b3fa42d9e15383ebea33d6293525a8e99ef0f94a"

URI_x86_64_v2_kf6-kio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kio}"
SRC_URI[x86_64_v2_kf6-kio.sha256sum] = "2c79f0eeb6d88dff12167f2e531e57d6cd96a46728e13da0c948ab72920e878a"

URI_x86_64_v2_kf6-kio-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-core-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kio-core}"
SRC_URI[x86_64_v2_kf6-kio-core.sha256sum] = "d41df8ca27d5e8544134daa2c28a1622478516b3e32015c57e153fa1429d5a26"

URI_x86_64_v2_kf6-kio-core-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-core-libs-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-core-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kio-core-libs}"
SRC_URI[x86_64_v2_kf6-kio-core-libs.sha256sum] = "8697a880005adcf21cdc2dc11ecab4794f4a20935b3393ecacf8291b8fe31e37"

URI_x86_64_v2_kf6-kio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kio-devel}"
SRC_URI[x86_64_v2_kf6-kio-devel.sha256sum] = "83940fcdf7f381839c0fb6168aa87a35940580cc2d7c116da0ccfb2486aa523b"

URI_x86_64_v2_kf6-kio-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kio-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kio-doc}"
SRC_URI[x86_64_v2_kf6-kio-doc.sha256sum] = "151590d5a7df4aad936cf7d94739fb06ee6d71414044308d0c020713f2cc5880"

URI_x86_64_v2_kf6-kio-file-widgets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-file-widgets-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-file-widgets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kio-file-widgets}"
SRC_URI[x86_64_v2_kf6-kio-file-widgets.sha256sum] = "8dd70d559d47436c7a16815e02d1c9da64b15497f7925930b138696524128e29"

URI_x86_64_v2_kf6-kio-gui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-gui-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kio-gui}"
SRC_URI[x86_64_v2_kf6-kio-gui.sha256sum] = "5819b0d961259bc2d7f5d439a468e4919d12b37e32132a94c719ece7f3a9a2e4"

URI_x86_64_v2_kf6-kio-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kio-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kio-html}"
SRC_URI[x86_64_v2_kf6-kio-html.sha256sum] = "abdb3069ce099cbbe399aeec35388f88fd24a4219b397c8b95047f727b066dd4"

URI_x86_64_v2_kf6-kio-qch-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-qch-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kio-qch-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kio-qch-doc}"
SRC_URI[x86_64_v2_kf6-kio-qch-doc.sha256sum] = "5a464039a7fdfebc0fb263e792c4f0937f034e5e421270cbcdf6325e56e88c19"

URI_x86_64_v2_kf6-kio-widgets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-widgets-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-widgets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kio-widgets}"
SRC_URI[x86_64_v2_kf6-kio-widgets.sha256sum] = "781291e7cec2157f2ebcc7a60d9bf69778aadc881908e12047c46a840c8305d0"

URI_x86_64_v2_kf6-kio-widgets-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-widgets-libs-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-widgets-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kio-widgets-libs}"
SRC_URI[x86_64_v2_kf6-kio-widgets-libs.sha256sum] = "9153eed2cf5ad77b0634a0528a877cc725d7736c8ef14d5dd7eae0dd56bf0b0f"

URI_aarch64_kf6-kio = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kio;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kio}"
SRC_URI[aarch64_kf6-kio.sha256sum] = "b6907f3d5f5ae7348bd666cba32652feac7f9a987e2aeed61c4c63b46757f53c"

URI_aarch64_kf6-kio-core = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-core-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kio-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kio-core}"
SRC_URI[aarch64_kf6-kio-core.sha256sum] = "5a21a67816ade3c1b914a391f73a8f3c487a609175f32983d3187181df8f7d8e"

URI_aarch64_kf6-kio-core-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-core-libs-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kio-core-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kio-core-libs}"
SRC_URI[aarch64_kf6-kio-core-libs.sha256sum] = "d04ce787bea022e403bfcd189b215598d8fe69a511cbd75ec275d365c2f172c5"

URI_aarch64_kf6-kio-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kio-devel}"
SRC_URI[aarch64_kf6-kio-devel.sha256sum] = "a2f3589a05e738197a9a91a140188e2cf58cbb2d6d4cd1f64211f9fcb4f9331d"

URI_aarch64_kf6-kio-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kio-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kio-doc}"
SRC_URI[aarch64_kf6-kio-doc.sha256sum] = "50eacae5275173a2f72eba50ddc3df6acf5ed82aeb99209a6c6467f8969b0ba9"

URI_aarch64_kf6-kio-file-widgets = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-file-widgets-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kio-file-widgets;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kio-file-widgets}"
SRC_URI[aarch64_kf6-kio-file-widgets.sha256sum] = "dde00a65e6ecee0c73b0b2d21459549962377d2502a3323645502e4df0127474"

URI_aarch64_kf6-kio-gui = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-gui-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kio-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kio-gui}"
SRC_URI[aarch64_kf6-kio-gui.sha256sum] = "c42e55570d750543b6bf53d26944e6f778030c2de86051f22675657779f161b5"

URI_aarch64_kf6-kio-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kio-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kio-html}"
SRC_URI[aarch64_kf6-kio-html.sha256sum] = "ecc5e174d5d93805c6e9153b6dbb220ac7c90228dc720dccf1cd148e8b575877"

URI_aarch64_kf6-kio-qch-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-qch-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kio-qch-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kio-qch-doc}"
SRC_URI[aarch64_kf6-kio-qch-doc.sha256sum] = "9d168729bdf4eab87895550799c65f4711c7bf1b99fea78ac8b483f88b031898"

URI_aarch64_kf6-kio-widgets = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-widgets-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kio-widgets;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kio-widgets}"
SRC_URI[aarch64_kf6-kio-widgets.sha256sum] = "a25e11d6309dbee4891dd7a13a07a87b10b380e949b033a56bcc75806bf3485b"

URI_aarch64_kf6-kio-widgets-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-widgets-libs-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kio-widgets-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kio-widgets-libs}"
SRC_URI[aarch64_kf6-kio-widgets-libs.sha256sum] = "111979a90ed9ca5d37576c4f54eb8868a76052a6daef8d5697a53f67071d35ff"

RDEPENDS:kf6-kio = " \
 kf6-kded \
 kf6-kio-core \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets \
 "
RDEPENDS:kf6-kio-core = " \
 glibc \
 kf6-filesystem \
 kf6-karchive \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdoctools \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-doc \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kservice \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libacl \
 libstdc++ \
 libxml2 \
 libxslt \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kio-core-libs = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core \
 kf6-kservice \
 libacl \
 libmount \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kio-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kbookmarks-devel \
 kf6-kcompletion-devel \
 kf6-kconfig-devel \
 kf6-kcoreaddons-devel \
 kf6-kio \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets \
 kf6-kio-widgets-libs \
 kf6-kitemviews-devel \
 kf6-kjobwidgets-devel \
 kf6-kservice-devel \
 kf6-kwindowsystem-devel \
 kf6-kxmlgui-devel \
 kf6-solid-devel \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kio-doc = " \
 kf6-kio-core \
 "
RDEPENDS:kf6-kio-file-widgets = " \
 glibc \
 kf6-kbookmarks \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kwidgetsaddons \
 kf6-solid \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kio-gui = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core \
 kf6-kio-core-libs \
 kf6-kservice \
 kf6-kwindowsystem \
 kf6-solid \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kio-html = " \
 "
RDEPENDS:kf6-kio-qch-doc = " \
 "
RDEPENDS:kf6-kio-widgets = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kservice \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kio-widgets-libs = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets \
 kf6-kjobwidgets \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
