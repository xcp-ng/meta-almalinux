# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "canl-java"
PV = "2.9.0"
PR = "1.el10_2"
PACKAGES = " \
 canl-java \
 canl-java-javadoc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/canl-java-2.9.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1f1f2d0065b9a00e5dd5bd2598adf496dc6bef5497ff783dfb4d78fccd39d99f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/canl-java-2.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_canl-java;unpack=0"
SRC_URI[x86_64_v2_canl-java.sha256sum] = "e37a08f97531f25030edae7fb9c0f477bcacd3a1ce08d493833a273f8de17f3b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/canl-java-javadoc-2.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_canl-java-javadoc;unpack=0"
SRC_URI[x86_64_v2_canl-java-javadoc.sha256sum] = "378a8c5fe4de7cdb8e9d2d661ce7d44cb997c37a854dad55f80505dd37964296"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/canl-java-2.9.0-1.el10_2.noarch.rpm;name=aarch64_canl-java;unpack=0"
SRC_URI[aarch64_canl-java.sha256sum] = "d22ea614e616450a6589a1c7264939edc28993988a278427af025d4bdcd7e174"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/canl-java-javadoc-2.9.0-1.el10_2.noarch.rpm;name=aarch64_canl-java-javadoc;unpack=0"
SRC_URI[aarch64_canl-java-javadoc.sha256sum] = "cbac970886a32317e7e54535af1ed8719c8ac536726d6d0b72325154ecc2e121"

RDEPENDS:canl-java = " \
 apache-commons-io \
 bouncycastle \
 bouncycastle-pkix \
 javapackages-filesystem \
 "
RDEPENDS:canl-java-javadoc = " \
 javapackages-filesystem \
 "
