# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_chgrp"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_chgrp+default-devel \
 rust-uu_chgrp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_chgrp-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2201cbb3b04e69d5bfce5553e59b19d5e3542e8c449f2feedcf9868e26dd23d8"

URI_x86_64_v2_rust-uu_chgrp+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_chgrp+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_chgrp+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_chgrp+default-devel}"
SRC_URI[x86_64_v2_rust-uu_chgrp+default-devel.sha256sum] = "bd611ee9b41086fdc86249c63dee599dae5f656b2124977c1748e29557624c2d"

URI_x86_64_v2_rust-uu_chgrp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_chgrp-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_chgrp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_chgrp-devel}"
SRC_URI[x86_64_v2_rust-uu_chgrp-devel.sha256sum] = "63da401a772e8b77db16255775744ff41a179c57b3f995e7c2987e380b8818fc"

URI_aarch64_rust-uu_chgrp+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_chgrp+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_chgrp+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_chgrp+default-devel}"
SRC_URI[aarch64_rust-uu_chgrp+default-devel.sha256sum] = "0d54312e90e6ff823a4a4f2340dfb82c827356511184660b1cbf8d09d95486f9"

URI_aarch64_rust-uu_chgrp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_chgrp-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_chgrp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_chgrp-devel}"
SRC_URI[aarch64_rust-uu_chgrp-devel.sha256sum] = "6401e398dc39415c3ebacc487cfd3f1e08384013615b5e839a2025b9de02e6c8"

RDEPENDS:rust-uu_chgrp+default-devel = " \
 cargo \
 rust-uu_chgrp-devel \
 "
RDEPENDS:rust-uu_chgrp-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uucore+default-devel \
 rust-uucore+entries-devel \
 rust-uucore+fs-devel \
 rust-uucore+perms-devel \
 "
