# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rnp"
PV = "0.18.1"
PR = "1.el10_1"
PACKAGES = " \
 librnp \
 librnp-devel \
 rnp \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rnp-0.18.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "95dd9949dd719f662e7eeedb5fcc5190208690492f165de4873b99adb6c1297e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librnp-0.18.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librnp;unpack=0"
SRC_URI[x86_64_v2_librnp.sha256sum] = "bf2e55c31b848ba2e5ed0b448f016dd6083b5aff9bf0b75aac20b2c99164a4c0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librnp-devel-0.18.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librnp-devel;unpack=0"
SRC_URI[x86_64_v2_librnp-devel.sha256sum] = "f8b8620c78ca4b2fc0dc5bd81bc1b0578a53581d298d7b4062f4062c410cfd48"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rnp-0.18.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rnp;unpack=0"
SRC_URI[x86_64_v2_rnp.sha256sum] = "4ad392cada80fa3b82b35ef7dde836acb83ac0eb952364c0fa96c1d4c7f6bf02"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/librnp-0.18.1-1.el10_1.aarch64.rpm;name=aarch64_librnp;unpack=0"
SRC_URI[aarch64_librnp.sha256sum] = "64e3d1b65cad0080edc5bc4c8c302226c88454688970c486083a64eef28982e4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/librnp-devel-0.18.1-1.el10_1.aarch64.rpm;name=aarch64_librnp-devel;unpack=0"
SRC_URI[aarch64_librnp-devel.sha256sum] = "671e5c4b9994ef76170b9d02bdde12514977381e81244215a7929bfdf79a3a1a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rnp-0.18.1-1.el10_1.aarch64.rpm;name=aarch64_rnp;unpack=0"
SRC_URI[aarch64_rnp.sha256sum] = "4fab553d6dea834950d76dc1718c37ed37798f4cb6a3a114f1594dd87a3ed8a0"

RDEPENDS:librnp = " \
 botan2 \
 bzip2-libs \
 glibc \
 json-c \
 libgcc \
 libsexpp \
 libstdc++ \
 zlib-ng-compat \
 "
RDEPENDS:librnp-devel = " \
 cmake-filesystem \
 librnp \
 pkgconf-pkg-config \
 "
RDEPENDS:rnp = " \
 glibc \
 json-c \
 libgcc \
 librnp \
 libstdc++ \
 "
