# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-UNIVERSAL-can"
PV = "1.20140328"
PR = "29.el10_0"
PACKAGES = " \
 perl-UNIVERSAL-can \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-UNIVERSAL-can-1.20140328-29.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0d75a869e03527b28d8b2d70925758b4f242e73f0ea1e0b028d6476f857873f6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-UNIVERSAL-can-1.20140328-29.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-UNIVERSAL-can;unpack=0"
SRC_URI[x86_64_v2_perl-UNIVERSAL-can.sha256sum] = "7a2a29586c4a0a0af9508b130b7aa704d0b31217f972f77ab64169009829a3f9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-UNIVERSAL-can-1.20140328-29.el10_0.noarch.rpm;name=aarch64_perl-UNIVERSAL-can;unpack=0"
SRC_URI[aarch64_perl-UNIVERSAL-can.sha256sum] = "aab1cffe77e5a6c558a77a838ed3a541b42d69da8f67883ea1c91b833336107e"

RDEPENDS:perl-UNIVERSAL-can = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-vars \
 "
