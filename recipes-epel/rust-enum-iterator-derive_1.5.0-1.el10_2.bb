# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-enum-iterator-derive"
PV = "1.5.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-enum-iterator-derive+default-devel \
 rust-enum-iterator-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-enum-iterator-derive-1.5.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6372245aa2805a2808523a553ee37f66b278cb1c13f30f986402e4db2ff7cff5"

URI_x86_64_v2_rust-enum-iterator-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enum-iterator-derive+default-devel-1.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enum-iterator-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enum-iterator-derive+default-devel}"
SRC_URI[x86_64_v2_rust-enum-iterator-derive+default-devel.sha256sum] = "681fbc4d0ba067a215a67b63c1dfdd55d519e0dff772410c0e03a731b9146ca9"

URI_x86_64_v2_rust-enum-iterator-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enum-iterator-derive-devel-1.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enum-iterator-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enum-iterator-derive-devel}"
SRC_URI[x86_64_v2_rust-enum-iterator-derive-devel.sha256sum] = "8085132470c21c31b779b61e4b0554260a9ad69bc41986f42b060242941be10e"

URI_aarch64_rust-enum-iterator-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enum-iterator-derive+default-devel-1.5.0-1.el10_2.noarch.rpm;name=aarch64_rust-enum-iterator-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enum-iterator-derive+default-devel}"
SRC_URI[aarch64_rust-enum-iterator-derive+default-devel.sha256sum] = "025168bae008273762ecf82450ed15f274b6a49ae5ad9c8d08dd985f71138dac"

URI_aarch64_rust-enum-iterator-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enum-iterator-derive-devel-1.5.0-1.el10_2.noarch.rpm;name=aarch64_rust-enum-iterator-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enum-iterator-derive-devel}"
SRC_URI[aarch64_rust-enum-iterator-derive-devel.sha256sum] = "05303cfde7c00d20939a5bdfd82d12d28740f005df36975accc71c566bc10993"

RDEPENDS:rust-enum-iterator-derive+default-devel = " \
 cargo \
 rust-enum-iterator-derive-devel \
 "
RDEPENDS:rust-enum-iterator-derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+extra-traits-devel \
 "
