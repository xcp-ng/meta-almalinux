# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lastpass-cli"
PV = "1.6.1"
PR = "1.el10_0"
PACKAGES = " \
 lastpass-cli \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lastpass-cli-1.6.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30def4c3722f3cd5a7ce48fc6c26673ea787156fd07c3e25fd4c3f2c2f4632e9"

URI_x86_64_v2_lastpass-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lastpass-cli-1.6.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lastpass-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lastpass-cli}"
SRC_URI[x86_64_v2_lastpass-cli.sha256sum] = "4903e348162fd61bb47df6f9b20a736c3ac6803c7fee417a30060e844a7c2975"

URI_aarch64_lastpass-cli = "${EPEL_MIRROR}/aarch64/Packages/l/lastpass-cli-1.6.1-1.el10_0.aarch64.rpm;name=aarch64_lastpass-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_lastpass-cli}"
SRC_URI[aarch64_lastpass-cli.sha256sum] = "f33f422a43f7ad72b55bab143d52eb2409c442c3824b7d7cb913269d767e9c68"

RDEPENDS:lastpass-cli = " \
 glibc \
 libgcc \
 libxml2 \
 openssl-libs \
 pinentry \
 virtual/libcurl.so.4___64bit_ \
 xclip \
 "
