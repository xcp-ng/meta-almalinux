# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-schemars"
PV = "1.2.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-schemars+arrayvec07-devel \
 rust-schemars+bigdecimal04-devel \
 rust-schemars+bytes1-devel \
 rust-schemars+chrono04-devel \
 rust-schemars+default-devel \
 rust-schemars+derive-devel \
 rust-schemars+either1-devel \
 rust-schemars+indexmap2-devel \
 rust-schemars+jiff02-devel \
 rust-schemars+preserve_order-devel \
 rust-schemars+raw_value-devel \
 rust-schemars+rust_decimal1-devel \
 rust-schemars+schemars_derive-devel \
 rust-schemars+semver1-devel \
 rust-schemars+smallvec1-devel \
 rust-schemars+smol_str02-devel \
 rust-schemars+smol_str03-devel \
 rust-schemars+std-devel \
 rust-schemars+url2-devel \
 rust-schemars+uuid1-devel \
 rust-schemars-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-schemars-1.2.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a2247048b5f7d5abe96b76ca9facad93114176c97c6b251e110a565fdf71cb45"

URI_x86_64_v2_rust-schemars+arrayvec07-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+arrayvec07-devel-1.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+arrayvec07-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+arrayvec07-devel}"
SRC_URI[x86_64_v2_rust-schemars+arrayvec07-devel.sha256sum] = "c68d6afafd6bfe2a62fd75cc86b25f99c15354e6f6b7a454b00adbb1a1248feb"

URI_x86_64_v2_rust-schemars+bigdecimal04-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+bigdecimal04-devel-1.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+bigdecimal04-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+bigdecimal04-devel}"
SRC_URI[x86_64_v2_rust-schemars+bigdecimal04-devel.sha256sum] = "ac420616f1e0c36c91309c1355e0331cb903338ce9969888f0a3603831801e80"

URI_x86_64_v2_rust-schemars+bytes1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+bytes1-devel-1.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+bytes1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+bytes1-devel}"
SRC_URI[x86_64_v2_rust-schemars+bytes1-devel.sha256sum] = "5c5cdcfd9ad0b1bb87d3793dd776534e9430a57343a91dfc891e6c75198b27f2"

URI_x86_64_v2_rust-schemars+chrono04-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+chrono04-devel-1.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+chrono04-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+chrono04-devel}"
SRC_URI[x86_64_v2_rust-schemars+chrono04-devel.sha256sum] = "5e2e3ec20bf7c868de5a60a501027170c58745b472a157b13e175f78bb6294e3"

URI_x86_64_v2_rust-schemars+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+default-devel-1.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+default-devel}"
SRC_URI[x86_64_v2_rust-schemars+default-devel.sha256sum] = "fd6f9e12aa1601c5aaa489b7cdaa72cfdb6cd2458f60aa0cbfa02e24e25bf8bd"

URI_x86_64_v2_rust-schemars+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+derive-devel-1.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+derive-devel}"
SRC_URI[x86_64_v2_rust-schemars+derive-devel.sha256sum] = "9df1d6f3682f1ecbf952657963590c5a7feb13c300ebe5df7f13b08e6b46ac4e"

URI_x86_64_v2_rust-schemars+either1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+either1-devel-1.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+either1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+either1-devel}"
SRC_URI[x86_64_v2_rust-schemars+either1-devel.sha256sum] = "bbce220730dd13498632537625ebaf0ed41364bffd684eba9562446eb057a74c"

URI_x86_64_v2_rust-schemars+indexmap2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+indexmap2-devel-1.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+indexmap2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+indexmap2-devel}"
SRC_URI[x86_64_v2_rust-schemars+indexmap2-devel.sha256sum] = "e3a9d33925ee9795210a1e1da78fa395b9ac2bf8464e700475460317a5ed61df"

URI_x86_64_v2_rust-schemars+jiff02-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+jiff02-devel-1.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+jiff02-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+jiff02-devel}"
SRC_URI[x86_64_v2_rust-schemars+jiff02-devel.sha256sum] = "eeac0fd3cc9dda9631025122a32caceff53cfc09605c4908ed5a95ab42c93b1e"

URI_x86_64_v2_rust-schemars+preserve_order-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+preserve_order-devel-1.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+preserve_order-devel}"
SRC_URI[x86_64_v2_rust-schemars+preserve_order-devel.sha256sum] = "05946dbfd8697bc05a2f9b8f367bc86feb3189e48d941dcc139cc10b4c8db899"

URI_x86_64_v2_rust-schemars+raw_value-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+raw_value-devel-1.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+raw_value-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+raw_value-devel}"
SRC_URI[x86_64_v2_rust-schemars+raw_value-devel.sha256sum] = "9519dcf2ff6616939bfc456ca37b5b05d8d02c530a78d7d45c9f95ecccacd105"

URI_x86_64_v2_rust-schemars+rust_decimal1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+rust_decimal1-devel-1.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+rust_decimal1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+rust_decimal1-devel}"
SRC_URI[x86_64_v2_rust-schemars+rust_decimal1-devel.sha256sum] = "91b919e73befa8f77bb3135448388f09e72cb28aefb737ba49774b3df896daf7"

URI_x86_64_v2_rust-schemars+schemars_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+schemars_derive-devel-1.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+schemars_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+schemars_derive-devel}"
SRC_URI[x86_64_v2_rust-schemars+schemars_derive-devel.sha256sum] = "d52165f987516eaa99f1b8b5930a47f504d598a68e94f05c6622d524d555b884"

URI_x86_64_v2_rust-schemars+semver1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+semver1-devel-1.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+semver1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+semver1-devel}"
SRC_URI[x86_64_v2_rust-schemars+semver1-devel.sha256sum] = "ba21f33e5a21f9773d75edd050c76f7048b345b29dab5d2c66bfd0c93c495579"

URI_x86_64_v2_rust-schemars+smallvec1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+smallvec1-devel-1.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+smallvec1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+smallvec1-devel}"
SRC_URI[x86_64_v2_rust-schemars+smallvec1-devel.sha256sum] = "3831958cc3687dc89954971dad34c8417f4b523e6ba0163f50e5ce4e94f0dbb8"

URI_x86_64_v2_rust-schemars+smol_str02-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+smol_str02-devel-1.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+smol_str02-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+smol_str02-devel}"
SRC_URI[x86_64_v2_rust-schemars+smol_str02-devel.sha256sum] = "5b64658ca407f99596f161480b679afb924f3c125edabd6bbcbc8104398db830"

URI_x86_64_v2_rust-schemars+smol_str03-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+smol_str03-devel-1.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+smol_str03-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+smol_str03-devel}"
SRC_URI[x86_64_v2_rust-schemars+smol_str03-devel.sha256sum] = "732435d55bc8f78dfff91a3c5c38e7fd2bbbe18e68f6651d6378c3d4296b1a77"

URI_x86_64_v2_rust-schemars+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+std-devel-1.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+std-devel}"
SRC_URI[x86_64_v2_rust-schemars+std-devel.sha256sum] = "61247e3bbc4de0fe4e9003aaf13daa244151f721c9717a30327a693c45b00630"

URI_x86_64_v2_rust-schemars+url2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+url2-devel-1.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+url2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+url2-devel}"
SRC_URI[x86_64_v2_rust-schemars+url2-devel.sha256sum] = "63af2cb2f25549d6d0532ca07d245d8f50897ae90cefa921d2657b0f4b65dba9"

URI_x86_64_v2_rust-schemars+uuid1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+uuid1-devel-1.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+uuid1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+uuid1-devel}"
SRC_URI[x86_64_v2_rust-schemars+uuid1-devel.sha256sum] = "682d1f30b92395ad2df7b6a5411020409eb71a330ea6c83cb787db797f5cb456"

URI_x86_64_v2_rust-schemars-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars-devel-1.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars-devel}"
SRC_URI[x86_64_v2_rust-schemars-devel.sha256sum] = "85253cab1260b701c3ebe9c99b2174073a1b3e0282ceaacd72d17f8c02cb89fe"

URI_aarch64_rust-schemars+arrayvec07-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+arrayvec07-devel-1.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-schemars+arrayvec07-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+arrayvec07-devel}"
SRC_URI[aarch64_rust-schemars+arrayvec07-devel.sha256sum] = "f6a462fc3c4da5fc5b84cabea778743569f9977376ce97962827a971dafd91d2"

URI_aarch64_rust-schemars+bigdecimal04-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+bigdecimal04-devel-1.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-schemars+bigdecimal04-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+bigdecimal04-devel}"
SRC_URI[aarch64_rust-schemars+bigdecimal04-devel.sha256sum] = "2ddb732e21bc0aa4e33eee010dd8e3fb5c83546765a03d82726dee846566a39b"

URI_aarch64_rust-schemars+bytes1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+bytes1-devel-1.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-schemars+bytes1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+bytes1-devel}"
SRC_URI[aarch64_rust-schemars+bytes1-devel.sha256sum] = "8693fba6fb0b4aa6df8fddea5da8daef85dcaf303b95508d08238ccb015f8a93"

URI_aarch64_rust-schemars+chrono04-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+chrono04-devel-1.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-schemars+chrono04-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+chrono04-devel}"
SRC_URI[aarch64_rust-schemars+chrono04-devel.sha256sum] = "55bf8d7630d0045d920e752f71425a5496699a446c68f07df6fc1120d8409ba5"

URI_aarch64_rust-schemars+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+default-devel-1.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-schemars+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+default-devel}"
SRC_URI[aarch64_rust-schemars+default-devel.sha256sum] = "2b69bb2f514a977e6026baa2cfcc51fc6a0e63d88f4c00215097c5a158c70807"

URI_aarch64_rust-schemars+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+derive-devel-1.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-schemars+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+derive-devel}"
SRC_URI[aarch64_rust-schemars+derive-devel.sha256sum] = "6b0d03c813d11369a50611a74abafcf1a23f10cb33d0443fd6630f95a295e37d"

URI_aarch64_rust-schemars+either1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+either1-devel-1.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-schemars+either1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+either1-devel}"
SRC_URI[aarch64_rust-schemars+either1-devel.sha256sum] = "0068401938af3b4d90cfe0e100db509f5a80a80730c7ef76075d69cd3f9f05dd"

URI_aarch64_rust-schemars+indexmap2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+indexmap2-devel-1.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-schemars+indexmap2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+indexmap2-devel}"
SRC_URI[aarch64_rust-schemars+indexmap2-devel.sha256sum] = "dca52ef249461c69ee13d3b183a172788e5239e3f14d9cca9abc5c8af8e44f32"

URI_aarch64_rust-schemars+jiff02-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+jiff02-devel-1.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-schemars+jiff02-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+jiff02-devel}"
SRC_URI[aarch64_rust-schemars+jiff02-devel.sha256sum] = "72753b5a587be5350720f9353fcba1afccd74338547b0b745145740bd70a8e8e"

URI_aarch64_rust-schemars+preserve_order-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+preserve_order-devel-1.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-schemars+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+preserve_order-devel}"
SRC_URI[aarch64_rust-schemars+preserve_order-devel.sha256sum] = "3ccbfcab00603ecd33f08aa2927bd432463c956b11688a11321c2663c538e42a"

URI_aarch64_rust-schemars+raw_value-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+raw_value-devel-1.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-schemars+raw_value-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+raw_value-devel}"
SRC_URI[aarch64_rust-schemars+raw_value-devel.sha256sum] = "25f76890b3fd769fff81becd43fced79e953b1d27ead854f4c4645e374a51fc9"

URI_aarch64_rust-schemars+rust_decimal1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+rust_decimal1-devel-1.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-schemars+rust_decimal1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+rust_decimal1-devel}"
SRC_URI[aarch64_rust-schemars+rust_decimal1-devel.sha256sum] = "833ea06d6b51d43bb58d57863036c3bf0e812a77fd9f7521b60139ea2ce80018"

URI_aarch64_rust-schemars+schemars_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+schemars_derive-devel-1.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-schemars+schemars_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+schemars_derive-devel}"
SRC_URI[aarch64_rust-schemars+schemars_derive-devel.sha256sum] = "a813167883b879304f97df2a5c58dc1fe8dcb9eb9f17d69ec84f73913dc6e151"

URI_aarch64_rust-schemars+semver1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+semver1-devel-1.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-schemars+semver1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+semver1-devel}"
SRC_URI[aarch64_rust-schemars+semver1-devel.sha256sum] = "0ca0573642be0214541aacdbc1f59f6e853df1da9b04e987835d34784820c68f"

URI_aarch64_rust-schemars+smallvec1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+smallvec1-devel-1.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-schemars+smallvec1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+smallvec1-devel}"
SRC_URI[aarch64_rust-schemars+smallvec1-devel.sha256sum] = "34c43a752027610d22e204a72bd4031e9f4862d06115cbf240cf1f3e0f44088b"

URI_aarch64_rust-schemars+smol_str02-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+smol_str02-devel-1.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-schemars+smol_str02-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+smol_str02-devel}"
SRC_URI[aarch64_rust-schemars+smol_str02-devel.sha256sum] = "e803f3962690853a10197bb2e4bf3adbf8b5c9e8e3f90c922a6d6a0777de5e9f"

URI_aarch64_rust-schemars+smol_str03-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+smol_str03-devel-1.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-schemars+smol_str03-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+smol_str03-devel}"
SRC_URI[aarch64_rust-schemars+smol_str03-devel.sha256sum] = "e534eb1092f3615ea928d36e9bea1cc42df97ec4827a5adb76f327523d6e3333"

URI_aarch64_rust-schemars+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+std-devel-1.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-schemars+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+std-devel}"
SRC_URI[aarch64_rust-schemars+std-devel.sha256sum] = "fdde652941a96968b6f0325d3434b4a9612bf7b0fb30ac89ff76f547257971e4"

URI_aarch64_rust-schemars+url2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+url2-devel-1.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-schemars+url2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+url2-devel}"
SRC_URI[aarch64_rust-schemars+url2-devel.sha256sum] = "0284174b618c8a80090f9a809e65c7ba2fd6e87abca7ec1df28e9eea58f89c56"

URI_aarch64_rust-schemars+uuid1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+uuid1-devel-1.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-schemars+uuid1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+uuid1-devel}"
SRC_URI[aarch64_rust-schemars+uuid1-devel.sha256sum] = "dcf827ad65d4b4113eca9b93a368e725a06ebf8ee9b3b20f2a3df4e2aeb778be"

URI_aarch64_rust-schemars-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars-devel-1.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-schemars-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars-devel}"
SRC_URI[aarch64_rust-schemars-devel.sha256sum] = "23122fd2cdb3944cf454c3f341565282091d499abf368b5f03a5a0fff3b985c5"

RDEPENDS:rust-schemars+arrayvec07-devel = " \
 cargo \
 rust-arrayvec-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+bigdecimal04-devel = " \
 cargo \
 rust-bigdecimal-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+bytes1-devel = " \
 cargo \
 rust-bytes-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+chrono04-devel = " \
 cargo \
 rust-chrono-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+default-devel = " \
 cargo \
 rust-schemars+derive-devel \
 rust-schemars+std-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+derive-devel = " \
 cargo \
 rust-schemars+schemars_derive-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+either1-devel = " \
 cargo \
 rust-either-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+indexmap2-devel = " \
 cargo \
 rust-indexmap-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+jiff02-devel = " \
 cargo \
 rust-jiff-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+preserve_order-devel = " \
 cargo \
 rust-schemars-devel \
 rust-serde_json+preserve_order-devel \
 "
RDEPENDS:rust-schemars+raw_value-devel = " \
 cargo \
 rust-schemars-devel \
 rust-serde_json+raw_value-devel \
 "
RDEPENDS:rust-schemars+rust_decimal1-devel = " \
 cargo \
 rust-rust_decimal-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+schemars_derive-devel = " \
 cargo \
 rust-schemars-devel \
 rust-schemars_derive+default-devel \
 "
RDEPENDS:rust-schemars+semver1-devel = " \
 cargo \
 rust-schemars-devel \
 rust-semver-devel \
 "
RDEPENDS:rust-schemars+smallvec1-devel = " \
 cargo \
 rust-schemars-devel \
 rust-smallvec-devel \
 "
RDEPENDS:rust-schemars+smol_str02-devel = " \
 cargo \
 rust-schemars-devel \
 rust-smol_str0.2-devel \
 "
RDEPENDS:rust-schemars+smol_str03-devel = " \
 cargo \
 rust-schemars-devel \
 rust-smol_str-devel \
 "
RDEPENDS:rust-schemars+std-devel = " \
 cargo \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+url2-devel = " \
 cargo \
 rust-schemars-devel \
 rust-url-devel \
 "
RDEPENDS:rust-schemars+uuid1-devel = " \
 cargo \
 rust-schemars-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-schemars-devel = " \
 cargo \
 rust \
 rust-dyn-clone+default-devel \
 rust-ref-cast+default-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 rust-serde_json+alloc-devel \
 rust-serde_json-devel \
 "
