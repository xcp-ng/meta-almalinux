# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libarchive"
PV = "3.7.7"
PR = "10.el10_2"
PACKAGES = " \
 bsdtar \
 libarchive \
 libarchive-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libarchive-3.7.7-10.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f2107fb52a914107c612dde1f1107e910335389b100420f3831ed1ee363c750"

URI_x86_64_v2_bsdtar = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bsdtar-3.7.7-10.el10_2.x86_64_v2.rpm;name=x86_64_v2_bsdtar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bsdtar}"
SRC_URI[x86_64_v2_bsdtar.sha256sum] = "421ba2efeea4cd6068924e0fa3ede5c64df5e2a288b8146ad5f2c92079c421dd"

URI_x86_64_v2_libarchive = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libarchive-3.7.7-10.el10_2.x86_64_v2.rpm;name=x86_64_v2_libarchive;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarchive}"
SRC_URI[x86_64_v2_libarchive.sha256sum] = "087cd264b4545cabaed347bfe14e22370d67638caeb62ab563279f9973f245b2"

URI_x86_64_v2_libarchive-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libarchive-devel-3.7.7-10.el10_2.x86_64_v2.rpm;name=x86_64_v2_libarchive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarchive-devel}"
SRC_URI[x86_64_v2_libarchive-devel.sha256sum] = "125d8c50877261464195cc9f281b0e257993d7134ed30fb9062803fd0fd8462a"

URI_aarch64_bsdtar = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bsdtar-3.7.7-10.el10_2.aarch64.rpm;name=aarch64_bsdtar;unpack=0"
SRC_URI:append = " ${URI_aarch64_bsdtar}"
SRC_URI[aarch64_bsdtar.sha256sum] = "03134a893bb12ff67d35bcc244acfa7bede6422d2a488bfc6a86b01047472a7b"

URI_aarch64_libarchive = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libarchive-3.7.7-10.el10_2.aarch64.rpm;name=aarch64_libarchive;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarchive}"
SRC_URI[aarch64_libarchive.sha256sum] = "ba78d14a63e517b027b8dd7c911b4cfdfcaa742bd997d1479997df82d7e71574"

URI_aarch64_libarchive-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libarchive-devel-3.7.7-10.el10_2.aarch64.rpm;name=aarch64_libarchive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarchive-devel}"
SRC_URI[aarch64_libarchive-devel.sha256sum] = "90e87d9fff51859b1fbdf9fae6bbd0eaee4704a79426ba1be43177381a456f4c"

RDEPENDS:bsdtar = " \
 glibc \
 libarchive \
 "
RDEPENDS:libarchive = " \
 bzip2-libs \
 glibc \
 libacl \
 libxml2 \
 libzstd \
 lz4-libs \
 openssl-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:libarchive-devel = " \
 libarchive \
 openssl-devel \
 pkgconf-pkg-config \
 "
