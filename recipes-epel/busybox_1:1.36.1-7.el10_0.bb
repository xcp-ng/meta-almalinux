# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "busybox"
PE = "1"
PV = "1.36.1"
PR = "7.el10_0"
PACKAGES = " \
 busybox \
 busybox-petitboot \
 busybox-shared \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/busybox-1.36.1-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d501655f16a64bd160749676994f34d5319dd8e7eb44cf129c5e139a1b33b2e1"

URI_x86_64_v2_busybox = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/busybox-1.36.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_busybox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_busybox}"
SRC_URI[x86_64_v2_busybox.sha256sum] = "07f0df683f98cdbf9c034aedc34c3cabf592203a080ff1424460d97e6040385f"

URI_x86_64_v2_busybox-petitboot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/busybox-petitboot-1.36.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_busybox-petitboot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_busybox-petitboot}"
SRC_URI[x86_64_v2_busybox-petitboot.sha256sum] = "fa064b38cca2ac3c42d5501738b0edef03b395135206d70e31641ed10177566f"

URI_x86_64_v2_busybox-shared = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/busybox-shared-1.36.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_busybox-shared;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_busybox-shared}"
SRC_URI[x86_64_v2_busybox-shared.sha256sum] = "09345f3c498aa9111655923383ee75d610258ef2f0762d9513c2f597d9486adf"

URI_aarch64_busybox = "${EPEL_MIRROR}/aarch64/Packages/b/busybox-1.36.1-7.el10_0.aarch64.rpm;name=aarch64_busybox;unpack=0"
SRC_URI:append = " ${URI_aarch64_busybox}"
SRC_URI[aarch64_busybox.sha256sum] = "dc3416014105ab33f1d7b6154d0680df8b6346bb8330cf604ef671544cad8489"

URI_aarch64_busybox-petitboot = "${EPEL_MIRROR}/aarch64/Packages/b/busybox-petitboot-1.36.1-7.el10_0.aarch64.rpm;name=aarch64_busybox-petitboot;unpack=0"
SRC_URI:append = " ${URI_aarch64_busybox-petitboot}"
SRC_URI[aarch64_busybox-petitboot.sha256sum] = "49d570c7e16d4b5ce3343052d2554cd9e72648acb91e0b352df9c779f7c2a2eb"

URI_aarch64_busybox-shared = "${EPEL_MIRROR}/aarch64/Packages/b/busybox-shared-1.36.1-7.el10_0.aarch64.rpm;name=aarch64_busybox-shared;unpack=0"
SRC_URI:append = " ${URI_aarch64_busybox-shared}"
SRC_URI[aarch64_busybox-shared.sha256sum] = "b2e6a34b0dbc16b503cfc33b2d342d5dede4c1e97cd4e158755aca580827e7fd"

RDEPENDS:busybox = " \
 glibc \
 "
RDEPENDS:busybox-petitboot = " \
 glibc \
 "
RDEPENDS:busybox-shared = " \
 glibc \
 "
