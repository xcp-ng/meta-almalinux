# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Perl-Critic-Lax"
PV = "0.014"
PR = "1.el10_0"
PACKAGES = " \
 perl-Perl-Critic-Lax \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Perl-Critic-Lax-0.014-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "57f4f6b17eb2783202603b5982ed589b58a6a5aa9a9716d96204d53be1d7ef80"

URI_x86_64_v2_perl-Perl-Critic-Lax = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Perl-Critic-Lax-0.014-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Perl-Critic-Lax;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Perl-Critic-Lax}"
SRC_URI[x86_64_v2_perl-Perl-Critic-Lax.sha256sum] = "e0f4585d442778e74421a202a6d50601cfded7c83e8fff97216a1c33172f34db"

URI_aarch64_perl-Perl-Critic-Lax = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Perl-Critic-Lax-0.014-1.el10_0.noarch.rpm;name=aarch64_perl-Perl-Critic-Lax;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Perl-Critic-Lax}"
SRC_URI[aarch64_perl-Perl-Critic-Lax.sha256sum] = "64a2c29e82852d1803dab082ac9565ae121183d7ce216db9d57d07b70c0fb49f"

RDEPENDS:perl-Perl-Critic-Lax = " \
 perl-Perl-Critic \
 perl-Readonly \
 perl-libs \
 perl-parent \
 "
