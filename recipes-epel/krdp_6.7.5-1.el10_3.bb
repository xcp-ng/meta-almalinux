# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "krdp"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 krdp \
 krdp-devel \
 krdp-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/krdp-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1612947509ad056ff4abf53769ff39156dd8853e08a245ffb43e50d6762491e8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krdp-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krdp;unpack=0"
SRC_URI[x86_64_v2_krdp.sha256sum] = "3b4bdf560ff8a27c3e7b7c2999f05ddd16f1189a1fe24da467e5e2119d08e4fc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krdp-devel-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krdp-devel;unpack=0"
SRC_URI[x86_64_v2_krdp-devel.sha256sum] = "d499b6056ec8ee2a66cd7b721b57c43d62590275955e1933801c5354cb9ec63c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krdp-libs-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krdp-libs;unpack=0"
SRC_URI[x86_64_v2_krdp-libs.sha256sum] = "42125a9c078efa6e350ce70bf7972aded40e97345e1145a08480a1a1e0f410d9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/krdp-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_krdp;unpack=0"
SRC_URI[aarch64_krdp.sha256sum] = "bc9b0e269553e792fe9edeff82d7a731c1a5ad11d749a1616459529924bdc7a3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/krdp-devel-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_krdp-devel;unpack=0"
SRC_URI[aarch64_krdp-devel.sha256sum] = "b1766527cd2ac5dc24663baf60674bc8c2adda4316229f88471b7d6948699884"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/krdp-libs-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_krdp-libs;unpack=0"
SRC_URI[aarch64_krdp-libs.sha256sum] = "29cba52d719897dfc1304530294d16295aa3b0979aed857a6e52d61a4cd845b2"

RDEPENDS:krdp = " \
 bash \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kirigami-addons \
 kf6-kstatusnotifieritem \
 kpipewire \
 krdp-libs \
 libstdc++ \
 openssl \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
RDEPENDS:krdp-devel = " \
 cmake-filesystem \
 krdp-libs \
 "
RDEPENDS:krdp-libs = " \
 freerdp \
 freerdp-libs \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kpipewire \
 libstdc++ \
 libwayland-client \
 libwinpr \
 libxkbcommon \
 pam-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
