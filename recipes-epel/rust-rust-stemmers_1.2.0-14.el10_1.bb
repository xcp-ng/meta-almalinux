# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rust-stemmers"
PV = "1.2.0"
PR = "14.el10_1"
PACKAGES = " \
 rust-rust-stemmers+default-devel \
 rust-rust-stemmers-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-rust-stemmers-1.2.0-14.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2bf2890e624727acd2ae620168464a0e447fb87da9397b6a0d31e804ef053f2a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-stemmers+default-devel-1.2.0-14.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-stemmers+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rust-stemmers+default-devel.sha256sum] = "5c2b5ca41b26ccf6ff72153c603dea42e23927cd1c0346b959bb1d9bc238d7da"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-stemmers-devel-1.2.0-14.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-stemmers-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rust-stemmers-devel.sha256sum] = "73862696fe0bfd4627daca0cb949156d6d87759ed5795d4269d5ec2f20e4aad4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-stemmers+default-devel-1.2.0-14.el10_1.noarch.rpm;name=aarch64_rust-rust-stemmers+default-devel;unpack=0"
SRC_URI[aarch64_rust-rust-stemmers+default-devel.sha256sum] = "7e430802c4b9a840b590272dc1cdc7d54f7688eef7c4226daf6174cbd4cb373b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-stemmers-devel-1.2.0-14.el10_1.noarch.rpm;name=aarch64_rust-rust-stemmers-devel;unpack=0"
SRC_URI[aarch64_rust-rust-stemmers-devel.sha256sum] = "e170507d6f1d99f5da0e757ea2502d618596433cf77c60787513af0f4d165b8c"

RDEPENDS:rust-rust-stemmers+default-devel = " \
 cargo \
 rust-rust-stemmers-devel \
 "
RDEPENDS:rust-rust-stemmers-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 "
