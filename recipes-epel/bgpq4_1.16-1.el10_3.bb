# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bgpq4"
PV = "1.16"
PR = "1.el10_3"
PACKAGES = " \
 bgpq4 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bgpq4-1.16-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac21b554b3e54fb1a366ea53736343542d2a88002140a29304d5c77dba3734f6"

URI_x86_64_v2_bgpq4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bgpq4-1.16-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bgpq4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bgpq4}"
SRC_URI[x86_64_v2_bgpq4.sha256sum] = "2effff71fab8156590d82435ead47a854c4d6d65cad0239e1db3d65935953d0c"

URI_aarch64_bgpq4 = "${EPEL_MIRROR}/aarch64/Packages/b/bgpq4-1.16-1.el10_3.aarch64.rpm;name=aarch64_bgpq4;unpack=0"
SRC_URI:append = " ${URI_aarch64_bgpq4}"
SRC_URI[aarch64_bgpq4.sha256sum] = "0f92611a4814b1aa44b5542d1be1d09c9c9ba3b77b34765e7f9e927556c28b39"

RDEPENDS:bgpq4 = " \
 glibc \
 "
