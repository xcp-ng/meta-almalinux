# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mtr"
PE = "2"
PV = "0.95"
PR = "11.el10"
PACKAGES = " \
 mtr \
 mtr-gtk \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/mtr-0.95-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30403ccd794011db51cbb7f750a0e87feb877c959c6524e30080e0a8b730937f"

URI_x86_64_v2_mtr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mtr-0.95-11.el10.x86_64_v2.rpm;name=x86_64_v2_mtr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mtr}"
SRC_URI[x86_64_v2_mtr.sha256sum] = "b91779273e5d4f3701b16e87b04639697914b2cf75a589bc232ff3ffd816a6f8"

URI_x86_64_v2_mtr-gtk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mtr-gtk-0.95-11.el10.x86_64_v2.rpm;name=x86_64_v2_mtr-gtk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mtr-gtk}"
SRC_URI[x86_64_v2_mtr-gtk.sha256sum] = "14311f62d6c3d138d1f488c41bacce59c67630b9538bf2f96283c97429f6e065"

URI_aarch64_mtr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mtr-0.95-11.el10.aarch64.rpm;name=aarch64_mtr;unpack=0"
SRC_URI:append = " ${URI_aarch64_mtr}"
SRC_URI[aarch64_mtr.sha256sum] = "9e8e9568be027ee00abf87132c03a60b0e7ba027edfff7934ee5f5fec6b31a0e"

URI_aarch64_mtr-gtk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mtr-gtk-0.95-11.el10.aarch64.rpm;name=aarch64_mtr-gtk;unpack=0"
SRC_URI:append = " ${URI_aarch64_mtr-gtk}"
SRC_URI[aarch64_mtr-gtk.sha256sum] = "7e8da08e0d893a695a220cc472167416c6972a13c6adfdfe081f13069fd9c204"

RDEPENDS:mtr = " \
 glibc \
 jansson \
 ncurses-libs \
 "
RDEPENDS:mtr-gtk = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 jansson \
 mtr \
 ncurses-libs \
 "
