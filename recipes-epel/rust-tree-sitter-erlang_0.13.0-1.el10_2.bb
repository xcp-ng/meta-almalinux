# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-erlang"
PV = "0.13.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-tree-sitter-erlang+default-devel \
 rust-tree-sitter-erlang-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-erlang-0.13.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1aa97de18ea849436092230bf0821d98566f1eac320ee464845b5cb982d24d10"

URI_x86_64_v2_rust-tree-sitter-erlang+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-erlang+default-devel-0.13.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-erlang+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-erlang+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-erlang+default-devel.sha256sum] = "c3e2a0a5445a6eb700920a0b495213ace137cf1c522f21ee9f28ea027f7a9faa"

URI_x86_64_v2_rust-tree-sitter-erlang-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-erlang-devel-0.13.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-erlang-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-erlang-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-erlang-devel.sha256sum] = "c44b40e7f062d3e4ca82ae5147605f156f1e306d1e4a67874c93b51d22d0ceb7"

URI_aarch64_rust-tree-sitter-erlang+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-erlang+default-devel-0.13.0-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-erlang+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-erlang+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-erlang+default-devel.sha256sum] = "a4863ac5b3159d02e91cb3285fa857d20874ea101c55bc3e85ba5ff26f69ec58"

URI_aarch64_rust-tree-sitter-erlang-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-erlang-devel-0.13.0-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-erlang-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-erlang-devel}"
SRC_URI[aarch64_rust-tree-sitter-erlang-devel.sha256sum] = "4ce041cde2687bb994435122955510b51aa353e090f237903b4f414acc5feed8"

RDEPENDS:rust-tree-sitter-erlang+default-devel = " \
 cargo \
 rust-tree-sitter-erlang-devel \
 "
RDEPENDS:rust-tree-sitter-erlang-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
