# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-clbanning-x2j"
PV = "1.1"
PR = "17.el10_0"
PACKAGES = " \
 golang-github-clbanning-x2j-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-clbanning-x2j-1.1-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "efa0dfe1cc4431e7073ce86dce3d19e532b28effc90479642767935dc3594f1e"

URI_x86_64_v2_golang-github-clbanning-x2j-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-clbanning-x2j-devel-1.1-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-clbanning-x2j-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-clbanning-x2j-devel}"
SRC_URI[x86_64_v2_golang-github-clbanning-x2j-devel.sha256sum] = "7833a75bcf3f5a510a14c79815f92d60ab301f303b5cb26a351ae739c43d2f3b"

URI_aarch64_golang-github-clbanning-x2j-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-clbanning-x2j-devel-1.1-17.el10_0.noarch.rpm;name=aarch64_golang-github-clbanning-x2j-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-clbanning-x2j-devel}"
SRC_URI[aarch64_golang-github-clbanning-x2j-devel.sha256sum] = "94a79faf3fc74d8775fea30eab5a8fc77712d549297c7fe47998af6e72ffba10"

RDEPENDS:golang-github-clbanning-x2j-devel = " \
 go-filesystem \
 "
