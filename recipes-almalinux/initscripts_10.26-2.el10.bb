# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "initscripts"
PV = "10.26"
PR = "2.el10"
PACKAGES = " \
 initscripts \
 initscripts-rename-device \
 initscripts-service \
 netconsole-service \
 readonly-root \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/initscripts-10.26-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bec074d4b671e245a10e4c6116d4e5b601c9f3130335092f81792dc4ddf582c0"

URI_x86_64_v2_initscripts = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/initscripts-10.26-2.el10.x86_64_v2.rpm;name=x86_64_v2_initscripts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_initscripts}"
SRC_URI[x86_64_v2_initscripts.sha256sum] = "bee6ba4dc36ccc650090ac38b51aaf0ed2fb0402d382b03a2b9eb1ada8a2a992"

URI_x86_64_v2_initscripts-rename-device = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/initscripts-rename-device-10.26-2.el10.x86_64_v2.rpm;name=x86_64_v2_initscripts-rename-device;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_initscripts-rename-device}"
SRC_URI[x86_64_v2_initscripts-rename-device.sha256sum] = "c2f11bdbf98600c2c632f5207901beae3716176431bc1b97f39eed648a541c59"

URI_x86_64_v2_initscripts-service = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/initscripts-service-10.26-2.el10.noarch.rpm;name=x86_64_v2_initscripts-service;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_initscripts-service}"
SRC_URI[x86_64_v2_initscripts-service.sha256sum] = "dcafa01802d9e327e49f56bf3c45aaa7209f9cb9b347ffcdbc5846d91b99d951"

URI_x86_64_v2_netconsole-service = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/netconsole-service-10.26-2.el10.noarch.rpm;name=x86_64_v2_netconsole-service;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netconsole-service}"
SRC_URI[x86_64_v2_netconsole-service.sha256sum] = "c20d99ff25ca13a8645843f5abddc8dc6ba6abd3aa9678befc805b3d2c434ec7"

URI_x86_64_v2_readonly-root = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/readonly-root-10.26-2.el10.noarch.rpm;name=x86_64_v2_readonly-root;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_readonly-root}"
SRC_URI[x86_64_v2_readonly-root.sha256sum] = "572c8b0da76d2b8a2b121556ab76e501e78663b2f40685c2a2f1c08d792c3271"

URI_aarch64_initscripts = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/initscripts-10.26-2.el10.aarch64.rpm;name=aarch64_initscripts;unpack=0"
SRC_URI:append = " ${URI_aarch64_initscripts}"
SRC_URI[aarch64_initscripts.sha256sum] = "2f1e08f90eb02118a9ae8669bc569f23df67d395f6db79edd3a8047b8a08d425"

URI_aarch64_initscripts-rename-device = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/initscripts-rename-device-10.26-2.el10.aarch64.rpm;name=aarch64_initscripts-rename-device;unpack=0"
SRC_URI:append = " ${URI_aarch64_initscripts-rename-device}"
SRC_URI[aarch64_initscripts-rename-device.sha256sum] = "ad75df0865dc4705fc8a65581fab0850741526cb9f66b24f5072408681eea12e"

URI_aarch64_initscripts-service = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/initscripts-service-10.26-2.el10.noarch.rpm;name=aarch64_initscripts-service;unpack=0"
SRC_URI:append = " ${URI_aarch64_initscripts-service}"
SRC_URI[aarch64_initscripts-service.sha256sum] = "dcafa01802d9e327e49f56bf3c45aaa7209f9cb9b347ffcdbc5846d91b99d951"

URI_aarch64_netconsole-service = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/netconsole-service-10.26-2.el10.noarch.rpm;name=aarch64_netconsole-service;unpack=0"
SRC_URI:append = " ${URI_aarch64_netconsole-service}"
SRC_URI[aarch64_netconsole-service.sha256sum] = "c20d99ff25ca13a8645843f5abddc8dc6ba6abd3aa9678befc805b3d2c434ec7"

URI_aarch64_readonly-root = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/readonly-root-10.26-2.el10.noarch.rpm;name=aarch64_readonly-root;unpack=0"
SRC_URI:append = " ${URI_aarch64_readonly-root}"
SRC_URI[aarch64_readonly-root.sha256sum] = "572c8b0da76d2b8a2b121556ab76e501e78663b2f40685c2a2f1c08d792c3271"

RDEPENDS:initscripts = " \
 bash \
 chkconfig \
 filesystem \
 findutils \
 gawk \
 glibc \
 grep \
 initscripts-rename-device \
 initscripts-service \
 popt \
 procps-ng \
 setup \
 shadow-utils \
 systemd \
 util-linux \
 virtual/coreutils \
 "
RDEPENDS:initscripts-rename-device = " \
 bash \
 filesystem \
 gawk \
 glib2 \
 glibc \
 virtual/coreutils \
 "
RDEPENDS:initscripts-service = " \
 bash \
 filesystem \
 gawk \
 systemd \
 virtual/coreutils \
 "
RDEPENDS:netconsole-service = " \
 bash \
 filesystem \
 gawk \
 glibc-common \
 initscripts \
 iproute \
 iputils \
 kmod \
 sed \
 util-linux \
 virtual/coreutils \
 "
RDEPENDS:readonly-root = " \
 bash \
 cpio \
 filesystem \
 findutils \
 gawk \
 hostname \
 initscripts \
 ipcalc \
 iproute \
 util-linux \
 virtual/coreutils \
 "
