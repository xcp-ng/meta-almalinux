# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libnotify"
PV = "0.8.3"
PR = "6.el10"
PACKAGES = " \
 libnotify \
 libnotify-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libnotify-0.8.3-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2da670eb275b73cf008e553996ff09fe3e044ba4a58af49819207d5c0fe6fade"

URI_x86_64_v2_libnotify = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libnotify-0.8.3-6.el10.x86_64_v2.rpm;name=x86_64_v2_libnotify;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnotify}"
SRC_URI[x86_64_v2_libnotify.sha256sum] = "a955d4f63e809b63e2bb2553afd6e929f25f549b212df0bcb8c5867f9220ebfb"

URI_x86_64_v2_libnotify-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libnotify-devel-0.8.3-6.el10.x86_64_v2.rpm;name=x86_64_v2_libnotify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnotify-devel}"
SRC_URI[x86_64_v2_libnotify-devel.sha256sum] = "dc213d6e207324cbc7be40fb371873483f0ef04ca0476cf47b349496db8eebe1"

URI_aarch64_libnotify = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libnotify-0.8.3-6.el10.aarch64.rpm;name=aarch64_libnotify;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnotify}"
SRC_URI[aarch64_libnotify.sha256sum] = "2349e6475cd14fb115a46a053a3f39f1718a582f0735d8a25debb5fae0184e79"

URI_aarch64_libnotify-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libnotify-devel-0.8.3-6.el10.aarch64.rpm;name=aarch64_libnotify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnotify-devel}"
SRC_URI[aarch64_libnotify-devel.sha256sum] = "e32c1e019ebbdc4d779dcf3cf443e31217b0ddddd813eeaa58bf31c8d0f0de47"

RDEPENDS:libnotify = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 "
RDEPENDS:libnotify-devel = " \
 gdk-pixbuf2-devel \
 glib2-devel \
 libnotify \
 pkgconf-pkg-config \
 "
