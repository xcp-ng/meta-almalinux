# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xfig"
PV = "3.2.9a"
PR = "3.20250317gitce9782a.el10_3"
PACKAGES = " \
 xfig \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xfig-3.2.9a-3.20250317gitce9782a.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5db56e730a141720ae63cbadbc63f93f867ec74cecbd7a7c6189eb2909e4ed9a"

URI_x86_64_v2_xfig = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xfig-3.2.9a-3.20250317gitce9782a.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xfig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xfig}"
SRC_URI[x86_64_v2_xfig.sha256sum] = "d165e38afb6a4a12c4f35ae6222d68bafa8c6c5038e172341858c5781afc55eb"

URI_aarch64_xfig = "${EPEL_MIRROR}/aarch64/Packages/x/xfig-3.2.9a-3.20250317gitce9782a.el10_3.aarch64.rpm;name=aarch64_xfig;unpack=0"
SRC_URI:append = " ${URI_aarch64_xfig}"
SRC_URI[aarch64_xfig.sha256sum] = "4d43621b7a08619ed9c8cba808058d1aa3eae7f9f0f03da30f5e84cbce70971f"

RDEPENDS:xfig = " \
 Xaw3d \
 fontconfig \
 ghostscript \
 glibc \
 libX11 \
 libXft \
 libXpm \
 libXt \
 libjpeg-turbo \
 libpng \
 libtiff \
 transfig \
 xorg-x11-fonts-misc \
 "
