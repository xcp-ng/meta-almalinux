# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "SDL2_mixer"
PV = "2.8.0"
PR = "2.el10_0"
PACKAGES = " \
 SDL2_mixer \
 SDL2_mixer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/SDL2_mixer-2.8.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6b19583ecb0b2d1fd581d45027ca7c32e15f0b0fccecd3883244b52a5eaebea"

URI_x86_64_v2_SDL2_mixer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SDL2_mixer-2.8.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_SDL2_mixer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SDL2_mixer}"
SRC_URI[x86_64_v2_SDL2_mixer.sha256sum] = "ed32e486d8d9b7bb6c1e99c2d61b8d2c8d2a23f8d40eaf21b5b11bbffbbb46ba"

URI_x86_64_v2_SDL2_mixer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SDL2_mixer-devel-2.8.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_SDL2_mixer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SDL2_mixer-devel}"
SRC_URI[x86_64_v2_SDL2_mixer-devel.sha256sum] = "5b4ae709cd0839e6b4151a77fd00097554dc803751a9323ae3f671d2ff5c708d"

URI_aarch64_SDL2_mixer = "${EPEL_MIRROR}/aarch64/Packages/s/SDL2_mixer-2.8.0-2.el10_0.aarch64.rpm;name=aarch64_SDL2_mixer;unpack=0"
SRC_URI:append = " ${URI_aarch64_SDL2_mixer}"
SRC_URI[aarch64_SDL2_mixer.sha256sum] = "5721a407a79cef736244589bc9c61ae370bcb49f16e863f5b828e37d4de36264"

URI_aarch64_SDL2_mixer-devel = "${EPEL_MIRROR}/aarch64/Packages/s/SDL2_mixer-devel-2.8.0-2.el10_0.aarch64.rpm;name=aarch64_SDL2_mixer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_SDL2_mixer-devel}"
SRC_URI[aarch64_SDL2_mixer-devel.sha256sum] = "004e0b2c0d7e2567cca932dc16e88bb8b27ca9ddc64c02ac4401aee52bf40c11"

RDEPENDS:SDL2_mixer = " \
 glibc \
 virtual/libSDL2-2.0.so.0___64bit_ \
 "
RDEPENDS:SDL2_mixer-devel = " \
 SDL2-devel \
 SDL2_mixer \
 pkgconf-pkg-config \
 "
