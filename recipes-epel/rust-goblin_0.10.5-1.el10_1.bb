# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-goblin"
PV = "0.10.5"
PR = "1.el10_1"
PACKAGES = " \
 rust-goblin+alloc-devel \
 rust-goblin+archive-devel \
 rust-goblin+default-devel \
 rust-goblin+elf32-devel \
 rust-goblin+elf64-devel \
 rust-goblin+endian_fd-devel \
 rust-goblin+log-devel \
 rust-goblin+mach32-devel \
 rust-goblin+mach64-devel \
 rust-goblin+pe32-devel \
 rust-goblin+pe64-devel \
 rust-goblin+std-devel \
 rust-goblin+te-devel \
 rust-goblin-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-goblin-0.10.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7bd26fabb320efac5f519499ebd94cd2a0d6e3e2ffbd7885a143ce831c412553"

URI_x86_64_v2_rust-goblin+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+alloc-devel-0.10.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+alloc-devel}"
SRC_URI[x86_64_v2_rust-goblin+alloc-devel.sha256sum] = "8e7b08106ccb10c82158f0a88ab2fae71bd5b5570a563f491e253775ba9f47b9"

URI_x86_64_v2_rust-goblin+archive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+archive-devel-0.10.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+archive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+archive-devel}"
SRC_URI[x86_64_v2_rust-goblin+archive-devel.sha256sum] = "c3e43a24442388f6eb8691990d5b291f7804c4fd45a734fbc2320285d43abb61"

URI_x86_64_v2_rust-goblin+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+default-devel-0.10.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+default-devel}"
SRC_URI[x86_64_v2_rust-goblin+default-devel.sha256sum] = "31b6ba35ff5f2f4fdf276855639892ee24d8bb1e1dc0be281368990975d70137"

URI_x86_64_v2_rust-goblin+elf32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+elf32-devel-0.10.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+elf32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+elf32-devel}"
SRC_URI[x86_64_v2_rust-goblin+elf32-devel.sha256sum] = "797d5d207af56c05dbc5144864af08019d304c7b022b8851c0b1fcbbb3fe2f3a"

URI_x86_64_v2_rust-goblin+elf64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+elf64-devel-0.10.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+elf64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+elf64-devel}"
SRC_URI[x86_64_v2_rust-goblin+elf64-devel.sha256sum] = "6cfd1c2ef03e6b260d7642fa2f10f28d7547a21db95d5e71693048cf85970261"

URI_x86_64_v2_rust-goblin+endian_fd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+endian_fd-devel-0.10.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+endian_fd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+endian_fd-devel}"
SRC_URI[x86_64_v2_rust-goblin+endian_fd-devel.sha256sum] = "ecc13c7580c5d6f25f643622ddd3c5c28b3602f6d36e68492f1dd2b6491bb073"

URI_x86_64_v2_rust-goblin+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+log-devel-0.10.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+log-devel}"
SRC_URI[x86_64_v2_rust-goblin+log-devel.sha256sum] = "a3701c5aa283d53b20ae36e2196003d3790606677438f6adf3adab5e80c67fbf"

URI_x86_64_v2_rust-goblin+mach32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+mach32-devel-0.10.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+mach32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+mach32-devel}"
SRC_URI[x86_64_v2_rust-goblin+mach32-devel.sha256sum] = "5b5926ff4cc098b8cad0e074bf4a04d9e94be9ab9ceb7631d4b01779ae7ee156"

URI_x86_64_v2_rust-goblin+mach64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+mach64-devel-0.10.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+mach64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+mach64-devel}"
SRC_URI[x86_64_v2_rust-goblin+mach64-devel.sha256sum] = "bc3427ae4acf1a392da2d30757f3302d235d471d3a6b7198d49175b22cacacd4"

URI_x86_64_v2_rust-goblin+pe32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+pe32-devel-0.10.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+pe32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+pe32-devel}"
SRC_URI[x86_64_v2_rust-goblin+pe32-devel.sha256sum] = "88d3be7a01217ed3626935fe72df4c035b42be5ab72635375c65d3fd544fdf66"

URI_x86_64_v2_rust-goblin+pe64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+pe64-devel-0.10.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+pe64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+pe64-devel}"
SRC_URI[x86_64_v2_rust-goblin+pe64-devel.sha256sum] = "7ee58c8163fc0cd2b85848162d34c34b0d78fb5a3500c823d47e458e99c9cf27"

URI_x86_64_v2_rust-goblin+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+std-devel-0.10.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+std-devel}"
SRC_URI[x86_64_v2_rust-goblin+std-devel.sha256sum] = "f60b23decb73a124e0b874adf4e11f49bcabc3bd9598856451b6ea70c039427f"

URI_x86_64_v2_rust-goblin+te-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+te-devel-0.10.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+te-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+te-devel}"
SRC_URI[x86_64_v2_rust-goblin+te-devel.sha256sum] = "80149b592f550f3d0da5cfd54458ed9b5ea1dddca91eb3a2a27e057356ddb06e"

URI_x86_64_v2_rust-goblin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin-devel-0.10.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin-devel}"
SRC_URI[x86_64_v2_rust-goblin-devel.sha256sum] = "622e04a65ad9dce12d1b5a16a9cd6680bf5f6aceebe0e12bff78eb7ebcfea632"

URI_aarch64_rust-goblin+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+alloc-devel-0.10.5-1.el10_1.noarch.rpm;name=aarch64_rust-goblin+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+alloc-devel}"
SRC_URI[aarch64_rust-goblin+alloc-devel.sha256sum] = "8324b78c52991db157199fda76d30e7b4fb5bb09a9f0c1ae04590f68b72b1fde"

URI_aarch64_rust-goblin+archive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+archive-devel-0.10.5-1.el10_1.noarch.rpm;name=aarch64_rust-goblin+archive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+archive-devel}"
SRC_URI[aarch64_rust-goblin+archive-devel.sha256sum] = "b25034cdaa3f0f0948b4eac0b44f44a8c673d5e80f92abbc275fd41598c43756"

URI_aarch64_rust-goblin+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+default-devel-0.10.5-1.el10_1.noarch.rpm;name=aarch64_rust-goblin+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+default-devel}"
SRC_URI[aarch64_rust-goblin+default-devel.sha256sum] = "dab00a00cf89fbe041794bf2afca993cb985ba0a1936c6f24d6ebf2c4670d720"

URI_aarch64_rust-goblin+elf32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+elf32-devel-0.10.5-1.el10_1.noarch.rpm;name=aarch64_rust-goblin+elf32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+elf32-devel}"
SRC_URI[aarch64_rust-goblin+elf32-devel.sha256sum] = "4d17b2142e90ffa8cac997a3eac413e1a145eb77ee9a18d5cd00ca055d68e739"

URI_aarch64_rust-goblin+elf64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+elf64-devel-0.10.5-1.el10_1.noarch.rpm;name=aarch64_rust-goblin+elf64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+elf64-devel}"
SRC_URI[aarch64_rust-goblin+elf64-devel.sha256sum] = "b7a52dd19c8d55fadccdce7af5ff54613d215d02102de6fe4397a7553edfb21d"

URI_aarch64_rust-goblin+endian_fd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+endian_fd-devel-0.10.5-1.el10_1.noarch.rpm;name=aarch64_rust-goblin+endian_fd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+endian_fd-devel}"
SRC_URI[aarch64_rust-goblin+endian_fd-devel.sha256sum] = "b72c29ae1678fa64487fc456fa2a470246762a54aa8f7c74a2ad09ad16936539"

URI_aarch64_rust-goblin+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+log-devel-0.10.5-1.el10_1.noarch.rpm;name=aarch64_rust-goblin+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+log-devel}"
SRC_URI[aarch64_rust-goblin+log-devel.sha256sum] = "21ba7a1d1cd3dacb54e80c1de0a61c51d383c4f142a8db8f19ae50433409dcd7"

URI_aarch64_rust-goblin+mach32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+mach32-devel-0.10.5-1.el10_1.noarch.rpm;name=aarch64_rust-goblin+mach32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+mach32-devel}"
SRC_URI[aarch64_rust-goblin+mach32-devel.sha256sum] = "4a4ec42dbd799806a304cdda34ce3fd533d333851cfaadd8e436b9f3c0f93372"

URI_aarch64_rust-goblin+mach64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+mach64-devel-0.10.5-1.el10_1.noarch.rpm;name=aarch64_rust-goblin+mach64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+mach64-devel}"
SRC_URI[aarch64_rust-goblin+mach64-devel.sha256sum] = "3d7588930ebaac4fc557fd470525ca2dd218b8ecb16fdf7e65ed05d4e681e2a5"

URI_aarch64_rust-goblin+pe32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+pe32-devel-0.10.5-1.el10_1.noarch.rpm;name=aarch64_rust-goblin+pe32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+pe32-devel}"
SRC_URI[aarch64_rust-goblin+pe32-devel.sha256sum] = "8ad8db99d9c159c105a3d3f77145dc2f26c30b438232c0d4b982ff02c3c80259"

URI_aarch64_rust-goblin+pe64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+pe64-devel-0.10.5-1.el10_1.noarch.rpm;name=aarch64_rust-goblin+pe64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+pe64-devel}"
SRC_URI[aarch64_rust-goblin+pe64-devel.sha256sum] = "3d8c510f182f59d2da803e002a69a99d36e3cedbbbff1ca186c1d2bcb0d7ff24"

URI_aarch64_rust-goblin+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+std-devel-0.10.5-1.el10_1.noarch.rpm;name=aarch64_rust-goblin+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+std-devel}"
SRC_URI[aarch64_rust-goblin+std-devel.sha256sum] = "45af7003bce9d88b33e7f12cffcaccb5efbdf4cb6de5252e0233815e6512bceb"

URI_aarch64_rust-goblin+te-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+te-devel-0.10.5-1.el10_1.noarch.rpm;name=aarch64_rust-goblin+te-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+te-devel}"
SRC_URI[aarch64_rust-goblin+te-devel.sha256sum] = "d0b217eabdcef4333bb23a0fa45016ecf5c4394caf9540501fbc0d3df52cefe3"

URI_aarch64_rust-goblin-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin-devel-0.10.5-1.el10_1.noarch.rpm;name=aarch64_rust-goblin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin-devel}"
SRC_URI[aarch64_rust-goblin-devel.sha256sum] = "5241583a6af696e7322ef9660d8319bfb6d11651fead3c2211d232224439153a"

RDEPENDS:rust-goblin+alloc-devel = " \
 cargo \
 rust-goblin+log-devel \
 rust-goblin-devel \
 rust-scroll+derive-devel \
 "
RDEPENDS:rust-goblin+archive-devel = " \
 cargo \
 rust-goblin+alloc-devel \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+default-devel = " \
 cargo \
 rust-goblin+archive-devel \
 rust-goblin+elf32-devel \
 rust-goblin+elf64-devel \
 rust-goblin+endian_fd-devel \
 rust-goblin+mach32-devel \
 rust-goblin+mach64-devel \
 rust-goblin+pe32-devel \
 rust-goblin+pe64-devel \
 rust-goblin+std-devel \
 rust-goblin+te-devel \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+elf32-devel = " \
 cargo \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+elf64-devel = " \
 cargo \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+endian_fd-devel = " \
 cargo \
 rust-goblin+alloc-devel \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+log-devel = " \
 cargo \
 rust-goblin-devel \
 rust-log-devel \
 "
RDEPENDS:rust-goblin+mach32-devel = " \
 cargo \
 rust-goblin+alloc-devel \
 rust-goblin+archive-devel \
 rust-goblin+endian_fd-devel \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+mach64-devel = " \
 cargo \
 rust-goblin+alloc-devel \
 rust-goblin+archive-devel \
 rust-goblin+endian_fd-devel \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+pe32-devel = " \
 cargo \
 rust-goblin+alloc-devel \
 rust-goblin+endian_fd-devel \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+pe64-devel = " \
 cargo \
 rust-goblin+alloc-devel \
 rust-goblin+endian_fd-devel \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+std-devel = " \
 cargo \
 rust-goblin+alloc-devel \
 rust-goblin-devel \
 rust-scroll+std-devel \
 "
RDEPENDS:rust-goblin+te-devel = " \
 cargo \
 rust-goblin+alloc-devel \
 rust-goblin+endian_fd-devel \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin-devel = " \
 cargo \
 rust \
 rust-plain+default-devel \
 rust-scroll-devel \
 "
