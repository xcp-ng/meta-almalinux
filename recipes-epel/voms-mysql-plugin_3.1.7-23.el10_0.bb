# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "voms-mysql-plugin"
PV = "3.1.7"
PR = "23.el10_0"
PACKAGES = " \
 voms-mysql-plugin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/voms-mysql-plugin-3.1.7-23.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "488385d40408756b52b19e926e004f1208908985722394a9e1a27f9e48b938c6"

URI_x86_64_v2_voms-mysql-plugin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/voms-mysql-plugin-3.1.7-23.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_voms-mysql-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_voms-mysql-plugin}"
SRC_URI[x86_64_v2_voms-mysql-plugin.sha256sum] = "5b22a0b19b2d4d56d29bb232e7bbea3e3aace6dfd5c741222234c6a5f1482098"

URI_aarch64_voms-mysql-plugin = "${EPEL_MIRROR}/aarch64/Packages/v/voms-mysql-plugin-3.1.7-23.el10_0.aarch64.rpm;name=aarch64_voms-mysql-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_voms-mysql-plugin}"
SRC_URI[aarch64_voms-mysql-plugin.sha256sum] = "9ab496a71093ad0da222858d4dd92ab7830a9e8568890f0c198b68ba134ce3b2"

RDEPENDS:voms-mysql-plugin = " \
 glibc \
 libgcc \
 libstdc++ \
 mariadb-connector-c \
 openssl-libs \
 voms-server \
 "
