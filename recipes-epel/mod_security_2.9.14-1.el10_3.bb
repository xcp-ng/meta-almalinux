# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mod_security"
PV = "2.9.14"
PR = "1.el10_3"
PACKAGES = " \
 mod_security \
 mod_security-mlogc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mod_security-2.9.14-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "18225bc2567dec8275ee1f943e5646077fd591476e8311f9ca6524eb7e1e0edc"

URI_x86_64_v2_mod_security = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mod_security-2.9.14-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mod_security;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_security}"
SRC_URI[x86_64_v2_mod_security.sha256sum] = "50f9af6946b1d39948deb92d741c8365d538b70c9d1304bed9a3bab5d0d63953"

URI_x86_64_v2_mod_security-mlogc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mod_security-mlogc-2.9.14-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mod_security-mlogc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_security-mlogc}"
SRC_URI[x86_64_v2_mod_security-mlogc.sha256sum] = "5dc7dbae950c42d8e60994ce551d9ee4bd6b546d56cf41f04f58d90f9d0d90af"

URI_aarch64_mod_security = "${EPEL_MIRROR}/aarch64/Packages/m/mod_security-2.9.14-1.el10_3.aarch64.rpm;name=aarch64_mod_security;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_security}"
SRC_URI[aarch64_mod_security.sha256sum] = "4e546045c56b49f40ea2d79502929987c6644ab07750b4cffdbe492541680450"

URI_aarch64_mod_security-mlogc = "${EPEL_MIRROR}/aarch64/Packages/m/mod_security-mlogc-2.9.14-1.el10_3.aarch64.rpm;name=aarch64_mod_security-mlogc;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_security-mlogc}"
SRC_URI[aarch64_mod_security-mlogc.sha256sum] = "2a5cacd02f5039964fc3a102375a77f71b0357660fc3670a9e352a74b0006494"

RDEPENDS:mod_security = " \
 apr \
 apr-util \
 expat \
 glibc \
 httpd \
 httpd-core \
 httpd-filesystem \
 libxcrypt \
 libxml2 \
 lua-libs \
 pcre2 \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:mod_security-mlogc = " \
 apr \
 glibc \
 httpd-filesystem \
 mod_security \
 pcre2 \
 perl-Digest-MD5 \
 perl-File-Find \
 perl-PathTools \
 perl-Sys-Hostname \
 perl-interpreter \
 perl-libs \
 virtual/libcurl.so.4___64bit_ \
 "
