# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-potential_utf"
PV = "0.1.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-potential_utf+alloc-devel \
 rust-potential_utf+databake-devel \
 rust-potential_utf+default-devel \
 rust-potential_utf+serde-devel \
 rust-potential_utf+writeable-devel \
 rust-potential_utf+zerovec-devel \
 rust-potential_utf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-potential_utf-0.1.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "244ca20f33b9cfbb293baa2a43aca1dc54a35010e5fd0938bc6764a08709b783"

URI_x86_64_v2_rust-potential_utf+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-potential_utf+alloc-devel-0.1.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-potential_utf+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-potential_utf+alloc-devel}"
SRC_URI[x86_64_v2_rust-potential_utf+alloc-devel.sha256sum] = "3e2884bafea056d075ee86b8fdcbb0e5e09f2856644141ec8c06aa16b849facd"

URI_x86_64_v2_rust-potential_utf+databake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-potential_utf+databake-devel-0.1.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-potential_utf+databake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-potential_utf+databake-devel}"
SRC_URI[x86_64_v2_rust-potential_utf+databake-devel.sha256sum] = "0ff2f61d70719a9e73b6938279d3916ebce2376407bd0b9246496229fb18b4ed"

URI_x86_64_v2_rust-potential_utf+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-potential_utf+default-devel-0.1.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-potential_utf+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-potential_utf+default-devel}"
SRC_URI[x86_64_v2_rust-potential_utf+default-devel.sha256sum] = "27c929651ea51e4ae2eb4eb503b3edb80949454494de0a435a5b048231b6e457"

URI_x86_64_v2_rust-potential_utf+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-potential_utf+serde-devel-0.1.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-potential_utf+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-potential_utf+serde-devel}"
SRC_URI[x86_64_v2_rust-potential_utf+serde-devel.sha256sum] = "3d07009093155e38b9582a6b4669ae8639ba85ab313868c91879d0da77331ce6"

URI_x86_64_v2_rust-potential_utf+writeable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-potential_utf+writeable-devel-0.1.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-potential_utf+writeable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-potential_utf+writeable-devel}"
SRC_URI[x86_64_v2_rust-potential_utf+writeable-devel.sha256sum] = "b1f03faed95a1f8c6529796ddbc9352d6c249a888873910af641763cad0aa34e"

URI_x86_64_v2_rust-potential_utf+zerovec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-potential_utf+zerovec-devel-0.1.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-potential_utf+zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-potential_utf+zerovec-devel}"
SRC_URI[x86_64_v2_rust-potential_utf+zerovec-devel.sha256sum] = "cb92ab6ae023c1af1f744781c860b0d01cee76982ecc6558f570b6aea5ac598a"

URI_x86_64_v2_rust-potential_utf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-potential_utf-devel-0.1.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-potential_utf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-potential_utf-devel}"
SRC_URI[x86_64_v2_rust-potential_utf-devel.sha256sum] = "17d1f00bbf06b501284a7567e903db04fd25bc3e438ea2c2f49106a78828d9cf"

URI_aarch64_rust-potential_utf+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-potential_utf+alloc-devel-0.1.4-1.el10_1.noarch.rpm;name=aarch64_rust-potential_utf+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-potential_utf+alloc-devel}"
SRC_URI[aarch64_rust-potential_utf+alloc-devel.sha256sum] = "d2aac3bcbca6d5d02953dd70ba4723ecbd0fd2f8461ccbd8c5a2e9c44f77542b"

URI_aarch64_rust-potential_utf+databake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-potential_utf+databake-devel-0.1.4-1.el10_1.noarch.rpm;name=aarch64_rust-potential_utf+databake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-potential_utf+databake-devel}"
SRC_URI[aarch64_rust-potential_utf+databake-devel.sha256sum] = "6ab15f2b24579665bfcb29b7327b14bbefb3eb9b8fffe76e55496c2fc2c1ed86"

URI_aarch64_rust-potential_utf+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-potential_utf+default-devel-0.1.4-1.el10_1.noarch.rpm;name=aarch64_rust-potential_utf+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-potential_utf+default-devel}"
SRC_URI[aarch64_rust-potential_utf+default-devel.sha256sum] = "eaa74e78001688e8af15e639fd4c5ba70d2f350e9e13e27225929a40f4e7acb2"

URI_aarch64_rust-potential_utf+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-potential_utf+serde-devel-0.1.4-1.el10_1.noarch.rpm;name=aarch64_rust-potential_utf+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-potential_utf+serde-devel}"
SRC_URI[aarch64_rust-potential_utf+serde-devel.sha256sum] = "cdc2af17442bcdaa915c770685dc4927d976a84f62fc1cdda3fe0d1c6c2a81a7"

URI_aarch64_rust-potential_utf+writeable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-potential_utf+writeable-devel-0.1.4-1.el10_1.noarch.rpm;name=aarch64_rust-potential_utf+writeable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-potential_utf+writeable-devel}"
SRC_URI[aarch64_rust-potential_utf+writeable-devel.sha256sum] = "9d860fa3b2e8f96e73cf0a8a90609051e2a7d4d3d8276bbbe2f6ff04f4cd6bca"

URI_aarch64_rust-potential_utf+zerovec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-potential_utf+zerovec-devel-0.1.4-1.el10_1.noarch.rpm;name=aarch64_rust-potential_utf+zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-potential_utf+zerovec-devel}"
SRC_URI[aarch64_rust-potential_utf+zerovec-devel.sha256sum] = "001dcb93923499e7deaa09693b35a212635f2592df44e670146b7e44ced2f60c"

URI_aarch64_rust-potential_utf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-potential_utf-devel-0.1.4-1.el10_1.noarch.rpm;name=aarch64_rust-potential_utf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-potential_utf-devel}"
SRC_URI[aarch64_rust-potential_utf-devel.sha256sum] = "a24076efcdb09527f5019ce1ee05d99fe22c76812d5f462c126d4db2d0b5ec39"

RDEPENDS:rust-potential_utf+alloc-devel = " \
 cargo \
 rust-potential_utf-devel \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 rust-writeable+alloc-devel \
 rust-writeable-devel \
 rust-zerovec+alloc-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-potential_utf+databake-devel = " \
 cargo \
 rust-databake-devel \
 rust-potential_utf-devel \
 "
RDEPENDS:rust-potential_utf+default-devel = " \
 cargo \
 rust-potential_utf+alloc-devel \
 rust-potential_utf-devel \
 "
RDEPENDS:rust-potential_utf+serde-devel = " \
 cargo \
 rust-potential_utf-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-potential_utf+writeable-devel = " \
 cargo \
 rust-potential_utf-devel \
 rust-writeable-devel \
 "
RDEPENDS:rust-potential_utf+zerovec-devel = " \
 cargo \
 rust-potential_utf-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-potential_utf-devel = " \
 cargo \
 rust \
 "
