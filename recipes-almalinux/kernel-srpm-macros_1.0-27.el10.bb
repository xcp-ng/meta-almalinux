# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kernel-srpm-macros"
PV = "1.0"
PR = "27.el10"
PACKAGES = " \
 kernel-rpm-macros \
 kernel-srpm-macros \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/kernel-srpm-macros-1.0-27.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f8bbdac72b3fa80327760f46b35ea49788a12a72bf035b512ad037643b886ed"

URI_x86_64_v2_kernel-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-rpm-macros-205-27.el10.noarch.rpm;name=x86_64_v2_kernel-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-rpm-macros}"
SRC_URI[x86_64_v2_kernel-rpm-macros.sha256sum] = "5391987b93504751feca331e979a80cc33bf10f37fb060b1f9a612860095e52c"

URI_x86_64_v2_kernel-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-srpm-macros-1.0-27.el10.noarch.rpm;name=x86_64_v2_kernel-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-srpm-macros}"
SRC_URI[x86_64_v2_kernel-srpm-macros.sha256sum] = "0421d244948314a77b2e51787dbabfc4fec4c8aefb9198f974dfd02cb6a969a9"

URI_aarch64_kernel-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-rpm-macros-205-27.el10.noarch.rpm;name=aarch64_kernel-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-rpm-macros}"
SRC_URI[aarch64_kernel-rpm-macros.sha256sum] = "5391987b93504751feca331e979a80cc33bf10f37fb060b1f9a612860095e52c"

URI_aarch64_kernel-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-srpm-macros-1.0-27.el10.noarch.rpm;name=aarch64_kernel-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-srpm-macros}"
SRC_URI[aarch64_kernel-srpm-macros.sha256sum] = "0421d244948314a77b2e51787dbabfc4fec4c8aefb9198f974dfd02cb6a969a9"

RDEPENDS:kernel-rpm-macros = " \
 bash \
 binutils \
 findutils \
 gawk \
 grep \
 kmod \
 perl-interpreter \
 redhat-rpm-config \
 sed \
 xz \
 "
RDEPENDS:kernel-srpm-macros = " \
 "
