# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-inconshreveable-log15"
PV = "2.15"
PR = "16.el10_0"
PACKAGES = " \
 compat-golang-gopkg-inconshreveable-log15-2-devel \
 golang-github-inconshreveable-log15-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-inconshreveable-log15-2.15-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ecb46e421355f3e4dd9293632ad1cdbb9a9d21b95465af3498f72f1c3ad2339"

URI_x86_64_v2_compat-golang-gopkg-inconshreveable-log15-2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/compat-golang-gopkg-inconshreveable-log15-2-devel-2.15-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_compat-golang-gopkg-inconshreveable-log15-2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_compat-golang-gopkg-inconshreveable-log15-2-devel}"
SRC_URI[x86_64_v2_compat-golang-gopkg-inconshreveable-log15-2-devel.sha256sum] = "93c20008b5a3ff19760569728ebb4b4269d8cd0e0b57f65f6b866cbffe850c84"

URI_x86_64_v2_golang-github-inconshreveable-log15-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-inconshreveable-log15-devel-2.15-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-inconshreveable-log15-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-inconshreveable-log15-devel}"
SRC_URI[x86_64_v2_golang-github-inconshreveable-log15-devel.sha256sum] = "affb7a60fec9ca84447c860c1cf80c73ef4b11a5ca7dd1ef7081a2457bc294d5"

URI_aarch64_compat-golang-gopkg-inconshreveable-log15-2-devel = "${EPEL_MIRROR}/aarch64/Packages/c/compat-golang-gopkg-inconshreveable-log15-2-devel-2.15-16.el10_0.noarch.rpm;name=aarch64_compat-golang-gopkg-inconshreveable-log15-2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_compat-golang-gopkg-inconshreveable-log15-2-devel}"
SRC_URI[aarch64_compat-golang-gopkg-inconshreveable-log15-2-devel.sha256sum] = "2895b12707a864c1be59ec6cf44c35ddc98ce00cb4ca9de79b37138741f20ee5"

URI_aarch64_golang-github-inconshreveable-log15-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-inconshreveable-log15-devel-2.15-16.el10_0.noarch.rpm;name=aarch64_golang-github-inconshreveable-log15-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-inconshreveable-log15-devel}"
SRC_URI[aarch64_golang-github-inconshreveable-log15-devel.sha256sum] = "3ed706d03418e0b8541ad6fa774490406ed20439d0d4a5f5fc7e69af1daa39e3"

RDEPENDS:compat-golang-gopkg-inconshreveable-log15-2-devel = " \
 go-filesystem \
 golang-github-inconshreveable-log15-devel \
 "
RDEPENDS:golang-github-inconshreveable-log15-devel = " \
 go-filesystem \
 golang-github-mattn-colorable-devel \
 golang-github-mattn-isatty-devel \
 golang-github-stack-devel \
 "
