# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aeskeyfind"
PV = "1.0"
PR = "20.el10_0"
PACKAGES = " \
 aeskeyfind \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aeskeyfind-1.0-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c968799fd648b7443c7fe7df7168f2afa29d09d55e09d13ab9937f15874fc078"

URI_x86_64_v2_aeskeyfind = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aeskeyfind-1.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aeskeyfind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aeskeyfind}"
SRC_URI[x86_64_v2_aeskeyfind.sha256sum] = "9de43ba15fc02b093ed249bad49ef75dbade3bdc7c848ac490eb125c54af9d83"

URI_aarch64_aeskeyfind = "${EPEL_MIRROR}/aarch64/Packages/a/aeskeyfind-1.0-20.el10_0.aarch64.rpm;name=aarch64_aeskeyfind;unpack=0"
SRC_URI:append = " ${URI_aarch64_aeskeyfind}"
SRC_URI[aarch64_aeskeyfind.sha256sum] = "b90eb5708019a44dd1bd169a1de2e5aa7da7828ba46c50fc0f055e67e70b0bc7"

RDEPENDS:aeskeyfind = " \
 glibc \
 "
