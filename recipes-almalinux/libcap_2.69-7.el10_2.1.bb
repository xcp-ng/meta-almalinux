# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libcap"
PV = "2.69"
PR = "7.el10_2.1"
PACKAGES = " \
 libcap \
 libcap-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libcap-2.69-7.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa045e6b53bea66976b0db792240afc7b4575bd527b1cb8bedb41d0b5e905b5c"

URI_x86_64_v2_libcap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libcap-2.69-7.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_libcap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcap}"
SRC_URI[x86_64_v2_libcap.sha256sum] = "a533ba80d9ae554416c1eb7369d5a2a578ef8d31457f00802878fff2c215304b"

URI_x86_64_v2_libcap-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libcap-devel-2.69-7.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_libcap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcap-devel}"
SRC_URI[x86_64_v2_libcap-devel.sha256sum] = "33b89e4ac6354b8a8d7e0eec840369b7e3e46737559590c75fa49af49bad5ee3"

URI_aarch64_libcap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libcap-2.69-7.el10_2.1.aarch64.rpm;name=aarch64_libcap;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcap}"
SRC_URI[aarch64_libcap.sha256sum] = "0e7692819c86e6366dcf8fdca9c77c37d97ebe394643e4fbe30b39cf78098d85"

URI_aarch64_libcap-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libcap-devel-2.69-7.el10_2.1.aarch64.rpm;name=aarch64_libcap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcap-devel}"
SRC_URI[aarch64_libcap-devel.sha256sum] = "ce239618bdb70ab5c7493e799eff383abf6c97613bb46ddd785d0694ae4aa684"

RDEPENDS:libcap = " \
 glibc \
 libgcc \
 pam-libs \
 "
RDEPENDS:libcap-devel = " \
 libcap \
 pkgconf-pkg-config \
 "
