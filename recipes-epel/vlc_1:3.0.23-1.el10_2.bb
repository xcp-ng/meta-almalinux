# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vlc"
PE = "1"
PV = "3.0.23"
PR = "1.el10_2"
PACKAGES = " \
 vlc \
 vlc-cli \
 vlc-devel \
 vlc-gui-ncurses \
 vlc-gui-qt \
 vlc-gui-skins2 \
 vlc-libs \
 vlc-plugin-ffmpeg \
 vlc-plugin-fluidsynth \
 vlc-plugin-gnome \
 vlc-plugin-gstreamer \
 vlc-plugin-ieee1394 \
 vlc-plugin-jack \
 vlc-plugin-kde \
 vlc-plugin-lua \
 vlc-plugin-notify \
 vlc-plugin-pulseaudio \
 vlc-plugin-rdp \
 vlc-plugin-samba \
 vlc-plugin-svg \
 vlc-plugin-visualization \
 vlc-plugin-vnc \
 vlc-plugins-all \
 vlc-plugins-base \
 vlc-plugins-extra \
 vlc-plugins-video-out \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vlc-3.0.23-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b9aa329fdb4625a6173965cbc26fafe22add7bd32643816b4cdadea75485e3de"

URI_x86_64_v2_vlc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-3.0.23-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc}"
SRC_URI[x86_64_v2_vlc.sha256sum] = "c8c0ee822a505ca570d5ae226a46050c84874cfb137c6a7fd29e936b7bcca745"

URI_x86_64_v2_vlc-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-cli-3.0.23-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-cli}"
SRC_URI[x86_64_v2_vlc-cli.sha256sum] = "96c0f0db7dbe0c8b3ad31fd606239326838daf899755980347529baa70d4a6e8"

URI_x86_64_v2_vlc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-devel-3.0.23-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-devel}"
SRC_URI[x86_64_v2_vlc-devel.sha256sum] = "4b442e10863ffd2cca1b24defec5c089034940c657eb732c207983e0cf0743bb"

URI_x86_64_v2_vlc-gui-ncurses = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-gui-ncurses-3.0.23-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-gui-ncurses;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-gui-ncurses}"
SRC_URI[x86_64_v2_vlc-gui-ncurses.sha256sum] = "aedee1806998845af39061c52dce4096d74b0d4c5310a4348562365874c2844a"

URI_x86_64_v2_vlc-gui-qt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-gui-qt-3.0.23-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-gui-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-gui-qt}"
SRC_URI[x86_64_v2_vlc-gui-qt.sha256sum] = "254f094eb3fd03e3a0f6734cdc4abc0ff559e27f77319e4be57a4f4d004d6c16"

URI_x86_64_v2_vlc-gui-skins2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-gui-skins2-3.0.23-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-gui-skins2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-gui-skins2}"
SRC_URI[x86_64_v2_vlc-gui-skins2.sha256sum] = "0d290c8b590b907c566c4a7f9336be732dd4576b76c93ba7b3c74a49fb4d33d9"

URI_x86_64_v2_vlc-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-libs-3.0.23-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-libs}"
SRC_URI[x86_64_v2_vlc-libs.sha256sum] = "cb03bd99331127b7aaeba3c8075a67b34ece4a2f6dffdf26af4874190195f847"

URI_x86_64_v2_vlc-plugin-ffmpeg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-ffmpeg-3.0.23-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-ffmpeg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-ffmpeg}"
SRC_URI[x86_64_v2_vlc-plugin-ffmpeg.sha256sum] = "7cf1d0e1a6a4e66bc673dfbdec6fe2f771adbaa5effbf4d66c856a0bd5b0aef1"

URI_x86_64_v2_vlc-plugin-fluidsynth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-fluidsynth-3.0.23-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-fluidsynth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-fluidsynth}"
SRC_URI[x86_64_v2_vlc-plugin-fluidsynth.sha256sum] = "ec62538865588fde66179ef003a819791a45debe412900384732c2f8256d924d"

URI_x86_64_v2_vlc-plugin-gnome = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-gnome-3.0.23-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-gnome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-gnome}"
SRC_URI[x86_64_v2_vlc-plugin-gnome.sha256sum] = "6c5e2d84df6bf43b23b8f69ff4dc7eacb7e2312a55f7af24e926699360c93ffb"

URI_x86_64_v2_vlc-plugin-gstreamer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-gstreamer-3.0.23-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-gstreamer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-gstreamer}"
SRC_URI[x86_64_v2_vlc-plugin-gstreamer.sha256sum] = "095b74595d91f1b8da5c1320a2ced68ffdeb86acbad57e4a598ee815ccec20e8"

URI_x86_64_v2_vlc-plugin-ieee1394 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-ieee1394-3.0.23-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-ieee1394;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-ieee1394}"
SRC_URI[x86_64_v2_vlc-plugin-ieee1394.sha256sum] = "9d849c7d6407fcdcc920bfa5df746273974b348be4c1da02f8eaa339542b3103"

URI_x86_64_v2_vlc-plugin-jack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-jack-3.0.23-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-jack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-jack}"
SRC_URI[x86_64_v2_vlc-plugin-jack.sha256sum] = "66f87124a51be27895c26b03b018249ebb1600d365565b026d619449ed4063ed"

URI_x86_64_v2_vlc-plugin-kde = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-kde-3.0.23-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-kde;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-kde}"
SRC_URI[x86_64_v2_vlc-plugin-kde.sha256sum] = "c9f280c658feff58482165e37bed116dbd36b1db681cfd921937b959b0806754"

URI_x86_64_v2_vlc-plugin-lua = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-lua-3.0.23-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-lua;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-lua}"
SRC_URI[x86_64_v2_vlc-plugin-lua.sha256sum] = "dcbb227c9706ed916c775e3665f74088a93a8096ba50b40debdcba21a3ea152d"

URI_x86_64_v2_vlc-plugin-notify = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-notify-3.0.23-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-notify;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-notify}"
SRC_URI[x86_64_v2_vlc-plugin-notify.sha256sum] = "0fe5770e27aea7b1090daac8d31f1a6d70f7cb217c0d92a9f465860b110e6599"

URI_x86_64_v2_vlc-plugin-pulseaudio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-pulseaudio-3.0.23-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-pulseaudio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-pulseaudio}"
SRC_URI[x86_64_v2_vlc-plugin-pulseaudio.sha256sum] = "1f3c05c2ca2d6db806a1dadce1be89cc378b7afced9032432bebffb97e56c36c"

URI_x86_64_v2_vlc-plugin-rdp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-rdp-3.0.23-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-rdp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-rdp}"
SRC_URI[x86_64_v2_vlc-plugin-rdp.sha256sum] = "c047da5604976e06aa92a87fb2be13fdbcae3f0275085e58473d73b5090ffc38"

URI_x86_64_v2_vlc-plugin-samba = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-samba-3.0.23-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-samba;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-samba}"
SRC_URI[x86_64_v2_vlc-plugin-samba.sha256sum] = "b2b1440942866e79b1b1cc3fdedf56b8866adb3c0ad639ca04c17456840a15a6"

URI_x86_64_v2_vlc-plugin-svg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-svg-3.0.23-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-svg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-svg}"
SRC_URI[x86_64_v2_vlc-plugin-svg.sha256sum] = "574f58a55d90c861c5bb779b88b8d84261095065b0edfabea9974bfc546072e9"

URI_x86_64_v2_vlc-plugin-visualization = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-visualization-3.0.23-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-visualization;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-visualization}"
SRC_URI[x86_64_v2_vlc-plugin-visualization.sha256sum] = "3d70b44c64c1376de7a66901796ce2216ccb1634a1517df083ec4ac263ad8c5f"

URI_x86_64_v2_vlc-plugin-vnc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-vnc-3.0.23-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-vnc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-vnc}"
SRC_URI[x86_64_v2_vlc-plugin-vnc.sha256sum] = "61e1bda4c517ad485fe3740fcf9f9de005766be2d22317e4a95e49167bac7196"

URI_x86_64_v2_vlc-plugins-all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugins-all-3.0.23-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugins-all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugins-all}"
SRC_URI[x86_64_v2_vlc-plugins-all.sha256sum] = "7d6f882d2b27cfe921613cb41b4f9e51cc2c6917e108c0c27221367837554034"

URI_x86_64_v2_vlc-plugins-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugins-base-3.0.23-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugins-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugins-base}"
SRC_URI[x86_64_v2_vlc-plugins-base.sha256sum] = "f8518f68300947a101c9c4139a0fb8489288731c12fad5eb7cc4954c69774d50"

URI_x86_64_v2_vlc-plugins-extra = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugins-extra-3.0.23-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugins-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugins-extra}"
SRC_URI[x86_64_v2_vlc-plugins-extra.sha256sum] = "89b59fcd53a596cb544cefc4dc99987c9c7b5e2abeb136f5c89fcd77b89505e2"

URI_x86_64_v2_vlc-plugins-video-out = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugins-video-out-3.0.23-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugins-video-out;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugins-video-out}"
SRC_URI[x86_64_v2_vlc-plugins-video-out.sha256sum] = "d6aad5c3703ceffb04e7ee4df7ed7afe558dc1c69c54a032d772207922116e8c"

URI_aarch64_vlc = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-3.0.23-1.el10_2.aarch64.rpm;name=aarch64_vlc;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc}"
SRC_URI[aarch64_vlc.sha256sum] = "0b0090703ddd95e1369f2c5f0ad7e9cd4a3185e0cbb0d3a88b7a66c2bba8177b"

URI_aarch64_vlc-cli = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-cli-3.0.23-1.el10_2.aarch64.rpm;name=aarch64_vlc-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-cli}"
SRC_URI[aarch64_vlc-cli.sha256sum] = "782b5f98f5f125626e78b9073b71dbff64cbbc66b2c29a6f298569fa36aa3966"

URI_aarch64_vlc-devel = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-devel-3.0.23-1.el10_2.aarch64.rpm;name=aarch64_vlc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-devel}"
SRC_URI[aarch64_vlc-devel.sha256sum] = "1d600309b4528c1433d3b8efcb406aa30a08a4a7c57774f83ca54c099919279a"

URI_aarch64_vlc-gui-ncurses = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-gui-ncurses-3.0.23-1.el10_2.aarch64.rpm;name=aarch64_vlc-gui-ncurses;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-gui-ncurses}"
SRC_URI[aarch64_vlc-gui-ncurses.sha256sum] = "5f946a3ea3158349a5a239ee354dd0b760ad945190430b35548d5ec89d93eb53"

URI_aarch64_vlc-gui-qt = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-gui-qt-3.0.23-1.el10_2.aarch64.rpm;name=aarch64_vlc-gui-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-gui-qt}"
SRC_URI[aarch64_vlc-gui-qt.sha256sum] = "f95bfe8f591bd8448ca0e4fa98edce9ac565fb315240188831ea2d4c0e5fd717"

URI_aarch64_vlc-gui-skins2 = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-gui-skins2-3.0.23-1.el10_2.aarch64.rpm;name=aarch64_vlc-gui-skins2;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-gui-skins2}"
SRC_URI[aarch64_vlc-gui-skins2.sha256sum] = "29d2de86c0a2b02793e00fd6ef7aac24755d9452081301ddc296c07fcb09b657"

URI_aarch64_vlc-libs = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-libs-3.0.23-1.el10_2.aarch64.rpm;name=aarch64_vlc-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-libs}"
SRC_URI[aarch64_vlc-libs.sha256sum] = "a79ed33aef7b10bd1b503e778c314752ccf1885f00b9e373874dece9e1abdb94"

URI_aarch64_vlc-plugin-ffmpeg = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-ffmpeg-3.0.23-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugin-ffmpeg;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-ffmpeg}"
SRC_URI[aarch64_vlc-plugin-ffmpeg.sha256sum] = "965362454709bbc62b4e98757f8203d2cd85555ba4d3265b7d849461d7905ee8"

URI_aarch64_vlc-plugin-fluidsynth = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-fluidsynth-3.0.23-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugin-fluidsynth;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-fluidsynth}"
SRC_URI[aarch64_vlc-plugin-fluidsynth.sha256sum] = "49f5164343b04291f314ef0403d0c1317eae058eec4377ed6d54eaa9b30a34b6"

URI_aarch64_vlc-plugin-gnome = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-gnome-3.0.23-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugin-gnome;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-gnome}"
SRC_URI[aarch64_vlc-plugin-gnome.sha256sum] = "1e620b3d4306b9789a5bade425c1de5d220ed8cdf9a301ae27d7d886ef3c38d2"

URI_aarch64_vlc-plugin-gstreamer = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-gstreamer-3.0.23-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugin-gstreamer;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-gstreamer}"
SRC_URI[aarch64_vlc-plugin-gstreamer.sha256sum] = "071448989bcdb6d31a067e27cb7208aff71e3448609b3a79e5ff467f279dce62"

URI_aarch64_vlc-plugin-ieee1394 = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-ieee1394-3.0.23-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugin-ieee1394;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-ieee1394}"
SRC_URI[aarch64_vlc-plugin-ieee1394.sha256sum] = "83aa8f20b215dc155dc485bbbff8720ab0314271e50798f543d31255e2f40437"

URI_aarch64_vlc-plugin-jack = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-jack-3.0.23-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugin-jack;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-jack}"
SRC_URI[aarch64_vlc-plugin-jack.sha256sum] = "1d7822f1424efd345da3a6eeadcd2e602025d451433fbc12bca150c65d6333d3"

URI_aarch64_vlc-plugin-kde = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-kde-3.0.23-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugin-kde;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-kde}"
SRC_URI[aarch64_vlc-plugin-kde.sha256sum] = "17a40997fcd0474d80b25e2593ee6aaae4cbfbf11059de4d94b8704047d157f8"

URI_aarch64_vlc-plugin-lua = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-lua-3.0.23-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugin-lua;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-lua}"
SRC_URI[aarch64_vlc-plugin-lua.sha256sum] = "59fb95d4aea5f3cfa8a7c6b75f3a01c5b3bf15b0a3ccb44595af42ffe83783b4"

URI_aarch64_vlc-plugin-notify = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-notify-3.0.23-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugin-notify;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-notify}"
SRC_URI[aarch64_vlc-plugin-notify.sha256sum] = "3e7d68c3ac61743fc56aff7cf9172be8e99096166de254d5f9d4bdf183838985"

URI_aarch64_vlc-plugin-pulseaudio = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-pulseaudio-3.0.23-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugin-pulseaudio;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-pulseaudio}"
SRC_URI[aarch64_vlc-plugin-pulseaudio.sha256sum] = "d2b190e99ade71f22527f0f459924edbe351d10de8534a357e1f8791247c3c51"

URI_aarch64_vlc-plugin-rdp = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-rdp-3.0.23-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugin-rdp;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-rdp}"
SRC_URI[aarch64_vlc-plugin-rdp.sha256sum] = "7d6dd2b8c54fc49e7661090b5764e4f253dc945cf7065eeaece243f9eb629c66"

URI_aarch64_vlc-plugin-samba = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-samba-3.0.23-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugin-samba;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-samba}"
SRC_URI[aarch64_vlc-plugin-samba.sha256sum] = "f4cac4fb2595a8fc714fd643c7416ad0eeb6ceaf69aad30663b3bd1c088258e2"

URI_aarch64_vlc-plugin-svg = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-svg-3.0.23-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugin-svg;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-svg}"
SRC_URI[aarch64_vlc-plugin-svg.sha256sum] = "7e9e65f76b07e20db0b88b2216895492fb8edc8f50dd596e65a15ca6fad988a3"

URI_aarch64_vlc-plugin-visualization = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-visualization-3.0.23-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugin-visualization;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-visualization}"
SRC_URI[aarch64_vlc-plugin-visualization.sha256sum] = "879f682da15ab9036a0c77c9f25af4400cec4da9941cc74e43c88f20cd9fa0f7"

URI_aarch64_vlc-plugin-vnc = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-vnc-3.0.23-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugin-vnc;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-vnc}"
SRC_URI[aarch64_vlc-plugin-vnc.sha256sum] = "09dde96ddfc1a6027afca135e635bbe1122431930509503a3b9adc549039a0af"

URI_aarch64_vlc-plugins-all = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugins-all-3.0.23-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugins-all;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugins-all}"
SRC_URI[aarch64_vlc-plugins-all.sha256sum] = "523496fba38ffd089623c72c6d9dc9eb59403f849e1fcbd7f7813cbc7c1625ff"

URI_aarch64_vlc-plugins-base = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugins-base-3.0.23-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugins-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugins-base}"
SRC_URI[aarch64_vlc-plugins-base.sha256sum] = "22e746b80065c23d9853a307790b6d0765424a756b99c20ea5b18d782220e51a"

URI_aarch64_vlc-plugins-extra = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugins-extra-3.0.23-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugins-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugins-extra}"
SRC_URI[aarch64_vlc-plugins-extra.sha256sum] = "c343ae176af88b764126e9cc230c4545051d82ebe02685f0a7567eb0e713d7d5"

URI_aarch64_vlc-plugins-video-out = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugins-video-out-3.0.23-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugins-video-out;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugins-video-out}"
SRC_URI[aarch64_vlc-plugins-video-out.sha256sum] = "b6f3229750b68f18bcb9332ac01a3f269f89868a0acebbf594ec0b25dca83a35"

RDEPENDS:vlc = " \
 bash \
 hicolor-icon-theme \
 kde-filesystem \
 vlc-gui-qt \
 "
RDEPENDS:vlc-cli = " \
 bash \
 glibc \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-devel = " \
 pkgconf-pkg-config \
 vlc-libs \
 "
RDEPENDS:vlc-gui-ncurses = " \
 bash \
 glibc \
 ncurses-libs \
 vlc-cli \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-gui-qt = " \
 bash \
 glibc \
 libX11 \
 libgcc \
 libstdc++ \
 libwayland-client \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtsvg \
 qt5-qtwayland \
 qt5-qtx11extras \
 vlc-cli \
 vlc-libs \
 vlc-plugin-lua \
 vlc-plugin-pipewire \
 vlc-plugin-pulseaudio \
 vlc-plugins-base \
 vlc-plugins-video-out \
 "
RDEPENDS:vlc-gui-skins2 = " \
 bash \
 freetype \
 fribidi \
 glibc \
 gnu-free-sans-fonts \
 libX11 \
 libXext \
 libXinerama \
 libXpm \
 libgcc \
 libstdc++ \
 vlc-cli \
 vlc-gui-qt \
 vlc-libs \
 "
RDEPENDS:vlc-libs = " \
 bash \
 dbus-libs \
 glibc \
 libgcc \
 libidn2 \
 "
RDEPENDS:vlc-plugin-ffmpeg = " \
 glibc \
 libX11 \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libchromaprint \
 libpostproc-free \
 libswscale-free \
 libva \
 vlc-libs \
 vlc-plugins-base \
 vlc-plugins-video-out \
 "
RDEPENDS:vlc-plugin-fluidsynth = " \
 fluidsynth-libs \
 glibc \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-gnome = " \
 glib2 \
 glibc \
 libsecret \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-gstreamer = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-bad-free \
 gstreamer1-plugins-base \
 gstreamer1-plugins-good \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-ieee1394 = " \
 glibc \
 libavc1394 \
 libdc1394 \
 libgcc \
 libraw1394 \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-jack = " \
 glibc \
 pipewire-jack-audio-connection-kit-libs \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-kde = " \
 dbus-libs \
 glibc \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-lua = " \
 glibc \
 libgcc \
 lua-libs \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-notify = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 libnotify \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-pulseaudio = " \
 glibc \
 pulseaudio-libs \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-rdp = " \
 freerdp2-libs \
 glibc \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-samba = " \
 glibc \
 libsmbclient \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-svg = " \
 cairo \
 glib2 \
 glibc \
 librsvg2 \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-visualization = " \
 glibc \
 libglvnd-glx \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-vnc = " \
 glibc \
 libvncserver \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugins-all = " \
 vlc-plugin-bittorrent \
 vlc-plugin-ffmpeg \
 vlc-plugin-fluidsynth \
 vlc-plugin-gnome \
 vlc-plugin-gstreamer \
 vlc-plugin-ieee1394 \
 vlc-plugin-jack \
 vlc-plugin-kde \
 vlc-plugin-lua \
 vlc-plugin-notify \
 vlc-plugin-pause-click \
 vlc-plugin-pipewire \
 vlc-plugin-pulseaudio \
 vlc-plugin-rdp \
 vlc-plugin-samba \
 vlc-plugin-svg \
 vlc-plugin-visualization \
 vlc-plugin-vnc \
 vlc-plugins-base \
 vlc-plugins-extra \
 vlc-plugins-video-out \
 "
RDEPENDS:vlc-plugins-base = " \
 alsa-lib \
 dbus-libs \
 faad2-libs \
 fdk-aac-free \
 flac-libs \
 glibc \
 gnutls \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 libdav1d \
 libgcc \
 libgcrypt \
 libgpg-error \
 libjpeg-turbo \
 libogg \
 libpng \
 libshout \
 libstdc++ \
 libtheora \
 libvorbis \
 libvpx \
 libxml2 \
 mpg123-libs \
 opus \
 speex \
 systemd-libs \
 taglib \
 twolame-libs \
 vlc-libs \
 zlib-ng-compat \
 "
RDEPENDS:vlc-plugins-extra:x86_64_v2 = " \
 aalib-libs \
 alsa-lib \
 aribb24 \
 aribb25 \
 avahi-libs \
 daala-libs \
 fontconfig \
 freetype \
 fribidi \
 game-music-emu \
 glibc \
 harfbuzz \
 libX11 \
 libaom \
 libarchive \
 libass \
 libbluray \
 libcaca \
 libcddb \
 libdvbpsi \
 libdvdnav \
 libdvdread \
 libebml \
 libgcc \
 libgcrypt \
 libkate \
 libmad \
 libmatroska \
 libmicrodns \
 libmodplug \
 libmpcdec \
 libmtp \
 libnfs \
 libsamplerate \
 libspatialaudio \
 libssh2 \
 libstdc++ \
 libtiger \
 libupnp \
 libvpl \
 libxcb \
 lirc-libs \
 live555 \
 pcsc-lite-libs \
 protobuf-lite \
 soxr \
 speexdsp \
 srt-libs \
 systemd-libs \
 vlc-libs \
 zlib-ng-compat \
 zvbi \
"
RDEPENDS:vlc-plugins-extra:aarch64 = " \
 aalib-libs \
 alsa-lib \
 aribb24 \
 aribb25 \
 avahi-libs \
 daala-libs \
 fontconfig \
 freetype \
 fribidi \
 game-music-emu \
 glibc \
 harfbuzz \
 libX11 \
 libaom \
 libarchive \
 libass \
 libbluray \
 libcaca \
 libcddb \
 libdvbpsi \
 libdvdnav \
 libdvdread \
 libebml \
 libgcc \
 libgcrypt \
 libkate \
 libmad \
 libmatroska \
 libmicrodns \
 libmodplug \
 libmpcdec \
 libmtp \
 libnfs \
 libsamplerate \
 libspatialaudio \
 libssh2 \
 libstdc++ \
 libtiger \
 libupnp \
 libxcb \
 lirc-libs \
 live555 \
 pcsc-lite-libs \
 protobuf-lite \
 soxr \
 speexdsp \
 srt-libs \
 systemd-libs \
 vlc-libs \
 zlib-ng-compat \
 zvbi \
"
RDEPENDS:vlc-plugins-video-out = " \
 glibc \
 libX11 \
 libgcc \
 libglvnd-egl \
 libglvnd-gles \
 libglvnd-glx \
 libva \
 libwayland-client \
 libwayland-egl \
 libxcb \
 vlc-libs \
 vlc-plugins-base \
 xcb-util-keysyms \
 "
