# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "usbguard"
PV = "1.1.3"
PR = "6.el10"
PACKAGES = " \
 usbguard \
 usbguard-dbus \
 usbguard-notifier \
 usbguard-selinux \
 usbguard-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/usbguard-1.1.3-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9a58a0a866384272ae4b77aad0b6eb7abcf0d576d2fadd1ba98ec9ca5df05840"

URI_x86_64_v2_usbguard = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/usbguard-1.1.3-6.el10.x86_64_v2.rpm;name=x86_64_v2_usbguard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_usbguard}"
SRC_URI[x86_64_v2_usbguard.sha256sum] = "4af9248abe8769064cdc3953bb8b58026ecea76bd6634064c2ac930f01596197"

URI_x86_64_v2_usbguard-dbus = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/usbguard-dbus-1.1.3-6.el10.x86_64_v2.rpm;name=x86_64_v2_usbguard-dbus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_usbguard-dbus}"
SRC_URI[x86_64_v2_usbguard-dbus.sha256sum] = "64f4fd555cd8d46f29ed9ec2f4d13600055e81b6d9f3c184d6ac5354b125648e"

URI_x86_64_v2_usbguard-notifier = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/usbguard-notifier-1.1.3-6.el10.x86_64_v2.rpm;name=x86_64_v2_usbguard-notifier;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_usbguard-notifier}"
SRC_URI[x86_64_v2_usbguard-notifier.sha256sum] = "652aaa62dafc187184533830f4f28682fdac8fb0280771f2865ac85648eae689"

URI_x86_64_v2_usbguard-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/usbguard-selinux-1.1.3-6.el10.noarch.rpm;name=x86_64_v2_usbguard-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_usbguard-selinux}"
SRC_URI[x86_64_v2_usbguard-selinux.sha256sum] = "bd7f1a5e03effc28d6da7ef1232bf04fad2bdaadaf68c6f63346a2915544ec73"

URI_x86_64_v2_usbguard-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/usbguard-tools-1.1.3-6.el10.x86_64_v2.rpm;name=x86_64_v2_usbguard-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_usbguard-tools}"
SRC_URI[x86_64_v2_usbguard-tools.sha256sum] = "558fb2fe2d5ece97c2cf2b325cb0d8c873286ea9e0d4774170b087f35b1c8443"

URI_aarch64_usbguard = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/usbguard-1.1.3-6.el10.aarch64.rpm;name=aarch64_usbguard;unpack=0"
SRC_URI:append = " ${URI_aarch64_usbguard}"
SRC_URI[aarch64_usbguard.sha256sum] = "7ff9e0c2dccd34819d296abc68ceebacc12402bd1e6d5dc11299cdd7b2837b0b"

URI_aarch64_usbguard-dbus = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/usbguard-dbus-1.1.3-6.el10.aarch64.rpm;name=aarch64_usbguard-dbus;unpack=0"
SRC_URI:append = " ${URI_aarch64_usbguard-dbus}"
SRC_URI[aarch64_usbguard-dbus.sha256sum] = "d15326224705e8f014a0352a298f82c5bf3650f4cccc5368f06140548fa6ffb0"

URI_aarch64_usbguard-notifier = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/usbguard-notifier-1.1.3-6.el10.aarch64.rpm;name=aarch64_usbguard-notifier;unpack=0"
SRC_URI:append = " ${URI_aarch64_usbguard-notifier}"
SRC_URI[aarch64_usbguard-notifier.sha256sum] = "caa530d913d7e4fb66e5568748a63dd0bc91a98b089b04148528bd7dc1bd3385"

URI_aarch64_usbguard-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/usbguard-selinux-1.1.3-6.el10.noarch.rpm;name=aarch64_usbguard-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_usbguard-selinux}"
SRC_URI[aarch64_usbguard-selinux.sha256sum] = "bd7f1a5e03effc28d6da7ef1232bf04fad2bdaadaf68c6f63346a2915544ec73"

URI_aarch64_usbguard-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/usbguard-tools-1.1.3-6.el10.aarch64.rpm;name=aarch64_usbguard-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_usbguard-tools}"
SRC_URI[aarch64_usbguard-tools.sha256sum] = "8cc8a26a2a6aafc54248fbd862b2c564d13119428ec4a2dbb65bb0a1283a48cd"

RDEPENDS:usbguard = " \
 audit-libs \
 bash \
 glibc \
 libcap-ng \
 libgcc \
 libqb \
 libstdc++ \
 openssl-libs \
 protobuf \
 systemd \
 "
RDEPENDS:usbguard-dbus = " \
 bash \
 dbus \
 glib2 \
 glibc \
 libgcc \
 libstdc++ \
 polkit \
 polkit-libs \
 usbguard \
 "
RDEPENDS:usbguard-notifier = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libnotify \
 librsvg2 \
 libstdc++ \
 systemd \
 usbguard \
 "
RDEPENDS:usbguard-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:usbguard-tools = " \
 glibc \
 libgcc \
 libstdc++ \
 usbguard \
 "
