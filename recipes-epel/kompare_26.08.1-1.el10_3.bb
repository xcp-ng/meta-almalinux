# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kompare"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kompare \
 kompare-devel \
 kompare-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kompare-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "335c6200c2d523639a2fd17ddcf9859d022666d0cc806f994b359266acf0a156"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kompare-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kompare;unpack=0"
SRC_URI[x86_64_v2_kompare.sha256sum] = "2c15815a55ce49f8922c07ae3f04a23556ce82f10ceed1150fcb7292257a8a42"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kompare-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kompare-devel;unpack=0"
SRC_URI[x86_64_v2_kompare-devel.sha256sum] = "f4539450e9fbee7c826585d19a271676d0c9f90638776f064d5db8aa58671174"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kompare-libs-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kompare-libs;unpack=0"
SRC_URI[x86_64_v2_kompare-libs.sha256sum] = "58dba7db62cc865fcee81f2b05aea80fc3968564bf16fd4c398b45b2fd15d702"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kompare-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kompare;unpack=0"
SRC_URI[aarch64_kompare.sha256sum] = "d6f40e134ce723ec916d8ad898edee6dfbc35198c7dd96ac3b8fcf8cc7aa7128"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kompare-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kompare-devel;unpack=0"
SRC_URI[aarch64_kompare-devel.sha256sum] = "e7f90fe44873bfc71ce72c8dc1288dcdcc557303b391b9af26d90e79449b7624"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kompare-libs-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kompare-libs;unpack=0"
SRC_URI[aarch64_kompare-libs.sha256sum] = "72add916b74df43ba3f689b70ee0f51db5ede5ab2026dac666a0d281ba8d587d"

RDEPENDS:kompare = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kparts \
 kf6-ktexteditor \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kompare-libs \
 libkomparediff2 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kompare-devel = " \
 kompare-libs \
 qt6-qtbase-devel \
 "
RDEPENDS:kompare-libs = " \
 glibc \
 kf6-kcodecs \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkomparediff2 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
