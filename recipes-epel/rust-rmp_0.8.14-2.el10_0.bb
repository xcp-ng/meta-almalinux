# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rmp"
PV = "0.8.14"
PR = "2.el10_0"
PACKAGES = " \
 rust-rmp+default-devel \
 rust-rmp+std-devel \
 rust-rmp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rmp-0.8.14-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09b2a7e8bb5a7b873855fe43445a4f0fbb1da3000d11169cb6614bfdf21022b8"

URI_x86_64_v2_rust-rmp+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rmp+default-devel-0.8.14-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rmp+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rmp+default-devel}"
SRC_URI[x86_64_v2_rust-rmp+default-devel.sha256sum] = "cf3c009b396fb81db8a03738e9c9ba4e8981a205419b326a6c28185d4f9045f1"

URI_x86_64_v2_rust-rmp+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rmp+std-devel-0.8.14-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rmp+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rmp+std-devel}"
SRC_URI[x86_64_v2_rust-rmp+std-devel.sha256sum] = "7ae062140eec4e682fdf1ebc64e1842e8b10a4673914abf4ebcff080960573bd"

URI_x86_64_v2_rust-rmp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rmp-devel-0.8.14-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rmp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rmp-devel}"
SRC_URI[x86_64_v2_rust-rmp-devel.sha256sum] = "5578794ff59c10cfe60ff4d25303e4cca3e2a96cbaf17e0f6a79f585ca600fe0"

URI_aarch64_rust-rmp+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rmp+default-devel-0.8.14-2.el10_0.noarch.rpm;name=aarch64_rust-rmp+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rmp+default-devel}"
SRC_URI[aarch64_rust-rmp+default-devel.sha256sum] = "471ed89b333021980c565dc0b498f6c9a8429da0ee81868760c79debaea55282"

URI_aarch64_rust-rmp+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rmp+std-devel-0.8.14-2.el10_0.noarch.rpm;name=aarch64_rust-rmp+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rmp+std-devel}"
SRC_URI[aarch64_rust-rmp+std-devel.sha256sum] = "b58e95f5b9e88e773ebf0ebf2e5a5655d7f318e0a85bbb44e9367f8acd211114"

URI_aarch64_rust-rmp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rmp-devel-0.8.14-2.el10_0.noarch.rpm;name=aarch64_rust-rmp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rmp-devel}"
SRC_URI[aarch64_rust-rmp-devel.sha256sum] = "5b8a963bd9b2f449ef210a9e9489dc337b255bb8ff2a37308f2a2e6ac198773a"

RDEPENDS:rust-rmp+default-devel = " \
 cargo \
 rust-rmp+std-devel \
 rust-rmp-devel \
 "
RDEPENDS:rust-rmp+std-devel = " \
 cargo \
 rust-byteorder+std-devel \
 rust-num-traits+std-devel \
 rust-rmp-devel \
 "
RDEPENDS:rust-rmp-devel = " \
 cargo \
 rust-byteorder-devel \
 rust-num-traits-devel \
 rust-paste+default-devel \
 "
