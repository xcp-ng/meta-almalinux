# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kquickimageeditor"
PV = "0.6.0"
PR = "1.el10_2"
PACKAGES = " \
 kquickimageeditor-qt6 \
 kquickimageeditor-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kquickimageeditor-0.6.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "39db49ca0876e9a28026371abb7e058badbbda1b0a42a224075fc277cf34de4d"

URI_x86_64_v2_kquickimageeditor-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kquickimageeditor-qt6-0.6.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kquickimageeditor-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kquickimageeditor-qt6}"
SRC_URI[x86_64_v2_kquickimageeditor-qt6.sha256sum] = "7599f3b60f1167d4c831c15dd2c72bab304ded144b0aa1be2ac014430feb1e94"

URI_x86_64_v2_kquickimageeditor-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kquickimageeditor-qt6-devel-0.6.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kquickimageeditor-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kquickimageeditor-qt6-devel}"
SRC_URI[x86_64_v2_kquickimageeditor-qt6-devel.sha256sum] = "fd21be0ba2f2ccf39533e9d57353f145ab1a18b081db2cc717826c624a63c251"

URI_aarch64_kquickimageeditor-qt6 = "${EPEL_MIRROR}/aarch64/Packages/k/kquickimageeditor-qt6-0.6.0-1.el10_2.aarch64.rpm;name=aarch64_kquickimageeditor-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_kquickimageeditor-qt6}"
SRC_URI[aarch64_kquickimageeditor-qt6.sha256sum] = "124d67d2ffdae8706f46b74aa6b895f9d75a1518bbc28c25c376196496cf2069"

URI_aarch64_kquickimageeditor-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kquickimageeditor-qt6-devel-0.6.0-1.el10_2.aarch64.rpm;name=aarch64_kquickimageeditor-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kquickimageeditor-qt6-devel}"
SRC_URI[aarch64_kquickimageeditor-qt6-devel.sha256sum] = "c9b5007574c5a780d2a0e267e4cd8fde87f0237737d3ca9fab2e47a3f2142290"

RDEPENDS:kquickimageeditor-qt6 = " \
 glibc \
 kf6-kconfig \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kquickimageeditor-qt6-devel = " \
 cmake-filesystem \
 kquickimageeditor-qt6 \
 "
