# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jeepney"
PV = "0.9.0"
PR = "5.el10_1"
PACKAGES = " \
 python3-jeepney \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-jeepney-0.9.0-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd3130c0d535acff43807fe2d346e59f171c385c9bddc3c06d92bdfe6fe419ea"

URI_x86_64_v2_python3-jeepney = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jeepney-0.9.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jeepney;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jeepney}"
SRC_URI[x86_64_v2_python3-jeepney.sha256sum] = "3b577684abf6ff5d38ce5a32839735d6d94019f2b88eed31d1cc98b39d8d27c7"

URI_aarch64_python3-jeepney = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jeepney-0.9.0-5.el10_1.noarch.rpm;name=aarch64_python3-jeepney;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jeepney}"
SRC_URI[aarch64_python3-jeepney.sha256sum] = "15074b30533b4dc0733f3a66952eb67ec2da71c0d55ad0582e1f0aa5b027a5cf"

RDEPENDS:python3-jeepney = " \
 python3 \
 "
