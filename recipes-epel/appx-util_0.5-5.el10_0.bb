# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "appx-util"
PV = "0.5"
PR = "5.el10_0"
PACKAGES = " \
 appx-util \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/appx-util-0.5-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c933380a052c1ed3de4502b40b5978e394e63d81cfcf57fe8a6cf81a4e77cab6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/appx-util-0.5-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_appx-util;unpack=0"
SRC_URI[x86_64_v2_appx-util.sha256sum] = "c3b2e6a1901469437a660c988f92dbfc008e0424884deb74458dd5cc64bf6433"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/appx-util-0.5-5.el10_0.aarch64.rpm;name=aarch64_appx-util;unpack=0"
SRC_URI[aarch64_appx-util.sha256sum] = "1c8e345b0fb09d564c13e07f6eb0c9592881cd2484c2d12bf42cf2bded80da95"

RDEPENDS:appx-util = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
