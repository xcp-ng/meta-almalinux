# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vorbis-tools"
PE = "1"
PV = "1.4.2"
PR = "14.el10_0"
PACKAGES = " \
 vorbis-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vorbis-tools-1.4.2-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be6f35755cb7ee8fd7f05b4b5f336b7bd2a19b3688f1ff20781655818017488a"

URI_x86_64_v2_vorbis-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vorbis-tools-1.4.2-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vorbis-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vorbis-tools}"
SRC_URI[x86_64_v2_vorbis-tools.sha256sum] = "3647b99b6935461e02c36aa215dcfdf5ef6e416fde5f1fcde43fc805b2926e7b"

URI_aarch64_vorbis-tools = "${EPEL_MIRROR}/aarch64/Packages/v/vorbis-tools-1.4.2-14.el10_0.aarch64.rpm;name=aarch64_vorbis-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_vorbis-tools}"
SRC_URI[aarch64_vorbis-tools.sha256sum] = "ed8de6c2114972cc546a7c6fc7a9bafd8dee22933e277a56beb463432955ea0f"

RDEPENDS:vorbis-tools = " \
 flac-libs \
 glibc \
 libao \
 libgcc \
 libogg \
 libvorbis \
 speex \
 virtual/libcurl.so.4___64bit_ \
 "
