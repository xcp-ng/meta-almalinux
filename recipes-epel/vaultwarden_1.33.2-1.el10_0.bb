# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vaultwarden"
PV = "1.33.2"
PR = "1.el10_0"
PACKAGES = " \
 vaultwarden \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vaultwarden-1.33.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62f42d09e92c7640b7ce0fa27ced01e94e53b334970d86831be2c4909c170d42"

URI_x86_64_v2_vaultwarden = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vaultwarden-1.33.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vaultwarden;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vaultwarden}"
SRC_URI[x86_64_v2_vaultwarden.sha256sum] = "9ffcc89b87cb11d243da7a9e598d8ab59cda04c2f35cec56524cadf1b1172168"

URI_aarch64_vaultwarden = "${EPEL_MIRROR}/aarch64/Packages/v/vaultwarden-1.33.2-1.el10_0.aarch64.rpm;name=aarch64_vaultwarden;unpack=0"
SRC_URI:append = " ${URI_aarch64_vaultwarden}"
SRC_URI[aarch64_vaultwarden.sha256sum] = "64ff6c61e6becf95cb712f7df0b9649dbe996ca509b6a33267177a345ec8fc56"

RDEPENDS:vaultwarden = " \
 bash \
 glibc \
 libgcc \
 libpq \
 mariadb-connector-c \
 openssl-libs \
 shadow-utils \
 vaultwarden-web \
 "
