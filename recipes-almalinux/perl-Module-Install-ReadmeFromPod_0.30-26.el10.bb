# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Module-Install-ReadmeFromPod"
PV = "0.30"
PR = "26.el10"
PACKAGES = " \
 perl-Module-Install-ReadmeFromPod \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Module-Install-ReadmeFromPod-0.30-26.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d6209f75c301be763619a82f67f1bf4f658370cfdf51db365c3cf1dc4d4a7eb5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Module-Install-ReadmeFromPod-0.30-26.el10.noarch.rpm;name=x86_64_v2_perl-Module-Install-ReadmeFromPod;unpack=0"
SRC_URI[x86_64_v2_perl-Module-Install-ReadmeFromPod.sha256sum] = "c4ea5bc195ca870999d7e2b4d77e3c8df82a3c13c310128bfd87eb34426a2d98"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Module-Install-ReadmeFromPod-0.30-26.el10.noarch.rpm;name=aarch64_perl-Module-Install-ReadmeFromPod;unpack=0"
SRC_URI[aarch64_perl-Module-Install-ReadmeFromPod.sha256sum] = "c4ea5bc195ca870999d7e2b4d77e3c8df82a3c13c310128bfd87eb34426a2d98"

RDEPENDS:perl-Module-Install-ReadmeFromPod = " \
 perl-Capture-Tiny \
 perl-IO-All \
 perl-Module-Install \
 perl-Pod-Html \
 perl-Pod-Markdown \
 perl-base \
 perl-libs \
 perl-podlators \
 perl-vars \
 "
