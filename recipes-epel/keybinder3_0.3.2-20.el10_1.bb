# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keybinder3"
PV = "0.3.2"
PR = "20.el10_1"
PACKAGES = " \
 keybinder3 \
 keybinder3-devel \
 keybinder3-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/keybinder3-0.3.2-20.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dac8535df9e66debb038099af9c2add7ddd2f298ce5791c04f4f1d92a659685e"

URI_x86_64_v2_keybinder3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/keybinder3-0.3.2-20.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_keybinder3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keybinder3}"
SRC_URI[x86_64_v2_keybinder3.sha256sum] = "e0c9f43919b8c916827ab1450063315c9d45d63aad4cf5217aebccc654a37519"

URI_x86_64_v2_keybinder3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/keybinder3-devel-0.3.2-20.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_keybinder3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keybinder3-devel}"
SRC_URI[x86_64_v2_keybinder3-devel.sha256sum] = "3ce0f57ed50423096287106a7317579a37c53dd789f80c5220564394e404d77e"

URI_x86_64_v2_keybinder3-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/keybinder3-doc-0.3.2-20.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_keybinder3-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keybinder3-doc}"
SRC_URI[x86_64_v2_keybinder3-doc.sha256sum] = "76ebd96bb28c2b3e6638602ca536baa12fbaa85748d6f930c8508dc17eba8117"

URI_aarch64_keybinder3 = "${EPEL_MIRROR}/aarch64/Packages/k/keybinder3-0.3.2-20.el10_1.aarch64.rpm;name=aarch64_keybinder3;unpack=0"
SRC_URI:append = " ${URI_aarch64_keybinder3}"
SRC_URI[aarch64_keybinder3.sha256sum] = "73b960a479deaf64d15736b7e6c54dd91c670da542db2d2eb6e1a2423a0fee59"

URI_aarch64_keybinder3-devel = "${EPEL_MIRROR}/aarch64/Packages/k/keybinder3-devel-0.3.2-20.el10_1.aarch64.rpm;name=aarch64_keybinder3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_keybinder3-devel}"
SRC_URI[aarch64_keybinder3-devel.sha256sum] = "a681a9a0127d43387d3970fdc80013b4e54f5e693b5f17a690fdfc40aa4dca78"

URI_aarch64_keybinder3-doc = "${EPEL_MIRROR}/aarch64/Packages/k/keybinder3-doc-0.3.2-20.el10_1.noarch.rpm;name=aarch64_keybinder3-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_keybinder3-doc}"
SRC_URI[aarch64_keybinder3-doc.sha256sum] = "8f17a6a32813390198ffbd56a9964c58a205b92fc8876d049a4302ba15a398f3"

RDEPENDS:keybinder3 = " \
 atk \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 libX11 \
 libXext \
 libXrender \
 pango \
 "
RDEPENDS:keybinder3-devel = " \
 gtk3-devel \
 keybinder3 \
 pkgconf-pkg-config \
 "
RDEPENDS:keybinder3-doc = " \
 devhelp \
 keybinder3 \
 "
