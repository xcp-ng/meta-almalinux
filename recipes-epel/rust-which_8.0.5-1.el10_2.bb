# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-which"
PV = "8.0.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-which+default-devel \
 rust-which+real-sys-devel \
 rust-which+regex-devel \
 rust-which+tracing-devel \
 rust-which-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-which-8.0.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eaa1bd30590aae6c550ca04293a5ddc3eab084d309ca30acefd516b989656f57"

URI_x86_64_v2_rust-which+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-which+default-devel-8.0.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-which+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-which+default-devel}"
SRC_URI[x86_64_v2_rust-which+default-devel.sha256sum] = "3e8ba9f0076c48ed92e9e28572e5d7bcd8364a53f49d9a9add20284e5490a356"

URI_x86_64_v2_rust-which+real-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-which+real-sys-devel-8.0.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-which+real-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-which+real-sys-devel}"
SRC_URI[x86_64_v2_rust-which+real-sys-devel.sha256sum] = "60d31e83f6800da0525500feb2cd212cef4d13ef4693aaf02335806e3d114a50"

URI_x86_64_v2_rust-which+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-which+regex-devel-8.0.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-which+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-which+regex-devel}"
SRC_URI[x86_64_v2_rust-which+regex-devel.sha256sum] = "55db78b3f813c0098f79f1851b75f387209dc46df172411c49a39fbeb2576cf7"

URI_x86_64_v2_rust-which+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-which+tracing-devel-8.0.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-which+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-which+tracing-devel}"
SRC_URI[x86_64_v2_rust-which+tracing-devel.sha256sum] = "bc6fb9fc3bf7b57b02225c7c9499ede2ef938c738978aa4758d462996e931d3b"

URI_x86_64_v2_rust-which-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-which-devel-8.0.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-which-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-which-devel}"
SRC_URI[x86_64_v2_rust-which-devel.sha256sum] = "4b48f60c72964e479ff76ce25cb3431322644d4ff9b3ef70e3d8565049c03a7b"

URI_aarch64_rust-which+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-which+default-devel-8.0.5-1.el10_2.noarch.rpm;name=aarch64_rust-which+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-which+default-devel}"
SRC_URI[aarch64_rust-which+default-devel.sha256sum] = "8b4f832608b5b4f87c3260c1e626798a8548d7f1101b1a404b557beeac01d6e6"

URI_aarch64_rust-which+real-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-which+real-sys-devel-8.0.5-1.el10_2.noarch.rpm;name=aarch64_rust-which+real-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-which+real-sys-devel}"
SRC_URI[aarch64_rust-which+real-sys-devel.sha256sum] = "ea3b16899002e7f016907184a68966d11b93195f77fcfc5e394a81ed6f23058e"

URI_aarch64_rust-which+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-which+regex-devel-8.0.5-1.el10_2.noarch.rpm;name=aarch64_rust-which+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-which+regex-devel}"
SRC_URI[aarch64_rust-which+regex-devel.sha256sum] = "0f713673da9f355ef39587847dcaaf75be10faed84b47ac96488304f608d787a"

URI_aarch64_rust-which+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-which+tracing-devel-8.0.5-1.el10_2.noarch.rpm;name=aarch64_rust-which+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-which+tracing-devel}"
SRC_URI[aarch64_rust-which+tracing-devel.sha256sum] = "d20e5926094312635b8db5a4af55547a0122f4cb950e063b36b9fb36dd562321"

URI_aarch64_rust-which-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-which-devel-8.0.5-1.el10_2.noarch.rpm;name=aarch64_rust-which-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-which-devel}"
SRC_URI[aarch64_rust-which-devel.sha256sum] = "767c515e6d171aec8ca9f1d5dd5d885f8f8eada929ff876ac258087e9f2875b0"

RDEPENDS:rust-which+default-devel = " \
 cargo \
 rust-which+real-sys-devel \
 rust-which-devel \
 "
RDEPENDS:rust-which+real-sys-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-which-devel \
 "
RDEPENDS:rust-which+regex-devel = " \
 cargo \
 rust-regex+default-devel \
 rust-which-devel \
 "
RDEPENDS:rust-which+tracing-devel = " \
 cargo \
 rust-tracing-devel \
 rust-which-devel \
 "
RDEPENDS:rust-which-devel = " \
 cargo \
 rust \
 "
