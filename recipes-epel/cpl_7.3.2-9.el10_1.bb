# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cpl"
PV = "7.3.2"
PR = "9.el10_1"
PACKAGES = " \
 cpl \
 cpl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cpl-7.3.2-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a1ac77575b668792091cf25e35e41ef6f63419724898acb2503f05e9df222be7"

URI_x86_64_v2_cpl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cpl-7.3.2-9.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cpl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cpl}"
SRC_URI[x86_64_v2_cpl.sha256sum] = "dc496fbb5c9ba26304dab53344d18eb8de623a05383ace1f324c0517ea64b4cb"

URI_x86_64_v2_cpl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cpl-devel-7.3.2-9.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cpl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cpl-devel}"
SRC_URI[x86_64_v2_cpl-devel.sha256sum] = "711f0206f9ef71c3050fdc467eae58776ccc92cf0867ad79bc1f45b132aefe41"

URI_aarch64_cpl = "${EPEL_MIRROR}/aarch64/Packages/c/cpl-7.3.2-9.el10_1.aarch64.rpm;name=aarch64_cpl;unpack=0"
SRC_URI:append = " ${URI_aarch64_cpl}"
SRC_URI[aarch64_cpl.sha256sum] = "bba628b79331c8f99a5e7c998e326244534c8717aed9a4d5468becb8552b4c35"

URI_aarch64_cpl-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cpl-devel-7.3.2-9.el10_1.aarch64.rpm;name=aarch64_cpl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cpl-devel}"
SRC_URI[aarch64_cpl-devel.sha256sum] = "4d68406efa85ce7ed882c6a85a5741076c787e382f18b5240f51a2fba22fb547"

RDEPENDS:cpl = " \
 cfitsio \
 fftw-libs-double \
 fftw-libs-single \
 glibc \
 libgcc \
 libgomp \
 wcslib \
 "
RDEPENDS:cpl-devel = " \
 cpl \
 pkgconf-pkg-config \
 "
