# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rust-embed-impl"
PV = "8.11.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-rust-embed-impl+debug-embed-devel \
 rust-rust-embed-impl+default-devel \
 rust-rust-embed-impl+deterministic-timestamps-devel \
 rust-rust-embed-impl+include-exclude-devel \
 rust-rust-embed-impl+interpolate-folder-path-devel \
 rust-rust-embed-impl+shellexpand-devel \
 rust-rust-embed-impl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rust-embed-impl-8.11.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd51204451c018a3b04a451f58a00973a6de863dff33e0333558a10eb852f934"

URI_x86_64_v2_rust-rust-embed-impl+debug-embed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-impl+debug-embed-devel-8.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-impl+debug-embed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-impl+debug-embed-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-impl+debug-embed-devel.sha256sum] = "f8e99bdaffee0b5822f5f8b0eb6c63f6f11368c9ecf7985ef375c7cfc06ba9f1"

URI_x86_64_v2_rust-rust-embed-impl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-impl+default-devel-8.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-impl+default-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-impl+default-devel.sha256sum] = "fdfd72823599f63a4fdf4cb99131636d70ac8c2bc264f0390f771cefbaf3c38c"

URI_x86_64_v2_rust-rust-embed-impl+deterministic-timestamps-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-impl+deterministic-timestamps-devel-8.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-impl+deterministic-timestamps-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-impl+deterministic-timestamps-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-impl+deterministic-timestamps-devel.sha256sum] = "1e3c8b12ed34dd510aadcfbee8e03e4696cbc00a1a494bd3df661082c1540030"

URI_x86_64_v2_rust-rust-embed-impl+include-exclude-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-impl+include-exclude-devel-8.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-impl+include-exclude-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-impl+include-exclude-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-impl+include-exclude-devel.sha256sum] = "649000d0b105239674de096976409ace22334f864429d1f384c72a868f17093b"

URI_x86_64_v2_rust-rust-embed-impl+interpolate-folder-path-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-impl+interpolate-folder-path-devel-8.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-impl+interpolate-folder-path-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-impl+interpolate-folder-path-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-impl+interpolate-folder-path-devel.sha256sum] = "a02f02cb6d3ad1bb745ace5221a8d5bcd26b9fec6b459250457fe7b6e8b8ac5e"

URI_x86_64_v2_rust-rust-embed-impl+shellexpand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-impl+shellexpand-devel-8.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-impl+shellexpand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-impl+shellexpand-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-impl+shellexpand-devel.sha256sum] = "a3fde27ac9cce3ce765e6b2c8b5e22d0a3af89140aec5c6d8090415751ee2ba3"

URI_x86_64_v2_rust-rust-embed-impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-impl-devel-8.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-impl-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-impl-devel.sha256sum] = "ae050e2d1ba969a53cb69f69da38c4e01be0f4c4a19148d2c04d8fb81df73348"

URI_aarch64_rust-rust-embed-impl+debug-embed-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-impl+debug-embed-devel-8.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust-embed-impl+debug-embed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-impl+debug-embed-devel}"
SRC_URI[aarch64_rust-rust-embed-impl+debug-embed-devel.sha256sum] = "b6ac3ec79875491345f779d650f60e77a46b2b154529f83a4060ee26fd5a8d2e"

URI_aarch64_rust-rust-embed-impl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-impl+default-devel-8.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust-embed-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-impl+default-devel}"
SRC_URI[aarch64_rust-rust-embed-impl+default-devel.sha256sum] = "d9e3a09df84f33f36e35794d8762f7b90ef7a47e2869bdcacb255b211ccd7ba3"

URI_aarch64_rust-rust-embed-impl+deterministic-timestamps-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-impl+deterministic-timestamps-devel-8.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust-embed-impl+deterministic-timestamps-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-impl+deterministic-timestamps-devel}"
SRC_URI[aarch64_rust-rust-embed-impl+deterministic-timestamps-devel.sha256sum] = "727abb3934080feecb0796542c9cf054b37713205e1179446fac775aa903b5e7"

URI_aarch64_rust-rust-embed-impl+include-exclude-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-impl+include-exclude-devel-8.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust-embed-impl+include-exclude-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-impl+include-exclude-devel}"
SRC_URI[aarch64_rust-rust-embed-impl+include-exclude-devel.sha256sum] = "726b2c286b38f01556334c7af7ee2addbf3a1e5e9d1568d3aa66d7627ef67a44"

URI_aarch64_rust-rust-embed-impl+interpolate-folder-path-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-impl+interpolate-folder-path-devel-8.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust-embed-impl+interpolate-folder-path-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-impl+interpolate-folder-path-devel}"
SRC_URI[aarch64_rust-rust-embed-impl+interpolate-folder-path-devel.sha256sum] = "b4c9b0bad23aa19514a9faabe16549e075eb445875c300d681a3d1d8a2992a32"

URI_aarch64_rust-rust-embed-impl+shellexpand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-impl+shellexpand-devel-8.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust-embed-impl+shellexpand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-impl+shellexpand-devel}"
SRC_URI[aarch64_rust-rust-embed-impl+shellexpand-devel.sha256sum] = "d7b1427f67302cb36baa18f27d4c29dac34cfcffc7b7e6954c1c8e9489fda80d"

URI_aarch64_rust-rust-embed-impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-impl-devel-8.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust-embed-impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-impl-devel}"
SRC_URI[aarch64_rust-rust-embed-impl-devel.sha256sum] = "b8370182d495b1ecc1e2ce4c4ad83b740b3c5a7e469cf8194c1a19ec7c2dbd6d"

RDEPENDS:rust-rust-embed-impl+debug-embed-devel = " \
 cargo \
 rust-rust-embed-impl-devel \
 "
RDEPENDS:rust-rust-embed-impl+default-devel = " \
 cargo \
 rust-rust-embed-impl-devel \
 "
RDEPENDS:rust-rust-embed-impl+deterministic-timestamps-devel = " \
 cargo \
 rust-rust-embed-impl-devel \
 "
RDEPENDS:rust-rust-embed-impl+include-exclude-devel = " \
 cargo \
 rust-rust-embed-impl-devel \
 rust-rust-embed-utils+include-exclude-devel \
 "
RDEPENDS:rust-rust-embed-impl+interpolate-folder-path-devel = " \
 cargo \
 rust-rust-embed-impl+shellexpand-devel \
 rust-rust-embed-impl-devel \
 "
RDEPENDS:rust-rust-embed-impl+shellexpand-devel = " \
 cargo \
 rust-rust-embed-impl-devel \
 rust-shellexpand+default-devel \
 "
RDEPENDS:rust-rust-embed-impl-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-rust-embed-utils+default-devel \
 rust-syn+derive-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 rust-walkdir+default-devel \
 "
