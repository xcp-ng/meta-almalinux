# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtwebsockets"
PV = "6.8.1"
PR = "2.el10"
PACKAGES = " \
 qt6-qtwebsockets \
 qt6-qtwebsockets-devel \
 qt6-qtwebsockets-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtwebsockets-6.8.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ddf3c97399c9f6eba069a3126d829786af5b36350e060a4e5f5bcdb6848f735d"

URI_x86_64_v2_qt6-qtwebsockets = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtwebsockets-6.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebsockets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebsockets}"
SRC_URI[x86_64_v2_qt6-qtwebsockets.sha256sum] = "c0a5734517bdfed80ee8447e1e442d3fab40136df5756c0e5b45f6135e4887c0"

URI_x86_64_v2_qt6-qtwebsockets-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtwebsockets-devel-6.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebsockets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebsockets-devel}"
SRC_URI[x86_64_v2_qt6-qtwebsockets-devel.sha256sum] = "f63be04021a65e363949bd5a5231f40d8404e1b19a7c1b180d817313e1513739"

URI_x86_64_v2_qt6-qtwebsockets-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtwebsockets-examples-6.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebsockets-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebsockets-examples}"
SRC_URI[x86_64_v2_qt6-qtwebsockets-examples.sha256sum] = "a097f5ce7e35e0a735a0484faaf6c92476817a5a208ca003ec2e5e4738dde2e6"

URI_aarch64_qt6-qtwebsockets = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtwebsockets-6.8.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtwebsockets;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebsockets}"
SRC_URI[aarch64_qt6-qtwebsockets.sha256sum] = "690e96cc66a07a4a9b47d99c2d50dd266f14226fde6e9685dbce2ba3195e521f"

URI_aarch64_qt6-qtwebsockets-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtwebsockets-devel-6.8.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtwebsockets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebsockets-devel}"
SRC_URI[aarch64_qt6-qtwebsockets-devel.sha256sum] = "e2252f3184e13fe1cbd9230a4796fa88157ac0df90ed054f166d05dbb43de3a0"

URI_aarch64_qt6-qtwebsockets-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtwebsockets-examples-6.8.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtwebsockets-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebsockets-examples}"
SRC_URI[aarch64_qt6-qtwebsockets-examples.sha256sum] = "b168e75abafff282dcf63401d93f47ef4b7dc029d415f1b45c819fcabdbe4798"

RDEPENDS:qt6-qtwebsockets = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:qt6-qtwebsockets-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtdeclarative \
 qt6-qtwebsockets \
 "
RDEPENDS:qt6-qtwebsockets-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebsockets \
 "
