# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-connections"
PV = "47.2.1"
PR = "1.el10"
PACKAGES = " \
 gnome-connections \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-connections-47.2.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b7346341ee1c4523ebd9e62526a2b970393c9a347af8e84cda68a8ac1e4919e"

URI_x86_64_v2_gnome-connections = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-connections-47.2.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-connections;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-connections}"
SRC_URI[x86_64_v2_gnome-connections.sha256sum] = "1d4e3e16ba28bc942a376a9d6a1c8eebd6aa570508e5a90b9697b02ebe065ee7"

URI_aarch64_gnome-connections = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-connections-47.2.1-1.el10.aarch64.rpm;name=aarch64_gnome-connections;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-connections}"
SRC_URI[aarch64_gnome-connections.sha256sum] = "c21bb82f7503fde89de493e69967d8e0b4baed130a0d6a9d133315cc344b4db5"

RDEPENDS:gnome-connections = " \
 cairo \
 freerdp-libs \
 fuse3-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk-vnc2 \
 gtk3 \
 gvnc \
 gvncpulse \
 hicolor-icon-theme \
 libhandy \
 libsecret \
 libwinpr \
 libxml2 \
 "
