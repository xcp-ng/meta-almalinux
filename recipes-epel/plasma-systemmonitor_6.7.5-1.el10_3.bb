# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-systemmonitor"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 plasma-systemmonitor \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma-systemmonitor-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "33600dc211184b3a5dd3ffc2447e7f89cef371b06f7bad3639f5054a6c94864e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-systemmonitor-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-systemmonitor;unpack=0"
SRC_URI[x86_64_v2_plasma-systemmonitor.sha256sum] = "92927a828e5e4636eca66334ae3ea9e0941810f70758bfdd26c1410247258ae6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-systemmonitor-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-systemmonitor;unpack=0"
SRC_URI[aarch64_plasma-systemmonitor.sha256sum] = "967b462cd797061625c48161007693dd03158e8882a5e45d2c012e62207e73ac"

RDEPENDS:plasma-systemmonitor = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-knewstuff \
 kf6-kquickcharts \
 kf6-kservice \
 kf6-kwindowsystem \
 ksystemstats \
 libksysguard \
 libstdc++ \
 python3 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
