# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-matchit0.7"
PV = "0.7.3"
PR = "3.el10_0"
PACKAGES = " \
 rust-matchit0.7+default-devel \
 rust-matchit0.7-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-matchit0.7-0.7.3-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f79021aefc38217482655dc7c1babb881fe12c313914144221a437c3af687ff"

URI_x86_64_v2_rust-matchit0.7+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matchit0.7+default-devel-0.7.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matchit0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matchit0.7+default-devel}"
SRC_URI[x86_64_v2_rust-matchit0.7+default-devel.sha256sum] = "5c939eaa23ff9156439bd6b098f358daded6edc4f0a5867d1705b21a7db3cd12"

URI_x86_64_v2_rust-matchit0.7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matchit0.7-devel-0.7.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matchit0.7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matchit0.7-devel}"
SRC_URI[x86_64_v2_rust-matchit0.7-devel.sha256sum] = "687ef26a1d7d4e7f97ef63896527c0cf1803144bc13e051f5d784a316934136a"

URI_aarch64_rust-matchit0.7+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matchit0.7+default-devel-0.7.3-3.el10_0.noarch.rpm;name=aarch64_rust-matchit0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matchit0.7+default-devel}"
SRC_URI[aarch64_rust-matchit0.7+default-devel.sha256sum] = "0e0025d9df6d918452cd51af0484947811c85d19c11b955045f83cc0a654d895"

URI_aarch64_rust-matchit0.7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matchit0.7-devel-0.7.3-3.el10_0.noarch.rpm;name=aarch64_rust-matchit0.7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matchit0.7-devel}"
SRC_URI[aarch64_rust-matchit0.7-devel.sha256sum] = "a1e3d65b1bcbf5f87ed722087d663cd2ef1824ba814dc4b701a1c4fec928cfde"

RDEPENDS:rust-matchit0.7+default-devel = " \
 cargo \
 rust-matchit0.7-devel \
 "
RDEPENDS:rust-matchit0.7-devel = " \
 cargo \
 "
