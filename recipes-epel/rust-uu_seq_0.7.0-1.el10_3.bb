# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_seq"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_seq+default-devel \
 rust-uu_seq-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_seq-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1bc58713d2a39b54864242fc36258a2cf5217cbcbe9d04fea1748021447a6e11"

URI_x86_64_v2_rust-uu_seq+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_seq+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_seq+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_seq+default-devel}"
SRC_URI[x86_64_v2_rust-uu_seq+default-devel.sha256sum] = "b71d4cf81bf2298e66fc10d02f6230a1707de0a00a0f6691f8428cad3dfe85e2"

URI_x86_64_v2_rust-uu_seq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_seq-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_seq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_seq-devel}"
SRC_URI[x86_64_v2_rust-uu_seq-devel.sha256sum] = "7b0eaa3f69c5233754e4d189272f7555debc864883949326d06d6c71844fb3e6"

URI_aarch64_rust-uu_seq+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_seq+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_seq+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_seq+default-devel}"
SRC_URI[aarch64_rust-uu_seq+default-devel.sha256sum] = "0c48c07f71f624fe285b04baa826fe459da08c02fa7a3ec11fc02b6e37ff6f0b"

URI_aarch64_rust-uu_seq-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_seq-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_seq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_seq-devel}"
SRC_URI[aarch64_rust-uu_seq-devel.sha256sum] = "cebbd8ae71d8566f4db2a480add5252095052ce3c72e76ae2f272955ef5d3ee2"

RDEPENDS:rust-uu_seq+default-devel = " \
 cargo \
 rust-uu_seq-devel \
 "
RDEPENDS:rust-uu_seq-devel = " \
 cargo \
 rust \
 rust-bigdecimal+default-devel \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-num-bigint+default-devel \
 rust-num-traits+default-devel \
 rust-thiserror+default-devel \
 rust-uucore+default-devel \
 rust-uucore+extendedbigdecimal-devel \
 rust-uucore+fast-inc-devel \
 rust-uucore+format-devel \
 rust-uucore+parser-devel \
 rust-uucore+quoting-style-devel \
 rust-uucore+signals-devel \
 "
