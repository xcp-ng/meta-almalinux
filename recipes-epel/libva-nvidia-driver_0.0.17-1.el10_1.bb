# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libva-nvidia-driver"
PV = "0.0.17"
PR = "1.el10_1"
PACKAGES = " \
 libva-nvidia-driver \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libva-nvidia-driver-0.0.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bec7bb65f150ea4b752e3b73652be3a1fdacde6b0018920353ee4b4ffe664849"

URI_x86_64_v2_libva-nvidia-driver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libva-nvidia-driver-0.0.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libva-nvidia-driver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libva-nvidia-driver}"
SRC_URI[x86_64_v2_libva-nvidia-driver.sha256sum] = "ff532156ea99573ef1ebf2f8a45969e15a387b39d356ec94177a96f33f0d8cb3"

URI_aarch64_libva-nvidia-driver = "${EPEL_MIRROR}/aarch64/Packages/l/libva-nvidia-driver-0.0.17-1.el10_1.aarch64.rpm;name=aarch64_libva-nvidia-driver;unpack=0"
SRC_URI:append = " ${URI_aarch64_libva-nvidia-driver}"
SRC_URI[aarch64_libva-nvidia-driver.sha256sum] = "88d756f6b3647061043de2083c131c1f1e44e086d1af56c6d3b71d1d7b056107"

RDEPENDS:libva-nvidia-driver = " \
 glibc \
 gstreamer1-plugins-bad-free-libs \
 libglvnd-egl \
 "
