# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vala"
PV = "0.56.18"
PR = "1.el10"
PACKAGES = " \
 libvala \
 libvala-devel \
 vala \
 vala-doc \
 valadoc \
 valadoc-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/vala-0.56.18-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "11a487dbc31ed2239f8072793384c7710cdc3aca17793872c6fdb3a1d70d5913"

URI_x86_64_v2_libvala = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libvala-0.56.18-1.el10.x86_64_v2.rpm;name=x86_64_v2_libvala;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvala}"
SRC_URI[x86_64_v2_libvala.sha256sum] = "5a974aeef1412b0e3c96f72d5a2f58f22a45e11b2494ab64fe84a9fbebdb7f1a"

URI_x86_64_v2_libvala-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libvala-devel-0.56.18-1.el10.x86_64_v2.rpm;name=x86_64_v2_libvala-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvala-devel}"
SRC_URI[x86_64_v2_libvala-devel.sha256sum] = "dd17a912e28e485dd10c0f71cb189a562c74d3a864969bc229f703eb91a56271"

URI_x86_64_v2_vala = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/vala-0.56.18-1.el10.x86_64_v2.rpm;name=x86_64_v2_vala;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vala}"
SRC_URI[x86_64_v2_vala.sha256sum] = "e31df475bcd0603267e9ed078d887546011a79c456361247d3f9f123d3cf102b"

URI_x86_64_v2_vala-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/vala-doc-0.56.18-1.el10.noarch.rpm;name=x86_64_v2_vala-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vala-doc}"
SRC_URI[x86_64_v2_vala-doc.sha256sum] = "e39b11b83d6f5faacb262fb94a57585498536aa57b4e03d2f45cdead9625ccbc"

URI_x86_64_v2_valadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/valadoc-0.56.18-1.el10.x86_64_v2.rpm;name=x86_64_v2_valadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_valadoc}"
SRC_URI[x86_64_v2_valadoc.sha256sum] = "a253e999f88b318c3d841f5c4994e5e6941c8f796a86c7483c239f032173e685"

URI_x86_64_v2_valadoc-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/valadoc-devel-0.56.18-1.el10.x86_64_v2.rpm;name=x86_64_v2_valadoc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_valadoc-devel}"
SRC_URI[x86_64_v2_valadoc-devel.sha256sum] = "95eb0ba71b2de59f753fdfc523f8ba5038bc9a585a9791c21d5bd128469d7514"

URI_aarch64_libvala = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libvala-0.56.18-1.el10.aarch64.rpm;name=aarch64_libvala;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvala}"
SRC_URI[aarch64_libvala.sha256sum] = "74cbe0621539917ad50b46dca9d9bad8345bd18dc17492b5e254d1892d4eacc1"

URI_aarch64_libvala-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libvala-devel-0.56.18-1.el10.aarch64.rpm;name=aarch64_libvala-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvala-devel}"
SRC_URI[aarch64_libvala-devel.sha256sum] = "5fcd2b0a1154d92a5a370d2d9f719935864839020de0e0c123aff2ac1c5938fa"

URI_aarch64_vala = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/vala-0.56.18-1.el10.aarch64.rpm;name=aarch64_vala;unpack=0"
SRC_URI:append = " ${URI_aarch64_vala}"
SRC_URI[aarch64_vala.sha256sum] = "7fb8d695072fd82afcdd35e0baf7ff2dda422ce51c6bbcdc9a7855fec6ae134c"

URI_aarch64_vala-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/vala-doc-0.56.18-1.el10.noarch.rpm;name=aarch64_vala-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_vala-doc}"
SRC_URI[aarch64_vala-doc.sha256sum] = "e39b11b83d6f5faacb262fb94a57585498536aa57b4e03d2f45cdead9625ccbc"

URI_aarch64_valadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/valadoc-0.56.18-1.el10.aarch64.rpm;name=aarch64_valadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_valadoc}"
SRC_URI[aarch64_valadoc.sha256sum] = "57e97220c54a8df1feaaefd8a8aa6fe66e970eca72e62a090bbd45300f2341f4"

URI_aarch64_valadoc-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/valadoc-devel-0.56.18-1.el10.aarch64.rpm;name=aarch64_valadoc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_valadoc-devel}"
SRC_URI[aarch64_valadoc-devel.sha256sum] = "644a1e9129da9cffbaebdb2fe015f2d3a672dca3a6652327cf1d71a771686f7a"

RDEPENDS:libvala = " \
 glib2 \
 glibc \
 libgcc \
 "
RDEPENDS:libvala-devel = " \
 glib2-devel \
 libvala \
 pkgconf-pkg-config \
 "
RDEPENDS:vala = " \
 bash \
 glib2 \
 glibc \
 gobject-introspection-devel \
 libvala \
 pkgconf-pkg-config \
 "
RDEPENDS:vala-doc = " \
 vala \
 "
RDEPENDS:valadoc = " \
 glib2 \
 glibc \
 graphviz \
 libvala \
 vala \
 "
RDEPENDS:valadoc-devel = " \
 glib2-devel \
 graphviz-devel \
 libvala-devel \
 pkgconf-pkg-config \
 valadoc \
 "
