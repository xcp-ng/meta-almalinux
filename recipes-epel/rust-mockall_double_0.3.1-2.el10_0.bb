# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mockall_double"
PV = "0.3.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-mockall_double+default-devel \
 rust-mockall_double-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mockall_double-0.3.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b68776a7ab53e695a952dc9d675ca5d983db587a310c4f948b1bf1087467eec"

URI_x86_64_v2_rust-mockall_double+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mockall_double+default-devel-0.3.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mockall_double+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mockall_double+default-devel}"
SRC_URI[x86_64_v2_rust-mockall_double+default-devel.sha256sum] = "a0a75d00aa7a9d80075b0d2fdeac42c48e89e6e3a17bcdae18d1a0c766ddd7b1"

URI_x86_64_v2_rust-mockall_double-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mockall_double-devel-0.3.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mockall_double-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mockall_double-devel}"
SRC_URI[x86_64_v2_rust-mockall_double-devel.sha256sum] = "fefab17d7e49717b0a0cae5395cad0b699a3524dd96142b791e9bf759304b336"

URI_aarch64_rust-mockall_double+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mockall_double+default-devel-0.3.1-2.el10_0.noarch.rpm;name=aarch64_rust-mockall_double+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mockall_double+default-devel}"
SRC_URI[aarch64_rust-mockall_double+default-devel.sha256sum] = "f793f3761ae824d4b9f66e0b7145acc76b15026f3aa403070b8f471e56cc98fa"

URI_aarch64_rust-mockall_double-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mockall_double-devel-0.3.1-2.el10_0.noarch.rpm;name=aarch64_rust-mockall_double-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mockall_double-devel}"
SRC_URI[aarch64_rust-mockall_double-devel.sha256sum] = "ab1d80bd3bd17f943c0a9b8adb820378496045741b9c270a5a671c8afb2044f6"

RDEPENDS:rust-mockall_double+default-devel = " \
 cargo \
 rust-mockall_double-devel \
 "
RDEPENDS:rust-mockall_double-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+full-devel \
 "
