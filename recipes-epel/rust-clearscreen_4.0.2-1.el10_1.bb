# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clearscreen"
PV = "4.0.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-clearscreen+default-devel \
 rust-clearscreen-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clearscreen-4.0.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "10b4c38589249773ac0b5b2a33bffff8920be3d4e5db85753ae41432afdc9608"

URI_x86_64_v2_rust-clearscreen+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clearscreen+default-devel-4.0.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clearscreen+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clearscreen+default-devel}"
SRC_URI[x86_64_v2_rust-clearscreen+default-devel.sha256sum] = "a65c9f862fdf4d39f2aafa8d3b91cd2af9f517f7c4577d06422dd01697796031"

URI_x86_64_v2_rust-clearscreen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clearscreen-devel-4.0.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clearscreen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clearscreen-devel}"
SRC_URI[x86_64_v2_rust-clearscreen-devel.sha256sum] = "417507f8c2932d5477199038354332cebc996066d3194e3f29e8f20292217830"

URI_aarch64_rust-clearscreen+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clearscreen+default-devel-4.0.2-1.el10_1.noarch.rpm;name=aarch64_rust-clearscreen+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clearscreen+default-devel}"
SRC_URI[aarch64_rust-clearscreen+default-devel.sha256sum] = "2f1982cfb0d5e222ddb0c470eae4ee956050c2098bfd190d2e846194fe1950f7"

URI_aarch64_rust-clearscreen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clearscreen-devel-4.0.2-1.el10_1.noarch.rpm;name=aarch64_rust-clearscreen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clearscreen-devel}"
SRC_URI[aarch64_rust-clearscreen-devel.sha256sum] = "4794a1d77328ce14fa201d9966a686ea5494d083d0ba4c408ec8442d7333449c"

RDEPENDS:rust-clearscreen+default-devel = " \
 cargo \
 rust-clearscreen-devel \
 "
RDEPENDS:rust-clearscreen-devel = " \
 cargo \
 rust \
 rust-nix0.29+fs-devel \
 rust-nix0.29+term-devel \
 rust-nix0.29-devel \
 rust-terminfo+default-devel \
 rust-thiserror+default-devel \
 rust-which+default-devel \
 "
