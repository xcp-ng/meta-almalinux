# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_core0.6"
PV = "0.6.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-rand_core0.6+alloc-devel \
 rust-rand_core0.6+default-devel \
 rust-rand_core0.6+getrandom-devel \
 rust-rand_core0.6+serde-devel \
 rust-rand_core0.6+serde1-devel \
 rust-rand_core0.6+std-devel \
 rust-rand_core0.6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_core0.6-0.6.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "615e812a18441360c725bd1198b7d1d20e2cab7db52feefb16f53777401bbf8a"

URI_x86_64_v2_rust-rand_core0.6+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_core0.6+alloc-devel-0.6.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_core0.6+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_core0.6+alloc-devel}"
SRC_URI[x86_64_v2_rust-rand_core0.6+alloc-devel.sha256sum] = "f8c8778e231a11c064d56af1c18c0566b7663078b65f2add62216c1772063ba4"

URI_x86_64_v2_rust-rand_core0.6+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_core0.6+default-devel-0.6.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_core0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_core0.6+default-devel}"
SRC_URI[x86_64_v2_rust-rand_core0.6+default-devel.sha256sum] = "5249667c629851490f59e41d3dd3a2a0c877b40bc157b36b62d523a8d340e05a"

URI_x86_64_v2_rust-rand_core0.6+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_core0.6+getrandom-devel-0.6.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_core0.6+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_core0.6+getrandom-devel}"
SRC_URI[x86_64_v2_rust-rand_core0.6+getrandom-devel.sha256sum] = "12c7829b47f458ed89cc40d3928b6ad245ca3f0a1ad591e51a3aa46c1da71bee"

URI_x86_64_v2_rust-rand_core0.6+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_core0.6+serde-devel-0.6.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_core0.6+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_core0.6+serde-devel}"
SRC_URI[x86_64_v2_rust-rand_core0.6+serde-devel.sha256sum] = "c0fdb061376d3a9f061b189c1ac6e3170e8a6cf692cf084292bd1836d5836c5d"

URI_x86_64_v2_rust-rand_core0.6+serde1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_core0.6+serde1-devel-0.6.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_core0.6+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_core0.6+serde1-devel}"
SRC_URI[x86_64_v2_rust-rand_core0.6+serde1-devel.sha256sum] = "43b07d3aa7dbcc802cdb599578730870c2430e770db3739bb681e432f59c8022"

URI_x86_64_v2_rust-rand_core0.6+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_core0.6+std-devel-0.6.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_core0.6+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_core0.6+std-devel}"
SRC_URI[x86_64_v2_rust-rand_core0.6+std-devel.sha256sum] = "8b565141f51492acc441658bd8b9ac45214da30e9284afd4d06fec1706b1217d"

URI_x86_64_v2_rust-rand_core0.6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_core0.6-devel-0.6.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_core0.6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_core0.6-devel}"
SRC_URI[x86_64_v2_rust-rand_core0.6-devel.sha256sum] = "4618175906a0e1c71a23590741aa37daf8a9dbdb1638a995ea0a2f3a806a4411"

URI_aarch64_rust-rand_core0.6+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_core0.6+alloc-devel-0.6.4-1.el10_0.noarch.rpm;name=aarch64_rust-rand_core0.6+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_core0.6+alloc-devel}"
SRC_URI[aarch64_rust-rand_core0.6+alloc-devel.sha256sum] = "dbf3ffb0925ca03ebb7fb8d0023143f200011f5cc9c659a7a64414c01735d4d1"

URI_aarch64_rust-rand_core0.6+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_core0.6+default-devel-0.6.4-1.el10_0.noarch.rpm;name=aarch64_rust-rand_core0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_core0.6+default-devel}"
SRC_URI[aarch64_rust-rand_core0.6+default-devel.sha256sum] = "a9220741119432ef36050572484ed3938d987d2617dfcabccf72e378175abebc"

URI_aarch64_rust-rand_core0.6+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_core0.6+getrandom-devel-0.6.4-1.el10_0.noarch.rpm;name=aarch64_rust-rand_core0.6+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_core0.6+getrandom-devel}"
SRC_URI[aarch64_rust-rand_core0.6+getrandom-devel.sha256sum] = "ded3e061dd4b6c90073fec5ce4bbdf2ac0cf02c64a367410c4ffd3e62f972f2a"

URI_aarch64_rust-rand_core0.6+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_core0.6+serde-devel-0.6.4-1.el10_0.noarch.rpm;name=aarch64_rust-rand_core0.6+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_core0.6+serde-devel}"
SRC_URI[aarch64_rust-rand_core0.6+serde-devel.sha256sum] = "9f93c8bebef5359b50150029376a81dd11d035b496c5042505b73f6db22aa530"

URI_aarch64_rust-rand_core0.6+serde1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_core0.6+serde1-devel-0.6.4-1.el10_0.noarch.rpm;name=aarch64_rust-rand_core0.6+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_core0.6+serde1-devel}"
SRC_URI[aarch64_rust-rand_core0.6+serde1-devel.sha256sum] = "a9edbfd98538867965a17a5e478b7214fa403e656dbdb17d81e3c5478d881173"

URI_aarch64_rust-rand_core0.6+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_core0.6+std-devel-0.6.4-1.el10_0.noarch.rpm;name=aarch64_rust-rand_core0.6+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_core0.6+std-devel}"
SRC_URI[aarch64_rust-rand_core0.6+std-devel.sha256sum] = "9087cbbaff2d719d3c4008f6bb9bedead217a34df537e1eeb8403042559b0932"

URI_aarch64_rust-rand_core0.6-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_core0.6-devel-0.6.4-1.el10_0.noarch.rpm;name=aarch64_rust-rand_core0.6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_core0.6-devel}"
SRC_URI[aarch64_rust-rand_core0.6-devel.sha256sum] = "eebea50a0b44482f6879729fd8460e1315b9c8b78746b1196765d64affc8b715"

RDEPENDS:rust-rand_core0.6+alloc-devel = " \
 cargo \
 rust-rand_core0.6-devel \
 "
RDEPENDS:rust-rand_core0.6+default-devel = " \
 cargo \
 rust-rand_core0.6-devel \
 "
RDEPENDS:rust-rand_core0.6+getrandom-devel = " \
 cargo \
 rust-getrandom0.2+default-devel \
 rust-rand_core0.6-devel \
 "
RDEPENDS:rust-rand_core0.6+serde-devel = " \
 cargo \
 rust-rand_core0.6-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand_core0.6+serde1-devel = " \
 cargo \
 rust-rand_core0.6+serde-devel \
 rust-rand_core0.6-devel \
 "
RDEPENDS:rust-rand_core0.6+std-devel = " \
 cargo \
 rust-getrandom0.2+default-devel \
 rust-getrandom0.2+std-devel \
 rust-rand_core0.6+alloc-devel \
 rust-rand_core0.6+getrandom-devel \
 rust-rand_core0.6-devel \
 "
RDEPENDS:rust-rand_core0.6-devel = " \
 cargo \
 "
