# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-backrefs"
PV = "6.1"
PR = "1.el10_2"
PACKAGES = " \
 python3-backrefs \
 python3-backrefs+extras \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-backrefs-6.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "93b491b60c9ffbd71705fb7a94aba7d15dfc8d32c29b9c2ebc28a0dae23e1b06"

URI_x86_64_v2_python3-backrefs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-backrefs-6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-backrefs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-backrefs}"
SRC_URI[x86_64_v2_python3-backrefs.sha256sum] = "735660add6d2a2664aef8a730970ab37ee3ab8cb8ada68241c37497d269ff9bd"

URI_x86_64_v2_python3-backrefs+extras = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-backrefs+extras-6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-backrefs+extras;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-backrefs+extras}"
SRC_URI[x86_64_v2_python3-backrefs+extras.sha256sum] = "c5ff424c2f48ba1328771dee51e863eccc8673e7aebf923bad390c4c7f2a89a7"

URI_aarch64_python3-backrefs = "${EPEL_MIRROR}/aarch64/Packages/p/python3-backrefs-6.1-1.el10_2.noarch.rpm;name=aarch64_python3-backrefs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-backrefs}"
SRC_URI[aarch64_python3-backrefs.sha256sum] = "b0597d0bafd3d437c9eb9ba854cc844ae2ded455c88d65fcd69df21990355cb5"

URI_aarch64_python3-backrefs+extras = "${EPEL_MIRROR}/aarch64/Packages/p/python3-backrefs+extras-6.1-1.el10_2.noarch.rpm;name=aarch64_python3-backrefs+extras;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-backrefs+extras}"
SRC_URI[aarch64_python3-backrefs+extras.sha256sum] = "01e26c1c2866ec1321fd6f8e99ef31d4dc41c06ca5d1c7d57b6157691cf2979c"

RDEPENDS:python3-backrefs = " \
 python3 \
 "
RDEPENDS:python3-backrefs+extras = " \
 python3 \
 python3-backrefs \
 python3-regex \
 "
