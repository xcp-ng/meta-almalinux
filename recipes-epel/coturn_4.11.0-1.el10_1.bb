# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "coturn"
PV = "4.11.0"
PR = "1.el10_1"
PACKAGES = " \
 coturn \
 coturn-client-devel \
 coturn-client-libs \
 coturn-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/coturn-4.11.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7513b81f014bf75f854a11a6bfa8953c30c3509f61380d9b44b2caa1541ebdff"

URI_x86_64_v2_coturn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/coturn-4.11.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_coturn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_coturn}"
SRC_URI[x86_64_v2_coturn.sha256sum] = "38626d7b77602a36ec2329bfcb1d5399e5c8a99ff8ce6761165b91ce603d3088"

URI_x86_64_v2_coturn-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/coturn-client-devel-4.11.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_coturn-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_coturn-client-devel}"
SRC_URI[x86_64_v2_coturn-client-devel.sha256sum] = "2a417c0b3f07d583f44d7d1d2a21ecbb861817c769c6e638c938165d1e12a3f6"

URI_x86_64_v2_coturn-client-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/coturn-client-libs-4.11.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_coturn-client-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_coturn-client-libs}"
SRC_URI[x86_64_v2_coturn-client-libs.sha256sum] = "f8859874a6b5954923e97434c4d11490bf6d73f46c8675e6886ce0144f829172"

URI_x86_64_v2_coturn-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/coturn-utils-4.11.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_coturn-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_coturn-utils}"
SRC_URI[x86_64_v2_coturn-utils.sha256sum] = "6658f02170f69d71d194bc3ae209c90e1db3972fdf4a8619da548301153e8a2b"

URI_aarch64_coturn = "${EPEL_MIRROR}/aarch64/Packages/c/coturn-4.11.0-1.el10_1.aarch64.rpm;name=aarch64_coturn;unpack=0"
SRC_URI:append = " ${URI_aarch64_coturn}"
SRC_URI[aarch64_coturn.sha256sum] = "fc83654ef6bd92fa13d69da50b8c0251292ae202f2f4670eb0b2126d3c59630e"

URI_aarch64_coturn-client-devel = "${EPEL_MIRROR}/aarch64/Packages/c/coturn-client-devel-4.11.0-1.el10_1.aarch64.rpm;name=aarch64_coturn-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_coturn-client-devel}"
SRC_URI[aarch64_coturn-client-devel.sha256sum] = "7bbd0147f01a0623e6d84113c35eedfe0232c5e85b36e148ab0e2c27e5f4395a"

URI_aarch64_coturn-client-libs = "${EPEL_MIRROR}/aarch64/Packages/c/coturn-client-libs-4.11.0-1.el10_1.aarch64.rpm;name=aarch64_coturn-client-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_coturn-client-libs}"
SRC_URI[aarch64_coturn-client-libs.sha256sum] = "bee1492a081cebd35146925a7a650fb6a112571cb7a80d77b0d3dc362a9f0dcb"

URI_aarch64_coturn-utils = "${EPEL_MIRROR}/aarch64/Packages/c/coturn-utils-4.11.0-1.el10_1.aarch64.rpm;name=aarch64_coturn-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_coturn-utils}"
SRC_URI[aarch64_coturn-utils.sha256sum] = "faf5435d9dc46b93348ae4332476d402a56157407f470a00074b05fc52f4df8e"

RDEPENDS:coturn = " \
 bash \
 glibc \
 hiredis \
 libevent \
 libpq \
 mariadb-connector-c \
 openssl-libs \
 shadow-utils \
 sqlite-libs \
 systemd \
 systemd-libs \
 "
RDEPENDS:coturn-client-devel = " \
 "
RDEPENDS:coturn-client-libs = " \
 "
RDEPENDS:coturn-utils = " \
 glibc \
 libevent \
 openssl-libs \
 "
