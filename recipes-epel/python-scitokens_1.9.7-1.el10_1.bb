# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-scitokens"
PV = "1.9.7"
PR = "1.el10_1"
PACKAGES = " \
 python3-scitokens \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-scitokens-1.9.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7aca0ea651118a372e742d3f271b32bc0c4116fda15dacebc2ece3bf1977d487"

URI_x86_64_v2_python3-scitokens = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-scitokens-1.9.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-scitokens;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-scitokens}"
SRC_URI[x86_64_v2_python3-scitokens.sha256sum] = "99fab0086a6809d9964d76b88002fc257359b3dda16086248bb41ffeb1c167fb"

URI_aarch64_python3-scitokens = "${EPEL_MIRROR}/aarch64/Packages/p/python3-scitokens-1.9.7-1.el10_1.noarch.rpm;name=aarch64_python3-scitokens;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-scitokens}"
SRC_URI[aarch64_python3-scitokens.sha256sum] = "0074a1f2b6e4c93bed508931b8e1c1b6e4bb15bb7a5563ce1a110fb25de6c277"

RDEPENDS:python3-scitokens = " \
 python3 \
 python3-cryptography \
 python3-jwt \
 python3-requests \
 "
