# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-metaclass"
PV = "0.0.4"
PR = "21.el10_2"
PACKAGES = " \
 rubygem-metaclass \
 rubygem-metaclass-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-metaclass-0.0.4-21.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "387bab646bbfe35936d143d52203a8e57f82619606777220101bc6ff60b5efea"

URI_x86_64_v2_rubygem-metaclass = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-metaclass-0.0.4-21.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-metaclass;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-metaclass}"
SRC_URI[x86_64_v2_rubygem-metaclass.sha256sum] = "007940cb788d246cdff8bcf6f3c64f7ce2e9e25738239d3385c190574b34e495"

URI_x86_64_v2_rubygem-metaclass-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-metaclass-doc-0.0.4-21.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-metaclass-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-metaclass-doc}"
SRC_URI[x86_64_v2_rubygem-metaclass-doc.sha256sum] = "1871f763374a5d4922e6b10519eca9ab07914bae310f1b14d66f583e83ebc817"

URI_aarch64_rubygem-metaclass = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-metaclass-0.0.4-21.el10_2.noarch.rpm;name=aarch64_rubygem-metaclass;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-metaclass}"
SRC_URI[aarch64_rubygem-metaclass.sha256sum] = "b0030b701bcd1eb01efccfd8114ce58573fe5653fed5ed3a9d2755f0eb2de155"

URI_aarch64_rubygem-metaclass-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-metaclass-doc-0.0.4-21.el10_2.noarch.rpm;name=aarch64_rubygem-metaclass-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-metaclass-doc}"
SRC_URI[aarch64_rubygem-metaclass-doc.sha256sum] = "8807aebbbe6b13090878051b5bc0131b41d006764dee23db3538fb775d89dd77"

RDEPENDS:rubygem-metaclass = " \
 rubygems \
 "
RDEPENDS:rubygem-metaclass-doc = " \
 rubygem-metaclass \
 "
