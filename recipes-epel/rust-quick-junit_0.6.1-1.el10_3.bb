# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-quick-junit"
PV = "0.6.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-quick-junit+default-devel \
 rust-quick-junit-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-quick-junit-0.6.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "51b74a8e1d9803aadfad37f65fcb3be1c7f632053bc47c1fc9d115f332f6111c"

URI_x86_64_v2_rust-quick-junit+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-junit+default-devel-0.6.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-junit+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-junit+default-devel}"
SRC_URI[x86_64_v2_rust-quick-junit+default-devel.sha256sum] = "8ec7577af29e1a22f7e3fcd679e8807c2e55220f7e9c54b82c5f9fd4b8bd5e08"

URI_x86_64_v2_rust-quick-junit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-junit-devel-0.6.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-junit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-junit-devel}"
SRC_URI[x86_64_v2_rust-quick-junit-devel.sha256sum] = "5ca691fe2f772ff04d8e46a7d26cc953dc628e1160965be8549a46f473c5b791"

URI_aarch64_rust-quick-junit+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-junit+default-devel-0.6.1-1.el10_3.noarch.rpm;name=aarch64_rust-quick-junit+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-junit+default-devel}"
SRC_URI[aarch64_rust-quick-junit+default-devel.sha256sum] = "bc17d61c364cbd89659706983b9849659e094f2cbd41be4b337d5a1a739e9d9a"

URI_aarch64_rust-quick-junit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-junit-devel-0.6.1-1.el10_3.noarch.rpm;name=aarch64_rust-quick-junit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-junit-devel}"
SRC_URI[aarch64_rust-quick-junit-devel.sha256sum] = "48f7faf5930d736b912a726a565bdec15e79172becba1ed3d45ecbd2a8a51c09"

RDEPENDS:rust-quick-junit+default-devel = " \
 cargo \
 rust-quick-junit-devel \
 "
RDEPENDS:rust-quick-junit-devel = " \
 cargo \
 rust \
 rust-chrono+std-devel \
 rust-chrono-devel \
 rust-indexmap+default-devel \
 rust-newtype-uuid+default-devel \
 rust-quick-xml+default-devel \
 rust-strip-ansi-escapes+default-devel \
 rust-thiserror+default-devel \
 rust-uuid+default-devel \
 "
