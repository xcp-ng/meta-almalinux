# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-DateTime-TimeZone"
PV = "2.69"
PR = "1.el10_2"
PACKAGES = " \
 perl-DateTime-TimeZone \
 perl-DateTime-TimeZone-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-DateTime-TimeZone-2.69-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8832a19e3825a1b973047c438ffec0e415e4771f61f85cb8075e50f02166114f"

URI_x86_64_v2_perl-DateTime-TimeZone = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DateTime-TimeZone-2.69-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-DateTime-TimeZone;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-DateTime-TimeZone}"
SRC_URI[x86_64_v2_perl-DateTime-TimeZone.sha256sum] = "2dbc87cc38d644f63384184e3c35a613df4361a807edc6c18275ae6f94570659"

URI_x86_64_v2_perl-DateTime-TimeZone-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DateTime-TimeZone-tests-2.69-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-DateTime-TimeZone-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-DateTime-TimeZone-tests}"
SRC_URI[x86_64_v2_perl-DateTime-TimeZone-tests.sha256sum] = "d73b901997a31c80b1e628104eedc6e80e3870fe1d1b951fbae9ed552cc3bd70"

URI_aarch64_perl-DateTime-TimeZone = "${EPEL_MIRROR}/aarch64/Packages/p/perl-DateTime-TimeZone-2.69-1.el10_2.noarch.rpm;name=aarch64_perl-DateTime-TimeZone;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-DateTime-TimeZone}"
SRC_URI[aarch64_perl-DateTime-TimeZone.sha256sum] = "4a47319301315fec5fa42d8a5a999e4770ae4800b57c8665d5585310c70e953f"

URI_aarch64_perl-DateTime-TimeZone-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-DateTime-TimeZone-tests-2.69-1.el10_2.noarch.rpm;name=aarch64_perl-DateTime-TimeZone-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-DateTime-TimeZone-tests}"
SRC_URI[aarch64_perl-DateTime-TimeZone-tests.sha256sum] = "57e2b430fa5c086da2a5323c11e6125ed617af4b50b6966eb315fba618ec0b06"

RDEPENDS:perl-DateTime-TimeZone = " \
 perl-Class-Singleton \
 perl-DateTime \
 perl-DateTime-TimeZone \
 perl-DateTime-TimeZone-Tzfile \
 perl-File-Basename \
 perl-File-Compare \
 perl-File-Find \
 perl-Module-Runtime \
 perl-Params-ValidationCompiler \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Specio \
 perl-Try-Tiny \
 perl-constant \
 perl-libs \
 perl-namespace-autoclean \
 perl-parent \
 "
RDEPENDS:perl-DateTime-TimeZone-tests = " \
 bash \
 perl-DateTime \
 perl-DateTime-TimeZone \
 perl-ExtUtils-MakeMaker \
 perl-File-Basename \
 perl-File-Path \
 perl-File-Temp \
 perl-PathTools \
 perl-Storable \
 perl-Sys-Hostname \
 perl-Test-Fatal \
 perl-Test-Harness \
 perl-Test-Output \
 perl-Test-Requires \
 perl-Test-Simple \
 perl-Test-Taint \
 perl-Try-Tiny \
 perl-base \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-overload \
 "
