# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-XML-Writer"
PV = "0.900"
PR = "15.el10_0"
PACKAGES = " \
 perl-XML-Writer \
 perl-XML-Writer-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-XML-Writer-0.900-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5623541a319d8acaf62caaa6d5ade3c2ce94b4b23a75880de8c32eda997bcdb9"

URI_x86_64_v2_perl-XML-Writer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-XML-Writer-0.900-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-XML-Writer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XML-Writer}"
SRC_URI[x86_64_v2_perl-XML-Writer.sha256sum] = "c1665018a5e960c85ee4be068a15eeb679a20c4bbd9ac8dd79521d798fe302ae"

URI_x86_64_v2_perl-XML-Writer-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-XML-Writer-tests-0.900-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-XML-Writer-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XML-Writer-tests}"
SRC_URI[x86_64_v2_perl-XML-Writer-tests.sha256sum] = "ca498655233c0d1ed4c9e946b85427e8ea85d1cc7ca91f9a3d7b647d0df59d25"

URI_aarch64_perl-XML-Writer = "${EPEL_MIRROR}/aarch64/Packages/p/perl-XML-Writer-0.900-15.el10_0.noarch.rpm;name=aarch64_perl-XML-Writer;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XML-Writer}"
SRC_URI[aarch64_perl-XML-Writer.sha256sum] = "19334bc9fcd069a1b05cf0df9cfdc0a67c391a3d3d5ec9689655a716de33aff7"

URI_aarch64_perl-XML-Writer-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-XML-Writer-tests-0.900-15.el10_0.noarch.rpm;name=aarch64_perl-XML-Writer-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XML-Writer-tests}"
SRC_URI[aarch64_perl-XML-Writer-tests.sha256sum] = "9c3b2f76413adb9f1c2a6c0e11fc9bfd72e14098376540558bbcad3bfe3fffaa"

RDEPENDS:perl-XML-Writer = " \
 perl-Carp \
 perl-IO \
 perl-libs \
 perl-overload \
 perl-vars \
 "
RDEPENDS:perl-XML-Writer-tests = " \
 bash \
 perl-Errno \
 perl-IO \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-XML-Writer \
 perl-interpreter \
 perl-libs \
 "
