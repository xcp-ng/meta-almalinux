# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-approx"
PV = "0.5.1"
PR = "7.el10_0"
PACKAGES = " \
 rust-approx+default-devel \
 rust-approx+num-complex-devel \
 rust-approx+std-devel \
 rust-approx-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-approx-0.5.1-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2de4f15359564b66e26da7b9c106d11bd619f2d5e28890699ae9bab6a97e5f28"

URI_x86_64_v2_rust-approx+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-approx+default-devel-0.5.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-approx+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-approx+default-devel}"
SRC_URI[x86_64_v2_rust-approx+default-devel.sha256sum] = "88b2065969011ae57fda7992ed256dea078c8473629426675b0937e9dfc6c0e7"

URI_x86_64_v2_rust-approx+num-complex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-approx+num-complex-devel-0.5.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-approx+num-complex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-approx+num-complex-devel}"
SRC_URI[x86_64_v2_rust-approx+num-complex-devel.sha256sum] = "22f956514eab3b70b7f741a87b5082d65cd2c73aae1478a1454ca0eb3deef16c"

URI_x86_64_v2_rust-approx+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-approx+std-devel-0.5.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-approx+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-approx+std-devel}"
SRC_URI[x86_64_v2_rust-approx+std-devel.sha256sum] = "9176f58c7e881cab6b93c5ff83d52cff0e8cc7a9b2ed85879090e9071c17fe22"

URI_x86_64_v2_rust-approx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-approx-devel-0.5.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-approx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-approx-devel}"
SRC_URI[x86_64_v2_rust-approx-devel.sha256sum] = "2abc6383054cf36ecb792d7b88c24e607320e9545a59d13fac9495ed77ddeb8b"

URI_aarch64_rust-approx+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-approx+default-devel-0.5.1-7.el10_0.noarch.rpm;name=aarch64_rust-approx+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-approx+default-devel}"
SRC_URI[aarch64_rust-approx+default-devel.sha256sum] = "f31f3c7ad4564e78936969e273cd3f8d4faf57d7a845cbb56b206457246bcd78"

URI_aarch64_rust-approx+num-complex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-approx+num-complex-devel-0.5.1-7.el10_0.noarch.rpm;name=aarch64_rust-approx+num-complex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-approx+num-complex-devel}"
SRC_URI[aarch64_rust-approx+num-complex-devel.sha256sum] = "9d7e14526c47fb7f106be40543c7414054feb74c800366131c08e30b5c504543"

URI_aarch64_rust-approx+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-approx+std-devel-0.5.1-7.el10_0.noarch.rpm;name=aarch64_rust-approx+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-approx+std-devel}"
SRC_URI[aarch64_rust-approx+std-devel.sha256sum] = "88a7e7c478557a482f3d1af595b18f46bd1b34afa704c9939f2aadbf9b224a97"

URI_aarch64_rust-approx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-approx-devel-0.5.1-7.el10_0.noarch.rpm;name=aarch64_rust-approx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-approx-devel}"
SRC_URI[aarch64_rust-approx-devel.sha256sum] = "03984775ddca47612b17088e135bbec340e5326f1856fa4de1a7426a965fff08"

RDEPENDS:rust-approx+default-devel = " \
 cargo \
 rust-approx+std-devel \
 rust-approx-devel \
 "
RDEPENDS:rust-approx+num-complex-devel = " \
 cargo \
 rust-approx-devel \
 rust-num-complex+default-devel \
 "
RDEPENDS:rust-approx+std-devel = " \
 cargo \
 rust-approx-devel \
 "
RDEPENDS:rust-approx-devel = " \
 cargo \
 rust-num-traits-devel \
 "
