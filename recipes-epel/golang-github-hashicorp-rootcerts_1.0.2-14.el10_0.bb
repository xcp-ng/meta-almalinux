# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-hashicorp-rootcerts"
PV = "1.0.2"
PR = "14.el10_0"
PACKAGES = " \
 golang-github-hashicorp-rootcerts-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-hashicorp-rootcerts-1.0.2-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "344f2e7239b70778d31f5f19e417b5d9f9ccc19c69979cebfd6f2d22f92a6261"

URI_x86_64_v2_golang-github-hashicorp-rootcerts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-hashicorp-rootcerts-devel-1.0.2-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-hashicorp-rootcerts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-hashicorp-rootcerts-devel}"
SRC_URI[x86_64_v2_golang-github-hashicorp-rootcerts-devel.sha256sum] = "befdc9b5e0a6ab482a7334c0503057d5eae1fac74939f9f943eec15b14762cd4"

URI_aarch64_golang-github-hashicorp-rootcerts-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-hashicorp-rootcerts-devel-1.0.2-14.el10_0.noarch.rpm;name=aarch64_golang-github-hashicorp-rootcerts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-hashicorp-rootcerts-devel}"
SRC_URI[aarch64_golang-github-hashicorp-rootcerts-devel.sha256sum] = "f4190a017f69f6963ea000f65fa688533e66ef04852f5ab047a8ed3979be1cd0"

RDEPENDS:golang-github-hashicorp-rootcerts-devel = " \
 go-filesystem \
 "
