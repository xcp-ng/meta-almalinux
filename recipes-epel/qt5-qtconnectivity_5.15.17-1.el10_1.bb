# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtconnectivity"
PV = "5.15.17"
PR = "1.el10_1"
PACKAGES = " \
 qt5-qtconnectivity \
 qt5-qtconnectivity-devel \
 qt5-qtconnectivity-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtconnectivity-5.15.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c50a4731c6de33cfe58b5396fdb9f2eda9b6c246b2a5d3ec4c48b65d4a9ef3e"

URI_x86_64_v2_qt5-qtconnectivity = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtconnectivity-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtconnectivity;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtconnectivity}"
SRC_URI[x86_64_v2_qt5-qtconnectivity.sha256sum] = "c31110e5d6221d796b22cc0b455cd4d1bac7752ad7608e171489e04d16609177"

URI_x86_64_v2_qt5-qtconnectivity-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtconnectivity-devel-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtconnectivity-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtconnectivity-devel}"
SRC_URI[x86_64_v2_qt5-qtconnectivity-devel.sha256sum] = "e6b47edfa2a27158ba1f72c8fcc70df522ac23783fe054999645558e802107cf"

URI_x86_64_v2_qt5-qtconnectivity-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtconnectivity-examples-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtconnectivity-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtconnectivity-examples}"
SRC_URI[x86_64_v2_qt5-qtconnectivity-examples.sha256sum] = "a7373d4c5689e89e4b5077bc1799cdd27737af700b63dfcdd35eab51ed983ceb"

URI_aarch64_qt5-qtconnectivity = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtconnectivity-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtconnectivity;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtconnectivity}"
SRC_URI[aarch64_qt5-qtconnectivity.sha256sum] = "aead3e1efb770cece32ab9c3c97d0aa3ea17e13101bcfc1a60419b42440a9ec5"

URI_aarch64_qt5-qtconnectivity-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtconnectivity-devel-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtconnectivity-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtconnectivity-devel}"
SRC_URI[aarch64_qt5-qtconnectivity-devel.sha256sum] = "7a6276f07e3d194c3a049f672575e62a0904fe5460ba608e0ff82bdf9df6644b"

URI_aarch64_qt5-qtconnectivity-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtconnectivity-examples-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtconnectivity-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtconnectivity-examples}"
SRC_URI[aarch64_qt5-qtconnectivity-examples.sha256sum] = "450b4763cd24180da8bf725f3e503b7c31141ad8bc529141584df01ab15382f7"

RDEPENDS:qt5-qtconnectivity = " \
 bluez-libs \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtconnectivity-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtconnectivity \
 "
RDEPENDS:qt5-qtconnectivity-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtconnectivity \
 qt5-qtdeclarative \
 "
