# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-url"
PV = "2.5.7"
PR = "1.el10_1"
PACKAGES = " \
 rust-url+default-devel \
 rust-url+expose_internals-devel \
 rust-url+serde-devel \
 rust-url+std-devel \
 rust-url-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-url-2.5.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a1372a2c7190d3143ab53e2fcd06a4b21aa81d938f63fec938fad3808f6fc42"

URI_x86_64_v2_rust-url+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-url+default-devel-2.5.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-url+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-url+default-devel}"
SRC_URI[x86_64_v2_rust-url+default-devel.sha256sum] = "c98954b0307d6e2f26d24974f4bf3d2b4784b912dc06550d399fbfffc9db0d6d"

URI_x86_64_v2_rust-url+expose_internals-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-url+expose_internals-devel-2.5.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-url+expose_internals-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-url+expose_internals-devel}"
SRC_URI[x86_64_v2_rust-url+expose_internals-devel.sha256sum] = "117a76e623fcac18e36e9ee7eef58239e03005c56ab34a3c0a26f98e2d6a8bbe"

URI_x86_64_v2_rust-url+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-url+serde-devel-2.5.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-url+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-url+serde-devel}"
SRC_URI[x86_64_v2_rust-url+serde-devel.sha256sum] = "6cc20e1a8c9ad229aecaae8a13f3519929c7edd6969db2dbe3e50c19ad19d109"

URI_x86_64_v2_rust-url+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-url+std-devel-2.5.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-url+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-url+std-devel}"
SRC_URI[x86_64_v2_rust-url+std-devel.sha256sum] = "1fecff5d2499eb1d3fe65c3d0d85685344277a71433fe1211d612d404b33d146"

URI_x86_64_v2_rust-url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-url-devel-2.5.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-url-devel}"
SRC_URI[x86_64_v2_rust-url-devel.sha256sum] = "73983cdac4359b30a71cb6375269e5e6fd50c477579528f81e2abe821be1abc1"

URI_aarch64_rust-url+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-url+default-devel-2.5.7-1.el10_1.noarch.rpm;name=aarch64_rust-url+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-url+default-devel}"
SRC_URI[aarch64_rust-url+default-devel.sha256sum] = "b730385531cfee75ac54cf60e84f2d52735714c64ce4a2b80b7cd6c528141509"

URI_aarch64_rust-url+expose_internals-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-url+expose_internals-devel-2.5.7-1.el10_1.noarch.rpm;name=aarch64_rust-url+expose_internals-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-url+expose_internals-devel}"
SRC_URI[aarch64_rust-url+expose_internals-devel.sha256sum] = "75f874008e059a3aa797ce181cf6eddee8bb131aa55dbe148ba696fc24d7b4ce"

URI_aarch64_rust-url+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-url+serde-devel-2.5.7-1.el10_1.noarch.rpm;name=aarch64_rust-url+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-url+serde-devel}"
SRC_URI[aarch64_rust-url+serde-devel.sha256sum] = "41adb1ea13e7962aaffb12bb3d7f5c00d667b05b4c092e0a65e3a737bdbb56a0"

URI_aarch64_rust-url+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-url+std-devel-2.5.7-1.el10_1.noarch.rpm;name=aarch64_rust-url+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-url+std-devel}"
SRC_URI[aarch64_rust-url+std-devel.sha256sum] = "fd727d750d1215b245016e6b30b101acbf694a21d08a18e7d930713c4a6fca0c"

URI_aarch64_rust-url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-url-devel-2.5.7-1.el10_1.noarch.rpm;name=aarch64_rust-url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-url-devel}"
SRC_URI[aarch64_rust-url-devel.sha256sum] = "1c3acbee5199749999b8529e405d1f0be686aefae7cadef7d915a6757f76d3e6"

RDEPENDS:rust-url+default-devel = " \
 cargo \
 rust-url+std-devel \
 rust-url-devel \
 "
RDEPENDS:rust-url+expose_internals-devel = " \
 cargo \
 rust-url-devel \
 "
RDEPENDS:rust-url+serde-devel = " \
 cargo \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-url-devel \
 "
RDEPENDS:rust-url+std-devel = " \
 cargo \
 rust-form_urlencoded+std-devel \
 rust-idna+std-devel \
 rust-percent-encoding+std-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 rust-url-devel \
 "
RDEPENDS:rust-url-devel = " \
 cargo \
 rust \
 rust-form_urlencoded+alloc-devel \
 rust-form_urlencoded-devel \
 rust-idna+alloc-devel \
 rust-idna+compiled_data-devel \
 rust-idna-devel \
 rust-percent-encoding+alloc-devel \
 rust-percent-encoding-devel \
 "
