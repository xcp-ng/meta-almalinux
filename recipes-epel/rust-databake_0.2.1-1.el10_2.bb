# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-databake"
PV = "0.2.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-databake+default-devel \
 rust-databake+derive-devel \
 rust-databake-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-databake-0.2.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eca385f93dcdd0b1c1d86c09ee4bad49e5e8184c2bbd7793b223ee0b3243879b"

URI_x86_64_v2_rust-databake+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-databake+default-devel-0.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-databake+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-databake+default-devel}"
SRC_URI[x86_64_v2_rust-databake+default-devel.sha256sum] = "e329698ed877001579b6dd15f32af8b4bdad5ba91a29a1ff4b5ee036ece0e3ab"

URI_x86_64_v2_rust-databake+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-databake+derive-devel-0.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-databake+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-databake+derive-devel}"
SRC_URI[x86_64_v2_rust-databake+derive-devel.sha256sum] = "2b56cf981804155cbfe995062784f3f3c67b6fb8d7059144c7c660d4f53abf6b"

URI_x86_64_v2_rust-databake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-databake-devel-0.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-databake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-databake-devel}"
SRC_URI[x86_64_v2_rust-databake-devel.sha256sum] = "7672a14a5f78f0aa66d1518ab7790ad1af1cd68c0261e208661b938b65533f8f"

URI_aarch64_rust-databake+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-databake+default-devel-0.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-databake+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-databake+default-devel}"
SRC_URI[aarch64_rust-databake+default-devel.sha256sum] = "452010478bdcd9daae119ad3ccb65fb2d632ed4fc98e7d23df5e33a26d087032"

URI_aarch64_rust-databake+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-databake+derive-devel-0.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-databake+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-databake+derive-devel}"
SRC_URI[aarch64_rust-databake+derive-devel.sha256sum] = "782da951a449fc070fed625b91d99b125b106aa6c476dd80ed1a2d21d98bb20e"

URI_aarch64_rust-databake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-databake-devel-0.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-databake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-databake-devel}"
SRC_URI[aarch64_rust-databake-devel.sha256sum] = "4f6d6703b511aa583a351291f243f3d38d6eb86357e410e6eec62e008d807a6d"

RDEPENDS:rust-databake+default-devel = " \
 cargo \
 rust-databake-devel \
 "
RDEPENDS:rust-databake+derive-devel = " \
 cargo \
 rust-databake-derive-devel \
 rust-databake-devel \
 "
RDEPENDS:rust-databake-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 "
