# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtdeclarative"
PV = "6.10.1"
PR = "1.el10_2.1"
PACKAGES = " \
 qt6-qtdeclarative \
 qt6-qtdeclarative-devel \
 qt6-qtdeclarative-examples \
 qt6-qtdeclarative-static \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtdeclarative-6.10.1-1.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c5a77f264d4f0b7267d78c774543be7e99d39c556ce12d732e4ff7a84575285c"

URI_x86_64_v2_qt6-qtdeclarative = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtdeclarative-6.10.1-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_qt6-qtdeclarative;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtdeclarative}"
SRC_URI[x86_64_v2_qt6-qtdeclarative.sha256sum] = "6045aa637e934198ef75659955d2aef2322950eb42a3866d726c991394f0484b"

URI_x86_64_v2_qt6-qtdeclarative-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtdeclarative-devel-6.10.1-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_qt6-qtdeclarative-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtdeclarative-devel}"
SRC_URI[x86_64_v2_qt6-qtdeclarative-devel.sha256sum] = "404b1d84a67ad7418edf5b5e15803a518bef691fa5591c46edc3967246b31a5a"

URI_x86_64_v2_qt6-qtdeclarative-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtdeclarative-examples-6.10.1-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_qt6-qtdeclarative-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtdeclarative-examples}"
SRC_URI[x86_64_v2_qt6-qtdeclarative-examples.sha256sum] = "dc84f039ef886301706d6542a9cf3c9dcd4af21c04f149926e01d9a837d6a37e"

URI_x86_64_v2_qt6-qtdeclarative-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtdeclarative-static-6.10.1-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_qt6-qtdeclarative-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtdeclarative-static}"
SRC_URI[x86_64_v2_qt6-qtdeclarative-static.sha256sum] = "d347c3a8f61302cbde7fc3dc8e7135536d43b3848df45cb83a74781e9c6dfb56"

URI_aarch64_qt6-qtdeclarative = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtdeclarative-6.10.1-1.el10_2.1.aarch64.rpm;name=aarch64_qt6-qtdeclarative;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtdeclarative}"
SRC_URI[aarch64_qt6-qtdeclarative.sha256sum] = "3f8775ab26a27330bf14aa2ddc23440a4e76e3923204ded5858a3f149abd6d2a"

URI_aarch64_qt6-qtdeclarative-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtdeclarative-devel-6.10.1-1.el10_2.1.aarch64.rpm;name=aarch64_qt6-qtdeclarative-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtdeclarative-devel}"
SRC_URI[aarch64_qt6-qtdeclarative-devel.sha256sum] = "eea640b28878ca3579447e364dbf6383265a59d89e15fe9507f747477a91d476"

URI_aarch64_qt6-qtdeclarative-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtdeclarative-examples-6.10.1-1.el10_2.1.aarch64.rpm;name=aarch64_qt6-qtdeclarative-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtdeclarative-examples}"
SRC_URI[aarch64_qt6-qtdeclarative-examples.sha256sum] = "558b82f6d2aa368cf160671491f397b0dd45662e1fc1dcfc35c2ff469f2c469e"

URI_aarch64_qt6-qtdeclarative-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtdeclarative-static-6.10.1-1.el10_2.1.aarch64.rpm;name=aarch64_qt6-qtdeclarative-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtdeclarative-static}"
SRC_URI[aarch64_qt6-qtdeclarative-static.sha256sum] = "5b139eb8ee6152b4593bebae37f36e27e4d3625dc53c08ee3ca2b3718c205026"

RDEPENDS:qt6-qtdeclarative:x86_64_v2 = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
"
RDEPENDS:qt6-qtdeclarative:aarch64 = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
"
RDEPENDS:qt6-qtdeclarative-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtdeclarative-devel \
 "
RDEPENDS:qt6-qtdeclarative-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:qt6-qtdeclarative-static = " \
 cmake-filesystem \
 qt6-qtdeclarative-devel \
 "
