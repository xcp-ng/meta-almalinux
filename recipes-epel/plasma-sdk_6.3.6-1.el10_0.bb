# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-sdk"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 plasma-sdk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-sdk-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c87259c3c9aada5ed6796213e0fde733094bd6e4df033c0c86668eaefa42d31c"

URI_x86_64_v2_plasma-sdk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-sdk-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-sdk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-sdk}"
SRC_URI[x86_64_v2_plasma-sdk.sha256sum] = "229db15bf6dff9f02d432a30ce3c1f5bded27895507a9818a2e00bcd0f925384"

URI_aarch64_plasma-sdk = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-sdk-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-sdk;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-sdk}"
SRC_URI[aarch64_plasma-sdk.sha256sum] = "1c01cfd9eb84dfd571a76e55340916f68340df513208d28d5a3067bae54ed5ae"

RDEPENDS:plasma-sdk = " \
 glibc \
 hicolor-icon-theme \
 kf6-filesystem \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kpackage \
 kf6-ktexteditor \
 kf6-kwidgetsaddons \
 libplasma \
 libstdc++ \
 plasma5support \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
