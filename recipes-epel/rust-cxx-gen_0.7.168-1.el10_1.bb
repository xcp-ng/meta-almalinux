# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cxx-gen"
PV = "0.7.168"
PR = "1.el10_1"
PACKAGES = " \
 rust-cxx-gen+default-devel \
 rust-cxx-gen-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cxx-gen-0.7.168-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "35322390b88c65eaa5e6c8d4840cf06b3e08ad81f46a61454de40a38a325b175"

URI_x86_64_v2_rust-cxx-gen+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx-gen+default-devel-0.7.168-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx-gen+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx-gen+default-devel}"
SRC_URI[x86_64_v2_rust-cxx-gen+default-devel.sha256sum] = "31999de489a37058e76cbba82c88a82538e58a14a51e40ed772851579e79d54f"

URI_x86_64_v2_rust-cxx-gen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx-gen-devel-0.7.168-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx-gen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx-gen-devel}"
SRC_URI[x86_64_v2_rust-cxx-gen-devel.sha256sum] = "067a65c40648b3d0c81406f326bf7ba8882f7e298e3c103e78acc006d48651bd"

URI_aarch64_rust-cxx-gen+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx-gen+default-devel-0.7.168-1.el10_1.noarch.rpm;name=aarch64_rust-cxx-gen+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx-gen+default-devel}"
SRC_URI[aarch64_rust-cxx-gen+default-devel.sha256sum] = "d500576351d42ca3911d58e731a98578095e06748949aff7dbfab3eccbee5753"

URI_aarch64_rust-cxx-gen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx-gen-devel-0.7.168-1.el10_1.noarch.rpm;name=aarch64_rust-cxx-gen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx-gen-devel}"
SRC_URI[aarch64_rust-cxx-gen-devel.sha256sum] = "f129806b067c37a2d772f6ad4f6a5420d610c9eb4e64a722bd0bc065079f2840"

RDEPENDS:rust-cxx-gen+default-devel = " \
 cargo \
 rust-cxx-gen-devel \
 "
RDEPENDS:rust-cxx-gen-devel = " \
 cargo \
 rust \
 rust-codespan-reporting+default-devel \
 rust-indexmap+default-devel \
 rust-proc-macro2+span-locations-devel \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn-devel \
 "
