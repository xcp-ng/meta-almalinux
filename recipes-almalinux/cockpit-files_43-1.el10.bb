# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cockpit-files"
PV = "43"
PR = "1.el10"
PACKAGES = " \
 cockpit-files \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cockpit-files-43-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2be26762540c9857d2a15372922d042efa4def8f2d7e63f88d82c41124cbf1f0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cockpit-files-43-1.el10.noarch.rpm;name=x86_64_v2_cockpit-files;unpack=0"
SRC_URI[x86_64_v2_cockpit-files.sha256sum] = "5dd88f9bfca983eebb37c4e9695722fd2e43fa303f0698de0a70cb9974ac0df3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cockpit-files-43-1.el10.noarch.rpm;name=aarch64_cockpit-files;unpack=0"
SRC_URI[aarch64_cockpit-files.sha256sum] = "5dd88f9bfca983eebb37c4e9695722fd2e43fa303f0698de0a70cb9974ac0df3"

RDEPENDS:cockpit-files = " \
 cockpit-bridge \
 "
