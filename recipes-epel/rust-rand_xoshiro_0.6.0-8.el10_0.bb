# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_xoshiro"
PV = "0.6.0"
PR = "8.el10_0"
PACKAGES = " \
 rust-rand_xoshiro+default-devel \
 rust-rand_xoshiro+serde-devel \
 rust-rand_xoshiro+serde1-devel \
 rust-rand_xoshiro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_xoshiro-0.6.0-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7cdab0c90bf1282c85d42fbc216993f64995aab15aceec6c21eba6392f45e0e9"

URI_x86_64_v2_rust-rand_xoshiro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xoshiro+default-devel-0.6.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xoshiro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xoshiro+default-devel}"
SRC_URI[x86_64_v2_rust-rand_xoshiro+default-devel.sha256sum] = "cd681195594f22b68642b0feba36c56b6790fd2533ccad21ec5d025be54d9dc4"

URI_x86_64_v2_rust-rand_xoshiro+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xoshiro+serde-devel-0.6.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xoshiro+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xoshiro+serde-devel}"
SRC_URI[x86_64_v2_rust-rand_xoshiro+serde-devel.sha256sum] = "755572b537f6d0fdc1f956c79808916138004371abe3ca3c7a10ce72d9577a4a"

URI_x86_64_v2_rust-rand_xoshiro+serde1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xoshiro+serde1-devel-0.6.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xoshiro+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xoshiro+serde1-devel}"
SRC_URI[x86_64_v2_rust-rand_xoshiro+serde1-devel.sha256sum] = "b6865226f803e2af1e57a303c6211847a93add7f5a6e9ac78bf5484106c52e44"

URI_x86_64_v2_rust-rand_xoshiro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xoshiro-devel-0.6.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xoshiro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xoshiro-devel}"
SRC_URI[x86_64_v2_rust-rand_xoshiro-devel.sha256sum] = "ed036f2366036836cc493c4f6ee7dcdf334d443ce88d98a220ec3a444f0692d9"

URI_aarch64_rust-rand_xoshiro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xoshiro+default-devel-0.6.0-8.el10_0.noarch.rpm;name=aarch64_rust-rand_xoshiro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xoshiro+default-devel}"
SRC_URI[aarch64_rust-rand_xoshiro+default-devel.sha256sum] = "3f1d14410f9ba73a75b0a661241126f389c10da9ce20e9283326024c8da7faa0"

URI_aarch64_rust-rand_xoshiro+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xoshiro+serde-devel-0.6.0-8.el10_0.noarch.rpm;name=aarch64_rust-rand_xoshiro+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xoshiro+serde-devel}"
SRC_URI[aarch64_rust-rand_xoshiro+serde-devel.sha256sum] = "8a614641772eed51b9d01e4ab398ca065f5532c572efc0ef651fd430b162d54c"

URI_aarch64_rust-rand_xoshiro+serde1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xoshiro+serde1-devel-0.6.0-8.el10_0.noarch.rpm;name=aarch64_rust-rand_xoshiro+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xoshiro+serde1-devel}"
SRC_URI[aarch64_rust-rand_xoshiro+serde1-devel.sha256sum] = "b3ab826957007c0f7302e2c0efefdd1729db206baafb41635b1d4d43c7f7b5af"

URI_aarch64_rust-rand_xoshiro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xoshiro-devel-0.6.0-8.el10_0.noarch.rpm;name=aarch64_rust-rand_xoshiro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xoshiro-devel}"
SRC_URI[aarch64_rust-rand_xoshiro-devel.sha256sum] = "34f39902c323e996e0aa26e560dc5589818579401353b08906da4ef3b3d9f567"

RDEPENDS:rust-rand_xoshiro+default-devel = " \
 cargo \
 rust-rand_xoshiro-devel \
 "
RDEPENDS:rust-rand_xoshiro+serde-devel = " \
 cargo \
 rust-rand_xoshiro-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand_xoshiro+serde1-devel = " \
 cargo \
 rust-rand_xoshiro+serde-devel \
 rust-rand_xoshiro-devel \
 "
RDEPENDS:rust-rand_xoshiro-devel = " \
 cargo \
 rust-rand_core0.6+default-devel \
 "
