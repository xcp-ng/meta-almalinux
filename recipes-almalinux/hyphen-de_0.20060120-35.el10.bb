# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyphen-de"
PV = "0.20060120"
PR = "35.el10"
PACKAGES = " \
 hyphen-de \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyphen-de-0.20060120-35.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bb5ad9dcb3e3bb848db57b45b065787205defb26d3144fa07d5cbe0bd75e6067"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-de-0.20060120-35.el10.noarch.rpm;name=x86_64_v2_hyphen-de;unpack=0"
SRC_URI[x86_64_v2_hyphen-de.sha256sum] = "fc68cd21736cdc8c2ca2837aa164b293eb2a8d07a1229b24ccc20c878c22f4d2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-de-0.20060120-35.el10.noarch.rpm;name=aarch64_hyphen-de;unpack=0"
SRC_URI[aarch64_hyphen-de.sha256sum] = "fc68cd21736cdc8c2ca2837aa164b293eb2a8d07a1229b24ccc20c878c22f4d2"

RDEPENDS:hyphen-de = " \
 hyphen \
 "
