# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sequoia-sop"
PV = "0.38.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-sequoia-sop+cli-devel \
 rust-sequoia-sop+cliv-devel \
 rust-sequoia-sop+crypto-nettle-devel \
 rust-sequoia-sop+crypto-openssl-devel \
 rust-sequoia-sop+default-devel \
 rust-sequoia-sop-devel \
 sequoia-sop \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sequoia-sop-0.38.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ebc4241433d68526e22cef43d519b23cf50ff40fb2b0639020f2341bcc526580"

URI_x86_64_v2_rust-sequoia-sop+cli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-sop+cli-devel-0.38.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-sop+cli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sequoia-sop+cli-devel}"
SRC_URI[x86_64_v2_rust-sequoia-sop+cli-devel.sha256sum] = "3726f1334f0ed010766aa6c6415e9c88f60aec6b9a6765e3190d22ebc0352528"

URI_x86_64_v2_rust-sequoia-sop+cliv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-sop+cliv-devel-0.38.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-sop+cliv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sequoia-sop+cliv-devel}"
SRC_URI[x86_64_v2_rust-sequoia-sop+cliv-devel.sha256sum] = "82d6e7af0eacdfc12b4d4336ac8302201bc77a6650683a7de210d079fdc2ff60"

URI_x86_64_v2_rust-sequoia-sop+crypto-nettle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-sop+crypto-nettle-devel-0.38.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-sop+crypto-nettle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sequoia-sop+crypto-nettle-devel}"
SRC_URI[x86_64_v2_rust-sequoia-sop+crypto-nettle-devel.sha256sum] = "f09a75d8d70f8a34a5529478711741f0b62ed71d7788a5da98b7e7eafb24273d"

URI_x86_64_v2_rust-sequoia-sop+crypto-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-sop+crypto-openssl-devel-0.38.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-sop+crypto-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sequoia-sop+crypto-openssl-devel}"
SRC_URI[x86_64_v2_rust-sequoia-sop+crypto-openssl-devel.sha256sum] = "17a4479e0afaec48e7b4d224c39194addff83f063559cb7f64f79c893601a33a"

URI_x86_64_v2_rust-sequoia-sop+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-sop+default-devel-0.38.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-sop+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sequoia-sop+default-devel}"
SRC_URI[x86_64_v2_rust-sequoia-sop+default-devel.sha256sum] = "b5e439fb95f731e503ac78e8869da9bbb03a198b6db2e8b7f86544fd6d522b2b"

URI_x86_64_v2_rust-sequoia-sop-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-sop-devel-0.38.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-sop-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sequoia-sop-devel}"
SRC_URI[x86_64_v2_rust-sequoia-sop-devel.sha256sum] = "d320bfead0f2d4748ef2b302b6700d90137a08649b3c509e6d1c8f2df797a926"

URI_x86_64_v2_sequoia-sop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sequoia-sop-0.38.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sequoia-sop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sequoia-sop}"
SRC_URI[x86_64_v2_sequoia-sop.sha256sum] = "dd5c609913084edc22c9db2f694b13d0e0070ee22960bc2c9772658a62e207aa"

URI_aarch64_rust-sequoia-sop+cli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-sop+cli-devel-0.38.0-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-sop+cli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sequoia-sop+cli-devel}"
SRC_URI[aarch64_rust-sequoia-sop+cli-devel.sha256sum] = "72c9ffa44aeb1c4a8e6c39f07004697401e1430092a253c536710692abc1c904"

URI_aarch64_rust-sequoia-sop+cliv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-sop+cliv-devel-0.38.0-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-sop+cliv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sequoia-sop+cliv-devel}"
SRC_URI[aarch64_rust-sequoia-sop+cliv-devel.sha256sum] = "961f001386231ae99a3b5e6ec98dd5d07568cb735a53a1ff962d13d94f0e147a"

URI_aarch64_rust-sequoia-sop+crypto-nettle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-sop+crypto-nettle-devel-0.38.0-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-sop+crypto-nettle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sequoia-sop+crypto-nettle-devel}"
SRC_URI[aarch64_rust-sequoia-sop+crypto-nettle-devel.sha256sum] = "90cd080fca989937dc8ca6baeb13eb31b7b2619da6a55c74e0531a83c8f610b9"

URI_aarch64_rust-sequoia-sop+crypto-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-sop+crypto-openssl-devel-0.38.0-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-sop+crypto-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sequoia-sop+crypto-openssl-devel}"
SRC_URI[aarch64_rust-sequoia-sop+crypto-openssl-devel.sha256sum] = "f1bbf9a1be794381f8868e8bd87dfbd32ee8a76d748626be03d49973b7b81963"

URI_aarch64_rust-sequoia-sop+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-sop+default-devel-0.38.0-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-sop+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sequoia-sop+default-devel}"
SRC_URI[aarch64_rust-sequoia-sop+default-devel.sha256sum] = "7d8f78e0ea4bb1d5bdc6e0c5406dd140fc670d232a57e5d8c4d73e0a5d671b9b"

URI_aarch64_rust-sequoia-sop-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-sop-devel-0.38.0-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-sop-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sequoia-sop-devel}"
SRC_URI[aarch64_rust-sequoia-sop-devel.sha256sum] = "eaee4f91ef0b888cb356c6ca2f702be2ce781106375c086037a79edefc7a3bbc"

URI_aarch64_sequoia-sop = "${EPEL_MIRROR}/aarch64/Packages/s/sequoia-sop-0.38.0-1.el10_3.aarch64.rpm;name=aarch64_sequoia-sop;unpack=0"
SRC_URI:append = " ${URI_aarch64_sequoia-sop}"
SRC_URI[aarch64_sequoia-sop.sha256sum] = "f615df9eb12a832345f669654e19ff71dee467b09b09042a0109c5ceb95b528f"

RDEPENDS:rust-sequoia-sop+cli-devel = " \
 cargo \
 rust-sequoia-policy-config-devel \
 rust-sequoia-sop-devel \
 rust-sop+cli-devel \
 "
RDEPENDS:rust-sequoia-sop+cliv-devel = " \
 cargo \
 rust-sequoia-policy-config-devel \
 rust-sequoia-sop-devel \
 rust-sop+cliv-devel \
 "
RDEPENDS:rust-sequoia-sop+crypto-nettle-devel = " \
 cargo \
 rust-sequoia-openpgp+crypto-nettle-devel \
 rust-sequoia-sop-devel \
 "
RDEPENDS:rust-sequoia-sop+crypto-openssl-devel = " \
 cargo \
 rust-sequoia-openpgp+crypto-openssl-devel \
 rust-sequoia-sop-devel \
 "
RDEPENDS:rust-sequoia-sop+default-devel = " \
 cargo \
 rust-sequoia-sop+crypto-openssl-devel \
 rust-sequoia-sop-devel \
 "
RDEPENDS:rust-sequoia-sop-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-sequoia-openpgp-devel \
 rust-sequoia-wot-devel \
 rust-sop+default-devel \
 "
RDEPENDS:sequoia-sop = " \
 glibc \
 libgcc \
 openssl-libs \
 sqlite-libs \
 "
