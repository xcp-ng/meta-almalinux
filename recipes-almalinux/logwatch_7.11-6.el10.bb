# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "logwatch"
PV = "7.11"
PR = "6.el10"
PACKAGES = " \
 logwatch \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/logwatch-7.11-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f5bbde10034a39c3d21ea7c3e6df080ce0aecec20475f06e5bfe1d57861d937b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/logwatch-7.11-6.el10.noarch.rpm;name=x86_64_v2_logwatch;unpack=0"
SRC_URI[x86_64_v2_logwatch.sha256sum] = "3bc9e44b6b13237364b40af0478d1ab37bfa3f91a9c14f9f0450e2eff9094a8a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/logwatch-7.11-6.el10.noarch.rpm;name=aarch64_logwatch;unpack=0"
SRC_URI[aarch64_logwatch.sha256sum] = "3bc9e44b6b13237364b40af0478d1ab37bfa3f91a9c14f9f0450e2eff9094a8a"

RDEPENDS:logwatch = " \
 bash \
 crontabs \
 grep \
 perl-Date-Manip \
 perl-Errno \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-HTML-Parser \
 perl-POSIX \
 perl-PathTools \
 perl-Socket \
 perl-Time-Local \
 perl-URI \
 perl-diagnostics \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-subs \
 perl-vars \
 "
