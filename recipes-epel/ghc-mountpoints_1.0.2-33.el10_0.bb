# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-mountpoints"
PV = "1.0.2"
PR = "33.el10_0"
PACKAGES = " \
 ghc-mountpoints \
 ghc-mountpoints-devel \
 ghc-mountpoints-doc \
 ghc-mountpoints-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-mountpoints-1.0.2-33.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e6ac9ae03c64a08eaa6aa8bd5fa24a782331cf85ab529438a0451373b97090b"

URI_x86_64_v2_ghc-mountpoints = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-mountpoints-1.0.2-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-mountpoints;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-mountpoints}"
SRC_URI[x86_64_v2_ghc-mountpoints.sha256sum] = "5ba4d49bfaeef6596763c8c8459c126e6887c535d6da6f59728330d48910e485"

URI_x86_64_v2_ghc-mountpoints-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-mountpoints-devel-1.0.2-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-mountpoints-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-mountpoints-devel}"
SRC_URI[x86_64_v2_ghc-mountpoints-devel.sha256sum] = "eee7eee592bfefb238923262c24d1add7eb707ce9be81a6eeb3fbf5b5035a800"

URI_x86_64_v2_ghc-mountpoints-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-mountpoints-doc-1.0.2-33.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-mountpoints-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-mountpoints-doc}"
SRC_URI[x86_64_v2_ghc-mountpoints-doc.sha256sum] = "af878342ac58d52a29efc152e6a2878280f1de26c6e2f4c00dd63aacce9d4c92"

URI_x86_64_v2_ghc-mountpoints-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-mountpoints-prof-1.0.2-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-mountpoints-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-mountpoints-prof}"
SRC_URI[x86_64_v2_ghc-mountpoints-prof.sha256sum] = "0a050cb0c61fb34ba738233500ece64d517e74f8164848242cac948f289840b3"

URI_aarch64_ghc-mountpoints = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-mountpoints-1.0.2-33.el10_0.aarch64.rpm;name=aarch64_ghc-mountpoints;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-mountpoints}"
SRC_URI[aarch64_ghc-mountpoints.sha256sum] = "665fcc4a4d307777a2e16ca32dafa5b72f2ea677423818915cf775c41f24f621"

URI_aarch64_ghc-mountpoints-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-mountpoints-devel-1.0.2-33.el10_0.aarch64.rpm;name=aarch64_ghc-mountpoints-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-mountpoints-devel}"
SRC_URI[aarch64_ghc-mountpoints-devel.sha256sum] = "94c15611410c7d174270a4aab66ac297c7c712d752b22dd79bfe6bd6589917f6"

URI_aarch64_ghc-mountpoints-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-mountpoints-doc-1.0.2-33.el10_0.noarch.rpm;name=aarch64_ghc-mountpoints-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-mountpoints-doc}"
SRC_URI[aarch64_ghc-mountpoints-doc.sha256sum] = "b46ba1292530bf899c195ebe27842249d82d1d94420aa97dd3273260bde6d822"

URI_aarch64_ghc-mountpoints-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-mountpoints-prof-1.0.2-33.el10_0.aarch64.rpm;name=aarch64_ghc-mountpoints-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-mountpoints-prof}"
SRC_URI[aarch64_ghc-mountpoints-prof.sha256sum] = "7455729f321c6491d80102ba64dd242544d16e45a4199a58af7f781b5a00dc9f"

RDEPENDS:ghc-mountpoints = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-mountpoints-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-mountpoints \
 "
RDEPENDS:ghc-mountpoints-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-mountpoints-prof = " \
 ghc-base-prof \
 ghc-mountpoints-devel \
 "
