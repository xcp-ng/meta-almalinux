# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-httpx"
PV = "0.28.1"
PR = "4.el10_2"
PACKAGES = " \
 python3-httpx \
 python3-httpx+brotli \
 python3-httpx+cli \
 python3-httpx+http2 \
 python3-httpx+socks \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-httpx-0.28.1-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5fa973a288ebc85e2f99b559838ac9216cb124768865c5257897e59a334b2c98"

URI_x86_64_v2_python3-httpx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-httpx-0.28.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-httpx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-httpx}"
SRC_URI[x86_64_v2_python3-httpx.sha256sum] = "d14125a72df3c98712b1514302ee8d9e50d04211cd8ffcf107592d54c42ebad9"

URI_x86_64_v2_python3-httpx+brotli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-httpx+brotli-0.28.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-httpx+brotli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-httpx+brotli}"
SRC_URI[x86_64_v2_python3-httpx+brotli.sha256sum] = "f6c0cdc10fdb31e77f5e4593480fe07af469cbdf5655226b9f9dc678da2b661f"

URI_x86_64_v2_python3-httpx+cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-httpx+cli-0.28.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-httpx+cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-httpx+cli}"
SRC_URI[x86_64_v2_python3-httpx+cli.sha256sum] = "597cf79c5087181684cac80357326a9ea083d796ff7a7a2d7771f8899b11bc5d"

URI_x86_64_v2_python3-httpx+http2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-httpx+http2-0.28.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-httpx+http2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-httpx+http2}"
SRC_URI[x86_64_v2_python3-httpx+http2.sha256sum] = "5468efac4c68c63042b46f518e0719bd1dab8b06a896ad9a4a63963250971b17"

URI_x86_64_v2_python3-httpx+socks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-httpx+socks-0.28.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-httpx+socks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-httpx+socks}"
SRC_URI[x86_64_v2_python3-httpx+socks.sha256sum] = "5076ea955c2cf4ceb789499809f1ccbcb4dd1a463c2f9b7925fc22ebdaeedd3f"

URI_aarch64_python3-httpx = "${EPEL_MIRROR}/aarch64/Packages/p/python3-httpx-0.28.1-4.el10_2.noarch.rpm;name=aarch64_python3-httpx;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-httpx}"
SRC_URI[aarch64_python3-httpx.sha256sum] = "888fb04c560914489e75b08938be8e574d4ff658d703440e17cd59987a89db47"

URI_aarch64_python3-httpx+brotli = "${EPEL_MIRROR}/aarch64/Packages/p/python3-httpx+brotli-0.28.1-4.el10_2.noarch.rpm;name=aarch64_python3-httpx+brotli;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-httpx+brotli}"
SRC_URI[aarch64_python3-httpx+brotli.sha256sum] = "0fa7b7a1cd0042b512516db5d87a16be002442fb2606def8ad257005302bbc46"

URI_aarch64_python3-httpx+cli = "${EPEL_MIRROR}/aarch64/Packages/p/python3-httpx+cli-0.28.1-4.el10_2.noarch.rpm;name=aarch64_python3-httpx+cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-httpx+cli}"
SRC_URI[aarch64_python3-httpx+cli.sha256sum] = "eda004e7fb0ded2eb5f11b1020ac66a81810464f3d2a0a8e2469c5bed4344ba7"

URI_aarch64_python3-httpx+http2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-httpx+http2-0.28.1-4.el10_2.noarch.rpm;name=aarch64_python3-httpx+http2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-httpx+http2}"
SRC_URI[aarch64_python3-httpx+http2.sha256sum] = "c013f61e611ee5c0c284a0d9a4f274b9576e94a504e997835f54aa4aef3f0957"

URI_aarch64_python3-httpx+socks = "${EPEL_MIRROR}/aarch64/Packages/p/python3-httpx+socks-0.28.1-4.el10_2.noarch.rpm;name=aarch64_python3-httpx+socks;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-httpx+socks}"
SRC_URI[aarch64_python3-httpx+socks.sha256sum] = "4842eb3d26c579764468b4fa5e8f49cb0364618eda463cae3193998195de3a47"

RDEPENDS:python3-httpx = " \
 python3 \
 python3-anyio \
 python3-certifi \
 python3-httpcore \
 python3-idna \
 "
RDEPENDS:python3-httpx+brotli = " \
 python3 \
 python3-brotli \
 python3-httpx \
 "
RDEPENDS:python3-httpx+cli = " \
 python3 \
 python3-click \
 python3-httpx \
 python3-pygments \
 python3-rich \
 "
RDEPENDS:python3-httpx+http2 = " \
 python3 \
 python3-h2 \
 python3-httpx \
 "
RDEPENDS:python3-httpx+socks = " \
 python3 \
 python3-httpx \
 python3-socksio \
 "
