# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "konsole"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 konsole \
 konsole-part \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/konsole-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36974d407831b34af1e9a8acf9118feb195708b2a2dc65bb74ebef64d589b501"

URI_x86_64_v2_konsole = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konsole-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konsole;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_konsole}"
SRC_URI[x86_64_v2_konsole.sha256sum] = "5781db4a86a5aff13b5da1f2b4f7a35cde33c8024d063cd6f8db5766501e22cf"

URI_x86_64_v2_konsole-part = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konsole-part-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konsole-part;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_konsole-part}"
SRC_URI[x86_64_v2_konsole-part.sha256sum] = "931ba0171ea1b333c1b94a118433b494fcb0cca08831522166ccc1476e7922bc"

URI_aarch64_konsole = "${EPEL_MIRROR}/aarch64/Packages/k/konsole-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_konsole;unpack=0"
SRC_URI:append = " ${URI_aarch64_konsole}"
SRC_URI[aarch64_konsole.sha256sum] = "e8320e56ad6b3a44449223058de3f5e2123c8b6edf674dfc929b520d686e0689"

URI_aarch64_konsole-part = "${EPEL_MIRROR}/aarch64/Packages/k/konsole-part-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_konsole-part;unpack=0"
SRC_URI:append = " ${URI_aarch64_konsole-part}"
SRC_URI[aarch64_konsole-part.sha256sum] = "4d3e8b2daa3592ec472e788fb34688870cc63b6dc06672e177b98bc7896a3bc3"

RDEPENDS:konsole = " \
 bash \
 glibc \
 keditbookmarks \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 konsole-part \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:konsole-part = " \
 glibc \
 kf6-kbookmarks \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kparts \
 kf6-kpty \
 kf6-kservice \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libicu \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 "
