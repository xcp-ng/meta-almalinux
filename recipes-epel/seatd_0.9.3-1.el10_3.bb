# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "seatd"
PV = "0.9.3"
PR = "1.el10_3"
PACKAGES = " \
 libseat \
 libseat-devel \
 seatd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/seatd-0.9.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe8d7817d46dcd11b3ef07698101a9498550365d40f4e2166df30c581853be6a"

URI_x86_64_v2_libseat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libseat-0.9.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libseat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libseat}"
SRC_URI[x86_64_v2_libseat.sha256sum] = "da2867012652888bf3b8e7b318d2e815610e4f5cb4289ed463cd33c837de7d3f"

URI_x86_64_v2_libseat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libseat-devel-0.9.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libseat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libseat-devel}"
SRC_URI[x86_64_v2_libseat-devel.sha256sum] = "715f640064616a3655d563c003f87498db195abcea007ec4122389bd45536b00"

URI_x86_64_v2_seatd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/seatd-0.9.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_seatd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_seatd}"
SRC_URI[x86_64_v2_seatd.sha256sum] = "836ab842986e89030209fa10591246db19c5dcdca706af62e8e0c83c10910005"

URI_aarch64_libseat = "${EPEL_MIRROR}/aarch64/Packages/l/libseat-0.9.3-1.el10_3.aarch64.rpm;name=aarch64_libseat;unpack=0"
SRC_URI:append = " ${URI_aarch64_libseat}"
SRC_URI[aarch64_libseat.sha256sum] = "67d532e18a38b87b9500bc7dcff29dde8d42fc61872258d4910120c1434593a1"

URI_aarch64_libseat-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libseat-devel-0.9.3-1.el10_3.aarch64.rpm;name=aarch64_libseat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libseat-devel}"
SRC_URI[aarch64_libseat-devel.sha256sum] = "ab84ddcb788bd159e196217da639b1962fee82cf2c209051b24b171ae3a5e628"

URI_aarch64_seatd = "${EPEL_MIRROR}/aarch64/Packages/s/seatd-0.9.3-1.el10_3.aarch64.rpm;name=aarch64_seatd;unpack=0"
SRC_URI:append = " ${URI_aarch64_seatd}"
SRC_URI[aarch64_seatd.sha256sum] = "d86f010798dc4ab153a586feb927d025b07ba38c8b8e95c5b1d134b21d75d1bf"

RDEPENDS:libseat = " \
 glibc \
 systemd-libs \
 "
RDEPENDS:libseat-devel = " \
 libseat \
 pkgconf-pkg-config \
 systemd-devel \
 "
RDEPENDS:seatd = " \
 bash \
 glibc \
 "
