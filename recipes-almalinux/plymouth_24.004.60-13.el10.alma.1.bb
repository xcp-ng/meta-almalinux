# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plymouth"
PV = "24.004.60"
PR = "13.el10.alma.1"
PACKAGES = " \
 plymouth \
 plymouth-core-libs \
 plymouth-devel \
 plymouth-graphics-libs \
 plymouth-plugin-fade-throbber \
 plymouth-plugin-label \
 plymouth-plugin-script \
 plymouth-plugin-space-flares \
 plymouth-plugin-two-step \
 plymouth-scripts \
 plymouth-system-theme \
 plymouth-theme-fade-in \
 plymouth-theme-script \
 plymouth-theme-solar \
 plymouth-theme-spinfinity \
 plymouth-theme-spinner \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/plymouth-24.004.60-13.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a59be2c57064c11d23c747d82f5882b385db7d7610fa86112f75eb9f2e578866"

URI_x86_64_v2_plymouth = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plymouth-24.004.60-13.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_plymouth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth}"
SRC_URI[x86_64_v2_plymouth.sha256sum] = "e78cb47a93d16fccbbebad4de2715030e79ad33f7f9fa46ea1c4d499d3ba16d3"

URI_x86_64_v2_plymouth-core-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plymouth-core-libs-24.004.60-13.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_plymouth-core-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-core-libs}"
SRC_URI[x86_64_v2_plymouth-core-libs.sha256sum] = "f89441e78de478525b461d74c654078b64935b538911a064808eebc1e9c22214"

URI_x86_64_v2_plymouth-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plymouth-devel-24.004.60-13.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_plymouth-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-devel}"
SRC_URI[x86_64_v2_plymouth-devel.sha256sum] = "bdc442eb22d14906a6a755f0c84c2f88c37f719568199e9ca1309ea70806e8bf"

URI_x86_64_v2_plymouth-graphics-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plymouth-graphics-libs-24.004.60-13.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_plymouth-graphics-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-graphics-libs}"
SRC_URI[x86_64_v2_plymouth-graphics-libs.sha256sum] = "650d378b9d952483ee87d531b8abdc7a84be103bebf1d56bfcdb3cc987e7ddc7"

URI_x86_64_v2_plymouth-plugin-fade-throbber = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plymouth-plugin-fade-throbber-24.004.60-13.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_plymouth-plugin-fade-throbber;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-plugin-fade-throbber}"
SRC_URI[x86_64_v2_plymouth-plugin-fade-throbber.sha256sum] = "daa9fdf1203faab8d19b281ab12b41a96afb94e8b486303ec88a7b8317e4d6b6"

URI_x86_64_v2_plymouth-plugin-label = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plymouth-plugin-label-24.004.60-13.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_plymouth-plugin-label;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-plugin-label}"
SRC_URI[x86_64_v2_plymouth-plugin-label.sha256sum] = "c9b1489ab1225a0f358a5a727e6cf4baba961b8db2f337324d10dc5ef083e8ec"

URI_x86_64_v2_plymouth-plugin-script = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plymouth-plugin-script-24.004.60-13.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_plymouth-plugin-script;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-plugin-script}"
SRC_URI[x86_64_v2_plymouth-plugin-script.sha256sum] = "97bf2c101b534d3103adc27a8c1967b5e36eaa73e313b29cf3ea4b9b0d53e8a1"

URI_x86_64_v2_plymouth-plugin-space-flares = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plymouth-plugin-space-flares-24.004.60-13.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_plymouth-plugin-space-flares;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-plugin-space-flares}"
SRC_URI[x86_64_v2_plymouth-plugin-space-flares.sha256sum] = "a5f5117ce7aa517d238255a343b6d941f861e2c102ba2689bde390d4e7667ae8"

URI_x86_64_v2_plymouth-plugin-two-step = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plymouth-plugin-two-step-24.004.60-13.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_plymouth-plugin-two-step;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-plugin-two-step}"
SRC_URI[x86_64_v2_plymouth-plugin-two-step.sha256sum] = "959428693cb55f1879bcf63ab58270384d6395d0043b1ea58ca0d22187bcea33"

URI_x86_64_v2_plymouth-scripts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plymouth-scripts-24.004.60-13.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_plymouth-scripts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-scripts}"
SRC_URI[x86_64_v2_plymouth-scripts.sha256sum] = "3e31cea42f9f0019bd64505d0a96617d1234e6feb157c07666de5172f7829437"

URI_x86_64_v2_plymouth-system-theme = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plymouth-system-theme-24.004.60-13.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_plymouth-system-theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-system-theme}"
SRC_URI[x86_64_v2_plymouth-system-theme.sha256sum] = "98038b0fb7732b7e2eee29115f4fc85feb9ac93a24bf4c4a1e345f1ca0a9b6b4"

URI_x86_64_v2_plymouth-theme-fade-in = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plymouth-theme-fade-in-24.004.60-13.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_plymouth-theme-fade-in;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-theme-fade-in}"
SRC_URI[x86_64_v2_plymouth-theme-fade-in.sha256sum] = "4feb7716873efb1cbba3a9e3dbdb9df1b9f56899c4f997f088ea39a6209d441b"

URI_x86_64_v2_plymouth-theme-script = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plymouth-theme-script-24.004.60-13.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_plymouth-theme-script;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-theme-script}"
SRC_URI[x86_64_v2_plymouth-theme-script.sha256sum] = "59eb8102bb279db62f6b7d7dedfbb0c78d5910cd9793b3e9eb8bbd1c4da6f58d"

URI_x86_64_v2_plymouth-theme-solar = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plymouth-theme-solar-24.004.60-13.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_plymouth-theme-solar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-theme-solar}"
SRC_URI[x86_64_v2_plymouth-theme-solar.sha256sum] = "f04577e4b509341f76acdfc052e33404a20b95e7d4b3bcdb81309c97569a4917"

URI_x86_64_v2_plymouth-theme-spinfinity = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plymouth-theme-spinfinity-24.004.60-13.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_plymouth-theme-spinfinity;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-theme-spinfinity}"
SRC_URI[x86_64_v2_plymouth-theme-spinfinity.sha256sum] = "ed826a236e55c02a0dc5109ae3a955ab9e0d0cc697ea23f2ad74f642453cc46e"

URI_x86_64_v2_plymouth-theme-spinner = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plymouth-theme-spinner-24.004.60-13.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_plymouth-theme-spinner;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-theme-spinner}"
SRC_URI[x86_64_v2_plymouth-theme-spinner.sha256sum] = "1484e644dd3a45eb4ae4fa1fca60700db47fe1a8ac517bacc61b1ebf1f99a6ea"

URI_aarch64_plymouth = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plymouth-24.004.60-13.el10.alma.1.aarch64.rpm;name=aarch64_plymouth;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth}"
SRC_URI[aarch64_plymouth.sha256sum] = "f2a508fbf08d286d771e448b9208255a2230e2a7136d26d4e57e46512f67236e"

URI_aarch64_plymouth-core-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plymouth-core-libs-24.004.60-13.el10.alma.1.aarch64.rpm;name=aarch64_plymouth-core-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-core-libs}"
SRC_URI[aarch64_plymouth-core-libs.sha256sum] = "7a1472b8e2d6e185b3813022c4149618b488f3745bf8ec47c798ea2427ad5e50"

URI_aarch64_plymouth-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plymouth-devel-24.004.60-13.el10.alma.1.aarch64.rpm;name=aarch64_plymouth-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-devel}"
SRC_URI[aarch64_plymouth-devel.sha256sum] = "1b0ca2556c968598aac1c5407b30e1e3609c61c527835b8058eac8338b042784"

URI_aarch64_plymouth-graphics-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plymouth-graphics-libs-24.004.60-13.el10.alma.1.aarch64.rpm;name=aarch64_plymouth-graphics-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-graphics-libs}"
SRC_URI[aarch64_plymouth-graphics-libs.sha256sum] = "9a086aae209a844bdfd04205f7b3c2f3113b5fd28af5d4debab444e14a7821ba"

URI_aarch64_plymouth-plugin-fade-throbber = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plymouth-plugin-fade-throbber-24.004.60-13.el10.alma.1.aarch64.rpm;name=aarch64_plymouth-plugin-fade-throbber;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-plugin-fade-throbber}"
SRC_URI[aarch64_plymouth-plugin-fade-throbber.sha256sum] = "074b34fce10f9720696a8dcd69a96b385804792214f8f5f76fe0d5b3baf794e8"

URI_aarch64_plymouth-plugin-label = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plymouth-plugin-label-24.004.60-13.el10.alma.1.aarch64.rpm;name=aarch64_plymouth-plugin-label;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-plugin-label}"
SRC_URI[aarch64_plymouth-plugin-label.sha256sum] = "ed7320b912f29cefa4df82373ed570903983a0588a2c3e7168a086be7d2231f7"

URI_aarch64_plymouth-plugin-script = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plymouth-plugin-script-24.004.60-13.el10.alma.1.aarch64.rpm;name=aarch64_plymouth-plugin-script;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-plugin-script}"
SRC_URI[aarch64_plymouth-plugin-script.sha256sum] = "a8c07efc0bcf7d9dd9415298a4e061089b43ce1f93b2bb90465083534a9eefeb"

URI_aarch64_plymouth-plugin-space-flares = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plymouth-plugin-space-flares-24.004.60-13.el10.alma.1.aarch64.rpm;name=aarch64_plymouth-plugin-space-flares;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-plugin-space-flares}"
SRC_URI[aarch64_plymouth-plugin-space-flares.sha256sum] = "cc33922be319dc3e623843143bc3f6f60ab8e5cea135aec856eeed3d905effc0"

URI_aarch64_plymouth-plugin-two-step = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plymouth-plugin-two-step-24.004.60-13.el10.alma.1.aarch64.rpm;name=aarch64_plymouth-plugin-two-step;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-plugin-two-step}"
SRC_URI[aarch64_plymouth-plugin-two-step.sha256sum] = "afc7e9dbd4b88ce4e415a5ab407eb1625dfd9e3ef4fffd460f25adc68f18df43"

URI_aarch64_plymouth-scripts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plymouth-scripts-24.004.60-13.el10.alma.1.aarch64.rpm;name=aarch64_plymouth-scripts;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-scripts}"
SRC_URI[aarch64_plymouth-scripts.sha256sum] = "6045f2898e8ea66e90105903542d1c9589bb4c1d926c603a0333f0bf937afa94"

URI_aarch64_plymouth-system-theme = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plymouth-system-theme-24.004.60-13.el10.alma.1.aarch64.rpm;name=aarch64_plymouth-system-theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-system-theme}"
SRC_URI[aarch64_plymouth-system-theme.sha256sum] = "8cb6f855bf614696c941f80485245f427d0dc3e376c625bb146ffbb10c5b5d68"

URI_aarch64_plymouth-theme-fade-in = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plymouth-theme-fade-in-24.004.60-13.el10.alma.1.aarch64.rpm;name=aarch64_plymouth-theme-fade-in;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-theme-fade-in}"
SRC_URI[aarch64_plymouth-theme-fade-in.sha256sum] = "909adeab477fabcb6b9f96ae99c4588ae5270e9a1ffc9c45bc4ef87e73646e1f"

URI_aarch64_plymouth-theme-script = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plymouth-theme-script-24.004.60-13.el10.alma.1.aarch64.rpm;name=aarch64_plymouth-theme-script;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-theme-script}"
SRC_URI[aarch64_plymouth-theme-script.sha256sum] = "45b6e9082070a46720b74ef8fb9ae71bd53fbfe0a7361f59b0b7520ba9efad55"

URI_aarch64_plymouth-theme-solar = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plymouth-theme-solar-24.004.60-13.el10.alma.1.aarch64.rpm;name=aarch64_plymouth-theme-solar;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-theme-solar}"
SRC_URI[aarch64_plymouth-theme-solar.sha256sum] = "48cdef697b06f61bc486b88d21a467f4c2a5e2830b012e48e06dde6025db6730"

URI_aarch64_plymouth-theme-spinfinity = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plymouth-theme-spinfinity-24.004.60-13.el10.alma.1.aarch64.rpm;name=aarch64_plymouth-theme-spinfinity;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-theme-spinfinity}"
SRC_URI[aarch64_plymouth-theme-spinfinity.sha256sum] = "fdd21a3a31869ad793818a438c54d741eec09fcf1d21098404727b804a91230c"

URI_aarch64_plymouth-theme-spinner = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plymouth-theme-spinner-24.004.60-13.el10.alma.1.aarch64.rpm;name=aarch64_plymouth-theme-spinner;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-theme-spinner}"
SRC_URI[aarch64_plymouth-theme-spinner.sha256sum] = "58ed46d7a46a5c88f39ba81934e4460be76b87745efd361eed561c5f29c3704d"

RDEPENDS:plymouth = " \
 glibc \
 plymouth-core-libs \
 plymouth-scripts \
 xkeyboard-config \
 "
RDEPENDS:plymouth-core-libs = " \
 glibc \
 libevdev \
 libxkbcommon \
 systemd-libs \
 "
RDEPENDS:plymouth-devel = " \
 cairo \
 glib2 \
 glibc \
 gtk3 \
 libevdev-devel \
 libpng-devel \
 libxkbcommon-devel \
 pkgconf-pkg-config \
 plymouth \
 plymouth-core-libs \
 plymouth-devel \
 plymouth-graphics-libs \
 systemd-devel \
 xkeyboard-config-devel \
 "
RDEPENDS:plymouth-graphics-libs = " \
 almalinux-logos \
 glibc \
 libdrm \
 libpng \
 plymouth-core-libs \
 "
RDEPENDS:plymouth-plugin-fade-throbber = " \
 glibc \
 plymouth \
 plymouth-core-libs \
 plymouth-graphics-libs \
 "
RDEPENDS:plymouth-plugin-label = " \
 cairo \
 freetype \
 glib2 \
 glibc \
 pango \
 plymouth \
 plymouth-core-libs \
 plymouth-graphics-libs \
 "
RDEPENDS:plymouth-plugin-script = " \
 glibc \
 plymouth \
 plymouth-core-libs \
 plymouth-graphics-libs \
 "
RDEPENDS:plymouth-plugin-space-flares = " \
 glibc \
 plymouth \
 plymouth-core-libs \
 plymouth-graphics-libs \
 plymouth-plugin-label \
 "
RDEPENDS:plymouth-plugin-two-step = " \
 glibc \
 plymouth \
 plymouth-core-libs \
 plymouth-graphics-libs \
 plymouth-plugin-label \
 "
RDEPENDS:plymouth-scripts = " \
 bash \
 cpio \
 dracut \
 findutils \
 gzip \
 plymouth \
 virtual/coreutils \
 xkeyboard-config \
 "
RDEPENDS:plymouth-system-theme = " \
 plymouth-theme-spinner \
 "
RDEPENDS:plymouth-theme-fade-in = " \
 bash \
 plymouth-plugin-fade-throbber \
 plymouth-scripts \
 "
RDEPENDS:plymouth-theme-script = " \
 plymouth-plugin-script \
 plymouth-scripts \
 "
RDEPENDS:plymouth-theme-solar = " \
 bash \
 plymouth-plugin-space-flares \
 plymouth-scripts \
 "
RDEPENDS:plymouth-theme-spinfinity = " \
 bash \
 plymouth-plugin-two-step \
 plymouth-scripts \
 "
RDEPENDS:plymouth-theme-spinner = " \
 bash \
 plymouth-plugin-two-step \
 plymouth-scripts \
 redhat-mono-vf-fonts \
 redhat-text-vf-fonts \
 "
