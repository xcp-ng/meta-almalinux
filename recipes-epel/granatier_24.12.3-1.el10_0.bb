# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "granatier"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 granatier \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/granatier-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4756f8bbd6ce7a99e4d9fcf455c21aee79c90aab0ce52a3f7e5643a8a4c00e6a"

URI_x86_64_v2_granatier = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/granatier-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_granatier;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_granatier}"
SRC_URI[x86_64_v2_granatier.sha256sum] = "d2d13c8e431b56d2499b2bf636d475efc333aa96910ae66917dd7fc8b179062c"

URI_aarch64_granatier = "${EPEL_MIRROR}/aarch64/Packages/g/granatier-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_granatier;unpack=0"
SRC_URI:append = " ${URI_aarch64_granatier}"
SRC_URI[aarch64_granatier.sha256sum] = "a376d1c6bc0570a499f9eb181347c3dce73157c3540dc8de8bad3fb14d965e0d"

RDEPENDS:granatier = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
