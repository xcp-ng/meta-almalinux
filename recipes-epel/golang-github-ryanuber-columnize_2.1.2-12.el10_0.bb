# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-ryanuber-columnize"
PV = "2.1.2"
PR = "12.el10_0"
PACKAGES = " \
 golang-github-ryanuber-columnize-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-ryanuber-columnize-2.1.2-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "11b7de9c6d8981a208178506c59b00ab517966c93e669fbe374a309ac802204c"

URI_x86_64_v2_golang-github-ryanuber-columnize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-ryanuber-columnize-devel-2.1.2-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-ryanuber-columnize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-ryanuber-columnize-devel}"
SRC_URI[x86_64_v2_golang-github-ryanuber-columnize-devel.sha256sum] = "6b57f36e227f6a207cc0436e5ba560a34fbcc5874e7bc3e8003812b8251bec65"

URI_aarch64_golang-github-ryanuber-columnize-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-ryanuber-columnize-devel-2.1.2-12.el10_0.noarch.rpm;name=aarch64_golang-github-ryanuber-columnize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-ryanuber-columnize-devel}"
SRC_URI[aarch64_golang-github-ryanuber-columnize-devel.sha256sum] = "20e72df94de9c834a037357a515eaa5d39e1c4d7cc330dafce8c54367b06d8f5"

RDEPENDS:golang-github-ryanuber-columnize-devel = " \
 go-filesystem \
 "
