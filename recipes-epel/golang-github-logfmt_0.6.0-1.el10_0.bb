# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-logfmt"
PV = "0.6.0"
PR = "1.el10_0"
PACKAGES = " \
 golang-github-logfmt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-logfmt-0.6.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4deb6fbcc6b88a2d94b32d23162400e5092f14bb79cd880dd03f8410bfce47c1"

URI_x86_64_v2_golang-github-logfmt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-logfmt-devel-0.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-logfmt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-logfmt-devel}"
SRC_URI[x86_64_v2_golang-github-logfmt-devel.sha256sum] = "4b275b780f89be7b6245b4d37a54e4813af176950c3ace2ef50ab594dd4d04ad"

URI_aarch64_golang-github-logfmt-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-logfmt-devel-0.6.0-1.el10_0.noarch.rpm;name=aarch64_golang-github-logfmt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-logfmt-devel}"
SRC_URI[aarch64_golang-github-logfmt-devel.sha256sum] = "03054225c4ab1c77b2786d8b65a16e7de90a31ff395ab1899f864fef3a699094"

RDEPENDS:golang-github-logfmt-devel = " \
 go-filesystem \
 "
