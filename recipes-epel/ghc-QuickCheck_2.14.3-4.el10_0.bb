# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-QuickCheck"
PV = "2.14.3"
PR = "4.el10_0"
PACKAGES = " \
 ghc-QuickCheck \
 ghc-QuickCheck-devel \
 ghc-QuickCheck-doc \
 ghc-QuickCheck-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-QuickCheck-2.14.3-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7d108e5a6257f05871ec94153ae17430a0e0a712625ef14debbd0850e00963d"

URI_x86_64_v2_ghc-QuickCheck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-QuickCheck-2.14.3-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-QuickCheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-QuickCheck}"
SRC_URI[x86_64_v2_ghc-QuickCheck.sha256sum] = "ffd0ed4722092647215981b783035d1b995c3ea4ea3bf3c194974ccbbaa62976"

URI_x86_64_v2_ghc-QuickCheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-QuickCheck-devel-2.14.3-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-QuickCheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-QuickCheck-devel}"
SRC_URI[x86_64_v2_ghc-QuickCheck-devel.sha256sum] = "b49af3ce09ba74ba08aa1212ce3ece311d911e7868faa98b1c0f881e29e69162"

URI_x86_64_v2_ghc-QuickCheck-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-QuickCheck-doc-2.14.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-QuickCheck-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-QuickCheck-doc}"
SRC_URI[x86_64_v2_ghc-QuickCheck-doc.sha256sum] = "0db0731cac6950519082748a3afa7c0eed62fd1979418904476aeb8fbff723c7"

URI_x86_64_v2_ghc-QuickCheck-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-QuickCheck-prof-2.14.3-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-QuickCheck-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-QuickCheck-prof}"
SRC_URI[x86_64_v2_ghc-QuickCheck-prof.sha256sum] = "c2252fd06ebf2153145206e14a4289aa1b7a9a814097409375108e0a1a4cef24"

URI_aarch64_ghc-QuickCheck = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-QuickCheck-2.14.3-4.el10_0.aarch64.rpm;name=aarch64_ghc-QuickCheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-QuickCheck}"
SRC_URI[aarch64_ghc-QuickCheck.sha256sum] = "dca733b8dc1c1058de16b4def9e00e4c552eadcece996e9c45bde8de002cd6a6"

URI_aarch64_ghc-QuickCheck-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-QuickCheck-devel-2.14.3-4.el10_0.aarch64.rpm;name=aarch64_ghc-QuickCheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-QuickCheck-devel}"
SRC_URI[aarch64_ghc-QuickCheck-devel.sha256sum] = "8adcc57fff70e9d298d32da8dc0e15f8407f5b72e768e766bfa76e013780700b"

URI_aarch64_ghc-QuickCheck-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-QuickCheck-doc-2.14.3-4.el10_0.noarch.rpm;name=aarch64_ghc-QuickCheck-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-QuickCheck-doc}"
SRC_URI[aarch64_ghc-QuickCheck-doc.sha256sum] = "1fb4abf027e9c07bc6dce00429e3f6300df05335a302583a28f6eb0d8238d6c6"

URI_aarch64_ghc-QuickCheck-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-QuickCheck-prof-2.14.3-4.el10_0.aarch64.rpm;name=aarch64_ghc-QuickCheck-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-QuickCheck-prof}"
SRC_URI[aarch64_ghc-QuickCheck-prof.sha256sum] = "6adf4812862f8d4074342b07faec948998ae124d48547e16ab87bfb7b7edd530"

RDEPENDS:ghc-QuickCheck = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-random \
 ghc-splitmix \
 ghc-template-haskell \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-QuickCheck-devel = " \
 ghc-QuickCheck \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-deepseq-devel \
 ghc-random-devel \
 ghc-splitmix-devel \
 ghc-template-haskell-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-QuickCheck-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-QuickCheck-prof = " \
 ghc-QuickCheck-devel \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-deepseq-prof \
 ghc-random-prof \
 ghc-splitmix-prof \
 ghc-template-haskell-prof \
 ghc-transformers-prof \
 "
