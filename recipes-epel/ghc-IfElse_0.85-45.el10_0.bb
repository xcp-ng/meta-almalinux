# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-IfElse"
PV = "0.85"
PR = "45.el10_0"
PACKAGES = " \
 ghc-IfElse \
 ghc-IfElse-devel \
 ghc-IfElse-doc \
 ghc-IfElse-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-IfElse-0.85-45.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ea2e75bf6edae4b15fc519658989deabcfe3d2cb31d33d92695326974e58457"

URI_x86_64_v2_ghc-IfElse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-IfElse-0.85-45.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-IfElse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-IfElse}"
SRC_URI[x86_64_v2_ghc-IfElse.sha256sum] = "066b2891e36a8507b4b7c71f8cf03e974b2e205651b91b68c820b00bcbe53b03"

URI_x86_64_v2_ghc-IfElse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-IfElse-devel-0.85-45.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-IfElse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-IfElse-devel}"
SRC_URI[x86_64_v2_ghc-IfElse-devel.sha256sum] = "d56c0416c3251be815a5f392a6b978edecb4606ba15e42495c5f21bb91354a22"

URI_x86_64_v2_ghc-IfElse-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-IfElse-doc-0.85-45.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-IfElse-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-IfElse-doc}"
SRC_URI[x86_64_v2_ghc-IfElse-doc.sha256sum] = "be058b947b5250fd3e5d531b3341455ac7f519c4bc17609f60de514315211172"

URI_x86_64_v2_ghc-IfElse-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-IfElse-prof-0.85-45.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-IfElse-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-IfElse-prof}"
SRC_URI[x86_64_v2_ghc-IfElse-prof.sha256sum] = "175eb735e2155919a8cef91dfb96bf07b533850d784f48aaeefb58573d08a78a"

URI_aarch64_ghc-IfElse = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-IfElse-0.85-45.el10_0.aarch64.rpm;name=aarch64_ghc-IfElse;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-IfElse}"
SRC_URI[aarch64_ghc-IfElse.sha256sum] = "0eca96e42d65fa2563d461874b3476343462472190465110b098ec547f54266f"

URI_aarch64_ghc-IfElse-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-IfElse-devel-0.85-45.el10_0.aarch64.rpm;name=aarch64_ghc-IfElse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-IfElse-devel}"
SRC_URI[aarch64_ghc-IfElse-devel.sha256sum] = "7c5ac42f97bcc6d8f237fc12b2ad0ef70cec4fda42170a8d3ef8644cb990848c"

URI_aarch64_ghc-IfElse-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-IfElse-doc-0.85-45.el10_0.noarch.rpm;name=aarch64_ghc-IfElse-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-IfElse-doc}"
SRC_URI[aarch64_ghc-IfElse-doc.sha256sum] = "b761c2ac9950f99b49d9fea5c37b336c0d3717f7c8403e5db752776a5dfff172"

URI_aarch64_ghc-IfElse-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-IfElse-prof-0.85-45.el10_0.aarch64.rpm;name=aarch64_ghc-IfElse-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-IfElse-prof}"
SRC_URI[aarch64_ghc-IfElse-prof.sha256sum] = "333140779a189a64fbef3fadb73f803a27eb917d6e0100085ee57aab97fefdbb"

RDEPENDS:ghc-IfElse = " \
 ghc-base \
 ghc-ghc-bignum \
 ghc-mtl \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-IfElse-devel = " \
 ghc-IfElse \
 ghc-base-devel \
 ghc-compiler \
 ghc-mtl-devel \
 "
RDEPENDS:ghc-IfElse-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-IfElse-prof = " \
 ghc-IfElse-devel \
 ghc-base-prof \
 ghc-mtl-prof \
 "
