# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "isoimagewriter"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 isoimagewriter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/isoimagewriter-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "768f6fb0c0a5c2ffad59a1ccbd6911701dfdb1dda201f2346825837b95304aba"

URI_x86_64_v2_isoimagewriter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/isoimagewriter-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_isoimagewriter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_isoimagewriter}"
SRC_URI[x86_64_v2_isoimagewriter.sha256sum] = "190bafa547ab6c3ca1d97ef5d6cca6eab22be055a711322cf78fe7fb862eedb3"

URI_aarch64_isoimagewriter = "${EPEL_MIRROR}/aarch64/Packages/i/isoimagewriter-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_isoimagewriter;unpack=0"
SRC_URI:append = " ${URI_aarch64_isoimagewriter}"
SRC_URI[aarch64_isoimagewriter.sha256sum] = "cfcd07e932a65194944e74ac7eccefae2e86b90482ba224d22a220f7372aedd5"

RDEPENDS:isoimagewriter = " \
 glibc \
 gpgme2pp \
 kf6-karchive \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-solid \
 libgcc \
 libstdc++ \
 qgpgme2-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
