# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "c-icap-modules"
PV = "0.5.7"
PR = "5.20250117git36a6688.el10_1"
PACKAGES = " \
 c-icap-modules \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/c-icap-modules-0.5.7-5.20250117git36a6688.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b4e475e6e9940f9f154f4772d48cc2183839e9c785abd1420593165af37277f"

URI_x86_64_v2_c-icap-modules = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/c-icap-modules-0.5.7-5.20250117git36a6688.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_c-icap-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_c-icap-modules}"
SRC_URI[x86_64_v2_c-icap-modules.sha256sum] = "d93f491ea15080c66726c9ea6eb0dadfe371761d6ff30a8c149f0311eaee453b"

URI_aarch64_c-icap-modules = "${EPEL_MIRROR}/aarch64/Packages/c/c-icap-modules-0.5.7-5.20250117git36a6688.el10_1.aarch64.rpm;name=aarch64_c-icap-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_c-icap-modules}"
SRC_URI[aarch64_c-icap-modules.sha256sum] = "8030c69d6ee2af5a8ce55d4595f1cbecbefee3d42c1630ae709b6d3515809650"

RDEPENDS:c-icap-modules = " \
 c-icap \
 c-icap-libs \
 clamav-lib \
 glibc \
 lmdb-libs \
 "
