# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libtirpc"
PV = "1.3.5"
PR = "1.el10"
PACKAGES = " \
 libtirpc \
 libtirpc-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libtirpc-1.3.5-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8941dc468defdc14a77ae3eb6fb0339c4f36278815d958e505914bd2a05d5e48"

URI_x86_64_v2_libtirpc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libtirpc-1.3.5-1.el10.x86_64_v2.rpm;name=x86_64_v2_libtirpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtirpc}"
SRC_URI[x86_64_v2_libtirpc.sha256sum] = "9f2b051efd3d299bfe9fb2646d1fcc7ff7eac96a71bdb2e7b1c75f702e00371d"

URI_x86_64_v2_libtirpc-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libtirpc-devel-1.3.5-1.el10.x86_64_v2.rpm;name=x86_64_v2_libtirpc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtirpc-devel}"
SRC_URI[x86_64_v2_libtirpc-devel.sha256sum] = "d5060ef88477266237e163472b42b9bbf7333eb5b9e528c143fa8525a1d1f3eb"

URI_aarch64_libtirpc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libtirpc-1.3.5-1.el10.aarch64.rpm;name=aarch64_libtirpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtirpc}"
SRC_URI[aarch64_libtirpc.sha256sum] = "7ce766b21df250e0aa5ba55a12b3da7046a02b5b89de75f5905da7c46e696804"

URI_aarch64_libtirpc-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libtirpc-devel-1.3.5-1.el10.aarch64.rpm;name=aarch64_libtirpc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtirpc-devel}"
SRC_URI[aarch64_libtirpc-devel.sha256sum] = "17da10b5d34c090c744f958295b10c7357959ae0aed142f1f1e9a2a6825fc829"

RDEPENDS:libtirpc = " \
 glibc \
 krb5-libs \
 libcom_err \
 "
RDEPENDS:libtirpc-devel = " \
 libtirpc \
 pkgconf-pkg-config \
 "
