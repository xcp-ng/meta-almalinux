# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "icecream"
PV = "1.4"
PR = "29.el10_2"
PACKAGES = " \
 icecream \
 icecream-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/icecream-1.4-29.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "33638cd4429160b77938232cc0a0ece5d8c24bb4d89d80cf904a3363a40a9230"

URI_x86_64_v2_icecream = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/icecream-1.4-29.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_icecream;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_icecream}"
SRC_URI[x86_64_v2_icecream.sha256sum] = "a97928f28a94260e77b8cf7478d1f692eacf003811538e40849fbf716b30588c"

URI_x86_64_v2_icecream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/icecream-devel-1.4-29.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_icecream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_icecream-devel}"
SRC_URI[x86_64_v2_icecream-devel.sha256sum] = "8107d19882a8c6c287b4985ef6e01f5aceea1fce5659765623f7272ee022cd4d"

URI_aarch64_icecream = "${EPEL_MIRROR}/aarch64/Packages/i/icecream-1.4-29.el10_2.aarch64.rpm;name=aarch64_icecream;unpack=0"
SRC_URI:append = " ${URI_aarch64_icecream}"
SRC_URI[aarch64_icecream.sha256sum] = "1edd25dd1ef193e7d9f4eb6bbacc6997e31d80db3fd3d0606cd30bd5ae1826b8"

URI_aarch64_icecream-devel = "${EPEL_MIRROR}/aarch64/Packages/i/icecream-devel-1.4-29.el10_2.aarch64.rpm;name=aarch64_icecream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_icecream-devel}"
SRC_URI[aarch64_icecream-devel.sha256sum] = "ca602ab0b57c4fe84d4d6c3096cc1c206b98622891ffaef350932b9b579d9525"

RDEPENDS:icecream = " \
 bash \
 firewalld-filesystem \
 glibc \
 libarchive \
 libcap-ng \
 libgcc \
 libstdc++ \
 libzstd \
 lzo \
 policycoreutils \
 policycoreutils-python-utils \
 shadow-utils \
 systemd \
 virtual/environment_modules_ \
 "
RDEPENDS:icecream-devel = " \
 icecream \
 libarchive-devel \
 libcap-ng-devel \
 libzstd-devel \
 lzo-devel \
 pkgconf-pkg-config \
 "
