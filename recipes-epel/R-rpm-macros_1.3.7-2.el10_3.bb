# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "R-rpm-macros"
PV = "1.3.7"
PR = "2.el10_3"
PACKAGES = " \
 R-rpm-macros \
 R-srpm-macros \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/R-rpm-macros-1.3.7-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50dc837c382b10388c8db774d54e9b1d2f972fda9670570a948587875bc4475f"

URI_x86_64_v2_R-rpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-rpm-macros-1.3.7-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_R-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-rpm-macros}"
SRC_URI[x86_64_v2_R-rpm-macros.sha256sum] = "90e7e95118d6dfc550b56378f83d5f26403cfe603311d4731b38e7282a663c05"

URI_x86_64_v2_R-srpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-srpm-macros-1.3.7-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_R-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-srpm-macros}"
SRC_URI[x86_64_v2_R-srpm-macros.sha256sum] = "7bc9b7c55a321c5d1df261842e2d775b96ad12976e2302d7aff5bf06bf5a7bd7"

URI_aarch64_R-rpm-macros = "${EPEL_MIRROR}/aarch64/Packages/r/R-rpm-macros-1.3.7-2.el10_3.noarch.rpm;name=aarch64_R-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-rpm-macros}"
SRC_URI[aarch64_R-rpm-macros.sha256sum] = "bb13aab4302d350655f831787733a6f0cd9439ba56845bc3c734ce8b212886d3"

URI_aarch64_R-srpm-macros = "${EPEL_MIRROR}/aarch64/Packages/r/R-srpm-macros-1.3.7-2.el10_3.noarch.rpm;name=aarch64_R-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-srpm-macros}"
SRC_URI[aarch64_R-srpm-macros.sha256sum] = "04a3d2cb99c32c9d3e2c25ed9ba21d30da79af1deb61fd4b46babc9947731c44"

RDEPENDS:R-rpm-macros = " \
 R-core \
 R-srpm-macros \
 rpm \
 "
RDEPENDS:R-srpm-macros = " \
 redhat-rpm-config \
 "
