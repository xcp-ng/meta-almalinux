# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "diffstat"
PV = "1.66"
PR = "3.el10"
PACKAGES = " \
 diffstat \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/diffstat-1.66-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f5e223ffdfc3de4742f7f2fc472b429e06c25a5b6bc50da45b9a7f9ae28bd3e0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/diffstat-1.66-3.el10.x86_64_v2.rpm;name=x86_64_v2_diffstat;unpack=0"
SRC_URI[x86_64_v2_diffstat.sha256sum] = "fa5b669929a1b0bb3cb0397842a8396fb739363ba87e5a29fb7a9ac11e761fe2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/diffstat-1.66-3.el10.aarch64.rpm;name=aarch64_diffstat;unpack=0"
SRC_URI[aarch64_diffstat.sha256sum] = "1509ee97cdd2f71f1532fe625ec7ee5804eed0b583a4e3d9cd009eea4ad580b6"

RDEPENDS:diffstat = " \
 glibc \
 "
