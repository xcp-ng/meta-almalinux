# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fping"
PV = "5.2"
PR = "3.el10_0"
PACKAGES = " \
 fping \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fping-5.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc222e59f05f75c1031286e285eab3e67a67b64ac2f09190c961d533e9d97aab"

URI_x86_64_v2_fping = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fping-5.2-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fping;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fping}"
SRC_URI[x86_64_v2_fping.sha256sum] = "b6451c1804a1a3b9e39190121324c45b78706e32e71a63cea2117d91ea16480e"

URI_aarch64_fping = "${EPEL_MIRROR}/aarch64/Packages/f/fping-5.2-3.el10_0.aarch64.rpm;name=aarch64_fping;unpack=0"
SRC_URI:append = " ${URI_aarch64_fping}"
SRC_URI[aarch64_fping.sha256sum] = "9338e268460fce67d0fbe5f1b2d11a2f725385e72624f4000b1c9e27e2e72da0"

RDEPENDS:fping = " \
 glibc \
 "
