# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "imath"
PV = "3.1.10"
PR = "4.el10"
PACKAGES = " \
 imath \
 imath-devel \
 python3-imath \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/imath-3.1.10-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0295c1b24a796dbc8ce548a9019016215f1da37d6b5f72ce80d6efb3c11bb365"

URI_x86_64_v2_imath = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/imath-3.1.10-4.el10.x86_64_v2.rpm;name=x86_64_v2_imath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_imath}"
SRC_URI[x86_64_v2_imath.sha256sum] = "62d6f930c3603288fa09e0d61f75481753457e7dc1a183aac68fa69e3908ad10"

URI_x86_64_v2_imath-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/imath-devel-3.1.10-4.el10.x86_64_v2.rpm;name=x86_64_v2_imath-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_imath-devel}"
SRC_URI[x86_64_v2_imath-devel.sha256sum] = "69cb993377dc95a785003ca7317fd059ce180fd87bf478b653a1c0bba890171d"

URI_x86_64_v2_python3-imath = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-imath-3.1.10-4.el10.x86_64_v2.rpm;name=x86_64_v2_python3-imath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-imath}"
SRC_URI[x86_64_v2_python3-imath.sha256sum] = "9ef22c616f21101f854018891b909ab8edac5d072059f565276ce45d51c505ae"

URI_aarch64_imath = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/imath-3.1.10-4.el10.aarch64.rpm;name=aarch64_imath;unpack=0"
SRC_URI:append = " ${URI_aarch64_imath}"
SRC_URI[aarch64_imath.sha256sum] = "bd7de34f78d5fba1b216b2c4d936811dc4646f6e5fc105cec5abdc24db8f6adf"

URI_aarch64_imath-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/imath-devel-3.1.10-4.el10.aarch64.rpm;name=aarch64_imath-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_imath-devel}"
SRC_URI[aarch64_imath-devel.sha256sum] = "b8fc3f80c712d8a57cc6fb81553a36f8ea4094575e27fbf50a01a1943af93a89"

URI_aarch64_python3-imath = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-imath-3.1.10-4.el10.aarch64.rpm;name=aarch64_python3-imath;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-imath}"
SRC_URI[aarch64_python3-imath.sha256sum] = "5b7e01e8aebcd5bab310fc5a2fff16d208a4336f780bba88141ca0e3db3d4e84"

RDEPENDS:imath = " \
 glibc \
 libstdc++ \
 "
RDEPENDS:imath-devel = " \
 boost-devel \
 cmake-filesystem \
 imath \
 pkgconf-pkg-config \
 python3-devel \
 python3-imath \
 "
RDEPENDS:python3-imath = " \
 boost-python3 \
 glibc \
 imath \
 libgcc \
 libstdc++ \
 python3 \
 python3-libs \
 "
