# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tinycdb"
PV = "0.80"
PR = "4.el10"
PACKAGES = " \
 tinycdb \
 tinycdb-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tinycdb-0.80-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12313ff2c67e513aadddea1fc12aa3f3bb5aef1626441dd246549c970ae740f5"

URI_x86_64_v2_tinycdb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tinycdb-0.80-4.el10.x86_64_v2.rpm;name=x86_64_v2_tinycdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tinycdb}"
SRC_URI[x86_64_v2_tinycdb.sha256sum] = "869264a9fa665c422fcba530d3fb61def41b0dd8cb59076af3156ec50aecffa2"

URI_x86_64_v2_tinycdb-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/tinycdb-devel-0.80-4.el10.x86_64_v2.rpm;name=x86_64_v2_tinycdb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tinycdb-devel}"
SRC_URI[x86_64_v2_tinycdb-devel.sha256sum] = "0c0fae225188ee2f165ae60982c545c2d0d621692c67b2caf27989aed2ef8cfe"

URI_aarch64_tinycdb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tinycdb-0.80-4.el10.aarch64.rpm;name=aarch64_tinycdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_tinycdb}"
SRC_URI[aarch64_tinycdb.sha256sum] = "d96023dab769061cc0f1ad267e7283f004eda0a255f5ba49a2cb337a9cdf96f4"

URI_aarch64_tinycdb-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/tinycdb-devel-0.80-4.el10.aarch64.rpm;name=aarch64_tinycdb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_tinycdb-devel}"
SRC_URI[aarch64_tinycdb-devel.sha256sum] = "945abdff1a4c35d17a024e828c714cf0cf60f931243aecbaac85fd9a997a73e0"

RDEPENDS:tinycdb = " \
 glibc \
 "
RDEPENDS:tinycdb-devel = " \
 pkgconf-pkg-config \
 tinycdb \
 "
