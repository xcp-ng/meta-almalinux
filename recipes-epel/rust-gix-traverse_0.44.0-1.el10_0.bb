# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-traverse"
PV = "0.44.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-traverse+default-devel \
 rust-gix-traverse-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-traverse-0.44.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff72cc7a0302b29c7e64e9180a41a1a267a1fdf3a3ce0b171a91f0fc8fe5eb46"

URI_x86_64_v2_rust-gix-traverse+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-traverse+default-devel-0.44.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-traverse+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-traverse+default-devel}"
SRC_URI[x86_64_v2_rust-gix-traverse+default-devel.sha256sum] = "da62446945a622279cb01043b3a7b92f2b69c3043f8862bcb40b694b6e301a4d"

URI_x86_64_v2_rust-gix-traverse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-traverse-devel-0.44.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-traverse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-traverse-devel}"
SRC_URI[x86_64_v2_rust-gix-traverse-devel.sha256sum] = "34116a9ad321bef14ef94f721d7cf72f8398c18fb5718e746c15030ec7063d60"

URI_aarch64_rust-gix-traverse+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-traverse+default-devel-0.44.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-traverse+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-traverse+default-devel}"
SRC_URI[aarch64_rust-gix-traverse+default-devel.sha256sum] = "d4d81df7e1db2f56147c2224ffca7d47b6add586e05d9770b9f938f9abde07af"

URI_aarch64_rust-gix-traverse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-traverse-devel-0.44.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-traverse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-traverse-devel}"
SRC_URI[aarch64_rust-gix-traverse-devel.sha256sum] = "139272a4b87a9a53d797121d5abbeb1e86fb30035c83384ea17cd53ce92b2654"

RDEPENDS:rust-gix-traverse+default-devel = " \
 cargo \
 rust-gix-traverse-devel \
 "
RDEPENDS:rust-gix-traverse-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-gix-commitgraph+default-devel \
 rust-gix-date+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-hashtable+default-devel \
 rust-gix-object+default-devel \
 rust-gix-revwalk+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 "
