# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkleo"
PV = "26.08.1"
PR = "1.1.el10_3"
PACKAGES = " \
 libkleo \
 libkleo-devel \
 libkleo-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libkleo-26.08.1-1.1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cf47ade986888ff727646a5c66db7f023081060bf282cf0038db65234633846d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkleo-26.08.1-1.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkleo;unpack=0"
SRC_URI[x86_64_v2_libkleo.sha256sum] = "40cf8c7f6ad7e5b0afe7d84b95254a8bba787d722b1378ca1e630a9f53b51e36"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkleo-devel-26.08.1-1.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkleo-devel;unpack=0"
SRC_URI[x86_64_v2_libkleo-devel.sha256sum] = "e5569aa79a3bf17dbbc751aedbebe36ffdc520fdc817736227e82d8fe1a75fd6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkleo-doc-26.08.1-1.1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_libkleo-doc;unpack=0"
SRC_URI[x86_64_v2_libkleo-doc.sha256sum] = "fcdb21e8b36b6726b6af9ea7cdb151b6a689754a15628402036d0558c9cb1771"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libkleo-26.08.1-1.1.el10_3.aarch64.rpm;name=aarch64_libkleo;unpack=0"
SRC_URI[aarch64_libkleo.sha256sum] = "4f2a28266f7e240145a8385fbd3ed14d4dd66e875ad597e77d32416b7696f3d9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libkleo-devel-26.08.1-1.1.el10_3.aarch64.rpm;name=aarch64_libkleo-devel;unpack=0"
SRC_URI[aarch64_libkleo-devel.sha256sum] = "ef561e8fca5b6684b930c57098301ca69f77c1ebf7e72297e9924f4ef6ecc4c0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libkleo-doc-26.08.1-1.1.el10_3.noarch.rpm;name=aarch64_libkleo-doc;unpack=0"
SRC_URI[aarch64_libkleo-doc.sha256sum] = "e79ce84780e343b327c62eeb7667e4b47cef07d5d551d8e7e90cc5a82c8d99ec"

RDEPENDS:libkleo = " \
 glibc \
 gpgme2pp \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kitemmodels \
 kf6-kwidgetsaddons \
 libgcc \
 libstdc++ \
 qgpgme2-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkleo-devel = " \
 cmake-filesystem \
 libkleo \
 virtual/cmake_Gpgmepp_ \
 virtual/cmake_QGpgmeQt6_ \
 "
RDEPENDS:libkleo-doc = " \
 "
