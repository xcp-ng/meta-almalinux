# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rmp"
PV = "0.8.15"
PR = "1.el10_2"
PACKAGES = " \
 rust-rmp+default-devel \
 rust-rmp+std-devel \
 rust-rmp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rmp-0.8.15-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "653ff7c775b34fe625519f91d3c42bee53386e31eb3ea22c6e09d7abbdc668da"

URI_x86_64_v2_rust-rmp+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rmp+default-devel-0.8.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rmp+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rmp+default-devel}"
SRC_URI[x86_64_v2_rust-rmp+default-devel.sha256sum] = "2a8e36bec9dfea656b69c7e885ef2cc96bd70c7090269317e1334b8809acaa87"

URI_x86_64_v2_rust-rmp+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rmp+std-devel-0.8.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rmp+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rmp+std-devel}"
SRC_URI[x86_64_v2_rust-rmp+std-devel.sha256sum] = "ff5eb5c6f46d749b283bfd8b054978a10610121418214faa2ab43d0686963740"

URI_x86_64_v2_rust-rmp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rmp-devel-0.8.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rmp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rmp-devel}"
SRC_URI[x86_64_v2_rust-rmp-devel.sha256sum] = "e805ecdb548b62893043d0ec8feee35b917144fe21c4e6861cf2b67c710db11b"

URI_aarch64_rust-rmp+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rmp+default-devel-0.8.15-1.el10_2.noarch.rpm;name=aarch64_rust-rmp+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rmp+default-devel}"
SRC_URI[aarch64_rust-rmp+default-devel.sha256sum] = "4694d6a44885897cbe99c5cfa8bce2adc279e293f780f85ff4868bcc9b7f737b"

URI_aarch64_rust-rmp+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rmp+std-devel-0.8.15-1.el10_2.noarch.rpm;name=aarch64_rust-rmp+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rmp+std-devel}"
SRC_URI[aarch64_rust-rmp+std-devel.sha256sum] = "17e0bb65f8ddc3ce643424fe4b1973093ec3fc5dba8d110c4cc831ffd5db816c"

URI_aarch64_rust-rmp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rmp-devel-0.8.15-1.el10_2.noarch.rpm;name=aarch64_rust-rmp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rmp-devel}"
SRC_URI[aarch64_rust-rmp-devel.sha256sum] = "56f990df207d2044fcb054789f796d2cd6893277fcba60cb3fa0a2b4ff68103e"

RDEPENDS:rust-rmp+default-devel = " \
 cargo \
 rust-rmp+std-devel \
 rust-rmp-devel \
 "
RDEPENDS:rust-rmp+std-devel = " \
 cargo \
 rust-num-traits+std-devel \
 rust-rmp-devel \
 "
RDEPENDS:rust-rmp-devel = " \
 cargo \
 rust \
 rust-num-traits-devel \
 "
