# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "criu"
PV = "3.19"
PR = "9.el10"
PACKAGES = " \
 crit \
 criu \
 criu-devel \
 criu-libs \
 python3-criu \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/criu-3.19-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "332df82619270c83fc14f8dcda266cee91c64bfdf45b00e5ff0c887aa08159de"

URI_x86_64_v2_crit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/crit-3.19-9.el10.x86_64_v2.rpm;name=x86_64_v2_crit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_crit}"
SRC_URI[x86_64_v2_crit.sha256sum] = "a2748dfd8b14d79ac9d93e3c65ebabcdfe0a7d782f879aa871b7effe7d0eed53"

URI_x86_64_v2_criu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/criu-3.19-9.el10.x86_64_v2.rpm;name=x86_64_v2_criu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_criu}"
SRC_URI[x86_64_v2_criu.sha256sum] = "fdc217ff3a50614560a95f3dd5678db8d0ff125499a7d0d74b2f7c3f6763cdc5"

URI_x86_64_v2_criu-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/criu-devel-3.19-9.el10.x86_64_v2.rpm;name=x86_64_v2_criu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_criu-devel}"
SRC_URI[x86_64_v2_criu-devel.sha256sum] = "8917c74360a62dcf2b251840c8f28dbddaab93ba4e1598e2afdb8bc6bfc1c20e"

URI_x86_64_v2_criu-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/criu-libs-3.19-9.el10.x86_64_v2.rpm;name=x86_64_v2_criu-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_criu-libs}"
SRC_URI[x86_64_v2_criu-libs.sha256sum] = "13cc444d244ad74d9e710ca82801c0ef5849c636e11305a21a1eb8ca453d51bc"

URI_x86_64_v2_python3-criu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-criu-3.19-9.el10.x86_64_v2.rpm;name=x86_64_v2_python3-criu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-criu}"
SRC_URI[x86_64_v2_python3-criu.sha256sum] = "7f457ccb3b162ed37b5d50379e7598846b787507ef21be9b25ec429b70e1d58f"

URI_aarch64_crit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/crit-3.19-9.el10.aarch64.rpm;name=aarch64_crit;unpack=0"
SRC_URI:append = " ${URI_aarch64_crit}"
SRC_URI[aarch64_crit.sha256sum] = "7840b8c48b8adc89359d2531b8ac2c2138d7362b521b3b42df40ddd8ae257c0b"

URI_aarch64_criu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/criu-3.19-9.el10.aarch64.rpm;name=aarch64_criu;unpack=0"
SRC_URI:append = " ${URI_aarch64_criu}"
SRC_URI[aarch64_criu.sha256sum] = "3d00d0c5c6254c76f18da7a5461ee7562d60d7b8ff6ed8a0e771bca45a3ee927"

URI_aarch64_criu-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/criu-devel-3.19-9.el10.aarch64.rpm;name=aarch64_criu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_criu-devel}"
SRC_URI[aarch64_criu-devel.sha256sum] = "69a050939e1312ee61a9e306c194b18878a86baf3df4aff8ee88baa17be24eac"

URI_aarch64_criu-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/criu-libs-3.19-9.el10.aarch64.rpm;name=aarch64_criu-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_criu-libs}"
SRC_URI[aarch64_criu-libs.sha256sum] = "7fce99f6910037d189fda8b33b58017c87337dba93c4f082d46150f5cf1e76a1"

URI_aarch64_python3-criu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-criu-3.19-9.el10.aarch64.rpm;name=aarch64_python3-criu;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-criu}"
SRC_URI[aarch64_python3-criu.sha256sum] = "166e52237eceb54237c651789e4ce16064f237da71870e6d1c0b862e4ec0dc59"

RDEPENDS:crit = " \
 python3 \
 python3-criu \
 "
RDEPENDS:criu = " \
 bash \
 glibc \
 gnutls \
 libgcc \
 libnet \
 libnl3 \
 libselinux \
 libuuid \
 nftables \
 protobuf-c \
 "
RDEPENDS:criu-devel = " \
 criu \
 criu-libs \
 pkgconf-pkg-config \
 protobuf-c-devel \
 "
RDEPENDS:criu-libs = " \
 criu \
 glibc \
 protobuf-c \
 "
RDEPENDS:python3-criu = " \
 python3 \
 python3-protobuf \
 "
