# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-NTLM"
PV = "1.09"
PR = "41.el10"
PACKAGES = " \
 perl-NTLM \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-NTLM-1.09-41.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8ba41fcb4cc735a83009dcf60ab8b66e4a44e93093408409ccc24728bd8c3bbc"

URI_x86_64_v2_perl-NTLM = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-NTLM-1.09-41.el10.noarch.rpm;name=x86_64_v2_perl-NTLM;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-NTLM}"
SRC_URI[x86_64_v2_perl-NTLM.sha256sum] = "afd979172e04a8cc4caa742c118219f99702e3a7915fa4e7166e757aab240849"

URI_aarch64_perl-NTLM = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-NTLM-1.09-41.el10.noarch.rpm;name=aarch64_perl-NTLM;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-NTLM}"
SRC_URI[aarch64_perl-NTLM.sha256sum] = "afd979172e04a8cc4caa742c118219f99702e3a7915fa4e7166e757aab240849"

RDEPENDS:perl-NTLM = " \
 perl-Digest-HMAC \
 perl-Exporter \
 perl-MIME-Base64 \
 perl-NTLM \
 perl-constant \
 perl-libs \
 perl-vars \
 "
