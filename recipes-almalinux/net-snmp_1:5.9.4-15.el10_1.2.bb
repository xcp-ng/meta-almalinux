# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "net-snmp"
PE = "1"
PV = "5.9.4"
PR = "15.el10_1.2"
PACKAGES = " \
 net-snmp \
 net-snmp-agent-libs \
 net-snmp-devel \
 net-snmp-libs \
 net-snmp-perl \
 net-snmp-perl-module \
 net-snmp-utils \
 python3-net-snmp \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/net-snmp-5.9.4-15.el10_1.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "95798e96986fb71c62a1d98456e8ea7a157c40c094443fb5f8f1b402d17d6bb5"

URI_x86_64_v2_net-snmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/net-snmp-5.9.4-15.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_net-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_net-snmp}"
SRC_URI[x86_64_v2_net-snmp.sha256sum] = "a3c69c1077d501985da98e8208f288d87210899bfe27c8bc09c817100641b2ac"

URI_x86_64_v2_net-snmp-agent-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/net-snmp-agent-libs-5.9.4-15.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_net-snmp-agent-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_net-snmp-agent-libs}"
SRC_URI[x86_64_v2_net-snmp-agent-libs.sha256sum] = "5316dc68e51b3c1cb15989ac78d6089cf50317e3873bcee7c8a2e2f7b64d41b8"

URI_x86_64_v2_net-snmp-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/net-snmp-devel-5.9.4-15.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_net-snmp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_net-snmp-devel}"
SRC_URI[x86_64_v2_net-snmp-devel.sha256sum] = "3096e89aaa213d0c89be364b52bc3b0d4307de3fef2fc4d826c2be1b27b27274"

URI_x86_64_v2_net-snmp-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/net-snmp-libs-5.9.4-15.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_net-snmp-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_net-snmp-libs}"
SRC_URI[x86_64_v2_net-snmp-libs.sha256sum] = "3bae2af1fdd7086adef00761fe9d67afaa414aa418bf95b0fdc79137d3a0028e"

URI_x86_64_v2_net-snmp-perl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/net-snmp-perl-5.9.4-15.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_net-snmp-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_net-snmp-perl}"
SRC_URI[x86_64_v2_net-snmp-perl.sha256sum] = "775b4ec2e1dc4df90ba1a7f65fb1f1f962e31494c090eebdfaad679777131f18"

URI_x86_64_v2_net-snmp-perl-module = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/net-snmp-perl-module-5.9.4-15.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_net-snmp-perl-module;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_net-snmp-perl-module}"
SRC_URI[x86_64_v2_net-snmp-perl-module.sha256sum] = "0fef7e64575f12b7335633af9c967b8572c1299e935e7da65a2b50132a69cc02"

URI_x86_64_v2_net-snmp-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/net-snmp-utils-5.9.4-15.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_net-snmp-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_net-snmp-utils}"
SRC_URI[x86_64_v2_net-snmp-utils.sha256sum] = "556c6af2f4671810f52910a681c036c2baf43fe6042b67d63def17bbe6480c95"

URI_x86_64_v2_python3-net-snmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-net-snmp-5.9.4-15.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_python3-net-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-net-snmp}"
SRC_URI[x86_64_v2_python3-net-snmp.sha256sum] = "568e3415032118126fd40933eb2580a017a725d97684f710e4ea3ca488dc3068"

URI_aarch64_net-snmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/net-snmp-5.9.4-15.el10_1.2.aarch64.rpm;name=aarch64_net-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_net-snmp}"
SRC_URI[aarch64_net-snmp.sha256sum] = "e6449783b01c2f462b28373c864bf6e9086fe073d425ecfba53f21892be25ed4"

URI_aarch64_net-snmp-agent-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/net-snmp-agent-libs-5.9.4-15.el10_1.2.aarch64.rpm;name=aarch64_net-snmp-agent-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_net-snmp-agent-libs}"
SRC_URI[aarch64_net-snmp-agent-libs.sha256sum] = "5248667f5a739470c1c882d5c5321fb88b628cfa145de9a62b106455741a907e"

URI_aarch64_net-snmp-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/net-snmp-devel-5.9.4-15.el10_1.2.aarch64.rpm;name=aarch64_net-snmp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_net-snmp-devel}"
SRC_URI[aarch64_net-snmp-devel.sha256sum] = "2496b60eb5daa86f8b7ec466cf3b50a98e26eab20cf2fef00636690a86c298bc"

URI_aarch64_net-snmp-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/net-snmp-libs-5.9.4-15.el10_1.2.aarch64.rpm;name=aarch64_net-snmp-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_net-snmp-libs}"
SRC_URI[aarch64_net-snmp-libs.sha256sum] = "25591a33602ffd717b7c968619021a556a023bc97dc126e3e0892facc67c59e7"

URI_aarch64_net-snmp-perl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/net-snmp-perl-5.9.4-15.el10_1.2.aarch64.rpm;name=aarch64_net-snmp-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_net-snmp-perl}"
SRC_URI[aarch64_net-snmp-perl.sha256sum] = "a8efc9736c49431ffcea555582bfe91a724fee5a274f1bfd483ca8112697a120"

URI_aarch64_net-snmp-perl-module = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/net-snmp-perl-module-5.9.4-15.el10_1.2.aarch64.rpm;name=aarch64_net-snmp-perl-module;unpack=0"
SRC_URI:append = " ${URI_aarch64_net-snmp-perl-module}"
SRC_URI[aarch64_net-snmp-perl-module.sha256sum] = "d05c030d2d6f1c88b2903cc0ce204546b019ffcb297b89f5e74601bbc64c9dea"

URI_aarch64_net-snmp-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/net-snmp-utils-5.9.4-15.el10_1.2.aarch64.rpm;name=aarch64_net-snmp-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_net-snmp-utils}"
SRC_URI[aarch64_net-snmp-utils.sha256sum] = "82a9dea76b62c4c6bf0fb55b5de9a1dce725207c301e80a914b63eb9f9891796"

URI_aarch64_python3-net-snmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-net-snmp-5.9.4-15.el10_1.2.aarch64.rpm;name=aarch64_python3-net-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-net-snmp}"
SRC_URI[aarch64_python3-net-snmp.sha256sum] = "2c1253da585389b6a09d4e410918385d5b913dd0032f7a6ac3ba4fde63d8d85a"

RDEPENDS:net-snmp = " \
 bash \
 glibc \
 net-snmp-agent-libs \
 net-snmp-libs \
 perl-Data-Dumper \
 perl-File-Copy \
 perl-Getopt-Std \
 perl-IO \
 perl-Term-ReadLine \
 perl-interpreter \
 systemd \
 "
RDEPENDS:net-snmp-agent-libs = " \
 glibc \
 libxcrypt \
 lm_sensors-libs \
 mariadb-connector-c \
 net-snmp-libs \
 openssl-libs \
 perl-libs \
 rpm-libs \
 "
RDEPENDS:net-snmp-devel = " \
 bash \
 elfutils-devel \
 elfutils-libelf-devel \
 lm_sensors-devel \
 net-snmp-agent-libs \
 net-snmp-libs \
 openssl-devel \
 perl-devel \
 pkgconf-pkg-config \
 redhat-rpm-config \
 rpm-devel \
 "
RDEPENDS:net-snmp-libs = " \
 glibc \
 openssl-libs \
 "
RDEPENDS:net-snmp-perl = " \
 bash \
 net-snmp-agent-libs \
 net-snmp-devel \
 net-snmp-libs \
 net-snmp-perl-module \
 perl-Carp \
 perl-Data-Dumper \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Path \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-JSON \
 perl-POSIX \
 perl-PathTools \
 perl-Sys-Hostname \
 perl-interpreter \
 perl-libnet \
 perl-libs \
 perl-vars \
 "
RDEPENDS:net-snmp-perl-module = " \
 glibc \
 net-snmp-agent-libs \
 net-snmp-libs \
 net-snmp-perl-module \
 perl-AutoLoader \
 perl-Carp \
 perl-Data-Dumper \
 perl-DynaLoader \
 perl-Exporter \
 perl-interpreter \
 perl-libs \
 perl-overload \
 perl-vars \
 "
RDEPENDS:net-snmp-utils = " \
 glibc \
 net-snmp-libs \
 openssl-libs \
 "
RDEPENDS:python3-net-snmp = " \
 glibc \
 net-snmp-libs \
 python3 \
 "
