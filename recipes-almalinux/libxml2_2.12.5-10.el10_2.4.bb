# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libxml2"
PV = "2.12.5"
PR = "10.el10_2.4"
PACKAGES = " \
 libxml2 \
 libxml2-devel \
 libxml2-static \
 python3-libxml2 \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libxml2-2.12.5-10.el10_2.4.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "37788a9b50bbad15c3f6088c4aa1ca49f9a35031eef227ffb12952b075760a03"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libxml2-2.12.5-10.el10_2.4.x86_64_v2.rpm;name=x86_64_v2_libxml2;unpack=0"
SRC_URI[x86_64_v2_libxml2.sha256sum] = "0a5372bb724125d4e2aef355ab1484f5cec88ff06ef33d3852316b32e1ce117b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libxml2-devel-2.12.5-10.el10_2.4.x86_64_v2.rpm;name=x86_64_v2_libxml2-devel;unpack=0"
SRC_URI[x86_64_v2_libxml2-devel.sha256sum] = "a7c4c6ef142c7328dcd7e912f1235c65daa6a240c77174d5e530fed61f74efa3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libxml2-static-2.12.5-10.el10_2.4.x86_64_v2.rpm;name=x86_64_v2_libxml2-static;unpack=0"
SRC_URI[x86_64_v2_libxml2-static.sha256sum] = "83a7f9ee41c04dbb9eaaed9e2d7e1dd98f3c417f19bc03e5a8ab1dfc783a32f0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-libxml2-2.12.5-10.el10_2.4.x86_64_v2.rpm;name=x86_64_v2_python3-libxml2;unpack=0"
SRC_URI[x86_64_v2_python3-libxml2.sha256sum] = "1cfe01e9718c5cddd5a05a3b045bacf15d8c60765ea937d58ea7c04421562c0c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libxml2-2.12.5-10.el10_2.4.aarch64.rpm;name=aarch64_libxml2;unpack=0"
SRC_URI[aarch64_libxml2.sha256sum] = "e725f4b0b4b1571013dcd93b0c6b56130a05d434dc116764d76e19da61590cb2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libxml2-devel-2.12.5-10.el10_2.4.aarch64.rpm;name=aarch64_libxml2-devel;unpack=0"
SRC_URI[aarch64_libxml2-devel.sha256sum] = "8c0220464b81fd92a36a11b9c1767758d23e10f3560dcab388ac630e2ec40f1b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libxml2-static-2.12.5-10.el10_2.4.aarch64.rpm;name=aarch64_libxml2-static;unpack=0"
SRC_URI[aarch64_libxml2-static.sha256sum] = "c34359eafb1a06c730d9a73454d767e42cf6a59905f3312c8c5b6c7ae0970b10"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-libxml2-2.12.5-10.el10_2.4.aarch64.rpm;name=aarch64_python3-libxml2;unpack=0"
SRC_URI[aarch64_python3-libxml2.sha256sum] = "45f80065ebaaf743999822763556f9d622b92a0d72adcb17493d861bca02e3a2"

RDEPENDS:libxml2 = " \
 glibc \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:libxml2-devel = " \
 bash \
 cmake-filesystem \
 libxml2 \
 pkgconf-pkg-config \
 xz-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:libxml2-static = " \
 "
RDEPENDS:python3-libxml2 = " \
 glibc \
 libxml2 \
 python3 \
 "
