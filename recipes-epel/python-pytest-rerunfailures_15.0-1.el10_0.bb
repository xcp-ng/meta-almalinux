# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-rerunfailures"
PV = "15.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-pytest-rerunfailures \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-pytest-rerunfailures-15.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b8d6c3f18dbbb1b2356812c4dd2b81811147dc8747a529872e6f94817dc2fb08"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-rerunfailures-15.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-rerunfailures;unpack=0"
SRC_URI[x86_64_v2_python3-pytest-rerunfailures.sha256sum] = "1e600db008945d8576054737e71f21cf5acb9cebd227aaa7cbed42d38fcc71d3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-rerunfailures-15.0-1.el10_0.noarch.rpm;name=aarch64_python3-pytest-rerunfailures;unpack=0"
SRC_URI[aarch64_python3-pytest-rerunfailures.sha256sum] = "74a5c5ddceeaf231bc2a96b6965c90b043e20852ce2f70fc788035798407674d"

RDEPENDS:python3-pytest-rerunfailures = " \
 python3 \
 python3-packaging \
 python3-pytest \
 "
