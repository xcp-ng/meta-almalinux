# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-channel"
PV = "0.3.31"
PR = "1.el10_0"
PACKAGES = " \
 rust-futures-channel+alloc-devel \
 rust-futures-channel+cfg-target-has-atomic-devel \
 rust-futures-channel+default-devel \
 rust-futures-channel+futures-sink-devel \
 rust-futures-channel+sink-devel \
 rust-futures-channel+std-devel \
 rust-futures-channel+unstable-devel \
 rust-futures-channel-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-channel-0.3.31-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f10ffee9291cde40eaf995aa74afde73e6b2571c81fd64a5142024b6df705bf3"

URI_x86_64_v2_rust-futures-channel+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-channel+alloc-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-channel+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-channel+alloc-devel}"
SRC_URI[x86_64_v2_rust-futures-channel+alloc-devel.sha256sum] = "c6d48b2d0b71025925e29d216754937f3e8f0bcfc34afc60cac50153f77efc29"

URI_x86_64_v2_rust-futures-channel+cfg-target-has-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-channel+cfg-target-has-atomic-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-channel+cfg-target-has-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-channel+cfg-target-has-atomic-devel}"
SRC_URI[x86_64_v2_rust-futures-channel+cfg-target-has-atomic-devel.sha256sum] = "e47e1ad0fb6713d7895858961c276b2a380eb83a89d150b29d33277f6e3e63ca"

URI_x86_64_v2_rust-futures-channel+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-channel+default-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-channel+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-channel+default-devel}"
SRC_URI[x86_64_v2_rust-futures-channel+default-devel.sha256sum] = "b48c95402eb2305fc4362f91889a1e41ba5fa25bbcfc1b900e964420ce49a87a"

URI_x86_64_v2_rust-futures-channel+futures-sink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-channel+futures-sink-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-channel+futures-sink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-channel+futures-sink-devel}"
SRC_URI[x86_64_v2_rust-futures-channel+futures-sink-devel.sha256sum] = "d4fd327c7bf5a21529d8c347acbfc5ffe25a8dcb3396ef31929b0e267bcd614e"

URI_x86_64_v2_rust-futures-channel+sink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-channel+sink-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-channel+sink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-channel+sink-devel}"
SRC_URI[x86_64_v2_rust-futures-channel+sink-devel.sha256sum] = "a623cbb1d84d44533e3883473ff5fa2928cf9540df20ae97fab103b34cf632ba"

URI_x86_64_v2_rust-futures-channel+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-channel+std-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-channel+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-channel+std-devel}"
SRC_URI[x86_64_v2_rust-futures-channel+std-devel.sha256sum] = "e5edc5736206d7ca96439e5024a9bde1c11598d17e726037dca7d1b17aa7696b"

URI_x86_64_v2_rust-futures-channel+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-channel+unstable-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-channel+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-channel+unstable-devel}"
SRC_URI[x86_64_v2_rust-futures-channel+unstable-devel.sha256sum] = "e1e1d9507319647e0f5e0327ab9ad918a4701335e7b6ed7f2aa297b2e5599e06"

URI_x86_64_v2_rust-futures-channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-channel-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-channel-devel}"
SRC_URI[x86_64_v2_rust-futures-channel-devel.sha256sum] = "943e2681501ef1f399b703281d6094cba46985e3af4e1236e8f619b89f468ecb"

URI_aarch64_rust-futures-channel+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-channel+alloc-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-channel+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-channel+alloc-devel}"
SRC_URI[aarch64_rust-futures-channel+alloc-devel.sha256sum] = "9f8e64010115b6b396288d7a3964ab8d4ede35abda0ce89faeb1201df95d78b1"

URI_aarch64_rust-futures-channel+cfg-target-has-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-channel+cfg-target-has-atomic-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-channel+cfg-target-has-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-channel+cfg-target-has-atomic-devel}"
SRC_URI[aarch64_rust-futures-channel+cfg-target-has-atomic-devel.sha256sum] = "b53ec7d673136d1000462490b02850a042bb25eae723ab562929e2a0625b15bf"

URI_aarch64_rust-futures-channel+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-channel+default-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-channel+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-channel+default-devel}"
SRC_URI[aarch64_rust-futures-channel+default-devel.sha256sum] = "f3c5943adf4279b7b9b07890acc565db8dcabaf20719e4592bda1c83885e8288"

URI_aarch64_rust-futures-channel+futures-sink-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-channel+futures-sink-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-channel+futures-sink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-channel+futures-sink-devel}"
SRC_URI[aarch64_rust-futures-channel+futures-sink-devel.sha256sum] = "3a77fd1929a7471a7dfe7bd414c3e4b4e5b635d275ddb2d9ebc49a3fe8fb0245"

URI_aarch64_rust-futures-channel+sink-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-channel+sink-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-channel+sink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-channel+sink-devel}"
SRC_URI[aarch64_rust-futures-channel+sink-devel.sha256sum] = "75ec4e7d660f5903615c1764bc41f4370d2328a5422bf3525de6f8e317e4d9c5"

URI_aarch64_rust-futures-channel+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-channel+std-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-channel+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-channel+std-devel}"
SRC_URI[aarch64_rust-futures-channel+std-devel.sha256sum] = "0ebd3ffbf896fbe22f53376119b94dfebf9a81b9eac3ce2c9f0f06ba60f58067"

URI_aarch64_rust-futures-channel+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-channel+unstable-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-channel+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-channel+unstable-devel}"
SRC_URI[aarch64_rust-futures-channel+unstable-devel.sha256sum] = "a36de6d2ed5428e9c8bbd97189dd39e17637eb505ba2b274965dbf86a27d593a"

URI_aarch64_rust-futures-channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-channel-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-channel-devel}"
SRC_URI[aarch64_rust-futures-channel-devel.sha256sum] = "242a864c14cc27d379b6e95d784719ac0853d39204d367da8ebcb15040b39ff5"

RDEPENDS:rust-futures-channel+alloc-devel = " \
 cargo \
 rust-futures-channel-devel \
 rust-futures-core+alloc-devel \
 "
RDEPENDS:rust-futures-channel+cfg-target-has-atomic-devel = " \
 cargo \
 rust-futures-channel-devel \
 "
RDEPENDS:rust-futures-channel+default-devel = " \
 cargo \
 rust-futures-channel+std-devel \
 rust-futures-channel-devel \
 "
RDEPENDS:rust-futures-channel+futures-sink-devel = " \
 cargo \
 rust-futures-channel-devel \
 rust-futures-sink-devel \
 "
RDEPENDS:rust-futures-channel+sink-devel = " \
 cargo \
 rust-futures-channel+futures-sink-devel \
 rust-futures-channel-devel \
 "
RDEPENDS:rust-futures-channel+std-devel = " \
 cargo \
 rust-futures-channel+alloc-devel \
 rust-futures-channel-devel \
 rust-futures-core+std-devel \
 "
RDEPENDS:rust-futures-channel+unstable-devel = " \
 cargo \
 rust-futures-channel-devel \
 "
RDEPENDS:rust-futures-channel-devel = " \
 cargo \
 rust \
 rust-futures-core-devel \
 "
