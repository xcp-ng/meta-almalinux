# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-open"
PV = "5.4.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-open+default-devel \
 rust-open-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-open-5.4.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "afe3260c3d3797e838797028b82e24f78b75b4c511b6dd9c5f579124a61eda0d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-open+default-devel-5.4.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-open+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-open+default-devel.sha256sum] = "1f7b3f168ce9d12177bd161e324712c73601e70928fb97268c40b91ad1cd18a2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-open-devel-5.4.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-open-devel;unpack=0"
SRC_URI[x86_64_v2_rust-open-devel.sha256sum] = "0752d0571961c51b6b8cf8605e55afcb7faa1a28288f39bd8647e3c860414347"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-open+default-devel-5.4.4-1.el10_2.noarch.rpm;name=aarch64_rust-open+default-devel;unpack=0"
SRC_URI[aarch64_rust-open+default-devel.sha256sum] = "97989465567402bd67ef0f7806ced4cf0ed4b29d6b671ac296150ba3da11c492"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-open-devel-5.4.4-1.el10_2.noarch.rpm;name=aarch64_rust-open-devel;unpack=0"
SRC_URI[aarch64_rust-open-devel.sha256sum] = "1cf555532e28e3e9fdecd4622ca7d2085e1b1e200d4661c5b973a036cfdb46cc"

RDEPENDS:rust-open+default-devel = " \
 cargo \
 rust-open-devel \
 "
RDEPENDS:rust-open-devel = " \
 cargo \
 rust \
 rust-is-wsl+default-devel \
 rust-libc+default-devel \
 "
