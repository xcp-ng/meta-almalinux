# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-salsa20"
PV = "0.10.2"
PR = "4.el10_0"
PACKAGES = " \
 rust-salsa20+default-devel \
 rust-salsa20+std-devel \
 rust-salsa20+zeroize-devel \
 rust-salsa20-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-salsa20-0.10.2-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64f0164f83488ae7a662bfd4ad538909f31d958b4e20c793235c208c17c8b0d6"

URI_x86_64_v2_rust-salsa20+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-salsa20+default-devel-0.10.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-salsa20+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-salsa20+default-devel}"
SRC_URI[x86_64_v2_rust-salsa20+default-devel.sha256sum] = "fe0c0592b11a4f41fae8f00ff4512de327fdfda7e1467bb7109e78d5ba3a88e4"

URI_x86_64_v2_rust-salsa20+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-salsa20+std-devel-0.10.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-salsa20+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-salsa20+std-devel}"
SRC_URI[x86_64_v2_rust-salsa20+std-devel.sha256sum] = "32090ca0409bdfab2fabbc41215cbeb46396be2c7d57ffaf3c1aa4ecab7222db"

URI_x86_64_v2_rust-salsa20+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-salsa20+zeroize-devel-0.10.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-salsa20+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-salsa20+zeroize-devel}"
SRC_URI[x86_64_v2_rust-salsa20+zeroize-devel.sha256sum] = "7b08789683c388f0e9f053afcb0194b6f5e9e5424400d2ddbf1f8af3ece9954f"

URI_x86_64_v2_rust-salsa20-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-salsa20-devel-0.10.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-salsa20-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-salsa20-devel}"
SRC_URI[x86_64_v2_rust-salsa20-devel.sha256sum] = "589b8297a5197870094c9255c4a7b0059bab02944a843e034e55cebb3fe42091"

URI_aarch64_rust-salsa20+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-salsa20+default-devel-0.10.2-4.el10_0.noarch.rpm;name=aarch64_rust-salsa20+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-salsa20+default-devel}"
SRC_URI[aarch64_rust-salsa20+default-devel.sha256sum] = "4de49565d997c67681c0c2bac50515ec298ef1e589b619e267d1c0ba8b2467ef"

URI_aarch64_rust-salsa20+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-salsa20+std-devel-0.10.2-4.el10_0.noarch.rpm;name=aarch64_rust-salsa20+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-salsa20+std-devel}"
SRC_URI[aarch64_rust-salsa20+std-devel.sha256sum] = "1410e1b500d452ed1005ec1252c4234c45806f69d0130270891891008e7f4a36"

URI_aarch64_rust-salsa20+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-salsa20+zeroize-devel-0.10.2-4.el10_0.noarch.rpm;name=aarch64_rust-salsa20+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-salsa20+zeroize-devel}"
SRC_URI[aarch64_rust-salsa20+zeroize-devel.sha256sum] = "adfc3cc2ca889da2ae65457072b022bdde2f878a5cb23b18b49316f885d3ea00"

URI_aarch64_rust-salsa20-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-salsa20-devel-0.10.2-4.el10_0.noarch.rpm;name=aarch64_rust-salsa20-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-salsa20-devel}"
SRC_URI[aarch64_rust-salsa20-devel.sha256sum] = "ead0a97b4687f79c5984ea9bef380063953535782d409c03d711c51a961e65a6"

RDEPENDS:rust-salsa20+default-devel = " \
 cargo \
 rust-salsa20-devel \
 "
RDEPENDS:rust-salsa20+std-devel = " \
 cargo \
 rust-cipher+std-devel \
 rust-salsa20-devel \
 "
RDEPENDS:rust-salsa20+zeroize-devel = " \
 cargo \
 rust-cipher+zeroize-devel \
 rust-salsa20-devel \
 "
RDEPENDS:rust-salsa20-devel = " \
 cargo \
 rust \
 rust-cipher+default-devel \
 "
