# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-accessible-pygments"
PV = "0.0.5"
PR = "5.el10_1"
PACKAGES = " \
 python3-accessible-pygments \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-accessible-pygments-0.0.5-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "70706840e2ac6389f3752cf3bd0bc487d1d5385aa3e9ee558068d69cdf5d4beb"

URI_x86_64_v2_python3-accessible-pygments = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-accessible-pygments-0.0.5-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-accessible-pygments;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-accessible-pygments}"
SRC_URI[x86_64_v2_python3-accessible-pygments.sha256sum] = "2519c6134ece60be0027beb56d800985b05c3430b281d0380604f5dbc6d1d0ff"

URI_aarch64_python3-accessible-pygments = "${EPEL_MIRROR}/aarch64/Packages/p/python3-accessible-pygments-0.0.5-5.el10_1.noarch.rpm;name=aarch64_python3-accessible-pygments;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-accessible-pygments}"
SRC_URI[aarch64_python3-accessible-pygments.sha256sum] = "4b2350eca56245353e91fda1de05a0c26cd47932777b619c4b8c3d54333fdecb"

RDEPENDS:python3-accessible-pygments = " \
 python3 \
 python3-pygments \
 "
