# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "botan2"
PV = "2.19.5"
PR = "4.el10_0"
PACKAGES = " \
 botan2 \
 botan2-devel \
 botan2-doc \
 python3-botan2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/botan2-2.19.5-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e06c06475e1612dc9f5bafa052c932e9b6abea72c7ac2af39bbcaadf1de0a5d9"

URI_x86_64_v2_botan2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/botan2-2.19.5-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_botan2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_botan2}"
SRC_URI[x86_64_v2_botan2.sha256sum] = "ca9eeadeabe07e7442da3736992bb014c29001462e59511508baf52df21eeb17"

URI_x86_64_v2_botan2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/botan2-devel-2.19.5-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_botan2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_botan2-devel}"
SRC_URI[x86_64_v2_botan2-devel.sha256sum] = "e62c8aefebdb685d9d6b10262c1cde90669152837f0b0e4ef5b227f07673bf45"

URI_x86_64_v2_botan2-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/botan2-doc-2.19.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_botan2-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_botan2-doc}"
SRC_URI[x86_64_v2_botan2-doc.sha256sum] = "11f68eda4a8a6c472e623aab88d94d1e9e63a94863631cc8c6b8b8e693104050"

URI_x86_64_v2_python3-botan2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-botan2-2.19.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-botan2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-botan2}"
SRC_URI[x86_64_v2_python3-botan2.sha256sum] = "dbc70abcf3169aee2d5841a5687cbb2ddec9d0a730735fe068c1980e24c24494"

URI_aarch64_botan2 = "${EPEL_MIRROR}/aarch64/Packages/b/botan2-2.19.5-4.el10_0.aarch64.rpm;name=aarch64_botan2;unpack=0"
SRC_URI:append = " ${URI_aarch64_botan2}"
SRC_URI[aarch64_botan2.sha256sum] = "6fa8acc0e37072f954d557ea046836a3ca34d61186d821527eccf2419031a3e0"

URI_aarch64_botan2-devel = "${EPEL_MIRROR}/aarch64/Packages/b/botan2-devel-2.19.5-4.el10_0.aarch64.rpm;name=aarch64_botan2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_botan2-devel}"
SRC_URI[aarch64_botan2-devel.sha256sum] = "ddd4e2a0755eece8669c9f9101b70b7cc35c1b9b50a015f0221e0d0196bed8f7"

URI_aarch64_botan2-doc = "${EPEL_MIRROR}/aarch64/Packages/b/botan2-doc-2.19.5-4.el10_0.noarch.rpm;name=aarch64_botan2-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_botan2-doc}"
SRC_URI[aarch64_botan2-doc.sha256sum] = "f194b26e46dd71a460c3e9515afcbf8493ea8cff49616e6774f066a7ee5549ab"

URI_aarch64_python3-botan2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-botan2-2.19.5-4.el10_0.noarch.rpm;name=aarch64_python3-botan2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-botan2}"
SRC_URI[aarch64_python3-botan2.sha256sum] = "d04779cd7fef8612631efe956dfa14ca73ec07d361bfe2cdd666f7c52e3a7f82"

RDEPENDS:botan2 = " \
 bzip2-libs \
 glibc \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
RDEPENDS:botan2-devel = " \
 botan2 \
 pkgconf-pkg-config \
 "
RDEPENDS:botan2-doc = " \
 "
RDEPENDS:python3-botan2 = " \
 botan2 \
 python3 \
 "
