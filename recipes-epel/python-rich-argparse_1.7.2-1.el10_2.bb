# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rich-argparse"
PV = "1.7.2"
PR = "1.el10_2"
PACKAGES = " \
 python3-rich-argparse \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-rich-argparse-1.7.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "573311a69c5ff35135d6fce89eabf711dba7cbb11a6baf753b8edcf9ebc82b88"

URI_x86_64_v2_python3-rich-argparse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rich-argparse-1.7.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rich-argparse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rich-argparse}"
SRC_URI[x86_64_v2_python3-rich-argparse.sha256sum] = "190ef849e46cd5a9bb9980aa379086ccc07e6e0fdf18b55a395962c888bee484"

URI_aarch64_python3-rich-argparse = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rich-argparse-1.7.2-1.el10_2.noarch.rpm;name=aarch64_python3-rich-argparse;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rich-argparse}"
SRC_URI[aarch64_python3-rich-argparse.sha256sum] = "25b739e606eedf76578d81640d59814d9361cb00d0505bb2804dd1e02e643015"

RDEPENDS:python3-rich-argparse = " \
 python3 \
 python3-rich \
 "
