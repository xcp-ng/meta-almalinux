# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xfsprogs"
PV = "6.11.0"
PR = "1.el10"
PACKAGES = " \
 xfsprogs \
 xfsprogs-devel \
 xfsprogs-xfs_scrub \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/xfsprogs-6.11.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da1f87414035e90b6db25e1a45e988215413684577c4d5276c64af83db81647a"

URI_x86_64_v2_xfsprogs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/xfsprogs-6.11.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_xfsprogs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xfsprogs}"
SRC_URI[x86_64_v2_xfsprogs.sha256sum] = "71e6d0222e84eaa8950c113f4d2b61177cae9ada8da908e3b4f7f01116016ccc"

URI_x86_64_v2_xfsprogs-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xfsprogs-devel-6.11.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_xfsprogs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xfsprogs-devel}"
SRC_URI[x86_64_v2_xfsprogs-devel.sha256sum] = "372ef1197442bb42a02e090f53bdfccc4e9e1dc8d42c3e889ae2129afbf4cb23"

URI_x86_64_v2_xfsprogs-xfs_scrub = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xfsprogs-xfs_scrub-6.11.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_xfsprogs-xfs_scrub;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xfsprogs-xfs_scrub}"
SRC_URI[x86_64_v2_xfsprogs-xfs_scrub.sha256sum] = "6462d7f012e47decd8d2bfa76bfaae8ef507cedbfcd9768e06c43ccffbda7f62"

URI_aarch64_xfsprogs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/xfsprogs-6.11.0-1.el10.aarch64.rpm;name=aarch64_xfsprogs;unpack=0"
SRC_URI:append = " ${URI_aarch64_xfsprogs}"
SRC_URI[aarch64_xfsprogs.sha256sum] = "a96c1bd835f893a04255acc2147d98b1158a2abc300dd38f46cf86a0793188b9"

URI_aarch64_xfsprogs-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xfsprogs-devel-6.11.0-1.el10.aarch64.rpm;name=aarch64_xfsprogs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xfsprogs-devel}"
SRC_URI[aarch64_xfsprogs-devel.sha256sum] = "79aa1de070f72045cca1a217b54014e0616fc728ffe774ebc056ee2d608700a8"

URI_aarch64_xfsprogs-xfs_scrub = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xfsprogs-xfs_scrub-6.11.0-1.el10.aarch64.rpm;name=aarch64_xfsprogs-xfs_scrub;unpack=0"
SRC_URI:append = " ${URI_aarch64_xfsprogs-xfs_scrub}"
SRC_URI[aarch64_xfsprogs-xfs_scrub.sha256sum] = "03456cde0fe7f39cc07c36f7b05981cee1ba5f2d5ae488484727ce270e4e5412"

RDEPENDS:xfsprogs = " \
 bash \
 glibc \
 inih \
 libblkid \
 libedit \
 libuuid \
 userspace-rcu \
 "
RDEPENDS:xfsprogs-devel = " \
 libuuid-devel \
 xfsprogs \
 "
RDEPENDS:xfsprogs-xfs_scrub = " \
 bash \
 glibc \
 libicu \
 python3 \
 userspace-rcu \
 util-linux \
 xfsprogs \
 "
