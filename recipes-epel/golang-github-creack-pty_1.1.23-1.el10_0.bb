# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-creack-pty"
PV = "1.1.23"
PR = "1.el10_0"
PACKAGES = " \
 golang-github-creack-pty-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/golang-github-creack-pty-1.1.23-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e29879ebbad78c2b1442a6a69064142425b6e82ea7855d737b046e99bb9c28db"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-creack-pty-devel-1.1.23-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-creack-pty-devel;unpack=0"
SRC_URI[x86_64_v2_golang-github-creack-pty-devel.sha256sum] = "d3d303cf3a4f29b814d52de462602ff2e860acbebc873bfc90dee013e02068fd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-github-creack-pty-devel-1.1.23-1.el10_0.noarch.rpm;name=aarch64_golang-github-creack-pty-devel;unpack=0"
SRC_URI[aarch64_golang-github-creack-pty-devel.sha256sum] = "ee9b74eb0e700c504149d357f15478b46d79c75ccf66ec0abe57630207a529e7"

RDEPENDS:golang-github-creack-pty-devel = " \
 go-filesystem \
 "
