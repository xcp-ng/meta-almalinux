# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-scheduler-event-generator"
PV = "6.6"
PR = "1.el10_1"
PACKAGES = " \
 globus-scheduler-event-generator \
 globus-scheduler-event-generator-devel \
 globus-scheduler-event-generator-doc \
 globus-scheduler-event-generator-progs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-scheduler-event-generator-6.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "41797d2a500f9ad401ef5d45052b871a7f5c334690a20da92e53e716563b37d4"

URI_x86_64_v2_globus-scheduler-event-generator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-scheduler-event-generator-6.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-scheduler-event-generator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-scheduler-event-generator}"
SRC_URI[x86_64_v2_globus-scheduler-event-generator.sha256sum] = "0889dcbc3d421d4cb467c811c0ac21bf65516288964ff85a42a9bd19fe2bc3e6"

URI_x86_64_v2_globus-scheduler-event-generator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-scheduler-event-generator-devel-6.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-scheduler-event-generator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-scheduler-event-generator-devel}"
SRC_URI[x86_64_v2_globus-scheduler-event-generator-devel.sha256sum] = "9027217184b510d7a38860f03ced3188fb481a57a74afd8dd51eba28b9b17237"

URI_x86_64_v2_globus-scheduler-event-generator-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-scheduler-event-generator-doc-6.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_globus-scheduler-event-generator-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-scheduler-event-generator-doc}"
SRC_URI[x86_64_v2_globus-scheduler-event-generator-doc.sha256sum] = "b0d4ac6d53fe915091a90328a1051a30844b758ad08f6e75f0f4bbbc3e7c9f94"

URI_x86_64_v2_globus-scheduler-event-generator-progs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-scheduler-event-generator-progs-6.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-scheduler-event-generator-progs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-scheduler-event-generator-progs}"
SRC_URI[x86_64_v2_globus-scheduler-event-generator-progs.sha256sum] = "68f20f82f242fbd734f652269f9ca07680006fa3a6aa0d777a533c70ee6ad60b"

URI_aarch64_globus-scheduler-event-generator = "${EPEL_MIRROR}/aarch64/Packages/g/globus-scheduler-event-generator-6.6-1.el10_1.aarch64.rpm;name=aarch64_globus-scheduler-event-generator;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-scheduler-event-generator}"
SRC_URI[aarch64_globus-scheduler-event-generator.sha256sum] = "916aade1f4b07b5354fedba66ec55f21fbc4f77d3b40d6f94452c06f34d9d8b1"

URI_aarch64_globus-scheduler-event-generator-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-scheduler-event-generator-devel-6.6-1.el10_1.aarch64.rpm;name=aarch64_globus-scheduler-event-generator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-scheduler-event-generator-devel}"
SRC_URI[aarch64_globus-scheduler-event-generator-devel.sha256sum] = "cb3b6ea0788189a0a0edbab9d5cfa5b497ad4b05197e84549ec6438ddba32dd1"

URI_aarch64_globus-scheduler-event-generator-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-scheduler-event-generator-doc-6.6-1.el10_1.noarch.rpm;name=aarch64_globus-scheduler-event-generator-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-scheduler-event-generator-doc}"
SRC_URI[aarch64_globus-scheduler-event-generator-doc.sha256sum] = "f84aa37025b5bee2e1e36dccbe605e48c0645399348470fd46702731fb7660dc"

URI_aarch64_globus-scheduler-event-generator-progs = "${EPEL_MIRROR}/aarch64/Packages/g/globus-scheduler-event-generator-progs-6.6-1.el10_1.aarch64.rpm;name=aarch64_globus-scheduler-event-generator-progs;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-scheduler-event-generator-progs}"
SRC_URI[aarch64_globus-scheduler-event-generator-progs.sha256sum] = "c0de8b5ea4fc784160f9e16c089fa67079f52da5c59f847a39dc654610d2ea0f"

RDEPENDS:globus-scheduler-event-generator = " \
 glibc \
 globus-common \
 globus-xio-gsi-driver \
 "
RDEPENDS:globus-scheduler-event-generator-devel = " \
 globus-common-devel \
 globus-gram-protocol-devel \
 globus-scheduler-event-generator \
 globus-xio-devel \
 globus-xio-gsi-driver-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-scheduler-event-generator-doc = " \
 "
RDEPENDS:globus-scheduler-event-generator-progs = " \
 bash \
 glibc \
 globus-common \
 globus-scheduler-event-generator \
 globus-xio \
 systemd \
 "
