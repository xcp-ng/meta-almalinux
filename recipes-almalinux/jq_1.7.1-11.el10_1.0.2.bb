# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jq"
PV = "1.7.1"
PR = "11.el10_1.0.2"
PACKAGES = " \
 jq \
 jq-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/jq-1.7.1-11.el10_1.0.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4204ff9ae5b6a32538f5093854e0bf3fc775633f5a42a925fdeae971691cb1c"

URI_x86_64_v2_jq = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/jq-1.7.1-11.el10_1.0.2.x86_64_v2.rpm;name=x86_64_v2_jq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jq}"
SRC_URI[x86_64_v2_jq.sha256sum] = "3477815a861d547d5298ae1b59d7cb36e37ec21e05365be93d4f94ad70e5443f"

URI_x86_64_v2_jq-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jq-devel-1.7.1-11.el10_1.0.2.x86_64_v2.rpm;name=x86_64_v2_jq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jq-devel}"
SRC_URI[x86_64_v2_jq-devel.sha256sum] = "ffe3296bda01499de98e6f550337ed63cefd476b0d732ebd95e58a4e904fc0d9"

URI_aarch64_jq = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/jq-1.7.1-11.el10_1.0.2.aarch64.rpm;name=aarch64_jq;unpack=0"
SRC_URI:append = " ${URI_aarch64_jq}"
SRC_URI[aarch64_jq.sha256sum] = "9a4fa7c581288a36a04a6d4448424c13ca42b16f47030e1fc2598f7d58f13462"

URI_aarch64_jq-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jq-devel-1.7.1-11.el10_1.0.2.aarch64.rpm;name=aarch64_jq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_jq-devel}"
SRC_URI[aarch64_jq-devel.sha256sum] = "2f46b2218da2847e592712ffc5ff4f781c275608117554b127e8587b8a0c2eee"

RDEPENDS:jq = " \
 glibc \
 oniguruma \
 "
RDEPENDS:jq-devel = " \
 jq \
 pkgconf-pkg-config \
 "
