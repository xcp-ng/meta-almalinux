# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-exacl"
PV = "0.12.0"
PR = "6.el10_3"
PACKAGES = " \
 rust-exacl+buildtime_bindgen-devel \
 rust-exacl+default-devel \
 rust-exacl+serde-devel \
 rust-exacl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-exacl-0.12.0-6.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f63953fbe6fb4c3c4f5716335e001c6fa4dae65ae8254296cccac7f3c0d1fc8"

URI_x86_64_v2_rust-exacl+buildtime_bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-exacl+buildtime_bindgen-devel-0.12.0-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-exacl+buildtime_bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-exacl+buildtime_bindgen-devel}"
SRC_URI[x86_64_v2_rust-exacl+buildtime_bindgen-devel.sha256sum] = "3d783bc5397cb6c0903702ce48fbef61e2a7b49b5bd111525598db3af86a841c"

URI_x86_64_v2_rust-exacl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-exacl+default-devel-0.12.0-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-exacl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-exacl+default-devel}"
SRC_URI[x86_64_v2_rust-exacl+default-devel.sha256sum] = "d7a0d11b1ae58b7e639c5e1fc070e6905b18ab6d5a1c64b819e410c80291fcd4"

URI_x86_64_v2_rust-exacl+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-exacl+serde-devel-0.12.0-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-exacl+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-exacl+serde-devel}"
SRC_URI[x86_64_v2_rust-exacl+serde-devel.sha256sum] = "0b03762d24d8bf358965a8734b8601785611bf972c5436f0df746b22e322fbb5"

URI_x86_64_v2_rust-exacl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-exacl-devel-0.12.0-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-exacl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-exacl-devel}"
SRC_URI[x86_64_v2_rust-exacl-devel.sha256sum] = "a7de8a2de2bad1f055d36d9e98276f95a7f0d2998e937012895e6b16010da084"

URI_aarch64_rust-exacl+buildtime_bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-exacl+buildtime_bindgen-devel-0.12.0-6.el10_3.noarch.rpm;name=aarch64_rust-exacl+buildtime_bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-exacl+buildtime_bindgen-devel}"
SRC_URI[aarch64_rust-exacl+buildtime_bindgen-devel.sha256sum] = "bc731d678d2a198478450ea1589a739877f71a0cd04e14b0abd1befe58a19a51"

URI_aarch64_rust-exacl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-exacl+default-devel-0.12.0-6.el10_3.noarch.rpm;name=aarch64_rust-exacl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-exacl+default-devel}"
SRC_URI[aarch64_rust-exacl+default-devel.sha256sum] = "2a28d7d85752325f92e3750fccf31304ef35f3219fe870c997439394920c193e"

URI_aarch64_rust-exacl+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-exacl+serde-devel-0.12.0-6.el10_3.noarch.rpm;name=aarch64_rust-exacl+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-exacl+serde-devel}"
SRC_URI[aarch64_rust-exacl+serde-devel.sha256sum] = "aa3efba037d99e6aa71ff8e497d7e7d1ec1cd188fcedf2a3bfb5154d5df8e374"

URI_aarch64_rust-exacl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-exacl-devel-0.12.0-6.el10_3.noarch.rpm;name=aarch64_rust-exacl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-exacl-devel}"
SRC_URI[aarch64_rust-exacl-devel.sha256sum] = "0fc4f50f87f8ee3b82869662a4587be1aa3a23b9bf63e04122da4fd0c0e2e143"

RDEPENDS:rust-exacl+buildtime_bindgen-devel = " \
 cargo \
 rust-exacl-devel \
 "
RDEPENDS:rust-exacl+default-devel = " \
 cargo \
 rust-exacl-devel \
 "
RDEPENDS:rust-exacl+serde-devel = " \
 cargo \
 rust-exacl-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-exacl-devel = " \
 cargo \
 libacl-devel \
 rust-bindgen+default-devel \
 rust-bitflags+default-devel \
 rust-log+default-devel \
 rust-scopeguard+default-devel \
 rust-uuid+default-devel \
 "
