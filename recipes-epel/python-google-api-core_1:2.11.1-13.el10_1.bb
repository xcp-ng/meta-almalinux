# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-google-api-core"
PE = "1"
PV = "2.11.1"
PR = "13.el10_1"
PACKAGES = " \
 python3-google-api-core \
 python3-google-api-core+grpc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-google-api-core-2.11.1-13.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fad06f6b03decf9d4b6b3224c0ae4ddd959668a2bc30c453568587fabd4dc3ad"

URI_x86_64_v2_python3-google-api-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-api-core-2.11.1-13.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-api-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-api-core}"
SRC_URI[x86_64_v2_python3-google-api-core.sha256sum] = "01b5dbbe46101c3dee39aa45527beb8f1290b7241f79e341b83ca31f6091b422"

URI_x86_64_v2_python3-google-api-core+grpc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-api-core+grpc-2.11.1-13.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-api-core+grpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-api-core+grpc}"
SRC_URI[x86_64_v2_python3-google-api-core+grpc.sha256sum] = "009c04a209280c2db42e5db637372a6abaebf5c28036aad3c166e999fa718e99"

URI_aarch64_python3-google-api-core = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-api-core-2.11.1-13.el10_1.noarch.rpm;name=aarch64_python3-google-api-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-api-core}"
SRC_URI[aarch64_python3-google-api-core.sha256sum] = "35d185e01f47621dfd638aaa3e4b407db9da5461e8e842bb82cb362355ad4e43"

URI_aarch64_python3-google-api-core+grpc = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-api-core+grpc-2.11.1-13.el10_1.noarch.rpm;name=aarch64_python3-google-api-core+grpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-api-core+grpc}"
SRC_URI[aarch64_python3-google-api-core+grpc.sha256sum] = "dd9ee44d00d0d2afab5abb0dfd0dd116247f353f315b83052cef597fe61dd059"

RDEPENDS:python3-google-api-core = " \
 python3 \
 python3-google-auth \
 python3-googleapis-common-protos \
 python3-grpcio \
 python3-grpcio-status \
 python3-protobuf \
 python3-requests \
 "
RDEPENDS:python3-google-api-core+grpc = " \
 python3 \
 python3-google-api-core \
 python3-grpcio \
 python3-grpcio-status \
 "
