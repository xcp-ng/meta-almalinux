# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-convert_case0.7"
PV = "0.7.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-convert_case0.7+default-devel \
 rust-convert_case0.7+rand-devel \
 rust-convert_case0.7+random-devel \
 rust-convert_case0.7-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-convert_case0.7-0.7.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8272ea17ee6f32ce9c32e359835f8846e1f6959f9607d67b90a7def26f8c95dd"

URI_x86_64_v2_rust-convert_case0.7+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-convert_case0.7+default-devel-0.7.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-convert_case0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-convert_case0.7+default-devel}"
SRC_URI[x86_64_v2_rust-convert_case0.7+default-devel.sha256sum] = "e86b6123c920d15d733cd0c2ac39d57a0e485db630c505dc8e7b3cdf014d57e3"

URI_x86_64_v2_rust-convert_case0.7+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-convert_case0.7+rand-devel-0.7.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-convert_case0.7+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-convert_case0.7+rand-devel}"
SRC_URI[x86_64_v2_rust-convert_case0.7+rand-devel.sha256sum] = "8296d6d9c0f752f70756847c8a5df30110a691fd88750696b6676ecb205e6263"

URI_x86_64_v2_rust-convert_case0.7+random-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-convert_case0.7+random-devel-0.7.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-convert_case0.7+random-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-convert_case0.7+random-devel}"
SRC_URI[x86_64_v2_rust-convert_case0.7+random-devel.sha256sum] = "6ce09c62b1928f33d4b43a2413c91dd99de5f663b4b51c8ce8fd4b1161dd4934"

URI_x86_64_v2_rust-convert_case0.7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-convert_case0.7-devel-0.7.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-convert_case0.7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-convert_case0.7-devel}"
SRC_URI[x86_64_v2_rust-convert_case0.7-devel.sha256sum] = "ea4ade63140a7ab36c63a0d53ed451abd94bddef183a3d999d5588cd53a8b87b"

URI_aarch64_rust-convert_case0.7+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-convert_case0.7+default-devel-0.7.1-1.el10_2.noarch.rpm;name=aarch64_rust-convert_case0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-convert_case0.7+default-devel}"
SRC_URI[aarch64_rust-convert_case0.7+default-devel.sha256sum] = "64de3c68e77b5a55b0fc0b634ae071c30223a578825f268789bd8f495efd0f3f"

URI_aarch64_rust-convert_case0.7+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-convert_case0.7+rand-devel-0.7.1-1.el10_2.noarch.rpm;name=aarch64_rust-convert_case0.7+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-convert_case0.7+rand-devel}"
SRC_URI[aarch64_rust-convert_case0.7+rand-devel.sha256sum] = "82bc556ec51d0ee568d965e3e04f93e8a53b0c1439f18f6ca8471306e86aeeab"

URI_aarch64_rust-convert_case0.7+random-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-convert_case0.7+random-devel-0.7.1-1.el10_2.noarch.rpm;name=aarch64_rust-convert_case0.7+random-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-convert_case0.7+random-devel}"
SRC_URI[aarch64_rust-convert_case0.7+random-devel.sha256sum] = "784bfd4d3f6a469dda120d075390d7b472e65a80732eb672573341bbacd537ef"

URI_aarch64_rust-convert_case0.7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-convert_case0.7-devel-0.7.1-1.el10_2.noarch.rpm;name=aarch64_rust-convert_case0.7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-convert_case0.7-devel}"
SRC_URI[aarch64_rust-convert_case0.7-devel.sha256sum] = "9892d23c4f3b1844747006c951d5090dfc754ce82c7dad5508fb010d80b306f4"

RDEPENDS:rust-convert_case0.7+default-devel = " \
 cargo \
 rust-convert_case0.7-devel \
 "
RDEPENDS:rust-convert_case0.7+rand-devel = " \
 cargo \
 rust-convert_case0.7-devel \
 rust-rand0.8+default-devel \
 "
RDEPENDS:rust-convert_case0.7+random-devel = " \
 cargo \
 rust-convert_case0.7+rand-devel \
 rust-convert_case0.7-devel \
 "
RDEPENDS:rust-convert_case0.7-devel = " \
 cargo \
 rust-unicode-segmentation+default-devel \
 "
