# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mdbook-preprocessor"
PV = "0.5.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-mdbook-preprocessor+default-devel \
 rust-mdbook-preprocessor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mdbook-preprocessor-0.5.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "10925f2144a1c1032709e5aaea812f096fba0889abd413b16f46285cdd7fea5a"

URI_x86_64_v2_rust-mdbook-preprocessor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mdbook-preprocessor+default-devel-0.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mdbook-preprocessor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mdbook-preprocessor+default-devel}"
SRC_URI[x86_64_v2_rust-mdbook-preprocessor+default-devel.sha256sum] = "65b04c3c17de4203ce7e4f4da2f038e3a57542cfc912d167fe2641e4052bfd3a"

URI_x86_64_v2_rust-mdbook-preprocessor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mdbook-preprocessor-devel-0.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mdbook-preprocessor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mdbook-preprocessor-devel}"
SRC_URI[x86_64_v2_rust-mdbook-preprocessor-devel.sha256sum] = "0e7e709b5cf87c17fe710b0e9a36c30b89d26bb79c52786acccda21db1ada259"

URI_aarch64_rust-mdbook-preprocessor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mdbook-preprocessor+default-devel-0.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-mdbook-preprocessor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mdbook-preprocessor+default-devel}"
SRC_URI[aarch64_rust-mdbook-preprocessor+default-devel.sha256sum] = "01985d69790d925c680e11df826e3fd6dc17094fab8a2c6ee5c65082397de70a"

URI_aarch64_rust-mdbook-preprocessor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mdbook-preprocessor-devel-0.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-mdbook-preprocessor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mdbook-preprocessor-devel}"
SRC_URI[aarch64_rust-mdbook-preprocessor-devel.sha256sum] = "8b2f27f943f16114918e8cb424b363edd46c2a19bafb4ecae798794379c5e0d8"

RDEPENDS:rust-mdbook-preprocessor+default-devel = " \
 cargo \
 rust-mdbook-preprocessor-devel \
 "
RDEPENDS:rust-mdbook-preprocessor-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-mdbook-core+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 "
