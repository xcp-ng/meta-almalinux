# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-prometheus-procfs"
PV = "0.14.0"
PR = "2.el10_0"
PACKAGES = " \
 golang-github-prometheus-procfs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-prometheus-procfs-0.14.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "edc906cd1ce18179502fed2ca8658ab8460642dec23a2cfc10e55c8009f41808"

URI_x86_64_v2_golang-github-prometheus-procfs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-prometheus-procfs-devel-0.14.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-prometheus-procfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-prometheus-procfs-devel}"
SRC_URI[x86_64_v2_golang-github-prometheus-procfs-devel.sha256sum] = "dbee031395830bd49fe01d9dbe875dd181bf582591fcb6af04ab5742b8b53441"

URI_aarch64_golang-github-prometheus-procfs-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-prometheus-procfs-devel-0.14.0-2.el10_0.noarch.rpm;name=aarch64_golang-github-prometheus-procfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-prometheus-procfs-devel}"
SRC_URI[aarch64_golang-github-prometheus-procfs-devel.sha256sum] = "acdf936d2bb630b0d71b4e8200f61f082e656266c7ca50878ace9956d9edffb6"

RDEPENDS:golang-github-prometheus-procfs-devel = " \
 go-filesystem \
 golang-x-sync-devel \
 golang-x-sys-devel \
 "
