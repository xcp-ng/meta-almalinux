# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "buildah"
PE = "2"
PV = "1.45.0"
PR = "2.el10"
PACKAGES = " \
 buildah \
 buildah-tests \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/buildah-1.45.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1f343a4042ecd4e0f410b8aac5ac3af85d2bafa04fb00ea89e9ae70c9d15d1e8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/buildah-1.45.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_buildah;unpack=0"
SRC_URI[x86_64_v2_buildah.sha256sum] = "3ea56f5fed939658c1ea48a08912bca2555700802553e446661168d3a7afe53b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/buildah-tests-1.45.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_buildah-tests;unpack=0"
SRC_URI[x86_64_v2_buildah-tests.sha256sum] = "e84875ac6badb7cd2d9c743159244740212a4a59fa8a3b01f9b2eb63c3d816ba"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/buildah-1.45.0-2.el10.aarch64.rpm;name=aarch64_buildah;unpack=0"
SRC_URI[aarch64_buildah.sha256sum] = "c65be979c13077708d60843ae9ada1f73ea674c1bdbb4277cc2155655a4d3369"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/buildah-tests-1.45.0-2.el10.aarch64.rpm;name=aarch64_buildah-tests;unpack=0"
SRC_URI[aarch64_buildah-tests.sha256sum] = "87a569a924035d1b94fa53927bcd5aa913131cc9ec781558065d2f44192962ab"

RDEPENDS:buildah = " \
 containers-common-extra \
 glibc \
 gpgme \
 libseccomp \
 podman-sequoia \
 shadow-utils-subid \
 sqlite-libs \
 "
RDEPENDS:buildah-tests = " \
 bash \
 buildah \
 bzip2 \
 git-daemon \
 glibc \
 golang \
 gpgme \
 httpd-tools \
 jq \
 libseccomp \
 libselinux-utils \
 nmap-ncat \
 openssl \
 podman \
 shadow-utils-subid \
 sqlite-libs \
 which \
 xz \
 zstd \
 "
