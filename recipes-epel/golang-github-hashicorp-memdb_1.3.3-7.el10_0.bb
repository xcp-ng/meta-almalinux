# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-hashicorp-memdb"
PV = "1.3.3"
PR = "7.el10_0"
PACKAGES = " \
 golang-github-hashicorp-memdb-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-hashicorp-memdb-1.3.3-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45b603824939f97ceac9368240e890b6b438c6dc75cdfcb6adedfa06773c31d3"

URI_x86_64_v2_golang-github-hashicorp-memdb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-hashicorp-memdb-devel-1.3.3-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-hashicorp-memdb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-hashicorp-memdb-devel}"
SRC_URI[x86_64_v2_golang-github-hashicorp-memdb-devel.sha256sum] = "c7e16e1b492719c5e995125c6091b1faa1463cb41195b7760370c984f35350ce"

URI_aarch64_golang-github-hashicorp-memdb-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-hashicorp-memdb-devel-1.3.3-7.el10_0.noarch.rpm;name=aarch64_golang-github-hashicorp-memdb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-hashicorp-memdb-devel}"
SRC_URI[aarch64_golang-github-hashicorp-memdb-devel.sha256sum] = "1b1fdcd6621b5bf87c0c54b7526e1c3482a4e1103611f696965ba05e3f522952"

RDEPENDS:golang-github-hashicorp-memdb-devel = " \
 go-filesystem \
 golang-github-hashicorp-immutable-radix-devel \
 "
