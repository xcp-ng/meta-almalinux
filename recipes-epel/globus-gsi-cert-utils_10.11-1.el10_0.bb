# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gsi-cert-utils"
PV = "10.11"
PR = "1.el10_0"
PACKAGES = " \
 globus-gsi-cert-utils \
 globus-gsi-cert-utils-devel \
 globus-gsi-cert-utils-doc \
 globus-gsi-cert-utils-progs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gsi-cert-utils-10.11-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ed7d9fe917df74fbd59781c52bfd5817e1aed68290b3e5de300e5124443adf3"

URI_x86_64_v2_globus-gsi-cert-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-cert-utils-10.11-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gsi-cert-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-cert-utils}"
SRC_URI[x86_64_v2_globus-gsi-cert-utils.sha256sum] = "3aa70c0fb215ad6516a7fe8ffd2cdbf11d9b3520ac00b5aa6c648260099e5bad"

URI_x86_64_v2_globus-gsi-cert-utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-cert-utils-devel-10.11-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gsi-cert-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-cert-utils-devel}"
SRC_URI[x86_64_v2_globus-gsi-cert-utils-devel.sha256sum] = "96632f2360171ce544a7a27d2b242c7753422ffc38b6967ccd281e1457286cb7"

URI_x86_64_v2_globus-gsi-cert-utils-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-cert-utils-doc-10.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gsi-cert-utils-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-cert-utils-doc}"
SRC_URI[x86_64_v2_globus-gsi-cert-utils-doc.sha256sum] = "dc9523954c58453b957805b5683c60d8806c07e7951f12e12eb819587f3aafb8"

URI_x86_64_v2_globus-gsi-cert-utils-progs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-cert-utils-progs-10.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gsi-cert-utils-progs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-cert-utils-progs}"
SRC_URI[x86_64_v2_globus-gsi-cert-utils-progs.sha256sum] = "f218ae8f6a1db34efa01286b93a92d02bef297c33e393b002945dfc6cab1152d"

URI_aarch64_globus-gsi-cert-utils = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-cert-utils-10.11-1.el10_0.aarch64.rpm;name=aarch64_globus-gsi-cert-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-cert-utils}"
SRC_URI[aarch64_globus-gsi-cert-utils.sha256sum] = "5aa020cf620f7f046a9e5c43d81a3b91b6a7021f120c0029df6c2f8645536e66"

URI_aarch64_globus-gsi-cert-utils-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-cert-utils-devel-10.11-1.el10_0.aarch64.rpm;name=aarch64_globus-gsi-cert-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-cert-utils-devel}"
SRC_URI[aarch64_globus-gsi-cert-utils-devel.sha256sum] = "73c20a141e2b3470aa85aee191925cac7ca7778d04f3ce00c2795288b90d27ae"

URI_aarch64_globus-gsi-cert-utils-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-cert-utils-doc-10.11-1.el10_0.noarch.rpm;name=aarch64_globus-gsi-cert-utils-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-cert-utils-doc}"
SRC_URI[aarch64_globus-gsi-cert-utils-doc.sha256sum] = "50b46004ffab70ae03a0a50a6d2456ea8092129a38eb3c3e1602a2827e0bb369"

URI_aarch64_globus-gsi-cert-utils-progs = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-cert-utils-progs-10.11-1.el10_0.noarch.rpm;name=aarch64_globus-gsi-cert-utils-progs;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-cert-utils-progs}"
SRC_URI[aarch64_globus-gsi-cert-utils-progs.sha256sum] = "47e1354907385da8e6465316e442193638ee8609d0fb4a3b0618f9aa16a7db2b"

RDEPENDS:globus-gsi-cert-utils = " \
 glibc \
 globus-common \
 globus-gsi-openssl-error \
 globus-openssl-module \
 openssl-libs \
 "
RDEPENDS:globus-gsi-cert-utils-devel = " \
 globus-common-devel \
 globus-gsi-cert-utils \
 globus-gsi-openssl-error-devel \
 globus-openssl-module-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-gsi-cert-utils-doc = " \
 "
RDEPENDS:globus-gsi-cert-utils-progs = " \
 bash \
 openssl \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 "
