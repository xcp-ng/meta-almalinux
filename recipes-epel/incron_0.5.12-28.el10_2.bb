# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "incron"
PV = "0.5.12"
PR = "28.el10_2"
PACKAGES = " \
 incron \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/incron-0.5.12-28.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a3ce325e4f87be2e1ab7c9a9d49bf869c7f23a4832116d63b21ba17dc27aa67b"

URI_x86_64_v2_incron = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/incron-0.5.12-28.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_incron;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_incron}"
SRC_URI[x86_64_v2_incron.sha256sum] = "2226d7d7f0db533710ce963503181c7e9bd8f3b3841bf30f8ae3107a146a5208"

URI_aarch64_incron = "${EPEL_MIRROR}/aarch64/Packages/i/incron-0.5.12-28.el10_2.aarch64.rpm;name=aarch64_incron;unpack=0"
SRC_URI:append = " ${URI_aarch64_incron}"
SRC_URI[aarch64_incron.sha256sum] = "d2eda0132a72d553e899ecea16cd3e9d04e39b56e856047739fb4a9fe3c8402c"

RDEPENDS:incron = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 systemd \
 "
