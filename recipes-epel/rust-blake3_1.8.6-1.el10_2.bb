# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-blake3"
PV = "1.8.6"
PR = "1.el10_2"
PACKAGES = " \
 rust-blake3+default-devel \
 rust-blake3+mmap-devel \
 rust-blake3+neon-devel \
 rust-blake3+rayon-devel \
 rust-blake3+serde-devel \
 rust-blake3+std-devel \
 rust-blake3+zeroize-devel \
 rust-blake3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-blake3-1.8.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8838f573b9e093b7b2373f5b86749f628a4bb5c51db3a86fae92fcc278de55a8"

URI_x86_64_v2_rust-blake3+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+default-devel-1.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+default-devel}"
SRC_URI[x86_64_v2_rust-blake3+default-devel.sha256sum] = "76733a7d34db274babbbab04007b63a79bbc6a5b5b2122cf8335f4462a2ce8ab"

URI_x86_64_v2_rust-blake3+mmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+mmap-devel-1.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+mmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+mmap-devel}"
SRC_URI[x86_64_v2_rust-blake3+mmap-devel.sha256sum] = "0f97649d26d601435fb2c1e012b868c8866bc2dbb73790057af32468c8220534"

URI_x86_64_v2_rust-blake3+neon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+neon-devel-1.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+neon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+neon-devel}"
SRC_URI[x86_64_v2_rust-blake3+neon-devel.sha256sum] = "ffa5bc0bd88c5df318f0ac2ca243f67a772b44d6d95c7e9c385c14435f0bea25"

URI_x86_64_v2_rust-blake3+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+rayon-devel-1.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+rayon-devel}"
SRC_URI[x86_64_v2_rust-blake3+rayon-devel.sha256sum] = "4201b65438474bf1a8f2516f9c60f19c75b192554e188a0146ad7037d82bf64e"

URI_x86_64_v2_rust-blake3+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+serde-devel-1.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+serde-devel}"
SRC_URI[x86_64_v2_rust-blake3+serde-devel.sha256sum] = "937794811e68d6c95a52562e31a31caa0c8df52be88f618cef160a4eab713088"

URI_x86_64_v2_rust-blake3+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+std-devel-1.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+std-devel}"
SRC_URI[x86_64_v2_rust-blake3+std-devel.sha256sum] = "281379c523bc2c1c0a7dc7144a6832830a762b94a0b9558ed207138290914186"

URI_x86_64_v2_rust-blake3+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+zeroize-devel-1.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+zeroize-devel}"
SRC_URI[x86_64_v2_rust-blake3+zeroize-devel.sha256sum] = "ba04f0679bae46bbc262bb7369204eab1e296ef63755063e2f65c01b4d043a85"

URI_x86_64_v2_rust-blake3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3-devel-1.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3-devel}"
SRC_URI[x86_64_v2_rust-blake3-devel.sha256sum] = "8888d2e3fd5f5646b2a28e8fbc2d8b54818a278ba8955909031325b23c0e210f"

URI_aarch64_rust-blake3+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+default-devel-1.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-blake3+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+default-devel}"
SRC_URI[aarch64_rust-blake3+default-devel.sha256sum] = "8e999d9edb6da1600af2e83fe92ef14d2e12c158e4d946c6b951dbce8001d9c1"

URI_aarch64_rust-blake3+mmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+mmap-devel-1.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-blake3+mmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+mmap-devel}"
SRC_URI[aarch64_rust-blake3+mmap-devel.sha256sum] = "a8367a6f4c3df80d7ceff440af129cf5683700e57e423862098bb382cb348e8c"

URI_aarch64_rust-blake3+neon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+neon-devel-1.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-blake3+neon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+neon-devel}"
SRC_URI[aarch64_rust-blake3+neon-devel.sha256sum] = "ea210a52918b64626bb1ba026038264bd0be14930554b7803561f165c1a9cd1d"

URI_aarch64_rust-blake3+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+rayon-devel-1.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-blake3+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+rayon-devel}"
SRC_URI[aarch64_rust-blake3+rayon-devel.sha256sum] = "dea3a2b3957a184438eed8210c51bb6eac31f45d2a930a002ca30917be6c425d"

URI_aarch64_rust-blake3+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+serde-devel-1.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-blake3+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+serde-devel}"
SRC_URI[aarch64_rust-blake3+serde-devel.sha256sum] = "113b5bebc0a100e2e3336d39025c894d8c1cf7c6cf13ae7d2243ab8653053c70"

URI_aarch64_rust-blake3+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+std-devel-1.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-blake3+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+std-devel}"
SRC_URI[aarch64_rust-blake3+std-devel.sha256sum] = "8a7114f6fa2c9a3b441891709293844cc2569ffeb422f3e73066a999de7faf05"

URI_aarch64_rust-blake3+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+zeroize-devel-1.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-blake3+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+zeroize-devel}"
SRC_URI[aarch64_rust-blake3+zeroize-devel.sha256sum] = "4d16111187347d1111f043531f4524103697cf228972f0a20ca393ccc48e8ad7"

URI_aarch64_rust-blake3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3-devel-1.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-blake3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3-devel}"
SRC_URI[aarch64_rust-blake3-devel.sha256sum] = "9ab2380e29bc94e1c19072f53158431cf002090de9afa6e80ddb7937f05353e8"

RDEPENDS:rust-blake3+default-devel = " \
 cargo \
 rust-blake3+std-devel \
 rust-blake3-devel \
 "
RDEPENDS:rust-blake3+mmap-devel = " \
 cargo \
 rust-blake3+std-devel \
 rust-blake3-devel \
 rust-memmap2+default-devel \
 "
RDEPENDS:rust-blake3+neon-devel = " \
 cargo \
 rust-blake3-devel \
 "
RDEPENDS:rust-blake3+rayon-devel = " \
 cargo \
 rust-blake3-devel \
 rust-rayon-core+default-devel \
 "
RDEPENDS:rust-blake3+serde-devel = " \
 cargo \
 rust-blake3-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-blake3+std-devel = " \
 cargo \
 rust-blake3-devel \
 rust-constant_time_eq+std-devel \
 "
RDEPENDS:rust-blake3+zeroize-devel = " \
 cargo \
 rust-arrayvec+zeroize-devel \
 rust-blake3-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-blake3-devel = " \
 cargo \
 python3 \
 rust-arrayref+default-devel \
 rust-arrayvec-devel \
 rust-cc+default-devel \
 rust-cfg-if+default-devel \
 rust-constant_time_eq-devel \
 rust-cpufeatures+default-devel \
 "
