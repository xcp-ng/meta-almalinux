# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-DBI"
PV = "1.643"
PR = "26.el10_2.7"
PACKAGES = " \
 perl-DBI \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-DBI-1.643-26.el10_2.7.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3857910cbb40d778343a762be8ac365d1297a21869b1f42d942d08ca8f6d3402"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-DBI-1.643-26.el10_2.7.x86_64_v2.rpm;name=x86_64_v2_perl-DBI;unpack=0"
SRC_URI[x86_64_v2_perl-DBI.sha256sum] = "ac1de8e0a2c70dc909545ac7954a121baa69bd792775588ab173f436679b5a64"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-DBI-1.643-26.el10_2.7.aarch64.rpm;name=aarch64_perl-DBI;unpack=0"
SRC_URI[aarch64_perl-DBI.sha256sum] = "8ae7067568352429100095f6a6fb0485d01e169982fb18659300fa6ce50b177a"

RDEPENDS:perl-DBI = " \
 glibc \
 perl-Carp \
 perl-DBI \
 perl-Data-Dumper \
 perl-DynaLoader \
 perl-Errno \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-IO \
 perl-IPC-Open3 \
 perl-Math-BigInt \
 perl-Module-Load \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-Symbol \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
