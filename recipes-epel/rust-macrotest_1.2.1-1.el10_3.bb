# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-macrotest"
PV = "1.2.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-macrotest+default-devel \
 rust-macrotest-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-macrotest-1.2.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d6052abc4a097bc9aa775484024e3f82434aa3c47f23ac22ea979aa1876adf33"

URI_x86_64_v2_rust-macrotest+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-macrotest+default-devel-1.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-macrotest+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-macrotest+default-devel}"
SRC_URI[x86_64_v2_rust-macrotest+default-devel.sha256sum] = "79b6e62207c0b0a2a6b7b60b78a4bae9c85be8efe12abb8f2be08ae610be9e6c"

URI_x86_64_v2_rust-macrotest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-macrotest-devel-1.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-macrotest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-macrotest-devel}"
SRC_URI[x86_64_v2_rust-macrotest-devel.sha256sum] = "e05899a8b3c9e5cb996b749daccf3c889d6686b82bff2eaef8402e1fb388a254"

URI_aarch64_rust-macrotest+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-macrotest+default-devel-1.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-macrotest+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-macrotest+default-devel}"
SRC_URI[aarch64_rust-macrotest+default-devel.sha256sum] = "21a4898460f68d7ce4b005c8f842b57582ec97795688d05490192ff095ca8aae"

URI_aarch64_rust-macrotest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-macrotest-devel-1.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-macrotest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-macrotest-devel}"
SRC_URI[aarch64_rust-macrotest-devel.sha256sum] = "c27268f3b4cf53d8858b9d444d29aa4c6ad8d38c69fbf2206e290a4e2442f117"

RDEPENDS:rust-macrotest+default-devel = " \
 cargo \
 rust-macrotest-devel \
 "
RDEPENDS:rust-macrotest-devel = " \
 cargo \
 rust \
 rust-diff+default-devel \
 rust-fastrand+default-devel \
 rust-glob+default-devel \
 rust-prettyplease+default-devel \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 rust-serde_json+default-devel \
 rust-syn2+full-devel \
 rust-syn2+parsing-devel \
 rust-syn2-devel \
 rust-toml+default-devel \
 "
