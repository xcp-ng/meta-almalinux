# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "SuperLU"
PV = "7.0.0"
PR = "1.el10_0"
PACKAGES = " \
 SuperLU \
 SuperLU-devel \
 SuperLU-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/SuperLU-7.0.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c5b27537f744f85ce9098eb3eb263a2834d347d3c20216c5435c89ea8e4ee36"

URI_x86_64_v2_SuperLU = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SuperLU-7.0.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_SuperLU;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SuperLU}"
SRC_URI[x86_64_v2_SuperLU.sha256sum] = "5e852b38711dfea8018d03bf6562e38a613ff894dbb88cf25316edaf64ff77f2"

URI_x86_64_v2_SuperLU-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SuperLU-devel-7.0.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_SuperLU-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SuperLU-devel}"
SRC_URI[x86_64_v2_SuperLU-devel.sha256sum] = "6cfb1a7499d348df17ae41c03f5d584bf02b853f107a80a2b3729da485d62ed9"

URI_x86_64_v2_SuperLU-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SuperLU-doc-7.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_SuperLU-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SuperLU-doc}"
SRC_URI[x86_64_v2_SuperLU-doc.sha256sum] = "c7f7c5a89cd18d87adf6ced1fe4a205115d99d8fc26dbceab802165c867579f3"

URI_aarch64_SuperLU = "${EPEL_MIRROR}/aarch64/Packages/s/SuperLU-7.0.0-1.el10_0.aarch64.rpm;name=aarch64_SuperLU;unpack=0"
SRC_URI:append = " ${URI_aarch64_SuperLU}"
SRC_URI[aarch64_SuperLU.sha256sum] = "95535143061f803cf4c1f0319995cc9f7259c35c063911300ae34697e3c0efba"

URI_aarch64_SuperLU-devel = "${EPEL_MIRROR}/aarch64/Packages/s/SuperLU-devel-7.0.0-1.el10_0.aarch64.rpm;name=aarch64_SuperLU-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_SuperLU-devel}"
SRC_URI[aarch64_SuperLU-devel.sha256sum] = "68d310c77a83f2836667caef9150b6109afaa34454d62241e8562d6fc848420c"

URI_aarch64_SuperLU-doc = "${EPEL_MIRROR}/aarch64/Packages/s/SuperLU-doc-7.0.0-1.el10_0.noarch.rpm;name=aarch64_SuperLU-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_SuperLU-doc}"
SRC_URI[aarch64_SuperLU-doc.sha256sum] = "347991d0327df73bb9ef1f5495a05ecfb69bc76f3c90ae6fb6cfc9eb4a9f3c7d"

RDEPENDS:SuperLU = " \
 flexiblas-netlib \
 glibc \
 metis \
 "
RDEPENDS:SuperLU-devel = " \
 SuperLU \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
RDEPENDS:SuperLU-doc = " \
 "
