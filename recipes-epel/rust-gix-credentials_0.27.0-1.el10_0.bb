# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-credentials"
PV = "0.27.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-credentials+default-devel \
 rust-gix-credentials+document-features-devel \
 rust-gix-credentials+serde-devel \
 rust-gix-credentials-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-credentials-0.27.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6311f41805ec306059c52fabb7a870535a12994f35c3e3618754fbc1bb3127d"

URI_x86_64_v2_rust-gix-credentials+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-credentials+default-devel-0.27.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-credentials+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-credentials+default-devel}"
SRC_URI[x86_64_v2_rust-gix-credentials+default-devel.sha256sum] = "3cd257c6023c2aa5da92c22deda8ec13856d091ebd02b5af0c819e58c2d4a28e"

URI_x86_64_v2_rust-gix-credentials+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-credentials+document-features-devel-0.27.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-credentials+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-credentials+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-credentials+document-features-devel.sha256sum] = "eac1d60ba298dc4837b4529b71ad011fcdfaade3c0ffe589b3a8be918a27252c"

URI_x86_64_v2_rust-gix-credentials+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-credentials+serde-devel-0.27.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-credentials+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-credentials+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-credentials+serde-devel.sha256sum] = "a383ab17f2b5d010fa730aac1976c0a8d8d3b4a8ea3957b0d1cc0d66fd326e06"

URI_x86_64_v2_rust-gix-credentials-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-credentials-devel-0.27.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-credentials-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-credentials-devel}"
SRC_URI[x86_64_v2_rust-gix-credentials-devel.sha256sum] = "cffb5454f02e6a7800832cbac1ea5c51df3499a6c0d54c9fd0dcfd9665cb00ed"

URI_aarch64_rust-gix-credentials+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-credentials+default-devel-0.27.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-credentials+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-credentials+default-devel}"
SRC_URI[aarch64_rust-gix-credentials+default-devel.sha256sum] = "7249beb19d2e29547e6b3ec0a83eb751a84c863abdd7dd2cf044531138b836de"

URI_aarch64_rust-gix-credentials+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-credentials+document-features-devel-0.27.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-credentials+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-credentials+document-features-devel}"
SRC_URI[aarch64_rust-gix-credentials+document-features-devel.sha256sum] = "138743e72a70d069ce221d787ba990c6aa321c161de17e251bfe508734dff684"

URI_aarch64_rust-gix-credentials+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-credentials+serde-devel-0.27.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-credentials+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-credentials+serde-devel}"
SRC_URI[aarch64_rust-gix-credentials+serde-devel.sha256sum] = "a080fb3398004f67cde5e0f2613ab8379096299e839d5e4eb528ab033adf517e"

URI_aarch64_rust-gix-credentials-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-credentials-devel-0.27.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-credentials-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-credentials-devel}"
SRC_URI[aarch64_rust-gix-credentials-devel.sha256sum] = "cc31518ad56fdccca30ad3417fe46b4be4bf76e969389d91b1e4221eb5312c50"

RDEPENDS:rust-gix-credentials+default-devel = " \
 cargo \
 rust-gix-credentials-devel \
 "
RDEPENDS:rust-gix-credentials+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-credentials-devel \
 "
RDEPENDS:rust-gix-credentials+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-credentials-devel \
 rust-gix-sec+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-credentials-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-command+default-devel \
 rust-gix-config-value+default-devel \
 rust-gix-path+default-devel \
 rust-gix-prompt+default-devel \
 rust-gix-sec+default-devel \
 rust-gix-trace+default-devel \
 rust-gix-url+default-devel \
 rust-thiserror+default-devel \
 "
