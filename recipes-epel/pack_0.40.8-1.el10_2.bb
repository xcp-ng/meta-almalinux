# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pack"
PV = "0.40.8"
PR = "1.el10_2"
PACKAGES = " \
 pack \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pack-0.40.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "70ff458be1377cd5f6f2fbdaa45be0936d7e468c0b05837a4b2d830c5b4878c4"

URI_x86_64_v2_pack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pack-0.40.8-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pack}"
SRC_URI[x86_64_v2_pack.sha256sum] = "d044b960e25b7381eb9687c7f8f302b7b1d4103f6c5fceadbf7d6c249f4cbdff"

URI_aarch64_pack = "${EPEL_MIRROR}/aarch64/Packages/p/pack-0.40.8-1.el10_2.aarch64.rpm;name=aarch64_pack;unpack=0"
SRC_URI:append = " ${URI_aarch64_pack}"
SRC_URI[aarch64_pack.sha256sum] = "a0b07321995c625a8a021c8cb1059a177c5195be0ee2ef3a27cd8f46ad8b0d66"

RDEPENDS:pack = " \
 glibc \
 "
