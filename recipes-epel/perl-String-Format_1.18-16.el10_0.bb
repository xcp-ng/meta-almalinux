# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-String-Format"
PV = "1.18"
PR = "16.el10_0"
PACKAGES = " \
 perl-String-Format \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-String-Format-1.18-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7efa3ceeb4f96e30c7b1b4bfa36b88dd56c2b11c9e0ab01dd52d3bd9a53ead0d"

URI_x86_64_v2_perl-String-Format = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-String-Format-1.18-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-String-Format;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-String-Format}"
SRC_URI[x86_64_v2_perl-String-Format.sha256sum] = "044005edba111244789709b990ec4c28348745b68edb92ecda2b00f38178ddac"

URI_aarch64_perl-String-Format = "${EPEL_MIRROR}/aarch64/Packages/p/perl-String-Format-1.18-16.el10_0.noarch.rpm;name=aarch64_perl-String-Format;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-String-Format}"
SRC_URI[aarch64_perl-String-Format.sha256sum] = "f5f913412851145abbed12bf6a53509534794107fc881e31df622e1fcddec880"

RDEPENDS:perl-String-Format = " \
 perl-Exporter \
 perl-base \
 perl-libs \
 perl-vars \
 "
