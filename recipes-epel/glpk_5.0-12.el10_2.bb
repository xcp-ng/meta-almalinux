# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glpk"
PV = "5.0"
PR = "12.el10_2"
PACKAGES = " \
 glpk \
 glpk-devel \
 glpk-doc \
 glpk-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/glpk-5.0-12.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "76e43351b4fd0ec9575cebe214189d21eb19c9c7b81032a1fb6ce1434b6a1c6d"

URI_x86_64_v2_glpk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glpk-5.0-12.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_glpk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glpk}"
SRC_URI[x86_64_v2_glpk.sha256sum] = "f730da4a9a526c99aa0f975101deb6458c1d447895a4b41c76878c509658e0c7"

URI_x86_64_v2_glpk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glpk-devel-5.0-12.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_glpk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glpk-devel}"
SRC_URI[x86_64_v2_glpk-devel.sha256sum] = "2bf7e33f43eb3e4d21f9d0d761ae03502822f754e1348d78129f15850fa631f3"

URI_x86_64_v2_glpk-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glpk-doc-5.0-12.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_glpk-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glpk-doc}"
SRC_URI[x86_64_v2_glpk-doc.sha256sum] = "2467ec8d9d7dc31fe054bb009a0bede191bf89c97772726a88ab9476925b35e2"

URI_x86_64_v2_glpk-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glpk-utils-5.0-12.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_glpk-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glpk-utils}"
SRC_URI[x86_64_v2_glpk-utils.sha256sum] = "8040cda1ff6bb77a531bb8486f0a5028c8732fce00a33cd6ee2f388bca8d9880"

URI_aarch64_glpk = "${EPEL_MIRROR}/aarch64/Packages/g/glpk-5.0-12.el10_2.aarch64.rpm;name=aarch64_glpk;unpack=0"
SRC_URI:append = " ${URI_aarch64_glpk}"
SRC_URI[aarch64_glpk.sha256sum] = "e69933d031930e0d3a79f84f89bef5e3e50f9f53092e7f5a4e6101fcf96d7fe7"

URI_aarch64_glpk-devel = "${EPEL_MIRROR}/aarch64/Packages/g/glpk-devel-5.0-12.el10_2.aarch64.rpm;name=aarch64_glpk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_glpk-devel}"
SRC_URI[aarch64_glpk-devel.sha256sum] = "0918eb5eeb0e08580c84186f8f9e32e0e2247ea6d0385b7240fc9cb7bb86d85d"

URI_aarch64_glpk-doc = "${EPEL_MIRROR}/aarch64/Packages/g/glpk-doc-5.0-12.el10_2.aarch64.rpm;name=aarch64_glpk-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glpk-doc}"
SRC_URI[aarch64_glpk-doc.sha256sum] = "d9968ebe2e60cadc16cbba43c8e8f0ab60385c3887c98ddad43d9642eeb9e752"

URI_aarch64_glpk-utils = "${EPEL_MIRROR}/aarch64/Packages/g/glpk-utils-5.0-12.el10_2.aarch64.rpm;name=aarch64_glpk-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_glpk-utils}"
SRC_URI[aarch64_glpk-utils.sha256sum] = "eab3dda7e151bdca800b1f7ac99aec9b025c85f8e1f7f44738c0dd6e8dfda5a1"

RDEPENDS:glpk = " \
 glibc \
 gmp \
 suitesparse \
 zlib-ng-compat \
 "
RDEPENDS:glpk-devel = " \
 glpk \
 "
RDEPENDS:glpk-doc = " \
 "
RDEPENDS:glpk-utils = " \
 glibc \
 glpk \
 "
