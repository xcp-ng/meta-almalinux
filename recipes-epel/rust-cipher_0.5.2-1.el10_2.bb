# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cipher"
PV = "0.5.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-cipher+alloc-devel \
 rust-cipher+blobby-devel \
 rust-cipher+block-buffer-devel \
 rust-cipher+block-padding-devel \
 rust-cipher+default-devel \
 rust-cipher+dev-devel \
 rust-cipher+getrandom-devel \
 rust-cipher+rand_core-devel \
 rust-cipher+stream-wrapper-devel \
 rust-cipher+zeroize-devel \
 rust-cipher-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cipher-0.5.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "10d345ab4c6a40e0071fce2eeb159d2f60e332dc3b08158139d87ef5099449cb"

URI_x86_64_v2_rust-cipher+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher+alloc-devel-0.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher+alloc-devel}"
SRC_URI[x86_64_v2_rust-cipher+alloc-devel.sha256sum] = "9f8511ed72305d044b9067cd3fec2632a8fa17763d31ed9a36b4d16db0889620"

URI_x86_64_v2_rust-cipher+blobby-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher+blobby-devel-0.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher+blobby-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher+blobby-devel}"
SRC_URI[x86_64_v2_rust-cipher+blobby-devel.sha256sum] = "58cc8750698ff02cb9d1c0c5e26a9631711763b8f959e3663c1fbc5aeb6b43b2"

URI_x86_64_v2_rust-cipher+block-buffer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher+block-buffer-devel-0.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher+block-buffer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher+block-buffer-devel}"
SRC_URI[x86_64_v2_rust-cipher+block-buffer-devel.sha256sum] = "2e07f7a73313c048d0d34aee8c4405210f16b563dfacfe0d8d89132c361c2399"

URI_x86_64_v2_rust-cipher+block-padding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher+block-padding-devel-0.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher+block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher+block-padding-devel}"
SRC_URI[x86_64_v2_rust-cipher+block-padding-devel.sha256sum] = "fa3f76c3359459c159efc872cbb6d1320265fb1949570fca9bc73400eea10a67"

URI_x86_64_v2_rust-cipher+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher+default-devel-0.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher+default-devel}"
SRC_URI[x86_64_v2_rust-cipher+default-devel.sha256sum] = "cb129d167891ab02d5fd5cbca7ada93b271d7c9398f1a486feb9b71e218de142"

URI_x86_64_v2_rust-cipher+dev-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher+dev-devel-0.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher+dev-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher+dev-devel}"
SRC_URI[x86_64_v2_rust-cipher+dev-devel.sha256sum] = "ae8d7c0fb28638dfccfe65e210e95711a357d5cefdef62a68f44cf98708b68e3"

URI_x86_64_v2_rust-cipher+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher+getrandom-devel-0.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher+getrandom-devel}"
SRC_URI[x86_64_v2_rust-cipher+getrandom-devel.sha256sum] = "4b8e4b0ab735907d12aa5ce2713fc977f09381fae05ad0c14a1ff9edbc905cad"

URI_x86_64_v2_rust-cipher+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher+rand_core-devel-0.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher+rand_core-devel}"
SRC_URI[x86_64_v2_rust-cipher+rand_core-devel.sha256sum] = "e27f0391d191ff15d5fa1f2183b26f23beccb4c0595c73811dcdf34b88b71a64"

URI_x86_64_v2_rust-cipher+stream-wrapper-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher+stream-wrapper-devel-0.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher+stream-wrapper-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher+stream-wrapper-devel}"
SRC_URI[x86_64_v2_rust-cipher+stream-wrapper-devel.sha256sum] = "c0ec82c012e9a5a13d868d81e839465e6714e8686e7617221d8a07e02d56221b"

URI_x86_64_v2_rust-cipher+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher+zeroize-devel-0.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher+zeroize-devel}"
SRC_URI[x86_64_v2_rust-cipher+zeroize-devel.sha256sum] = "381510a904602a363987ad956be1a3fbd8c3011cd5d8fcf9d2f9f927f8d0736b"

URI_x86_64_v2_rust-cipher-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher-devel-0.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher-devel}"
SRC_URI[x86_64_v2_rust-cipher-devel.sha256sum] = "b25f7c0ea665221d2eea0785409f09a52e030f0242a4aac6ba8b8069547e33b5"

URI_aarch64_rust-cipher+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher+alloc-devel-0.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-cipher+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher+alloc-devel}"
SRC_URI[aarch64_rust-cipher+alloc-devel.sha256sum] = "af5e8b9711be562e877ac8d344d04eff1bec83213c27d574af3741e3cfe10837"

URI_aarch64_rust-cipher+blobby-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher+blobby-devel-0.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-cipher+blobby-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher+blobby-devel}"
SRC_URI[aarch64_rust-cipher+blobby-devel.sha256sum] = "b756a433720421e0bbe2480dfa4fe6836d014eafeda3e950be6b80aee49594ac"

URI_aarch64_rust-cipher+block-buffer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher+block-buffer-devel-0.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-cipher+block-buffer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher+block-buffer-devel}"
SRC_URI[aarch64_rust-cipher+block-buffer-devel.sha256sum] = "6663304145b1d567e800d229c2abe6fc03e7b0b5b9e28ac7bb21412ef069f917"

URI_aarch64_rust-cipher+block-padding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher+block-padding-devel-0.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-cipher+block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher+block-padding-devel}"
SRC_URI[aarch64_rust-cipher+block-padding-devel.sha256sum] = "7b969e7b27ee860913e5b97d64da462a776d19dca6f6e2a0f84a8ffebcab66b6"

URI_aarch64_rust-cipher+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher+default-devel-0.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-cipher+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher+default-devel}"
SRC_URI[aarch64_rust-cipher+default-devel.sha256sum] = "a043963a146af92b59566b7593547c21026bb611dc557801cfefae522013d99c"

URI_aarch64_rust-cipher+dev-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher+dev-devel-0.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-cipher+dev-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher+dev-devel}"
SRC_URI[aarch64_rust-cipher+dev-devel.sha256sum] = "afd2396addc2841577d440b554ef7624aaf11f9681c25ad6fb7aeb78247130c1"

URI_aarch64_rust-cipher+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher+getrandom-devel-0.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-cipher+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher+getrandom-devel}"
SRC_URI[aarch64_rust-cipher+getrandom-devel.sha256sum] = "ef15233a2af11355d9ea8e40ef9720698171d7049c77a6459f7d5db95ed48546"

URI_aarch64_rust-cipher+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher+rand_core-devel-0.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-cipher+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher+rand_core-devel}"
SRC_URI[aarch64_rust-cipher+rand_core-devel.sha256sum] = "2d226bf83007dfaa7a1611865fa418f705b4eacf0ebe4c8bd5133afcd20df34b"

URI_aarch64_rust-cipher+stream-wrapper-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher+stream-wrapper-devel-0.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-cipher+stream-wrapper-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher+stream-wrapper-devel}"
SRC_URI[aarch64_rust-cipher+stream-wrapper-devel.sha256sum] = "17f7b12115a9ef3b1c76d56f6c88f7220ef6ed3465e52be2c1ca8d9dbd039496"

URI_aarch64_rust-cipher+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher+zeroize-devel-0.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-cipher+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher+zeroize-devel}"
SRC_URI[aarch64_rust-cipher+zeroize-devel.sha256sum] = "8ff2044640010564f8fb615f6c2f8d69ccaebb8086a9ddead5c866c9f1ac5bcc"

URI_aarch64_rust-cipher-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher-devel-0.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-cipher-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher-devel}"
SRC_URI[aarch64_rust-cipher-devel.sha256sum] = "61fb3a7c103a20bb4096d5d2268b70039059130b7db9e554020bf1f48e0c9a04"

RDEPENDS:rust-cipher+alloc-devel = " \
 cargo \
 rust-cipher-devel \
 "
RDEPENDS:rust-cipher+blobby-devel = " \
 cargo \
 rust-blobby+default-devel \
 rust-cipher-devel \
 "
RDEPENDS:rust-cipher+block-buffer-devel = " \
 cargo \
 rust-block-buffer+default-devel \
 rust-cipher-devel \
 "
RDEPENDS:rust-cipher+block-padding-devel = " \
 cargo \
 rust-cipher-devel \
 rust-inout+block-padding-devel \
 "
RDEPENDS:rust-cipher+default-devel = " \
 cargo \
 rust-cipher-devel \
 "
RDEPENDS:rust-cipher+dev-devel = " \
 cargo \
 rust-cipher+blobby-devel \
 rust-cipher-devel \
 "
RDEPENDS:rust-cipher+getrandom-devel = " \
 cargo \
 rust-cipher-devel \
 rust-crypto-common+getrandom-devel \
 "
RDEPENDS:rust-cipher+rand_core-devel = " \
 cargo \
 rust-cipher-devel \
 rust-crypto-common+rand_core-devel \
 "
RDEPENDS:rust-cipher+stream-wrapper-devel = " \
 cargo \
 rust-cipher+block-buffer-devel \
 rust-cipher-devel \
 "
RDEPENDS:rust-cipher+zeroize-devel = " \
 cargo \
 rust-block-buffer+default-devel \
 rust-block-buffer+zeroize-devel \
 rust-cipher-devel \
 rust-crypto-common+zeroize-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-cipher-devel = " \
 cargo \
 rust \
 rust-crypto-common+default-devel \
 rust-inout+default-devel \
 "
