# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ifuse"
PV = "1.1.4"
PR = "17.el10_0"
PACKAGES = " \
 ifuse \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/ifuse-1.1.4-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8803dc526de865b9a2d48c7b74434c1c6d15ccf1bca0dceaf3575b228a318f15"

URI_x86_64_v2_ifuse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ifuse-1.1.4-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ifuse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ifuse}"
SRC_URI[x86_64_v2_ifuse.sha256sum] = "010f9f347d38c470e3d51fb343f46c30123621bf6903b386afa7a4559a13fb79"

URI_aarch64_ifuse = "${EPEL_MIRROR}/aarch64/Packages/i/ifuse-1.1.4-17.el10_0.aarch64.rpm;name=aarch64_ifuse;unpack=0"
SRC_URI:append = " ${URI_aarch64_ifuse}"
SRC_URI[aarch64_ifuse.sha256sum] = "78dd45ccfdb96a40067c54d1edc3482b68650b7ec52c2d75425e5ac5fd85b9b0"

RDEPENDS:ifuse = " \
 fuse \
 fuse-libs \
 glibc \
 libimobiledevice \
 libplist \
 "
