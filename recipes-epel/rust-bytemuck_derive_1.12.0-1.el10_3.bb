# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bytemuck_derive"
PV = "1.12.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-bytemuck_derive+default-devel \
 rust-bytemuck_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bytemuck_derive-1.12.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0bfcbc8ee1367d864b12b1d533d3f968630532c795d31023f514b2827ea80a8a"

URI_x86_64_v2_rust-bytemuck_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck_derive+default-devel-1.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck_derive+default-devel}"
SRC_URI[x86_64_v2_rust-bytemuck_derive+default-devel.sha256sum] = "84c36527470b80a2f22e0a9229fd8ed0a8d282d61565e0b080ec5ec9318b9c45"

URI_x86_64_v2_rust-bytemuck_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck_derive-devel-1.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck_derive-devel}"
SRC_URI[x86_64_v2_rust-bytemuck_derive-devel.sha256sum] = "48bc74b92e928c3c54eb86d69eb2df72f704723cb060d0d83dbcc2e7632bec30"

URI_aarch64_rust-bytemuck_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck_derive+default-devel-1.12.0-1.el10_3.noarch.rpm;name=aarch64_rust-bytemuck_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck_derive+default-devel}"
SRC_URI[aarch64_rust-bytemuck_derive+default-devel.sha256sum] = "3238ad7cecdead4947c9f78fdf09338b8cbf34ae297758961701b730eab324c2"

URI_aarch64_rust-bytemuck_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck_derive-devel-1.12.0-1.el10_3.noarch.rpm;name=aarch64_rust-bytemuck_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck_derive-devel}"
SRC_URI[aarch64_rust-bytemuck_derive-devel.sha256sum] = "400a6c6891df56a045a94ea3c480e69cc39db829a50f2456fd1235b4c6159313"

RDEPENDS:rust-bytemuck_derive+default-devel = " \
 cargo \
 rust-bytemuck_derive-devel \
 "
RDEPENDS:rust-bytemuck_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
