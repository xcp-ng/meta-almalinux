# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdnssd"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kdnssd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdnssd-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e784dedfbc5e33c9a2c0c4732e5e57b91bb828b889471ca098cb5d74dcfbcf4"

URI_x86_64_v2_kdnssd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdnssd-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdnssd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdnssd}"
SRC_URI[x86_64_v2_kdnssd.sha256sum] = "29487d9e5555fe25c29ad81eacb157d85ba8b664f5138b11942244ed0a5e9ada"

URI_aarch64_kdnssd = "${EPEL_MIRROR}/aarch64/Packages/k/kdnssd-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kdnssd;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdnssd}"
SRC_URI[aarch64_kdnssd.sha256sum] = "f74a50d7cae5291a5f3531b4e630b367cebcb60b2c07b1b2c6609455edc6bd42"

RDEPENDS:kdnssd = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kdnssd \
 kf6-ki18n \
 kf6-kio-core-libs \
 libstdc++ \
 qt6-qtbase \
 "
