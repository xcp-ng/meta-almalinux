# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-workspace-wallpapers"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 plasma-workspace-wallpapers \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-workspace-wallpapers-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "821a20bba4c621f9c5b678134ae6f08e51ca0ddf5cf0bed03b2640d12f3c9d9a"

URI_x86_64_v2_plasma-workspace-wallpapers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-workspace-wallpapers-6.3.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-workspace-wallpapers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-workspace-wallpapers}"
SRC_URI[x86_64_v2_plasma-workspace-wallpapers.sha256sum] = "986cfd3df78c464b24b4459c3ecaedb97d4f3a6ae7bbf846ddb0bddc7da76212"

URI_aarch64_plasma-workspace-wallpapers = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-workspace-wallpapers-6.3.6-1.el10_0.noarch.rpm;name=aarch64_plasma-workspace-wallpapers;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-workspace-wallpapers}"
SRC_URI[aarch64_plasma-workspace-wallpapers.sha256sum] = "4de8f211211df28c8587ac4260f88d342fbcb47c3389e5026b379370a5ba5807"

RDEPENDS:plasma-workspace-wallpapers = " \
 kde-filesystem \
 "
