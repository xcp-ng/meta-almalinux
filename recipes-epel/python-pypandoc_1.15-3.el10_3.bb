# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pypandoc"
PV = "1.15"
PR = "3.el10_3"
PACKAGES = " \
 python3-pypandoc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pypandoc-1.15-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69139b28fe3893218955390bc2ef5194ffe7499343744e8afd44e4df40e326ab"

URI_x86_64_v2_python3-pypandoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pypandoc-1.15-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pypandoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pypandoc}"
SRC_URI[x86_64_v2_python3-pypandoc.sha256sum] = "d4a61bee3f1f0f86292810f02d74efe9e6d497c2667eff08bb14311f4132f65d"

URI_aarch64_python3-pypandoc = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pypandoc-1.15-3.el10_3.noarch.rpm;name=aarch64_python3-pypandoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pypandoc}"
SRC_URI[aarch64_python3-pypandoc.sha256sum] = "2583aa233eb76b9590d80b9a7d58ab87f6b0ac57eb0ba4ce076bd775939d3c42"

RDEPENDS:python3-pypandoc = " \
 pandoc \
 python3 \
 "
