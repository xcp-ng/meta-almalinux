# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Image-Xbm"
PV = "1.10"
PR = "25.el10_0"
PACKAGES = " \
 perl-Image-Xbm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Image-Xbm-1.10-25.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "97d76eeb865bd16edcbc3eb3b0927485c4db264fe963d241953525a0d53413ac"

URI_x86_64_v2_perl-Image-Xbm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Image-Xbm-1.10-25.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Image-Xbm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Image-Xbm}"
SRC_URI[x86_64_v2_perl-Image-Xbm.sha256sum] = "a71d941c98aa767b791180ef3e9268f09278f8611f81a92b4f1951a1f55f3867"

URI_aarch64_perl-Image-Xbm = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Image-Xbm-1.10-25.el10_0.noarch.rpm;name=aarch64_perl-Image-Xbm;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Image-Xbm}"
SRC_URI[aarch64_perl-Image-Xbm.sha256sum] = "c6125136a4acfbadf9f7bf2c0e514560903b2790d88ec015568de049bd7567ed"

RDEPENDS:perl-Image-Xbm = " \
 perl-Carp \
 perl-Image-Base \
 perl-Symbol \
 perl-libs \
 perl-vars \
 "
