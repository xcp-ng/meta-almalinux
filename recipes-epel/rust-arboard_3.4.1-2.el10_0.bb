# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-arboard"
PV = "3.4.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-arboard+default-devel \
 rust-arboard+image-data-devel \
 rust-arboard+image-devel \
 rust-arboard+wayland-data-control-devel \
 rust-arboard+wl-clipboard-rs-devel \
 rust-arboard-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-arboard-3.4.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "931b5c2aed00da3c2819865611ac31db01220511dae7f59d2c866cdfab95c06f"

URI_x86_64_v2_rust-arboard+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arboard+default-devel-3.4.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arboard+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arboard+default-devel}"
SRC_URI[x86_64_v2_rust-arboard+default-devel.sha256sum] = "e27bce02d5bd7395e4d33cac624a32d48a727928d3d158be5658a18ca339550b"

URI_x86_64_v2_rust-arboard+image-data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arboard+image-data-devel-3.4.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arboard+image-data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arboard+image-data-devel}"
SRC_URI[x86_64_v2_rust-arboard+image-data-devel.sha256sum] = "1be15c38b0c523ab92a3ba7bfb6c46bda92e9b0d72bb27c066789db88e13d3e4"

URI_x86_64_v2_rust-arboard+image-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arboard+image-devel-3.4.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arboard+image-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arboard+image-devel}"
SRC_URI[x86_64_v2_rust-arboard+image-devel.sha256sum] = "bbffa6c681e5c3a6438daddd5fea560f1dcac6f3005ad4de0dfcf1e2b0e8205f"

URI_x86_64_v2_rust-arboard+wayland-data-control-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arboard+wayland-data-control-devel-3.4.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arboard+wayland-data-control-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arboard+wayland-data-control-devel}"
SRC_URI[x86_64_v2_rust-arboard+wayland-data-control-devel.sha256sum] = "0f3d6584492e190e760be4b002c017dfe3179f7c4da901a1f11205e4eb8b9b64"

URI_x86_64_v2_rust-arboard+wl-clipboard-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arboard+wl-clipboard-rs-devel-3.4.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arboard+wl-clipboard-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arboard+wl-clipboard-rs-devel}"
SRC_URI[x86_64_v2_rust-arboard+wl-clipboard-rs-devel.sha256sum] = "e78b6d3465adbdcb51da572beaf63295f4fd33137b414b38e4c96efbea61ceb0"

URI_x86_64_v2_rust-arboard-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arboard-devel-3.4.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arboard-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arboard-devel}"
SRC_URI[x86_64_v2_rust-arboard-devel.sha256sum] = "37e5caeb05b7e89bcbc0bc45f83d23eb2bdae794ea09f2cfd1daa0c227075058"

URI_aarch64_rust-arboard+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arboard+default-devel-3.4.1-2.el10_0.noarch.rpm;name=aarch64_rust-arboard+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arboard+default-devel}"
SRC_URI[aarch64_rust-arboard+default-devel.sha256sum] = "6db14fcb78105d651c191af9fe892119634e0119bc5227ecca7d7b49c786a8ca"

URI_aarch64_rust-arboard+image-data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arboard+image-data-devel-3.4.1-2.el10_0.noarch.rpm;name=aarch64_rust-arboard+image-data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arboard+image-data-devel}"
SRC_URI[aarch64_rust-arboard+image-data-devel.sha256sum] = "ed3294d2fe83277646dd0c13f1d29636abe2ba80a97814285225c1c2870e549a"

URI_aarch64_rust-arboard+image-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arboard+image-devel-3.4.1-2.el10_0.noarch.rpm;name=aarch64_rust-arboard+image-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arboard+image-devel}"
SRC_URI[aarch64_rust-arboard+image-devel.sha256sum] = "b185407a4b7be92a5b8cd33d0c633bc272105e12e81aa385f24200797062dfa4"

URI_aarch64_rust-arboard+wayland-data-control-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arboard+wayland-data-control-devel-3.4.1-2.el10_0.noarch.rpm;name=aarch64_rust-arboard+wayland-data-control-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arboard+wayland-data-control-devel}"
SRC_URI[aarch64_rust-arboard+wayland-data-control-devel.sha256sum] = "b4dc2aa2cf97cd6ce947b125c94389a535b64155d76bc9102c34586a3a50e34c"

URI_aarch64_rust-arboard+wl-clipboard-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arboard+wl-clipboard-rs-devel-3.4.1-2.el10_0.noarch.rpm;name=aarch64_rust-arboard+wl-clipboard-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arboard+wl-clipboard-rs-devel}"
SRC_URI[aarch64_rust-arboard+wl-clipboard-rs-devel.sha256sum] = "97f4e1f166d001f667021ecfb1ca6c565542f0a8ea43299db585bd269f72c5ae"

URI_aarch64_rust-arboard-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arboard-devel-3.4.1-2.el10_0.noarch.rpm;name=aarch64_rust-arboard-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arboard-devel}"
SRC_URI[aarch64_rust-arboard-devel.sha256sum] = "02df42e53bb853c1a579d621f06729cafb6106a7265424f91b8250968817642c"

RDEPENDS:rust-arboard+default-devel = " \
 cargo \
 rust-arboard+image-data-devel \
 rust-arboard-devel \
 "
RDEPENDS:rust-arboard+image-data-devel = " \
 cargo \
 rust-arboard+image-devel \
 rust-arboard-devel \
 "
RDEPENDS:rust-arboard+image-devel = " \
 cargo \
 rust-arboard-devel \
 rust-image+png-devel \
 rust-image-devel \
 "
RDEPENDS:rust-arboard+wayland-data-control-devel = " \
 cargo \
 rust-arboard+wl-clipboard-rs-devel \
 rust-arboard-devel \
 "
RDEPENDS:rust-arboard+wl-clipboard-rs-devel = " \
 cargo \
 rust-arboard-devel \
 rust-wl-clipboard-rs+default-devel \
 "
RDEPENDS:rust-arboard-devel = " \
 bash \
 cargo \
 rust \
 rust-log+default-devel \
 rust-parking_lot+default-devel \
 rust-x11rb+default-devel \
 "
