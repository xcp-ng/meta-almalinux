# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-geoip2"
PV = "4.8.1"
PR = "3.el10_2"
PACKAGES = " \
 python-geoip2-doc \
 python3-geoip2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-geoip2-4.8.1-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d577a6df01c7aa648b19aaad6cf6b5bbe27e10b7c82b8684451f26e4271ad76e"

URI_x86_64_v2_python-geoip2-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-geoip2-doc-4.8.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-geoip2-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-geoip2-doc}"
SRC_URI[x86_64_v2_python-geoip2-doc.sha256sum] = "40f3ceda449891b4286448f70d253b30fc5a03362c019b61052bbda92faca892"

URI_x86_64_v2_python3-geoip2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-geoip2-4.8.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-geoip2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-geoip2}"
SRC_URI[x86_64_v2_python3-geoip2.sha256sum] = "35f8f01d9971de89322e1e30a70af6fc89a51dff52179b3545078cda4c5dbcc2"

URI_aarch64_python-geoip2-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-geoip2-doc-4.8.1-3.el10_2.noarch.rpm;name=aarch64_python-geoip2-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-geoip2-doc}"
SRC_URI[aarch64_python-geoip2-doc.sha256sum] = "4a4995e1f41677fa21a2c6ca24bb144f2aafdcd4f16f3d377f8f95657fe15032"

URI_aarch64_python3-geoip2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-geoip2-4.8.1-3.el10_2.noarch.rpm;name=aarch64_python3-geoip2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-geoip2}"
SRC_URI[aarch64_python3-geoip2.sha256sum] = "01b22d710aa03773fa651843090d3ee5332583c397327f62e42b8d44823b32fc"

RDEPENDS:python-geoip2-doc = " \
 "
RDEPENDS:python3-geoip2 = " \
 python3 \
 python3-aiohttp \
 python3-maxminddb \
 python3-requests \
 "
