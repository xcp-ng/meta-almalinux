# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lscolors"
PV = "0.20.0"
PR = "2.el10_0"
PACKAGES = " \
 lscolors \
 rust-lscolors+ansi_term-devel \
 rust-lscolors+crossterm-devel \
 rust-lscolors+default-devel \
 rust-lscolors+gnu_legacy-devel \
 rust-lscolors+nu-ansi-term-devel \
 rust-lscolors+owo-colors-devel \
 rust-lscolors-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lscolors-0.20.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "219e5575d94506f2a826d949aa3abf38dd477db2052122d70c5762c07a546ecb"

URI_x86_64_v2_lscolors = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lscolors-0.20.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lscolors;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lscolors}"
SRC_URI[x86_64_v2_lscolors.sha256sum] = "32e8f514a9eed3173175cd7f1268243f4fcb66ce20e978ad89563d884604d78d"

URI_x86_64_v2_rust-lscolors+ansi_term-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lscolors+ansi_term-devel-0.20.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lscolors+ansi_term-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lscolors+ansi_term-devel}"
SRC_URI[x86_64_v2_rust-lscolors+ansi_term-devel.sha256sum] = "becf31422ce84f02a104c72349878d18f16e589d12cbe032eff9c578ec12a037"

URI_x86_64_v2_rust-lscolors+crossterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lscolors+crossterm-devel-0.20.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lscolors+crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lscolors+crossterm-devel}"
SRC_URI[x86_64_v2_rust-lscolors+crossterm-devel.sha256sum] = "f390771e011108a9d650da5a61bb2ebd245e60cce801b56893129ffc4f4fba18"

URI_x86_64_v2_rust-lscolors+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lscolors+default-devel-0.20.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lscolors+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lscolors+default-devel}"
SRC_URI[x86_64_v2_rust-lscolors+default-devel.sha256sum] = "4af7276d9af060fcb8812a359ca1ef2734631201a48e42c9964ef4c165ac8408"

URI_x86_64_v2_rust-lscolors+gnu_legacy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lscolors+gnu_legacy-devel-0.20.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lscolors+gnu_legacy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lscolors+gnu_legacy-devel}"
SRC_URI[x86_64_v2_rust-lscolors+gnu_legacy-devel.sha256sum] = "5b047c5d1ef71d9f57a2a6972b02133b142a8c5cc9765e4ae4d3401159f739bf"

URI_x86_64_v2_rust-lscolors+nu-ansi-term-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lscolors+nu-ansi-term-devel-0.20.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lscolors+nu-ansi-term-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lscolors+nu-ansi-term-devel}"
SRC_URI[x86_64_v2_rust-lscolors+nu-ansi-term-devel.sha256sum] = "821f04f1b3ecd5585ce682e0d4b11bb4f17f287f7d8e0b8c6629c4663f20bd8b"

URI_x86_64_v2_rust-lscolors+owo-colors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lscolors+owo-colors-devel-0.20.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lscolors+owo-colors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lscolors+owo-colors-devel}"
SRC_URI[x86_64_v2_rust-lscolors+owo-colors-devel.sha256sum] = "49d07eebfb1872dc9841e3aaaf6ab37dc1554e5c3ff2475527278a6f8a5cfcd3"

URI_x86_64_v2_rust-lscolors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lscolors-devel-0.20.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lscolors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lscolors-devel}"
SRC_URI[x86_64_v2_rust-lscolors-devel.sha256sum] = "e295ced70e18cdbd589cf65986a85650adf93534ed2a88c7ab95611ebe3a3572"

URI_aarch64_lscolors = "${EPEL_MIRROR}/aarch64/Packages/l/lscolors-0.20.0-2.el10_0.aarch64.rpm;name=aarch64_lscolors;unpack=0"
SRC_URI:append = " ${URI_aarch64_lscolors}"
SRC_URI[aarch64_lscolors.sha256sum] = "8460fdb35bd5adbf965a6d6a986bab740bc7d8e7bde2e01df2beaad668f0197e"

URI_aarch64_rust-lscolors+ansi_term-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lscolors+ansi_term-devel-0.20.0-2.el10_0.noarch.rpm;name=aarch64_rust-lscolors+ansi_term-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lscolors+ansi_term-devel}"
SRC_URI[aarch64_rust-lscolors+ansi_term-devel.sha256sum] = "80a67870faf68fe45363feb857d1b1c38cd54e04936c86c212cdfb3ea1132763"

URI_aarch64_rust-lscolors+crossterm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lscolors+crossterm-devel-0.20.0-2.el10_0.noarch.rpm;name=aarch64_rust-lscolors+crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lscolors+crossterm-devel}"
SRC_URI[aarch64_rust-lscolors+crossterm-devel.sha256sum] = "81ca45787b2215d4e0b51719718ab1854282bc25e7625f9f15beeb7b6b45a951"

URI_aarch64_rust-lscolors+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lscolors+default-devel-0.20.0-2.el10_0.noarch.rpm;name=aarch64_rust-lscolors+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lscolors+default-devel}"
SRC_URI[aarch64_rust-lscolors+default-devel.sha256sum] = "ceb22f72c59e8364f77f887af58a6aa90ee27ec59bffb67e46afd45342acd76e"

URI_aarch64_rust-lscolors+gnu_legacy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lscolors+gnu_legacy-devel-0.20.0-2.el10_0.noarch.rpm;name=aarch64_rust-lscolors+gnu_legacy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lscolors+gnu_legacy-devel}"
SRC_URI[aarch64_rust-lscolors+gnu_legacy-devel.sha256sum] = "e4264dbdb727e65e70b9a6f0b2fb69042c657ec07310a12442a0d91966e367a7"

URI_aarch64_rust-lscolors+nu-ansi-term-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lscolors+nu-ansi-term-devel-0.20.0-2.el10_0.noarch.rpm;name=aarch64_rust-lscolors+nu-ansi-term-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lscolors+nu-ansi-term-devel}"
SRC_URI[aarch64_rust-lscolors+nu-ansi-term-devel.sha256sum] = "1911013a8084a92a96c505e214e091d585f15c4216177529deed4f99dfa296d5"

URI_aarch64_rust-lscolors+owo-colors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lscolors+owo-colors-devel-0.20.0-2.el10_0.noarch.rpm;name=aarch64_rust-lscolors+owo-colors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lscolors+owo-colors-devel}"
SRC_URI[aarch64_rust-lscolors+owo-colors-devel.sha256sum] = "c7b102caa80dd6e8d32f783cead77981865dcadfbe0acbbe819e4993b88f2c44"

URI_aarch64_rust-lscolors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lscolors-devel-0.20.0-2.el10_0.noarch.rpm;name=aarch64_rust-lscolors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lscolors-devel}"
SRC_URI[aarch64_rust-lscolors-devel.sha256sum] = "efe43a513c1841a97be5ed50230645d74b689ccf84c3ac16d8d6fe22f55f5dc9"

RDEPENDS:lscolors = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-lscolors+ansi_term-devel = " \
 cargo \
 rust-ansi_term+default-devel \
 rust-lscolors-devel \
 "
RDEPENDS:rust-lscolors+crossterm-devel = " \
 cargo \
 rust-crossterm+default-devel \
 rust-lscolors-devel \
 "
RDEPENDS:rust-lscolors+default-devel = " \
 cargo \
 rust-lscolors+nu-ansi-term-devel \
 rust-lscolors-devel \
 "
RDEPENDS:rust-lscolors+gnu_legacy-devel = " \
 cargo \
 rust-lscolors-devel \
 rust-nu-ansi-term+default-devel \
 rust-nu-ansi-term+gnu_legacy-devel \
 "
RDEPENDS:rust-lscolors+nu-ansi-term-devel = " \
 cargo \
 rust-lscolors-devel \
 rust-nu-ansi-term+default-devel \
 "
RDEPENDS:rust-lscolors+owo-colors-devel = " \
 cargo \
 rust-lscolors-devel \
 rust-owo-colors+default-devel \
 "
RDEPENDS:rust-lscolors-devel = " \
 cargo \
 rust \
 rust-aho-corasick+default-devel \
 "
