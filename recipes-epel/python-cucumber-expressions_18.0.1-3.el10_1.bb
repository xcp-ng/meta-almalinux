# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cucumber-expressions"
PV = "18.0.1"
PR = "3.el10_1"
PACKAGES = " \
 python3-cucumber-expressions \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cucumber-expressions-18.0.1-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad372a11f8cd8f6760afce6debaf5456b219accff2feee6aded4df1fcbe80e04"

URI_x86_64_v2_python3-cucumber-expressions = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cucumber-expressions-18.0.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cucumber-expressions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cucumber-expressions}"
SRC_URI[x86_64_v2_python3-cucumber-expressions.sha256sum] = "f36933f9b108967c5b8d3b65dc9d8d39132270fd49a58298df5ee599fb220497"

URI_aarch64_python3-cucumber-expressions = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cucumber-expressions-18.0.1-3.el10_1.noarch.rpm;name=aarch64_python3-cucumber-expressions;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cucumber-expressions}"
SRC_URI[aarch64_python3-cucumber-expressions.sha256sum] = "a727f5c22d5a157a8fffc3d25f40843b6dba36161ea510b5338b0bc9a4d58fba"

RDEPENDS:python3-cucumber-expressions = " \
 python3 \
 "
