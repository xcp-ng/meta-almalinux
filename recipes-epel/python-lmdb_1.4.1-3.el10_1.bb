# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-lmdb"
PV = "1.4.1"
PR = "3.el10_1"
PACKAGES = " \
 python3-lmdb \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-lmdb-1.4.1-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a1e03c19cffee59659fdaf84e8780774a10313d807928842a8676056a4c38354"

URI_x86_64_v2_python3-lmdb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-lmdb-1.4.1-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-lmdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lmdb}"
SRC_URI[x86_64_v2_python3-lmdb.sha256sum] = "bb22b9a532dc02e1ee94ba64a3b42602a8ecc8095661bfff58ebe5dfc3df260e"

URI_aarch64_python3-lmdb = "${EPEL_MIRROR}/aarch64/Packages/p/python3-lmdb-1.4.1-3.el10_1.aarch64.rpm;name=aarch64_python3-lmdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lmdb}"
SRC_URI[aarch64_python3-lmdb.sha256sum] = "18bd074a34c10f5de0d04fafaa4ba249f15f39d9e19e72ef650a197e3a06517c"

RDEPENDS:python3-lmdb = " \
 glibc \
 lmdb-libs \
 python3 \
 "
