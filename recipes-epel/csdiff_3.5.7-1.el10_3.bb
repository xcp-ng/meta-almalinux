# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "csdiff"
PV = "3.5.7"
PR = "1.el10_3"
PACKAGES = " \
 csdiff \
 csdiff-static \
 python3-csdiff \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/csdiff-3.5.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d3d007a92d4d390cc57146cb39d59fda888864d30fea0acb5fc278ec4202502"

URI_x86_64_v2_csdiff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csdiff-3.5.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_csdiff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csdiff}"
SRC_URI[x86_64_v2_csdiff.sha256sum] = "94c0e71f6f8a53dbe7b2904e12c6a98fd20f6556eedf889752b4d67c102d78d1"

URI_x86_64_v2_csdiff-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csdiff-static-3.5.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_csdiff-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csdiff-static}"
SRC_URI[x86_64_v2_csdiff-static.sha256sum] = "241acb24f7e8f2677fdb9b311ccb55226efd202db2a8cb2564c3e208af2c95f5"

URI_x86_64_v2_python3-csdiff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-csdiff-3.5.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-csdiff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-csdiff}"
SRC_URI[x86_64_v2_python3-csdiff.sha256sum] = "231a05c4aab8afe001fe42b114dc0e6fb4241011428d507d8636ee9248f9c9e8"

URI_aarch64_csdiff = "${EPEL_MIRROR}/aarch64/Packages/c/csdiff-3.5.7-1.el10_3.aarch64.rpm;name=aarch64_csdiff;unpack=0"
SRC_URI:append = " ${URI_aarch64_csdiff}"
SRC_URI[aarch64_csdiff.sha256sum] = "a518682d2e17531d67146a6eff88707aa59e4dd28ae7c9838ffc06bd3d2e6339"

URI_aarch64_csdiff-static = "${EPEL_MIRROR}/aarch64/Packages/c/csdiff-static-3.5.7-1.el10_3.aarch64.rpm;name=aarch64_csdiff-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_csdiff-static}"
SRC_URI[aarch64_csdiff-static.sha256sum] = "ecf3919403f064dc3dd88d68c65acf3d286aad4a8c9ac6ea71a700d00b6e1d6e"

URI_aarch64_python3-csdiff = "${EPEL_MIRROR}/aarch64/Packages/p/python3-csdiff-3.5.7-1.el10_3.aarch64.rpm;name=aarch64_python3-csdiff;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-csdiff}"
SRC_URI[aarch64_python3-csdiff.sha256sum] = "4cd33728e8848df34c1980a393b67d9ed77a3b6448bf7eea86089a788e2d0614"

RDEPENDS:csdiff = " \
 boost-filesystem \
 boost-program-options \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
RDEPENDS:csdiff-static = " \
 "
RDEPENDS:python3-csdiff = " \
 boost-filesystem \
 boost-python3 \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
