# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-krb5"
PV = "1.2.3"
PR = "1.el10_1"
PACKAGES = " \
 php-pecl-krb5 \
 php-pecl-krb5-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-krb5-1.2.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "708e1ce4476f469d71f5fb6be2e15926aea6dca42175ef2690c52c34039a3fbe"

URI_x86_64_v2_php-pecl-krb5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-krb5-1.2.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-krb5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-krb5}"
SRC_URI[x86_64_v2_php-pecl-krb5.sha256sum] = "4c022cffe1906a24789fe73b80ade2d6e5a84665db18a340b4cdf22d23ffbff1"

URI_x86_64_v2_php-pecl-krb5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-krb5-devel-1.2.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-krb5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-krb5-devel}"
SRC_URI[x86_64_v2_php-pecl-krb5-devel.sha256sum] = "0b3f0f77c659fcf054fa5c18e79f15b28a58c59eaa41e48385f65360115901c2"

URI_aarch64_php-pecl-krb5 = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-krb5-1.2.3-1.el10_1.aarch64.rpm;name=aarch64_php-pecl-krb5;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-krb5}"
SRC_URI[aarch64_php-pecl-krb5.sha256sum] = "982a14f00d6a125d1b05411811b2d986bb3cc33f9fd26b6693045a7eec653081"

URI_aarch64_php-pecl-krb5-devel = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-krb5-devel-1.2.3-1.el10_1.aarch64.rpm;name=aarch64_php-pecl-krb5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-krb5-devel}"
SRC_URI[aarch64_php-pecl-krb5-devel.sha256sum] = "bf76ae5ce2f703dbd2b9694aeab47b9f9b358ca4fe5a64478dc97f07d5be00b1"

RDEPENDS:php-pecl-krb5 = " \
 glibc \
 krb5-libs \
 libcom_err \
 libkadm5 \
 php-common \
 "
RDEPENDS:php-pecl-krb5-devel = " \
 php-devel \
 php-pecl-krb5 \
 "
