# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fwupd-efi"
PV = "1.6"
PR = "3.el10.alma.1"
PACKAGES = " \
 fwupd-efi \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/fwupd-efi-1.6-3.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92f5861a9f6dbc1e90970fa81db8581eb1a1bc4a6f909b5e29475230320c1cb7"

URI_x86_64_v2_fwupd-efi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/fwupd-efi-1.6-3.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_fwupd-efi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fwupd-efi}"
SRC_URI[x86_64_v2_fwupd-efi.sha256sum] = "16bb17c4f4af334c8d9292c58e9dff12316e01a54eb4c646bfc1a90358e68155"

URI_aarch64_fwupd-efi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/fwupd-efi-1.6-3.el10.alma.1.aarch64.rpm;name=aarch64_fwupd-efi;unpack=0"
SRC_URI:append = " ${URI_aarch64_fwupd-efi}"
SRC_URI[aarch64_fwupd-efi.sha256sum] = "5dfe53060b7729fe30d3949f60d99dca894a1a990d02804b0c7e74ef6aa1b6d6"

RDEPENDS:fwupd-efi = " \
 pkgconf-pkg-config \
 "
