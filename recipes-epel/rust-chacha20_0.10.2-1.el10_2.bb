# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-chacha20"
PV = "0.10.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-chacha20+cipher-devel \
 rust-chacha20+default-devel \
 rust-chacha20+legacy-devel \
 rust-chacha20+rng-devel \
 rust-chacha20+xchacha-devel \
 rust-chacha20+zeroize-devel \
 rust-chacha20-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-chacha20-0.10.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ea23663c0f555180d241459417759a0aa66e3bc604c9dac66b9c4fa6a1c68b84"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chacha20+cipher-devel-0.10.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chacha20+cipher-devel;unpack=0"
SRC_URI[x86_64_v2_rust-chacha20+cipher-devel.sha256sum] = "90dc0595e9931dee6d27bd2281060ccea227766f062bb33a840a05af58bff0c5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chacha20+default-devel-0.10.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chacha20+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-chacha20+default-devel.sha256sum] = "aee56246efd9ee4c0e6e23e83fc427c88a7097cc807657ce02229e7c32da2750"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chacha20+legacy-devel-0.10.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chacha20+legacy-devel;unpack=0"
SRC_URI[x86_64_v2_rust-chacha20+legacy-devel.sha256sum] = "542863278d7fb78b09ff27d9a439c21fe4c3419ac1cdab52b980d32cc2b58e12"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chacha20+rng-devel-0.10.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chacha20+rng-devel;unpack=0"
SRC_URI[x86_64_v2_rust-chacha20+rng-devel.sha256sum] = "2a919fc44bd7608ad13df2cd8595fde81129da1190607a9e858f6f8d063144da"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chacha20+xchacha-devel-0.10.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chacha20+xchacha-devel;unpack=0"
SRC_URI[x86_64_v2_rust-chacha20+xchacha-devel.sha256sum] = "dbaa607467e457e733752eca48e6fed468e1531641a25de574e58baf91d77412"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chacha20+zeroize-devel-0.10.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chacha20+zeroize-devel;unpack=0"
SRC_URI[x86_64_v2_rust-chacha20+zeroize-devel.sha256sum] = "22839a3e35f6abb73b65cd459c548178394c50205c5de75b632dfd78727b7215"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chacha20-devel-0.10.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chacha20-devel;unpack=0"
SRC_URI[x86_64_v2_rust-chacha20-devel.sha256sum] = "de91c034eed699352ebe9ecba10c4e7f274d605e8442a74d5b034041f6fc0d2a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-chacha20+cipher-devel-0.10.2-1.el10_2.noarch.rpm;name=aarch64_rust-chacha20+cipher-devel;unpack=0"
SRC_URI[aarch64_rust-chacha20+cipher-devel.sha256sum] = "e5d2c8494df5aabfc6ffa427849915d0b97c94e7ae78d1fafe03ac5b226547a8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-chacha20+default-devel-0.10.2-1.el10_2.noarch.rpm;name=aarch64_rust-chacha20+default-devel;unpack=0"
SRC_URI[aarch64_rust-chacha20+default-devel.sha256sum] = "bd80ce3e6e45721f07e5374685aa48f6aa76bd459b4e475a4a58f316b8699768"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-chacha20+legacy-devel-0.10.2-1.el10_2.noarch.rpm;name=aarch64_rust-chacha20+legacy-devel;unpack=0"
SRC_URI[aarch64_rust-chacha20+legacy-devel.sha256sum] = "09fe84699a81d32fa4d809e342ee7407c16cad64888d9a2684a1a26b56c58e55"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-chacha20+rng-devel-0.10.2-1.el10_2.noarch.rpm;name=aarch64_rust-chacha20+rng-devel;unpack=0"
SRC_URI[aarch64_rust-chacha20+rng-devel.sha256sum] = "89f6b5ec7a36ef1ae1a3707e30f3fdad6963995306b2a96fafe3516650a7a7ad"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-chacha20+xchacha-devel-0.10.2-1.el10_2.noarch.rpm;name=aarch64_rust-chacha20+xchacha-devel;unpack=0"
SRC_URI[aarch64_rust-chacha20+xchacha-devel.sha256sum] = "9980cf66fbf8e9dc24316951d132b8ae4858b3a53cb3921e5efd5d56ab511223"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-chacha20+zeroize-devel-0.10.2-1.el10_2.noarch.rpm;name=aarch64_rust-chacha20+zeroize-devel;unpack=0"
SRC_URI[aarch64_rust-chacha20+zeroize-devel.sha256sum] = "c0cb54422ae6b6c29021d9dd6d61ea775458b64ed885806760b60ed192df9b31"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-chacha20-devel-0.10.2-1.el10_2.noarch.rpm;name=aarch64_rust-chacha20-devel;unpack=0"
SRC_URI[aarch64_rust-chacha20-devel.sha256sum] = "2d791772016da21ef6b983037d13a8fe1416bec38f9b0e4e420bf7c646ae6f09"

RDEPENDS:rust-chacha20+cipher-devel = " \
 cargo \
 rust-chacha20-devel \
 rust-cipher+default-devel \
 rust-cipher+stream-wrapper-devel \
 "
RDEPENDS:rust-chacha20+default-devel = " \
 cargo \
 rust-chacha20+cipher-devel \
 rust-chacha20-devel \
 "
RDEPENDS:rust-chacha20+legacy-devel = " \
 cargo \
 rust-chacha20+cipher-devel \
 rust-chacha20-devel \
 "
RDEPENDS:rust-chacha20+rng-devel = " \
 cargo \
 rust-chacha20-devel \
 rust-rand_core-devel \
 "
RDEPENDS:rust-chacha20+xchacha-devel = " \
 cargo \
 rust-chacha20+cipher-devel \
 rust-chacha20-devel \
 "
RDEPENDS:rust-chacha20+zeroize-devel = " \
 cargo \
 rust-chacha20-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-chacha20-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-cpufeatures+default-devel \
 "
