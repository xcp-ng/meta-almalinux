# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "guestfs-tools"
PV = "1.56.0"
PR = "1.el10.alma.1"
PACKAGES = " \
 guestfs-tools \
 virt-win-reg \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/guestfs-tools-1.56.0-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f922000aad8e69cead6df8e502f52faae0f779f0721e95027516f7d9cd5d53f3"

URI_x86_64_v2_guestfs-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/guestfs-tools-1.56.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_guestfs-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_guestfs-tools}"
SRC_URI[x86_64_v2_guestfs-tools.sha256sum] = "6a25e31547c7b046d041edf18e3be521b09ed05d0c29439c47046f8ea116f979"

URI_x86_64_v2_virt-win-reg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/virt-win-reg-1.56.0-1.el10.alma.1.noarch.rpm;name=x86_64_v2_virt-win-reg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virt-win-reg}"
SRC_URI[x86_64_v2_virt-win-reg.sha256sum] = "531b1013a983136961564f3e88c7f2c982ac73931954c237c9812c25eab45f7e"

URI_aarch64_guestfs-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/guestfs-tools-1.56.0-1.el10.alma.1.aarch64.rpm;name=aarch64_guestfs-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_guestfs-tools}"
SRC_URI[aarch64_guestfs-tools.sha256sum] = "6ada57e89f1b2b405c8fb29051d2f7655bbb7d5b7dc0d0d0d3423c9c64769bbe"

URI_aarch64_virt-win-reg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/virt-win-reg-1.56.0-1.el10.alma.1.noarch.rpm;name=aarch64_virt-win-reg;unpack=0"
SRC_URI:append = " ${URI_aarch64_virt-win-reg}"
SRC_URI[aarch64_virt-win-reg.sha256sum] = "531b1013a983136961564f3e88c7f2c982ac73931954c237c9812c25eab45f7e"

RDEPENDS:guestfs-tools = " \
 curl \
 glib2 \
 glibc \
 gnupg2 \
 json-c \
 libgcc \
 libguestfs \
 libosinfo \
 libvirt-libs \
 libxcrypt \
 libxml2 \
 ncurses-libs \
 pcre2 \
 qemu-img \
 xz \
 xz-libs \
 "
RDEPENDS:virt-win-reg = " \
 perl-File-Basename \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-Pod-Usage \
 perl-Sys-Guestfs \
 perl-hivex \
 perl-interpreter \
 perl-libintl-perl \
 perl-libs \
 "
