# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-apprise"
PV = "1.9.7"
PR = "1.el10_2"
PACKAGES = " \
 apprise \
 python3-apprise \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-apprise-1.9.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "672f1da016b0d02b3618098e672cc030b4cc039e0f8091b996d2228ebbc4f49b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apprise-1.9.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_apprise;unpack=0"
SRC_URI[x86_64_v2_apprise.sha256sum] = "e2d0ed782e1f7bd28faa1cea660e11bba2d7ec5066a3489b33132559cdd58605"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-apprise-1.9.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-apprise;unpack=0"
SRC_URI[x86_64_v2_python3-apprise.sha256sum] = "bd4e97cf92d57586c1789fd21bdf750fca75ccc717761fb44d3646d2e95f273c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/apprise-1.9.7-1.el10_2.noarch.rpm;name=aarch64_apprise;unpack=0"
SRC_URI[aarch64_apprise.sha256sum] = "fab52b4f1c71666b6645869198265bcc9093b3fff9fe10479b2c8b7cf09e585d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-apprise-1.9.7-1.el10_2.noarch.rpm;name=aarch64_python3-apprise;unpack=0"
SRC_URI[aarch64_python3-apprise.sha256sum] = "d8608bd3cdb4fadeb58c27dc92f1f2fe0edee082222e9e7e4ad939b553826404"

RDEPENDS:apprise = " \
 python3 \
 python3-apprise \
 python3-click \
 "
RDEPENDS:python3-apprise = " \
 python3 \
 python3-certifi \
 python3-click \
 python3-cryptography \
 python3-markdown \
 python3-pyyaml \
 python3-requests \
 python3-requests-oauthlib \
 "
