# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ouroboros"
PV = "0.18.5"
PR = "1.el10_1"
PACKAGES = " \
 rust-ouroboros+default-devel \
 rust-ouroboros+std-devel \
 rust-ouroboros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ouroboros-0.18.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52278133cd220c67b3a9bec90d54a393f0dc975125c0a71043b020fca387ae0f"

URI_x86_64_v2_rust-ouroboros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ouroboros+default-devel-0.18.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ouroboros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ouroboros+default-devel}"
SRC_URI[x86_64_v2_rust-ouroboros+default-devel.sha256sum] = "8c1750ae17f751729407aa27b92d314902a90caadd37859080a17fb845d06d83"

URI_x86_64_v2_rust-ouroboros+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ouroboros+std-devel-0.18.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ouroboros+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ouroboros+std-devel}"
SRC_URI[x86_64_v2_rust-ouroboros+std-devel.sha256sum] = "8af73b767193bfb8d77d1713079c89ab631f6a660ed75c8d33158113369ee0c0"

URI_x86_64_v2_rust-ouroboros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ouroboros-devel-0.18.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ouroboros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ouroboros-devel}"
SRC_URI[x86_64_v2_rust-ouroboros-devel.sha256sum] = "f747a869c1cf7660f973d8515f12d5614ef5a2fa8e8112c77d4b11f613887ccc"

URI_aarch64_rust-ouroboros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ouroboros+default-devel-0.18.5-1.el10_1.noarch.rpm;name=aarch64_rust-ouroboros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ouroboros+default-devel}"
SRC_URI[aarch64_rust-ouroboros+default-devel.sha256sum] = "6ed97177266faf4171f42f86b14e60f1a57ff762518ecfda7b741c6c3327ad09"

URI_aarch64_rust-ouroboros+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ouroboros+std-devel-0.18.5-1.el10_1.noarch.rpm;name=aarch64_rust-ouroboros+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ouroboros+std-devel}"
SRC_URI[aarch64_rust-ouroboros+std-devel.sha256sum] = "47a26b6f90a0c182c46d87ec6e2b78f5c721d6ae5058c10008902d854b2695e2"

URI_aarch64_rust-ouroboros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ouroboros-devel-0.18.5-1.el10_1.noarch.rpm;name=aarch64_rust-ouroboros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ouroboros-devel}"
SRC_URI[aarch64_rust-ouroboros-devel.sha256sum] = "0ed7061d8c9c8e968566a0e0dea4e19d21d43dc98a46f60151f1956da1667580"

RDEPENDS:rust-ouroboros+default-devel = " \
 cargo \
 rust-ouroboros+std-devel \
 rust-ouroboros-devel \
 "
RDEPENDS:rust-ouroboros+std-devel = " \
 cargo \
 rust-ouroboros-devel \
 rust-ouroboros_macro+std-devel \
 "
RDEPENDS:rust-ouroboros-devel = " \
 cargo \
 rust-aliasable+default-devel \
 rust-ouroboros_macro+default-devel \
 rust-static_assertions+default-devel \
 "
