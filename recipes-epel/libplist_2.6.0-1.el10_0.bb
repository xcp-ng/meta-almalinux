# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libplist"
PV = "2.6.0"
PR = "1.el10_0"
PACKAGES = " \
 libplist \
 libplist-devel \
 python3-libplist \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libplist-2.6.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8ea34a0f4442f699ba4f2bc4c66d6c1a710cfc4672efa9de4e549bc92f408779"

URI_x86_64_v2_libplist = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libplist-2.6.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libplist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libplist}"
SRC_URI[x86_64_v2_libplist.sha256sum] = "7177cce65b9b3249ebaa4cc310a9cf41ab345dad75a2c2c901bb86101948b485"

URI_x86_64_v2_libplist-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libplist-devel-2.6.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libplist-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libplist-devel}"
SRC_URI[x86_64_v2_libplist-devel.sha256sum] = "1f404d57899ce1a9f4cf41706c4c92e2a0b97bcb8e5fb6d4b8f2c6f6937a7a0c"

URI_x86_64_v2_python3-libplist = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-libplist-2.6.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-libplist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libplist}"
SRC_URI[x86_64_v2_python3-libplist.sha256sum] = "68f4dd23880ad232fb9477f074426e4c1111977724231fb062a0c938541f43fb"

URI_aarch64_libplist = "${EPEL_MIRROR}/aarch64/Packages/l/libplist-2.6.0-1.el10_0.aarch64.rpm;name=aarch64_libplist;unpack=0"
SRC_URI:append = " ${URI_aarch64_libplist}"
SRC_URI[aarch64_libplist.sha256sum] = "f8a57513dc84bc5782de6e0769448a15982091be88ea0ee37df8aabd9afb7e69"

URI_aarch64_libplist-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libplist-devel-2.6.0-1.el10_0.aarch64.rpm;name=aarch64_libplist-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libplist-devel}"
SRC_URI[aarch64_libplist-devel.sha256sum] = "5ced7c42f1b91b8aa1dbc35e0917d50a0829a19e9edebe014a1876cbbb1ebf0a"

URI_aarch64_python3-libplist = "${EPEL_MIRROR}/aarch64/Packages/p/python3-libplist-2.6.0-1.el10_0.aarch64.rpm;name=aarch64_python3-libplist;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libplist}"
SRC_URI[aarch64_python3-libplist.sha256sum] = "d9a1f06703877d1636fdc1bb41c554f4ba61e876076ff3090a80de4898a47cc8"

RDEPENDS:libplist = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libplist-devel = " \
 libplist \
 libplist-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-libplist = " \
 glibc \
 libplist \
 python3 \
 python3-libs \
 "
