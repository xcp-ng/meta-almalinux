# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-which"
PV = "8.0.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-which+default-devel \
 rust-which+real-sys-devel \
 rust-which+regex-devel \
 rust-which+tracing-devel \
 rust-which-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-which-8.0.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dbcea8cff358dd8cc03f22a5c3f14458c867451302c616c9c00f23f9dd2e6380"

URI_x86_64_v2_rust-which+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-which+default-devel-8.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-which+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-which+default-devel}"
SRC_URI[x86_64_v2_rust-which+default-devel.sha256sum] = "7a9faf02fde6a9f174fecf997d7b06fd671da4012d1774ed01c5f2430fd1cd48"

URI_x86_64_v2_rust-which+real-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-which+real-sys-devel-8.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-which+real-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-which+real-sys-devel}"
SRC_URI[x86_64_v2_rust-which+real-sys-devel.sha256sum] = "a03664635d0bd91f063eb9c12c218815af9f515cf3fac83e5e6d172a0a56952f"

URI_x86_64_v2_rust-which+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-which+regex-devel-8.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-which+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-which+regex-devel}"
SRC_URI[x86_64_v2_rust-which+regex-devel.sha256sum] = "c97be9ec7cb0841ae8177e5a4d463563d872c9de809c5ec63c941837e50c092f"

URI_x86_64_v2_rust-which+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-which+tracing-devel-8.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-which+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-which+tracing-devel}"
SRC_URI[x86_64_v2_rust-which+tracing-devel.sha256sum] = "264a4744e53104bc9fd07afafad8de5247cbb7a8c63f793873b4a32bff11c607"

URI_x86_64_v2_rust-which-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-which-devel-8.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-which-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-which-devel}"
SRC_URI[x86_64_v2_rust-which-devel.sha256sum] = "2989ab6826a6237d37aaec45ea8a2e0800b9ef5e0d950c2baefab5ddd107bf67"

URI_aarch64_rust-which+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-which+default-devel-8.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-which+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-which+default-devel}"
SRC_URI[aarch64_rust-which+default-devel.sha256sum] = "7f858306f741a05eed3e2dc8e142afc36c042f6ee7720baa277488a0b2d2945f"

URI_aarch64_rust-which+real-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-which+real-sys-devel-8.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-which+real-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-which+real-sys-devel}"
SRC_URI[aarch64_rust-which+real-sys-devel.sha256sum] = "22a7766774a0a529fc84f3114f0a9780bb19d168fa619f73a15407157a09c9c6"

URI_aarch64_rust-which+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-which+regex-devel-8.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-which+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-which+regex-devel}"
SRC_URI[aarch64_rust-which+regex-devel.sha256sum] = "3b5b870e41dbe96630990a76ad5dd2566155a3d896b8e7a6f55dfd50d8e2196a"

URI_aarch64_rust-which+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-which+tracing-devel-8.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-which+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-which+tracing-devel}"
SRC_URI[aarch64_rust-which+tracing-devel.sha256sum] = "0c5a92f703e95bbeec90fdb67df99a734524c80edc72db11d54d4713e12f826f"

URI_aarch64_rust-which-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-which-devel-8.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-which-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-which-devel}"
SRC_URI[aarch64_rust-which-devel.sha256sum] = "487b2fec0cf42dbab5d6a6371164e5bea15442a71d17513c4e8b53c3f7ba5d37"

RDEPENDS:rust-which+default-devel = " \
 cargo \
 rust-which+real-sys-devel \
 rust-which-devel \
 "
RDEPENDS:rust-which+real-sys-devel = " \
 cargo \
 rust-env_home+default-devel \
 rust-rustix+fs-devel \
 rust-rustix+std-devel \
 rust-rustix-devel \
 rust-which-devel \
 "
RDEPENDS:rust-which+regex-devel = " \
 cargo \
 rust-regex+default-devel \
 rust-which-devel \
 "
RDEPENDS:rust-which+tracing-devel = " \
 cargo \
 rust-tracing-devel \
 rust-which-devel \
 "
RDEPENDS:rust-which-devel = " \
 cargo \
 rust \
 "
