# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "google-auth-httplib2"
PV = "0.3.0"
PR = "2.el10_2"
PACKAGES = " \
 python3-google-auth-httplib2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/google-auth-httplib2-0.3.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fecb02e9c8a3bc52131e26853868265e1054007d0fa59c9901656659434d6a51"

URI_x86_64_v2_python3-google-auth-httplib2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-auth-httplib2-0.3.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-auth-httplib2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-auth-httplib2}"
SRC_URI[x86_64_v2_python3-google-auth-httplib2.sha256sum] = "5e27a10fba6ab5ee7afde6a03e8951b4d29db289ab3492da5a618cd694ebb1a0"

URI_aarch64_python3-google-auth-httplib2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-auth-httplib2-0.3.0-2.el10_2.noarch.rpm;name=aarch64_python3-google-auth-httplib2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-auth-httplib2}"
SRC_URI[aarch64_python3-google-auth-httplib2.sha256sum] = "0fa290caa790289ed9e64a940213ed8c61eabab3e4ab4909ea0bada5d2d1f104"

RDEPENDS:python3-google-auth-httplib2 = " \
 python3 \
 python3-google-auth \
 python3-httplib2 \
 "
