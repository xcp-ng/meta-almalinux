# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kbrickbuster"
PV = "25.08.0"
PR = "1.el10_1"
PACKAGES = " \
 kbrickbuster \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kbrickbuster-25.08.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c45bc885a421cdfd0dd61806945f9b8ffbf9598d723d32c01d29e1ea455cc62"

URI_x86_64_v2_kbrickbuster = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kbrickbuster-25.08.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kbrickbuster;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kbrickbuster}"
SRC_URI[x86_64_v2_kbrickbuster.sha256sum] = "ea8c426b89ab23197a407e8a8ab71593342c74e71fa6c9d597a97314224f066b"

URI_aarch64_kbrickbuster = "${EPEL_MIRROR}/aarch64/Packages/k/kbrickbuster-25.08.0-1.el10_1.aarch64.rpm;name=aarch64_kbrickbuster;unpack=0"
SRC_URI:append = " ${URI_aarch64_kbrickbuster}"
SRC_URI[aarch64_kbrickbuster.sha256sum] = "3ff977048485cfe1e4fb54cda362fa1438f8b16f68a733efda5108c714ac8f5d"

RDEPENDS:kbrickbuster = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
