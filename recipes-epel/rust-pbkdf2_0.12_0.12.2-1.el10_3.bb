# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pbkdf2_0.12"
PV = "0.12.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-pbkdf2_0.12+default-devel \
 rust-pbkdf2_0.12+hmac-devel \
 rust-pbkdf2_0.12+parallel-devel \
 rust-pbkdf2_0.12+password-hash-devel \
 rust-pbkdf2_0.12+rayon-devel \
 rust-pbkdf2_0.12+sha1-devel \
 rust-pbkdf2_0.12+sha2-devel \
 rust-pbkdf2_0.12+simple-devel \
 rust-pbkdf2_0.12+std-devel \
 rust-pbkdf2_0.12-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pbkdf2_0.12-0.12.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2eacc15ca231c25848230ca9c5128512e5ce601165fcdd5f566034daa18fca24"

URI_x86_64_v2_rust-pbkdf2_0.12+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2_0.12+default-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2_0.12+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pbkdf2_0.12+default-devel}"
SRC_URI[x86_64_v2_rust-pbkdf2_0.12+default-devel.sha256sum] = "7a081413c48b1c687f561e4b8da49203e9b1c4ea16f91639fa85e16d1bf91fdb"

URI_x86_64_v2_rust-pbkdf2_0.12+hmac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2_0.12+hmac-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2_0.12+hmac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pbkdf2_0.12+hmac-devel}"
SRC_URI[x86_64_v2_rust-pbkdf2_0.12+hmac-devel.sha256sum] = "f87b934a15a7d1eb490b5c083b3e5b3e8bd3422b8fe2f0f1a60d5dc11e264b08"

URI_x86_64_v2_rust-pbkdf2_0.12+parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2_0.12+parallel-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2_0.12+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pbkdf2_0.12+parallel-devel}"
SRC_URI[x86_64_v2_rust-pbkdf2_0.12+parallel-devel.sha256sum] = "d90fba75d53d34e0cbe432df973093220a9bca5c647868079d4eae6595687fd0"

URI_x86_64_v2_rust-pbkdf2_0.12+password-hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2_0.12+password-hash-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2_0.12+password-hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pbkdf2_0.12+password-hash-devel}"
SRC_URI[x86_64_v2_rust-pbkdf2_0.12+password-hash-devel.sha256sum] = "653417ffb27ea8dafe905a8702de7deaff6793936003345dcfda498ee17633da"

URI_x86_64_v2_rust-pbkdf2_0.12+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2_0.12+rayon-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2_0.12+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pbkdf2_0.12+rayon-devel}"
SRC_URI[x86_64_v2_rust-pbkdf2_0.12+rayon-devel.sha256sum] = "737d3cdfe6cbe28596ea044d2ca553cda50fafff8977bad9c7570a2d43fae507"

URI_x86_64_v2_rust-pbkdf2_0.12+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2_0.12+sha1-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2_0.12+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pbkdf2_0.12+sha1-devel}"
SRC_URI[x86_64_v2_rust-pbkdf2_0.12+sha1-devel.sha256sum] = "c974b0755a7e47f4eee1ecdd5a59e0405d2b42c6552103476b79412ea4cc0093"

URI_x86_64_v2_rust-pbkdf2_0.12+sha2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2_0.12+sha2-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2_0.12+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pbkdf2_0.12+sha2-devel}"
SRC_URI[x86_64_v2_rust-pbkdf2_0.12+sha2-devel.sha256sum] = "2e22d3c3750f906e37bb60b6eb4d24b52a365c84140587dca2a5a959e4bac192"

URI_x86_64_v2_rust-pbkdf2_0.12+simple-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2_0.12+simple-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2_0.12+simple-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pbkdf2_0.12+simple-devel}"
SRC_URI[x86_64_v2_rust-pbkdf2_0.12+simple-devel.sha256sum] = "f548bb7ac0dbd2721918ba16886c62f8a54dba8382debc1ed8ae5eae1c35b7b3"

URI_x86_64_v2_rust-pbkdf2_0.12+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2_0.12+std-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2_0.12+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pbkdf2_0.12+std-devel}"
SRC_URI[x86_64_v2_rust-pbkdf2_0.12+std-devel.sha256sum] = "e13221c0bd21ec20b888944d682bd1c9921c75005499ad36149248b80016785d"

URI_x86_64_v2_rust-pbkdf2_0.12-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2_0.12-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2_0.12-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pbkdf2_0.12-devel}"
SRC_URI[x86_64_v2_rust-pbkdf2_0.12-devel.sha256sum] = "13bb8025c6d15b12b4ffcdf1d328a4865c712c358c45449ce61874073b43e738"

URI_aarch64_rust-pbkdf2_0.12+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2_0.12+default-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-pbkdf2_0.12+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pbkdf2_0.12+default-devel}"
SRC_URI[aarch64_rust-pbkdf2_0.12+default-devel.sha256sum] = "d2417906555b10875e813a7d1e97128d61d03609f512500a599f61f237766eac"

URI_aarch64_rust-pbkdf2_0.12+hmac-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2_0.12+hmac-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-pbkdf2_0.12+hmac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pbkdf2_0.12+hmac-devel}"
SRC_URI[aarch64_rust-pbkdf2_0.12+hmac-devel.sha256sum] = "af3ce24b5d2dc0d79c125d42f40de1315adb8ca288b1200ab07d888095faff14"

URI_aarch64_rust-pbkdf2_0.12+parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2_0.12+parallel-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-pbkdf2_0.12+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pbkdf2_0.12+parallel-devel}"
SRC_URI[aarch64_rust-pbkdf2_0.12+parallel-devel.sha256sum] = "0ff1368fff3a53acae932c46e6ba926947071e29f268e5f15d364773fd4247bb"

URI_aarch64_rust-pbkdf2_0.12+password-hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2_0.12+password-hash-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-pbkdf2_0.12+password-hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pbkdf2_0.12+password-hash-devel}"
SRC_URI[aarch64_rust-pbkdf2_0.12+password-hash-devel.sha256sum] = "0483a26d96692e6e6299f36bc7e4eb9529d2cdef4c5e63a6a67d09def62c8a21"

URI_aarch64_rust-pbkdf2_0.12+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2_0.12+rayon-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-pbkdf2_0.12+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pbkdf2_0.12+rayon-devel}"
SRC_URI[aarch64_rust-pbkdf2_0.12+rayon-devel.sha256sum] = "9d60a4d9d3c73faa8af14544043342ac2d32cb8d5c531b33ee0aa5fa82a79058"

URI_aarch64_rust-pbkdf2_0.12+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2_0.12+sha1-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-pbkdf2_0.12+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pbkdf2_0.12+sha1-devel}"
SRC_URI[aarch64_rust-pbkdf2_0.12+sha1-devel.sha256sum] = "052137ebc56460e21c017737284b17a835cefc94a1ae562581dc5289c4c39efb"

URI_aarch64_rust-pbkdf2_0.12+sha2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2_0.12+sha2-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-pbkdf2_0.12+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pbkdf2_0.12+sha2-devel}"
SRC_URI[aarch64_rust-pbkdf2_0.12+sha2-devel.sha256sum] = "1f0e11166831e40c92e8bee7a71919224e5b96daf125ca5365a71fc29cf8e0fa"

URI_aarch64_rust-pbkdf2_0.12+simple-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2_0.12+simple-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-pbkdf2_0.12+simple-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pbkdf2_0.12+simple-devel}"
SRC_URI[aarch64_rust-pbkdf2_0.12+simple-devel.sha256sum] = "aec0363e0f75e633dab69cd72703d288bdefb71bce1a2d989d47f624c800c035"

URI_aarch64_rust-pbkdf2_0.12+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2_0.12+std-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-pbkdf2_0.12+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pbkdf2_0.12+std-devel}"
SRC_URI[aarch64_rust-pbkdf2_0.12+std-devel.sha256sum] = "13c7bfc0dd797a85bd3387ab5301abca1580b1b28fdbf664a07c16eab61bbad3"

URI_aarch64_rust-pbkdf2_0.12-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2_0.12-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-pbkdf2_0.12-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pbkdf2_0.12-devel}"
SRC_URI[aarch64_rust-pbkdf2_0.12-devel.sha256sum] = "36056c042e98a295c2e275a1fe03575ac54827c0faa8de1482f9227ef1813aa7"

RDEPENDS:rust-pbkdf2_0.12+default-devel = " \
 cargo \
 rust-pbkdf2_0.12+hmac-devel \
 rust-pbkdf2_0.12-devel \
 "
RDEPENDS:rust-pbkdf2_0.12+hmac-devel = " \
 cargo \
 rust-hmac0.12-devel \
 rust-pbkdf2_0.12-devel \
 "
RDEPENDS:rust-pbkdf2_0.12+parallel-devel = " \
 cargo \
 rust-pbkdf2_0.12+rayon-devel \
 rust-pbkdf2_0.12+std-devel \
 rust-pbkdf2_0.12-devel \
 "
RDEPENDS:rust-pbkdf2_0.12+password-hash-devel = " \
 cargo \
 rust-password-hash0.5+rand_core-devel \
 rust-password-hash0.5-devel \
 rust-pbkdf2_0.12-devel \
 "
RDEPENDS:rust-pbkdf2_0.12+rayon-devel = " \
 cargo \
 rust-pbkdf2_0.12-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-pbkdf2_0.12+sha1-devel = " \
 cargo \
 rust-pbkdf2_0.12-devel \
 rust-sha1_0.10-devel \
 "
RDEPENDS:rust-pbkdf2_0.12+sha2-devel = " \
 cargo \
 rust-pbkdf2_0.12-devel \
 rust-sha2_0.10-devel \
 "
RDEPENDS:rust-pbkdf2_0.12+simple-devel = " \
 cargo \
 rust-pbkdf2_0.12+hmac-devel \
 rust-pbkdf2_0.12+password-hash-devel \
 rust-pbkdf2_0.12+sha2-devel \
 rust-pbkdf2_0.12-devel \
 "
RDEPENDS:rust-pbkdf2_0.12+std-devel = " \
 cargo \
 rust-password-hash0.5+rand_core-devel \
 rust-password-hash0.5+std-devel \
 rust-password-hash0.5-devel \
 rust-pbkdf2_0.12-devel \
 "
RDEPENDS:rust-pbkdf2_0.12-devel = " \
 cargo \
 rust \
 rust-digest0.10+default-devel \
 rust-digest0.10+mac-devel \
 "
