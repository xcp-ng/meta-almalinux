# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmediainfo"
PV = "25.07"
PR = "1.el10_2"
PACKAGES = " \
 libmediainfo \
 libmediainfo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libmediainfo-25.07-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d3328a7ac2995de32fa6a9fba13a52e2b9ca5e9ea54c010b6259965a4c5b62f"

URI_x86_64_v2_libmediainfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmediainfo-25.07-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmediainfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmediainfo}"
SRC_URI[x86_64_v2_libmediainfo.sha256sum] = "260d0f78de2f696e19815f714165de5b686fb137b6c5ea3adc85d43b9436090a"

URI_x86_64_v2_libmediainfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmediainfo-devel-25.07-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmediainfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmediainfo-devel}"
SRC_URI[x86_64_v2_libmediainfo-devel.sha256sum] = "efdf5349790d9ca6bd20c267a24b6a84f808b6fee522b9fb3b1a158d5ef58024"

URI_aarch64_libmediainfo = "${EPEL_MIRROR}/aarch64/Packages/l/libmediainfo-25.07-1.el10_2.aarch64.rpm;name=aarch64_libmediainfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmediainfo}"
SRC_URI[aarch64_libmediainfo.sha256sum] = "a75ae99ef71b91a3ac3ade80e405db0c98c010ed4a662c7e2d5a49c4ff77b03c"

URI_aarch64_libmediainfo-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libmediainfo-devel-25.07-1.el10_2.aarch64.rpm;name=aarch64_libmediainfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmediainfo-devel}"
SRC_URI[aarch64_libmediainfo-devel.sha256sum] = "05b38385e2903e106f6eea1a012c6ca0920b283b1400b7fd44ea1d4fdd72a0e2"

RDEPENDS:libmediainfo = " \
 glibc \
 libgcc \
 libstdc++ \
 libzen \
 tinyxml2 \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:libmediainfo-devel = " \
 cmake-filesystem \
 libcurl-devel \
 libmediainfo \
 libzen-devel \
 pkgconf-pkg-config \
 "
