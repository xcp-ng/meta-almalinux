# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-protocol"
PV = "0.63.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-protocol+async-client-devel \
 rust-gix-protocol+blocking-client-devel \
 rust-gix-protocol+default-devel \
 rust-gix-protocol+document-features-devel \
 rust-gix-protocol+fetch-devel \
 rust-gix-protocol+futures-lite-devel \
 rust-gix-protocol+handshake-devel \
 rust-gix-protocol+serde-devel \
 rust-gix-protocol+sha1-devel \
 rust-gix-protocol+sha256-devel \
 rust-gix-protocol-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-protocol-0.63.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87cfb0375099db32c285e9cad183ac61545cfdfed04ef8a99b8effa42052eada"

URI_x86_64_v2_rust-gix-protocol+async-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol+async-client-devel-0.63.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol+async-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol+async-client-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol+async-client-devel.sha256sum] = "f7a90d7d613e2958745ea45c22314068bb1a6f025811cf307e063fd3e6c5d146"

URI_x86_64_v2_rust-gix-protocol+blocking-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol+blocking-client-devel-0.63.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol+blocking-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol+blocking-client-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol+blocking-client-devel.sha256sum] = "e520d8fd58f010cfd60843ce543b5cc70b136e75aba21a35db62ade970244f98"

URI_x86_64_v2_rust-gix-protocol+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol+default-devel-0.63.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol+default-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol+default-devel.sha256sum] = "b90f6113f6f9d0812a449faddc1c396a4bc2ec3f1e4545fadbe669edab437674"

URI_x86_64_v2_rust-gix-protocol+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol+document-features-devel-0.63.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol+document-features-devel.sha256sum] = "67f8320d74b962f2d713091612f60379b77a0bd028f54d0abd94e6acd4e36bce"

URI_x86_64_v2_rust-gix-protocol+fetch-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol+fetch-devel-0.63.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol+fetch-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol+fetch-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol+fetch-devel.sha256sum] = "be8dc42bc58bbe733b2c7b52eaf6154e58e4450a94e06639f6022ca0b1e99217"

URI_x86_64_v2_rust-gix-protocol+futures-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol+futures-lite-devel-0.63.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol+futures-lite-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol+futures-lite-devel.sha256sum] = "d61a450cd1b4bcecc381d4b9248e0a67927288e3737837401f2711654e46fc6a"

URI_x86_64_v2_rust-gix-protocol+handshake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol+handshake-devel-0.63.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol+handshake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol+handshake-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol+handshake-devel.sha256sum] = "1bf39560f371577986839f7cbc0337d40a6d396290d149d3b1c4e1fea9597c20"

URI_x86_64_v2_rust-gix-protocol+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol+serde-devel-0.63.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol+serde-devel.sha256sum] = "ee35e5abb2bc2790b203031f59ad0777608b82e1091a15ddf6a8f5433966adc6"

URI_x86_64_v2_rust-gix-protocol+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol+sha1-devel-0.63.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol+sha1-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol+sha1-devel.sha256sum] = "2f444da4caa4d66c5595b11cb72e81254d46db45ccfa88618f2277c32e767398"

URI_x86_64_v2_rust-gix-protocol+sha256-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol+sha256-devel-0.63.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol+sha256-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol+sha256-devel.sha256sum] = "db223eaaf71de96866d9ca2d4844a0229f1cab0edc60b4bb0b89c8b97ed65604"

URI_x86_64_v2_rust-gix-protocol-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol-devel-0.63.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol-devel.sha256sum] = "40f4e5bc44066a39e2cb9b46e3fffbc4a0870d2932db61b7c86762f6bc7dfa87"

URI_aarch64_rust-gix-protocol+async-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol+async-client-devel-0.63.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-protocol+async-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol+async-client-devel}"
SRC_URI[aarch64_rust-gix-protocol+async-client-devel.sha256sum] = "ba5df3e21f56b6bf3710e21f465007caa4faff8aedfee0dc877b75fa16d702de"

URI_aarch64_rust-gix-protocol+blocking-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol+blocking-client-devel-0.63.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-protocol+blocking-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol+blocking-client-devel}"
SRC_URI[aarch64_rust-gix-protocol+blocking-client-devel.sha256sum] = "1c63bc4d007f34d9731b30c38d9c35cb66108eb52585fec41841a02fb2d3b977"

URI_aarch64_rust-gix-protocol+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol+default-devel-0.63.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-protocol+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol+default-devel}"
SRC_URI[aarch64_rust-gix-protocol+default-devel.sha256sum] = "283589c416662bd6568cf2836c810d7b035a7bcd39aa958ef582b8eec6429f19"

URI_aarch64_rust-gix-protocol+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol+document-features-devel-0.63.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-protocol+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol+document-features-devel}"
SRC_URI[aarch64_rust-gix-protocol+document-features-devel.sha256sum] = "c12e519802778e3b6b4aab02de2aed5a278dd42f172b1640f46c7bc434686010"

URI_aarch64_rust-gix-protocol+fetch-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol+fetch-devel-0.63.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-protocol+fetch-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol+fetch-devel}"
SRC_URI[aarch64_rust-gix-protocol+fetch-devel.sha256sum] = "c58051be6bf0a4c0ef3e68d335c99bb826da31ae59bb48de33e474fc86190e77"

URI_aarch64_rust-gix-protocol+futures-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol+futures-lite-devel-0.63.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-protocol+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol+futures-lite-devel}"
SRC_URI[aarch64_rust-gix-protocol+futures-lite-devel.sha256sum] = "361fda89d6f65bee489291a65a78d089b25443d5db5975428c52e4563714aa3d"

URI_aarch64_rust-gix-protocol+handshake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol+handshake-devel-0.63.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-protocol+handshake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol+handshake-devel}"
SRC_URI[aarch64_rust-gix-protocol+handshake-devel.sha256sum] = "2de596b5f4266b53d5f6e7183202bf9e528342149d003b9d44cb1a1727e41649"

URI_aarch64_rust-gix-protocol+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol+serde-devel-0.63.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-protocol+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol+serde-devel}"
SRC_URI[aarch64_rust-gix-protocol+serde-devel.sha256sum] = "70d115b57f952bf1260f1c7c6026c7d55ba965af7f56698c33442c295aad1f9c"

URI_aarch64_rust-gix-protocol+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol+sha1-devel-0.63.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-protocol+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol+sha1-devel}"
SRC_URI[aarch64_rust-gix-protocol+sha1-devel.sha256sum] = "439f46e8524e5e080e22bdfd829e6bc7e3c816c3be06f39486a5f202d40f7f3f"

URI_aarch64_rust-gix-protocol+sha256-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol+sha256-devel-0.63.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-protocol+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol+sha256-devel}"
SRC_URI[aarch64_rust-gix-protocol+sha256-devel.sha256sum] = "7e1385646d276e4a9f80a08a818b573b5b66c0e2ccb96c8ea368be9947382e0c"

URI_aarch64_rust-gix-protocol-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol-devel-0.63.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-protocol-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol-devel}"
SRC_URI[aarch64_rust-gix-protocol-devel.sha256sum] = "2bb6c15f4451d49c7e456d8c7d93d86abd688cc4cf6ab9625e5bc32e0911dbf6"

RDEPENDS:rust-gix-protocol+async-client-devel = " \
 cargo \
 rust-async-trait+default-devel \
 rust-futures-io+default-devel \
 rust-gix-protocol+fetch-devel \
 rust-gix-protocol+futures-lite-devel \
 rust-gix-protocol+handshake-devel \
 rust-gix-protocol-devel \
 rust-gix-transport+async-client-devel \
 "
RDEPENDS:rust-gix-protocol+blocking-client-devel = " \
 cargo \
 rust-gix-protocol+fetch-devel \
 rust-gix-protocol+handshake-devel \
 rust-gix-protocol-devel \
 rust-gix-transport+blocking-client-devel \
 rust-maybe-async+is_sync-devel \
 "
RDEPENDS:rust-gix-protocol+default-devel = " \
 cargo \
 rust-gix-protocol-devel \
 "
RDEPENDS:rust-gix-protocol+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-protocol-devel \
 "
RDEPENDS:rust-gix-protocol+fetch-devel = " \
 cargo \
 rust-gix-lock+default-devel \
 rust-gix-negotiate+default-devel \
 rust-gix-object+default-devel \
 rust-gix-protocol-devel \
 rust-gix-refspec+default-devel \
 rust-gix-revwalk+default-devel \
 rust-gix-trace+default-devel \
 "
RDEPENDS:rust-gix-protocol+futures-lite-devel = " \
 cargo \
 rust-futures-lite+default-devel \
 rust-gix-protocol-devel \
 "
RDEPENDS:rust-gix-protocol+handshake-devel = " \
 cargo \
 rust-gix-credentials+default-devel \
 rust-gix-protocol-devel \
 "
RDEPENDS:rust-gix-protocol+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-hash+serde-devel \
 rust-gix-protocol-devel \
 rust-gix-shallow+serde-devel \
 rust-gix-transport+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-protocol+sha1-devel = " \
 cargo \
 rust-gix-hash+sha1-devel \
 rust-gix-protocol-devel \
 "
RDEPENDS:rust-gix-protocol+sha256-devel = " \
 cargo \
 rust-gix-hash+sha256-devel \
 rust-gix-protocol-devel \
 "
RDEPENDS:rust-gix-protocol-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-date+default-devel \
 rust-gix-features+default-devel \
 rust-gix-features+progress-devel \
 rust-gix-hash+default-devel \
 rust-gix-ref+default-devel \
 rust-gix-shallow+default-devel \
 rust-gix-transport+default-devel \
 rust-gix-utils+default-devel \
 rust-maybe-async+default-devel \
 rust-nonempty+default-devel \
 rust-thiserror+default-devel \
 "
