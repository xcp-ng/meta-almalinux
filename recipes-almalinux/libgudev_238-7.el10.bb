# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgudev"
PV = "238"
PR = "7.el10"
PACKAGES = " \
 libgudev \
 libgudev-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libgudev-238-7.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b6c28908cf9e451670b44ccd7f2842cbae4753f1f1ba9a9bf6ebbbbe276b288b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libgudev-238-7.el10.x86_64_v2.rpm;name=x86_64_v2_libgudev;unpack=0"
SRC_URI[x86_64_v2_libgudev.sha256sum] = "4688a5cb81d1fdcf760fc6dbfdc9a49938422e4c4ea835619b4edeffd3257316"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgudev-devel-238-7.el10.x86_64_v2.rpm;name=x86_64_v2_libgudev-devel;unpack=0"
SRC_URI[x86_64_v2_libgudev-devel.sha256sum] = "538baafba6fe10b3bc6c1079c3f7e85ab1421bafc714a5ebec1c96de5c9344a8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libgudev-238-7.el10.aarch64.rpm;name=aarch64_libgudev;unpack=0"
SRC_URI[aarch64_libgudev.sha256sum] = "3998b7a146a8789dcd3f0fd892c22584632aa70fe6418204741d85e85ff69a8a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libgudev-devel-238-7.el10.aarch64.rpm;name=aarch64_libgudev-devel;unpack=0"
SRC_URI[aarch64_libgudev-devel.sha256sum] = "c3be7d6d92ff331c4014b9bf7e2b1319e59c798fb4a990184b4b977e9831be96"

RDEPENDS:libgudev = " \
 glib2 \
 glibc \
 libgcc \
 systemd-libs \
 "
RDEPENDS:libgudev-devel = " \
 glib2-devel \
 libgudev \
 pkgconf-pkg-config \
 systemd-devel \
 "
