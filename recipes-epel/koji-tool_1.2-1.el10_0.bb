# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "koji-tool"
PV = "1.2"
PR = "1.el10_0"
PACKAGES = " \
 koji-tool \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/koji-tool-1.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eaa7499c246e1f736c3f1965785f6d07199502e3525afbb0361bcce91338bf6c"

URI_x86_64_v2_koji-tool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-tool-1.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_koji-tool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-tool}"
SRC_URI[x86_64_v2_koji-tool.sha256sum] = "2fed3e8b01c958d5dfc3b214b349b0ea0356ac6796ac7c56d85dbfb420384d46"

URI_aarch64_koji-tool = "${EPEL_MIRROR}/aarch64/Packages/k/koji-tool-1.2-1.el10_0.aarch64.rpm;name=aarch64_koji-tool;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-tool}"
SRC_URI[aarch64_koji-tool.sha256sum] = "378105b208f8b3ef60a3303475f93f70a91e772adddf7a395284f0d72b606945"

RDEPENDS:koji-tool = " \
 glibc \
 gmp \
 libffi \
 ncurses-libs \
 openssl-libs \
 zlib-ng-compat \
 "
