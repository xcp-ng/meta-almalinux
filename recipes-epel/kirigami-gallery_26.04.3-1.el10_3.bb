# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kirigami-gallery"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kirigami-gallery \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kirigami-gallery-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "698ed6c8207eb6dd9c9726f773d35fbe8af89716b614632ed4ac20af38f506d7"

URI_x86_64_v2_kirigami-gallery = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kirigami-gallery-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kirigami-gallery;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kirigami-gallery}"
SRC_URI[x86_64_v2_kirigami-gallery.sha256sum] = "2d4089f987c39b14bbaa6a3ca620a0ffcac96fc4fff33662a81531f320458d57"

URI_aarch64_kirigami-gallery = "${EPEL_MIRROR}/aarch64/Packages/k/kirigami-gallery-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kirigami-gallery;unpack=0"
SRC_URI:append = " ${URI_aarch64_kirigami-gallery}"
SRC_URI[aarch64_kirigami-gallery.sha256sum] = "d90b714fe68bab74aa3b5eca8954d523fd3cfe610d34e6025dd4ce151b89a4c1"

RDEPENDS:kirigami-gallery = " \
 breeze-icon-theme \
 glibc \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
