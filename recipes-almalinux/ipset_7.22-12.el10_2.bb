# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ipset"
PV = "7.22"
PR = "12.el10_2"
PACKAGES = " \
 ipset \
 ipset-devel \
 ipset-libs \
 ipset-service \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/ipset-7.22-12.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "248c2d7c0703e082a7d9846aca30103f3822ca6fd8e1b41e8a821e5eab11bd91"

URI_x86_64_v2_ipset = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ipset-7.22-12.el10_2.x86_64_v2.rpm;name=x86_64_v2_ipset;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipset}"
SRC_URI[x86_64_v2_ipset.sha256sum] = "b2327addff9ccb8c59409aa65bdbf21f9b5d9e3e4bf5272948df9a4318031939"

URI_x86_64_v2_ipset-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ipset-devel-7.22-12.el10_2.x86_64_v2.rpm;name=x86_64_v2_ipset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipset-devel}"
SRC_URI[x86_64_v2_ipset-devel.sha256sum] = "0c9e100dd3d9ef96002e01980d8567e11fed5f98494b640344f868ef89b50fe0"

URI_x86_64_v2_ipset-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ipset-libs-7.22-12.el10_2.x86_64_v2.rpm;name=x86_64_v2_ipset-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipset-libs}"
SRC_URI[x86_64_v2_ipset-libs.sha256sum] = "d4314daebb17509ad0c72fd33ce2f0f85ce489e23f459c573575745f19f80bf1"

URI_x86_64_v2_ipset-service = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipset-service-7.22-12.el10_2.noarch.rpm;name=x86_64_v2_ipset-service;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipset-service}"
SRC_URI[x86_64_v2_ipset-service.sha256sum] = "4a75677052c5cbddef5d639e0f34b811e9045621ba90d5e60ea4c318fb98278c"

URI_aarch64_ipset = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ipset-7.22-12.el10_2.aarch64.rpm;name=aarch64_ipset;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipset}"
SRC_URI[aarch64_ipset.sha256sum] = "a095aa3dc7f1f4e2b704fdcdb860c5657e36496902473ec93d8f34deb48eeea8"

URI_aarch64_ipset-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ipset-devel-7.22-12.el10_2.aarch64.rpm;name=aarch64_ipset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipset-devel}"
SRC_URI[aarch64_ipset-devel.sha256sum] = "20359f9c7b9b2d3c2c5f6c4db1acfaa1cf2f6a2282ad495d3ac864d167bf3d5b"

URI_aarch64_ipset-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ipset-libs-7.22-12.el10_2.aarch64.rpm;name=aarch64_ipset-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipset-libs}"
SRC_URI[aarch64_ipset-libs.sha256sum] = "c783ee9b30b08a5dbd1d7153286274b2205961b51b4c9ed791a57bf8d116f88c"

URI_aarch64_ipset-service = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipset-service-7.22-12.el10_2.noarch.rpm;name=aarch64_ipset-service;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipset-service}"
SRC_URI[aarch64_ipset-service.sha256sum] = "4a75677052c5cbddef5d639e0f34b811e9045621ba90d5e60ea4c318fb98278c"

RDEPENDS:ipset = " \
 bash \
 glibc \
 ipset-libs \
 "
RDEPENDS:ipset-devel = " \
 ipset-libs \
 kernel-headers \
 libmnl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:ipset-libs = " \
 glibc \
 libmnl \
 "
RDEPENDS:ipset-service = " \
 bash \
 ipset \
 iptables-nft-services \
 systemd \
 "
