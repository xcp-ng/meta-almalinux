# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mock_instant0.3"
PV = "0.3.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-mock_instant0.3+default-devel \
 rust-mock_instant0.3+once_cell-devel \
 rust-mock_instant0.3+sync-devel \
 rust-mock_instant0.3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mock_instant0.3-0.3.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "56c8609191aa5da84dbf94003a417f493f52e045563c9677c4fdd6cdcafd2ca1"

URI_x86_64_v2_rust-mock_instant0.3+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mock_instant0.3+default-devel-0.3.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mock_instant0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mock_instant0.3+default-devel}"
SRC_URI[x86_64_v2_rust-mock_instant0.3+default-devel.sha256sum] = "cfd366d85b401067852d7cb26617b39a9a6bd19b80f5e688f298b8907c3a2069"

URI_x86_64_v2_rust-mock_instant0.3+once_cell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mock_instant0.3+once_cell-devel-0.3.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mock_instant0.3+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mock_instant0.3+once_cell-devel}"
SRC_URI[x86_64_v2_rust-mock_instant0.3+once_cell-devel.sha256sum] = "55e5f8804b4c7c96e14a40cf3ecd50fdcae1e6ace6af376911dc181ce513bc39"

URI_x86_64_v2_rust-mock_instant0.3+sync-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mock_instant0.3+sync-devel-0.3.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mock_instant0.3+sync-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mock_instant0.3+sync-devel}"
SRC_URI[x86_64_v2_rust-mock_instant0.3+sync-devel.sha256sum] = "c8b3fce8bc9dcbfbf23b483cb023ab232d4898ff7d6fe70021a7c9d409c4fce3"

URI_x86_64_v2_rust-mock_instant0.3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mock_instant0.3-devel-0.3.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mock_instant0.3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mock_instant0.3-devel}"
SRC_URI[x86_64_v2_rust-mock_instant0.3-devel.sha256sum] = "5cb12a8c15954623eb4597532eceef9a9eadda4c2804aca3a1022ad0f7adb2b0"

URI_aarch64_rust-mock_instant0.3+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mock_instant0.3+default-devel-0.3.2-1.el10_1.noarch.rpm;name=aarch64_rust-mock_instant0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mock_instant0.3+default-devel}"
SRC_URI[aarch64_rust-mock_instant0.3+default-devel.sha256sum] = "eabe98534f7cc8a7d9f3171130d17f4fd78df6d37e1cb1cb21601de4bb83aaa8"

URI_aarch64_rust-mock_instant0.3+once_cell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mock_instant0.3+once_cell-devel-0.3.2-1.el10_1.noarch.rpm;name=aarch64_rust-mock_instant0.3+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mock_instant0.3+once_cell-devel}"
SRC_URI[aarch64_rust-mock_instant0.3+once_cell-devel.sha256sum] = "7c86853576c5bf581721a529f2ac39de4ac3e640fe2c0446d818d5de1378a350"

URI_aarch64_rust-mock_instant0.3+sync-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mock_instant0.3+sync-devel-0.3.2-1.el10_1.noarch.rpm;name=aarch64_rust-mock_instant0.3+sync-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mock_instant0.3+sync-devel}"
SRC_URI[aarch64_rust-mock_instant0.3+sync-devel.sha256sum] = "bed1c8e32dbc0feebd6612538306525a127287e89f7184fc43a94cadb44d786c"

URI_aarch64_rust-mock_instant0.3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mock_instant0.3-devel-0.3.2-1.el10_1.noarch.rpm;name=aarch64_rust-mock_instant0.3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mock_instant0.3-devel}"
SRC_URI[aarch64_rust-mock_instant0.3-devel.sha256sum] = "f2856760551d0edb19855275f1263edcb3d99fe33f43b5ebaeebedd25117623a"

RDEPENDS:rust-mock_instant0.3+default-devel = " \
 cargo \
 rust-mock_instant0.3-devel \
 "
RDEPENDS:rust-mock_instant0.3+once_cell-devel = " \
 cargo \
 rust-mock_instant0.3-devel \
 rust-once_cell+default-devel \
 "
RDEPENDS:rust-mock_instant0.3+sync-devel = " \
 cargo \
 rust-mock_instant0.3+once_cell-devel \
 rust-mock_instant0.3-devel \
 "
RDEPENDS:rust-mock_instant0.3-devel = " \
 cargo \
 "
