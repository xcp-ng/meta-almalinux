# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "inotify-tools"
PV = "4.23.9.0"
PR = "4.el10_0"
PACKAGES = " \
 inotify-tools \
 inotify-tools-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/inotify-tools-4.23.9.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a55021a00970bbb7af67aaa41b841d3bc4e1ac824c394c87b460242645e39d06"

URI_x86_64_v2_inotify-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/inotify-tools-4.23.9.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_inotify-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_inotify-tools}"
SRC_URI[x86_64_v2_inotify-tools.sha256sum] = "25a1ff9f004944571a43072657d4969cbdab236610ae22a3880d9f540e82fd7c"

URI_x86_64_v2_inotify-tools-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/inotify-tools-devel-4.23.9.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_inotify-tools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_inotify-tools-devel}"
SRC_URI[x86_64_v2_inotify-tools-devel.sha256sum] = "71cc387b43747d38d4f1cc2b0e2324cf997c772798451f742cfb0f1bfba917d1"

URI_aarch64_inotify-tools = "${EPEL_MIRROR}/aarch64/Packages/i/inotify-tools-4.23.9.0-4.el10_0.aarch64.rpm;name=aarch64_inotify-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_inotify-tools}"
SRC_URI[aarch64_inotify-tools.sha256sum] = "d553b81cd082d388c338eb41be0f83d846dd93966e0f1392a4dbb2e941f50ea0"

URI_aarch64_inotify-tools-devel = "${EPEL_MIRROR}/aarch64/Packages/i/inotify-tools-devel-4.23.9.0-4.el10_0.aarch64.rpm;name=aarch64_inotify-tools-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_inotify-tools-devel}"
SRC_URI[aarch64_inotify-tools-devel.sha256sum] = "05a198b452bad652514921bee9e7ba3bddf8d44f327752dd414a1d9975ef882d"

RDEPENDS:inotify-tools = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:inotify-tools-devel = " \
 inotify-tools \
 "
