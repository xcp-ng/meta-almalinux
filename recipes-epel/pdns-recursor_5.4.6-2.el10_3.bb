# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pdns-recursor"
PV = "5.4.6"
PR = "2.el10_3"
PACKAGES = " \
 pdns-recursor \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/pdns-recursor-5.4.6-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c2246ec45d3ff5b3e03fe5d1a1680ec3d92fed9db8ac75746b192257d7aaa1be"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - pdns-recursor: libcap.so.2()(64bit)

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-recursor-5.4.6-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-recursor;unpack=0"
SRC_URI[x86_64_v2_pdns-recursor.sha256sum] = "e5e286cb38ac9b089c51827166934977adf8f1621f1f63008d07ea73a1e0f295"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pdns-recursor-5.4.6-2.el10_3.aarch64.rpm;name=aarch64_pdns-recursor;unpack=0"
SRC_URI[aarch64_pdns-recursor.sha256sum] = "920be10475a705930fa623fc27afd160530c5e89a174060e6ebb52066e2e9dc3"

RDEPENDS:pdns-recursor:x86_64_v2 = " \
 bash \
 boost-context \
 boost-filesystem \
 fstrm \
 glibc \
 libcap \
 libgcc \
 libsodium \
 libstdc++ \
 luajit \
 openssl-libs \
 systemd \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
"
RDEPENDS:pdns-recursor:aarch64 = " \
 bash \
 boost-context \
 boost-filesystem \
 fstrm \
 glibc \
 libgcc \
 libsodium \
 libstdc++ \
 luajit \
 openssl-libs \
 systemd \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
"
