# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "git-imerge"
PV = "1.2.0"
PR = "1.el10_2"
PACKAGES = " \
 git-imerge \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/git-imerge-1.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ba8c3de4146622a0cc433ac90012b021b1f0da5e93646966f7699947c649a1cd"

URI_x86_64_v2_git-imerge = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/git-imerge-1.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_git-imerge;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-imerge}"
SRC_URI[x86_64_v2_git-imerge.sha256sum] = "a67fa18a8d0985986b7af904489e54305afb7acca73f0abda45507d99e667f11"

URI_aarch64_git-imerge = "${EPEL_MIRROR}/aarch64/Packages/g/git-imerge-1.2.0-1.el10_2.noarch.rpm;name=aarch64_git-imerge;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-imerge}"
SRC_URI[aarch64_git-imerge.sha256sum] = "b43224e7bc12b4809efe3066c1c2b6687d685f4e5317e0142ed3678f83e9f0af"

RDEPENDS:git-imerge = " \
 git-core \
 python3 \
 "
