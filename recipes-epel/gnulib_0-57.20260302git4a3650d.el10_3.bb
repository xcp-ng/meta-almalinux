# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnulib"
PV = "0"
PR = "57.20260302git4a3650d.el10_3"
PACKAGES = " \
 gnulib-devel \
 gnulib-docs \
 gnulib-javaversion \
 python3-gnulib \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gnulib-0-57.20260302git4a3650d.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b9f9f8adfcdf93591534af5c5e3f990ee7527a040d2809c1956035dff6c05bab"

URI_x86_64_v2_gnulib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnulib-devel-0-57.20260302git4a3650d.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_gnulib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnulib-devel}"
SRC_URI[x86_64_v2_gnulib-devel.sha256sum] = "58d4d4faa054a0f6971848f998e5e362a878d78734cdbc316edb7dbfafb9f9fd"

URI_x86_64_v2_gnulib-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnulib-docs-0-57.20260302git4a3650d.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_gnulib-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnulib-docs}"
SRC_URI[x86_64_v2_gnulib-docs.sha256sum] = "e6cb8534057f38fe0acca0f280114d8d78a493f90e99347a2ac2fc8b4c14214e"

URI_x86_64_v2_gnulib-javaversion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnulib-javaversion-0-57.20260302git4a3650d.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gnulib-javaversion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnulib-javaversion}"
SRC_URI[x86_64_v2_gnulib-javaversion.sha256sum] = "9c69eeac078336c8a0784ad6f46dd9e595c8fb7e8ecd5c56bd94840f6f22120d"

URI_x86_64_v2_python3-gnulib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gnulib-0-57.20260302git4a3650d.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-gnulib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gnulib}"
SRC_URI[x86_64_v2_python3-gnulib.sha256sum] = "2fba58ce5c78117ca5867d2f901f07f8932591f03a287b16711d90753223cdb4"

URI_aarch64_gnulib-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gnulib-devel-0-57.20260302git4a3650d.el10_3.noarch.rpm;name=aarch64_gnulib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnulib-devel}"
SRC_URI[aarch64_gnulib-devel.sha256sum] = "9c5385baee38a63c2879c1799623f31e3b962fc927f2b9310ee84a822392d1c2"

URI_aarch64_gnulib-docs = "${EPEL_MIRROR}/aarch64/Packages/g/gnulib-docs-0-57.20260302git4a3650d.el10_3.noarch.rpm;name=aarch64_gnulib-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnulib-docs}"
SRC_URI[aarch64_gnulib-docs.sha256sum] = "2d768a7b289e42028cdeff4bd369fc5f5d20877bc3d6d6e402b224e0277f2ef7"

URI_aarch64_gnulib-javaversion = "${EPEL_MIRROR}/aarch64/Packages/g/gnulib-javaversion-0-57.20260302git4a3650d.el10_3.aarch64.rpm;name=aarch64_gnulib-javaversion;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnulib-javaversion}"
SRC_URI[aarch64_gnulib-javaversion.sha256sum] = "414d858d2886c4d809ec013968194b1b9b1ea096f3409bce7f99ab552a61d020"

URI_aarch64_python3-gnulib = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gnulib-0-57.20260302git4a3650d.el10_3.noarch.rpm;name=aarch64_python3-gnulib;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gnulib}"
SRC_URI[aarch64_python3-gnulib.sha256sum] = "672eeab71b6fb79e131e3bc84f2a35f0b6bd04099a527727cf8df97a90448051"

RDEPENDS:gnulib-devel = " \
 autoconf \
 automake \
 bash \
 bison \
 diffutils \
 gawk \
 gcc \
 gettext-devel \
 gperf \
 grep \
 libtool \
 m4 \
 make \
 patch \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-constant \
 perl-interpreter \
 perl-libs \
 python3 \
 python3-gnulib \
 texinfo \
 virtual/coreutils \
 "
RDEPENDS:gnulib-docs = " \
 gnulib-devel \
 "
RDEPENDS:gnulib-javaversion = " \
 gnulib-devel \
 "
RDEPENDS:python3-gnulib = " \
 gnulib-devel \
 python3 \
 "
