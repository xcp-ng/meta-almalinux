# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hwloc"
PV = "2.11.1"
PR = "3.el10"
PACKAGES = " \
 hwloc \
 hwloc-devel \
 hwloc-gui \
 hwloc-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/hwloc-2.11.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6544f0810cbfbd42284a4801e0e7e2afa2e62fb510a872d58c2f41fd2ec6417f"

URI_x86_64_v2_hwloc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/hwloc-2.11.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_hwloc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hwloc}"
SRC_URI[x86_64_v2_hwloc.sha256sum] = "bf90da8c0e2633e2c8af20f62d7ceb2cad9cad388892103fc9bf75a68210e8bd"

URI_x86_64_v2_hwloc-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hwloc-devel-2.11.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_hwloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hwloc-devel}"
SRC_URI[x86_64_v2_hwloc-devel.sha256sum] = "235dafde5e32216bc13617f6680be363b0037d138e643652fe2458ef38494b13"

URI_x86_64_v2_hwloc-gui = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hwloc-gui-2.11.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_hwloc-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hwloc-gui}"
SRC_URI[x86_64_v2_hwloc-gui.sha256sum] = "3265c45d840fec984730f43f29adcd5452fc1ca7ea26dc16a9842dbc6582a83b"

URI_x86_64_v2_hwloc-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/hwloc-libs-2.11.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_hwloc-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hwloc-libs}"
SRC_URI[x86_64_v2_hwloc-libs.sha256sum] = "21157180a1c51411985359722f47a5dd7b6533a21d6a862edab6312c7323b4ff"

URI_aarch64_hwloc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/hwloc-2.11.1-3.el10.aarch64.rpm;name=aarch64_hwloc;unpack=0"
SRC_URI:append = " ${URI_aarch64_hwloc}"
SRC_URI[aarch64_hwloc.sha256sum] = "2481bbec6bc32854fd29e6f76d1b72680f8528cc5c0ceac40e961bb08e3321bd"

URI_aarch64_hwloc-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hwloc-devel-2.11.1-3.el10.aarch64.rpm;name=aarch64_hwloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_hwloc-devel}"
SRC_URI[aarch64_hwloc-devel.sha256sum] = "3c0ea9f64586353ddb2e09f2de5396757af7c943bd8fe2dbd0ba5fd816b39bfc"

URI_aarch64_hwloc-gui = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hwloc-gui-2.11.1-3.el10.aarch64.rpm;name=aarch64_hwloc-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_hwloc-gui}"
SRC_URI[aarch64_hwloc-gui.sha256sum] = "6938e6cc5de6871e91db9ecdd4b717bef0c146548747cb277fa3fa628e0b8f9a"

URI_aarch64_hwloc-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/hwloc-libs-2.11.1-3.el10.aarch64.rpm;name=aarch64_hwloc-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_hwloc-libs}"
SRC_URI[aarch64_hwloc-libs.sha256sum] = "b41ea409bbf37cc5f230bfe4ad29c54b45d59f84e17eecab5acd2bc38883d403"

RDEPENDS:hwloc:x86_64_v2 = " \
 bash \
 glibc \
 hwloc-libs \
 ncurses-libs \
 systemd \
"
RDEPENDS:hwloc:aarch64 = " \
 bash \
 glibc \
 hwloc-libs \
 ncurses-libs \
"
RDEPENDS:hwloc-devel = " \
 hwloc-libs \
 libpciaccess-devel \
 libxml2-devel \
 pkgconf-pkg-config \
 rdma-core-devel \
 "
RDEPENDS:hwloc-gui = " \
 cairo \
 glibc \
 hwloc-libs \
 libX11 \
 ncurses-libs \
 "
RDEPENDS:hwloc-libs = " \
 glibc \
 libpciaccess \
 libxml2 \
 ocl-icd \
 systemd-libs \
 "
