# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "egl-x11"
PV = "1.0.3"
PR = "1.el10_0"
PACKAGES = " \
 egl-x11 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/egl-x11-1.0.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dbc576b0438f151137cad182a59c1d6e8467873571d3bbe4a07cb9fe79b95e67"

URI_x86_64_v2_egl-x11 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/egl-x11-1.0.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_egl-x11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_egl-x11}"
SRC_URI[x86_64_v2_egl-x11.sha256sum] = "3b75fa0f210bf376b6719a99c83de5ba7530915c930d45fddb13c8d6dac79908"

URI_aarch64_egl-x11 = "${EPEL_MIRROR}/aarch64/Packages/e/egl-x11-1.0.3-1.el10_0.aarch64.rpm;name=aarch64_egl-x11;unpack=0"
SRC_URI:append = " ${URI_aarch64_egl-x11}"
SRC_URI[aarch64_egl-x11.sha256sum] = "bc89578e973a3387c93830637073edbc3cce181f41d00c999dd9bb1ed6b08ac6"

RDEPENDS:egl-x11 = " \
 glibc \
 libX11 \
 libX11-xcb \
 libdrm \
 libglvnd-egl \
 libxcb \
 mesa-libgbm \
 "
