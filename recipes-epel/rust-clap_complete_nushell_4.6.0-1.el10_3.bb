# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap_complete_nushell"
PV = "4.6.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-clap_complete_nushell+default-devel \
 rust-clap_complete_nushell-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap_complete_nushell-4.6.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d175e0dc3ce7b34d029507f1e3552871e180d896527dcf6f040f4df9ef4f9155"

URI_x86_64_v2_rust-clap_complete_nushell+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete_nushell+default-devel-4.6.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete_nushell+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete_nushell+default-devel}"
SRC_URI[x86_64_v2_rust-clap_complete_nushell+default-devel.sha256sum] = "f9110bf02b92fcb2dbebd127a2d441231a9564f7714acae743db85668353f165"

URI_x86_64_v2_rust-clap_complete_nushell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete_nushell-devel-4.6.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete_nushell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete_nushell-devel}"
SRC_URI[x86_64_v2_rust-clap_complete_nushell-devel.sha256sum] = "83fc0ca22f0c12909643b8252edb590300c063aa4463a4a77936c4d096cf0c55"

URI_aarch64_rust-clap_complete_nushell+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete_nushell+default-devel-4.6.0-1.el10_3.noarch.rpm;name=aarch64_rust-clap_complete_nushell+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete_nushell+default-devel}"
SRC_URI[aarch64_rust-clap_complete_nushell+default-devel.sha256sum] = "6131a82ab6a489ca89c9ae01b517d5459ab9b31a7a66743801dbf2c3037bf90d"

URI_aarch64_rust-clap_complete_nushell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete_nushell-devel-4.6.0-1.el10_3.noarch.rpm;name=aarch64_rust-clap_complete_nushell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete_nushell-devel}"
SRC_URI[aarch64_rust-clap_complete_nushell-devel.sha256sum] = "4f0b0aa73ea8a030d8f70743f8620221de4f7d9ae50ff3bddcef3cfa57961b0e"

RDEPENDS:rust-clap_complete_nushell+default-devel = " \
 cargo \
 rust-clap_complete_nushell-devel \
 "
RDEPENDS:rust-clap_complete_nushell-devel = " \
 cargo \
 rust \
 rust-clap+std-devel \
 rust-clap-devel \
 rust-clap_complete+default-devel \
 "
