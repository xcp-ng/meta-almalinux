# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pep508_rs"
PV = "0.9.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-pep508_rs+default-devel \
 rust-pep508_rs+non-pep508-extensions-devel \
 rust-pep508_rs+schemars-devel \
 rust-pep508_rs+tracing-devel \
 rust-pep508_rs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pep508_rs-0.9.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b1d02954cbdfedc8eb9d6367f5302f983836249bca84a232f513a326efcefc62"

URI_x86_64_v2_rust-pep508_rs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pep508_rs+default-devel-0.9.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pep508_rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pep508_rs+default-devel}"
SRC_URI[x86_64_v2_rust-pep508_rs+default-devel.sha256sum] = "b4286889252437397a5b24ab8cb9f52a290cdb270c2c2933d9c58de23efd51f2"

URI_x86_64_v2_rust-pep508_rs+non-pep508-extensions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pep508_rs+non-pep508-extensions-devel-0.9.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pep508_rs+non-pep508-extensions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pep508_rs+non-pep508-extensions-devel}"
SRC_URI[x86_64_v2_rust-pep508_rs+non-pep508-extensions-devel.sha256sum] = "ccb276f8c31886937d721442bb97054c7688670dc1890c8e24ef61940e1fc8bc"

URI_x86_64_v2_rust-pep508_rs+schemars-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pep508_rs+schemars-devel-0.9.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pep508_rs+schemars-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pep508_rs+schemars-devel}"
SRC_URI[x86_64_v2_rust-pep508_rs+schemars-devel.sha256sum] = "d4a97e1a0962f94ce247ad0dbfeacbfc4281617c2733371e8ef567521647fad0"

URI_x86_64_v2_rust-pep508_rs+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pep508_rs+tracing-devel-0.9.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pep508_rs+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pep508_rs+tracing-devel}"
SRC_URI[x86_64_v2_rust-pep508_rs+tracing-devel.sha256sum] = "41f9e4835c591346d2fd7c1edbb4f6fce0eaf1b6423c1cfcbc42f1e99686f13d"

URI_x86_64_v2_rust-pep508_rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pep508_rs-devel-0.9.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pep508_rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pep508_rs-devel}"
SRC_URI[x86_64_v2_rust-pep508_rs-devel.sha256sum] = "7deb746789cc4eefcdeb163d6d9e9ccd78c7397a625f643477a742bbdd2e2eb3"

URI_aarch64_rust-pep508_rs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pep508_rs+default-devel-0.9.2-1.el10_1.noarch.rpm;name=aarch64_rust-pep508_rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pep508_rs+default-devel}"
SRC_URI[aarch64_rust-pep508_rs+default-devel.sha256sum] = "9e80660f7e839d527bb49ef76fa864225b1f78f75062c42af591f1a1a8580b76"

URI_aarch64_rust-pep508_rs+non-pep508-extensions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pep508_rs+non-pep508-extensions-devel-0.9.2-1.el10_1.noarch.rpm;name=aarch64_rust-pep508_rs+non-pep508-extensions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pep508_rs+non-pep508-extensions-devel}"
SRC_URI[aarch64_rust-pep508_rs+non-pep508-extensions-devel.sha256sum] = "4ec41c497635744bb2f49aed9027618ebb9dcd9a79e15b2bcd4e49808d8272c0"

URI_aarch64_rust-pep508_rs+schemars-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pep508_rs+schemars-devel-0.9.2-1.el10_1.noarch.rpm;name=aarch64_rust-pep508_rs+schemars-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pep508_rs+schemars-devel}"
SRC_URI[aarch64_rust-pep508_rs+schemars-devel.sha256sum] = "967ce0cefaa24b2605bb2f9fae11132ecd3438ec37b43fa4c1a98be86c20d1ed"

URI_aarch64_rust-pep508_rs+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pep508_rs+tracing-devel-0.9.2-1.el10_1.noarch.rpm;name=aarch64_rust-pep508_rs+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pep508_rs+tracing-devel}"
SRC_URI[aarch64_rust-pep508_rs+tracing-devel.sha256sum] = "a25a86407fdfd69475450fa46fbe9da5d9102d086f0f8dbd32284bb1ddece07b"

URI_aarch64_rust-pep508_rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pep508_rs-devel-0.9.2-1.el10_1.noarch.rpm;name=aarch64_rust-pep508_rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pep508_rs-devel}"
SRC_URI[aarch64_rust-pep508_rs-devel.sha256sum] = "33294f03485365a08ad19556301d44735994d6311a4cd51997dfd042f3294bea"

RDEPENDS:rust-pep508_rs+default-devel = " \
 cargo \
 rust-pep508_rs-devel \
 "
RDEPENDS:rust-pep508_rs+non-pep508-extensions-devel = " \
 cargo \
 rust-pep508_rs-devel \
 "
RDEPENDS:rust-pep508_rs+schemars-devel = " \
 cargo \
 rust-pep508_rs-devel \
 rust-schemars0.8+default-devel \
 "
RDEPENDS:rust-pep508_rs+tracing-devel = " \
 cargo \
 rust-pep440_rs+tracing-devel \
 rust-pep508_rs-devel \
 rust-tracing+default-devel \
 "
RDEPENDS:rust-pep508_rs-devel = " \
 cargo \
 rust-boxcar+default-devel \
 rust-indexmap+default-devel \
 rust-itertools0.13+default-devel \
 rust-once_cell+default-devel \
 rust-pep440_rs+default-devel \
 rust-pep440_rs+version-ranges-devel \
 rust-regex+default-devel \
 rust-rustc-hash+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-smallvec+default-devel \
 rust-thiserror1+default-devel \
 rust-unicode-width+default-devel \
 rust-url+default-devel \
 rust-url+serde-devel \
 rust-urlencoding+default-devel \
 rust-version-ranges+default-devel \
 "
