# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-LWP-Protocol-https"
PV = "6.13"
PR = "3.el10"
PACKAGES = " \
 perl-LWP-Protocol-https \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-LWP-Protocol-https-6.13-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "941eb4e6f6bdd5571fb2fa20a94ffb1ac63a6deaefc0e387c5592a2d50dcbd58"

URI_x86_64_v2_perl-LWP-Protocol-https = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-LWP-Protocol-https-6.13-3.el10.noarch.rpm;name=x86_64_v2_perl-LWP-Protocol-https;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-LWP-Protocol-https}"
SRC_URI[x86_64_v2_perl-LWP-Protocol-https.sha256sum] = "1b67b13dd6a4688907673b62a20d3382b99e0d81b173effd1cdd81ecf43e45b0"

URI_aarch64_perl-LWP-Protocol-https = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-LWP-Protocol-https-6.13-3.el10.noarch.rpm;name=aarch64_perl-LWP-Protocol-https;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-LWP-Protocol-https}"
SRC_URI[aarch64_perl-LWP-Protocol-https.sha256sum] = "1b67b13dd6a4688907673b62a20d3382b99e0d81b173effd1cdd81ecf43e45b0"

RDEPENDS:perl-LWP-Protocol-https = " \
 perl-IO-Socket-SSL \
 perl-Mozilla-CA \
 perl-Net-HTTP \
 perl-base \
 perl-libs \
 perl-libwww-perl \
 "
