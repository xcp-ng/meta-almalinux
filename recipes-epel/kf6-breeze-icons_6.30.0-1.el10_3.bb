# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-breeze-icons"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 breeze-icon-theme \
 breeze-icon-theme-rcc \
 kf6-breeze-icons \
 kf6-breeze-icons-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-breeze-icons-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e0244cb5fbd297b81c21fc9b1fa97f949a349be26aeb93250a31367cdc380149"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-icon-theme-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-icon-theme;unpack=0"
SRC_URI[x86_64_v2_breeze-icon-theme.sha256sum] = "725b48da482cd1d83526a71dc46860f56622bfad4f67b260ad3a7d5fe27796d1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-icon-theme-rcc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-icon-theme-rcc;unpack=0"
SRC_URI[x86_64_v2_breeze-icon-theme-rcc.sha256sum] = "c417b955a88d323a5fe77cb0b5f2831b7db633ca945eb1a21b14872ed1371a90"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-breeze-icons-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-breeze-icons;unpack=0"
SRC_URI[x86_64_v2_kf6-breeze-icons.sha256sum] = "0529a4b176966c4f87966824f689c39e8c04c43fc3fc0c5910c3b40944f32249"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-breeze-icons-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-breeze-icons-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-breeze-icons-devel.sha256sum] = "35f6d12cec49add4c352cf5f1640b37e2ae5c5a5105feeca2138306499738d88"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/breeze-icon-theme-6.30.0-1.el10_3.noarch.rpm;name=aarch64_breeze-icon-theme;unpack=0"
SRC_URI[aarch64_breeze-icon-theme.sha256sum] = "47ab6a429ec8cf46105fd2547c0a58d2093577aa5abe81ef0b21cf2728981bc2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/breeze-icon-theme-rcc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_breeze-icon-theme-rcc;unpack=0"
SRC_URI[aarch64_breeze-icon-theme-rcc.sha256sum] = "678c7e3521db35068a9bb713b39932a403e2ca5a02ff19c969b5873dac86b0ef"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-breeze-icons-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-breeze-icons;unpack=0"
SRC_URI[aarch64_kf6-breeze-icons.sha256sum] = "e2e3de0e4be742bf2dd55c7f49e0a534b60d0435a3eb0159fb78237c5d3b1244"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-breeze-icons-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-breeze-icons-devel;unpack=0"
SRC_URI[aarch64_kf6-breeze-icons-devel.sha256sum] = "36dc34065fb91643e70f561879481eeebba86ce591ce815fa168a6b889ae9c51"

RDEPENDS:breeze-icon-theme = " \
 almalinux-logos \
 bash \
 hicolor-icon-theme \
 "
RDEPENDS:breeze-icon-theme-rcc = " \
 "
RDEPENDS:kf6-breeze-icons = " \
 breeze-icon-theme \
 glibc \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-breeze-icons-devel = " \
 cmake-filesystem \
 kf6-breeze-icons \
 "
