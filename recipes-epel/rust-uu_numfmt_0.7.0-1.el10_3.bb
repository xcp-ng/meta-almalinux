# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_numfmt"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_numfmt+default-devel \
 rust-uu_numfmt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_numfmt-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ec1182ec2bffe7083a614d95a6d37be3cc611fea64f8d922941910eb8dd324c"

URI_x86_64_v2_rust-uu_numfmt+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_numfmt+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_numfmt+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_numfmt+default-devel}"
SRC_URI[x86_64_v2_rust-uu_numfmt+default-devel.sha256sum] = "4af8b89b39d347f037e4aec82c8c401c763ffe987e49074d4d519c1f280ab820"

URI_x86_64_v2_rust-uu_numfmt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_numfmt-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_numfmt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_numfmt-devel}"
SRC_URI[x86_64_v2_rust-uu_numfmt-devel.sha256sum] = "9d474221f923388d5891754a7ae2dbad776cc6b4131684f5b2ca657e15e65d25"

URI_aarch64_rust-uu_numfmt+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_numfmt+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_numfmt+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_numfmt+default-devel}"
SRC_URI[aarch64_rust-uu_numfmt+default-devel.sha256sum] = "d9cebfca81563fd0727d716e40118130ec3fcf8db87eefcf379ba30f58f04fda"

URI_aarch64_rust-uu_numfmt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_numfmt-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_numfmt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_numfmt-devel}"
SRC_URI[aarch64_rust-uu_numfmt-devel.sha256sum] = "a6ba171c620445f378140874389c0ec515a0846befba72412e328ee69aff40c4"

RDEPENDS:rust-uu_numfmt+default-devel = " \
 cargo \
 rust-uu_numfmt-devel \
 "
RDEPENDS:rust-uu_numfmt-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-memchr+default-devel \
 rust-thiserror+default-devel \
 rust-uucore+default-devel \
 rust-uucore+parser-devel \
 rust-uucore+ranges-devel \
 "
