# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-devtools"
PV = "0.3.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-colcon-devtools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-devtools-0.3.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69b5bc94dcc17af2b2e95a567959cd7bbea6ec1141e04a92fc9c8795e97e1b12"

URI_x86_64_v2_python3-colcon-devtools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-devtools-0.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-devtools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-devtools}"
SRC_URI[x86_64_v2_python3-colcon-devtools.sha256sum] = "97bbde820ee698892eb1357e5c506a46f8b639ce06ec46e7aff6343efb9d0118"

URI_aarch64_python3-colcon-devtools = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-devtools-0.3.0-1.el10_1.noarch.rpm;name=aarch64_python3-colcon-devtools;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-devtools}"
SRC_URI[aarch64_python3-colcon-devtools.sha256sum] = "9697fad8f8911fa4fb31a640dec88c6d3eeee748c934f795781fd4fad32d7a25"

RDEPENDS:python3-colcon-devtools = " \
 python3 \
 python3-colcon-core \
 python3-packaging \
 "
