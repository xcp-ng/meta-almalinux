# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "maven-clean-plugin"
PV = "3.3.2"
PR = "6.el10_0"
PACKAGES = " \
 maven-clean-plugin \
 maven-clean-plugin-javadoc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/maven-clean-plugin-3.3.2-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "34e21583e786854bd70a24665ccf7c2867d1ab6f9c47e7fbb662e803fb075c90"

URI_x86_64_v2_maven-clean-plugin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/maven-clean-plugin-3.3.2-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_maven-clean-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-clean-plugin}"
SRC_URI[x86_64_v2_maven-clean-plugin.sha256sum] = "a8db48c3434083e4e1288e8d35d6898ace697161d3f0251c603ab0376f0ad0b1"

URI_x86_64_v2_maven-clean-plugin-javadoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/maven-clean-plugin-javadoc-3.3.2-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_maven-clean-plugin-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-clean-plugin-javadoc}"
SRC_URI[x86_64_v2_maven-clean-plugin-javadoc.sha256sum] = "2097e47330d294b91d31f4e63e4883e127d8fdcbfe979bd2ee82f3190a908c7f"

URI_aarch64_maven-clean-plugin = "${EPEL_MIRROR}/aarch64/Packages/m/maven-clean-plugin-3.3.2-6.el10_0.noarch.rpm;name=aarch64_maven-clean-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-clean-plugin}"
SRC_URI[aarch64_maven-clean-plugin.sha256sum] = "944cf54f32e9bc7eab9dfedf5bb163768b395cd10f3e25e9fbb7e9b27945639e"

URI_aarch64_maven-clean-plugin-javadoc = "${EPEL_MIRROR}/aarch64/Packages/m/maven-clean-plugin-javadoc-3.3.2-6.el10_0.noarch.rpm;name=aarch64_maven-clean-plugin-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-clean-plugin-javadoc}"
SRC_URI[aarch64_maven-clean-plugin-javadoc.sha256sum] = "5a94913956a8e8a2984b3e9a53be5f9b36b43502dffc61b63f4fdd989321781b"

RDEPENDS:maven-clean-plugin = " \
 javapackages-filesystem \
 plexus-utils \
 "
RDEPENDS:maven-clean-plugin-javadoc = " \
 javapackages-filesystem \
 "
