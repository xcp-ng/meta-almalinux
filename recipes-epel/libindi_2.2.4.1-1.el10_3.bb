# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libindi"
PV = "2.2.4.1"
PR = "1.el10_3"
PACKAGES = " \
 libindi \
 libindi-devel \
 libindi-libs \
 libindi-qt \
 libindi-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libindi-2.2.4.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c4841bb3be6b9d141bd2c56fb343654df27eef9665bc0ac06c83bb759de08693"

URI_x86_64_v2_libindi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libindi-2.2.4.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libindi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libindi}"
SRC_URI[x86_64_v2_libindi.sha256sum] = "bae839960191aeeaa5c12467e466698aa0d6a6a1f4aa2691bf78f7d06f0f4f5e"

URI_x86_64_v2_libindi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libindi-devel-2.2.4.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libindi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libindi-devel}"
SRC_URI[x86_64_v2_libindi-devel.sha256sum] = "ab3a106ff740482a4b97131ba0f8d55fc7133e7fd343c9232142aecb2ac2df29"

URI_x86_64_v2_libindi-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libindi-libs-2.2.4.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libindi-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libindi-libs}"
SRC_URI[x86_64_v2_libindi-libs.sha256sum] = "09bd1306b71794a0c86d56cb4e7400cd333e2e627521dfb050ecadc22e0528d2"

URI_x86_64_v2_libindi-qt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libindi-qt-2.2.4.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libindi-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libindi-qt}"
SRC_URI[x86_64_v2_libindi-qt.sha256sum] = "08ac68d573f4d1ef2a0c16df619bfdee6f9894187b1138e355e118a4373bbdbe"

URI_x86_64_v2_libindi-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libindi-static-2.2.4.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libindi-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libindi-static}"
SRC_URI[x86_64_v2_libindi-static.sha256sum] = "171c97aba4780d6504c679c34c455776f1dea80d84d9a7100b06b03ff9bb18cd"

URI_aarch64_libindi = "${EPEL_MIRROR}/aarch64/Packages/l/libindi-2.2.4.1-1.el10_3.aarch64.rpm;name=aarch64_libindi;unpack=0"
SRC_URI:append = " ${URI_aarch64_libindi}"
SRC_URI[aarch64_libindi.sha256sum] = "eb52db0bbfc9efcddc0e4cd78d87bb755a332cdce1c2ef063c04ee1a6bd47b20"

URI_aarch64_libindi-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libindi-devel-2.2.4.1-1.el10_3.aarch64.rpm;name=aarch64_libindi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libindi-devel}"
SRC_URI[aarch64_libindi-devel.sha256sum] = "48010ed6f0aeefc1418dc7395fb0b52b18d8597adf649f9b3d1528ece270732c"

URI_aarch64_libindi-libs = "${EPEL_MIRROR}/aarch64/Packages/l/libindi-libs-2.2.4.1-1.el10_3.aarch64.rpm;name=aarch64_libindi-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libindi-libs}"
SRC_URI[aarch64_libindi-libs.sha256sum] = "180df776ea14a2c7ab109d154af2f4985c97cee7969231b99f469d8d9fb1a6e0"

URI_aarch64_libindi-qt = "${EPEL_MIRROR}/aarch64/Packages/l/libindi-qt-2.2.4.1-1.el10_3.aarch64.rpm;name=aarch64_libindi-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_libindi-qt}"
SRC_URI[aarch64_libindi-qt.sha256sum] = "a96a1783637bd51ce906d52ef50e16f2f5b0658b3574f49ac51f384d4b2385bc"

URI_aarch64_libindi-static = "${EPEL_MIRROR}/aarch64/Packages/l/libindi-static-2.2.4.1-1.el10_3.aarch64.rpm;name=aarch64_libindi-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libindi-static}"
SRC_URI[aarch64_libindi-static.sha256sum] = "41b52af1e3a82da537bdd5fec102152d0bcc0c7b75d7bdf87113d0197dc5e6f9"

RDEPENDS:libindi = " \
 cfitsio \
 glibc \
 hidapi \
 libev \
 libgcc \
 libindi-libs \
 libnova \
 libstdc++ \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:libindi-devel = " \
 libindi-libs \
 libindi-qt \
 libindi-static \
 pkgconf-pkg-config \
 "
RDEPENDS:libindi-libs = " \
 cfitsio \
 fftw-libs-double \
 glibc \
 gsl \
 hidapi \
 libXISF \
 libgcc \
 libjpeg-turbo \
 libnova \
 libogg \
 libstdc++ \
 libtheora \
 libusb1 \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:libindi-qt = " \
 glibc \
 libgcc \
 libindi-libs \
 libnova \
 libstdc++ \
 qt6-qtbase \
 zlib-ng-compat \
 "
RDEPENDS:libindi-static = " \
 libindi-libs \
 "
