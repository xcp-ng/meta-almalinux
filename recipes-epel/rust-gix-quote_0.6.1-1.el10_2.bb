# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-quote"
PV = "0.6.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-quote+default-devel \
 rust-gix-quote-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-quote-0.6.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce93cb9a35ad06b35cf097ddc1a6c4542db321fe09400ba3a4059ce4badb83c6"

URI_x86_64_v2_rust-gix-quote+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-quote+default-devel-0.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-quote+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-quote+default-devel}"
SRC_URI[x86_64_v2_rust-gix-quote+default-devel.sha256sum] = "9371c284db1be8a6de68f7662c7a1db5fe58b8a997351276ebe134c5ae4f0c31"

URI_x86_64_v2_rust-gix-quote-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-quote-devel-0.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-quote-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-quote-devel}"
SRC_URI[x86_64_v2_rust-gix-quote-devel.sha256sum] = "769069485bfab41e86a3d4c746a0177c1636ed674e6cefe2ac8ec4047868cd3c"

URI_aarch64_rust-gix-quote+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-quote+default-devel-0.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-quote+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-quote+default-devel}"
SRC_URI[aarch64_rust-gix-quote+default-devel.sha256sum] = "cf6dd32f5b721bfa73446cfaab73ca334555546c2f4766818c6217d1d5ff967b"

URI_aarch64_rust-gix-quote-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-quote-devel-0.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-quote-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-quote-devel}"
SRC_URI[aarch64_rust-gix-quote-devel.sha256sum] = "bd1705328e53537cad88900b375bdc689426be6ef8664feae485175ee88919ed"

RDEPENDS:rust-gix-quote+default-devel = " \
 cargo \
 rust-gix-quote-devel \
 "
RDEPENDS:rust-gix-quote-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-utils+default-devel \
 rust-thiserror+default-devel \
 "
