# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "platform"
PV = "2.1.0.1"
PR = "21.el10_0"
PACKAGES = " \
 platform \
 platform-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/platform-2.1.0.1-21.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6b32c39f965725a8b3100c065b30ae410e18ddd1f7bb7eda89e4c27251f5048c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/platform-2.1.0.1-21.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_platform;unpack=0"
SRC_URI[x86_64_v2_platform.sha256sum] = "4e4fb14225767a8b556c3b6b437e9fa95cdae4c8bfb6be9f0f95011bd18bd2dd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/platform-devel-2.1.0.1-21.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_platform-devel;unpack=0"
SRC_URI[x86_64_v2_platform-devel.sha256sum] = "b7b40cb0c9c827e2a180ad1c7369ba0f5397b42fcecd00a22786716c3a9ef3f8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/platform-2.1.0.1-21.el10_0.aarch64.rpm;name=aarch64_platform;unpack=0"
SRC_URI[aarch64_platform.sha256sum] = "370649a808114cc479687fbd0e68338ccd50729857da9a65aa4679ed5e80eb49"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/platform-devel-2.1.0.1-21.el10_0.aarch64.rpm;name=aarch64_platform-devel;unpack=0"
SRC_URI[aarch64_platform-devel.sha256sum] = "2295b30bab848e113f8957c0347e8a57d07167bdeca158018b9e8d5d211b3718"

RDEPENDS:platform = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:platform-devel = " \
 cmake \
 pkgconf-pkg-config \
 platform \
 "
