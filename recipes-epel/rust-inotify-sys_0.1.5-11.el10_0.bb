# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-inotify-sys"
PV = "0.1.5"
PR = "11.el10_0"
PACKAGES = " \
 rust-inotify-sys+default-devel \
 rust-inotify-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-inotify-sys-0.1.5-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a4a8b97f5160e270e7a223bc76873184ff21b261aa63deb127bddda2e2040aaf"

URI_x86_64_v2_rust-inotify-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inotify-sys+default-devel-0.1.5-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inotify-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inotify-sys+default-devel}"
SRC_URI[x86_64_v2_rust-inotify-sys+default-devel.sha256sum] = "8c6e77cdf3d3715d50cca634cd9d7882a0443307a3c96042ce1c78aafc245bec"

URI_x86_64_v2_rust-inotify-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inotify-sys-devel-0.1.5-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inotify-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inotify-sys-devel}"
SRC_URI[x86_64_v2_rust-inotify-sys-devel.sha256sum] = "9786d7859f163e4e2e6e8d508824892222fcd364b1cf4bb916bd335b048c4b04"

URI_aarch64_rust-inotify-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inotify-sys+default-devel-0.1.5-11.el10_0.noarch.rpm;name=aarch64_rust-inotify-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inotify-sys+default-devel}"
SRC_URI[aarch64_rust-inotify-sys+default-devel.sha256sum] = "cf9e399c7fd43b34dee2750a0abab71fad885e0a4943ea8033e670c8f7a9cd40"

URI_aarch64_rust-inotify-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inotify-sys-devel-0.1.5-11.el10_0.noarch.rpm;name=aarch64_rust-inotify-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inotify-sys-devel}"
SRC_URI[aarch64_rust-inotify-sys-devel.sha256sum] = "302388acd7975ad6115713c49a3c1b4a1ad0dc0a521dab704a2f7c683afc3c03"

RDEPENDS:rust-inotify-sys+default-devel = " \
 cargo \
 rust-inotify-sys-devel \
 "
RDEPENDS:rust-inotify-sys-devel = " \
 cargo \
 rust-libc+default-devel \
 "
