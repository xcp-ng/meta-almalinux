# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rtl-sdr"
PV = "2.0.1"
PR = "3.el10_0"
PACKAGES = " \
 rtl-sdr \
 rtl-sdr-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rtl-sdr-2.0.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9c924c49c9402da9d8f1e617e76d1d9c70d77aa4f8a2609b0b3910a7194537f5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rtl-sdr-2.0.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rtl-sdr;unpack=0"
SRC_URI[x86_64_v2_rtl-sdr.sha256sum] = "fe81bdf7cf384d3f206af2a67032d280130cc07f7e23b713484186defe77ce18"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rtl-sdr-devel-2.0.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rtl-sdr-devel;unpack=0"
SRC_URI[x86_64_v2_rtl-sdr-devel.sha256sum] = "9b6d881d3f43afc7898e4b72677afa382e9be29eb238746b8a5420f6f24644e9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rtl-sdr-2.0.1-3.el10_0.aarch64.rpm;name=aarch64_rtl-sdr;unpack=0"
SRC_URI[aarch64_rtl-sdr.sha256sum] = "ac4c86c1a3f3569e7d42c4afe1552c57102b39727b912a76e71247660de0727f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rtl-sdr-devel-2.0.1-3.el10_0.aarch64.rpm;name=aarch64_rtl-sdr-devel;unpack=0"
SRC_URI[aarch64_rtl-sdr-devel.sha256sum] = "281a5619f1b2be274332168c87a7c8babef6cab2318ae58ac5e249f0d776ab2f"

RDEPENDS:rtl-sdr = " \
 bash \
 glibc \
 glibc-common \
 libusb1 \
 shadow-utils \
 "
RDEPENDS:rtl-sdr-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 rtl-sdr \
 "
