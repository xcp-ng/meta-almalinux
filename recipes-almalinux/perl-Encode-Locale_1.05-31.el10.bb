# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Encode-Locale"
PV = "1.05"
PR = "31.el10"
PACKAGES = " \
 perl-Encode-Locale \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Encode-Locale-1.05-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd2d67caeb30f8b4463ff14967ed522cb58f6e4dffa054cfcc69af066057becd"

URI_x86_64_v2_perl-Encode-Locale = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Encode-Locale-1.05-31.el10.noarch.rpm;name=x86_64_v2_perl-Encode-Locale;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Encode-Locale}"
SRC_URI[x86_64_v2_perl-Encode-Locale.sha256sum] = "1a7846226ee2dcb29ae55648f9f991b81c784771583e5d0fbcd7e56eff95cfbf"

URI_aarch64_perl-Encode-Locale = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Encode-Locale-1.05-31.el10.noarch.rpm;name=aarch64_perl-Encode-Locale;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Encode-Locale}"
SRC_URI[aarch64_perl-Encode-Locale.sha256sum] = "1a7846226ee2dcb29ae55648f9f991b81c784771583e5d0fbcd7e56eff95cfbf"

RDEPENDS:perl-Encode-Locale = " \
 perl-Encode \
 perl-Exporter \
 perl-I18N-Langinfo \
 perl-base \
 perl-libs \
 "
