# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "llhttp"
PV = "9.1.3"
PR = "9.el10"
PACKAGES = " \
 llhttp \
 llhttp-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/llhttp-9.1.3-9.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "025d9d06ae5b5a1c92afd13fd9666c02e17b3ff84b6a5ba12fbc381c90bf09dc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llhttp-9.1.3-9.el10.x86_64_v2.rpm;name=x86_64_v2_llhttp;unpack=0"
SRC_URI[x86_64_v2_llhttp.sha256sum] = "cf4cb69278f9d47c013a1a7a3fe511aa5c2ede0eba14b28ed8fb38b528d25a5c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/llhttp-devel-9.1.3-9.el10.x86_64_v2.rpm;name=x86_64_v2_llhttp-devel;unpack=0"
SRC_URI[x86_64_v2_llhttp-devel.sha256sum] = "e827ab4d9030b6fc7517bee7d2a303c60bc739551337c86f5db7ee02fd1e5f7d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llhttp-9.1.3-9.el10.aarch64.rpm;name=aarch64_llhttp;unpack=0"
SRC_URI[aarch64_llhttp.sha256sum] = "a20787f0c54a6c2e1183a854f44e32bf8eef4ce9d39399bb31b3fcbcb0e442d9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/llhttp-devel-9.1.3-9.el10.aarch64.rpm;name=aarch64_llhttp-devel;unpack=0"
SRC_URI[aarch64_llhttp-devel.sha256sum] = "504d50fca990d981b3b282af2e0edbb75984c9fa00f9b1c10476b7655a2b5b33"

RDEPENDS:llhttp = " \
 glibc \
 "
RDEPENDS:llhttp-devel = " \
 cmake-filesystem \
 llhttp \
 pkgconf-pkg-config \
 "
