# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "stoken"
PV = "0.93"
PR = "2.el10_2"
PACKAGES = " \
 stoken-cli \
 stoken-devel \
 stoken-gui \
 stoken-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/stoken-0.93-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2780d1e1eeb9aaca31e16bec8f7dd9f19051ce5003618406a07b92da48038b3"

URI_x86_64_v2_stoken-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stoken-cli-0.93-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stoken-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stoken-cli}"
SRC_URI[x86_64_v2_stoken-cli.sha256sum] = "7cdccc62cc01647bdd08d8d5f9f62197abb9f2b3c31ddd1edc126ed932459093"

URI_x86_64_v2_stoken-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stoken-devel-0.93-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stoken-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stoken-devel}"
SRC_URI[x86_64_v2_stoken-devel.sha256sum] = "5a514ed5254fba38d5d675379e22c90f94d015e729d2d03e9c5e5895cdbc683e"

URI_x86_64_v2_stoken-gui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stoken-gui-0.93-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stoken-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stoken-gui}"
SRC_URI[x86_64_v2_stoken-gui.sha256sum] = "97f8c65a3b6881ca2a6acca2b7dd6e73b970210ecd4036bee2f39d4411de1a68"

URI_x86_64_v2_stoken-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stoken-libs-0.93-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stoken-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stoken-libs}"
SRC_URI[x86_64_v2_stoken-libs.sha256sum] = "28877c75307ba24ee24fb2dedd528a303945ac60b91c35c431e0ac31a181e547"

URI_aarch64_stoken-cli = "${EPEL_MIRROR}/aarch64/Packages/s/stoken-cli-0.93-2.el10_2.aarch64.rpm;name=aarch64_stoken-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_stoken-cli}"
SRC_URI[aarch64_stoken-cli.sha256sum] = "e6b734fde71d11532ac5d0cc6135ab6e8c478b606e663203f8c26071b0829ab1"

URI_aarch64_stoken-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stoken-devel-0.93-2.el10_2.aarch64.rpm;name=aarch64_stoken-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stoken-devel}"
SRC_URI[aarch64_stoken-devel.sha256sum] = "56bf46a631831a2c515cc566fb14a3c728e536b6b659a78a06abb9effffb4388"

URI_aarch64_stoken-gui = "${EPEL_MIRROR}/aarch64/Packages/s/stoken-gui-0.93-2.el10_2.aarch64.rpm;name=aarch64_stoken-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_stoken-gui}"
SRC_URI[aarch64_stoken-gui.sha256sum] = "93b8a5c61639b6d90e712102a46ca0492e24a1e724da5c246182d1a0394ac7fe"

URI_aarch64_stoken-libs = "${EPEL_MIRROR}/aarch64/Packages/s/stoken-libs-0.93-2.el10_2.aarch64.rpm;name=aarch64_stoken-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_stoken-libs}"
SRC_URI[aarch64_stoken-libs.sha256sum] = "2a8c038225a554c9fe0eb8019f269576e5326db495078f6545f5709a175dca51"

RDEPENDS:stoken-cli = " \
 glibc \
 stoken-libs \
 "
RDEPENDS:stoken-devel = " \
 gmp-devel \
 libxml2-devel \
 nettle-devel \
 pkgconf-pkg-config \
 stoken-libs \
 "
RDEPENDS:stoken-gui = " \
 cairo \
 glib2 \
 glibc \
 gtk3 \
 stoken-libs \
 "
RDEPENDS:stoken-libs = " \
 glibc \
 gmp \
 libxml2 \
 nettle \
 "
