# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyghmi"
PV = "1.6.16"
PR = "2.el10_3"
PACKAGES = " \
 python-pyghmi-doc \
 python3-pyghmi \
 python3-pyghmi-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyghmi-1.6.16-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e32f41669fd79cbd7cd820a9022dc98d6cfd52afb7fe9d6667f39cb7a2c124d5"

URI_x86_64_v2_python-pyghmi-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-pyghmi-doc-1.6.16-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-pyghmi-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-pyghmi-doc}"
SRC_URI[x86_64_v2_python-pyghmi-doc.sha256sum] = "6e2c7fae285612677493b0afb6e35c0b997e4ec34a02e56439d0f91e2ddf0aad"

URI_x86_64_v2_python3-pyghmi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyghmi-1.6.16-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pyghmi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyghmi}"
SRC_URI[x86_64_v2_python3-pyghmi.sha256sum] = "3544344d650cfb863b1c8e8f0a80bd34bd27a8549b65f47e73250df43b96acbf"

URI_x86_64_v2_python3-pyghmi-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyghmi-tests-1.6.16-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pyghmi-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyghmi-tests}"
SRC_URI[x86_64_v2_python3-pyghmi-tests.sha256sum] = "241be731046f4c2e670b5c57213a93c15c23066aebaa11bdf962bd26670863ae"

URI_aarch64_python-pyghmi-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-pyghmi-doc-1.6.16-2.el10_3.noarch.rpm;name=aarch64_python-pyghmi-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-pyghmi-doc}"
SRC_URI[aarch64_python-pyghmi-doc.sha256sum] = "57b28775d45ba77b8b9110b0620a028e74937a2c9e431f83e9d699a1ea049c97"

URI_aarch64_python3-pyghmi = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyghmi-1.6.16-2.el10_3.noarch.rpm;name=aarch64_python3-pyghmi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyghmi}"
SRC_URI[aarch64_python3-pyghmi.sha256sum] = "4fc2cdfbc2aabeef25ec9f41faaa2ccc3279cf73460f63537f66aaea53aa3c9b"

URI_aarch64_python3-pyghmi-tests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyghmi-tests-1.6.16-2.el10_3.noarch.rpm;name=aarch64_python3-pyghmi-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyghmi-tests}"
SRC_URI[aarch64_python3-pyghmi-tests.sha256sum] = "8a11778481ee98672368922f98116a8a79babcdb3746585dee11b0b289072d76"

RDEPENDS:python-pyghmi-doc = " \
 "
RDEPENDS:python3-pyghmi = " \
 python3 \
 python3-cryptography \
 python3-dateutil \
 "
RDEPENDS:python3-pyghmi-tests = " \
 python3 \
 python3-pyghmi \
 "
