# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tcltls"
PV = "2.0.1"
PR = "2.el10_2"
PACKAGES = " \
 tcltls \
 tcltls-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/t/tcltls-2.0.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0a5736b1b91be9bb3a6e353502368de823cdc4a07814428c3900648b0ee8f73b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tcltls-2.0.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tcltls;unpack=0"
SRC_URI[x86_64_v2_tcltls.sha256sum] = "9c151a800daac0f3f17fc518325e6cdcd45d45ae040c5f192d07f42c80917b18"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tcltls-devel-2.0.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tcltls-devel;unpack=0"
SRC_URI[x86_64_v2_tcltls-devel.sha256sum] = "012af1fe359132cf79bc410d527447d89fb7122ac9f7328be979b61d5c0ffa90"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/tcltls-2.0.1-2.el10_2.aarch64.rpm;name=aarch64_tcltls;unpack=0"
SRC_URI[aarch64_tcltls.sha256sum] = "bc6d50eab1159443f3e268b4aef12f6c86503d6bd5403c9574b2325a1ce0d082"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/tcltls-devel-2.0.1-2.el10_2.aarch64.rpm;name=aarch64_tcltls-devel;unpack=0"
SRC_URI[aarch64_tcltls-devel.sha256sum] = "8df7ba1b0569e69c6f78f34de0ffd399aae861412b6390984c22ef1b9d757ecb"

RDEPENDS:tcltls = " \
 glibc \
 openssl-libs \
 tcl \
 "
RDEPENDS:tcltls-devel = " \
 tcltls \
 "
