# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-novaclient"
PE = "1"
PV = "18.12.0"
PR = "1.el10_2"
PACKAGES = " \
 python-novaclient-doc \
 python3-novaclient \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-novaclient-18.12.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "096dd13c7303a0299ef64cfe157d2d662a1727ae53e520b2503fad7b30b71e22"

URI_x86_64_v2_python-novaclient-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-novaclient-doc-18.12.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-novaclient-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-novaclient-doc}"
SRC_URI[x86_64_v2_python-novaclient-doc.sha256sum] = "bc406389ebac1f89d6649d654672e702c015fa5f5470f0739a44efa56f041a28"

URI_x86_64_v2_python3-novaclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-novaclient-18.12.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-novaclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-novaclient}"
SRC_URI[x86_64_v2_python3-novaclient.sha256sum] = "67df1ef23cb073d935e51461f28d78a0c54fdf23ba24a79ff9da8ce086d29985"

URI_aarch64_python-novaclient-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-novaclient-doc-18.12.0-1.el10_2.noarch.rpm;name=aarch64_python-novaclient-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-novaclient-doc}"
SRC_URI[aarch64_python-novaclient-doc.sha256sum] = "e854958569a14f9536bdeb28170f8b9d1529221d098670e6d33b0957bd521c9a"

URI_aarch64_python3-novaclient = "${EPEL_MIRROR}/aarch64/Packages/p/python3-novaclient-18.12.0-1.el10_2.noarch.rpm;name=aarch64_python3-novaclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-novaclient}"
SRC_URI[aarch64_python3-novaclient.sha256sum] = "b4f268ad7b9481250928efdbeb4d5957f4f79cdd184860dd618704b7bc95aa0d"

RDEPENDS:python-novaclient-doc = " \
 "
RDEPENDS:python3-novaclient = " \
 python3 \
 python3-iso8601 \
 python3-keystoneauth1 \
 python3-oslo-i18n \
 python3-oslo-serialization \
 python3-oslo-utils \
 python3-pbr \
 python3-prettytable \
 python3-stevedore \
 "
