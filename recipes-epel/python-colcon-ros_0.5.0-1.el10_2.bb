# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-ros"
PV = "0.5.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-colcon-ros \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-ros-0.5.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "49ad373afa2a0fc53138189d66ddf9bc36551f158543ed893b0b2ea5281c3115"

URI_x86_64_v2_python3-colcon-ros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-ros-0.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-ros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-ros}"
SRC_URI[x86_64_v2_python3-colcon-ros.sha256sum] = "2e4e9a486baddb543c45fb8307e2f20e555695abf14e3bf6ce5acff2649853f6"

URI_aarch64_python3-colcon-ros = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-ros-0.5.0-1.el10_2.noarch.rpm;name=aarch64_python3-colcon-ros;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-ros}"
SRC_URI[aarch64_python3-colcon-ros.sha256sum] = "f56ae60a8afa4fd0cda18072b1271d3ede4a81d441a43d6a2c1c0c9aab77c5a0"

RDEPENDS:python3-colcon-ros = " \
 python3 \
 python3-catkin_pkg \
 python3-colcon-cmake \
 python3-colcon-core \
 python3-colcon-pkg-config \
 python3-colcon-python-setup-py \
 python3-colcon-recursive-crawl \
 "
