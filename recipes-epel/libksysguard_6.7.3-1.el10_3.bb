# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libksysguard"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 libksysguard \
 libksysguard-common \
 libksysguard-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libksysguard-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eaa4def26b939b9ba3271b5ce84f7dbd823e8db2b3b5d0636881a4a768ee482d"

URI_x86_64_v2_libksysguard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksysguard-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libksysguard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libksysguard}"
SRC_URI[x86_64_v2_libksysguard.sha256sum] = "0cd8fedae3f54d86aabbdf4d9d5e6d94e32af5b4f3b1351fdfab495c1865214f"

URI_x86_64_v2_libksysguard-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksysguard-common-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libksysguard-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libksysguard-common}"
SRC_URI[x86_64_v2_libksysguard-common.sha256sum] = "e62c30dfecdf026e551957a703986dc54be719bea7c55deddaee1a5538128b59"

URI_x86_64_v2_libksysguard-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksysguard-devel-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libksysguard-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libksysguard-devel}"
SRC_URI[x86_64_v2_libksysguard-devel.sha256sum] = "91126a0dfcd47ef2e9247c5983f7f9967fbc209ce347a854ed100e2ab271eae2"

URI_aarch64_libksysguard = "${EPEL_MIRROR}/aarch64/Packages/l/libksysguard-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_libksysguard;unpack=0"
SRC_URI:append = " ${URI_aarch64_libksysguard}"
SRC_URI[aarch64_libksysguard.sha256sum] = "a8765f2614677c3516ee73abb6cd2196b5e9ca820eb7d7ec07c0453f6ebb0884"

URI_aarch64_libksysguard-common = "${EPEL_MIRROR}/aarch64/Packages/l/libksysguard-common-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_libksysguard-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_libksysguard-common}"
SRC_URI[aarch64_libksysguard-common.sha256sum] = "802694b07afc371039f2e44da83595c5a93837806c524a7eceed7ff20bca6cbd"

URI_aarch64_libksysguard-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libksysguard-devel-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_libksysguard-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libksysguard-devel}"
SRC_URI[aarch64_libksysguard-devel.sha256sum] = "bc4e357c68710e1526b40caf45574a8490ba13faf7feb4a8f82148989b9ad624"

RDEPENDS:libksysguard = " \
 glibc \
 kf6-kauth \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kpackage \
 kf6-kservice \
 kf6-solid \
 libdrm \
 libgcc \
 libksysguard-common \
 libnl3 \
 libpcap \
 libstdc++ \
 lm_sensors-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:libksysguard-common = " \
 glibc \
 kf6-kauth \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:libksysguard-devel = " \
 cmake-filesystem \
 kf6-kconfig-devel \
 kf6-ki18n-devel \
 kf6-kiconthemes-devel \
 libksysguard \
 qt6-qtbase-devel \
 "
