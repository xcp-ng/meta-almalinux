# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-no-std-net"
PV = "0.6.0"
PR = "6.el10_1"
PACKAGES = " \
 rust-no-std-net+default-devel \
 rust-no-std-net+i128-devel \
 rust-no-std-net+serde-devel \
 rust-no-std-net+std-devel \
 rust-no-std-net-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-no-std-net-0.6.0-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4acc0c762a0090a2d030140984038e76e9678cddfbf04afb2cf1846ceae4c389"

URI_x86_64_v2_rust-no-std-net+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-no-std-net+default-devel-0.6.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-no-std-net+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-no-std-net+default-devel}"
SRC_URI[x86_64_v2_rust-no-std-net+default-devel.sha256sum] = "776535a8963674cf0888cdb98abe0857487cfb5a2c24902a4f5b54b02ec15b5e"

URI_x86_64_v2_rust-no-std-net+i128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-no-std-net+i128-devel-0.6.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-no-std-net+i128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-no-std-net+i128-devel}"
SRC_URI[x86_64_v2_rust-no-std-net+i128-devel.sha256sum] = "577a2d9a3ba9d021674dbc533b4fb36273f0984e578e86fb6f8cc2c87778e8e0"

URI_x86_64_v2_rust-no-std-net+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-no-std-net+serde-devel-0.6.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-no-std-net+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-no-std-net+serde-devel}"
SRC_URI[x86_64_v2_rust-no-std-net+serde-devel.sha256sum] = "d12ed30827adf229a760a735182b3052b12c5dcc14119dd857211e066b55d831"

URI_x86_64_v2_rust-no-std-net+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-no-std-net+std-devel-0.6.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-no-std-net+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-no-std-net+std-devel}"
SRC_URI[x86_64_v2_rust-no-std-net+std-devel.sha256sum] = "010def0890ded6cee22d4c01780b6d22724539b98a82a3f3ca3524cc3aea6026"

URI_x86_64_v2_rust-no-std-net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-no-std-net-devel-0.6.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-no-std-net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-no-std-net-devel}"
SRC_URI[x86_64_v2_rust-no-std-net-devel.sha256sum] = "25c4093fda4e466ada2de403bbc215b40dcddbecc482eb342fa7a6eaa7bf6d90"

URI_aarch64_rust-no-std-net+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-no-std-net+default-devel-0.6.0-6.el10_1.noarch.rpm;name=aarch64_rust-no-std-net+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-no-std-net+default-devel}"
SRC_URI[aarch64_rust-no-std-net+default-devel.sha256sum] = "e7d84a7303ba831cec748c903c9ec763d48f8d9e0a91ac6657d3824587acaa47"

URI_aarch64_rust-no-std-net+i128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-no-std-net+i128-devel-0.6.0-6.el10_1.noarch.rpm;name=aarch64_rust-no-std-net+i128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-no-std-net+i128-devel}"
SRC_URI[aarch64_rust-no-std-net+i128-devel.sha256sum] = "74fe1b6109553290b0b79973f8dfb6e6223d9ebcc4ceeabf142cf64f411c33af"

URI_aarch64_rust-no-std-net+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-no-std-net+serde-devel-0.6.0-6.el10_1.noarch.rpm;name=aarch64_rust-no-std-net+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-no-std-net+serde-devel}"
SRC_URI[aarch64_rust-no-std-net+serde-devel.sha256sum] = "6ca2237d2409275453af704777515e57c768f933feb45d8fbe430afda0560e8f"

URI_aarch64_rust-no-std-net+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-no-std-net+std-devel-0.6.0-6.el10_1.noarch.rpm;name=aarch64_rust-no-std-net+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-no-std-net+std-devel}"
SRC_URI[aarch64_rust-no-std-net+std-devel.sha256sum] = "b4104a23568ce7a3255f587a00bf96282af2d1022b0dd65c9b9a2d5175d90054"

URI_aarch64_rust-no-std-net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-no-std-net-devel-0.6.0-6.el10_1.noarch.rpm;name=aarch64_rust-no-std-net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-no-std-net-devel}"
SRC_URI[aarch64_rust-no-std-net-devel.sha256sum] = "260438eb1d84d2da1d78c20704d4aebc038a4b7eb2f727745868f7e3660b03f5"

RDEPENDS:rust-no-std-net+default-devel = " \
 cargo \
 rust-no-std-net-devel \
 "
RDEPENDS:rust-no-std-net+i128-devel = " \
 cargo \
 rust-no-std-net-devel \
 "
RDEPENDS:rust-no-std-net+serde-devel = " \
 cargo \
 rust-no-std-net-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-no-std-net+std-devel = " \
 cargo \
 rust-no-std-net-devel \
 "
RDEPENDS:rust-no-std-net-devel = " \
 cargo \
 "
