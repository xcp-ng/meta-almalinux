# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "byacc"
PV = "2.0.20230521"
PR = "7.el10"
PACKAGES = " \
 byacc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/byacc-2.0.20230521-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d27a846c0067d952eea2a196f8fccc439acb40d52655c086bafdb2f9ad1841d7"

URI_x86_64_v2_byacc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/byacc-2.0.20230521-7.el10.x86_64_v2.rpm;name=x86_64_v2_byacc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_byacc}"
SRC_URI[x86_64_v2_byacc.sha256sum] = "1a6026e3c4f372efe71e66e82498f36faf3b884067c82a1601c53e8a709932e9"

URI_aarch64_byacc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/byacc-2.0.20230521-7.el10.aarch64.rpm;name=aarch64_byacc;unpack=0"
SRC_URI:append = " ${URI_aarch64_byacc}"
SRC_URI[aarch64_byacc.sha256sum] = "83efd1fa866110e2f9db565a10cbbe78c1ee277e5e709890ab8dfdf6cf40492f"

RDEPENDS:byacc = " \
 glibc \
 "
