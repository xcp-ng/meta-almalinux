# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kglobalacceld"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 kglobalacceld \
 kglobalacceld-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kglobalacceld-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1222e65e6a7711e0bdc6f6af8e731f0e00f172769a6aba6050a6caceec95c433"

URI_x86_64_v2_kglobalacceld = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kglobalacceld-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kglobalacceld;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kglobalacceld}"
SRC_URI[x86_64_v2_kglobalacceld.sha256sum] = "3171bfc0218544632875e614bf072394bc55cd9bcea59600f9d78fa105ca6b84"

URI_x86_64_v2_kglobalacceld-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kglobalacceld-devel-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kglobalacceld-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kglobalacceld-devel}"
SRC_URI[x86_64_v2_kglobalacceld-devel.sha256sum] = "eb0535ae5404c8745c7936d8d954be86ade12e5ff74f8e5d67901bc6aadbec32"

URI_aarch64_kglobalacceld = "${EPEL_MIRROR}/aarch64/Packages/k/kglobalacceld-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_kglobalacceld;unpack=0"
SRC_URI:append = " ${URI_aarch64_kglobalacceld}"
SRC_URI[aarch64_kglobalacceld.sha256sum] = "2f2a02f6a12972b79e0c6228d4e90b3af64da18d0d39e9429d3b69eb12cc5581"

URI_aarch64_kglobalacceld-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kglobalacceld-devel-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_kglobalacceld-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kglobalacceld-devel}"
SRC_URI[aarch64_kglobalacceld-devel.sha256sum] = "593a18557ae6aa0d2239e89a01b3b0773f5b6cc54c414566739179d774676328"

RDEPENDS:kglobalacceld = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-kservice \
 kf6-kwindowsystem \
 libX11 \
 libstdc++ \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 xcb-util-keysyms \
 "
RDEPENDS:kglobalacceld-devel = " \
 cmake-filesystem \
 kglobalacceld \
 qt6-qtbase-devel \
 "
