# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-snapbox0.6"
PV = "0.6.24"
PR = "1.el10_2"
PACKAGES = " \
 rust-snapbox0.6+cmd-devel \
 rust-snapbox0.6+color-auto-devel \
 rust-snapbox0.6+color-devel \
 rust-snapbox0.6+debug-devel \
 rust-snapbox0.6+default-devel \
 rust-snapbox0.6+detect-encoding-devel \
 rust-snapbox0.6+diff-devel \
 rust-snapbox0.6+dir-devel \
 rust-snapbox0.6+document-features-devel \
 rust-snapbox0.6+examples-devel \
 rust-snapbox0.6+json-devel \
 rust-snapbox0.6+path-devel \
 rust-snapbox0.6+regex-devel \
 rust-snapbox0.6+structured-data-devel \
 rust-snapbox0.6+term-svg-devel \
 rust-snapbox0.6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-snapbox0.6-0.6.24-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d7d8f9786b306442610c873f276792ec18c14b242a4b8e6da44f3e82ee2cd33"

URI_x86_64_v2_rust-snapbox0.6+cmd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox0.6+cmd-devel-0.6.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox0.6+cmd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox0.6+cmd-devel}"
SRC_URI[x86_64_v2_rust-snapbox0.6+cmd-devel.sha256sum] = "4826f87944556c0551e9a838a044c7aec7c61ee5eb1fa2c29a2f631cd1071512"

URI_x86_64_v2_rust-snapbox0.6+color-auto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox0.6+color-auto-devel-0.6.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox0.6+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox0.6+color-auto-devel}"
SRC_URI[x86_64_v2_rust-snapbox0.6+color-auto-devel.sha256sum] = "6b16c8e25dfba53a7d7e7f0763b1b720c882a469b5e088d1516dcd43c9441705"

URI_x86_64_v2_rust-snapbox0.6+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox0.6+color-devel-0.6.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox0.6+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox0.6+color-devel}"
SRC_URI[x86_64_v2_rust-snapbox0.6+color-devel.sha256sum] = "87a5e18f8e6ad807819e274b990225c7116da6fd170a171bc3472c7b87c64f94"

URI_x86_64_v2_rust-snapbox0.6+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox0.6+debug-devel-0.6.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox0.6+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox0.6+debug-devel}"
SRC_URI[x86_64_v2_rust-snapbox0.6+debug-devel.sha256sum] = "1a2de66c8a4940b292f4ef2a6be715e3cc22bbc355f88bc531bc8c94ceae0bd7"

URI_x86_64_v2_rust-snapbox0.6+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox0.6+default-devel-0.6.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox0.6+default-devel}"
SRC_URI[x86_64_v2_rust-snapbox0.6+default-devel.sha256sum] = "c443d420411f7c44a7f2f4f559e167212645e7fbcd04d8b38d342b74652884bd"

URI_x86_64_v2_rust-snapbox0.6+detect-encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox0.6+detect-encoding-devel-0.6.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox0.6+detect-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox0.6+detect-encoding-devel}"
SRC_URI[x86_64_v2_rust-snapbox0.6+detect-encoding-devel.sha256sum] = "c6febcc96d63012fc49d587195a0a258d1bf0612cf24254b5e652496c03647a2"

URI_x86_64_v2_rust-snapbox0.6+diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox0.6+diff-devel-0.6.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox0.6+diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox0.6+diff-devel}"
SRC_URI[x86_64_v2_rust-snapbox0.6+diff-devel.sha256sum] = "9a92b2da53b73ed30ce4e3dfbe375ecd3bf3756300932ef407c256bbaac11445"

URI_x86_64_v2_rust-snapbox0.6+dir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox0.6+dir-devel-0.6.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox0.6+dir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox0.6+dir-devel}"
SRC_URI[x86_64_v2_rust-snapbox0.6+dir-devel.sha256sum] = "3a1dced73475ec6b9bc5d6d883b02411b4f0e62dd09a1877445fb0826d2d2ab2"

URI_x86_64_v2_rust-snapbox0.6+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox0.6+document-features-devel-0.6.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox0.6+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox0.6+document-features-devel}"
SRC_URI[x86_64_v2_rust-snapbox0.6+document-features-devel.sha256sum] = "117ef25e1807c18304932e56bf9dfe0cf23f680649ac045982ded67ae7cf638a"

URI_x86_64_v2_rust-snapbox0.6+examples-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox0.6+examples-devel-0.6.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox0.6+examples-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox0.6+examples-devel}"
SRC_URI[x86_64_v2_rust-snapbox0.6+examples-devel.sha256sum] = "8a4ff926e9175226bf011d25f62a3a2a9425fc0e5a8da250b543158cf3efc7a7"

URI_x86_64_v2_rust-snapbox0.6+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox0.6+json-devel-0.6.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox0.6+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox0.6+json-devel}"
SRC_URI[x86_64_v2_rust-snapbox0.6+json-devel.sha256sum] = "e9ac6f22be95ba52aa946a53d30c4d2187d028c24b121d0022106bcded6d3928"

URI_x86_64_v2_rust-snapbox0.6+path-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox0.6+path-devel-0.6.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox0.6+path-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox0.6+path-devel}"
SRC_URI[x86_64_v2_rust-snapbox0.6+path-devel.sha256sum] = "19daba2d3b148aceabd553a9ace09cc879ae70e063709a9a3584e814a052f98a"

URI_x86_64_v2_rust-snapbox0.6+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox0.6+regex-devel-0.6.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox0.6+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox0.6+regex-devel}"
SRC_URI[x86_64_v2_rust-snapbox0.6+regex-devel.sha256sum] = "7b9486b869ca17d0464063e674b8f7f46b0e16ba495a0a7cb466677a9772c358"

URI_x86_64_v2_rust-snapbox0.6+structured-data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox0.6+structured-data-devel-0.6.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox0.6+structured-data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox0.6+structured-data-devel}"
SRC_URI[x86_64_v2_rust-snapbox0.6+structured-data-devel.sha256sum] = "c53b3de7098b4b0c737d939b9a4a6d68d169b22c6d79006f3d8100b22d153c4c"

URI_x86_64_v2_rust-snapbox0.6+term-svg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox0.6+term-svg-devel-0.6.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox0.6+term-svg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox0.6+term-svg-devel}"
SRC_URI[x86_64_v2_rust-snapbox0.6+term-svg-devel.sha256sum] = "7cac9c0cfe305f492b0c412c1ba324472b7cdb373e4b8645c94b0f41bfe5b860"

URI_x86_64_v2_rust-snapbox0.6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox0.6-devel-0.6.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox0.6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox0.6-devel}"
SRC_URI[x86_64_v2_rust-snapbox0.6-devel.sha256sum] = "c18c0bcc5a62add30f7d440eeafb6576c04acd47eef5c4548c610ef7a0fdd7ea"

URI_aarch64_rust-snapbox0.6+cmd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox0.6+cmd-devel-0.6.24-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox0.6+cmd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox0.6+cmd-devel}"
SRC_URI[aarch64_rust-snapbox0.6+cmd-devel.sha256sum] = "58ae88ff402c88ead54b7aec5bac1df71923883e15a189316395a0f4b1e8c484"

URI_aarch64_rust-snapbox0.6+color-auto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox0.6+color-auto-devel-0.6.24-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox0.6+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox0.6+color-auto-devel}"
SRC_URI[aarch64_rust-snapbox0.6+color-auto-devel.sha256sum] = "453827664268d7da1af94f2062f7706451df6c56fe68721f944e7b5f7bc77d54"

URI_aarch64_rust-snapbox0.6+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox0.6+color-devel-0.6.24-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox0.6+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox0.6+color-devel}"
SRC_URI[aarch64_rust-snapbox0.6+color-devel.sha256sum] = "f2e37e4e61a4e84d22454fa17d9307ed1a57bcfef83bf68a31f65688888e53c3"

URI_aarch64_rust-snapbox0.6+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox0.6+debug-devel-0.6.24-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox0.6+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox0.6+debug-devel}"
SRC_URI[aarch64_rust-snapbox0.6+debug-devel.sha256sum] = "50fe1c32a0b9a5f62d6721f7282ded6ca3ce14a76dc2721206a0a594a84dbca2"

URI_aarch64_rust-snapbox0.6+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox0.6+default-devel-0.6.24-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox0.6+default-devel}"
SRC_URI[aarch64_rust-snapbox0.6+default-devel.sha256sum] = "f6843079d5f63d2d4f410346dfdb82e362309520d6d4bd151b758502c3f16e61"

URI_aarch64_rust-snapbox0.6+detect-encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox0.6+detect-encoding-devel-0.6.24-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox0.6+detect-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox0.6+detect-encoding-devel}"
SRC_URI[aarch64_rust-snapbox0.6+detect-encoding-devel.sha256sum] = "e0cec9c37f38f6c580f0e69a6b10663d30282b1ccea44e0a33ae3eae2058cdaa"

URI_aarch64_rust-snapbox0.6+diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox0.6+diff-devel-0.6.24-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox0.6+diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox0.6+diff-devel}"
SRC_URI[aarch64_rust-snapbox0.6+diff-devel.sha256sum] = "dbfa59efac14ffd78812e7ee32f10897eaa87a705b6126fdfc4dd482835979c2"

URI_aarch64_rust-snapbox0.6+dir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox0.6+dir-devel-0.6.24-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox0.6+dir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox0.6+dir-devel}"
SRC_URI[aarch64_rust-snapbox0.6+dir-devel.sha256sum] = "06a7298f6f1d029e914a7471e45fa657e38b50c1160ef86722117024b377dc37"

URI_aarch64_rust-snapbox0.6+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox0.6+document-features-devel-0.6.24-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox0.6+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox0.6+document-features-devel}"
SRC_URI[aarch64_rust-snapbox0.6+document-features-devel.sha256sum] = "9aa086393bafcc14cbf2bf028c4987501982d8816ffb25cf0f55c884b7088b72"

URI_aarch64_rust-snapbox0.6+examples-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox0.6+examples-devel-0.6.24-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox0.6+examples-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox0.6+examples-devel}"
SRC_URI[aarch64_rust-snapbox0.6+examples-devel.sha256sum] = "d6cc3d172608ee23077d5e5dad0c9ff82db8a789172a6f3b841a6b60bdf43663"

URI_aarch64_rust-snapbox0.6+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox0.6+json-devel-0.6.24-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox0.6+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox0.6+json-devel}"
SRC_URI[aarch64_rust-snapbox0.6+json-devel.sha256sum] = "ba75a62206fbbb653059ae1914119bcc9b52fa2534876ad73638d1b7c7423b7c"

URI_aarch64_rust-snapbox0.6+path-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox0.6+path-devel-0.6.24-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox0.6+path-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox0.6+path-devel}"
SRC_URI[aarch64_rust-snapbox0.6+path-devel.sha256sum] = "f0cdb96bec30c21775fa0a41c9a14cb827ece3f554e49e1d3d511ea88ce93560"

URI_aarch64_rust-snapbox0.6+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox0.6+regex-devel-0.6.24-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox0.6+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox0.6+regex-devel}"
SRC_URI[aarch64_rust-snapbox0.6+regex-devel.sha256sum] = "33d1081d7a12c1bedb06109afe1b4c4f0a61798c1a47f7668c5ee7f9341c9563"

URI_aarch64_rust-snapbox0.6+structured-data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox0.6+structured-data-devel-0.6.24-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox0.6+structured-data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox0.6+structured-data-devel}"
SRC_URI[aarch64_rust-snapbox0.6+structured-data-devel.sha256sum] = "4768e9fc4b7c8438f640a4ae3a54c50175fb9a6c7ab8512e730597ced089c058"

URI_aarch64_rust-snapbox0.6+term-svg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox0.6+term-svg-devel-0.6.24-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox0.6+term-svg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox0.6+term-svg-devel}"
SRC_URI[aarch64_rust-snapbox0.6+term-svg-devel.sha256sum] = "205eb0b6377ef9cc1a32d1bdc2740f29a68970eb992c4b8905d1b9356f1aad63"

URI_aarch64_rust-snapbox0.6-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox0.6-devel-0.6.24-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox0.6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox0.6-devel}"
SRC_URI[aarch64_rust-snapbox0.6-devel.sha256sum] = "c1a45a48af72a0bcda10109a0d0c039def66c6d88304ea5f48a1d0dc3cc7f3cb"

RDEPENDS:rust-snapbox0.6+cmd-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-os_pipe+default-devel \
 rust-snapbox0.6-devel \
 rust-wait-timeout+default-devel \
 "
RDEPENDS:rust-snapbox0.6+color-auto-devel = " \
 cargo \
 rust-snapbox0.6+color-devel \
 rust-snapbox0.6-devel \
 "
RDEPENDS:rust-snapbox0.6+color-devel = " \
 cargo \
 rust-anstream0.6+default-devel \
 rust-snapbox-macros0.4+color-devel \
 rust-snapbox0.6-devel \
 "
RDEPENDS:rust-snapbox0.6+debug-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-snapbox-macros0.4+debug-devel \
 rust-snapbox0.6-devel \
 "
RDEPENDS:rust-snapbox0.6+default-devel = " \
 cargo \
 rust-snapbox0.6+color-auto-devel \
 rust-snapbox0.6+diff-devel \
 rust-snapbox0.6-devel \
 "
RDEPENDS:rust-snapbox0.6+detect-encoding-devel = " \
 cargo \
 rust-content_inspector+default-devel \
 rust-snapbox0.6-devel \
 "
RDEPENDS:rust-snapbox0.6+diff-devel = " \
 cargo \
 rust-similar2+default-devel \
 rust-similar2+inline-devel \
 rust-snapbox0.6-devel \
 "
RDEPENDS:rust-snapbox0.6+dir-devel = " \
 cargo \
 rust-dunce+default-devel \
 rust-filetime+default-devel \
 rust-snapbox0.6+detect-encoding-devel \
 rust-snapbox0.6-devel \
 rust-tempfile+default-devel \
 rust-walkdir+default-devel \
 "
RDEPENDS:rust-snapbox0.6+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-snapbox0.6-devel \
 "
RDEPENDS:rust-snapbox0.6+examples-devel = " \
 cargo \
 rust-escargot+default-devel \
 rust-snapbox0.6-devel \
 "
RDEPENDS:rust-snapbox0.6+json-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde_json+default-devel \
 rust-snapbox0.6+structured-data-devel \
 rust-snapbox0.6-devel \
 "
RDEPENDS:rust-snapbox0.6+path-devel = " \
 cargo \
 rust-snapbox0.6+dir-devel \
 rust-snapbox0.6-devel \
 "
RDEPENDS:rust-snapbox0.6+regex-devel = " \
 cargo \
 rust-regex+std-devel \
 rust-regex-devel \
 rust-snapbox0.6-devel \
 "
RDEPENDS:rust-snapbox0.6+structured-data-devel = " \
 cargo \
 rust-serde_json+default-devel \
 rust-snapbox0.6-devel \
 "
RDEPENDS:rust-snapbox0.6+term-svg-devel = " \
 cargo \
 rust-anstyle-svg0.1+default-devel \
 rust-snapbox0.6+structured-data-devel \
 rust-snapbox0.6-devel \
 "
RDEPENDS:rust-snapbox0.6-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-normalize-line-endings+default-devel \
 rust-snapbox-macros0.4+default-devel \
 "
