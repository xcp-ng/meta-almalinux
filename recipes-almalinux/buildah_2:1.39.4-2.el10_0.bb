# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "buildah"
PE = "2"
PV = "1.39.4"
PR = "2.el10_0"
PACKAGES = " \
 buildah \
 buildah-tests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/buildah-1.39.4-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ae9a1a0e2837f5511e2582129fb9bde23badf36e47408334bec51588752fb2df"

URI_x86_64_v2_buildah = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/buildah-1.39.4-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_buildah;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_buildah}"
SRC_URI[x86_64_v2_buildah.sha256sum] = "26d5354fd20ad4094fb0421e65c8ce7ef76f0019819c7560523d7785664f6a79"

URI_x86_64_v2_buildah-tests = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/buildah-tests-1.39.4-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_buildah-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_buildah-tests}"
SRC_URI[x86_64_v2_buildah-tests.sha256sum] = "1f8197ac52ff6cef88d493d0b83f7401d48ed412f5f54d21d86354c8484ec17d"

URI_aarch64_buildah = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/buildah-1.39.4-2.el10_0.aarch64.rpm;name=aarch64_buildah;unpack=0"
SRC_URI:append = " ${URI_aarch64_buildah}"
SRC_URI[aarch64_buildah.sha256sum] = "ff46e7e31a7670a1d76c9e632a2c5eb08a7ed0c3fe8311d36bb137d7072dc1e0"

URI_aarch64_buildah-tests = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/buildah-tests-1.39.4-2.el10_0.aarch64.rpm;name=aarch64_buildah-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_buildah-tests}"
SRC_URI[aarch64_buildah-tests.sha256sum] = "3a5c4cd38c6e2908bd4ea9631f3f90e755346776578ae3977afae2892ad50879"

RDEPENDS:buildah = " \
 containers-common-extra \
 glibc \
 gpgme \
 libseccomp \
 shadow-utils-subid \
 "
RDEPENDS:buildah-tests = " \
 bash \
 buildah \
 bzip2 \
 git-daemon \
 glibc \
 golang \
 gpgme \
 httpd-tools \
 jq \
 libseccomp \
 nmap-ncat \
 openssl \
 podman \
 shadow-utils-subid \
 "
