# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "blinken"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 blinken \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/blinken-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "727fa98c93eedf1e54e388c210461197f27fbb6cabbb6c54e5158f0efc27d061"

URI_x86_64_v2_blinken = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blinken-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_blinken;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blinken}"
SRC_URI[x86_64_v2_blinken.sha256sum] = "a4a09bb1845ca1a01e8f29a8b39be7867d2236a8f89ed76c69e765557d613720"

URI_aarch64_blinken = "${EPEL_MIRROR}/aarch64/Packages/b/blinken-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_blinken;unpack=0"
SRC_URI:append = " ${URI_aarch64_blinken}"
SRC_URI[aarch64_blinken.sha256sum] = "8118605d7ebc51bf12c4a10bb162ff56d37d1451b92cf31c5b5bef41d4a92110"

RDEPENDS:blinken = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
 sj-stevehand-fonts \
 "
