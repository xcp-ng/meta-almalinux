# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnf-plugins-core"
PV = "4.7.0"
PR = "12.el10"
PACKAGES = " \
 dnf-plugins-core \
 python3-dnf-plugin-leaves \
 python3-dnf-plugin-modulesync \
 python3-dnf-plugin-post-transaction-actions \
 python3-dnf-plugin-pre-transaction-actions \
 python3-dnf-plugin-show-leaves \
 python3-dnf-plugin-versionlock \
 python3-dnf-plugins-core \
 yum-utils \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/dnf-plugins-core-4.7.0-12.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "78fd995a8f2189117008bf073cefe41037bf793b4034d358a3099a961b8d96e9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dnf-plugins-core-4.7.0-12.el10.noarch.rpm;name=x86_64_v2_dnf-plugins-core;unpack=0"
SRC_URI[x86_64_v2_dnf-plugins-core.sha256sum] = "72857314d1f7014031de86c0233e0fcbe1147681c5e23ec56664a65e7d37c8a2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-dnf-plugin-leaves-4.7.0-12.el10.noarch.rpm;name=x86_64_v2_python3-dnf-plugin-leaves;unpack=0"
SRC_URI[x86_64_v2_python3-dnf-plugin-leaves.sha256sum] = "a61ce5e972767e12c1739288eb7bdc91333ff47a5ea2bed9ab077d8b0d926043"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-dnf-plugin-modulesync-4.7.0-12.el10.noarch.rpm;name=x86_64_v2_python3-dnf-plugin-modulesync;unpack=0"
SRC_URI[x86_64_v2_python3-dnf-plugin-modulesync.sha256sum] = "30048b0e429a454ddff216055a650958605b2d6e056cb745eb60de63cfcf883b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-dnf-plugin-post-transaction-actions-4.7.0-12.el10.noarch.rpm;name=x86_64_v2_python3-dnf-plugin-post-transaction-actions;unpack=0"
SRC_URI[x86_64_v2_python3-dnf-plugin-post-transaction-actions.sha256sum] = "802635410e59299cdb93dd1c9361b6b45180e894b30b312c88c47fc3d462545d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-dnf-plugin-pre-transaction-actions-4.7.0-12.el10.noarch.rpm;name=x86_64_v2_python3-dnf-plugin-pre-transaction-actions;unpack=0"
SRC_URI[x86_64_v2_python3-dnf-plugin-pre-transaction-actions.sha256sum] = "96190a98b9f11066c8e3c8a7a42a7068e49c864d691e4448ef5c627ccd2096c3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-dnf-plugin-show-leaves-4.7.0-12.el10.noarch.rpm;name=x86_64_v2_python3-dnf-plugin-show-leaves;unpack=0"
SRC_URI[x86_64_v2_python3-dnf-plugin-show-leaves.sha256sum] = "c0a387d3a65558da3471214e03647991049ff9cef18a851a9303a98d635336c2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-dnf-plugin-versionlock-4.7.0-12.el10.noarch.rpm;name=x86_64_v2_python3-dnf-plugin-versionlock;unpack=0"
SRC_URI[x86_64_v2_python3-dnf-plugin-versionlock.sha256sum] = "aee3e67b9e7f0d4858c113d03f8b03fb823cd09ca72ceb9febb74e5de69d1d82"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-dnf-plugins-core-4.7.0-12.el10.noarch.rpm;name=x86_64_v2_python3-dnf-plugins-core;unpack=0"
SRC_URI[x86_64_v2_python3-dnf-plugins-core.sha256sum] = "f2663db1fa982d211a4b061077c92661a130f8431adf0480430694f09973470f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/yum-utils-4.7.0-12.el10.noarch.rpm;name=x86_64_v2_yum-utils;unpack=0"
SRC_URI[x86_64_v2_yum-utils.sha256sum] = "1bf577638a7af9874a5ccc1f8f369949bbdf59894c81b59ae1bd41942e197d31"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dnf-plugins-core-4.7.0-12.el10.noarch.rpm;name=aarch64_dnf-plugins-core;unpack=0"
SRC_URI[aarch64_dnf-plugins-core.sha256sum] = "72857314d1f7014031de86c0233e0fcbe1147681c5e23ec56664a65e7d37c8a2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-dnf-plugin-leaves-4.7.0-12.el10.noarch.rpm;name=aarch64_python3-dnf-plugin-leaves;unpack=0"
SRC_URI[aarch64_python3-dnf-plugin-leaves.sha256sum] = "a61ce5e972767e12c1739288eb7bdc91333ff47a5ea2bed9ab077d8b0d926043"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-dnf-plugin-modulesync-4.7.0-12.el10.noarch.rpm;name=aarch64_python3-dnf-plugin-modulesync;unpack=0"
SRC_URI[aarch64_python3-dnf-plugin-modulesync.sha256sum] = "30048b0e429a454ddff216055a650958605b2d6e056cb745eb60de63cfcf883b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-dnf-plugin-post-transaction-actions-4.7.0-12.el10.noarch.rpm;name=aarch64_python3-dnf-plugin-post-transaction-actions;unpack=0"
SRC_URI[aarch64_python3-dnf-plugin-post-transaction-actions.sha256sum] = "802635410e59299cdb93dd1c9361b6b45180e894b30b312c88c47fc3d462545d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-dnf-plugin-pre-transaction-actions-4.7.0-12.el10.noarch.rpm;name=aarch64_python3-dnf-plugin-pre-transaction-actions;unpack=0"
SRC_URI[aarch64_python3-dnf-plugin-pre-transaction-actions.sha256sum] = "96190a98b9f11066c8e3c8a7a42a7068e49c864d691e4448ef5c627ccd2096c3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-dnf-plugin-show-leaves-4.7.0-12.el10.noarch.rpm;name=aarch64_python3-dnf-plugin-show-leaves;unpack=0"
SRC_URI[aarch64_python3-dnf-plugin-show-leaves.sha256sum] = "c0a387d3a65558da3471214e03647991049ff9cef18a851a9303a98d635336c2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-dnf-plugin-versionlock-4.7.0-12.el10.noarch.rpm;name=aarch64_python3-dnf-plugin-versionlock;unpack=0"
SRC_URI[aarch64_python3-dnf-plugin-versionlock.sha256sum] = "aee3e67b9e7f0d4858c113d03f8b03fb823cd09ca72ceb9febb74e5de69d1d82"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-dnf-plugins-core-4.7.0-12.el10.noarch.rpm;name=aarch64_python3-dnf-plugins-core;unpack=0"
SRC_URI[aarch64_python3-dnf-plugins-core.sha256sum] = "f2663db1fa982d211a4b061077c92661a130f8431adf0480430694f09973470f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/yum-utils-4.7.0-12.el10.noarch.rpm;name=aarch64_yum-utils;unpack=0"
SRC_URI[aarch64_yum-utils.sha256sum] = "1bf577638a7af9874a5ccc1f8f369949bbdf59894c81b59ae1bd41942e197d31"

RDEPENDS:dnf-plugins-core = " \
 python3-dnf-plugins-core \
 "
RDEPENDS:python3-dnf-plugin-leaves = " \
 python3 \
 python3-dnf-plugins-core \
 "
RDEPENDS:python3-dnf-plugin-modulesync = " \
 createrepo_c \
 python3 \
 python3-dnf-plugins-core \
 "
RDEPENDS:python3-dnf-plugin-post-transaction-actions = " \
 python3 \
 python3-dnf-plugins-core \
 "
RDEPENDS:python3-dnf-plugin-pre-transaction-actions = " \
 python3 \
 python3-dnf-plugins-core \
 "
RDEPENDS:python3-dnf-plugin-show-leaves = " \
 python3 \
 python3-dnf-plugin-leaves \
 python3-dnf-plugins-core \
 "
RDEPENDS:python3-dnf-plugin-versionlock = " \
 python3 \
 python3-dnf-plugins-core \
 "
RDEPENDS:python3-dnf-plugins-core = " \
 python3 \
 python3-dateutil \
 python3-dbus \
 python3-dnf \
 python3-hawkey \
 python3-systemd \
 "
RDEPENDS:yum-utils = " \
 dnf-plugins-core \
 python3 \
 python3-dnf \
 "
