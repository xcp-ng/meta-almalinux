# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Number-Bytes-Human"
PV = "0.11"
PR = "25.el10_0"
PACKAGES = " \
 perl-Number-Bytes-Human \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Number-Bytes-Human-0.11-25.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30c774671b5e020f1c1234218936fcc31c7bda2437db0b585ca392d284941cc1"

URI_x86_64_v2_perl-Number-Bytes-Human = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Number-Bytes-Human-0.11-25.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Number-Bytes-Human;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Number-Bytes-Human}"
SRC_URI[x86_64_v2_perl-Number-Bytes-Human.sha256sum] = "9a092295d456b6ef41f366292644d9da4abd660d28eb438a6d8e6a3fe1adca94"

URI_aarch64_perl-Number-Bytes-Human = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Number-Bytes-Human-0.11-25.el10_0.noarch.rpm;name=aarch64_perl-Number-Bytes-Human;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Number-Bytes-Human}"
SRC_URI[aarch64_perl-Number-Bytes-Human.sha256sum] = "9a8dd6702fb958f35fe659ae39b750e616cf9088b185a1276e5b624d62b1f035"

RDEPENDS:perl-Number-Bytes-Human = " \
 perl-Carp \
 perl-Exporter \
 perl-POSIX \
 perl-libs \
 "
