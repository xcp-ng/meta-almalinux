# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "SuperLUMT"
PV = "4.0.1"
PR = "6.el10_2"
PACKAGES = " \
 SuperLUMT \
 SuperLUMT-common \
 SuperLUMT-complex \
 SuperLUMT-complex16 \
 SuperLUMT-devel \
 SuperLUMT-double \
 SuperLUMT64 \
 SuperLUMT64-complex \
 SuperLUMT64-complex16 \
 SuperLUMT64-devel \
 SuperLUMT64-double \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/SuperLUMT-4.0.1-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c87ea41c02925db9c883018feaaf4e92f0fbc9b7e1e5474dde8e2e742ee5aa7"

URI_x86_64_v2_SuperLUMT = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SuperLUMT-4.0.1-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_SuperLUMT;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SuperLUMT}"
SRC_URI[x86_64_v2_SuperLUMT.sha256sum] = "62e258cb516ae37b848834805459ecb8b1ff8083f571790a396bc750ce8fe1ba"

URI_x86_64_v2_SuperLUMT-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SuperLUMT-common-4.0.1-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_SuperLUMT-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SuperLUMT-common}"
SRC_URI[x86_64_v2_SuperLUMT-common.sha256sum] = "9e252955fbd14e8d534f6e7d58869fab027dba24fb59dedd36ca482a90f07a86"

URI_x86_64_v2_SuperLUMT-complex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SuperLUMT-complex-4.0.1-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_SuperLUMT-complex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SuperLUMT-complex}"
SRC_URI[x86_64_v2_SuperLUMT-complex.sha256sum] = "c69790cd83ff53256669bdc93afb7e7c5cb3dfd8a3d188c4493e382fce33bb48"

URI_x86_64_v2_SuperLUMT-complex16 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SuperLUMT-complex16-4.0.1-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_SuperLUMT-complex16;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SuperLUMT-complex16}"
SRC_URI[x86_64_v2_SuperLUMT-complex16.sha256sum] = "6d0de59f1afccef5934d599efaae2933acff5d04f1c47491bfdb0436e7b20454"

URI_x86_64_v2_SuperLUMT-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SuperLUMT-devel-4.0.1-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_SuperLUMT-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SuperLUMT-devel}"
SRC_URI[x86_64_v2_SuperLUMT-devel.sha256sum] = "7a7b705abec0053603844d5e06b6ae20b3360d34813be92b295c36b33b00a9b4"

URI_x86_64_v2_SuperLUMT-double = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SuperLUMT-double-4.0.1-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_SuperLUMT-double;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SuperLUMT-double}"
SRC_URI[x86_64_v2_SuperLUMT-double.sha256sum] = "7616256bce9d1febe548db1a3c70a46cc9ec9e2bc9933335f01021f6312141d2"

URI_x86_64_v2_SuperLUMT64 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SuperLUMT64-4.0.1-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_SuperLUMT64;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SuperLUMT64}"
SRC_URI[x86_64_v2_SuperLUMT64.sha256sum] = "ee168485eaa381e58cbbf78f70077c096cbf5741025cb6ae65364fce57649984"

URI_x86_64_v2_SuperLUMT64-complex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SuperLUMT64-complex-4.0.1-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_SuperLUMT64-complex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SuperLUMT64-complex}"
SRC_URI[x86_64_v2_SuperLUMT64-complex.sha256sum] = "ad1e856f038628b74ef25d9e46e0b6dd0d728132a69a7342b16fe7a6da160e90"

URI_x86_64_v2_SuperLUMT64-complex16 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SuperLUMT64-complex16-4.0.1-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_SuperLUMT64-complex16;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SuperLUMT64-complex16}"
SRC_URI[x86_64_v2_SuperLUMT64-complex16.sha256sum] = "2d6c3304b7431c6fd8a1dd7d8a06389177ad39a1b2513bde7f13bc6c52b362eb"

URI_x86_64_v2_SuperLUMT64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SuperLUMT64-devel-4.0.1-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_SuperLUMT64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SuperLUMT64-devel}"
SRC_URI[x86_64_v2_SuperLUMT64-devel.sha256sum] = "b7a887caa287809151e8f6034430516a44eaf038c36721f2d1ef7a521dcb43f4"

URI_x86_64_v2_SuperLUMT64-double = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SuperLUMT64-double-4.0.1-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_SuperLUMT64-double;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SuperLUMT64-double}"
SRC_URI[x86_64_v2_SuperLUMT64-double.sha256sum] = "d617910f2a3a593c1bf4124b92eae2b80313ad7b3234adb5379fbdbbebe49337"

URI_aarch64_SuperLUMT = "${EPEL_MIRROR}/aarch64/Packages/s/SuperLUMT-4.0.1-6.el10_2.aarch64.rpm;name=aarch64_SuperLUMT;unpack=0"
SRC_URI:append = " ${URI_aarch64_SuperLUMT}"
SRC_URI[aarch64_SuperLUMT.sha256sum] = "da5308ee7338299bee3ae4ca302e49264201438fe39c501aab6a1921119fb532"

URI_aarch64_SuperLUMT-common = "${EPEL_MIRROR}/aarch64/Packages/s/SuperLUMT-common-4.0.1-6.el10_2.noarch.rpm;name=aarch64_SuperLUMT-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_SuperLUMT-common}"
SRC_URI[aarch64_SuperLUMT-common.sha256sum] = "21608bfd0213e566d191f2c27260f6e9419a74ad6abeee57c815047ae76d7643"

URI_aarch64_SuperLUMT-complex = "${EPEL_MIRROR}/aarch64/Packages/s/SuperLUMT-complex-4.0.1-6.el10_2.aarch64.rpm;name=aarch64_SuperLUMT-complex;unpack=0"
SRC_URI:append = " ${URI_aarch64_SuperLUMT-complex}"
SRC_URI[aarch64_SuperLUMT-complex.sha256sum] = "626e9f16b07e13f6781da7713a61aee563e3865fee09c33061fe868d86be5db7"

URI_aarch64_SuperLUMT-complex16 = "${EPEL_MIRROR}/aarch64/Packages/s/SuperLUMT-complex16-4.0.1-6.el10_2.aarch64.rpm;name=aarch64_SuperLUMT-complex16;unpack=0"
SRC_URI:append = " ${URI_aarch64_SuperLUMT-complex16}"
SRC_URI[aarch64_SuperLUMT-complex16.sha256sum] = "1d87370fcfd72ded5ed50dc12957704a58211bdaf6d45b6aadea50a7d5f3ca07"

URI_aarch64_SuperLUMT-devel = "${EPEL_MIRROR}/aarch64/Packages/s/SuperLUMT-devel-4.0.1-6.el10_2.aarch64.rpm;name=aarch64_SuperLUMT-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_SuperLUMT-devel}"
SRC_URI[aarch64_SuperLUMT-devel.sha256sum] = "53b5f46baa0e39c00ef9ff29a42c406103a077b4982e0baa0ca9c23fff37c951"

URI_aarch64_SuperLUMT-double = "${EPEL_MIRROR}/aarch64/Packages/s/SuperLUMT-double-4.0.1-6.el10_2.aarch64.rpm;name=aarch64_SuperLUMT-double;unpack=0"
SRC_URI:append = " ${URI_aarch64_SuperLUMT-double}"
SRC_URI[aarch64_SuperLUMT-double.sha256sum] = "f3b80ec1a6701e23edc7233b39d410e26ae50eb17c49663dc16633ff90cfbf52"

URI_aarch64_SuperLUMT64 = "${EPEL_MIRROR}/aarch64/Packages/s/SuperLUMT64-4.0.1-6.el10_2.aarch64.rpm;name=aarch64_SuperLUMT64;unpack=0"
SRC_URI:append = " ${URI_aarch64_SuperLUMT64}"
SRC_URI[aarch64_SuperLUMT64.sha256sum] = "d7637d8a0ab06405d29d8639344a904575e8dbe28ed4d0b99e5fc25e01e99aac"

URI_aarch64_SuperLUMT64-complex = "${EPEL_MIRROR}/aarch64/Packages/s/SuperLUMT64-complex-4.0.1-6.el10_2.aarch64.rpm;name=aarch64_SuperLUMT64-complex;unpack=0"
SRC_URI:append = " ${URI_aarch64_SuperLUMT64-complex}"
SRC_URI[aarch64_SuperLUMT64-complex.sha256sum] = "35cec932ee8fb330e878c80f01e560879438e75fc01cc4cd1c1b6d812936cf00"

URI_aarch64_SuperLUMT64-complex16 = "${EPEL_MIRROR}/aarch64/Packages/s/SuperLUMT64-complex16-4.0.1-6.el10_2.aarch64.rpm;name=aarch64_SuperLUMT64-complex16;unpack=0"
SRC_URI:append = " ${URI_aarch64_SuperLUMT64-complex16}"
SRC_URI[aarch64_SuperLUMT64-complex16.sha256sum] = "8113d3ea3bc796a396be33bd86aa25a2b868b5fe3b12fc4d8f48c2f7c031de9b"

URI_aarch64_SuperLUMT64-devel = "${EPEL_MIRROR}/aarch64/Packages/s/SuperLUMT64-devel-4.0.1-6.el10_2.aarch64.rpm;name=aarch64_SuperLUMT64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_SuperLUMT64-devel}"
SRC_URI[aarch64_SuperLUMT64-devel.sha256sum] = "507936a2cc9de58bce1538a6e4f2da734e43bddc6fa9209c134baac023808b73"

URI_aarch64_SuperLUMT64-double = "${EPEL_MIRROR}/aarch64/Packages/s/SuperLUMT64-double-4.0.1-6.el10_2.aarch64.rpm;name=aarch64_SuperLUMT64-double;unpack=0"
SRC_URI:append = " ${URI_aarch64_SuperLUMT64-double}"
SRC_URI[aarch64_SuperLUMT64-double.sha256sum] = "3abf1d364b75f1728d87d1c9f96be12dc4faaf2c02b2183d40f3d6e6e8f464b6"

RDEPENDS:SuperLUMT = " \
 SuperLUMT-common \
 flexiblas-netlib \
 glibc \
 libgomp \
 "
RDEPENDS:SuperLUMT-common = " \
 "
RDEPENDS:SuperLUMT-complex = " \
 SuperLUMT-common \
 flexiblas-netlib \
 glibc \
 libgomp \
 "
RDEPENDS:SuperLUMT-complex16 = " \
 SuperLUMT-common \
 flexiblas-netlib \
 glibc \
 libgomp \
 "
RDEPENDS:SuperLUMT-devel = " \
 SuperLUMT \
 SuperLUMT-complex \
 SuperLUMT-complex16 \
 SuperLUMT-double \
 "
RDEPENDS:SuperLUMT-double = " \
 SuperLUMT-common \
 flexiblas-netlib \
 glibc \
 libgomp \
 "
RDEPENDS:SuperLUMT64 = " \
 SuperLUMT-common \
 flexiblas-netlib64 \
 glibc \
 libgomp \
 "
RDEPENDS:SuperLUMT64-complex = " \
 SuperLUMT-common \
 flexiblas-netlib64 \
 glibc \
 libgomp \
 "
RDEPENDS:SuperLUMT64-complex16 = " \
 SuperLUMT-common \
 flexiblas-netlib64 \
 glibc \
 libgomp \
 "
RDEPENDS:SuperLUMT64-devel = " \
 SuperLUMT64 \
 SuperLUMT64-complex \
 SuperLUMT64-complex16 \
 SuperLUMT64-double \
 "
RDEPENDS:SuperLUMT64-double = " \
 SuperLUMT-common \
 flexiblas-netlib64 \
 glibc \
 libgomp \
 "
