# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qemu-kvm"
PE = "18"
PV = "9.1.0"
PR = "15.el10_0.4.alma.1"
PACKAGES:x86_64_v2 = " \
 qemu-guest-agent \
 qemu-img \
 qemu-kvm \
 qemu-kvm-audio-pa \
 qemu-kvm-block-blkio \
 qemu-kvm-block-curl \
 qemu-kvm-block-rbd \
 qemu-kvm-common \
 qemu-kvm-core \
 qemu-kvm-device-display-virtio-gpu \
 qemu-kvm-device-display-virtio-gpu-pci \
 qemu-kvm-device-display-virtio-vga \
 qemu-kvm-device-usb-host \
 qemu-kvm-device-usb-redirect \
 qemu-kvm-docs \
 qemu-kvm-tools \
 qemu-kvm-ui-egl-headless \
 qemu-kvm-ui-opengl \
 qemu-kvm-ui-spice \
 qemu-pr-helper \
"
PACKAGES:aarch64 = " \
 qemu-guest-agent \
 qemu-img \
 qemu-kvm \
 qemu-kvm-audio-pa \
 qemu-kvm-block-blkio \
 qemu-kvm-block-curl \
 qemu-kvm-block-rbd \
 qemu-kvm-common \
 qemu-kvm-core \
 qemu-kvm-device-display-virtio-gpu \
 qemu-kvm-device-display-virtio-gpu-pci \
 qemu-kvm-device-usb-host \
 qemu-kvm-device-usb-redirect \
 qemu-kvm-docs \
 qemu-kvm-tools \
 qemu-kvm-ui-spice \
 qemu-pr-helper \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qemu-kvm-9.1.0-15.el10_0.4.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64ddebf44c56cca65690a1d5d32193485d16aa51ee4a341c0a89f708ebb9de43"

URI_x86_64_v2_qemu-guest-agent = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-guest-agent-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-guest-agent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-guest-agent}"
SRC_URI[x86_64_v2_qemu-guest-agent.sha256sum] = "daa5211f799bb67f4cef6b99167a5e260a1ee01ee37e4a9c13e677003764da2e"

URI_x86_64_v2_qemu-img = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-img-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-img;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-img}"
SRC_URI[x86_64_v2_qemu-img.sha256sum] = "344e001def38e99693a1e0dcdba2fa04b6c341e712e9bc69aaccfa4facbfc7bb"

URI_x86_64_v2_qemu-kvm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm}"
SRC_URI[x86_64_v2_qemu-kvm.sha256sum] = "dd1a784918ab6f763b718f1aa822d0b047f0e57a01afd30cfcf0afa43242e9e8"

URI_x86_64_v2_qemu-kvm-audio-pa = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-audio-pa-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-audio-pa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-audio-pa}"
SRC_URI[x86_64_v2_qemu-kvm-audio-pa.sha256sum] = "321584ac074fb00ccd648a9adfa45fef015bce3d6d0bb22fb395e5fdc9f93bd2"

URI_x86_64_v2_qemu-kvm-block-blkio = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-block-blkio-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-block-blkio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-block-blkio}"
SRC_URI[x86_64_v2_qemu-kvm-block-blkio.sha256sum] = "52d15f2654e5b98cd8ed50e0fde3d7a21ff223577b4bfde4e0a8add31d60e295"

URI_x86_64_v2_qemu-kvm-block-curl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-block-curl-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-block-curl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-block-curl}"
SRC_URI[x86_64_v2_qemu-kvm-block-curl.sha256sum] = "84ca2c07fe1bc7a32645c203e28b57866090763025d87b87178b9b04a14e6cb9"

URI_x86_64_v2_qemu-kvm-block-rbd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-block-rbd-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-block-rbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-block-rbd}"
SRC_URI[x86_64_v2_qemu-kvm-block-rbd.sha256sum] = "094526ea1f16fe578b04f01551d1c069a40a72935928d76062a0c41400237fd1"

URI_x86_64_v2_qemu-kvm-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-common-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-common}"
SRC_URI[x86_64_v2_qemu-kvm-common.sha256sum] = "c3bcb201cfd831fb6fcb662e99480a0d1679a6faa715a1f6fa6bd735e98c71a1"

URI_x86_64_v2_qemu-kvm-core = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-core-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-core}"
SRC_URI[x86_64_v2_qemu-kvm-core.sha256sum] = "07c58fee5da229dee534fc335c301ec5c914d77088d8457f952ec33f8acfef1c"

URI_x86_64_v2_qemu-kvm-device-display-virtio-gpu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-display-virtio-gpu-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-device-display-virtio-gpu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-device-display-virtio-gpu}"
SRC_URI[x86_64_v2_qemu-kvm-device-display-virtio-gpu.sha256sum] = "a192331388fdafb77395d31b5afe62f2a27cd779b1a7c72150fd84ee8a4adeff"

URI_x86_64_v2_qemu-kvm-device-display-virtio-gpu-pci = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-display-virtio-gpu-pci-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-device-display-virtio-gpu-pci;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-device-display-virtio-gpu-pci}"
SRC_URI[x86_64_v2_qemu-kvm-device-display-virtio-gpu-pci.sha256sum] = "44dd4aec022849a07ed94728392861cf83c47c40db10c2e4a2ea8352475d3a70"

URI_x86_64_v2_qemu-kvm-device-display-virtio-vga = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-display-virtio-vga-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-device-display-virtio-vga;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-device-display-virtio-vga}"
SRC_URI[x86_64_v2_qemu-kvm-device-display-virtio-vga.sha256sum] = "f6dee20ed97caeb9ef4902cae9279b1e95632246c772615b3b77cefce0bf5671"

URI_x86_64_v2_qemu-kvm-device-usb-host = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-usb-host-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-device-usb-host;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-device-usb-host}"
SRC_URI[x86_64_v2_qemu-kvm-device-usb-host.sha256sum] = "a07bfc5a377415daccaf7b1e6ef3c53254c316bbe8bfd760db6e63211c7adb8f"

URI_x86_64_v2_qemu-kvm-device-usb-redirect = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-usb-redirect-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-device-usb-redirect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-device-usb-redirect}"
SRC_URI[x86_64_v2_qemu-kvm-device-usb-redirect.sha256sum] = "d7a67b82594d165c9d2c4aedd238488e4831897c8a18cf80e817809ec570f8d8"

URI_x86_64_v2_qemu-kvm-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-docs-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-docs}"
SRC_URI[x86_64_v2_qemu-kvm-docs.sha256sum] = "418d503a5a372c8f33dadda241b3a06238f21636692e40005c5bf36c56e44c6c"

URI_x86_64_v2_qemu-kvm-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-tools-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-tools}"
SRC_URI[x86_64_v2_qemu-kvm-tools.sha256sum] = "4336e4df18554b0678de7daf3218e2d8caeddeb1eb9845e43b66a9ee05ac3086"

URI_x86_64_v2_qemu-kvm-ui-egl-headless = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-ui-egl-headless-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-ui-egl-headless;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-ui-egl-headless}"
SRC_URI[x86_64_v2_qemu-kvm-ui-egl-headless.sha256sum] = "cd58c619086f854da59f6952c60f0492f48d2a5b1a4609b73ba7c155e4cfa96d"

URI_x86_64_v2_qemu-kvm-ui-opengl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-ui-opengl-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-ui-opengl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-ui-opengl}"
SRC_URI[x86_64_v2_qemu-kvm-ui-opengl.sha256sum] = "a3bdf9cc596fb266110d59ba90ae7f4578ea6934b749bfbd34b438423cb477f9"

URI_x86_64_v2_qemu-kvm-ui-spice = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-ui-spice-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-ui-spice;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-ui-spice}"
SRC_URI[x86_64_v2_qemu-kvm-ui-spice.sha256sum] = "edcd2f7f9a1658fd0f0a60cdd94b6942cfa0899c38e361f69f2d882c5084234c"

URI_x86_64_v2_qemu-pr-helper = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-pr-helper-9.1.0-15.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-pr-helper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-pr-helper}"
SRC_URI[x86_64_v2_qemu-pr-helper.sha256sum] = "488d464d7a35f82d1659529345b3d2612c4eb0ea43aee1173cff33eb689a33f9"

URI_aarch64_qemu-guest-agent = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-guest-agent-9.1.0-15.el10_0.4.alma.1.aarch64.rpm;name=aarch64_qemu-guest-agent;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-guest-agent}"
SRC_URI[aarch64_qemu-guest-agent.sha256sum] = "0429882426be2e2f0e838f9b0167b23a23caa531c12609cf91bdc7417ca40268"

URI_aarch64_qemu-img = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-img-9.1.0-15.el10_0.4.alma.1.aarch64.rpm;name=aarch64_qemu-img;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-img}"
SRC_URI[aarch64_qemu-img.sha256sum] = "c57de52ca51805b93d67bb623a38991e588810aba841245074c2a5c4a27b4d00"

URI_aarch64_qemu-kvm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-9.1.0-15.el10_0.4.alma.1.aarch64.rpm;name=aarch64_qemu-kvm;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm}"
SRC_URI[aarch64_qemu-kvm.sha256sum] = "4c3472f47d9e4b9168e0a5f6f73b4860f68a9720fd0301dd91630a6edf606efc"

URI_aarch64_qemu-kvm-audio-pa = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-audio-pa-9.1.0-15.el10_0.4.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-audio-pa;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-audio-pa}"
SRC_URI[aarch64_qemu-kvm-audio-pa.sha256sum] = "def6764c29c88b1309cb2817aebaf60a40a98c6aec069d138d2330ad85a38096"

URI_aarch64_qemu-kvm-block-blkio = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-block-blkio-9.1.0-15.el10_0.4.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-block-blkio;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-block-blkio}"
SRC_URI[aarch64_qemu-kvm-block-blkio.sha256sum] = "054d77ef691f61f0b30e21d12af39ed948a08d2c9f30b748b1b0300bab5d7b36"

URI_aarch64_qemu-kvm-block-curl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-block-curl-9.1.0-15.el10_0.4.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-block-curl;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-block-curl}"
SRC_URI[aarch64_qemu-kvm-block-curl.sha256sum] = "f03c023ce866505c42f5f7f6f4b7548ed242ff2dc99d4d2f892768fb37a42fd6"

URI_aarch64_qemu-kvm-block-rbd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-block-rbd-9.1.0-15.el10_0.4.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-block-rbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-block-rbd}"
SRC_URI[aarch64_qemu-kvm-block-rbd.sha256sum] = "fb45163cb4b0e1b5283fa61c757ed5ccc804db3108e44e3e502136ce46cf2d37"

URI_aarch64_qemu-kvm-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-common-9.1.0-15.el10_0.4.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-common}"
SRC_URI[aarch64_qemu-kvm-common.sha256sum] = "be146e03dbf4a8fe602b9ee3162d0d3e32c1feea58d1c70e5858c098fa7295c3"

URI_aarch64_qemu-kvm-core = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-core-9.1.0-15.el10_0.4.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-core}"
SRC_URI[aarch64_qemu-kvm-core.sha256sum] = "bfc05ecca9fb1db31c19405c4782527debf2155a60cc7a2e7dbe96061f1e1952"

URI_aarch64_qemu-kvm-device-display-virtio-gpu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-device-display-virtio-gpu-9.1.0-15.el10_0.4.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-device-display-virtio-gpu;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-device-display-virtio-gpu}"
SRC_URI[aarch64_qemu-kvm-device-display-virtio-gpu.sha256sum] = "da15e8ebc92c911c07e1ad3a3c811d0ead9ab7751cab0b91914f3a88ba486d7e"

URI_aarch64_qemu-kvm-device-display-virtio-gpu-pci = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-device-display-virtio-gpu-pci-9.1.0-15.el10_0.4.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-device-display-virtio-gpu-pci;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-device-display-virtio-gpu-pci}"
SRC_URI[aarch64_qemu-kvm-device-display-virtio-gpu-pci.sha256sum] = "b8b49d0a2f8f5d0025d47fbe60396b0ff576bc7e9fd1e8eb78299896e397857f"

URI_aarch64_qemu-kvm-device-usb-host = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-device-usb-host-9.1.0-15.el10_0.4.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-device-usb-host;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-device-usb-host}"
SRC_URI[aarch64_qemu-kvm-device-usb-host.sha256sum] = "0b5dc36ef02aed8ccf4e1e196a27ddc29cfbfe595f220aeae5233d2e72fb6cc5"

URI_aarch64_qemu-kvm-device-usb-redirect = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-device-usb-redirect-9.1.0-15.el10_0.4.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-device-usb-redirect;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-device-usb-redirect}"
SRC_URI[aarch64_qemu-kvm-device-usb-redirect.sha256sum] = "878dc067cf91792cfdb839ea955824d5ebd7294208ceae0162eca3b13000ec91"

URI_aarch64_qemu-kvm-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-docs-9.1.0-15.el10_0.4.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-docs}"
SRC_URI[aarch64_qemu-kvm-docs.sha256sum] = "d0496d0cc13fd62cd097444f00a6fcfe7ec3b6673b99d8bf860a53fdd9a1e0c1"

URI_aarch64_qemu-kvm-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-tools-9.1.0-15.el10_0.4.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-tools}"
SRC_URI[aarch64_qemu-kvm-tools.sha256sum] = "8be35c7d069c25f74cc85d8d436fc967c945d56c36762f9a6f7a87ca97cc470d"

URI_aarch64_qemu-kvm-ui-spice = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-ui-spice-9.1.0-15.el10_0.4.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-ui-spice;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-ui-spice}"
SRC_URI[aarch64_qemu-kvm-ui-spice.sha256sum] = "63dc1fea03c9a988ad011a83240f426db5f407bc0f23fa3429d913226843e703"

URI_aarch64_qemu-pr-helper = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-pr-helper-9.1.0-15.el10_0.4.alma.1.aarch64.rpm;name=aarch64_qemu-pr-helper;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-pr-helper}"
SRC_URI[aarch64_qemu-pr-helper.sha256sum] = "0c589a4e63666aea25344fccbf375b939fa90c42ac231d8ba25ed17f119aa0f1"

RDEPENDS:qemu-guest-agent = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 liburing \
 numactl-libs \
 systemd \
 systemd-libs \
 "
RDEPENDS:qemu-img = " \
 glib2 \
 glibc \
 gnutls \
 libaio \
 libgcc \
 libselinux \
 liburing \
 libzstd \
 numactl-libs \
 zlib-ng-compat \
 "
RDEPENDS:qemu-kvm:x86_64_v2 = " \
 qemu-kvm-audio-pa \
 qemu-kvm-block-blkio \
 qemu-kvm-block-rbd \
 qemu-kvm-core \
 qemu-kvm-device-display-virtio-gpu \
 qemu-kvm-device-display-virtio-gpu-pci \
 qemu-kvm-device-display-virtio-vga \
 qemu-kvm-device-usb-host \
 qemu-kvm-device-usb-redirect \
 qemu-kvm-docs \
 qemu-kvm-tools \
 qemu-kvm-ui-egl-headless \
 qemu-kvm-ui-opengl \
 qemu-kvm-ui-spice \
 qemu-pr-helper \
 virtiofsd \
"
RDEPENDS:qemu-kvm:aarch64 = " \
 qemu-kvm-audio-pa \
 qemu-kvm-block-blkio \
 qemu-kvm-block-rbd \
 qemu-kvm-core \
 qemu-kvm-device-display-virtio-gpu \
 qemu-kvm-device-display-virtio-gpu-pci \
 qemu-kvm-device-usb-host \
 qemu-kvm-device-usb-redirect \
 qemu-kvm-docs \
 qemu-kvm-tools \
 qemu-kvm-ui-spice \
 qemu-pr-helper \
 virtiofsd \
"
RDEPENDS:qemu-kvm-audio-pa = " \
 glibc \
 pulseaudio-libs \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-block-blkio = " \
 glibc \
 libblkio \
 libgcc \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-block-curl = " \
 glibc \
 libgcc \
 qemu-kvm-common \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:qemu-kvm-block-rbd = " \
 glibc \
 libgcc \
 librados2 \
 librbd1 \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-common:x86_64_v2 = " \
 bash \
 glib2 \
 glibc \
 glibc-common \
 ipxe-roms-qemu \
 libcap-ng \
 libgcc \
 seabios-bin \
 seavgabios-bin \
 shadow-utils \
 systemd \
"
RDEPENDS:qemu-kvm-common:aarch64 = " \
 bash \
 glib2 \
 glibc \
 glibc-common \
 libcap-ng \
 libgcc \
 shadow-utils \
 systemd \
"
RDEPENDS:qemu-kvm-core:x86_64_v2 = " \
 capstone \
 cyrus-sasl-lib \
 edk2-ovmf \
 glib2 \
 glibc \
 gnutls \
 libaio \
 libfdt \
 libgcc \
 libpng \
 libseccomp \
 libslirp \
 liburing \
 libusb1 \
 libzstd \
 lzo \
 numactl-libs \
 pixman \
 qemu-img \
 qemu-kvm-common \
 snappy \
 zlib-ng-compat \
"
RDEPENDS:qemu-kvm-core:aarch64 = " \
 capstone \
 cyrus-sasl-lib \
 edk2-aarch64 \
 glib2 \
 glibc \
 gnutls \
 libaio \
 libfdt \
 libgcc \
 libpng \
 libseccomp \
 libslirp \
 liburing \
 libusb1 \
 libzstd \
 lzo \
 numactl-libs \
 pixman \
 qemu-img \
 qemu-kvm-common \
 snappy \
 zlib-ng-compat \
"
RDEPENDS:qemu-kvm-device-display-virtio-gpu = " \
 glibc \
 pixman \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-device-display-virtio-gpu-pci = " \
 glibc \
 qemu-kvm-common \
 qemu-kvm-device-display-virtio-gpu \
 "
RDEPENDS:qemu-kvm-device-display-virtio-vga = " \
 glibc \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-device-usb-host = " \
 glibc \
 libusb1 \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-device-usb-redirect = " \
 glibc \
 libgcc \
 qemu-kvm-common \
 usbredir \
 "
RDEPENDS:qemu-kvm-docs = " \
 "
RDEPENDS:qemu-kvm-tools = " \
 glib2 \
 glibc \
 libgcc \
 libxkbcommon \
 python3 \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:qemu-kvm-ui-egl-headless = " \
 glibc \
 libepoxy \
 pixman \
 qemu-kvm-common \
 qemu-kvm-ui-opengl \
 "
RDEPENDS:qemu-kvm-ui-opengl = " \
 glibc \
 libepoxy \
 libgcc \
 mesa-dri-drivers \
 mesa-libEGL \
 mesa-libGL \
 mesa-libgbm \
 pixman \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-ui-spice:x86_64_v2 = " \
 glibc \
 libgcc \
 pixman \
 qemu-kvm-common \
 qemu-kvm-ui-opengl \
 spice-server \
"
RDEPENDS:qemu-kvm-ui-spice:aarch64 = " \
 glibc \
 libgcc \
 pixman \
 qemu-kvm-common \
 spice-server \
"
RDEPENDS:qemu-pr-helper = " \
 device-mapper-multipath-libs \
 glib2 \
 glibc \
 gnutls \
 libcap-ng \
 libgcc \
 liburing \
 numactl-libs \
 systemd-libs \
 "
