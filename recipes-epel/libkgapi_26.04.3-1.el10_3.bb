# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkgapi"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 libkgapi \
 libkgapi-devel \
 libkgapi-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkgapi-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5d3c543410669c0a2828d57a418c4b01ee5f637463040a0046afc9f8cb48d2d9"

URI_x86_64_v2_libkgapi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkgapi-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkgapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkgapi}"
SRC_URI[x86_64_v2_libkgapi.sha256sum] = "9c3929f662242359786e3e0a4af066d185447a8e41d126de7d87ae0e83cb2c5c"

URI_x86_64_v2_libkgapi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkgapi-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkgapi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkgapi-devel}"
SRC_URI[x86_64_v2_libkgapi-devel.sha256sum] = "d98907ec6ed0cca8e096ae108055c20327027bf7444f07bacd1cb32650482c57"

URI_x86_64_v2_libkgapi-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkgapi-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_libkgapi-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkgapi-doc}"
SRC_URI[x86_64_v2_libkgapi-doc.sha256sum] = "cf63b1ac9e09c67e8c8b4d363f2a2a85763c61af7838b3fd9d8245adad74e871"

URI_aarch64_libkgapi = "${EPEL_MIRROR}/aarch64/Packages/l/libkgapi-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_libkgapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkgapi}"
SRC_URI[aarch64_libkgapi.sha256sum] = "89b09ef034a9a1c7c6dd8104addd124cef5f44c7b0d373f577c6f414374b2673"

URI_aarch64_libkgapi-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkgapi-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_libkgapi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkgapi-devel}"
SRC_URI[aarch64_libkgapi-devel.sha256sum] = "5bf5b7c922a904ef991300dd4867d421da9ecd45a51c399355d714f5ffbbe07b"

URI_aarch64_libkgapi-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libkgapi-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_libkgapi-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkgapi-doc}"
SRC_URI[aarch64_libkgapi-doc.sha256sum] = "a943ff729864893f30fff75eb351668b05d84a8ce7f8178088f22e2444717a8e"

RDEPENDS:libkgapi = " \
 glibc \
 kf6-kcalendarcore \
 kf6-kcontacts \
 kf6-kwallet-libs \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkgapi-devel = " \
 cmake-filesystem \
 kf6-kcalendarcore-devel \
 kf6-kcontacts-devel \
 kf6-kcoreaddons-devel \
 libkgapi \
 "
RDEPENDS:libkgapi-doc = " \
 "
