# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-ExtUtils-Builder"
PV = "0.020"
PR = "2.el10_3"
PACKAGES = " \
 perl-ExtUtils-Builder \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-ExtUtils-Builder-0.020-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "251405390fc7165231580b93271ee756bf839bce7b64c6ee32632ffc0cda3c80"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-ExtUtils-Builder-0.020-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-ExtUtils-Builder;unpack=0"
SRC_URI[x86_64_v2_perl-ExtUtils-Builder.sha256sum] = "678773cd96b980c84ef62a3347b6c0ffb4bd18fc7d6885a5ac767443eae284c2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-ExtUtils-Builder-0.020-2.el10_3.noarch.rpm;name=aarch64_perl-ExtUtils-Builder;unpack=0"
SRC_URI[aarch64_perl-ExtUtils-Builder.sha256sum] = "136fa1c6085a054873524d095d8e6417318159fd63a00d3b3d58d304eb947a6d"

RDEPENDS:perl-ExtUtils-Builder = " \
 perl-Carp \
 perl-Data-Dumper \
 perl-Exporter \
 perl-ExtUtils-Builder \
 perl-ExtUtils-Config \
 perl-ExtUtils-Helpers \
 perl-ExtUtils-MakeMaker \
 perl-ExtUtils-Manifest \
 perl-File-Basename \
 perl-PathTools \
 perl-Perl-OSType \
 perl-Scalar-List-Utils \
 perl-base \
 perl-libs \
 perl-parent \
 perl-version \
 "
