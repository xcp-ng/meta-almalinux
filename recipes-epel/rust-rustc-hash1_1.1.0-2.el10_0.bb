# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustc-hash1"
PV = "1.1.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-rustc-hash1+default-devel \
 rust-rustc-hash1+std-devel \
 rust-rustc-hash1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustc-hash1-1.1.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15304dfcd9d3f840347ac3df17dff9d3ae8ce687bce1e5880f581449a4e03841"

URI_x86_64_v2_rust-rustc-hash1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustc-hash1+default-devel-1.1.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustc-hash1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustc-hash1+default-devel}"
SRC_URI[x86_64_v2_rust-rustc-hash1+default-devel.sha256sum] = "857037958545c1503febcfe19484284db8bbc35d3c9f07c0f742b658f2763bc7"

URI_x86_64_v2_rust-rustc-hash1+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustc-hash1+std-devel-1.1.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustc-hash1+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustc-hash1+std-devel}"
SRC_URI[x86_64_v2_rust-rustc-hash1+std-devel.sha256sum] = "7553094de52613e86d40dd1b6f466ee5fdc386edc59f67ecc80d1305479bac6f"

URI_x86_64_v2_rust-rustc-hash1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustc-hash1-devel-1.1.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustc-hash1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustc-hash1-devel}"
SRC_URI[x86_64_v2_rust-rustc-hash1-devel.sha256sum] = "ed4b6727cd07bdcc9fe80ec828cedb1c0a920ce2342d37021dd3a5a1fef30546"

URI_aarch64_rust-rustc-hash1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustc-hash1+default-devel-1.1.0-2.el10_0.noarch.rpm;name=aarch64_rust-rustc-hash1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustc-hash1+default-devel}"
SRC_URI[aarch64_rust-rustc-hash1+default-devel.sha256sum] = "aef6fe9e45dd7b866b44a67e47f532b09eaddf6350705a48413af5f9ce2ba3dc"

URI_aarch64_rust-rustc-hash1+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustc-hash1+std-devel-1.1.0-2.el10_0.noarch.rpm;name=aarch64_rust-rustc-hash1+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustc-hash1+std-devel}"
SRC_URI[aarch64_rust-rustc-hash1+std-devel.sha256sum] = "107914de73cca02777c53b1d3ef5f270dc26568f3d7a268d0f7b2aa44249fc59"

URI_aarch64_rust-rustc-hash1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustc-hash1-devel-1.1.0-2.el10_0.noarch.rpm;name=aarch64_rust-rustc-hash1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustc-hash1-devel}"
SRC_URI[aarch64_rust-rustc-hash1-devel.sha256sum] = "7972389c29176dc83a2e4b54fd3dc86dbf817defb2139378092d1505b6fdd683"

RDEPENDS:rust-rustc-hash1+default-devel = " \
 cargo \
 rust-rustc-hash1+std-devel \
 rust-rustc-hash1-devel \
 "
RDEPENDS:rust-rustc-hash1+std-devel = " \
 cargo \
 rust-rustc-hash1-devel \
 "
RDEPENDS:rust-rustc-hash1-devel = " \
 cargo \
 "
