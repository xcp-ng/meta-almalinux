# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "liquidctl"
PV = "1.16.0"
PR = "1.el10_3"
PACKAGES = " \
 liquidctl \
 liquidctl-doc \
 liquidctl-udev \
 python3-liquidctl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/liquidctl-1.16.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc2755f9ead39091582278764787b04587a2cb3eb7929a799243df551127d4a6"

URI_x86_64_v2_liquidctl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liquidctl-1.16.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_liquidctl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liquidctl}"
SRC_URI[x86_64_v2_liquidctl.sha256sum] = "d8cbabae78fffb6ed6df2cc3315ce05558f4381db0d4073483faa0c70a937032"

URI_x86_64_v2_liquidctl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liquidctl-doc-1.16.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_liquidctl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liquidctl-doc}"
SRC_URI[x86_64_v2_liquidctl-doc.sha256sum] = "2d4f37482666fc6ecc59833d7d261280e9b02e7883e49754477af12f3edca0b0"

URI_x86_64_v2_liquidctl-udev = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liquidctl-udev-1.16.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_liquidctl-udev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liquidctl-udev}"
SRC_URI[x86_64_v2_liquidctl-udev.sha256sum] = "0731db72a90d417479943199336e8ff489b4f56505fcc037640099b50f1e6e6f"

URI_x86_64_v2_python3-liquidctl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-liquidctl-1.16.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-liquidctl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-liquidctl}"
SRC_URI[x86_64_v2_python3-liquidctl.sha256sum] = "c284510f31235b8971c0213a7410affcc996ec28563b711745094c087034c88b"

URI_aarch64_liquidctl = "${EPEL_MIRROR}/aarch64/Packages/l/liquidctl-1.16.0-1.el10_3.noarch.rpm;name=aarch64_liquidctl;unpack=0"
SRC_URI:append = " ${URI_aarch64_liquidctl}"
SRC_URI[aarch64_liquidctl.sha256sum] = "118d727691d9313c8ed2f57ccba9f7bcd1c2021f3138a0b6cb9b82a59fa4b253"

URI_aarch64_liquidctl-doc = "${EPEL_MIRROR}/aarch64/Packages/l/liquidctl-doc-1.16.0-1.el10_3.noarch.rpm;name=aarch64_liquidctl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_liquidctl-doc}"
SRC_URI[aarch64_liquidctl-doc.sha256sum] = "4331f3ecb81fe76ded88a3c5ef30dd134ae7dd285aa04271ca55f9b5184036a0"

URI_aarch64_liquidctl-udev = "${EPEL_MIRROR}/aarch64/Packages/l/liquidctl-udev-1.16.0-1.el10_3.noarch.rpm;name=aarch64_liquidctl-udev;unpack=0"
SRC_URI:append = " ${URI_aarch64_liquidctl-udev}"
SRC_URI[aarch64_liquidctl-udev.sha256sum] = "d8a12199b7a058d67894962e613b826f5eed53e9a0dfe64130d9e3ad6be439d6"

URI_aarch64_python3-liquidctl = "${EPEL_MIRROR}/aarch64/Packages/p/python3-liquidctl-1.16.0-1.el10_3.noarch.rpm;name=aarch64_python3-liquidctl;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-liquidctl}"
SRC_URI[aarch64_python3-liquidctl.sha256sum] = "6bfc924b500fa45136d3009d09b56996bfdc84b735396331c2d720bb047947b6"

RDEPENDS:liquidctl = " \
 python3 \
 python3-liquidctl \
 "
RDEPENDS:liquidctl-doc = " \
 "
RDEPENDS:liquidctl-udev = " \
 liquidctl \
 "
RDEPENDS:python3-liquidctl = " \
 python3 \
 python3-colorlog \
 python3-crcmod \
 python3-docopt \
 python3-hidapi \
 python3-i2c-tools \
 python3-pillow \
 python3-pyusb \
 "
