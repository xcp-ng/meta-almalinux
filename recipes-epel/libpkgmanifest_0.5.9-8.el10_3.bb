# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libpkgmanifest"
PV = "0.5.9"
PR = "8.el10_3"
PACKAGES = " \
 libpkgmanifest \
 libpkgmanifest-devel \
 python3-libpkgmanifest \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libpkgmanifest-0.5.9-8.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86777b88527ef2bf669455690c56faef2947bad53d74a1c0042e1a1d69ad3238"

URI_x86_64_v2_libpkgmanifest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpkgmanifest-0.5.9-8.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpkgmanifest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpkgmanifest}"
SRC_URI[x86_64_v2_libpkgmanifest.sha256sum] = "b2385f5b5d5fee565311e37ed3e88cd1b12333fdf56f6f84f26b2126f2f8edb2"

URI_x86_64_v2_libpkgmanifest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpkgmanifest-devel-0.5.9-8.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpkgmanifest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpkgmanifest-devel}"
SRC_URI[x86_64_v2_libpkgmanifest-devel.sha256sum] = "f762c29c30b8987dc34a0cdf860ba575635c4b98faaefe4b36f6a0631fb222a3"

URI_x86_64_v2_python3-libpkgmanifest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-libpkgmanifest-0.5.9-8.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-libpkgmanifest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libpkgmanifest}"
SRC_URI[x86_64_v2_python3-libpkgmanifest.sha256sum] = "6aa2fc8e665b2fc62abce387ddcbf926126dae2c589d1496bcf8f6ade28aa759"

URI_aarch64_libpkgmanifest = "${EPEL_MIRROR}/aarch64/Packages/l/libpkgmanifest-0.5.9-8.el10_3.aarch64.rpm;name=aarch64_libpkgmanifest;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpkgmanifest}"
SRC_URI[aarch64_libpkgmanifest.sha256sum] = "52452bb0fb35360883c4a039e221b7f9c852ec4563bd6452dcff5b85f7c7ace5"

URI_aarch64_libpkgmanifest-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libpkgmanifest-devel-0.5.9-8.el10_3.aarch64.rpm;name=aarch64_libpkgmanifest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpkgmanifest-devel}"
SRC_URI[aarch64_libpkgmanifest-devel.sha256sum] = "f7e2302416421a154b0f4ffa8bd1ccdf2310fd72f9a80c213c0b4d046ad27cbd"

URI_aarch64_python3-libpkgmanifest = "${EPEL_MIRROR}/aarch64/Packages/p/python3-libpkgmanifest-0.5.9-8.el10_3.aarch64.rpm;name=aarch64_python3-libpkgmanifest;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libpkgmanifest}"
SRC_URI[aarch64_python3-libpkgmanifest.sha256sum] = "63f23da3271ae62b53fe4d0309350f6ad0df1f7548bf579fd81e7818ae6c3502"

RDEPENDS:libpkgmanifest = " \
 glibc \
 libgcc \
 libstdc++ \
 yaml-cpp \
 "
RDEPENDS:libpkgmanifest-devel = " \
 libpkgmanifest \
 pkgconf-pkg-config \
 virtual/pkgconfig_yaml-cpp_ \
 "
RDEPENDS:python3-libpkgmanifest = " \
 glibc \
 libgcc \
 libpkgmanifest \
 libstdc++ \
 python3 \
 python3-libs \
 "
