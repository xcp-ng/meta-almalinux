# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "facebook-time"
PV = "0^20260703git5fa5c15"
PR = "3.el10_3"
PACKAGES = " \
 caliper \
 calnex \
 facebook-time-vendor-licenses \
 fbclock \
 ntpcheck \
 ntpresponder \
 ntripper \
 pshark \
 ptp4u \
 ptpcheck \
 sa53 \
 sptp \
 ziffy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/facebook-time-0^20260703git5fa5c15-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e4e2b84aebcc0865a89ead392646d128a68b2947794412302b0d11fc692077b"

URI_x86_64_v2_caliper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/caliper-0^20260703git5fa5c15-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_caliper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_caliper}"
SRC_URI[x86_64_v2_caliper.sha256sum] = "af8afe6d3d0f96edfa5d36f9e6aac36e15689e354dfd3bb24f1b4acb174a9a8a"

URI_x86_64_v2_calnex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/calnex-0^20260703git5fa5c15-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_calnex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_calnex}"
SRC_URI[x86_64_v2_calnex.sha256sum] = "dc527c18b77bad6e978805da1e72428d83e87751ecc8511ed317e3734d1905f0"

URI_x86_64_v2_facebook-time-vendor-licenses = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/facebook-time-vendor-licenses-0^20260703git5fa5c15-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_facebook-time-vendor-licenses;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_facebook-time-vendor-licenses}"
SRC_URI[x86_64_v2_facebook-time-vendor-licenses.sha256sum] = "dad40429ee0bd526eb1a838c9b702aa5fceedcc66cfe66ecd2b19a93c764b339"

URI_x86_64_v2_fbclock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fbclock-0^20260703git5fa5c15-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fbclock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fbclock}"
SRC_URI[x86_64_v2_fbclock.sha256sum] = "49edf9aa8500eb7405aa5b82af1e54c255c7341906cee960a68c679dd5bad4c5"

URI_x86_64_v2_ntpcheck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ntpcheck-0^20260703git5fa5c15-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ntpcheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ntpcheck}"
SRC_URI[x86_64_v2_ntpcheck.sha256sum] = "b99666da3cbed7fa2adb899e92aba241db6b43ba152a980aff40c1d401d50c89"

URI_x86_64_v2_ntpresponder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ntpresponder-0^20260703git5fa5c15-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ntpresponder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ntpresponder}"
SRC_URI[x86_64_v2_ntpresponder.sha256sum] = "94ecd9e4d9582ac949f53fa10c89ee9c60fd9d7566203f9175ccc46db83c9f51"

URI_x86_64_v2_ntripper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ntripper-0^20260703git5fa5c15-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ntripper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ntripper}"
SRC_URI[x86_64_v2_ntripper.sha256sum] = "58359408db9fb56759b9459d82ae37afd2a76ddcce8eb338d66b9e7983d87f31"

URI_x86_64_v2_pshark = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pshark-0^20260703git5fa5c15-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pshark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pshark}"
SRC_URI[x86_64_v2_pshark.sha256sum] = "3198159dd43863b81e30ead426601a55aa10c1c35d329cb1dd94a1b2c911cfd4"

URI_x86_64_v2_ptp4u = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ptp4u-0^20260703git5fa5c15-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ptp4u;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ptp4u}"
SRC_URI[x86_64_v2_ptp4u.sha256sum] = "fb8de260949ad9d45da4bdac8a9648d6fac47d7d6bd18534794a4ff7a08df4ea"

URI_x86_64_v2_ptpcheck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ptpcheck-0^20260703git5fa5c15-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ptpcheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ptpcheck}"
SRC_URI[x86_64_v2_ptpcheck.sha256sum] = "6b5da4fee11b3a2e4e6765a211121f746e5a095165b1ee28cad017f33a36adeb"

URI_x86_64_v2_sa53 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sa53-0^20260703git5fa5c15-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sa53;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sa53}"
SRC_URI[x86_64_v2_sa53.sha256sum] = "af1f2eeefaaea78db1a18daee65e79646b7da31f14dba289ec38d3e7caf07df9"

URI_x86_64_v2_sptp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sptp-0^20260703git5fa5c15-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sptp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sptp}"
SRC_URI[x86_64_v2_sptp.sha256sum] = "eff97f530323157c2df502ddb3162d68ff9ebd3e2f4bdc3c5ca2180ce15ebee3"

URI_x86_64_v2_ziffy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ziffy-0^20260703git5fa5c15-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ziffy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ziffy}"
SRC_URI[x86_64_v2_ziffy.sha256sum] = "0a2aae7811c93a0e1b17f055431dd38af1e94b1c552f5fb452e3a8649d96c056"

URI_aarch64_caliper = "${EPEL_MIRROR}/aarch64/Packages/c/caliper-0^20260703git5fa5c15-3.el10_3.aarch64.rpm;name=aarch64_caliper;unpack=0"
SRC_URI:append = " ${URI_aarch64_caliper}"
SRC_URI[aarch64_caliper.sha256sum] = "3fd0d8fd7b3f2efd5a5a6cc72d0db0ce6c4f007fabb2e16000dcb3a4a0ef6ef2"

URI_aarch64_calnex = "${EPEL_MIRROR}/aarch64/Packages/c/calnex-0^20260703git5fa5c15-3.el10_3.aarch64.rpm;name=aarch64_calnex;unpack=0"
SRC_URI:append = " ${URI_aarch64_calnex}"
SRC_URI[aarch64_calnex.sha256sum] = "b432ac00872a3ebaec1df048d012828743fbf11b8882a846dd2c70233f2bee51"

URI_aarch64_facebook-time-vendor-licenses = "${EPEL_MIRROR}/aarch64/Packages/f/facebook-time-vendor-licenses-0^20260703git5fa5c15-3.el10_3.noarch.rpm;name=aarch64_facebook-time-vendor-licenses;unpack=0"
SRC_URI:append = " ${URI_aarch64_facebook-time-vendor-licenses}"
SRC_URI[aarch64_facebook-time-vendor-licenses.sha256sum] = "e44206e9f80d75260f48d264d5c2172a13a369036c1d36c8cfbd6b9739928194"

URI_aarch64_fbclock = "${EPEL_MIRROR}/aarch64/Packages/f/fbclock-0^20260703git5fa5c15-3.el10_3.aarch64.rpm;name=aarch64_fbclock;unpack=0"
SRC_URI:append = " ${URI_aarch64_fbclock}"
SRC_URI[aarch64_fbclock.sha256sum] = "3141cdbfb09e01fb17b673007d20df04e1c2bf28ce40e08d752aaaad28ac50e1"

URI_aarch64_ntpcheck = "${EPEL_MIRROR}/aarch64/Packages/n/ntpcheck-0^20260703git5fa5c15-3.el10_3.aarch64.rpm;name=aarch64_ntpcheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_ntpcheck}"
SRC_URI[aarch64_ntpcheck.sha256sum] = "b1d50d94e5eff2ca9da9fc96fb744eb4d73916de9214068669287aa871ec3e82"

URI_aarch64_ntpresponder = "${EPEL_MIRROR}/aarch64/Packages/n/ntpresponder-0^20260703git5fa5c15-3.el10_3.aarch64.rpm;name=aarch64_ntpresponder;unpack=0"
SRC_URI:append = " ${URI_aarch64_ntpresponder}"
SRC_URI[aarch64_ntpresponder.sha256sum] = "ff360d62f8a0f89c85625de468a6315dbd87d5c5712d17b6fdc6a60d5d69abc5"

URI_aarch64_ntripper = "${EPEL_MIRROR}/aarch64/Packages/n/ntripper-0^20260703git5fa5c15-3.el10_3.aarch64.rpm;name=aarch64_ntripper;unpack=0"
SRC_URI:append = " ${URI_aarch64_ntripper}"
SRC_URI[aarch64_ntripper.sha256sum] = "aaa1d02fe871bf4e91d37b0193f33ae6971e09d0c538017a460087795e88d246"

URI_aarch64_pshark = "${EPEL_MIRROR}/aarch64/Packages/p/pshark-0^20260703git5fa5c15-3.el10_3.aarch64.rpm;name=aarch64_pshark;unpack=0"
SRC_URI:append = " ${URI_aarch64_pshark}"
SRC_URI[aarch64_pshark.sha256sum] = "a9e7d652f2afa47e77e67714fcf43285ea303df0d1bc728779d82aac1508f823"

URI_aarch64_ptp4u = "${EPEL_MIRROR}/aarch64/Packages/p/ptp4u-0^20260703git5fa5c15-3.el10_3.aarch64.rpm;name=aarch64_ptp4u;unpack=0"
SRC_URI:append = " ${URI_aarch64_ptp4u}"
SRC_URI[aarch64_ptp4u.sha256sum] = "ff2d3be8bdc043b9f303d904a74ce44eb8683870352ac58730e27a3038c3afcd"

URI_aarch64_ptpcheck = "${EPEL_MIRROR}/aarch64/Packages/p/ptpcheck-0^20260703git5fa5c15-3.el10_3.aarch64.rpm;name=aarch64_ptpcheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_ptpcheck}"
SRC_URI[aarch64_ptpcheck.sha256sum] = "2489d8a6d11fa9374a8485936d45ccab43c29ee5526fb2982282a2502c8309c7"

URI_aarch64_sa53 = "${EPEL_MIRROR}/aarch64/Packages/s/sa53-0^20260703git5fa5c15-3.el10_3.aarch64.rpm;name=aarch64_sa53;unpack=0"
SRC_URI:append = " ${URI_aarch64_sa53}"
SRC_URI[aarch64_sa53.sha256sum] = "899da9fb206e61094875ce746d8745691770485a8386a6fbe73f722af1401311"

URI_aarch64_sptp = "${EPEL_MIRROR}/aarch64/Packages/s/sptp-0^20260703git5fa5c15-3.el10_3.aarch64.rpm;name=aarch64_sptp;unpack=0"
SRC_URI:append = " ${URI_aarch64_sptp}"
SRC_URI[aarch64_sptp.sha256sum] = "b4b6839a324b3804af48df663a2ad83b31526b22b9a8cc4b97468d327bf6c345"

URI_aarch64_ziffy = "${EPEL_MIRROR}/aarch64/Packages/z/ziffy-0^20260703git5fa5c15-3.el10_3.aarch64.rpm;name=aarch64_ziffy;unpack=0"
SRC_URI:append = " ${URI_aarch64_ziffy}"
SRC_URI[aarch64_ziffy.sha256sum] = "a876dea7dfe8d7da272adcf2ca92e5200aa31f52c19edfbdf25b6c66dcbaf5c5"

RDEPENDS:caliper = " \
 facebook-time-vendor-licenses \
 glibc \
 "
RDEPENDS:calnex = " \
 facebook-time-vendor-licenses \
 glibc \
 "
RDEPENDS:facebook-time-vendor-licenses = " \
 "
RDEPENDS:fbclock = " \
 facebook-time-vendor-licenses \
 glibc \
 "
RDEPENDS:ntpcheck = " \
 facebook-time-vendor-licenses \
 glibc \
 "
RDEPENDS:ntpresponder = " \
 facebook-time-vendor-licenses \
 glibc \
 "
RDEPENDS:ntripper = " \
 facebook-time-vendor-licenses \
 glibc \
 "
RDEPENDS:pshark = " \
 facebook-time-vendor-licenses \
 glibc \
 "
RDEPENDS:ptp4u = " \
 facebook-time-vendor-licenses \
 glibc \
 "
RDEPENDS:ptpcheck = " \
 facebook-time-vendor-licenses \
 glibc \
 "
RDEPENDS:sa53 = " \
 facebook-time-vendor-licenses \
 glibc \
 "
RDEPENDS:sptp = " \
 facebook-time-vendor-licenses \
 glibc \
 "
RDEPENDS:ziffy = " \
 facebook-time-vendor-licenses \
 glibc \
 libpcap \
 "
