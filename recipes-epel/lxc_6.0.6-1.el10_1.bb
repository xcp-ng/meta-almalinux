# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lxc"
PV = "6.0.6"
PR = "1.el10_1"
PACKAGES = " \
 lxc \
 lxc-devel \
 lxc-doc \
 lxc-libs \
 lxc-templates \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lxc-6.0.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ca8e9c433802e2720389bcac56ddad04b901440f019f8c30566dc99b3507ffe"

URI_x86_64_v2_lxc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lxc-6.0.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lxc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lxc}"
SRC_URI[x86_64_v2_lxc.sha256sum] = "b96297976bf7da09d113db54be5bf3274792b3283b233bb194585824d043dbda"

URI_x86_64_v2_lxc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lxc-devel-6.0.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lxc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lxc-devel}"
SRC_URI[x86_64_v2_lxc-devel.sha256sum] = "d323f38146172e3ac5ea5c92f045d093a6119d8da28394092a59b075d91e9bcb"

URI_x86_64_v2_lxc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lxc-doc-6.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lxc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lxc-doc}"
SRC_URI[x86_64_v2_lxc-doc.sha256sum] = "38c8218ac861b55eca770a8aff722a4c7bbc373c86a56f98ddb4a335dc31a0b5"

URI_x86_64_v2_lxc-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lxc-libs-6.0.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lxc-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lxc-libs}"
SRC_URI[x86_64_v2_lxc-libs.sha256sum] = "65ebe9dc0c345dec786a97b57a7cf46b88edb629d037e9a49bb7179d8e79a973"

URI_x86_64_v2_lxc-templates = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lxc-templates-6.0.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lxc-templates;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lxc-templates}"
SRC_URI[x86_64_v2_lxc-templates.sha256sum] = "d3d28a9abff47269352f2d0550947cdcbdf6dd32745b889eb35f353f582f133e"

URI_aarch64_lxc = "${EPEL_MIRROR}/aarch64/Packages/l/lxc-6.0.6-1.el10_1.aarch64.rpm;name=aarch64_lxc;unpack=0"
SRC_URI:append = " ${URI_aarch64_lxc}"
SRC_URI[aarch64_lxc.sha256sum] = "dea04a214a007f7476e6a77ff3f8fbc27ab670d09590c7becf44ac81cd11bcd2"

URI_aarch64_lxc-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lxc-devel-6.0.6-1.el10_1.aarch64.rpm;name=aarch64_lxc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lxc-devel}"
SRC_URI[aarch64_lxc-devel.sha256sum] = "c44db105cbf3dfb4950143cfdab9c6ed290da8a0b1458125c2558863be6ed981"

URI_aarch64_lxc-doc = "${EPEL_MIRROR}/aarch64/Packages/l/lxc-doc-6.0.6-1.el10_1.noarch.rpm;name=aarch64_lxc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_lxc-doc}"
SRC_URI[aarch64_lxc-doc.sha256sum] = "f7f6730332026d40a58e504862a836d1a6ad7145a160820c523f8909313536f2"

URI_aarch64_lxc-libs = "${EPEL_MIRROR}/aarch64/Packages/l/lxc-libs-6.0.6-1.el10_1.aarch64.rpm;name=aarch64_lxc-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_lxc-libs}"
SRC_URI[aarch64_lxc-libs.sha256sum] = "4143b55b0cbf146f76c8f9a3021f04a4c87f3eb5cf7b45038e71d4a059d782ec"

URI_aarch64_lxc-templates = "${EPEL_MIRROR}/aarch64/Packages/l/lxc-templates-6.0.6-1.el10_1.aarch64.rpm;name=aarch64_lxc-templates;unpack=0"
SRC_URI:append = " ${URI_aarch64_lxc-templates}"
SRC_URI[aarch64_lxc-templates.sha256sum] = "4a349ff21c1ebc91993725cbf7f96a560126f16e513bf50b4eae2f499e0669cc"

RDEPENDS:lxc = " \
 bash \
 dbus-libs \
 glibc \
 libcap \
 libgcc \
 libseccomp \
 libselinux \
 lxc-libs \
 lxcfs \
 openssl \
 openssl-libs \
 rsync \
 "
RDEPENDS:lxc-devel = " \
 dbus-devel \
 libcap-devel \
 libseccomp-devel \
 libselinux-devel \
 lxc-libs \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:lxc-doc = " \
 "
RDEPENDS:lxc-libs = " \
 bash \
 dbus-libs \
 glibc \
 libcap \
 libgcc \
 libseccomp \
 libselinux \
 openssl-libs \
 pam-libs \
 rsync \
 systemd \
 "
RDEPENDS:lxc-templates = " \
 bash \
 lxc-libs \
 wget \
 "
