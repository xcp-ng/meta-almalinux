# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "conntrack-tools"
PV = "1.4.8"
PR = "3.el10"
PACKAGES = " \
 conntrack-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/conntrack-tools-1.4.8-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0dfc610338c65d17408a3fdfef4dcdd3b4dda4d1f318186fbeddf336c211f00d"

URI_x86_64_v2_conntrack-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/conntrack-tools-1.4.8-3.el10.x86_64_v2.rpm;name=x86_64_v2_conntrack-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_conntrack-tools}"
SRC_URI[x86_64_v2_conntrack-tools.sha256sum] = "b0b18c6d84e1b05b1d8bcbe868893f3fffc42f7d3c4234305720f832e08e4a2b"

URI_aarch64_conntrack-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/conntrack-tools-1.4.8-3.el10.aarch64.rpm;name=aarch64_conntrack-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_conntrack-tools}"
SRC_URI[aarch64_conntrack-tools.sha256sum] = "5d0c55ca681e0ee131ef64f9523385bd65b353458582f9d5d7b432f555333652"

RDEPENDS:conntrack-tools = " \
 bash \
 glibc \
 libmnl \
 libnetfilter_conntrack \
 libnetfilter_cthelper \
 libnetfilter_cttimeout \
 libnetfilter_queue \
 libnfnetlink \
 systemd \
 systemd-libs \
 "
