# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tin"
PV = "2.6.6"
PR = "1.el10_2"
PACKAGES = " \
 tin \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/t/tin-2.6.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a28ac2c048ed21d6ffd9d635893dd24e749ab7d6a87c62ace750fb1f343e082c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tin-2.6.6-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tin;unpack=0"
SRC_URI[x86_64_v2_tin.sha256sum] = "39d3297c2e11dc2cf3b6a339402f24bb761652f425021a6cb8f96438cb4d670a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/tin-2.6.6-1.el10_2.aarch64.rpm;name=aarch64_tin;unpack=0"
SRC_URI[aarch64_tin.sha256sum] = "f0e6bee2870d0e1ea97a586bf23f3c9614584183d6a8ccc87c283ebcd644e917"

RDEPENDS:tin = " \
 bash \
 glibc \
 libcanlock \
 libgsasl \
 libicu \
 ncurses-libs \
 openssl-libs \
 pcre2 \
 perl-Getopt-Long \
 perl-IO \
 perl-Pod-Usage \
 perl-Sys-Hostname \
 perl-Term-ReadLine \
 perl-Time-Local \
 perl-interpreter \
 perl-libnet \
 perl-libs \
 zlib-ng-compat \
 "
