# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bzip2"
PV = "0.5.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-bzip2+default-devel \
 rust-bzip2+libbz2-rs-sys-devel \
 rust-bzip2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bzip2-0.5.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad0d82a1520b252c1bdeb42dfd6ab88ccba55da0f203b30def02e49c1c8d13eb"

URI_x86_64_v2_rust-bzip2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bzip2+default-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bzip2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bzip2+default-devel}"
SRC_URI[x86_64_v2_rust-bzip2+default-devel.sha256sum] = "c5dd7c3178885fc96e6da613941ec8cc4229c0a5dc96c93b19e3ea0dfb1395b3"

URI_x86_64_v2_rust-bzip2+libbz2-rs-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bzip2+libbz2-rs-sys-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bzip2+libbz2-rs-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bzip2+libbz2-rs-sys-devel}"
SRC_URI[x86_64_v2_rust-bzip2+libbz2-rs-sys-devel.sha256sum] = "5a53f062670c84c3347b8b92aa63dd26cbbf4b0aa0c35bc4e7d170f86a84ccfd"

URI_x86_64_v2_rust-bzip2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bzip2-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bzip2-devel}"
SRC_URI[x86_64_v2_rust-bzip2-devel.sha256sum] = "f3329e237dcc2b9fe33cbbd8d354a4321974df52c94ca3e7d52786c585e984a0"

URI_aarch64_rust-bzip2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bzip2+default-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-bzip2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bzip2+default-devel}"
SRC_URI[aarch64_rust-bzip2+default-devel.sha256sum] = "a6eeb5dda9bf8b2f24302beda3aeeddd07bd112e6b6215b000882c796521847a"

URI_aarch64_rust-bzip2+libbz2-rs-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bzip2+libbz2-rs-sys-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-bzip2+libbz2-rs-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bzip2+libbz2-rs-sys-devel}"
SRC_URI[aarch64_rust-bzip2+libbz2-rs-sys-devel.sha256sum] = "eb14e8620e5f814a9501f499677e67f4616c5783e09f5d2e98a91fbaa9f23504"

URI_aarch64_rust-bzip2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bzip2-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bzip2-devel}"
SRC_URI[aarch64_rust-bzip2-devel.sha256sum] = "2fe12b3f6477cd88ccf25f046a665a3a440c0d75895964f991ec8ac314aca8a0"

RDEPENDS:rust-bzip2+default-devel = " \
 cargo \
 rust-bzip2-devel \
 rust-bzip2-sys+default-devel \
 "
RDEPENDS:rust-bzip2+libbz2-rs-sys-devel = " \
 cargo \
 rust-bzip2-devel \
 rust-bzip2-sys+__disabled-devel \
 rust-bzip2-sys+default-devel \
 rust-libbz2-rs-sys+rust-allocator-devel \
 rust-libbz2-rs-sys+semver-prefix-devel \
 rust-libbz2-rs-sys-devel \
 "
RDEPENDS:rust-bzip2-devel = " \
 cargo \
 rust \
 "
