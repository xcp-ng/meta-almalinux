# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustls-pki-types"
PV = "1.13.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-rustls-pki-types+alloc-devel \
 rust-rustls-pki-types+default-devel \
 rust-rustls-pki-types+std-devel \
 rust-rustls-pki-types+web-devel \
 rust-rustls-pki-types-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustls-pki-types-1.13.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6d1e9f81296801ee60ae427d53c670e12cc42fccf45495f00bed958cfe0470ef"

URI_x86_64_v2_rust-rustls-pki-types+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pki-types+alloc-devel-1.13.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pki-types+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-pki-types+alloc-devel}"
SRC_URI[x86_64_v2_rust-rustls-pki-types+alloc-devel.sha256sum] = "0e85f79d0367db99e12b7fe75421c8522bc60e59097c25b6e6e08b23d05c8f35"

URI_x86_64_v2_rust-rustls-pki-types+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pki-types+default-devel-1.13.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pki-types+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-pki-types+default-devel}"
SRC_URI[x86_64_v2_rust-rustls-pki-types+default-devel.sha256sum] = "2645a327074ded6ded3a147ba139efe141334e2ddb47b31df601bd1b89df86e6"

URI_x86_64_v2_rust-rustls-pki-types+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pki-types+std-devel-1.13.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pki-types+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-pki-types+std-devel}"
SRC_URI[x86_64_v2_rust-rustls-pki-types+std-devel.sha256sum] = "4baa9ccf7fdf5fc697b369a259c4c7eebc8b7ffd8402478647e866295bef3959"

URI_x86_64_v2_rust-rustls-pki-types+web-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pki-types+web-devel-1.13.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pki-types+web-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-pki-types+web-devel}"
SRC_URI[x86_64_v2_rust-rustls-pki-types+web-devel.sha256sum] = "e85a334939d0ef9e592026261d6396b52e20eecfa20e105e7baf0fa5ff99061a"

URI_x86_64_v2_rust-rustls-pki-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pki-types-devel-1.13.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pki-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-pki-types-devel}"
SRC_URI[x86_64_v2_rust-rustls-pki-types-devel.sha256sum] = "3f2c9843e98ee1194a98a4487f197007a6c383fedac6632271d8aa9a0bb1effc"

URI_aarch64_rust-rustls-pki-types+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pki-types+alloc-devel-1.13.0-1.el10_0.noarch.rpm;name=aarch64_rust-rustls-pki-types+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-pki-types+alloc-devel}"
SRC_URI[aarch64_rust-rustls-pki-types+alloc-devel.sha256sum] = "58450070f9f8278def91680dfaaf65037cf0a069c55f1ce2ad6283bb89e4eda8"

URI_aarch64_rust-rustls-pki-types+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pki-types+default-devel-1.13.0-1.el10_0.noarch.rpm;name=aarch64_rust-rustls-pki-types+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-pki-types+default-devel}"
SRC_URI[aarch64_rust-rustls-pki-types+default-devel.sha256sum] = "09dfee0184d8f45b5afbfed38c867894db22a97c476716bb94f5d8360a242d12"

URI_aarch64_rust-rustls-pki-types+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pki-types+std-devel-1.13.0-1.el10_0.noarch.rpm;name=aarch64_rust-rustls-pki-types+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-pki-types+std-devel}"
SRC_URI[aarch64_rust-rustls-pki-types+std-devel.sha256sum] = "8d9579ae3bc13ad55936994932528ad92d365e0e9bb1275e1219316d2e8cb1c1"

URI_aarch64_rust-rustls-pki-types+web-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pki-types+web-devel-1.13.0-1.el10_0.noarch.rpm;name=aarch64_rust-rustls-pki-types+web-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-pki-types+web-devel}"
SRC_URI[aarch64_rust-rustls-pki-types+web-devel.sha256sum] = "dc17eefa270e1dd796c46146a5f832c5e64792b33b9b0c696a494308cf387e5c"

URI_aarch64_rust-rustls-pki-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pki-types-devel-1.13.0-1.el10_0.noarch.rpm;name=aarch64_rust-rustls-pki-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-pki-types-devel}"
SRC_URI[aarch64_rust-rustls-pki-types-devel.sha256sum] = "26588d3b2e38d8289ce0a18b303cbb14a7224b095460b1b799821298e32e8fb1"

RDEPENDS:rust-rustls-pki-types+alloc-devel = " \
 cargo \
 rust-rustls-pki-types-devel \
 rust-zeroize+default-devel \
 "
RDEPENDS:rust-rustls-pki-types+default-devel = " \
 cargo \
 rust-rustls-pki-types+alloc-devel \
 rust-rustls-pki-types-devel \
 "
RDEPENDS:rust-rustls-pki-types+std-devel = " \
 cargo \
 rust-rustls-pki-types+alloc-devel \
 rust-rustls-pki-types-devel \
 "
RDEPENDS:rust-rustls-pki-types+web-devel = " \
 cargo \
 rust-rustls-pki-types-devel \
 "
RDEPENDS:rust-rustls-pki-types-devel = " \
 cargo \
 rust \
 "
