# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "koji-image-builder"
PV = "8"
PR = "1.el10_1"
PACKAGES = " \
 koji-image-builder \
 koji-image-builder-builder \
 koji-image-builder-cli \
 koji-image-builder-hub \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/koji-image-builder-8-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3fd01b1fde0f3282d5cfa87a143f6f182eed07b7e5d41bae2a637c4be0ec2499"

URI_x86_64_v2_koji-image-builder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-image-builder-8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_koji-image-builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-image-builder}"
SRC_URI[x86_64_v2_koji-image-builder.sha256sum] = "85d673961670c3b791b7449711ae824c468f4d623bcdedb0a2a2bb580715b9c3"

URI_x86_64_v2_koji-image-builder-builder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-image-builder-builder-8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_koji-image-builder-builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-image-builder-builder}"
SRC_URI[x86_64_v2_koji-image-builder-builder.sha256sum] = "0eae89fd2a3769d72f6f92315eb9144f583bce1aef92bd53c8ee3ca46d0dfe18"

URI_x86_64_v2_koji-image-builder-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-image-builder-cli-8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_koji-image-builder-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-image-builder-cli}"
SRC_URI[x86_64_v2_koji-image-builder-cli.sha256sum] = "f943f261ef5ea744ebcccc8ef3361dec46834091712af654bbc1d586ecefad44"

URI_x86_64_v2_koji-image-builder-hub = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-image-builder-hub-8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_koji-image-builder-hub;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-image-builder-hub}"
SRC_URI[x86_64_v2_koji-image-builder-hub.sha256sum] = "9fc1705f26fd188aa492a8286bbd8897193f0caf34f148d5f39b18671e6acbf9"

URI_aarch64_koji-image-builder = "${EPEL_MIRROR}/aarch64/Packages/k/koji-image-builder-8-1.el10_1.noarch.rpm;name=aarch64_koji-image-builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-image-builder}"
SRC_URI[aarch64_koji-image-builder.sha256sum] = "44604a205fee26c87e9bc589173a6fa17772133185e832f3e9821ed97f5e8ee3"

URI_aarch64_koji-image-builder-builder = "${EPEL_MIRROR}/aarch64/Packages/k/koji-image-builder-builder-8-1.el10_1.noarch.rpm;name=aarch64_koji-image-builder-builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-image-builder-builder}"
SRC_URI[aarch64_koji-image-builder-builder.sha256sum] = "fac3432cd84546bb51d65a22dca999a0549ae0ec7ce377c8e2fde2f165a37c8f"

URI_aarch64_koji-image-builder-cli = "${EPEL_MIRROR}/aarch64/Packages/k/koji-image-builder-cli-8-1.el10_1.noarch.rpm;name=aarch64_koji-image-builder-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-image-builder-cli}"
SRC_URI[aarch64_koji-image-builder-cli.sha256sum] = "c215b9b0c7a1abedaeabb7c898a966b87689bd0dcc1fa31575e32e8263b3b478"

URI_aarch64_koji-image-builder-hub = "${EPEL_MIRROR}/aarch64/Packages/k/koji-image-builder-hub-8-1.el10_1.noarch.rpm;name=aarch64_koji-image-builder-hub;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-image-builder-hub}"
SRC_URI[aarch64_koji-image-builder-hub.sha256sum] = "04a8ae00f73c76230d9e68f6903c4ff9ea1578a08c1f3175e4177dfc4b564bc7"

RDEPENDS:koji-image-builder = " \
 "
RDEPENDS:koji-image-builder-builder = " \
 koji-builder \
 koji-builder-plugins \
 koji-image-builder \
 python3 \
 "
RDEPENDS:koji-image-builder-cli = " \
 koji \
 koji-image-builder \
 python3 \
 python3-koji-cli-plugins \
 "
RDEPENDS:koji-image-builder-hub = " \
 koji-hub \
 koji-hub-plugins \
 koji-image-builder \
 python3-jsonschema \
 "
