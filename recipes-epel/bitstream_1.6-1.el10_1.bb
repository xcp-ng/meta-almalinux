# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bitstream"
PV = "1.6"
PR = "1.el10_1"
PACKAGES = " \
 bitstream-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/b/bitstream-1.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fccc963ce7705f7e51f11357e1aec8a96964e41c656487a6581609e40651771c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bitstream-devel-1.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_bitstream-devel;unpack=0"
SRC_URI[x86_64_v2_bitstream-devel.sha256sum] = "413615034b3218bad2934e76cf96557700a4119569d0a3e4096e8c63ff93e715"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bitstream-devel-1.6-1.el10_1.noarch.rpm;name=aarch64_bitstream-devel;unpack=0"
SRC_URI[aarch64_bitstream-devel.sha256sum] = "1e7e784f1bd5d57b958008641af4aaa9baef8190f2a7823c83ac0883bc11be7d"

RDEPENDS:bitstream-devel = " \
 pkgconf-pkg-config \
 "
