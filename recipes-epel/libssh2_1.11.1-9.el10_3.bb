# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libssh2"
PV = "1.11.1"
PR = "9.el10_3"
PACKAGES = " \
 libssh2 \
 libssh2-devel \
 libssh2-docs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libssh2-1.11.1-9.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1875c455a67c0f7dda0f2ba7376f55c3a9932f623c1f1e2d932901cac29df238"

URI_x86_64_v2_libssh2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libssh2-1.11.1-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libssh2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libssh2}"
SRC_URI[x86_64_v2_libssh2.sha256sum] = "6783c263e37fcfd363ea57ba0adce056a638de24c7c0814e33715f72570083f1"

URI_x86_64_v2_libssh2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libssh2-devel-1.11.1-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libssh2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libssh2-devel}"
SRC_URI[x86_64_v2_libssh2-devel.sha256sum] = "5fddd85bc2d0f12b9214269152d576729cbf3f4743dabd2295f5c95c6c0c0ada"

URI_x86_64_v2_libssh2-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libssh2-docs-1.11.1-9.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_libssh2-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libssh2-docs}"
SRC_URI[x86_64_v2_libssh2-docs.sha256sum] = "3dfa5e267fdd182fa46e75663e15578289902db941a3b0bbfeac6a257b84bdaf"

URI_aarch64_libssh2 = "${EPEL_MIRROR}/aarch64/Packages/l/libssh2-1.11.1-9.el10_3.aarch64.rpm;name=aarch64_libssh2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libssh2}"
SRC_URI[aarch64_libssh2.sha256sum] = "e4b86ba08b700ba425d236f0a309e5479d2532896de88a345ec3388d161f7b48"

URI_aarch64_libssh2-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libssh2-devel-1.11.1-9.el10_3.aarch64.rpm;name=aarch64_libssh2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libssh2-devel}"
SRC_URI[aarch64_libssh2-devel.sha256sum] = "537b00020dfb06df7dfc107f8ee8c59f6f20cedfb3b1526978f27af0841650d9"

URI_aarch64_libssh2-docs = "${EPEL_MIRROR}/aarch64/Packages/l/libssh2-docs-1.11.1-9.el10_3.noarch.rpm;name=aarch64_libssh2-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libssh2-docs}"
SRC_URI[aarch64_libssh2-docs.sha256sum] = "b991d8d7444f69e6792a5d5212035a0d19c46c031ed3e7c9702ffb70d6266216"

RDEPENDS:libssh2 = " \
 glibc \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:libssh2-devel = " \
 libssh2 \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:libssh2-docs = " \
 libssh2 \
 "
