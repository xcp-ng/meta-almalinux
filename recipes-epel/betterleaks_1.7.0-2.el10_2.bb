# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "betterleaks"
PV = "1.7.0"
PR = "2.el10_2"
PACKAGES = " \
 betterleaks \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/betterleaks-1.7.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d60f964a4981b06a72ea7cb9dd23cf4856dde1bf75de7f65675116dc62fc42d7"

URI_x86_64_v2_betterleaks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/betterleaks-1.7.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_betterleaks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_betterleaks}"
SRC_URI[x86_64_v2_betterleaks.sha256sum] = "cf7847f72297b4e54fb17a895f841a4493bb001fe774745ebfb582abf113a692"

URI_aarch64_betterleaks = "${EPEL_MIRROR}/aarch64/Packages/b/betterleaks-1.7.0-2.el10_2.aarch64.rpm;name=aarch64_betterleaks;unpack=0"
SRC_URI:append = " ${URI_aarch64_betterleaks}"
SRC_URI[aarch64_betterleaks.sha256sum] = "c2bb7c9849fe5d4bd9b6789c6b45f4f7b91abf2ff0b5e3257e7b507b50ff5847"

RDEPENDS:betterleaks = " \
 git-core \
 glibc \
 "
