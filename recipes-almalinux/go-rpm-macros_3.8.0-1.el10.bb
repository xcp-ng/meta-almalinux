# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "go-rpm-macros"
PV = "3.8.0"
PR = "1.el10"
PACKAGES = " \
 go-filesystem \
 go-rpm-macros \
 go-rpm-templates \
 go-srpm-macros \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/go-rpm-macros-3.8.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "490a06f418bc7242d8cb6f3d798aa0c7e3b027d49ae8c71cb69e672240668627"

URI_x86_64_v2_go-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-filesystem-3.8.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_go-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-filesystem}"
SRC_URI[x86_64_v2_go-filesystem.sha256sum] = "24ebdbde4115f2b53c6136e83686797ecb4939ff7e6dda5a4fb243122a126a56"

URI_x86_64_v2_go-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-rpm-macros-3.8.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_go-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-rpm-macros}"
SRC_URI[x86_64_v2_go-rpm-macros.sha256sum] = "a96266a0a76b7c0fb99b7d217a6043221d0b7150d4051e7bc62e972e22582dac"

URI_x86_64_v2_go-rpm-templates = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-rpm-templates-3.8.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_go-rpm-templates;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-rpm-templates}"
SRC_URI[x86_64_v2_go-rpm-templates.sha256sum] = "dbbb01ec2bdef778405a7d3b03e9684741b43950d54b5eafe2b910153dd099e4"

URI_x86_64_v2_go-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-srpm-macros-3.8.0-1.el10.noarch.rpm;name=x86_64_v2_go-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-srpm-macros}"
SRC_URI[x86_64_v2_go-srpm-macros.sha256sum] = "9e5e87cd317a9329616ce89932e0d9c86668c820926ad28d3a55e3421290c4e2"

URI_aarch64_go-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-filesystem-3.8.0-1.el10.aarch64.rpm;name=aarch64_go-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-filesystem}"
SRC_URI[aarch64_go-filesystem.sha256sum] = "ec8e3c06aedee89c8f6f4ae9aff6e4443ef64b6ff1b99a3da10c70bb25bd1095"

URI_aarch64_go-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-rpm-macros-3.8.0-1.el10.aarch64.rpm;name=aarch64_go-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-rpm-macros}"
SRC_URI[aarch64_go-rpm-macros.sha256sum] = "352f5cc824ae491df25b47a65eee72782b52feb815ff33656946faeb0ce10c91"

URI_aarch64_go-rpm-templates = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-rpm-templates-3.8.0-1.el10.aarch64.rpm;name=aarch64_go-rpm-templates;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-rpm-templates}"
SRC_URI[aarch64_go-rpm-templates.sha256sum] = "b882863384d39759802cbdf006568e3b37ae295a037efeea2a581220080d2510"

URI_aarch64_go-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-srpm-macros-3.8.0-1.el10.noarch.rpm;name=aarch64_go-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-srpm-macros}"
SRC_URI[aarch64_go-srpm-macros.sha256sum] = "9e5e87cd317a9329616ce89932e0d9c86668c820926ad28d3a55e3421290c4e2"

RDEPENDS:go-filesystem = " \
 "
RDEPENDS:go-rpm-macros = " \
 bash \
 glibc \
 go-filesystem \
 go-srpm-macros \
 golang \
 python3 \
 "
RDEPENDS:go-rpm-templates = " \
 go-rpm-macros \
 "
RDEPENDS:go-srpm-macros = " \
 redhat-rpm-config \
 "
