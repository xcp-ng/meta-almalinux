# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rpmautospec"
PV = "0.8.4"
PR = "1.el10_3"
PACKAGES = " \
 python3-rpmautospec \
 python3-rpmautospec+all \
 python3-rpmautospec+click \
 python3-rpmautospec+pygit2 \
 python3-rpmautospec+rpm \
 rpmautospec \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-rpmautospec-0.8.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1fecbb2d71826830850962057d9dda269dcb35266182e89cefe4aa59e9c6c8e0"

URI_x86_64_v2_python3-rpmautospec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rpmautospec-0.8.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rpmautospec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rpmautospec}"
SRC_URI[x86_64_v2_python3-rpmautospec.sha256sum] = "329e21542e2a38f291e889963d0e0cb8ca79b352babf9f144ecfc67c099b9e41"

URI_x86_64_v2_python3-rpmautospec+all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rpmautospec+all-0.8.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rpmautospec+all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rpmautospec+all}"
SRC_URI[x86_64_v2_python3-rpmautospec+all.sha256sum] = "cb4d067c0a78c2e8810de775a708872958df690a3b1a83154922607df4a9be6e"

URI_x86_64_v2_python3-rpmautospec+click = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rpmautospec+click-0.8.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rpmautospec+click;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rpmautospec+click}"
SRC_URI[x86_64_v2_python3-rpmautospec+click.sha256sum] = "3e960c2972696452e87379b0634e75c964265653a19a71c5b40933c3efb8627f"

URI_x86_64_v2_python3-rpmautospec+pygit2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rpmautospec+pygit2-0.8.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rpmautospec+pygit2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rpmautospec+pygit2}"
SRC_URI[x86_64_v2_python3-rpmautospec+pygit2.sha256sum] = "7bbeca369ec0c46340c33bf1d9166efa3009580101e2748fb23ad7c8e208c2dc"

URI_x86_64_v2_python3-rpmautospec+rpm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rpmautospec+rpm-0.8.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rpmautospec+rpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rpmautospec+rpm}"
SRC_URI[x86_64_v2_python3-rpmautospec+rpm.sha256sum] = "baad450030c1bb61f629f1f8e030777cad1628a49ddfe171839bf521d1e6afdf"

URI_x86_64_v2_rpmautospec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpmautospec-0.8.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rpmautospec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpmautospec}"
SRC_URI[x86_64_v2_rpmautospec.sha256sum] = "0c64130526aa1466d9f2a7acfe57c521bc96436ef0123b190f6be4bd06a237ac"

URI_aarch64_python3-rpmautospec = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rpmautospec-0.8.4-1.el10_3.noarch.rpm;name=aarch64_python3-rpmautospec;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rpmautospec}"
SRC_URI[aarch64_python3-rpmautospec.sha256sum] = "60fc954afac8a37cab455ddb602a43ef84d0fb02fb92198e26a45c94ca557044"

URI_aarch64_python3-rpmautospec+all = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rpmautospec+all-0.8.4-1.el10_3.noarch.rpm;name=aarch64_python3-rpmautospec+all;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rpmautospec+all}"
SRC_URI[aarch64_python3-rpmautospec+all.sha256sum] = "d572b06298cbdeed8aeca61b33928a7fa7bf1658b5278b2a10610df31ebbbe54"

URI_aarch64_python3-rpmautospec+click = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rpmautospec+click-0.8.4-1.el10_3.noarch.rpm;name=aarch64_python3-rpmautospec+click;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rpmautospec+click}"
SRC_URI[aarch64_python3-rpmautospec+click.sha256sum] = "2dbe1dc9d0f6dc4abd9c9d81a9c84c8c9e31f5b2c74a90d1e4bb016428c22bf8"

URI_aarch64_python3-rpmautospec+pygit2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rpmautospec+pygit2-0.8.4-1.el10_3.noarch.rpm;name=aarch64_python3-rpmautospec+pygit2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rpmautospec+pygit2}"
SRC_URI[aarch64_python3-rpmautospec+pygit2.sha256sum] = "fbafa29df42163fac502eec97beda53fd061a99e758b92eac3330b2927d3efa8"

URI_aarch64_python3-rpmautospec+rpm = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rpmautospec+rpm-0.8.4-1.el10_3.noarch.rpm;name=aarch64_python3-rpmautospec+rpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rpmautospec+rpm}"
SRC_URI[aarch64_python3-rpmautospec+rpm.sha256sum] = "fa35072b4e62051c368b65a0b4380b1f1c561fd539666ead59a725ba4982d524"

URI_aarch64_rpmautospec = "${EPEL_MIRROR}/aarch64/Packages/r/rpmautospec-0.8.4-1.el10_3.noarch.rpm;name=aarch64_rpmautospec;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpmautospec}"
SRC_URI[aarch64_rpmautospec.sha256sum] = "43837412417df27cd8b6dd74b91f43fab3b9d701af04d062a1187ed524f4a14b"

RDEPENDS:python3-rpmautospec = " \
 python3 \
 python3-rpmautospec-core \
 "
RDEPENDS:python3-rpmautospec+all = " \
 python3 \
 python3-click \
 python3-norpm \
 python3-pygit2 \
 python3-rpm \
 python3-rpmautospec \
 "
RDEPENDS:python3-rpmautospec+click = " \
 python3 \
 python3-click \
 python3-rpmautospec \
 "
RDEPENDS:python3-rpmautospec+pygit2 = " \
 python3 \
 python3-pygit2 \
 python3-rpmautospec \
 "
RDEPENDS:python3-rpmautospec+rpm = " \
 python3 \
 python3-rpm \
 python3-rpmautospec \
 "
RDEPENDS:rpmautospec = " \
 libgit2 \
 python3 \
 rpm-build-libs \
 rpm-libs \
 "
