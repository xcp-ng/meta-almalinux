# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Params-Classify"
PV = "0.015"
PR = "18.el10_0"
PACKAGES = " \
 perl-Params-Classify \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Params-Classify-0.015-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd025f02b5fad85e3358169ca6e9759b774521303c8c33cca11323b528f710aa"

URI_x86_64_v2_perl-Params-Classify = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Params-Classify-0.015-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Params-Classify;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Params-Classify}"
SRC_URI[x86_64_v2_perl-Params-Classify.sha256sum] = "1769a2d97c2c5d9f185a07357fa9b7f49e6f7a8f85526aca8fe2d5b0718300bb"

URI_aarch64_perl-Params-Classify = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Params-Classify-0.015-18.el10_0.aarch64.rpm;name=aarch64_perl-Params-Classify;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Params-Classify}"
SRC_URI[aarch64_perl-Params-Classify.sha256sum] = "da8185c80b467afc2052c38f129966b47643bcbf118bff4ac530506f4079bf49"

RDEPENDS:perl-Params-Classify = " \
 glibc \
 perl-Devel-CallChecker \
 perl-Exporter \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-parent \
 "
