# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-cmake"
PV = "0.2.29"
PR = "1.el10_0"
PACKAGES = " \
 python3-colcon-cmake \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-cmake-0.2.29-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e7fd59482cd862308a18b6628fe137f41b9399a07d8b901314347796b31b73c9"

URI_x86_64_v2_python3-colcon-cmake = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-cmake-0.2.29-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-cmake;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-cmake}"
SRC_URI[x86_64_v2_python3-colcon-cmake.sha256sum] = "e5eb1ac1265e3a67283d6859873b32086f4187e0131f2c638e5ab930bf8b3061"

URI_aarch64_python3-colcon-cmake = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-cmake-0.2.29-1.el10_0.noarch.rpm;name=aarch64_python3-colcon-cmake;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-cmake}"
SRC_URI[aarch64_python3-colcon-cmake.sha256sum] = "18e8c25ebe2773c51d37e0ad8dd6077a44166976a475e987b5931368e7a4035d"

RDEPENDS:python3-colcon-cmake = " \
 python3 \
 python3-colcon-core \
 python3-colcon-library-path \
 python3-colcon-test-result \
 python3-packaging \
 "
