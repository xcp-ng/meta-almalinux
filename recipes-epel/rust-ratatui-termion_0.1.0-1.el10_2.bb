# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ratatui-termion"
PV = "0.1.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-ratatui-termion+default-devel \
 rust-ratatui-termion+document-features-devel \
 rust-ratatui-termion+scrolling-regions-devel \
 rust-ratatui-termion+serde-devel \
 rust-ratatui-termion+unstable-backend-writer-devel \
 rust-ratatui-termion+unstable-devel \
 rust-ratatui-termion-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ratatui-termion-0.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a9f04be4dee1a1babb4cf6b6c1e8f2b7561c0ba9b193dc80d7e6c5a6506a0be1"

URI_x86_64_v2_rust-ratatui-termion+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-termion+default-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-termion+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-termion+default-devel}"
SRC_URI[x86_64_v2_rust-ratatui-termion+default-devel.sha256sum] = "ed34d82c9afcd657d558affa62c0f785ef9e3b080ccaf25f9a904a27c50d357b"

URI_x86_64_v2_rust-ratatui-termion+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-termion+document-features-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-termion+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-termion+document-features-devel}"
SRC_URI[x86_64_v2_rust-ratatui-termion+document-features-devel.sha256sum] = "796c5e7693aa623f978da72d0a5aebc0e04bfab9e2ef25698f3b4248875e3719"

URI_x86_64_v2_rust-ratatui-termion+scrolling-regions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-termion+scrolling-regions-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-termion+scrolling-regions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-termion+scrolling-regions-devel}"
SRC_URI[x86_64_v2_rust-ratatui-termion+scrolling-regions-devel.sha256sum] = "365136d8aad573bd5c342972c8f9436cc0b6eb8e93f5c425a95067a0310ac608"

URI_x86_64_v2_rust-ratatui-termion+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-termion+serde-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-termion+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-termion+serde-devel}"
SRC_URI[x86_64_v2_rust-ratatui-termion+serde-devel.sha256sum] = "c85ccdd355f60cbf51456e78c2a4f4c33cd7cbe067207895bd8aad03d7fa3ab3"

URI_x86_64_v2_rust-ratatui-termion+unstable-backend-writer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-termion+unstable-backend-writer-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-termion+unstable-backend-writer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-termion+unstable-backend-writer-devel}"
SRC_URI[x86_64_v2_rust-ratatui-termion+unstable-backend-writer-devel.sha256sum] = "3987b10694fac3350ea8ced09391dd6e2117e0918374b2803bbccc8646475310"

URI_x86_64_v2_rust-ratatui-termion+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-termion+unstable-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-termion+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-termion+unstable-devel}"
SRC_URI[x86_64_v2_rust-ratatui-termion+unstable-devel.sha256sum] = "2cbc99c9226ad1f6079797347e71167ce9e3d42864b9150849080641f59b253e"

URI_x86_64_v2_rust-ratatui-termion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-termion-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-termion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-termion-devel}"
SRC_URI[x86_64_v2_rust-ratatui-termion-devel.sha256sum] = "4a6886ec1d31cd3707aa5a3d8c84319baec7fac825f7fa7bbbaa8b7e93694539"

URI_aarch64_rust-ratatui-termion+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-termion+default-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-termion+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-termion+default-devel}"
SRC_URI[aarch64_rust-ratatui-termion+default-devel.sha256sum] = "5d3029d23389fca070ec4db4a30d64ef58f2b399e7fa509bc7512a7aeb0a99bc"

URI_aarch64_rust-ratatui-termion+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-termion+document-features-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-termion+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-termion+document-features-devel}"
SRC_URI[aarch64_rust-ratatui-termion+document-features-devel.sha256sum] = "2c328e5060c65325f4e0c7c52d6f27ed28f1a540577d6e0d582aad5c7b38cdee"

URI_aarch64_rust-ratatui-termion+scrolling-regions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-termion+scrolling-regions-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-termion+scrolling-regions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-termion+scrolling-regions-devel}"
SRC_URI[aarch64_rust-ratatui-termion+scrolling-regions-devel.sha256sum] = "8642a785e69764c241b266125f7a2ec54a17eb3faf98fb6b1577f109dd710656"

URI_aarch64_rust-ratatui-termion+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-termion+serde-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-termion+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-termion+serde-devel}"
SRC_URI[aarch64_rust-ratatui-termion+serde-devel.sha256sum] = "11da311028a2d4495f1016efa1f4a26e153a17f86ce3f3c3ccbebb7a5add9fa5"

URI_aarch64_rust-ratatui-termion+unstable-backend-writer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-termion+unstable-backend-writer-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-termion+unstable-backend-writer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-termion+unstable-backend-writer-devel}"
SRC_URI[aarch64_rust-ratatui-termion+unstable-backend-writer-devel.sha256sum] = "e102deb4911a9006965374be5285f18e5e0e14412a1d85dc5cb267638d1c7fec"

URI_aarch64_rust-ratatui-termion+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-termion+unstable-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-termion+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-termion+unstable-devel}"
SRC_URI[aarch64_rust-ratatui-termion+unstable-devel.sha256sum] = "bab351c917dbb336c9c560210b647e904be919d99af3ce74402412ba7a36eb45"

URI_aarch64_rust-ratatui-termion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-termion-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-termion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-termion-devel}"
SRC_URI[aarch64_rust-ratatui-termion-devel.sha256sum] = "c24c235aa1e04639bfc8251938d6cf15b93219d8d9a3b7cfe7e951836a81c446"

RDEPENDS:rust-ratatui-termion+default-devel = " \
 cargo \
 rust-ratatui-termion-devel \
 "
RDEPENDS:rust-ratatui-termion+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-ratatui-termion-devel \
 "
RDEPENDS:rust-ratatui-termion+scrolling-regions-devel = " \
 cargo \
 rust-ratatui-core+scrolling-regions-devel \
 rust-ratatui-termion-devel \
 "
RDEPENDS:rust-ratatui-termion+serde-devel = " \
 cargo \
 rust-ratatui-termion-devel \
 rust-termion+serde-devel \
 "
RDEPENDS:rust-ratatui-termion+unstable-backend-writer-devel = " \
 cargo \
 rust-ratatui-termion-devel \
 "
RDEPENDS:rust-ratatui-termion+unstable-devel = " \
 cargo \
 rust-ratatui-termion+unstable-backend-writer-devel \
 rust-ratatui-termion-devel \
 "
RDEPENDS:rust-ratatui-termion-devel = " \
 cargo \
 rust \
 rust-instability+default-devel \
 rust-ratatui-core+default-devel \
 rust-termion+default-devel \
 "
