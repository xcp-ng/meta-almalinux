# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-hypothesis"
PV = "6.104.2"
PR = "7.el10_0"
PACKAGES = " \
 python3-hypothesis \
 python3-hypothesis+dateutil \
 python3-hypothesis+lark \
 python3-hypothesis+numpy \
 python3-hypothesis+pandas \
 python3-hypothesis+pytest \
 python3-hypothesis+pytz \
 python3-hypothesis+redis \
 python3-hypothesis+zoneinfo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-hypothesis-6.104.2-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "842f0586187da3f1d6b4e2c32c52839299e48fdc83b0ce31ac5d28632590a59d"

URI_x86_64_v2_python3-hypothesis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-hypothesis-6.104.2-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-hypothesis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-hypothesis}"
SRC_URI[x86_64_v2_python3-hypothesis.sha256sum] = "07312ea43a8ed9a09a605218744c3756812191de61fc73eda784ba1b89e291bc"

URI_x86_64_v2_python3-hypothesis+dateutil = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-hypothesis+dateutil-6.104.2-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-hypothesis+dateutil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-hypothesis+dateutil}"
SRC_URI[x86_64_v2_python3-hypothesis+dateutil.sha256sum] = "76bdd20f7e77cf9d93e3723cd3db6f0f001f2f77c2526225f9e446ca2b643613"

URI_x86_64_v2_python3-hypothesis+lark = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-hypothesis+lark-6.104.2-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-hypothesis+lark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-hypothesis+lark}"
SRC_URI[x86_64_v2_python3-hypothesis+lark.sha256sum] = "4dc86b14836d7c111ebf099c0bc3aaf10557ada69a2cf4d8e5f565b5a69af9f1"

URI_x86_64_v2_python3-hypothesis+numpy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-hypothesis+numpy-6.104.2-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-hypothesis+numpy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-hypothesis+numpy}"
SRC_URI[x86_64_v2_python3-hypothesis+numpy.sha256sum] = "6d78ba16427e424bd06cb1d15d7bce53ed54fc9a3e6f6c020c4546957e0cd704"

URI_x86_64_v2_python3-hypothesis+pandas = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-hypothesis+pandas-6.104.2-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-hypothesis+pandas;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-hypothesis+pandas}"
SRC_URI[x86_64_v2_python3-hypothesis+pandas.sha256sum] = "de5200d797ab22a4e24202a5a532e0a698410d75fb56e6a5fdfe24236d898971"

URI_x86_64_v2_python3-hypothesis+pytest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-hypothesis+pytest-6.104.2-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-hypothesis+pytest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-hypothesis+pytest}"
SRC_URI[x86_64_v2_python3-hypothesis+pytest.sha256sum] = "ef083a9df2b54c7d10882e11abc75030d97e0502c301abbe516435553f4c6900"

URI_x86_64_v2_python3-hypothesis+pytz = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-hypothesis+pytz-6.104.2-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-hypothesis+pytz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-hypothesis+pytz}"
SRC_URI[x86_64_v2_python3-hypothesis+pytz.sha256sum] = "2b97e87e11b7ecaf1c17dc6b3910e3bbea09a7c235e54eac5b879b55c54fe6a6"

URI_x86_64_v2_python3-hypothesis+redis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-hypothesis+redis-6.104.2-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-hypothesis+redis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-hypothesis+redis}"
SRC_URI[x86_64_v2_python3-hypothesis+redis.sha256sum] = "9844c30401d3410acc42364d744ed42c4c3da54331f5830bb4d7c5114a53b5aa"

URI_x86_64_v2_python3-hypothesis+zoneinfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-hypothesis+zoneinfo-6.104.2-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-hypothesis+zoneinfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-hypothesis+zoneinfo}"
SRC_URI[x86_64_v2_python3-hypothesis+zoneinfo.sha256sum] = "69610436aacd1c4e477f24167d2627dd04b4fa25b7111c84f441a61679b098c4"

URI_aarch64_python3-hypothesis = "${EPEL_MIRROR}/aarch64/Packages/p/python3-hypothesis-6.104.2-7.el10_0.noarch.rpm;name=aarch64_python3-hypothesis;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-hypothesis}"
SRC_URI[aarch64_python3-hypothesis.sha256sum] = "b11538d78ed33dfe5f3f153140d2a537bf8909c02e9d9044d76a820d7f1394b1"

URI_aarch64_python3-hypothesis+dateutil = "${EPEL_MIRROR}/aarch64/Packages/p/python3-hypothesis+dateutil-6.104.2-7.el10_0.noarch.rpm;name=aarch64_python3-hypothesis+dateutil;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-hypothesis+dateutil}"
SRC_URI[aarch64_python3-hypothesis+dateutil.sha256sum] = "48c4894d487dbf5bd0f1ca35aaf1db28e0141047b0fdd6b8d31fdd5986b634f7"

URI_aarch64_python3-hypothesis+lark = "${EPEL_MIRROR}/aarch64/Packages/p/python3-hypothesis+lark-6.104.2-7.el10_0.noarch.rpm;name=aarch64_python3-hypothesis+lark;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-hypothesis+lark}"
SRC_URI[aarch64_python3-hypothesis+lark.sha256sum] = "a7b0eeef9e1b6aaef95559f8ef7b03d02c82c85252218ba2902d0ea019b33633"

URI_aarch64_python3-hypothesis+numpy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-hypothesis+numpy-6.104.2-7.el10_0.noarch.rpm;name=aarch64_python3-hypothesis+numpy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-hypothesis+numpy}"
SRC_URI[aarch64_python3-hypothesis+numpy.sha256sum] = "31e6bdcaf06bf1122bf2c5d6adb556a6af09bdeb259e9d534583339b9fa53c89"

URI_aarch64_python3-hypothesis+pandas = "${EPEL_MIRROR}/aarch64/Packages/p/python3-hypothesis+pandas-6.104.2-7.el10_0.noarch.rpm;name=aarch64_python3-hypothesis+pandas;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-hypothesis+pandas}"
SRC_URI[aarch64_python3-hypothesis+pandas.sha256sum] = "2381d2d2fc15f4457a06d3ff6b41e56ecc7308cd6b19bd74daead9468bd73af7"

URI_aarch64_python3-hypothesis+pytest = "${EPEL_MIRROR}/aarch64/Packages/p/python3-hypothesis+pytest-6.104.2-7.el10_0.noarch.rpm;name=aarch64_python3-hypothesis+pytest;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-hypothesis+pytest}"
SRC_URI[aarch64_python3-hypothesis+pytest.sha256sum] = "b751de220290644e30146c10eae12d315f7f57ef0a0a9b1c83133af960ba4bb5"

URI_aarch64_python3-hypothesis+pytz = "${EPEL_MIRROR}/aarch64/Packages/p/python3-hypothesis+pytz-6.104.2-7.el10_0.noarch.rpm;name=aarch64_python3-hypothesis+pytz;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-hypothesis+pytz}"
SRC_URI[aarch64_python3-hypothesis+pytz.sha256sum] = "e289d52034918f39c7f0e0efc77471669e5d68863af433483868f06ffc35c7ae"

URI_aarch64_python3-hypothesis+redis = "${EPEL_MIRROR}/aarch64/Packages/p/python3-hypothesis+redis-6.104.2-7.el10_0.noarch.rpm;name=aarch64_python3-hypothesis+redis;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-hypothesis+redis}"
SRC_URI[aarch64_python3-hypothesis+redis.sha256sum] = "1879806d42b844a6be08c2dd0b51c62fb4ee36cafd452dd7e6a84a4e3545ec3a"

URI_aarch64_python3-hypothesis+zoneinfo = "${EPEL_MIRROR}/aarch64/Packages/p/python3-hypothesis+zoneinfo-6.104.2-7.el10_0.noarch.rpm;name=aarch64_python3-hypothesis+zoneinfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-hypothesis+zoneinfo}"
SRC_URI[aarch64_python3-hypothesis+zoneinfo.sha256sum] = "315dc12c42763e9233e591e78dec376a23a5f64a04dc94f709f00173b19e8b58"

RDEPENDS:python3-hypothesis = " \
 python3 \
 python3-attrs \
 python3-sortedcontainers \
 "
RDEPENDS:python3-hypothesis+dateutil = " \
 python3 \
 python3-dateutil \
 python3-hypothesis \
 "
RDEPENDS:python3-hypothesis+lark = " \
 python3 \
 python3-hypothesis \
 python3-lark \
 "
RDEPENDS:python3-hypothesis+numpy = " \
 python3 \
 python3-hypothesis \
 python3-numpy \
 "
RDEPENDS:python3-hypothesis+pandas = " \
 python3 \
 python3-hypothesis \
 python3-pandas \
 "
RDEPENDS:python3-hypothesis+pytest = " \
 python3 \
 python3-hypothesis \
 python3-pytest \
 "
RDEPENDS:python3-hypothesis+pytz = " \
 python3 \
 python3-hypothesis \
 python3-pytz \
 "
RDEPENDS:python3-hypothesis+redis = " \
 python3 \
 python3-hypothesis \
 python3-redis \
 "
RDEPENDS:python3-hypothesis+zoneinfo = " \
 python3 \
 python3-hypothesis \
 "
