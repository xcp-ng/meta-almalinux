# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uucore"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uucore+backup-control-devel \
 rust-uucore+base64-simd-devel \
 rust-uucore+bigdecimal-devel \
 rust-uucore+blake2b_simd-devel \
 rust-uucore+blake3-devel \
 rust-uucore+bstr-devel \
 rust-uucore+buf-copy-devel \
 rust-uucore+checksum-devel \
 rust-uucore+colors-devel \
 rust-uucore+crc-fast-devel \
 rust-uucore+data-encoding-devel \
 rust-uucore+data-encoding-macro-devel \
 rust-uucore+default-devel \
 rust-uucore+digest-devel \
 rust-uucore+dns-lookup-devel \
 rust-uucore+dunce-devel \
 rust-uucore+encoding-devel \
 rust-uucore+entries-devel \
 rust-uucore+extendedbigdecimal-devel \
 rust-uucore+fast-inc-devel \
 rust-uucore+feat_systemd_logind-devel \
 rust-uucore+format-devel \
 rust-uucore+fs-devel \
 rust-uucore+fsext-devel \
 rust-uucore+fsxattr-devel \
 rust-uucore+glob-devel \
 rust-uucore+hardware-devel \
 rust-uucore+hex-devel \
 rust-uucore+i18n-all-devel \
 rust-uucore+i18n-charmap-devel \
 rust-uucore+i18n-collator-devel \
 rust-uucore+i18n-common-devel \
 rust-uucore+i18n-datetime-devel \
 rust-uucore+i18n-decimal-devel \
 rust-uucore+icu_calendar-devel \
 rust-uucore+icu_collator-devel \
 rust-uucore+icu_datetime-devel \
 rust-uucore+icu_decimal-devel \
 rust-uucore+icu_locale-devel \
 rust-uucore+icu_provider-devel \
 rust-uucore+itertools-devel \
 rust-uucore+jiff-devel \
 rust-uucore+jiff-icu-devel \
 rust-uucore+libc-devel \
 rust-uucore+lines-devel \
 rust-uucore+md-5-devel \
 rust-uucore+memchr-devel \
 rust-uucore+mode-devel \
 rust-uucore+num-traits-devel \
 rust-uucore+parser-devel \
 rust-uucore+parser-glob-devel \
 rust-uucore+parser-num-devel \
 rust-uucore+parser-size-devel \
 rust-uucore+perms-devel \
 rust-uucore+pipes-devel \
 rust-uucore+proc-info-devel \
 rust-uucore+process-devel \
 rust-uucore+procfs-devel \
 rust-uucore+quoting-style-devel \
 rust-uucore+ranges-devel \
 rust-uucore+ringbuffer-devel \
 rust-uucore+safe-traversal-devel \
 rust-uucore+selinux-devel \
 rust-uucore+sha1-devel \
 rust-uucore+sha2-devel \
 rust-uucore+sha3-devel \
 rust-uucore+signals-devel \
 rust-uucore+sm3-devel \
 rust-uucore+smack-devel \
 rust-uucore+sum-devel \
 rust-uucore+tempfile-devel \
 rust-uucore+time-devel \
 rust-uucore+tty-devel \
 rust-uucore+unit-prefix-devel \
 rust-uucore+update-control-devel \
 rust-uucore+uptime-devel \
 rust-uucore+utf8-devel \
 rust-uucore+utmpx-devel \
 rust-uucore+version-cmp-devel \
 rust-uucore+walkdir-devel \
 rust-uucore+wide-devel \
 rust-uucore+xattr-devel \
 rust-uucore+z85-devel \
 rust-uucore-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uucore-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cfdc26df4ecfa849599dd029d59c6504fe63d1b44539836761e38717a691fd20"

URI_x86_64_v2_rust-uucore+backup-control-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+backup-control-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+backup-control-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+backup-control-devel}"
SRC_URI[x86_64_v2_rust-uucore+backup-control-devel.sha256sum] = "0cf9cb50e77ebf42e3144624b52aedf82443d3edff964e99a89b9456959ecf8a"

URI_x86_64_v2_rust-uucore+base64-simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+base64-simd-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+base64-simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+base64-simd-devel}"
SRC_URI[x86_64_v2_rust-uucore+base64-simd-devel.sha256sum] = "1b3a1e79a0296b01749e6bd00f8e652aa1fbafc9a44dc671bd9904674b17f097"

URI_x86_64_v2_rust-uucore+bigdecimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+bigdecimal-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+bigdecimal-devel}"
SRC_URI[x86_64_v2_rust-uucore+bigdecimal-devel.sha256sum] = "f2d61c85d8e9f31528411ff62257d6bc45979823c6ab4ffc884754f5663eefb3"

URI_x86_64_v2_rust-uucore+blake2b_simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+blake2b_simd-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+blake2b_simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+blake2b_simd-devel}"
SRC_URI[x86_64_v2_rust-uucore+blake2b_simd-devel.sha256sum] = "427e6651efeb02316f87d0d676335cafc9dcb85b08ad598da34fd127c391e767"

URI_x86_64_v2_rust-uucore+blake3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+blake3-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+blake3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+blake3-devel}"
SRC_URI[x86_64_v2_rust-uucore+blake3-devel.sha256sum] = "a18704465f3f3c3243a81e8dda27b6f9d3fe35f1f0632d68e9a0f0254dc7a9f9"

URI_x86_64_v2_rust-uucore+bstr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+bstr-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+bstr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+bstr-devel}"
SRC_URI[x86_64_v2_rust-uucore+bstr-devel.sha256sum] = "a67e0c4d7f5d64f720b31df9c266f1897cf4fbb24a7ebd2f1e65abcbfb4c3366"

URI_x86_64_v2_rust-uucore+buf-copy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+buf-copy-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+buf-copy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+buf-copy-devel}"
SRC_URI[x86_64_v2_rust-uucore+buf-copy-devel.sha256sum] = "18e2268ba8c5b6336049a57d869dccdca2c0c2bae0ca331e73ef9862d148e0b5"

URI_x86_64_v2_rust-uucore+checksum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+checksum-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+checksum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+checksum-devel}"
SRC_URI[x86_64_v2_rust-uucore+checksum-devel.sha256sum] = "60aaf3975fcdcdaf470c12a22b806e724ddafeb127293bea705a333d2afe429a"

URI_x86_64_v2_rust-uucore+colors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+colors-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+colors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+colors-devel}"
SRC_URI[x86_64_v2_rust-uucore+colors-devel.sha256sum] = "27b4fba14259ef41460527cf401c85e9e1d14a9accae5ea72d806189484c9778"

URI_x86_64_v2_rust-uucore+crc-fast-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+crc-fast-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+crc-fast-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+crc-fast-devel}"
SRC_URI[x86_64_v2_rust-uucore+crc-fast-devel.sha256sum] = "700ae52de925c097b2ab2fce4e79aa01cb709c6e8be16bf7e98baa647a38565d"

URI_x86_64_v2_rust-uucore+data-encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+data-encoding-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+data-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+data-encoding-devel}"
SRC_URI[x86_64_v2_rust-uucore+data-encoding-devel.sha256sum] = "218eb7b005f51a91867744570d24685122c0bad6d0465691f5cb5e3efad9f3a1"

URI_x86_64_v2_rust-uucore+data-encoding-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+data-encoding-macro-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+data-encoding-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+data-encoding-macro-devel}"
SRC_URI[x86_64_v2_rust-uucore+data-encoding-macro-devel.sha256sum] = "be99b04d94efc29343b5f87dd7250f824de7908a54a09bc2d5ca794569138877"

URI_x86_64_v2_rust-uucore+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+default-devel}"
SRC_URI[x86_64_v2_rust-uucore+default-devel.sha256sum] = "30fbbc122c14379b8e31b74aa9e39113100b6005de6826d8a475d5c1a9a008b8"

URI_x86_64_v2_rust-uucore+digest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+digest-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+digest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+digest-devel}"
SRC_URI[x86_64_v2_rust-uucore+digest-devel.sha256sum] = "fc923dab61a499b876c168fcc40a447dc41e39f942331cc695e928978e30423e"

URI_x86_64_v2_rust-uucore+dns-lookup-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+dns-lookup-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+dns-lookup-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+dns-lookup-devel}"
SRC_URI[x86_64_v2_rust-uucore+dns-lookup-devel.sha256sum] = "2a99976e7116b16ecc4bc5a753ee18d7184d024dace9e33eb777858000c46d26"

URI_x86_64_v2_rust-uucore+dunce-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+dunce-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+dunce-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+dunce-devel}"
SRC_URI[x86_64_v2_rust-uucore+dunce-devel.sha256sum] = "ee95bd9b03ec4ed1c6d688fa7d08933cfa9f046bc24f514224fe0d6ec93804e7"

URI_x86_64_v2_rust-uucore+encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+encoding-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+encoding-devel}"
SRC_URI[x86_64_v2_rust-uucore+encoding-devel.sha256sum] = "11687e57cf0aad332cd75ee811e2a3fe15507de3ce5c6e68ccfad24948ce7335"

URI_x86_64_v2_rust-uucore+entries-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+entries-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+entries-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+entries-devel}"
SRC_URI[x86_64_v2_rust-uucore+entries-devel.sha256sum] = "0f1bbb29a8945d68f7f5843b65d644c0a04c3222684919fa1b6deba5f39578ae"

URI_x86_64_v2_rust-uucore+extendedbigdecimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+extendedbigdecimal-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+extendedbigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+extendedbigdecimal-devel}"
SRC_URI[x86_64_v2_rust-uucore+extendedbigdecimal-devel.sha256sum] = "61a9b44b0cdddc75d1a4f33a81464f0ff525d31d7eeb892e376a113f4adf8ef0"

URI_x86_64_v2_rust-uucore+fast-inc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+fast-inc-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+fast-inc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+fast-inc-devel}"
SRC_URI[x86_64_v2_rust-uucore+fast-inc-devel.sha256sum] = "4e3b8f45117f48a0c4b519353bf52727c20cb407481f67a8d1bd8de2b126cc75"

URI_x86_64_v2_rust-uucore+feat_systemd_logind-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+feat_systemd_logind-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+feat_systemd_logind-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+feat_systemd_logind-devel}"
SRC_URI[x86_64_v2_rust-uucore+feat_systemd_logind-devel.sha256sum] = "7d755b78984cc08f0dd7dbc308523ce78abaef379bdc797079116ec672c24f03"

URI_x86_64_v2_rust-uucore+format-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+format-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+format-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+format-devel}"
SRC_URI[x86_64_v2_rust-uucore+format-devel.sha256sum] = "80ccd6a6f0e71c178197dffefc1dc8696f26ced9d74a33fb4492c6622452878a"

URI_x86_64_v2_rust-uucore+fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+fs-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+fs-devel}"
SRC_URI[x86_64_v2_rust-uucore+fs-devel.sha256sum] = "56e6a71344ce5d468a114ace7ab7f58eadfaa03d3450781cb2d1002b30ea42cd"

URI_x86_64_v2_rust-uucore+fsext-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+fsext-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+fsext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+fsext-devel}"
SRC_URI[x86_64_v2_rust-uucore+fsext-devel.sha256sum] = "a5144714fc58aa85e94b7eb153101c14c2d53a8a92cf1cd8966777a54d02c553"

URI_x86_64_v2_rust-uucore+fsxattr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+fsxattr-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+fsxattr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+fsxattr-devel}"
SRC_URI[x86_64_v2_rust-uucore+fsxattr-devel.sha256sum] = "19f199fee6450735ace1d5f1bd42989e8f4d76ec827e886d940ceec44906ba50"

URI_x86_64_v2_rust-uucore+glob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+glob-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+glob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+glob-devel}"
SRC_URI[x86_64_v2_rust-uucore+glob-devel.sha256sum] = "891387bdda1a63cdc5ec9bffb3f513be873e4d873c8c21475b424395495abaa2"

URI_x86_64_v2_rust-uucore+hardware-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+hardware-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+hardware-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+hardware-devel}"
SRC_URI[x86_64_v2_rust-uucore+hardware-devel.sha256sum] = "1a21efc8976fa14c148fe4aa392b1b53d04c367a7126696c0399c81bd4c6b0dc"

URI_x86_64_v2_rust-uucore+hex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+hex-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+hex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+hex-devel}"
SRC_URI[x86_64_v2_rust-uucore+hex-devel.sha256sum] = "5e1c98adc7e3b299b4c08613fe6a7a522b03e996fd57a1e4afba8b245132b108"

URI_x86_64_v2_rust-uucore+i18n-all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+i18n-all-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+i18n-all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+i18n-all-devel}"
SRC_URI[x86_64_v2_rust-uucore+i18n-all-devel.sha256sum] = "db19ab859501af16d222f9e1eba3e9971f260677d6fb9a63ea2ba6c4243dfe13"

URI_x86_64_v2_rust-uucore+i18n-charmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+i18n-charmap-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+i18n-charmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+i18n-charmap-devel}"
SRC_URI[x86_64_v2_rust-uucore+i18n-charmap-devel.sha256sum] = "785984fe262ce83e5349953244eb9bf8a043b3f279f5cfb36778e57c6b660ace"

URI_x86_64_v2_rust-uucore+i18n-collator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+i18n-collator-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+i18n-collator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+i18n-collator-devel}"
SRC_URI[x86_64_v2_rust-uucore+i18n-collator-devel.sha256sum] = "edb240ddfe58cf3f8f2c89eae53ed32ab709394967e0bdea0493fe492224e6c5"

URI_x86_64_v2_rust-uucore+i18n-common-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+i18n-common-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+i18n-common-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+i18n-common-devel}"
SRC_URI[x86_64_v2_rust-uucore+i18n-common-devel.sha256sum] = "dcddd0079d0cf11f58d5c9e7459182725359b41eb2967fb464b8693cd7767c98"

URI_x86_64_v2_rust-uucore+i18n-datetime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+i18n-datetime-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+i18n-datetime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+i18n-datetime-devel}"
SRC_URI[x86_64_v2_rust-uucore+i18n-datetime-devel.sha256sum] = "cde062ea3c5f6c626e65badc52e350cb582c8ae7e112e70905d7a0a707039604"

URI_x86_64_v2_rust-uucore+i18n-decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+i18n-decimal-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+i18n-decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+i18n-decimal-devel}"
SRC_URI[x86_64_v2_rust-uucore+i18n-decimal-devel.sha256sum] = "724f5a29eb5fd04191db2a97abd5268131ec3084dc1bb4f8d0a7dcbc4db431c8"

URI_x86_64_v2_rust-uucore+icu_calendar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+icu_calendar-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+icu_calendar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+icu_calendar-devel}"
SRC_URI[x86_64_v2_rust-uucore+icu_calendar-devel.sha256sum] = "c8dfb24e7f8d7f4f9fdfa4366ff6f4ccd685dc94ee30c35fe488c09d791bb130"

URI_x86_64_v2_rust-uucore+icu_collator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+icu_collator-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+icu_collator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+icu_collator-devel}"
SRC_URI[x86_64_v2_rust-uucore+icu_collator-devel.sha256sum] = "cc43631c2d7b749fb00403c2dc742900d4e896469a2f0d21f2ea4810bb6bf84f"

URI_x86_64_v2_rust-uucore+icu_datetime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+icu_datetime-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+icu_datetime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+icu_datetime-devel}"
SRC_URI[x86_64_v2_rust-uucore+icu_datetime-devel.sha256sum] = "ab5511131ea71eeece8843d5c56bdbf3323be414efa72864a70dcfb88a468686"

URI_x86_64_v2_rust-uucore+icu_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+icu_decimal-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+icu_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+icu_decimal-devel}"
SRC_URI[x86_64_v2_rust-uucore+icu_decimal-devel.sha256sum] = "8fcac5a80140404e043ef53be47755a8b3d606a91a11467471337ff260b93163"

URI_x86_64_v2_rust-uucore+icu_locale-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+icu_locale-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+icu_locale-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+icu_locale-devel}"
SRC_URI[x86_64_v2_rust-uucore+icu_locale-devel.sha256sum] = "9ddddaf1abf32132b229d03dc859629ea69c5683e53530667322d0c60243db86"

URI_x86_64_v2_rust-uucore+icu_provider-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+icu_provider-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+icu_provider-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+icu_provider-devel}"
SRC_URI[x86_64_v2_rust-uucore+icu_provider-devel.sha256sum] = "c644bb5c36f614470c230f3369dda814c5a345f880de47fdbc95c1ff235a0968"

URI_x86_64_v2_rust-uucore+itertools-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+itertools-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+itertools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+itertools-devel}"
SRC_URI[x86_64_v2_rust-uucore+itertools-devel.sha256sum] = "3d677f98148276f52f0b574ab78cf4083b8970fe3affeae397a1cd9e49333ef7"

URI_x86_64_v2_rust-uucore+jiff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+jiff-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+jiff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+jiff-devel}"
SRC_URI[x86_64_v2_rust-uucore+jiff-devel.sha256sum] = "e53a626a3acac3ea397da71e9b677a1e489df005e1ff20da99cfdeb6fb8910eb"

URI_x86_64_v2_rust-uucore+jiff-icu-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+jiff-icu-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+jiff-icu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+jiff-icu-devel}"
SRC_URI[x86_64_v2_rust-uucore+jiff-icu-devel.sha256sum] = "52cde884c98f26fd9b3a9a5e3882df69d754676de78c3adf072832b68979f3d8"

URI_x86_64_v2_rust-uucore+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+libc-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+libc-devel}"
SRC_URI[x86_64_v2_rust-uucore+libc-devel.sha256sum] = "e958481a5b457c7123774b3ed81aba4c400cbf10ba13e1403c4b565dfbde5655"

URI_x86_64_v2_rust-uucore+lines-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+lines-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+lines-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+lines-devel}"
SRC_URI[x86_64_v2_rust-uucore+lines-devel.sha256sum] = "7dad38602bcef515fa81f26ccf7769190d9a1907cc3eb8d3b90eadce4ce31f8b"

URI_x86_64_v2_rust-uucore+md-5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+md-5-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+md-5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+md-5-devel}"
SRC_URI[x86_64_v2_rust-uucore+md-5-devel.sha256sum] = "4bc3da3a5e74d249b97febceba6db461358bc0e476d153ef67f0453c84803295"

URI_x86_64_v2_rust-uucore+memchr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+memchr-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+memchr-devel}"
SRC_URI[x86_64_v2_rust-uucore+memchr-devel.sha256sum] = "9633c3503ca5e3ed5ad06ffbc53b29e941df66905e44cad8f1d85fddd585e926"

URI_x86_64_v2_rust-uucore+mode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+mode-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+mode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+mode-devel}"
SRC_URI[x86_64_v2_rust-uucore+mode-devel.sha256sum] = "7e54a4d04532889db4ae24edc201a77d594aa5a954695d9bc11bae4b86658562"

URI_x86_64_v2_rust-uucore+num-traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+num-traits-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+num-traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+num-traits-devel}"
SRC_URI[x86_64_v2_rust-uucore+num-traits-devel.sha256sum] = "77446128ebdffd7314d3d8b21c413fcb0467c9eb1b9e56154cecdc5cb290573a"

URI_x86_64_v2_rust-uucore+parser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+parser-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+parser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+parser-devel}"
SRC_URI[x86_64_v2_rust-uucore+parser-devel.sha256sum] = "d1e7520c7244473a96ac1614c3c6c544eb7b2021969cfd88c521ddb0204cc5f2"

URI_x86_64_v2_rust-uucore+parser-glob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+parser-glob-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+parser-glob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+parser-glob-devel}"
SRC_URI[x86_64_v2_rust-uucore+parser-glob-devel.sha256sum] = "1a099f74e731d8760e4b5656bb050e480d7f03333486ac29cf399ff8cf022ce6"

URI_x86_64_v2_rust-uucore+parser-num-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+parser-num-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+parser-num-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+parser-num-devel}"
SRC_URI[x86_64_v2_rust-uucore+parser-num-devel.sha256sum] = "407b0a600617d64422840d1d56575695642d7dcd24d27a6ccdc3f8792fb64ac9"

URI_x86_64_v2_rust-uucore+parser-size-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+parser-size-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+parser-size-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+parser-size-devel}"
SRC_URI[x86_64_v2_rust-uucore+parser-size-devel.sha256sum] = "f47ae25c5c79047c006c76d3ed10147ab495cf5bb0786e5271dd156bfecdd933"

URI_x86_64_v2_rust-uucore+perms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+perms-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+perms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+perms-devel}"
SRC_URI[x86_64_v2_rust-uucore+perms-devel.sha256sum] = "6dfc4bca03254febd391233778efb615a85f45b8396bc03efe15fcda6d0ecc06"

URI_x86_64_v2_rust-uucore+pipes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+pipes-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+pipes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+pipes-devel}"
SRC_URI[x86_64_v2_rust-uucore+pipes-devel.sha256sum] = "8c7d8941b7cd3cdd6f8c8710892938ca65c8e7f75533f8d9aab24201022d84ae"

URI_x86_64_v2_rust-uucore+proc-info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+proc-info-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+proc-info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+proc-info-devel}"
SRC_URI[x86_64_v2_rust-uucore+proc-info-devel.sha256sum] = "f3f9ae7dcfcac298f0af66e39dee81a022ebc256c1f5330f79ccd4313f5b9a8a"

URI_x86_64_v2_rust-uucore+process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+process-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+process-devel}"
SRC_URI[x86_64_v2_rust-uucore+process-devel.sha256sum] = "eb19b84f80e3ea9bdd402775c492e307011b85d9bc5eaf4738e312b9a8583235"

URI_x86_64_v2_rust-uucore+procfs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+procfs-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+procfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+procfs-devel}"
SRC_URI[x86_64_v2_rust-uucore+procfs-devel.sha256sum] = "aac741b63787342e4d52be486c26a1d2c01b08f39fa432f8fbe8e81f8302a0b9"

URI_x86_64_v2_rust-uucore+quoting-style-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+quoting-style-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+quoting-style-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+quoting-style-devel}"
SRC_URI[x86_64_v2_rust-uucore+quoting-style-devel.sha256sum] = "21b07f23a6a92c905223826e09de314fd326ae5c9be77da6f81af48455b2609d"

URI_x86_64_v2_rust-uucore+ranges-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+ranges-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+ranges-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+ranges-devel}"
SRC_URI[x86_64_v2_rust-uucore+ranges-devel.sha256sum] = "84dc2ccda1e185ee5001ca4a619e9092129dd17e594660c5be075e4bfd10e1d3"

URI_x86_64_v2_rust-uucore+ringbuffer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+ringbuffer-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+ringbuffer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+ringbuffer-devel}"
SRC_URI[x86_64_v2_rust-uucore+ringbuffer-devel.sha256sum] = "e325dda1a091728f90c35d7c40d2028a45ff0e7403b071edba2f2970d17e4786"

URI_x86_64_v2_rust-uucore+safe-traversal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+safe-traversal-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+safe-traversal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+safe-traversal-devel}"
SRC_URI[x86_64_v2_rust-uucore+safe-traversal-devel.sha256sum] = "f28a5d03109743651e986a93a276475e5eca767fa84787c89cfbec40185c62e4"

URI_x86_64_v2_rust-uucore+selinux-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+selinux-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+selinux-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+selinux-devel}"
SRC_URI[x86_64_v2_rust-uucore+selinux-devel.sha256sum] = "3740a3090406e9b35ae2b7452035a57e5aeb7e6734bfed3b676eef32d3dd4d06"

URI_x86_64_v2_rust-uucore+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+sha1-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+sha1-devel}"
SRC_URI[x86_64_v2_rust-uucore+sha1-devel.sha256sum] = "faecd1e31d3f5713af8c476e86420846a53e5d2dabb9db6d4eeea5820d8754dc"

URI_x86_64_v2_rust-uucore+sha2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+sha2-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+sha2-devel}"
SRC_URI[x86_64_v2_rust-uucore+sha2-devel.sha256sum] = "448fa9275f22a64a64ee2d7af7342e0cb4c0b76bdef8b003e8e2d7d395b3257c"

URI_x86_64_v2_rust-uucore+sha3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+sha3-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+sha3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+sha3-devel}"
SRC_URI[x86_64_v2_rust-uucore+sha3-devel.sha256sum] = "2b0790a35503eb5ae58dffb756abb3302a52a56d50ab96c4a7417a193dc11ca9"

URI_x86_64_v2_rust-uucore+signals-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+signals-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+signals-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+signals-devel}"
SRC_URI[x86_64_v2_rust-uucore+signals-devel.sha256sum] = "e6f720dc69414d3353331426604efc8bf11e4468aea00b4c837cd11564b7f85b"

URI_x86_64_v2_rust-uucore+sm3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+sm3-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+sm3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+sm3-devel}"
SRC_URI[x86_64_v2_rust-uucore+sm3-devel.sha256sum] = "e9f3939788094c9fe8ea877b3e90bafc653542619ac65f316b918d52815b590a"

URI_x86_64_v2_rust-uucore+smack-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+smack-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+smack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+smack-devel}"
SRC_URI[x86_64_v2_rust-uucore+smack-devel.sha256sum] = "f30f3f8aa7b33c70a71337391ba10052fd6f15b0306ac6da9d0b7126082e0c34"

URI_x86_64_v2_rust-uucore+sum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+sum-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+sum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+sum-devel}"
SRC_URI[x86_64_v2_rust-uucore+sum-devel.sha256sum] = "2075ad792a73cc679f1589234b007c021b865c9f84b7fcc0f988d193becfe17e"

URI_x86_64_v2_rust-uucore+tempfile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+tempfile-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+tempfile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+tempfile-devel}"
SRC_URI[x86_64_v2_rust-uucore+tempfile-devel.sha256sum] = "f74ea713e03117118fa3ff77877dff97a02cf9120f56bef86888f0b9d54589e7"

URI_x86_64_v2_rust-uucore+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+time-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+time-devel}"
SRC_URI[x86_64_v2_rust-uucore+time-devel.sha256sum] = "32145ff4b6b2133964ffb8c6e71732fa2ac6c2ba56bab84853c4ace97308e037"

URI_x86_64_v2_rust-uucore+tty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+tty-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+tty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+tty-devel}"
SRC_URI[x86_64_v2_rust-uucore+tty-devel.sha256sum] = "0ea10256e841a3d1d4f71613ffde88ae6ee98fa11506b1ada22536043de3de74"

URI_x86_64_v2_rust-uucore+unit-prefix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+unit-prefix-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+unit-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+unit-prefix-devel}"
SRC_URI[x86_64_v2_rust-uucore+unit-prefix-devel.sha256sum] = "cc75bfdd506cfc42aef659f76a21cf6abe91149f3c2ae029eca6dc4a8271cd78"

URI_x86_64_v2_rust-uucore+update-control-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+update-control-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+update-control-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+update-control-devel}"
SRC_URI[x86_64_v2_rust-uucore+update-control-devel.sha256sum] = "7f792ac978326f952df8a60445068208a68c27df9d5ca5cd93ba01cf84509477"

URI_x86_64_v2_rust-uucore+uptime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+uptime-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+uptime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+uptime-devel}"
SRC_URI[x86_64_v2_rust-uucore+uptime-devel.sha256sum] = "33ca03be74504ff60e7d039bf736345f9d163b4db73b72f68e8dbca9134310e8"

URI_x86_64_v2_rust-uucore+utf8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+utf8-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+utf8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+utf8-devel}"
SRC_URI[x86_64_v2_rust-uucore+utf8-devel.sha256sum] = "be32aed7ab95c4dc6c73b80b6c75fccc5528335594bc445741884651abbe38c6"

URI_x86_64_v2_rust-uucore+utmpx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+utmpx-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+utmpx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+utmpx-devel}"
SRC_URI[x86_64_v2_rust-uucore+utmpx-devel.sha256sum] = "fe3a7ce95ad40dd016596bb1f2a3223f4ea81adc515f4b809397674af7f8bd50"

URI_x86_64_v2_rust-uucore+version-cmp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+version-cmp-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+version-cmp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+version-cmp-devel}"
SRC_URI[x86_64_v2_rust-uucore+version-cmp-devel.sha256sum] = "422801b28f7bdc3e65a608b1262fe8f951c05f0ce4ff3d961d6df7135ad58600"

URI_x86_64_v2_rust-uucore+walkdir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+walkdir-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+walkdir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+walkdir-devel}"
SRC_URI[x86_64_v2_rust-uucore+walkdir-devel.sha256sum] = "875ff1e3eb59fd40c184a73533ad59e4f4f3e48b24799b46bc0c1e3713c2f4d6"

URI_x86_64_v2_rust-uucore+wide-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+wide-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+wide-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+wide-devel}"
SRC_URI[x86_64_v2_rust-uucore+wide-devel.sha256sum] = "ce9bcfd5e42e614194760a83ad8c4b590ca40a346373184e5341061b0542d7c5"

URI_x86_64_v2_rust-uucore+xattr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+xattr-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+xattr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+xattr-devel}"
SRC_URI[x86_64_v2_rust-uucore+xattr-devel.sha256sum] = "fc61af2ae7e6002a85c2350cdbe2544142f12cf5b10243c70b741ee15f4d6fa8"

URI_x86_64_v2_rust-uucore+z85-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore+z85-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore+z85-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore+z85-devel}"
SRC_URI[x86_64_v2_rust-uucore+z85-devel.sha256sum] = "3a23776f055b36ee2fd5037f5646d5047dd4b8424b9d373c0050fccd98e474b0"

URI_x86_64_v2_rust-uucore-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore-devel}"
SRC_URI[x86_64_v2_rust-uucore-devel.sha256sum] = "1e1b3d6165614ca7c69bce638d6f000a17b35470d25558ec6e6b3a2f35e46c3d"

URI_aarch64_rust-uucore+backup-control-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+backup-control-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+backup-control-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+backup-control-devel}"
SRC_URI[aarch64_rust-uucore+backup-control-devel.sha256sum] = "e4e3a7ee1526d5880f562496f2a5c16e3f7c83f20b875fe64aa655b2e07cb585"

URI_aarch64_rust-uucore+base64-simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+base64-simd-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+base64-simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+base64-simd-devel}"
SRC_URI[aarch64_rust-uucore+base64-simd-devel.sha256sum] = "1d555d4945c155df2be9a7e78027806b1a21aab7808d1e3f3a34b16e79b70bd5"

URI_aarch64_rust-uucore+bigdecimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+bigdecimal-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+bigdecimal-devel}"
SRC_URI[aarch64_rust-uucore+bigdecimal-devel.sha256sum] = "8896880235736f8ca25688aeb9c7abd87a3a6e73ff6f6df8db57333a325e8871"

URI_aarch64_rust-uucore+blake2b_simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+blake2b_simd-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+blake2b_simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+blake2b_simd-devel}"
SRC_URI[aarch64_rust-uucore+blake2b_simd-devel.sha256sum] = "da66ff49a9c6d38ec834c5b1727c25e4489d69f5dc1e75bad849344a9b32ae46"

URI_aarch64_rust-uucore+blake3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+blake3-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+blake3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+blake3-devel}"
SRC_URI[aarch64_rust-uucore+blake3-devel.sha256sum] = "69e183ff9b9b2772cde52fa7a39eafdbcba1c49fbb3a133a42184201ac068e8c"

URI_aarch64_rust-uucore+bstr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+bstr-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+bstr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+bstr-devel}"
SRC_URI[aarch64_rust-uucore+bstr-devel.sha256sum] = "18965de7ab4ae48f8130b57b7957e858e8a200b7002f8444d11c8639c3bcaa3b"

URI_aarch64_rust-uucore+buf-copy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+buf-copy-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+buf-copy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+buf-copy-devel}"
SRC_URI[aarch64_rust-uucore+buf-copy-devel.sha256sum] = "92f89fb649ce746cf2cd67d3e54689a30474100dfbf2b8844e4e7805a3109ce9"

URI_aarch64_rust-uucore+checksum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+checksum-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+checksum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+checksum-devel}"
SRC_URI[aarch64_rust-uucore+checksum-devel.sha256sum] = "018990d8f9ab42f49081592ad361e42862f94d69b67e21f8fa65940aef8d09a3"

URI_aarch64_rust-uucore+colors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+colors-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+colors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+colors-devel}"
SRC_URI[aarch64_rust-uucore+colors-devel.sha256sum] = "35dccf9d82863941972c79e265df47965c55529ee0f4744862b0e1e08c0601c2"

URI_aarch64_rust-uucore+crc-fast-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+crc-fast-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+crc-fast-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+crc-fast-devel}"
SRC_URI[aarch64_rust-uucore+crc-fast-devel.sha256sum] = "d58db757bfc826206ae210f43c8b241cbe967d4feae978e24d4ed1beeaba8a35"

URI_aarch64_rust-uucore+data-encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+data-encoding-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+data-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+data-encoding-devel}"
SRC_URI[aarch64_rust-uucore+data-encoding-devel.sha256sum] = "95ce44477f3bdcc2214afcbd7e59bccbc57ccd5020b0751f8d691a5bc9c590dd"

URI_aarch64_rust-uucore+data-encoding-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+data-encoding-macro-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+data-encoding-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+data-encoding-macro-devel}"
SRC_URI[aarch64_rust-uucore+data-encoding-macro-devel.sha256sum] = "3dbc2e8730fc8888a58b9523e1435ae9e75a955a7c8c3c856fcbd61cc7c22ef9"

URI_aarch64_rust-uucore+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+default-devel}"
SRC_URI[aarch64_rust-uucore+default-devel.sha256sum] = "a001585f91d50293382f2aefbfbf9487715a27b55f2ea3b05516d4488cc05ff4"

URI_aarch64_rust-uucore+digest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+digest-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+digest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+digest-devel}"
SRC_URI[aarch64_rust-uucore+digest-devel.sha256sum] = "e45b6a24a6c1c18016749707a543b1c41491016e850d43ca1f83d3e232c0894d"

URI_aarch64_rust-uucore+dns-lookup-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+dns-lookup-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+dns-lookup-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+dns-lookup-devel}"
SRC_URI[aarch64_rust-uucore+dns-lookup-devel.sha256sum] = "a295ff670c5bbdeb77d9842cf39dfb7c33928b4919be7a3967e080bce6363fa9"

URI_aarch64_rust-uucore+dunce-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+dunce-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+dunce-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+dunce-devel}"
SRC_URI[aarch64_rust-uucore+dunce-devel.sha256sum] = "efe28c2d59a890ebd8cbb126f9a11f3dafa420156ff41de69462ccc051d08d2e"

URI_aarch64_rust-uucore+encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+encoding-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+encoding-devel}"
SRC_URI[aarch64_rust-uucore+encoding-devel.sha256sum] = "f74f9643d3ddc45a2b4525c875148a3ea6254ba3bc1a57e6e27149d70792be85"

URI_aarch64_rust-uucore+entries-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+entries-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+entries-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+entries-devel}"
SRC_URI[aarch64_rust-uucore+entries-devel.sha256sum] = "788a7bb04378ee245b6fb48a1b2a92f7a822bdc634268aeb75c4d5d2542c09d9"

URI_aarch64_rust-uucore+extendedbigdecimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+extendedbigdecimal-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+extendedbigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+extendedbigdecimal-devel}"
SRC_URI[aarch64_rust-uucore+extendedbigdecimal-devel.sha256sum] = "80f0d8ce5e574d590a4cacc7da96bd450fe21feec57886ef37fab6e3b39f4e38"

URI_aarch64_rust-uucore+fast-inc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+fast-inc-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+fast-inc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+fast-inc-devel}"
SRC_URI[aarch64_rust-uucore+fast-inc-devel.sha256sum] = "917247d957bbe71ba2d35fe02ee2f637cff725fccf5e5ac4513d3792764e75f0"

URI_aarch64_rust-uucore+feat_systemd_logind-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+feat_systemd_logind-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+feat_systemd_logind-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+feat_systemd_logind-devel}"
SRC_URI[aarch64_rust-uucore+feat_systemd_logind-devel.sha256sum] = "4aacd268f7116071b8c446e2a360ede781d59d923b8f64a8d26dc8983dbef197"

URI_aarch64_rust-uucore+format-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+format-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+format-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+format-devel}"
SRC_URI[aarch64_rust-uucore+format-devel.sha256sum] = "48990295c13de77f01adc6f3f6ed1bba4184b250810689edf2eba8c38a531226"

URI_aarch64_rust-uucore+fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+fs-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+fs-devel}"
SRC_URI[aarch64_rust-uucore+fs-devel.sha256sum] = "dbc120c66f8f7c3bd4a07cd68ba1ba2f662d58662471f49a2c306c185252caaf"

URI_aarch64_rust-uucore+fsext-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+fsext-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+fsext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+fsext-devel}"
SRC_URI[aarch64_rust-uucore+fsext-devel.sha256sum] = "75b6ff966b3421a51593c63ff2cce98aa616712ade0acd263d1daa666c5b0206"

URI_aarch64_rust-uucore+fsxattr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+fsxattr-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+fsxattr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+fsxattr-devel}"
SRC_URI[aarch64_rust-uucore+fsxattr-devel.sha256sum] = "956055aa8ce02cb13a5ba65b04660d06dfe8b0939197435f491bc36a93ae71ef"

URI_aarch64_rust-uucore+glob-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+glob-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+glob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+glob-devel}"
SRC_URI[aarch64_rust-uucore+glob-devel.sha256sum] = "bb09040f90368ec8efaca05a884b0162c82073ad6b914f3ec2cd46a313921848"

URI_aarch64_rust-uucore+hardware-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+hardware-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+hardware-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+hardware-devel}"
SRC_URI[aarch64_rust-uucore+hardware-devel.sha256sum] = "7081634e4e9e9f9895e71fa5fbfd8a3e900e8dd024dcfe7324147de2197fc168"

URI_aarch64_rust-uucore+hex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+hex-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+hex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+hex-devel}"
SRC_URI[aarch64_rust-uucore+hex-devel.sha256sum] = "1a2d7564d2d33ecdc4d95b20712d1127c9810af1c836c147d238f39299e2e5c4"

URI_aarch64_rust-uucore+i18n-all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+i18n-all-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+i18n-all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+i18n-all-devel}"
SRC_URI[aarch64_rust-uucore+i18n-all-devel.sha256sum] = "dae4a2ddc9e92156f7c2c0f343461bb1581ae80e56e94098a8db1f7f8f84d37d"

URI_aarch64_rust-uucore+i18n-charmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+i18n-charmap-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+i18n-charmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+i18n-charmap-devel}"
SRC_URI[aarch64_rust-uucore+i18n-charmap-devel.sha256sum] = "e6312274a4c801f2c752ab85752a3f8729c373a1ee635422750f519915897961"

URI_aarch64_rust-uucore+i18n-collator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+i18n-collator-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+i18n-collator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+i18n-collator-devel}"
SRC_URI[aarch64_rust-uucore+i18n-collator-devel.sha256sum] = "e61cb54a61a1f76f0cde9677ab33b6cc3ffbe4d8aed065b4ce46fb2619eb44ef"

URI_aarch64_rust-uucore+i18n-common-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+i18n-common-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+i18n-common-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+i18n-common-devel}"
SRC_URI[aarch64_rust-uucore+i18n-common-devel.sha256sum] = "411e201c0c857d66d84a007e2f4c937ccd422cb4e665501fb44b29a5d62d5748"

URI_aarch64_rust-uucore+i18n-datetime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+i18n-datetime-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+i18n-datetime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+i18n-datetime-devel}"
SRC_URI[aarch64_rust-uucore+i18n-datetime-devel.sha256sum] = "9c9bb9417e94afb6f765d28358835b5e3e4b4cfae603ceaa137110bad423d2d9"

URI_aarch64_rust-uucore+i18n-decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+i18n-decimal-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+i18n-decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+i18n-decimal-devel}"
SRC_URI[aarch64_rust-uucore+i18n-decimal-devel.sha256sum] = "aef49d5955bfd7a81daf1d22594b4fddd55a5a6b5938beeffd2ba73476b43b29"

URI_aarch64_rust-uucore+icu_calendar-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+icu_calendar-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+icu_calendar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+icu_calendar-devel}"
SRC_URI[aarch64_rust-uucore+icu_calendar-devel.sha256sum] = "db8d6541572a687818316be446b556777f4e57e1b0cd0835009b47ea3a77959e"

URI_aarch64_rust-uucore+icu_collator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+icu_collator-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+icu_collator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+icu_collator-devel}"
SRC_URI[aarch64_rust-uucore+icu_collator-devel.sha256sum] = "83a3593e0a0250f656d2637f3078a71a032d85c5251748cb9507d6fd8316ecd9"

URI_aarch64_rust-uucore+icu_datetime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+icu_datetime-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+icu_datetime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+icu_datetime-devel}"
SRC_URI[aarch64_rust-uucore+icu_datetime-devel.sha256sum] = "d7ab20415cb5288794deab4f570d58d23129553b3c8b78225c0cc56997dcb90f"

URI_aarch64_rust-uucore+icu_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+icu_decimal-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+icu_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+icu_decimal-devel}"
SRC_URI[aarch64_rust-uucore+icu_decimal-devel.sha256sum] = "7f010a208768a1212b5e1d65168667182ea51f3e3e67ba44c37e41f77cb595e9"

URI_aarch64_rust-uucore+icu_locale-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+icu_locale-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+icu_locale-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+icu_locale-devel}"
SRC_URI[aarch64_rust-uucore+icu_locale-devel.sha256sum] = "d8bba4d008836952388ade3c372ce307258a8e26e431f7c56dd6ab94254741df"

URI_aarch64_rust-uucore+icu_provider-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+icu_provider-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+icu_provider-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+icu_provider-devel}"
SRC_URI[aarch64_rust-uucore+icu_provider-devel.sha256sum] = "de4363c421ca9c8893014e962e1d480bbfee293c7cd412e42611130a4312493c"

URI_aarch64_rust-uucore+itertools-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+itertools-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+itertools-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+itertools-devel}"
SRC_URI[aarch64_rust-uucore+itertools-devel.sha256sum] = "6dbefe0eebf930beefe075be9829a6c2c58a4ab20da15da9b9f0a5b85e3d26c5"

URI_aarch64_rust-uucore+jiff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+jiff-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+jiff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+jiff-devel}"
SRC_URI[aarch64_rust-uucore+jiff-devel.sha256sum] = "10fee173098342a2a05a435a5582b154d2b0f87ca62982d19aba1ba8af360b50"

URI_aarch64_rust-uucore+jiff-icu-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+jiff-icu-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+jiff-icu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+jiff-icu-devel}"
SRC_URI[aarch64_rust-uucore+jiff-icu-devel.sha256sum] = "acc107a39fd2b3863b85f324ede3a1b506c6dcf8901bb1922c3c6d0d1783f056"

URI_aarch64_rust-uucore+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+libc-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+libc-devel}"
SRC_URI[aarch64_rust-uucore+libc-devel.sha256sum] = "2ddf534e09327c40bb4d6055ed944abaa2d22acabf53c7782f0b5dfa004f0bf6"

URI_aarch64_rust-uucore+lines-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+lines-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+lines-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+lines-devel}"
SRC_URI[aarch64_rust-uucore+lines-devel.sha256sum] = "a0aad500fab12387ca770f0a943cf98ec97d4e5f0673e0b2c5d96a36715fc6eb"

URI_aarch64_rust-uucore+md-5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+md-5-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+md-5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+md-5-devel}"
SRC_URI[aarch64_rust-uucore+md-5-devel.sha256sum] = "d6836faa5fd64625329afecd84941f63f71585ff3bee4195242eb8420a9ed79a"

URI_aarch64_rust-uucore+memchr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+memchr-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+memchr-devel}"
SRC_URI[aarch64_rust-uucore+memchr-devel.sha256sum] = "51b5aa5bdaa2750714ccd8b0ca9629a760693271ecd6d9276996d48f0dc48bd7"

URI_aarch64_rust-uucore+mode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+mode-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+mode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+mode-devel}"
SRC_URI[aarch64_rust-uucore+mode-devel.sha256sum] = "46ee8157ebe4671bd6137c4c0a4f0d79b86c710927973faabbca2163d6d59601"

URI_aarch64_rust-uucore+num-traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+num-traits-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+num-traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+num-traits-devel}"
SRC_URI[aarch64_rust-uucore+num-traits-devel.sha256sum] = "b439824dbb0c7cbb196aedcf6b764a431acde831a13af957ce07f16eb316853d"

URI_aarch64_rust-uucore+parser-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+parser-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+parser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+parser-devel}"
SRC_URI[aarch64_rust-uucore+parser-devel.sha256sum] = "7ebac7fb18d8020095f5c376b6c3350a2745a49ee004b10c5e65d0bc5814c333"

URI_aarch64_rust-uucore+parser-glob-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+parser-glob-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+parser-glob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+parser-glob-devel}"
SRC_URI[aarch64_rust-uucore+parser-glob-devel.sha256sum] = "a83246966c0082ac9d7212805217a3e5875e8abb1f7f2ff5ae68cb1b2b0b39e2"

URI_aarch64_rust-uucore+parser-num-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+parser-num-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+parser-num-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+parser-num-devel}"
SRC_URI[aarch64_rust-uucore+parser-num-devel.sha256sum] = "8269c62d62b4de9e9af5876e2166f916c8bb530faa230f2ea6e174b2fd97e4af"

URI_aarch64_rust-uucore+parser-size-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+parser-size-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+parser-size-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+parser-size-devel}"
SRC_URI[aarch64_rust-uucore+parser-size-devel.sha256sum] = "5d56b799efa1afcc46b26b065b4831cfd9ae3d06ecccd890a30f6b65f04d344f"

URI_aarch64_rust-uucore+perms-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+perms-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+perms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+perms-devel}"
SRC_URI[aarch64_rust-uucore+perms-devel.sha256sum] = "013942dd8582c62dae83c16e43954b4c74a0be1b2c3c721d6ca043fb9946d52a"

URI_aarch64_rust-uucore+pipes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+pipes-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+pipes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+pipes-devel}"
SRC_URI[aarch64_rust-uucore+pipes-devel.sha256sum] = "33e26a776cc9a669bab77da2bf12002743d09bd16427bd90be1a48f7bbf4df7f"

URI_aarch64_rust-uucore+proc-info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+proc-info-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+proc-info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+proc-info-devel}"
SRC_URI[aarch64_rust-uucore+proc-info-devel.sha256sum] = "b20aa164d1bc18462210365d3863589ac67536c33dda4fa93ab57512f5f9f2ac"

URI_aarch64_rust-uucore+process-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+process-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+process-devel}"
SRC_URI[aarch64_rust-uucore+process-devel.sha256sum] = "8926ce4ff0c96fda448090d609bb460b2591f75b9e87c8242f4fa2049e9b96e3"

URI_aarch64_rust-uucore+procfs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+procfs-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+procfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+procfs-devel}"
SRC_URI[aarch64_rust-uucore+procfs-devel.sha256sum] = "e803a504fac0c391de34aea13826973711ba725a0aef1d36dce8a3457223232a"

URI_aarch64_rust-uucore+quoting-style-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+quoting-style-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+quoting-style-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+quoting-style-devel}"
SRC_URI[aarch64_rust-uucore+quoting-style-devel.sha256sum] = "535771b5d891c75be1d33dd91178a18fed0ced770d7284afbee6f6f2152b9d63"

URI_aarch64_rust-uucore+ranges-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+ranges-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+ranges-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+ranges-devel}"
SRC_URI[aarch64_rust-uucore+ranges-devel.sha256sum] = "095f8c26fa8d5653b9103b765979b3ed4e5e75c0c0f6278b0611a1a0f5658cef"

URI_aarch64_rust-uucore+ringbuffer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+ringbuffer-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+ringbuffer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+ringbuffer-devel}"
SRC_URI[aarch64_rust-uucore+ringbuffer-devel.sha256sum] = "68dcf7169424137df9d332d52b1d3ba7586a571f1e888f7d04037074b553f7b6"

URI_aarch64_rust-uucore+safe-traversal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+safe-traversal-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+safe-traversal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+safe-traversal-devel}"
SRC_URI[aarch64_rust-uucore+safe-traversal-devel.sha256sum] = "4cf6f542b8c66b8d6f500c22cfc6e61b249f52624749d9995b18adac46e7147c"

URI_aarch64_rust-uucore+selinux-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+selinux-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+selinux-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+selinux-devel}"
SRC_URI[aarch64_rust-uucore+selinux-devel.sha256sum] = "7088bd8686c8d89918354ca23585c76177e97f16e2cd0b15bc9d5cf2a0b1ca2d"

URI_aarch64_rust-uucore+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+sha1-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+sha1-devel}"
SRC_URI[aarch64_rust-uucore+sha1-devel.sha256sum] = "9f3f01072db7e9a72be9ec55044bbc4eb7e8b4f52e2fa326ebbb22b871a062f3"

URI_aarch64_rust-uucore+sha2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+sha2-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+sha2-devel}"
SRC_URI[aarch64_rust-uucore+sha2-devel.sha256sum] = "50b27e110f650c7f745fee8d2cb95ef4d8cdcdd4e67de0566268e68bcda16bd0"

URI_aarch64_rust-uucore+sha3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+sha3-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+sha3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+sha3-devel}"
SRC_URI[aarch64_rust-uucore+sha3-devel.sha256sum] = "5125a9acc2870c079e3458be78a1f1951ab167936fff61315c21e6a22cdd921b"

URI_aarch64_rust-uucore+signals-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+signals-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+signals-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+signals-devel}"
SRC_URI[aarch64_rust-uucore+signals-devel.sha256sum] = "169ff5ca8de60624ae2214625c2132e8c4b599fab3ce74f78cd6fdeabd5534de"

URI_aarch64_rust-uucore+sm3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+sm3-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+sm3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+sm3-devel}"
SRC_URI[aarch64_rust-uucore+sm3-devel.sha256sum] = "d00606511ddebb3e1cc1755384422b8dbab5fdc2ef4f39d81a4ce78683c21b86"

URI_aarch64_rust-uucore+smack-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+smack-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+smack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+smack-devel}"
SRC_URI[aarch64_rust-uucore+smack-devel.sha256sum] = "fbdaf49cab69e8df5d4df33db26e929aabe330886c4ce638918d3b44bfe148d2"

URI_aarch64_rust-uucore+sum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+sum-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+sum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+sum-devel}"
SRC_URI[aarch64_rust-uucore+sum-devel.sha256sum] = "5450774a6037d3492cc8f8961fdbc710db4748b06c6d8fb1a09f3b601da5039f"

URI_aarch64_rust-uucore+tempfile-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+tempfile-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+tempfile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+tempfile-devel}"
SRC_URI[aarch64_rust-uucore+tempfile-devel.sha256sum] = "92a03b38f562f97bed39a74f18a8ba05402f153ed746133939fb39341631f314"

URI_aarch64_rust-uucore+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+time-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+time-devel}"
SRC_URI[aarch64_rust-uucore+time-devel.sha256sum] = "9215002a368a0337325232c7e8eab0cfa69e41f90ea1f714c69294affe09256e"

URI_aarch64_rust-uucore+tty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+tty-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+tty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+tty-devel}"
SRC_URI[aarch64_rust-uucore+tty-devel.sha256sum] = "0b7443e6c37a762726aecc0f59fa74b41becc38868fe564c16b041fc12cfb23b"

URI_aarch64_rust-uucore+unit-prefix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+unit-prefix-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+unit-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+unit-prefix-devel}"
SRC_URI[aarch64_rust-uucore+unit-prefix-devel.sha256sum] = "1247a7a84ec967d7960dbe7b11e6a187047e429f3ff889f2422aa307cfde8c6b"

URI_aarch64_rust-uucore+update-control-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+update-control-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+update-control-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+update-control-devel}"
SRC_URI[aarch64_rust-uucore+update-control-devel.sha256sum] = "cab7ff5a88d9a166b19c5d25b997369dd014a84f8b4d4413473111e3e8c571eb"

URI_aarch64_rust-uucore+uptime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+uptime-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+uptime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+uptime-devel}"
SRC_URI[aarch64_rust-uucore+uptime-devel.sha256sum] = "63afee391e48914c0b98e0b0b609ed697f990d4898a1d509de9f3cc2ce88215b"

URI_aarch64_rust-uucore+utf8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+utf8-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+utf8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+utf8-devel}"
SRC_URI[aarch64_rust-uucore+utf8-devel.sha256sum] = "e5ec723b68d164bc7fa3d4d5e65706434c2cb66d828c273ae242b161a6bcedc3"

URI_aarch64_rust-uucore+utmpx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+utmpx-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+utmpx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+utmpx-devel}"
SRC_URI[aarch64_rust-uucore+utmpx-devel.sha256sum] = "99925d598613cbd36636197921f343bf565922181f7a3188f5f687fb9a17db1b"

URI_aarch64_rust-uucore+version-cmp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+version-cmp-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+version-cmp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+version-cmp-devel}"
SRC_URI[aarch64_rust-uucore+version-cmp-devel.sha256sum] = "bbd54486d624da79938431c742aa182c69e891c5c7d6e6437b068fe6df753716"

URI_aarch64_rust-uucore+walkdir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+walkdir-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+walkdir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+walkdir-devel}"
SRC_URI[aarch64_rust-uucore+walkdir-devel.sha256sum] = "1aa41c639becaaa0dc71371a395b3167336985a855a5a419f9eeefe8c0cf2985"

URI_aarch64_rust-uucore+wide-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+wide-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+wide-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+wide-devel}"
SRC_URI[aarch64_rust-uucore+wide-devel.sha256sum] = "9d6cb61e83f08d91c42e4b307d67d85ba21e272deb8348dcb4a1d05b50304124"

URI_aarch64_rust-uucore+xattr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+xattr-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+xattr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+xattr-devel}"
SRC_URI[aarch64_rust-uucore+xattr-devel.sha256sum] = "c49454798cdb91a81656e2a19a1fcfb544860f0687423220d9d0d8a69444b5e2"

URI_aarch64_rust-uucore+z85-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore+z85-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore+z85-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore+z85-devel}"
SRC_URI[aarch64_rust-uucore+z85-devel.sha256sum] = "452f5a274f3eb29d4caa60a4d3b4cac9775bab1136441ecf7f0628fb41e3688c"

URI_aarch64_rust-uucore-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore-devel}"
SRC_URI[aarch64_rust-uucore-devel.sha256sum] = "5057ed944332d6f16614ffcd6ef0783f2e4f48fbac13123fddd0c1f463824a13"

RDEPENDS:rust-uucore+backup-control-devel = " \
 cargo \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+base64-simd-devel = " \
 cargo \
 rust-base64-simd+default-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+bigdecimal-devel = " \
 cargo \
 rust-bigdecimal+default-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+blake2b_simd-devel = " \
 cargo \
 rust-blake2b_simd+default-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+blake3-devel = " \
 cargo \
 rust-blake3+default-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+bstr-devel = " \
 cargo \
 rust-bstr+default-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+buf-copy-devel = " \
 cargo \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+checksum-devel = " \
 cargo \
 rust-uucore+base64-simd-devel \
 rust-uucore+quoting-style-devel \
 rust-uucore+sum-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+colors-devel = " \
 cargo \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+crc-fast-devel = " \
 cargo \
 rust-crc-fast+default-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+data-encoding-devel = " \
 cargo \
 rust-data-encoding+default-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+data-encoding-macro-devel = " \
 cargo \
 rust-data-encoding-macro+default-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+default-devel = " \
 cargo \
 rust-uucore+signals-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+digest-devel = " \
 cargo \
 rust-digest0.10+default-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+dns-lookup-devel = " \
 cargo \
 rust-dns-lookup+default-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+dunce-devel = " \
 cargo \
 rust-dunce+default-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+encoding-devel = " \
 cargo \
 rust-uucore+base64-simd-devel \
 rust-uucore+data-encoding-devel \
 rust-uucore+data-encoding-macro-devel \
 rust-uucore+z85-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+entries-devel = " \
 cargo \
 rust-uucore+libc-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+extendedbigdecimal-devel = " \
 cargo \
 rust-uucore+bigdecimal-devel \
 rust-uucore+num-traits-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+fast-inc-devel = " \
 cargo \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+feat_systemd_logind-devel = " \
 cargo \
 rust-uucore+libc-devel \
 rust-uucore+utmpx-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+format-devel = " \
 cargo \
 rust-uucore+bigdecimal-devel \
 rust-uucore+extendedbigdecimal-devel \
 rust-uucore+itertools-devel \
 rust-uucore+num-traits-devel \
 rust-uucore+parser-num-devel \
 rust-uucore+quoting-style-devel \
 rust-uucore+unit-prefix-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+fs-devel = " \
 cargo \
 rust-uucore+dunce-devel \
 rust-uucore+libc-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+fsext-devel = " \
 cargo \
 rust-uucore+bstr-devel \
 rust-uucore+libc-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+fsxattr-devel = " \
 cargo \
 rust-uucore+itertools-devel \
 rust-uucore+xattr-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+glob-devel = " \
 cargo \
 rust-glob+default-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+hardware-devel = " \
 cargo \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+hex-devel = " \
 cargo \
 rust-hex+default-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+i18n-all-devel = " \
 cargo \
 rust-uucore+i18n-charmap-devel \
 rust-uucore+i18n-collator-devel \
 rust-uucore+i18n-datetime-devel \
 rust-uucore+i18n-decimal-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+i18n-charmap-devel = " \
 cargo \
 rust-uucore+i18n-common-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+i18n-collator-devel = " \
 cargo \
 rust-uucore+i18n-common-devel \
 rust-uucore+icu_collator-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+i18n-common-devel = " \
 cargo \
 rust-uucore+icu_locale-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+i18n-datetime-devel = " \
 cargo \
 rust-uucore+i18n-common-devel \
 rust-uucore+icu_calendar-devel \
 rust-uucore+icu_datetime-devel \
 rust-uucore+jiff-devel \
 rust-uucore+jiff-icu-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+i18n-decimal-devel = " \
 cargo \
 rust-uucore+i18n-common-devel \
 rust-uucore+icu_decimal-devel \
 rust-uucore+icu_provider-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+icu_calendar-devel = " \
 cargo \
 rust-icu_calendar+compiled_data-devel \
 rust-icu_calendar+default-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+icu_collator-devel = " \
 cargo \
 rust-icu_collator+compiled_data-devel \
 rust-icu_collator+default-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+icu_datetime-devel = " \
 cargo \
 rust-icu_datetime+compiled_data-devel \
 rust-icu_datetime+default-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+icu_decimal-devel = " \
 cargo \
 rust-icu_decimal+compiled_data-devel \
 rust-icu_decimal+default-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+icu_locale-devel = " \
 cargo \
 rust-icu_locale+compiled_data-devel \
 rust-icu_locale+default-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+icu_provider-devel = " \
 cargo \
 rust-icu_provider+default-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+itertools-devel = " \
 cargo \
 rust-itertools0.14+default-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+jiff-devel = " \
 cargo \
 rust-jiff+default-devel \
 rust-jiff+tzdb-bundle-platform-devel \
 rust-jiff+tzdb-concatenated-devel \
 rust-jiff+tzdb-zoneinfo-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+jiff-icu-devel = " \
 cargo \
 rust-jiff-icu+default-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+libc-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+lines-devel = " \
 cargo \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+md-5-devel = " \
 cargo \
 rust-md-5_0.10+default-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+memchr-devel = " \
 cargo \
 rust-memchr+default-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+mode-devel = " \
 cargo \
 rust-uucore+libc-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+num-traits-devel = " \
 cargo \
 rust-num-traits+default-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+parser-devel = " \
 cargo \
 rust-uucore+parser-glob-devel \
 rust-uucore+parser-num-devel \
 rust-uucore+parser-size-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+parser-glob-devel = " \
 cargo \
 rust-uucore+glob-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+parser-num-devel = " \
 cargo \
 rust-uucore+extendedbigdecimal-devel \
 rust-uucore+num-traits-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+parser-size-devel = " \
 cargo \
 rust-uucore+parser-num-devel \
 rust-uucore+procfs-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+perms-devel = " \
 cargo \
 rust-uucore+entries-devel \
 rust-uucore+libc-devel \
 rust-uucore+walkdir-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+pipes-devel = " \
 cargo \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+proc-info-devel = " \
 cargo \
 rust-uucore+tty-devel \
 rust-uucore+walkdir-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+process-devel = " \
 cargo \
 rust-uucore+libc-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+procfs-devel = " \
 cargo \
 rust-procfs+default-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+quoting-style-devel = " \
 cargo \
 rust-uucore+i18n-common-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+ranges-devel = " \
 cargo \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+ringbuffer-devel = " \
 cargo \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+safe-traversal-devel = " \
 cargo \
 rust-uucore+libc-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+selinux-devel = " \
 cargo \
 rust-selinux+default-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+sha1-devel = " \
 cargo \
 rust-sha1_0.10+default-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+sha2-devel = " \
 cargo \
 rust-sha2_0.10+default-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+sha3-devel = " \
 cargo \
 rust-sha3+default-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+signals-devel = " \
 cargo \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+sm3-devel = " \
 cargo \
 rust-sm3+default-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+smack-devel = " \
 cargo \
 rust-uucore+xattr-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+sum-devel = " \
 cargo \
 rust-uucore+blake2b_simd-devel \
 rust-uucore+blake3-devel \
 rust-uucore+crc-fast-devel \
 rust-uucore+data-encoding-devel \
 rust-uucore+digest-devel \
 rust-uucore+hex-devel \
 rust-uucore+md-5-devel \
 rust-uucore+memchr-devel \
 rust-uucore+sha1-devel \
 rust-uucore+sha2-devel \
 rust-uucore+sha3-devel \
 rust-uucore+sm3-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+tempfile-devel = " \
 cargo \
 rust-tempfile+default-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+time-devel = " \
 cargo \
 rust-uucore+jiff-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+tty-devel = " \
 cargo \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+unit-prefix-devel = " \
 cargo \
 rust-unit-prefix+default-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+update-control-devel = " \
 cargo \
 rust-uucore+parser-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+uptime-devel = " \
 cargo \
 rust-uucore+jiff-devel \
 rust-uucore+libc-devel \
 rust-uucore+utmpx-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+utf8-devel = " \
 cargo \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+utmpx-devel = " \
 cargo \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+local-offset-devel \
 rust-time+macros-devel \
 rust-uucore+dns-lookup-devel \
 rust-uucore+libc-devel \
 rust-uucore+time-devel \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+version-cmp-devel = " \
 cargo \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+walkdir-devel = " \
 cargo \
 rust-uucore-devel \
 rust-walkdir+default-devel \
 "
RDEPENDS:rust-uucore+wide-devel = " \
 cargo \
 rust-uucore-devel \
 "
RDEPENDS:rust-uucore+xattr-devel = " \
 cargo \
 rust-uucore-devel \
 rust-xattr+default-devel \
 "
RDEPENDS:rust-uucore+z85-devel = " \
 cargo \
 rust-uucore-devel \
 rust-z85+default-devel \
 "
RDEPENDS:rust-uucore-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-fluent-bundle+default-devel \
 rust-fluent-syntax+default-devel \
 rust-nix0.30+dir-devel \
 rust-nix0.30+fs-devel \
 rust-nix0.30+poll-devel \
 rust-nix0.30+signal-devel \
 rust-nix0.30+uio-devel \
 rust-nix0.30+user-devel \
 rust-nix0.30+zerocopy-devel \
 rust-nix0.30-devel \
 rust-os_display+default-devel \
 rust-rustc-hash+default-devel \
 rust-thiserror+default-devel \
 rust-unic-langid+default-devel \
 rust-uucore_procs+default-devel \
 "
