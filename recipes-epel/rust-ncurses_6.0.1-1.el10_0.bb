# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ncurses"
PV = "6.0.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-ncurses+default-devel \
 rust-ncurses+extended_colors-devel \
 rust-ncurses+menu-devel \
 rust-ncurses+mouse_v1-devel \
 rust-ncurses+panel-devel \
 rust-ncurses+wide-devel \
 rust-ncurses+wide_chtype-devel \
 rust-ncurses-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ncurses-6.0.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "20b7987eaebd76e572a0376ddc3f57ae1ead0e39124a3a9291482870c6ca0747"

URI_x86_64_v2_rust-ncurses+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ncurses+default-devel-6.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ncurses+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ncurses+default-devel}"
SRC_URI[x86_64_v2_rust-ncurses+default-devel.sha256sum] = "ba6103135ed9aa12117ee60ffe711539f8da008b7d178da6aeeec025394d39b8"

URI_x86_64_v2_rust-ncurses+extended_colors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ncurses+extended_colors-devel-6.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ncurses+extended_colors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ncurses+extended_colors-devel}"
SRC_URI[x86_64_v2_rust-ncurses+extended_colors-devel.sha256sum] = "36296c3e4ac398f10789652460e25691fa43f12d0727eda8046db7e1dad7ce83"

URI_x86_64_v2_rust-ncurses+menu-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ncurses+menu-devel-6.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ncurses+menu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ncurses+menu-devel}"
SRC_URI[x86_64_v2_rust-ncurses+menu-devel.sha256sum] = "ee3563007fd33cf128de0dd71010bd120dd3942ca1faa0a519e857d42a22b894"

URI_x86_64_v2_rust-ncurses+mouse_v1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ncurses+mouse_v1-devel-6.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ncurses+mouse_v1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ncurses+mouse_v1-devel}"
SRC_URI[x86_64_v2_rust-ncurses+mouse_v1-devel.sha256sum] = "ce051c7a48dff39fe8693c464c00b3a29e52ad78180da5e34e55fc1f65bef756"

URI_x86_64_v2_rust-ncurses+panel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ncurses+panel-devel-6.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ncurses+panel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ncurses+panel-devel}"
SRC_URI[x86_64_v2_rust-ncurses+panel-devel.sha256sum] = "52d922e200a8d4e2d21d121e9b90b1e08f141cb2cdf37830efbd5cb79a9d7cc6"

URI_x86_64_v2_rust-ncurses+wide-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ncurses+wide-devel-6.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ncurses+wide-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ncurses+wide-devel}"
SRC_URI[x86_64_v2_rust-ncurses+wide-devel.sha256sum] = "f7bd926f958bf01a86322e18a7079fa31a31993b57ac96b043a1561762a3fd9e"

URI_x86_64_v2_rust-ncurses+wide_chtype-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ncurses+wide_chtype-devel-6.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ncurses+wide_chtype-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ncurses+wide_chtype-devel}"
SRC_URI[x86_64_v2_rust-ncurses+wide_chtype-devel.sha256sum] = "b1e8b249a0ab490dab9dcdf00ae6963434c284313c6182afaac48b31d43cdfe4"

URI_x86_64_v2_rust-ncurses-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ncurses-devel-6.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ncurses-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ncurses-devel}"
SRC_URI[x86_64_v2_rust-ncurses-devel.sha256sum] = "cd33910af34f1da854be3eda86e1850648611c7ca80263e2adfc3781afe42abb"

URI_aarch64_rust-ncurses+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ncurses+default-devel-6.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-ncurses+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ncurses+default-devel}"
SRC_URI[aarch64_rust-ncurses+default-devel.sha256sum] = "2925afdf6856a677163131250f05989d3070046d000910e6a9111a2038b1448f"

URI_aarch64_rust-ncurses+extended_colors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ncurses+extended_colors-devel-6.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-ncurses+extended_colors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ncurses+extended_colors-devel}"
SRC_URI[aarch64_rust-ncurses+extended_colors-devel.sha256sum] = "573bfbf3ed86450fcb2a9e97bbe0b869abbf938cc5a809d7e06a9c774d01d2e0"

URI_aarch64_rust-ncurses+menu-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ncurses+menu-devel-6.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-ncurses+menu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ncurses+menu-devel}"
SRC_URI[aarch64_rust-ncurses+menu-devel.sha256sum] = "2dbcaa7d25983f3ed3d7ecb2f9925bba7f51ce9c5bb6ed3a8c9086ab616bd246"

URI_aarch64_rust-ncurses+mouse_v1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ncurses+mouse_v1-devel-6.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-ncurses+mouse_v1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ncurses+mouse_v1-devel}"
SRC_URI[aarch64_rust-ncurses+mouse_v1-devel.sha256sum] = "e580ed5ab690ecc3b00b13509e33af18f74fa08a2f04ea6338d92448aca97f47"

URI_aarch64_rust-ncurses+panel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ncurses+panel-devel-6.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-ncurses+panel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ncurses+panel-devel}"
SRC_URI[aarch64_rust-ncurses+panel-devel.sha256sum] = "c7e1c0113360b301371f1e12b1ef7093a077d703e01c15450d03a12589fce73b"

URI_aarch64_rust-ncurses+wide-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ncurses+wide-devel-6.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-ncurses+wide-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ncurses+wide-devel}"
SRC_URI[aarch64_rust-ncurses+wide-devel.sha256sum] = "7c4d1bca962715c3f2ccd6abc7a07e89b4751b6f18b259a84247ec078b63a686"

URI_aarch64_rust-ncurses+wide_chtype-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ncurses+wide_chtype-devel-6.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-ncurses+wide_chtype-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ncurses+wide_chtype-devel}"
SRC_URI[aarch64_rust-ncurses+wide_chtype-devel.sha256sum] = "d2a0a87afe4ef49aa04540f6b3e826daaa5896cf22062150353c4267fcde0c33"

URI_aarch64_rust-ncurses-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ncurses-devel-6.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-ncurses-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ncurses-devel}"
SRC_URI[aarch64_rust-ncurses-devel.sha256sum] = "c954cdd84bc0ac184e20f72e464ec8fa5705ad530d73cc7685f7f88d8da02125"

RDEPENDS:rust-ncurses+default-devel = " \
 cargo \
 rust-ncurses-devel \
 "
RDEPENDS:rust-ncurses+extended_colors-devel = " \
 cargo \
 rust-ncurses+wide-devel \
 rust-ncurses-devel \
 "
RDEPENDS:rust-ncurses+menu-devel = " \
 cargo \
 rust-ncurses-devel \
 "
RDEPENDS:rust-ncurses+mouse_v1-devel = " \
 cargo \
 rust-ncurses-devel \
 "
RDEPENDS:rust-ncurses+panel-devel = " \
 cargo \
 rust-ncurses-devel \
 "
RDEPENDS:rust-ncurses+wide-devel = " \
 cargo \
 rust-ncurses-devel \
 "
RDEPENDS:rust-ncurses+wide_chtype-devel = " \
 cargo \
 rust-ncurses-devel \
 "
RDEPENDS:rust-ncurses-devel = " \
 cargo \
 ncurses-devel \
 rust-cc+default-devel \
 rust-libc+default-devel \
 rust-pkg-config+default-devel \
 "
