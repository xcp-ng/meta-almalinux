# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apache-commons-lang3"
PV = "3.14.0"
PR = "6.el10"
PACKAGES = " \
 apache-commons-lang3 \
 apache-commons-lang3-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/apache-commons-lang3-3.14.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b0113cc39b39c3883f35417f156cfc1ec2841b81b1047a483884265f26ce081a"

URI_x86_64_v2_apache-commons-lang3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apache-commons-lang3-3.14.0-6.el10.noarch.rpm;name=x86_64_v2_apache-commons-lang3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apache-commons-lang3}"
SRC_URI[x86_64_v2_apache-commons-lang3.sha256sum] = "89e7bf219b86d02bf4d801f810e7f3c9099271753edacda9af50660e3429f904"

URI_x86_64_v2_apache-commons-lang3-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/apache-commons-lang3-javadoc-3.14.0-6.el10.noarch.rpm;name=x86_64_v2_apache-commons-lang3-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apache-commons-lang3-javadoc}"
SRC_URI[x86_64_v2_apache-commons-lang3-javadoc.sha256sum] = "dbcefad6e340242fb7a951eb3036cd86937a839475d278a03ccac74b8e73fb23"

URI_aarch64_apache-commons-lang3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apache-commons-lang3-3.14.0-6.el10.noarch.rpm;name=aarch64_apache-commons-lang3;unpack=0"
SRC_URI:append = " ${URI_aarch64_apache-commons-lang3}"
SRC_URI[aarch64_apache-commons-lang3.sha256sum] = "89e7bf219b86d02bf4d801f810e7f3c9099271753edacda9af50660e3429f904"

URI_aarch64_apache-commons-lang3-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/apache-commons-lang3-javadoc-3.14.0-6.el10.noarch.rpm;name=aarch64_apache-commons-lang3-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_apache-commons-lang3-javadoc}"
SRC_URI[aarch64_apache-commons-lang3-javadoc.sha256sum] = "dbcefad6e340242fb7a951eb3036cd86937a839475d278a03ccac74b8e73fb23"

RDEPENDS:apache-commons-lang3 = " \
 javapackages-filesystem \
 "
RDEPENDS:apache-commons-lang3-javadoc = " \
 javapackages-filesystem \
 "
