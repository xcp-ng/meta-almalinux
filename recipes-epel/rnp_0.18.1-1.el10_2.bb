# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rnp"
PV = "0.18.1"
PR = "1.el10_2"
PACKAGES = " \
 librnp \
 librnp-devel \
 rnp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rnp-0.18.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e79bbef3606ad31c6b2cde9ab4698cb11b1f210cbcf0f7deac0bf76f861850d"

URI_x86_64_v2_librnp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librnp-0.18.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librnp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librnp}"
SRC_URI[x86_64_v2_librnp.sha256sum] = "6b8fc71d2f679c0158ecc4774e329270f0a021c7756f28cf336ad9047d960f2b"

URI_x86_64_v2_librnp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librnp-devel-0.18.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librnp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librnp-devel}"
SRC_URI[x86_64_v2_librnp-devel.sha256sum] = "1fb52738a8f70c58262d1f0a3e55e3508a8e28b5d608390f0eb049e31083ae1e"

URI_x86_64_v2_rnp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rnp-0.18.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rnp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rnp}"
SRC_URI[x86_64_v2_rnp.sha256sum] = "dac79b6715c7291f5c8f0410ddbf0314b0a04febbd91dba2df76b61b268291b2"

URI_aarch64_librnp = "${EPEL_MIRROR}/aarch64/Packages/l/librnp-0.18.1-1.el10_2.aarch64.rpm;name=aarch64_librnp;unpack=0"
SRC_URI:append = " ${URI_aarch64_librnp}"
SRC_URI[aarch64_librnp.sha256sum] = "3d39eb9d3cb476c0320882a655ce974cb5c810175abc0d8ef8ebb5869a87175f"

URI_aarch64_librnp-devel = "${EPEL_MIRROR}/aarch64/Packages/l/librnp-devel-0.18.1-1.el10_2.aarch64.rpm;name=aarch64_librnp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_librnp-devel}"
SRC_URI[aarch64_librnp-devel.sha256sum] = "f87aa6a1e32017193d47da8070f485a783d4090822ad3bf8a954416b9f9b71fa"

URI_aarch64_rnp = "${EPEL_MIRROR}/aarch64/Packages/r/rnp-0.18.1-1.el10_2.aarch64.rpm;name=aarch64_rnp;unpack=0"
SRC_URI:append = " ${URI_aarch64_rnp}"
SRC_URI[aarch64_rnp.sha256sum] = "60f717e0b34042d412155f52f524471227a43046d1060ecbc07c7da946282464"

RDEPENDS:librnp = " \
 botan2 \
 bzip2-libs \
 glibc \
 json-c \
 libgcc \
 libsexpp \
 libstdc++ \
 zlib-ng-compat \
 "
RDEPENDS:librnp-devel = " \
 cmake-filesystem \
 librnp \
 pkgconf-pkg-config \
 "
RDEPENDS:rnp = " \
 glibc \
 json-c \
 libgcc \
 librnp \
 libstdc++ \
 "
