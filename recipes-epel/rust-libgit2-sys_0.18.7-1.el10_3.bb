# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libgit2-sys"
PV = "0.18.7"
PR = "1.el10_3"
PACKAGES = " \
 rust-libgit2-sys+default-devel \
 rust-libgit2-sys+https-devel \
 rust-libgit2-sys+libssh2-sys-devel \
 rust-libgit2-sys+openssl-sys-devel \
 rust-libgit2-sys+ssh-devel \
 rust-libgit2-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libgit2-sys-0.18.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3083176bef912f6f2c4f88ea372922cc08f9f1b021697cc6559feaf82e268273"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - rust-libgit2-sys-devel: (pkgconfig(libgit2) >= 1.9.6 with pkgconfig(libgit2) < 1.10.0~)

URI_x86_64_v2_rust-libgit2-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys+default-devel-0.18.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys+default-devel.sha256sum] = "80f5068ca6dc5a6c1961e9edb24c5e7666d07c0facfe355cc5f66404dd9f4260"

URI_x86_64_v2_rust-libgit2-sys+https-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys+https-devel-0.18.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys+https-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys+https-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys+https-devel.sha256sum] = "ea9fabdfe83c0efc350cbc1729691a1ab1ad2705413923f2500c3114bff52c57"

URI_x86_64_v2_rust-libgit2-sys+libssh2-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys+libssh2-sys-devel-0.18.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys+libssh2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys+libssh2-sys-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys+libssh2-sys-devel.sha256sum] = "419b265f55c4b4b0585d13c1eb4b1a3d815f1e26deb7a70bc8a4d73063b9d516"

URI_x86_64_v2_rust-libgit2-sys+openssl-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys+openssl-sys-devel-0.18.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys+openssl-sys-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys+openssl-sys-devel.sha256sum] = "35bfc10788fb686602ac7115e032ea92e5da95c53e1e5d0afbfb125135a902af"

URI_x86_64_v2_rust-libgit2-sys+ssh-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys+ssh-devel-0.18.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys+ssh-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys+ssh-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys+ssh-devel.sha256sum] = "ad44e13743ca492c2643db34fdd62c540a2a72d94e49d506931c60a1cfb63948"

URI_x86_64_v2_rust-libgit2-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys-devel-0.18.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys-devel.sha256sum] = "c38c4751f2364b882f0e331a918e55e417f445d5d63d36e16130d0e36886a315"

URI_aarch64_rust-libgit2-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys+default-devel-0.18.7-1.el10_3.noarch.rpm;name=aarch64_rust-libgit2-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys+default-devel}"
SRC_URI[aarch64_rust-libgit2-sys+default-devel.sha256sum] = "d7b93cac0e95f957200b7473448b8fdac6756dfbe41e10d38dbc80b68ff5ccdf"

URI_aarch64_rust-libgit2-sys+https-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys+https-devel-0.18.7-1.el10_3.noarch.rpm;name=aarch64_rust-libgit2-sys+https-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys+https-devel}"
SRC_URI[aarch64_rust-libgit2-sys+https-devel.sha256sum] = "e81308deccdf1f395b84d62519314e0048bc90768d35b89894c17b1ae9f63b1e"

URI_aarch64_rust-libgit2-sys+libssh2-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys+libssh2-sys-devel-0.18.7-1.el10_3.noarch.rpm;name=aarch64_rust-libgit2-sys+libssh2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys+libssh2-sys-devel}"
SRC_URI[aarch64_rust-libgit2-sys+libssh2-sys-devel.sha256sum] = "e2f5524d3b9dee9b27bb691149007cafaad475aa62f7c8e3ece0dd5ee8f27b7e"

URI_aarch64_rust-libgit2-sys+openssl-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys+openssl-sys-devel-0.18.7-1.el10_3.noarch.rpm;name=aarch64_rust-libgit2-sys+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys+openssl-sys-devel}"
SRC_URI[aarch64_rust-libgit2-sys+openssl-sys-devel.sha256sum] = "bcf8dbcac88b1a5127bb0024e1a1efea4ab657f4b5771ae0ad58b51741d838c2"

URI_aarch64_rust-libgit2-sys+ssh-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys+ssh-devel-0.18.7-1.el10_3.noarch.rpm;name=aarch64_rust-libgit2-sys+ssh-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys+ssh-devel}"
SRC_URI[aarch64_rust-libgit2-sys+ssh-devel.sha256sum] = "10133a6ef2faf19057b4bc1030c328d83325201734e994bd16bdc47e6c25488d"

URI_aarch64_rust-libgit2-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys-devel-0.18.7-1.el10_3.noarch.rpm;name=aarch64_rust-libgit2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys-devel}"
SRC_URI[aarch64_rust-libgit2-sys-devel.sha256sum] = "7c30f683db1a3e2e2f849b55a72a93d723ddee0d4d61c0b5e0d8ffd21346cb34"

RDEPENDS:rust-libgit2-sys+default-devel = " \
 cargo \
 rust-libgit2-sys-devel \
 "
RDEPENDS:rust-libgit2-sys+https-devel = " \
 cargo \
 rust-libgit2-sys+openssl-sys-devel \
 rust-libgit2-sys-devel \
 "
RDEPENDS:rust-libgit2-sys+libssh2-sys-devel = " \
 cargo \
 rust-libgit2-sys-devel \
 rust-libssh2-sys+default-devel \
 "
RDEPENDS:rust-libgit2-sys+openssl-sys-devel = " \
 cargo \
 rust-libgit2-sys-devel \
 rust-openssl-sys+default-devel \
 "
RDEPENDS:rust-libgit2-sys+ssh-devel = " \
 cargo \
 rust-libgit2-sys+libssh2-sys-devel \
 rust-libgit2-sys-devel \
 "
RDEPENDS:rust-libgit2-sys-devel:x86_64_v2 = " \
 cargo \
 rust-cc+default-devel \
 rust-cc+parallel-devel \
 rust-libc+default-devel \
 rust-libz-sys+libc-devel \
 rust-libz-sys-devel \
 rust-pkg-config+default-devel \
"
RDEPENDS:rust-libgit2-sys-devel:aarch64 = " \
 cargo \
 libgit2_1.9-devel \
 rust-cc+default-devel \
 rust-cc+parallel-devel \
 rust-libc+default-devel \
 rust-libz-sys+libc-devel \
 rust-libz-sys-devel \
 rust-pkg-config+default-devel \
"
