# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-binary-heap-plus"
PV = "0.5.0"
PR = "5.el10_3"
PACKAGES = " \
 rust-binary-heap-plus+default-devel \
 rust-binary-heap-plus+serde-devel \
 rust-binary-heap-plus-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-binary-heap-plus-0.5.0-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f8962d81678218e289988f0d07a0c9114b38384f13d5f068bb82403e7425f553"

URI_x86_64_v2_rust-binary-heap-plus+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-binary-heap-plus+default-devel-0.5.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-binary-heap-plus+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-binary-heap-plus+default-devel}"
SRC_URI[x86_64_v2_rust-binary-heap-plus+default-devel.sha256sum] = "29a2d03404bab7aa1afa101f24a8b257174666e2218b640776d13d33f7410ce4"

URI_x86_64_v2_rust-binary-heap-plus+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-binary-heap-plus+serde-devel-0.5.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-binary-heap-plus+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-binary-heap-plus+serde-devel}"
SRC_URI[x86_64_v2_rust-binary-heap-plus+serde-devel.sha256sum] = "c5884ffa45c99c7aca7b3f19500d4dc9c745c994d9d7d0b184cc5345cc48f527"

URI_x86_64_v2_rust-binary-heap-plus-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-binary-heap-plus-devel-0.5.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-binary-heap-plus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-binary-heap-plus-devel}"
SRC_URI[x86_64_v2_rust-binary-heap-plus-devel.sha256sum] = "07e50208bfccd9fd1f9f76b0e9d8bc5038f452569f56b620df82418b3c084690"

URI_aarch64_rust-binary-heap-plus+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-binary-heap-plus+default-devel-0.5.0-5.el10_3.noarch.rpm;name=aarch64_rust-binary-heap-plus+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-binary-heap-plus+default-devel}"
SRC_URI[aarch64_rust-binary-heap-plus+default-devel.sha256sum] = "507024660937c6e06bb042059e666f78e4fb1b26642a0413e3c64daea153f31d"

URI_aarch64_rust-binary-heap-plus+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-binary-heap-plus+serde-devel-0.5.0-5.el10_3.noarch.rpm;name=aarch64_rust-binary-heap-plus+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-binary-heap-plus+serde-devel}"
SRC_URI[aarch64_rust-binary-heap-plus+serde-devel.sha256sum] = "48816d1fc92a328ef84c40672e7d42634c8c6756aaa2af5e3fa62a7d00bae408"

URI_aarch64_rust-binary-heap-plus-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-binary-heap-plus-devel-0.5.0-5.el10_3.noarch.rpm;name=aarch64_rust-binary-heap-plus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-binary-heap-plus-devel}"
SRC_URI[aarch64_rust-binary-heap-plus-devel.sha256sum] = "60662f9c55a62f281a6585f44efed665cd9829ebfbf080fa47ec5e9ab24cab37"

RDEPENDS:rust-binary-heap-plus+default-devel = " \
 cargo \
 rust-binary-heap-plus-devel \
 "
RDEPENDS:rust-binary-heap-plus+serde-devel = " \
 cargo \
 rust-binary-heap-plus-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-binary-heap-plus-devel = " \
 cargo \
 rust \
 rust-compare+default-devel \
 "
