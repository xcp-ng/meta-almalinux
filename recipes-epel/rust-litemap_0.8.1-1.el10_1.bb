# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-litemap"
PV = "0.8.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-litemap+alloc-devel \
 rust-litemap+databake-devel \
 rust-litemap+default-devel \
 rust-litemap+serde-devel \
 rust-litemap+testing-devel \
 rust-litemap+yoke-devel \
 rust-litemap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-litemap-0.8.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe62f156defaf819575368224a8d25277095eff3a3a99054e9b69de5d9b3adf9"

URI_x86_64_v2_rust-litemap+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap+alloc-devel-0.8.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litemap+alloc-devel}"
SRC_URI[x86_64_v2_rust-litemap+alloc-devel.sha256sum] = "edd185515b16bfa1c280cf8aed63d4c32afcce9e5bb659da5c9736b143b5936b"

URI_x86_64_v2_rust-litemap+databake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap+databake-devel-0.8.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap+databake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litemap+databake-devel}"
SRC_URI[x86_64_v2_rust-litemap+databake-devel.sha256sum] = "ee78bd74c567be62316df083026d1acb56fe2eb423b3532afb63c9e3cc8062ca"

URI_x86_64_v2_rust-litemap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap+default-devel-0.8.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litemap+default-devel}"
SRC_URI[x86_64_v2_rust-litemap+default-devel.sha256sum] = "da1e7bd1b14bf995e7725a1e702848fde2cea290aa532aa9f56391d6be553adc"

URI_x86_64_v2_rust-litemap+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap+serde-devel-0.8.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litemap+serde-devel}"
SRC_URI[x86_64_v2_rust-litemap+serde-devel.sha256sum] = "5dc2fe4b87e587baee303844de956ebade69af4e2c926bfa0986790714afd248"

URI_x86_64_v2_rust-litemap+testing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap+testing-devel-0.8.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap+testing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litemap+testing-devel}"
SRC_URI[x86_64_v2_rust-litemap+testing-devel.sha256sum] = "cb9ab0689fb7be9598e1e32abf524214217b903ef1fbe529e5aa419988c00b4d"

URI_x86_64_v2_rust-litemap+yoke-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap+yoke-devel-0.8.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap+yoke-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litemap+yoke-devel}"
SRC_URI[x86_64_v2_rust-litemap+yoke-devel.sha256sum] = "e55b1bb4c48c2b4b674557ea69699d4cba8cabd68915edd8f00cbac2c48240f5"

URI_x86_64_v2_rust-litemap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap-devel-0.8.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litemap-devel}"
SRC_URI[x86_64_v2_rust-litemap-devel.sha256sum] = "e29056b46d026cf165142baad7a5fe9d2f7edc73d8121b7542d1cddad585cca2"

URI_aarch64_rust-litemap+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap+alloc-devel-0.8.1-1.el10_1.noarch.rpm;name=aarch64_rust-litemap+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litemap+alloc-devel}"
SRC_URI[aarch64_rust-litemap+alloc-devel.sha256sum] = "b97d89d0ce4490f0a4be5bbe240e0e41bd69baf4124266e56c84b4a6c52dd56f"

URI_aarch64_rust-litemap+databake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap+databake-devel-0.8.1-1.el10_1.noarch.rpm;name=aarch64_rust-litemap+databake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litemap+databake-devel}"
SRC_URI[aarch64_rust-litemap+databake-devel.sha256sum] = "4aae1c96ef6e297badaf4ce1669fa47eb0bac4a538ee648e076c7d8a6bb78346"

URI_aarch64_rust-litemap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap+default-devel-0.8.1-1.el10_1.noarch.rpm;name=aarch64_rust-litemap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litemap+default-devel}"
SRC_URI[aarch64_rust-litemap+default-devel.sha256sum] = "9f61f52b073544faf14343db9b74312083857779d901dc05c66afe2fbde77d20"

URI_aarch64_rust-litemap+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap+serde-devel-0.8.1-1.el10_1.noarch.rpm;name=aarch64_rust-litemap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litemap+serde-devel}"
SRC_URI[aarch64_rust-litemap+serde-devel.sha256sum] = "25a941df56f57a52930e8ef0fcb6c52f7e04a3896a3a86ac72439a20bd27ab33"

URI_aarch64_rust-litemap+testing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap+testing-devel-0.8.1-1.el10_1.noarch.rpm;name=aarch64_rust-litemap+testing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litemap+testing-devel}"
SRC_URI[aarch64_rust-litemap+testing-devel.sha256sum] = "0ab253fa73f1bd921fc770cf5fe835cf704a3f36330754420512deea5043aa90"

URI_aarch64_rust-litemap+yoke-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap+yoke-devel-0.8.1-1.el10_1.noarch.rpm;name=aarch64_rust-litemap+yoke-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litemap+yoke-devel}"
SRC_URI[aarch64_rust-litemap+yoke-devel.sha256sum] = "452ea09222dc4970e5a9f752713dc59c01cbc867da0e1cccbb34ace73c646f3b"

URI_aarch64_rust-litemap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap-devel-0.8.1-1.el10_1.noarch.rpm;name=aarch64_rust-litemap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litemap-devel}"
SRC_URI[aarch64_rust-litemap-devel.sha256sum] = "e5c20767a0c277e10137b97ab926d9b6b91f55a3e08da8934ed4fbd86897421d"

RDEPENDS:rust-litemap+alloc-devel = " \
 cargo \
 rust-litemap-devel \
 "
RDEPENDS:rust-litemap+databake-devel = " \
 cargo \
 rust-databake-devel \
 rust-litemap-devel \
 "
RDEPENDS:rust-litemap+default-devel = " \
 cargo \
 rust-litemap+alloc-devel \
 rust-litemap-devel \
 "
RDEPENDS:rust-litemap+serde-devel = " \
 cargo \
 rust-litemap+alloc-devel \
 rust-litemap-devel \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-litemap+testing-devel = " \
 cargo \
 rust-litemap+alloc-devel \
 rust-litemap-devel \
 "
RDEPENDS:rust-litemap+yoke-devel = " \
 cargo \
 rust-litemap-devel \
 rust-yoke+derive-devel \
 rust-yoke-devel \
 "
RDEPENDS:rust-litemap-devel = " \
 cargo \
 rust \
 "
