# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "koji"
PV = "1.35.3"
PR = "4.el10_0"
PACKAGES = " \
 koji \
 koji-builder \
 koji-builder-plugins \
 koji-hub \
 koji-hub-plugins \
 koji-utils \
 koji-vm \
 koji-web \
 python3-koji \
 python3-koji-cli-plugins \
 python3-koji-hub \
 python3-koji-hub-plugins \
 python3-koji-web \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/koji-1.35.3-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7122bd24a2eb28ef77b8184b2f41b703d6cf8b69a5a608f72d634a92c1b86066"

URI_x86_64_v2_koji = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-1.35.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_koji;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji}"
SRC_URI[x86_64_v2_koji.sha256sum] = "36e31cfe84adb9efd351a4354f554c6fc28e74db8488e7e0267c7b2c664cee26"

URI_x86_64_v2_koji-builder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-builder-1.35.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_koji-builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-builder}"
SRC_URI[x86_64_v2_koji-builder.sha256sum] = "a15ea6e8da0dccf2215e2ab127fb3e6a2d2822fd34005861154cb91eca0a9e29"

URI_x86_64_v2_koji-builder-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-builder-plugins-1.35.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_koji-builder-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-builder-plugins}"
SRC_URI[x86_64_v2_koji-builder-plugins.sha256sum] = "23d5cca110efaa9e112060c1c59a237bf490d03dc82a6879f1842f15d1f6f82e"

URI_x86_64_v2_koji-hub = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-hub-1.35.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_koji-hub;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-hub}"
SRC_URI[x86_64_v2_koji-hub.sha256sum] = "37536895ac5148eba6c6394d8409ea90ca0ae327c64e63c99964857dc1763d9e"

URI_x86_64_v2_koji-hub-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-hub-plugins-1.35.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_koji-hub-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-hub-plugins}"
SRC_URI[x86_64_v2_koji-hub-plugins.sha256sum] = "9afc86bf450d69256c26082b7b51844f51470ff2af0999f2b042f831a8114f06"

URI_x86_64_v2_koji-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-utils-1.35.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_koji-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-utils}"
SRC_URI[x86_64_v2_koji-utils.sha256sum] = "1669cbfbd27f9be081f424d7303e7e44e2b43ad9a1e353dfaf8d1f68a7f44c26"

URI_x86_64_v2_koji-vm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-vm-1.35.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_koji-vm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-vm}"
SRC_URI[x86_64_v2_koji-vm.sha256sum] = "b15cbe1ff4bf6646206a745fbf4d3fd0aa3abf3ac8c306a2a8933ea40df668d4"

URI_x86_64_v2_koji-web = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-web-1.35.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_koji-web;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-web}"
SRC_URI[x86_64_v2_koji-web.sha256sum] = "691e87105cf79318037dc675fc17ff8e64ec6b3292e325f2250d7596c2712880"

URI_x86_64_v2_python3-koji = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-koji-1.35.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-koji;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-koji}"
SRC_URI[x86_64_v2_python3-koji.sha256sum] = "6f7f1efae6512eb6cdd51285794ca6947551b86942fb862fab9f2d12dc6cd2d5"

URI_x86_64_v2_python3-koji-cli-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-koji-cli-plugins-1.35.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-koji-cli-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-koji-cli-plugins}"
SRC_URI[x86_64_v2_python3-koji-cli-plugins.sha256sum] = "0cb3760707043986861187ef7f4faa1b5432c5fbb8278ace160964761f56771c"

URI_x86_64_v2_python3-koji-hub = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-koji-hub-1.35.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-koji-hub;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-koji-hub}"
SRC_URI[x86_64_v2_python3-koji-hub.sha256sum] = "2b8fbd90adfa2352801758436b86ee3705766cc2eb8f41616d15c6a50017becf"

URI_x86_64_v2_python3-koji-hub-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-koji-hub-plugins-1.35.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-koji-hub-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-koji-hub-plugins}"
SRC_URI[x86_64_v2_python3-koji-hub-plugins.sha256sum] = "af9e6c2df34cdd41eedfeb1d1322593b9e29fb0433f17f39628c5373b4ee2ba0"

URI_x86_64_v2_python3-koji-web = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-koji-web-1.35.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-koji-web;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-koji-web}"
SRC_URI[x86_64_v2_python3-koji-web.sha256sum] = "e9e370b1f172145a12195648663a72ab049a92a9234b9f308b5cdfe6fdb29d68"

URI_aarch64_koji = "${EPEL_MIRROR}/aarch64/Packages/k/koji-1.35.3-4.el10_0.noarch.rpm;name=aarch64_koji;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji}"
SRC_URI[aarch64_koji.sha256sum] = "cdca76dfbf88d92bdf890f796009f1ef1414f435e0a5ca0cff540cb49e6d85da"

URI_aarch64_koji-builder = "${EPEL_MIRROR}/aarch64/Packages/k/koji-builder-1.35.3-4.el10_0.noarch.rpm;name=aarch64_koji-builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-builder}"
SRC_URI[aarch64_koji-builder.sha256sum] = "619c26d90227503b860b8cb9c13fdb4ada8ca2bc461bb401026f540aa083dcfa"

URI_aarch64_koji-builder-plugins = "${EPEL_MIRROR}/aarch64/Packages/k/koji-builder-plugins-1.35.3-4.el10_0.noarch.rpm;name=aarch64_koji-builder-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-builder-plugins}"
SRC_URI[aarch64_koji-builder-plugins.sha256sum] = "d53b76bbdeb7af1f585f2825bfaa0a54bbccfb28896d3d937e58239b1c7660fa"

URI_aarch64_koji-hub = "${EPEL_MIRROR}/aarch64/Packages/k/koji-hub-1.35.3-4.el10_0.noarch.rpm;name=aarch64_koji-hub;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-hub}"
SRC_URI[aarch64_koji-hub.sha256sum] = "966ffecc1d3e0c3c6411df954a041303ffa24eac31881d266d63f63e9453fd0d"

URI_aarch64_koji-hub-plugins = "${EPEL_MIRROR}/aarch64/Packages/k/koji-hub-plugins-1.35.3-4.el10_0.noarch.rpm;name=aarch64_koji-hub-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-hub-plugins}"
SRC_URI[aarch64_koji-hub-plugins.sha256sum] = "ca6119a626181d60a19aa9cda59af787521fb6c8a0dc46d958b9313113c15e98"

URI_aarch64_koji-utils = "${EPEL_MIRROR}/aarch64/Packages/k/koji-utils-1.35.3-4.el10_0.noarch.rpm;name=aarch64_koji-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-utils}"
SRC_URI[aarch64_koji-utils.sha256sum] = "27d910285355b0851c8c14c3db0b832a0234f7adb693e220e7e98c26c844b0a0"

URI_aarch64_koji-vm = "${EPEL_MIRROR}/aarch64/Packages/k/koji-vm-1.35.3-4.el10_0.noarch.rpm;name=aarch64_koji-vm;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-vm}"
SRC_URI[aarch64_koji-vm.sha256sum] = "f9095f483aa2eada45446648e31ee82573c7c43e60e46132605692459aa6b865"

URI_aarch64_koji-web = "${EPEL_MIRROR}/aarch64/Packages/k/koji-web-1.35.3-4.el10_0.noarch.rpm;name=aarch64_koji-web;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-web}"
SRC_URI[aarch64_koji-web.sha256sum] = "bea5926a9066c5e584450207527669a8915283f227c27803b444501ecd9f14ae"

URI_aarch64_python3-koji = "${EPEL_MIRROR}/aarch64/Packages/p/python3-koji-1.35.3-4.el10_0.noarch.rpm;name=aarch64_python3-koji;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-koji}"
SRC_URI[aarch64_python3-koji.sha256sum] = "5afdfe29f2e9a6e8ecbc29fad3b2a75602af9a2287109f4615baf5801b221f0e"

URI_aarch64_python3-koji-cli-plugins = "${EPEL_MIRROR}/aarch64/Packages/p/python3-koji-cli-plugins-1.35.3-4.el10_0.noarch.rpm;name=aarch64_python3-koji-cli-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-koji-cli-plugins}"
SRC_URI[aarch64_python3-koji-cli-plugins.sha256sum] = "bc9700c9fa515b54d33eefc5ae0025abac546d540af3513bef74412107dd9702"

URI_aarch64_python3-koji-hub = "${EPEL_MIRROR}/aarch64/Packages/p/python3-koji-hub-1.35.3-4.el10_0.noarch.rpm;name=aarch64_python3-koji-hub;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-koji-hub}"
SRC_URI[aarch64_python3-koji-hub.sha256sum] = "862ff27d2f3180834d65c82209f845d10c806ef8dfb2dd67f002dc86c0a984b7"

URI_aarch64_python3-koji-hub-plugins = "${EPEL_MIRROR}/aarch64/Packages/p/python3-koji-hub-plugins-1.35.3-4.el10_0.noarch.rpm;name=aarch64_python3-koji-hub-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-koji-hub-plugins}"
SRC_URI[aarch64_python3-koji-hub-plugins.sha256sum] = "fa3e8400f3941529ef5a1a0f681b697c607d37a10afc909c330a82d63188f741"

URI_aarch64_python3-koji-web = "${EPEL_MIRROR}/aarch64/Packages/p/python3-koji-web-1.35.3-4.el10_0.noarch.rpm;name=aarch64_python3-koji-web;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-koji-web}"
SRC_URI[aarch64_python3-koji-web.sha256sum] = "6a761822ae57e7286bd71e00c206508bf85b4a7c55f0e0a23407eafbc13034c1"

RDEPENDS:koji = " \
 python3 \
 python3-koji \
 python3-libcomps \
 "
RDEPENDS:koji-builder = " \
 bash \
 createrepo_c \
 git-core \
 mock \
 python3 \
 python3-cheetah \
 python3-koji \
 python3-librepo \
 python3-multilib \
 python3-pycdio \
 squashfs-tools \
 subversion \
 systemd \
 "
RDEPENDS:koji-builder-plugins = " \
 koji \
 koji-builder \
 "
RDEPENDS:koji-hub = " \
 koji \
 python3 \
 python3-koji-hub \
 "
RDEPENDS:koji-hub-plugins = " \
 python3-koji-hub-plugins \
 "
RDEPENDS:koji-utils = " \
 bash \
 koji \
 python3 \
 python3-psycopg2 \
 systemd \
 "
RDEPENDS:koji-vm = " \
 bash \
 koji \
 python3 \
 python3-libvirt \
 python3-libxml2 \
 qemu-img \
 systemd \
 virt-install \
 "
RDEPENDS:koji-web = " \
 koji \
 python3-koji-web \
 "
RDEPENDS:python3-koji = " \
 python3 \
 python3-dateutil \
 python3-defusedxml \
 python3-requests \
 python3-requests-gssapi \
 python3-rpm \
 python3-six \
 "
RDEPENDS:python3-koji-cli-plugins = " \
 python3 \
 python3-koji \
 "
RDEPENDS:python3-koji-hub = " \
 httpd \
 mod_auth_gssapi \
 python3 \
 python3-koji \
 python3-mod_wsgi \
 python3-psycopg2 \
 "
RDEPENDS:python3-koji-hub-plugins = " \
 cpio \
 python3-koji-hub \
 python3-qpid-proton \
 "
RDEPENDS:python3-koji-web = " \
 httpd \
 mod_auth_gssapi \
 python3-cheetah \
 python3-koji \
 python3-mod_wsgi \
 python3-psycopg2 \
 "
