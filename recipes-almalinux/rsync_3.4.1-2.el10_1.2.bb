# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rsync"
PV = "3.4.1"
PR = "2.el10_1.2"
PACKAGES = " \
 rsync \
 rsync-daemon \
 rsync-rrsync \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/rsync-3.4.1-2.el10_1.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "66fe97fdea28e0fe8bdaba5fd2e5afafe71c00904f6ba6433defcc166a969f2a"

URI_x86_64_v2_rsync = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rsync-3.4.1-2.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_rsync;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsync}"
SRC_URI[x86_64_v2_rsync.sha256sum] = "1da2a0d99ace547f543a35e6b28d78b7eda9feee58f5eef7ed42e1ca122b644d"

URI_x86_64_v2_rsync-daemon = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsync-daemon-3.4.1-2.el10_1.2.noarch.rpm;name=x86_64_v2_rsync-daemon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsync-daemon}"
SRC_URI[x86_64_v2_rsync-daemon.sha256sum] = "4eaa9be2a98f8dc6ad9f44ddc8e3aeeb4c15899b5737ee95f2194839cd9acf24"

URI_x86_64_v2_rsync-rrsync = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsync-rrsync-3.4.1-2.el10_1.2.noarch.rpm;name=x86_64_v2_rsync-rrsync;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsync-rrsync}"
SRC_URI[x86_64_v2_rsync-rrsync.sha256sum] = "a62546e89a302dc693f950c150bf3d9bff56fadcbd453142b1c65065959eec45"

URI_aarch64_rsync = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rsync-3.4.1-2.el10_1.2.aarch64.rpm;name=aarch64_rsync;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsync}"
SRC_URI[aarch64_rsync.sha256sum] = "2d000cdb25b5210376db16a01e6d240a09e62628df6d49a7d0c0d58ff20ed801"

URI_aarch64_rsync-daemon = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsync-daemon-3.4.1-2.el10_1.2.noarch.rpm;name=aarch64_rsync-daemon;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsync-daemon}"
SRC_URI[aarch64_rsync-daemon.sha256sum] = "4eaa9be2a98f8dc6ad9f44ddc8e3aeeb4c15899b5737ee95f2194839cd9acf24"

URI_aarch64_rsync-rrsync = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsync-rrsync-3.4.1-2.el10_1.2.noarch.rpm;name=aarch64_rsync-rrsync;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsync-rrsync}"
SRC_URI[aarch64_rsync-rrsync.sha256sum] = "a62546e89a302dc693f950c150bf3d9bff56fadcbd453142b1c65065959eec45"

RDEPENDS:rsync = " \
 bash \
 glibc \
 libacl \
 libzstd \
 lz4-libs \
 openssl-libs \
 popt \
 "
RDEPENDS:rsync-daemon = " \
 bash \
 rsync \
 systemd \
 "
RDEPENDS:rsync-rrsync = " \
 python3 \
 rsync \
 "
