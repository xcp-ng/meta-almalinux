# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sys-Mmap"
PV = "0.20"
PR = "18.el10_0"
PACKAGES = " \
 perl-Sys-Mmap \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Sys-Mmap-0.20-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2c5977322833128feee4078d7f7f50bece86d0577f14d3db44a76ff878edef2e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sys-Mmap-0.20-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Sys-Mmap;unpack=0"
SRC_URI[x86_64_v2_perl-Sys-Mmap.sha256sum] = "2263ff03144a8b26f20dddebf9b7437581ed9533636228e0507680ad87a511ba"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Sys-Mmap-0.20-18.el10_0.aarch64.rpm;name=aarch64_perl-Sys-Mmap;unpack=0"
SRC_URI[aarch64_perl-Sys-Mmap.sha256sum] = "afdf0410567be9b6957a8db203c763d57b48fc8f1fe666d9e628c404a9f7e1b1"

RDEPENDS:perl-Sys-Mmap = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
