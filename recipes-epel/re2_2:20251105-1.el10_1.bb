# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "re2"
PE = "2"
PV = "20251105"
PR = "1.el10_1"
PACKAGES = " \
 python3-google-re2 \
 re2 \
 re2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/re2-20251105-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "84c49a6a6ebec96e49735a635ad0b8e3ef7aa020fad726efd64845a11c12b458"

URI_x86_64_v2_python3-google-re2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-re2-1.1.20251105-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-google-re2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-re2}"
SRC_URI[x86_64_v2_python3-google-re2.sha256sum] = "e0d54b39a04bc8af4fd78b74efc2168c44a6f05e222ea0561119b00e1194dd38"

URI_x86_64_v2_re2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/re2-20251105-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_re2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_re2}"
SRC_URI[x86_64_v2_re2.sha256sum] = "feed5a9f1b3199fc9b7eb4651fe6cae0cd19defc60f864fe9f740f03666e7b4f"

URI_x86_64_v2_re2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/re2-devel-20251105-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_re2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_re2-devel}"
SRC_URI[x86_64_v2_re2-devel.sha256sum] = "41b53e57ae5e94103b7ed281a9ad16484d893e027cdd1b50370d70261fdb368f"

URI_aarch64_python3-google-re2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-re2-1.1.20251105-1.el10_1.aarch64.rpm;name=aarch64_python3-google-re2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-re2}"
SRC_URI[aarch64_python3-google-re2.sha256sum] = "bb0e660c280baa1137e235170b2b5e5fdc1c4ba516b9735a4e6f624cb12485f0"

URI_aarch64_re2 = "${EPEL_MIRROR}/aarch64/Packages/r/re2-20251105-1.el10_1.aarch64.rpm;name=aarch64_re2;unpack=0"
SRC_URI:append = " ${URI_aarch64_re2}"
SRC_URI[aarch64_re2.sha256sum] = "f8f2d893f49bd0c6c54bca7b21e172868e1339898d057a51f32679fd33704eb8"

URI_aarch64_re2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/re2-devel-20251105-1.el10_1.aarch64.rpm;name=aarch64_re2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_re2-devel}"
SRC_URI[aarch64_re2-devel.sha256sum] = "b92770a4af6756bfbb041640cc61628c96348428c487a10ec4122d81c986ae27"

RDEPENDS:python3-google-re2 = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 re2 \
 "
RDEPENDS:re2 = " \
 abseil-cpp \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 "
RDEPENDS:re2-devel = " \
 abseil-cpp-devel \
 cmake-filesystem \
 libicu-devel \
 pkgconf-pkg-config \
 re2 \
 "
