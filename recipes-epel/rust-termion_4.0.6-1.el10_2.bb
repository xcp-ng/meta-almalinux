# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-termion"
PV = "4.0.6"
PR = "1.el10_2"
PACKAGES = " \
 rust-termion+default-devel \
 rust-termion+serde-devel \
 rust-termion-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-termion-4.0.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ade4b87e53655fc7d1e30ea2bbab98272921ff26c09956d5da2a2148743d644"

URI_x86_64_v2_rust-termion+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-termion+default-devel-4.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-termion+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-termion+default-devel}"
SRC_URI[x86_64_v2_rust-termion+default-devel.sha256sum] = "c1c4a390979227ebdac7f6a927daee03df9fed491df72b83b195adb946b52e6c"

URI_x86_64_v2_rust-termion+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-termion+serde-devel-4.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-termion+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-termion+serde-devel}"
SRC_URI[x86_64_v2_rust-termion+serde-devel.sha256sum] = "56449df219ec39dd1a7a99c412169d5e563026cf192b791f443c8ab967077429"

URI_x86_64_v2_rust-termion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-termion-devel-4.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-termion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-termion-devel}"
SRC_URI[x86_64_v2_rust-termion-devel.sha256sum] = "b018907e1a06329475c19ac70c23ffc75e2275d74ee849cb5920b46affd8a00d"

URI_aarch64_rust-termion+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-termion+default-devel-4.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-termion+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-termion+default-devel}"
SRC_URI[aarch64_rust-termion+default-devel.sha256sum] = "f652a3f88d46a133b455465c5158bccdc730ae54e4cbc9d9af485aea570d694d"

URI_aarch64_rust-termion+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-termion+serde-devel-4.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-termion+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-termion+serde-devel}"
SRC_URI[aarch64_rust-termion+serde-devel.sha256sum] = "82847af751ebb7aef428775b0850fb0b8f9cf74e033cb39d7cf4966fb617b550"

URI_aarch64_rust-termion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-termion-devel-4.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-termion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-termion-devel}"
SRC_URI[aarch64_rust-termion-devel.sha256sum] = "ff1a9f52767dc2207a0f06521d08648dc4f090188d3e417096b83be14fd2c21d"

RDEPENDS:rust-termion+default-devel = " \
 cargo \
 rust-termion-devel \
 "
RDEPENDS:rust-termion+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-termion-devel \
 "
RDEPENDS:rust-termion-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-numtoa+default-devel \
 "
