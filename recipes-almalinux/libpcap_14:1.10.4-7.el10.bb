# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libpcap"
PE = "14"
PV = "1.10.4"
PR = "7.el10"
PACKAGES = " \
 libpcap \
 libpcap-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libpcap-1.10.4-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "00f59192c18361e2f95b2bbb9d11561f3d3a9e98333cd928141d362eaf80b680"

URI_x86_64_v2_libpcap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libpcap-1.10.4-7.el10.x86_64_v2.rpm;name=x86_64_v2_libpcap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpcap}"
SRC_URI[x86_64_v2_libpcap.sha256sum] = "ed48eb9883dc7f05a871b94b8b16333865e94dfdeaeb7710b0e1d48c213de725"

URI_x86_64_v2_libpcap-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libpcap-devel-1.10.4-7.el10.x86_64_v2.rpm;name=x86_64_v2_libpcap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpcap-devel}"
SRC_URI[x86_64_v2_libpcap-devel.sha256sum] = "c97126a0fa73a295ed7941997ba244cb675ac02ea93bcf2e2be2444a0c3e2be8"

URI_aarch64_libpcap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libpcap-1.10.4-7.el10.aarch64.rpm;name=aarch64_libpcap;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpcap}"
SRC_URI[aarch64_libpcap.sha256sum] = "5895ee6e31a3674740c81c427a21c30edb3535c40a6e9f73b92a609c0fd14be9"

URI_aarch64_libpcap-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libpcap-devel-1.10.4-7.el10.aarch64.rpm;name=aarch64_libpcap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpcap-devel}"
SRC_URI[aarch64_libpcap-devel.sha256sum] = "8ae467ae086408d6c6f8bf318fe6bc1f4da076be93ea4182b21ec1b27241a286"

RDEPENDS:libpcap = " \
 glibc \
 libibverbs \
 "
RDEPENDS:libpcap-devel = " \
 bash \
 libpcap \
 pkgconf-pkg-config \
 rdma-core-devel \
 "
