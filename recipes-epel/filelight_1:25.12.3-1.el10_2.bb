# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "filelight"
PE = "1"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 filelight \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/filelight-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a02d40606b93950010783c9b42449bfb79d8685597b61273ac648fef1d1433b"

URI_x86_64_v2_filelight = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/filelight-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_filelight;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_filelight}"
SRC_URI[x86_64_v2_filelight.sha256sum] = "67d1b811ff7f293ebc8f08b59c9f9b3c74e974d092daab7d8a6e18cd3a8ef6ab"

URI_aarch64_filelight = "${EPEL_MIRROR}/aarch64/Packages/f/filelight-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_filelight;unpack=0"
SRC_URI:append = " ${URI_aarch64_filelight}"
SRC_URI[aarch64_filelight.sha256sum] = "761751ee615545d337ec0c06350a6a34aa0c9c34a4f02301d640488a45808b68"

RDEPENDS:filelight = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kquickcharts \
 kf6-kwidgetsaddons \
 kf6-qqc2-desktop-style \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
