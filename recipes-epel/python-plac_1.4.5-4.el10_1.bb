# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-plac"
PV = "1.4.5"
PR = "4.el10_1"
PACKAGES = " \
 python-plac-doc \
 python3-plac \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-plac-1.4.5-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f291818f685b1c49f48dfe757dd0b50a53e94d84680e7a4fb9b6b9d5185b139d"

URI_x86_64_v2_python-plac-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-plac-doc-1.4.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-plac-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-plac-doc}"
SRC_URI[x86_64_v2_python-plac-doc.sha256sum] = "807d5ddd0ab62f635551c03f6cc2bb5f246b7cd300eb788d3df5344c48d5e796"

URI_x86_64_v2_python3-plac = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-plac-1.4.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-plac;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-plac}"
SRC_URI[x86_64_v2_python3-plac.sha256sum] = "427ab1426b6ce3c0327e789179d5d909e1ef500eef3b9c2dea4b245f754bee3c"

URI_aarch64_python-plac-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-plac-doc-1.4.5-4.el10_1.noarch.rpm;name=aarch64_python-plac-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-plac-doc}"
SRC_URI[aarch64_python-plac-doc.sha256sum] = "8ed976ca2cfda5997688b5968ea028fa9435eb7fbf9a3a0644ffc047ef8c9461"

URI_aarch64_python3-plac = "${EPEL_MIRROR}/aarch64/Packages/p/python3-plac-1.4.5-4.el10_1.noarch.rpm;name=aarch64_python3-plac;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-plac}"
SRC_URI[aarch64_python3-plac.sha256sum] = "faa2c8db5792bcb5946d6b2a97d28a4c6ebae1d9570cfff8675035c3d0492d4e"

RDEPENDS:python-plac-doc = " \
 "
RDEPENDS:python3-plac = " \
 python3 \
 "
