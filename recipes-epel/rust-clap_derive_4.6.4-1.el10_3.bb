# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap_derive"
PV = "4.6.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-clap_derive+debug-devel \
 rust-clap_derive+default-devel \
 rust-clap_derive+deprecated-devel \
 rust-clap_derive+raw-deprecated-devel \
 rust-clap_derive+unstable-markdown-devel \
 rust-clap_derive+unstable-v5-devel \
 rust-clap_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap_derive-4.6.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fba7b4995dc6a97ecaa08091b3a3de322c6847243e0eec02e734f0b6b34f25ab"

URI_x86_64_v2_rust-clap_derive+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive+debug-devel-4.6.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_derive+debug-devel}"
SRC_URI[x86_64_v2_rust-clap_derive+debug-devel.sha256sum] = "d55fe39ee9bf82f7bb453d6dd4fd61260a402c4e618ca51d829b4ec735eae670"

URI_x86_64_v2_rust-clap_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive+default-devel-4.6.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_derive+default-devel}"
SRC_URI[x86_64_v2_rust-clap_derive+default-devel.sha256sum] = "97764781084c6bb7969fb7c9416685b5f078aff32066eebe0027bab39052734d"

URI_x86_64_v2_rust-clap_derive+deprecated-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive+deprecated-devel-4.6.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive+deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_derive+deprecated-devel}"
SRC_URI[x86_64_v2_rust-clap_derive+deprecated-devel.sha256sum] = "a54dff6a73d8acd86f6e76f93b12e98fbce68d5f3faec32639a132545100e3b7"

URI_x86_64_v2_rust-clap_derive+raw-deprecated-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive+raw-deprecated-devel-4.6.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive+raw-deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_derive+raw-deprecated-devel}"
SRC_URI[x86_64_v2_rust-clap_derive+raw-deprecated-devel.sha256sum] = "5bd5eb6f148c6d2c7010ac970bae188c260f22c2645cdb01d6fe9f40bbae0d66"

URI_x86_64_v2_rust-clap_derive+unstable-markdown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive+unstable-markdown-devel-4.6.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive+unstable-markdown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_derive+unstable-markdown-devel}"
SRC_URI[x86_64_v2_rust-clap_derive+unstable-markdown-devel.sha256sum] = "90a1cb08786d3158fab64d5fd5f211d062da4c0bdabcf9c52712b6f865ec4efa"

URI_x86_64_v2_rust-clap_derive+unstable-v5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive+unstable-v5-devel-4.6.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive+unstable-v5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_derive+unstable-v5-devel}"
SRC_URI[x86_64_v2_rust-clap_derive+unstable-v5-devel.sha256sum] = "d26031aa449adacdd704b3e373f8489bebe77ad83a15f4d713b9c906a1fee295"

URI_x86_64_v2_rust-clap_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive-devel-4.6.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_derive-devel}"
SRC_URI[x86_64_v2_rust-clap_derive-devel.sha256sum] = "7c9e85752a7950a13574105231307e29f49561b99187cfe107e47e47e4486f35"

URI_aarch64_rust-clap_derive+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive+debug-devel-4.6.4-1.el10_3.noarch.rpm;name=aarch64_rust-clap_derive+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_derive+debug-devel}"
SRC_URI[aarch64_rust-clap_derive+debug-devel.sha256sum] = "472292521f6e1c4c771c0df31921af8ac5acd8f5b557705ac88efa3f142e55a9"

URI_aarch64_rust-clap_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive+default-devel-4.6.4-1.el10_3.noarch.rpm;name=aarch64_rust-clap_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_derive+default-devel}"
SRC_URI[aarch64_rust-clap_derive+default-devel.sha256sum] = "a6416c24f4975cf5a74c680039fd86e05c3fa6bff0918174262788dcca350858"

URI_aarch64_rust-clap_derive+deprecated-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive+deprecated-devel-4.6.4-1.el10_3.noarch.rpm;name=aarch64_rust-clap_derive+deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_derive+deprecated-devel}"
SRC_URI[aarch64_rust-clap_derive+deprecated-devel.sha256sum] = "d536fa232efa59af35d394b1a4dbd0e400eae9f9409500dc39547c6f8a552abd"

URI_aarch64_rust-clap_derive+raw-deprecated-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive+raw-deprecated-devel-4.6.4-1.el10_3.noarch.rpm;name=aarch64_rust-clap_derive+raw-deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_derive+raw-deprecated-devel}"
SRC_URI[aarch64_rust-clap_derive+raw-deprecated-devel.sha256sum] = "e303cb9799d586fae9fa67db83c1e5404db0f74c0bcb623d4c7b66d595d54899"

URI_aarch64_rust-clap_derive+unstable-markdown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive+unstable-markdown-devel-4.6.4-1.el10_3.noarch.rpm;name=aarch64_rust-clap_derive+unstable-markdown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_derive+unstable-markdown-devel}"
SRC_URI[aarch64_rust-clap_derive+unstable-markdown-devel.sha256sum] = "2899c4ff03f976886665c2be470b62a6cf59d755fd23f41ab4d119c516e040c4"

URI_aarch64_rust-clap_derive+unstable-v5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive+unstable-v5-devel-4.6.4-1.el10_3.noarch.rpm;name=aarch64_rust-clap_derive+unstable-v5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_derive+unstable-v5-devel}"
SRC_URI[aarch64_rust-clap_derive+unstable-v5-devel.sha256sum] = "0211577424a85022d376cd9770b8f78d61c78dff85e4669ffd0e5c354422ed2b"

URI_aarch64_rust-clap_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive-devel-4.6.4-1.el10_3.noarch.rpm;name=aarch64_rust-clap_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_derive-devel}"
SRC_URI[aarch64_rust-clap_derive-devel.sha256sum] = "78d1f6868648ce5bba5b13f7d01addfb2fdad988f7931bcc9eff3ac21fc6fcd3"

RDEPENDS:rust-clap_derive+debug-devel = " \
 cargo \
 rust-clap_derive-devel \
 "
RDEPENDS:rust-clap_derive+default-devel = " \
 cargo \
 rust-clap_derive-devel \
 "
RDEPENDS:rust-clap_derive+deprecated-devel = " \
 cargo \
 rust-clap_derive-devel \
 "
RDEPENDS:rust-clap_derive+raw-deprecated-devel = " \
 cargo \
 rust-clap_derive+deprecated-devel \
 rust-clap_derive-devel \
 "
RDEPENDS:rust-clap_derive+unstable-markdown-devel = " \
 cargo \
 rust-anstyle+default-devel \
 rust-clap_derive-devel \
 rust-pulldown-cmark-devel \
 "
RDEPENDS:rust-clap_derive+unstable-v5-devel = " \
 cargo \
 rust-clap_derive+deprecated-devel \
 rust-clap_derive-devel \
 "
RDEPENDS:rust-clap_derive-devel = " \
 cargo \
 rust \
 rust-heck+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
