# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-discover"
PV = "0.43.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-discover+default-devel \
 rust-gix-discover-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-discover-0.43.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86b7d7c1039001cdaa64de2fc55dadf5f12601879371d2d95a3c7147240af241"

URI_x86_64_v2_rust-gix-discover+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-discover+default-devel-0.43.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-discover+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-discover+default-devel}"
SRC_URI[x86_64_v2_rust-gix-discover+default-devel.sha256sum] = "219f3f89bdae90db718b7e43682c8edbad135e0c88ba12dfbb0b2a34f537494d"

URI_x86_64_v2_rust-gix-discover-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-discover-devel-0.43.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-discover-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-discover-devel}"
SRC_URI[x86_64_v2_rust-gix-discover-devel.sha256sum] = "c569a9b0423b288c0bdcd2000eea0f2ad51142f11b30d44264cbe4f4c3b4dfa5"

URI_aarch64_rust-gix-discover+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-discover+default-devel-0.43.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-discover+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-discover+default-devel}"
SRC_URI[aarch64_rust-gix-discover+default-devel.sha256sum] = "322f2f357bb0aabc3afae51801638ccd81d2a116b41efb728b7c1b2fd6dbb78e"

URI_aarch64_rust-gix-discover-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-discover-devel-0.43.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-discover-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-discover-devel}"
SRC_URI[aarch64_rust-gix-discover-devel.sha256sum] = "074fc9583f07b58a1d06d1ea9c4329408369b1bc6cb771af20d6ec9ab1116d62"

RDEPENDS:rust-gix-discover+default-devel = " \
 cargo \
 rust-gix-discover-devel \
 "
RDEPENDS:rust-gix-discover-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-fs+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-path+default-devel \
 rust-gix-ref+default-devel \
 rust-gix-sec+default-devel \
 rust-thiserror+default-devel \
 "
