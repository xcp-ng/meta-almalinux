# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-sfapex"
PV = "2.4.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-tree-sitter-sfapex+default-devel \
 rust-tree-sitter-sfapex-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-sfapex-2.4.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e1a4fb78f862463ba178500e09588fb82428c1da9be9a783ae3a37f0b1d02c19"

URI_x86_64_v2_rust-tree-sitter-sfapex+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-sfapex+default-devel-2.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-sfapex+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-sfapex+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-sfapex+default-devel.sha256sum] = "cd7b01dc84ced86fde3770a9c34eb69a96cf3369fccd2bcc3191718b855aebbe"

URI_x86_64_v2_rust-tree-sitter-sfapex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-sfapex-devel-2.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-sfapex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-sfapex-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-sfapex-devel.sha256sum] = "439dd989b5c4db10112296f81488378d7c47ffb7a1f5c37c2457bf766e0c4f1c"

URI_aarch64_rust-tree-sitter-sfapex+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-sfapex+default-devel-2.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-sfapex+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-sfapex+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-sfapex+default-devel.sha256sum] = "54da23fbb61cb9840adb74add31c802dd6b33d998070bb612d78445890f03517"

URI_aarch64_rust-tree-sitter-sfapex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-sfapex-devel-2.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-sfapex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-sfapex-devel}"
SRC_URI[aarch64_rust-tree-sitter-sfapex-devel.sha256sum] = "87c875a604539f463392bc188f0722a45741b7423af8e611e6db84d4857b7ff6"

RDEPENDS:rust-tree-sitter-sfapex+default-devel = " \
 cargo \
 rust-tree-sitter-sfapex-devel \
 "
RDEPENDS:rust-tree-sitter-sfapex-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
