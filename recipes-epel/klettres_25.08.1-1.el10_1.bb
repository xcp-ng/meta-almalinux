# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "klettres"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 klettres \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/klettres-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e384f49d3aaf9723e783ac69b0a9a40cbad123ec532c9d14ae68d5732349d5a"

URI_x86_64_v2_klettres = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/klettres-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_klettres;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_klettres}"
SRC_URI[x86_64_v2_klettres.sha256sum] = "1c056e18ac62f398b21a44ef955b6b770f65af5b6c13a834a85b0fa6d313f1cd"

URI_aarch64_klettres = "${EPEL_MIRROR}/aarch64/Packages/k/klettres-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_klettres;unpack=0"
SRC_URI:append = " ${URI_aarch64_klettres}"
SRC_URI[aarch64_klettres.sha256sum] = "54f92d4a721725ac2d3589c916a4bc19e603e590b3e7d79c1faf058ac691bb71"

RDEPENDS:klettres = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
 "
