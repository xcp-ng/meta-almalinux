# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libvpx"
PV = "1.14.1"
PR = "6.el10_2"
PACKAGES = " \
 libvpx \
 libvpx-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libvpx-1.14.1-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "33f9efb9ba79a139ba1e2337909c96eb7454884c2e64b61208ddb568c3d014ee"

URI_x86_64_v2_libvpx = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvpx-1.14.1-6.el10_2.x86_64_v2.rpm;name=x86_64_v2_libvpx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvpx}"
SRC_URI[x86_64_v2_libvpx.sha256sum] = "e8ef7982709345f57c8d8ba6e5bd5aebe2dd66201f3727509f7ac70266310656"

URI_x86_64_v2_libvpx-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libvpx-devel-1.14.1-6.el10_2.x86_64_v2.rpm;name=x86_64_v2_libvpx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvpx-devel}"
SRC_URI[x86_64_v2_libvpx-devel.sha256sum] = "39cc360c975d6b9f6f8a23e6a39467d2d53600d69f446a5c8515fd2304cb8286"

URI_aarch64_libvpx = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvpx-1.14.1-6.el10_2.aarch64.rpm;name=aarch64_libvpx;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvpx}"
SRC_URI[aarch64_libvpx.sha256sum] = "3f7a34dc8987c174627ad649e06b37e436adf6d2cc211ba2741292c65c2046ce"

URI_aarch64_libvpx-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libvpx-devel-1.14.1-6.el10_2.aarch64.rpm;name=aarch64_libvpx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvpx-devel}"
SRC_URI[aarch64_libvpx-devel.sha256sum] = "b052478d8699003450c82d893ecf83d95ad5f8358ff8eb2fccdc41d3c854f799"

RDEPENDS:libvpx = " \
 glibc \
 "
RDEPENDS:libvpx-devel = " \
 libvpx \
 pkgconf-pkg-config \
 "
