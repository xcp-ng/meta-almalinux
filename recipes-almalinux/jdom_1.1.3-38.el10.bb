# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jdom"
PV = "1.1.3"
PR = "38.el10"
PACKAGES = " \
 jdom \
 jdom-demo \
 jdom-javadoc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/jdom-1.1.3-38.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "eacd4489ba01f0aaa72221b0b34b227b00bf01fcfad70fd5f6327025d16a9859"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jdom-1.1.3-38.el10.noarch.rpm;name=x86_64_v2_jdom;unpack=0"
SRC_URI[x86_64_v2_jdom.sha256sum] = "86590ac360ccf1036fe6a1ffcd7903e339a0b56f8814619a1635f1362e7fc343"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jdom-demo-1.1.3-38.el10.noarch.rpm;name=x86_64_v2_jdom-demo;unpack=0"
SRC_URI[x86_64_v2_jdom-demo.sha256sum] = "fc8312d9b04da304001b76a356b09c38a0814eed2f4a471f7c01f90de6600f5c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jdom-javadoc-1.1.3-38.el10.noarch.rpm;name=x86_64_v2_jdom-javadoc;unpack=0"
SRC_URI[x86_64_v2_jdom-javadoc.sha256sum] = "d9eaeba99b86a50ed2c72a35f01f3cc1c819659f428a35a6a55cedb6a8dfe472"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jdom-1.1.3-38.el10.noarch.rpm;name=aarch64_jdom;unpack=0"
SRC_URI[aarch64_jdom.sha256sum] = "86590ac360ccf1036fe6a1ffcd7903e339a0b56f8814619a1635f1362e7fc343"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jdom-demo-1.1.3-38.el10.noarch.rpm;name=aarch64_jdom-demo;unpack=0"
SRC_URI[aarch64_jdom-demo.sha256sum] = "fc8312d9b04da304001b76a356b09c38a0814eed2f4a471f7c01f90de6600f5c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jdom-javadoc-1.1.3-38.el10.noarch.rpm;name=aarch64_jdom-javadoc;unpack=0"
SRC_URI[aarch64_jdom-javadoc.sha256sum] = "d9eaeba99b86a50ed2c72a35f01f3cc1c819659f428a35a6a55cedb6a8dfe472"

RDEPENDS:jdom = " \
 javapackages-filesystem \
 "
RDEPENDS:jdom-demo = " \
 jdom \
 "
RDEPENDS:jdom-javadoc = " \
 javapackages-filesystem \
 "
