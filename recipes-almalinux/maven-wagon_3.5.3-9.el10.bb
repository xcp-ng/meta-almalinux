# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "maven-wagon"
PV = "3.5.3"
PR = "9.el10"
PACKAGES = " \
 maven-wagon \
 maven-wagon-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/maven-wagon-3.5.3-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d97af45160bbac0a1ccbb4ff3ca3dcd1771cad37e065afdb8373ecae5f878a7b"

URI_x86_64_v2_maven-wagon = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/maven-wagon-3.5.3-9.el10.noarch.rpm;name=x86_64_v2_maven-wagon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-wagon}"
SRC_URI[x86_64_v2_maven-wagon.sha256sum] = "c19bcb2722d2f5da0e7f5d9bc3a3b822294212eba7e302f947a97cbe9de2d7ee"

URI_x86_64_v2_maven-wagon-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-wagon-javadoc-3.5.3-9.el10.noarch.rpm;name=x86_64_v2_maven-wagon-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-wagon-javadoc}"
SRC_URI[x86_64_v2_maven-wagon-javadoc.sha256sum] = "b3bb338565dd0b5c243fe47763f3da30c23e5af0b5021c759e2d1df4e9daf976"

URI_aarch64_maven-wagon = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/maven-wagon-3.5.3-9.el10.noarch.rpm;name=aarch64_maven-wagon;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-wagon}"
SRC_URI[aarch64_maven-wagon.sha256sum] = "c19bcb2722d2f5da0e7f5d9bc3a3b822294212eba7e302f947a97cbe9de2d7ee"

URI_aarch64_maven-wagon-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-wagon-javadoc-3.5.3-9.el10.noarch.rpm;name=aarch64_maven-wagon-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-wagon-javadoc}"
SRC_URI[aarch64_maven-wagon-javadoc.sha256sum] = "b3bb338565dd0b5c243fe47763f3da30c23e5af0b5021c759e2d1df4e9daf976"

RDEPENDS:maven-wagon = " \
 httpcomponents-client \
 httpcomponents-core \
 javapackages-filesystem \
 jcl-over-slf4j \
 plexus-utils \
 slf4j \
 "
RDEPENDS:maven-wagon-javadoc = " \
 javapackages-filesystem \
 "
