# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kwalletmanager5"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kwalletmanager5 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kwalletmanager5-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec6d428561881555e7eee373b06c755dd37cad5abce56b87d98e47610e219516"

URI_x86_64_v2_kwalletmanager5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwalletmanager5-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwalletmanager5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwalletmanager5}"
SRC_URI[x86_64_v2_kwalletmanager5.sha256sum] = "b84db433277ee9e6fb74b15501bf725f4f5899bab9fbb8dfc16976cbcf82d98e"

URI_aarch64_kwalletmanager5 = "${EPEL_MIRROR}/aarch64/Packages/k/kwalletmanager5-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kwalletmanager5;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwalletmanager5}"
SRC_URI[aarch64_kwalletmanager5.sha256sum] = "10cdd03066bb978d134ff5570b50ba97e3c6a89b9aa2d942bdc8889b722b82f0"

RDEPENDS:kwalletmanager5 = " \
 glibc \
 kf6-karchive \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kitemviews \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
