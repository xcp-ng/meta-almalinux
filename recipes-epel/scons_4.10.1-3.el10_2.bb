# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "scons"
PV = "4.10.1"
PR = "3.el10_2"
PACKAGES = " \
 python3-scons \
 scons-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/scons-4.10.1-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0e6b02b97e023d890296f93fa118cab069a0c7e570b8fa9674aa8b8fbf6b6e04"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-scons-4.10.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-scons;unpack=0"
SRC_URI[x86_64_v2_python3-scons.sha256sum] = "a57f540e17e0c424a15c954b17f6be72e893a808d3784779ea131ed51faa7587"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scons-doc-4.10.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_scons-doc;unpack=0"
SRC_URI[x86_64_v2_scons-doc.sha256sum] = "5bbcd652c46c74a4abc8624adbd93b79a5b346d610791a995064c4c277ee308c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-scons-4.10.1-3.el10_2.noarch.rpm;name=aarch64_python3-scons;unpack=0"
SRC_URI[aarch64_python3-scons.sha256sum] = "0afad43b80a11fbe18c65531e0322ea0e40d5e940abc6a124775a39bbc789270"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/scons-doc-4.10.1-3.el10_2.noarch.rpm;name=aarch64_scons-doc;unpack=0"
SRC_URI[aarch64_scons-doc.sha256sum] = "38e8a5d0ba0e446fda1d465f908274dc99ff40ad9fdd235c24cca1255b19c2ac"

RDEPENDS:python3-scons = " \
 python3 \
 "
RDEPENDS:scons-doc = " \
 "
