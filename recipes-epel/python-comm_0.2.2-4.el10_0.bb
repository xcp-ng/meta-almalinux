# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-comm"
PV = "0.2.2"
PR = "4.el10_0"
PACKAGES = " \
 python3-comm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-comm-0.2.2-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "766a2b727e71e34fa7b68c85149767e040cf93e8e23372a5cab8d926895938f4"

URI_x86_64_v2_python3-comm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-comm-0.2.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-comm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-comm}"
SRC_URI[x86_64_v2_python3-comm.sha256sum] = "ecda97728390db5f42f31af257aaca1d5058ac05a7c2baf53971aa8afaf32abf"

URI_aarch64_python3-comm = "${EPEL_MIRROR}/aarch64/Packages/p/python3-comm-0.2.2-4.el10_0.noarch.rpm;name=aarch64_python3-comm;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-comm}"
SRC_URI[aarch64_python3-comm.sha256sum] = "2bcb15a95eb49ada5ca6794e8e06dbb3e25bbcad7d926006e953c90165dda72b"

RDEPENDS:python3-comm = " \
 python3 \
 python3-traitlets \
 "
