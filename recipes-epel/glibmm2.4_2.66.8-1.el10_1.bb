# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glibmm2.4"
PV = "2.66.8"
PR = "1.el10_1"
PACKAGES = " \
 glibmm2.4 \
 glibmm2.4-devel \
 glibmm2.4-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/glibmm2.4-2.66.8-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "81160580d40a296bb38e20d10fc85d9f5a8b389b1d362bd93dd59251a8091548"

URI_x86_64_v2_glibmm2.4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glibmm2.4-2.66.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_glibmm2.4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibmm2.4}"
SRC_URI[x86_64_v2_glibmm2.4.sha256sum] = "d7d64ab656836b517c0a453ab9334bfd2722a3c1835383416c777dcfcbe9a161"

URI_x86_64_v2_glibmm2.4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glibmm2.4-devel-2.66.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_glibmm2.4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibmm2.4-devel}"
SRC_URI[x86_64_v2_glibmm2.4-devel.sha256sum] = "e5b7594ea5156b3bb80d2f17fe5aeb54f7520e66d47776dc6ee4092338e552f1"

URI_x86_64_v2_glibmm2.4-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glibmm2.4-doc-2.66.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_glibmm2.4-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibmm2.4-doc}"
SRC_URI[x86_64_v2_glibmm2.4-doc.sha256sum] = "5821d661140de5436983a31bd53669700deb1dd346e6ac77db911e9139ebcd91"

URI_aarch64_glibmm2.4 = "${EPEL_MIRROR}/aarch64/Packages/g/glibmm2.4-2.66.8-1.el10_1.aarch64.rpm;name=aarch64_glibmm2.4;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibmm2.4}"
SRC_URI[aarch64_glibmm2.4.sha256sum] = "5d86d89ba3df2aa46132c77f452927541c053f2c046b9edf45f37fba25cb8d47"

URI_aarch64_glibmm2.4-devel = "${EPEL_MIRROR}/aarch64/Packages/g/glibmm2.4-devel-2.66.8-1.el10_1.aarch64.rpm;name=aarch64_glibmm2.4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibmm2.4-devel}"
SRC_URI[aarch64_glibmm2.4-devel.sha256sum] = "c96f2760e413f2cd5e0b270db33bdf12f083bf0f9e61397493b477454173438c"

URI_aarch64_glibmm2.4-doc = "${EPEL_MIRROR}/aarch64/Packages/g/glibmm2.4-doc-2.66.8-1.el10_1.noarch.rpm;name=aarch64_glibmm2.4-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibmm2.4-doc}"
SRC_URI[aarch64_glibmm2.4-doc.sha256sum] = "8d8887e2e564e4efa70dc6418c46c14f16fbc8e03424f2893c7812998b500b6e"

RDEPENDS:glibmm2.4 = " \
 glib2 \
 glibc \
 libgcc \
 libsigc++20 \
 libstdc++ \
 "
RDEPENDS:glibmm2.4-devel = " \
 glib2-devel \
 glibmm2.4 \
 glibmm2.4-devel \
 libsigc++20-devel \
 perl-Exporter \
 perl-XML-Parser \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-open \
 pkgconf-pkg-config \
 "
RDEPENDS:glibmm2.4-doc = " \
 glibmm2.4 \
 libsigc++20-doc \
 "
