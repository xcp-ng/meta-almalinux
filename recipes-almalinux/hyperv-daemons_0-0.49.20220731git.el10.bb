# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyperv-daemons"
PV = "0"
PR = "0.49.20220731git.el10"
PACKAGES:x86_64_v2 = " \
 hyperv-daemons \
 hyperv-daemons-license \
 hyperv-tools \
 hypervfcopyd \
 hypervkvpd \
 hypervvssd \
"
PACKAGES:aarch64 = " \
 hyperv-daemons \
 hyperv-daemons-license \
 hyperv-tools \
 hypervkvpd \
 hypervvssd \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyperv-daemons-0-0.49.20220731git.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "54ac1bde3948216099feca1fee424fa6bcd02cfeac6500aa2a07212bd707fa1a"

URI_x86_64_v2_hyperv-daemons = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyperv-daemons-0-0.49.20220731git.el10.x86_64_v2.rpm;name=x86_64_v2_hyperv-daemons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyperv-daemons}"
SRC_URI[x86_64_v2_hyperv-daemons.sha256sum] = "af8cab3fce5bc39273bfb0eee1ecc101f53b850a713b529b2482f0d2fa23b418"

URI_x86_64_v2_hyperv-daemons-license = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyperv-daemons-license-0-0.49.20220731git.el10.noarch.rpm;name=x86_64_v2_hyperv-daemons-license;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyperv-daemons-license}"
SRC_URI[x86_64_v2_hyperv-daemons-license.sha256sum] = "7aa89a5ab1182d60ab29ae3b746b399aa72a2920f8e838375ff4d941c548dbc3"

URI_x86_64_v2_hyperv-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyperv-tools-0-0.49.20220731git.el10.noarch.rpm;name=x86_64_v2_hyperv-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyperv-tools}"
SRC_URI[x86_64_v2_hyperv-tools.sha256sum] = "91dbfe854f43677348e3427d4db6ce373832c3e8fdee9d7913ae8a9de5b522e1"

URI_x86_64_v2_hypervfcopyd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hypervfcopyd-0-0.49.20220731git.el10.x86_64_v2.rpm;name=x86_64_v2_hypervfcopyd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hypervfcopyd}"
SRC_URI[x86_64_v2_hypervfcopyd.sha256sum] = "3e53d0c12710168c1063003bcc0ff0e32d51f1584d7604232d06eedeb76c61ef"

URI_x86_64_v2_hypervkvpd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hypervkvpd-0-0.49.20220731git.el10.x86_64_v2.rpm;name=x86_64_v2_hypervkvpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hypervkvpd}"
SRC_URI[x86_64_v2_hypervkvpd.sha256sum] = "e7ecf42d008d8d2d460fcb868fe2f7e17e6eb9793f35c9ea9599278d6e2a1e79"

URI_x86_64_v2_hypervvssd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hypervvssd-0-0.49.20220731git.el10.x86_64_v2.rpm;name=x86_64_v2_hypervvssd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hypervvssd}"
SRC_URI[x86_64_v2_hypervvssd.sha256sum] = "25da15a2d9a181a8b0597539045ab3402a257b6f9e5ebd0123802937abfe9546"

URI_aarch64_hyperv-daemons = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyperv-daemons-0-0.49.20220731git.el10.aarch64.rpm;name=aarch64_hyperv-daemons;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyperv-daemons}"
SRC_URI[aarch64_hyperv-daemons.sha256sum] = "9d213a44eb2d11a6fd75564952ee548cf83f09df2d85e2a013b12a5351babac4"

URI_aarch64_hyperv-daemons-license = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyperv-daemons-license-0-0.49.20220731git.el10.noarch.rpm;name=aarch64_hyperv-daemons-license;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyperv-daemons-license}"
SRC_URI[aarch64_hyperv-daemons-license.sha256sum] = "7aa89a5ab1182d60ab29ae3b746b399aa72a2920f8e838375ff4d941c548dbc3"

URI_aarch64_hyperv-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyperv-tools-0-0.49.20220731git.el10.noarch.rpm;name=aarch64_hyperv-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyperv-tools}"
SRC_URI[aarch64_hyperv-tools.sha256sum] = "91dbfe854f43677348e3427d4db6ce373832c3e8fdee9d7913ae8a9de5b522e1"

URI_aarch64_hypervkvpd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hypervkvpd-0-0.49.20220731git.el10.aarch64.rpm;name=aarch64_hypervkvpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_hypervkvpd}"
SRC_URI[aarch64_hypervkvpd.sha256sum] = "90f02e9fa0d8d8cc943c21587a3488a12beeec7847cdeaba13aa4b0cadb7c4ff"

URI_aarch64_hypervvssd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hypervvssd-0-0.49.20220731git.el10.aarch64.rpm;name=aarch64_hypervvssd;unpack=0"
SRC_URI:append = " ${URI_aarch64_hypervvssd}"
SRC_URI[aarch64_hypervvssd.sha256sum] = "c0a3dc5bff57950266a03f417695f1395d3e3822adc1d8c61ea10f2e1f9dd0a5"

RDEPENDS:hyperv-daemons:x86_64_v2 = " \
 hypervfcopyd \
 hypervkvpd \
 hypervvssd \
"
RDEPENDS:hyperv-daemons:aarch64 = " \
 hypervkvpd \
 hypervvssd \
"
RDEPENDS:hyperv-daemons-license = " \
 "
RDEPENDS:hyperv-tools = " \
 python3 \
 "
RDEPENDS:hypervfcopyd = " \
 bash \
 glibc \
 hyperv-daemons-license \
 systemd \
 "
RDEPENDS:hypervkvpd = " \
 bash \
 glibc \
 hyperv-daemons-license \
 systemd \
 "
RDEPENDS:hypervvssd = " \
 bash \
 glibc \
 hyperv-daemons-license \
 systemd \
 "
