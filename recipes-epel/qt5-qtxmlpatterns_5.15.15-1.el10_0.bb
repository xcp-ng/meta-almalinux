# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtxmlpatterns"
PV = "5.15.15"
PR = "1.el10_0"
PACKAGES = " \
 qt5-qtxmlpatterns \
 qt5-qtxmlpatterns-devel \
 qt5-qtxmlpatterns-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtxmlpatterns-5.15.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91279b8430591d68bed6ebd5fed1a7796f319f15afe58f1c143f4b5cdbcf75dc"

URI_x86_64_v2_qt5-qtxmlpatterns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtxmlpatterns-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtxmlpatterns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtxmlpatterns}"
SRC_URI[x86_64_v2_qt5-qtxmlpatterns.sha256sum] = "0a335296887b5764ab04736a3d4f97478198e7265e0c40128109652529255d2a"

URI_x86_64_v2_qt5-qtxmlpatterns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtxmlpatterns-devel-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtxmlpatterns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtxmlpatterns-devel}"
SRC_URI[x86_64_v2_qt5-qtxmlpatterns-devel.sha256sum] = "402b030b56bfd500f1f5276098b60070dcfa9a4ca7ccd921b5e71c0cea318ac6"

URI_x86_64_v2_qt5-qtxmlpatterns-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtxmlpatterns-examples-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtxmlpatterns-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtxmlpatterns-examples}"
SRC_URI[x86_64_v2_qt5-qtxmlpatterns-examples.sha256sum] = "0ee8e1a3cc7e6a1cf1521129023512bb9b3ff084b4e9837919de01c34b7d46a4"

URI_aarch64_qt5-qtxmlpatterns = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtxmlpatterns-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtxmlpatterns;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtxmlpatterns}"
SRC_URI[aarch64_qt5-qtxmlpatterns.sha256sum] = "25e6b3b2fa528eb952cf5b2919664b67d69e149777a692a3859fd45e70630151"

URI_aarch64_qt5-qtxmlpatterns-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtxmlpatterns-devel-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtxmlpatterns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtxmlpatterns-devel}"
SRC_URI[aarch64_qt5-qtxmlpatterns-devel.sha256sum] = "1c708854b772f6f419456aae2d5e43cef589845323b4205f9c01b01a364d799d"

URI_aarch64_qt5-qtxmlpatterns-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtxmlpatterns-examples-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtxmlpatterns-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtxmlpatterns-examples}"
SRC_URI[aarch64_qt5-qtxmlpatterns-examples.sha256sum] = "d8415757912c3a20ef85e1df352e6ef29692ce635769ac985e88e80f248bb4a8"

RDEPENDS:qt5-qtxmlpatterns = " \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtxmlpatterns-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt5-qtbase \
 qt5-qtbase-devel \
 qt5-qtxmlpatterns \
 "
RDEPENDS:qt5-qtxmlpatterns-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtxmlpatterns \
 "
