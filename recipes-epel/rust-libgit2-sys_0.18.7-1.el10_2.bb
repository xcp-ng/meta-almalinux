# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libgit2-sys"
PV = "0.18.7"
PR = "1.el10_2"
PACKAGES = " \
 rust-libgit2-sys+default-devel \
 rust-libgit2-sys+https-devel \
 rust-libgit2-sys+libssh2-sys-devel \
 rust-libgit2-sys+openssl-sys-devel \
 rust-libgit2-sys+ssh-devel \
 rust-libgit2-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libgit2-sys-0.18.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c8cc9c82a7c68d1d98e3cca3a41b6bd65f35aa1dc1c7ed3f38c53ded4e7ee9b"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - rust-libgit2-sys-devel: (pkgconfig(libgit2) >= 1.9.6 with pkgconfig(libgit2) < 1.10.0~)

URI_x86_64_v2_rust-libgit2-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys+default-devel-0.18.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys+default-devel.sha256sum] = "2927c64efc8245dff9ecd9941ba63eb7fbe2261234b6453242e22fa8bc6509f4"

URI_x86_64_v2_rust-libgit2-sys+https-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys+https-devel-0.18.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys+https-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys+https-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys+https-devel.sha256sum] = "9245e00aac4dd1e082bd08743dd9691253bd19013ec82ed1d09f554ef801451b"

URI_x86_64_v2_rust-libgit2-sys+libssh2-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys+libssh2-sys-devel-0.18.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys+libssh2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys+libssh2-sys-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys+libssh2-sys-devel.sha256sum] = "191bb98298f2c45d097585be7bf4fe0ba887842dee255fe7efe2cb1794d64f20"

URI_x86_64_v2_rust-libgit2-sys+openssl-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys+openssl-sys-devel-0.18.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys+openssl-sys-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys+openssl-sys-devel.sha256sum] = "6f276ff735c7968daa38f1870d187a24ef01e5689bf45b33c0f162bf5109ca1e"

URI_x86_64_v2_rust-libgit2-sys+ssh-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys+ssh-devel-0.18.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys+ssh-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys+ssh-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys+ssh-devel.sha256sum] = "f6dc073455d76f8b8ec098c879cf1d46769eafba012c971e74663625fd054f2e"

URI_x86_64_v2_rust-libgit2-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys-devel-0.18.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys-devel.sha256sum] = "d8ee2b4a5ad851b4c471e6e510b91d8d759e74c53376571b8fe7d2914985eddd"

URI_aarch64_rust-libgit2-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys+default-devel-0.18.7-1.el10_2.noarch.rpm;name=aarch64_rust-libgit2-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys+default-devel}"
SRC_URI[aarch64_rust-libgit2-sys+default-devel.sha256sum] = "88110ca91c85d09c108fbb8a98f68a190cb7706cc80273c06476b988d7323abd"

URI_aarch64_rust-libgit2-sys+https-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys+https-devel-0.18.7-1.el10_2.noarch.rpm;name=aarch64_rust-libgit2-sys+https-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys+https-devel}"
SRC_URI[aarch64_rust-libgit2-sys+https-devel.sha256sum] = "2d65fc7c1993fbb3637661fc31894cf17d15d78688f69a274d750bbf501a741e"

URI_aarch64_rust-libgit2-sys+libssh2-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys+libssh2-sys-devel-0.18.7-1.el10_2.noarch.rpm;name=aarch64_rust-libgit2-sys+libssh2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys+libssh2-sys-devel}"
SRC_URI[aarch64_rust-libgit2-sys+libssh2-sys-devel.sha256sum] = "845c6c13ba73da4efece7ab1152654d02517dbd2108e2e6f6e6aab180e1c8965"

URI_aarch64_rust-libgit2-sys+openssl-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys+openssl-sys-devel-0.18.7-1.el10_2.noarch.rpm;name=aarch64_rust-libgit2-sys+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys+openssl-sys-devel}"
SRC_URI[aarch64_rust-libgit2-sys+openssl-sys-devel.sha256sum] = "074fe352b32f71a1e4d97673d4945f903083008324d5c310a7b9a763e2f6cf7b"

URI_aarch64_rust-libgit2-sys+ssh-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys+ssh-devel-0.18.7-1.el10_2.noarch.rpm;name=aarch64_rust-libgit2-sys+ssh-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys+ssh-devel}"
SRC_URI[aarch64_rust-libgit2-sys+ssh-devel.sha256sum] = "3c56bc10045015f0848e290ff0c8ddb5991ea786b632b5c1e7858b6fae04bfc0"

URI_aarch64_rust-libgit2-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys-devel-0.18.7-1.el10_2.noarch.rpm;name=aarch64_rust-libgit2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys-devel}"
SRC_URI[aarch64_rust-libgit2-sys-devel.sha256sum] = "259490536ce00a4703e1cf046df7520d53bc809e9968c55717b84dca61fd0f60"

RDEPENDS:rust-libgit2-sys+default-devel = " \
 cargo \
 rust-libgit2-sys-devel \
 "
RDEPENDS:rust-libgit2-sys+https-devel = " \
 cargo \
 rust-libgit2-sys+openssl-sys-devel \
 rust-libgit2-sys-devel \
 "
RDEPENDS:rust-libgit2-sys+libssh2-sys-devel = " \
 cargo \
 rust-libgit2-sys-devel \
 rust-libssh2-sys+default-devel \
 "
RDEPENDS:rust-libgit2-sys+openssl-sys-devel = " \
 cargo \
 rust-libgit2-sys-devel \
 rust-openssl-sys+default-devel \
 "
RDEPENDS:rust-libgit2-sys+ssh-devel = " \
 cargo \
 rust-libgit2-sys+libssh2-sys-devel \
 rust-libgit2-sys-devel \
 "
RDEPENDS:rust-libgit2-sys-devel:x86_64_v2 = " \
 cargo \
 rust-cc+default-devel \
 rust-cc+parallel-devel \
 rust-libc+default-devel \
 rust-libz-sys+libc-devel \
 rust-libz-sys-devel \
 rust-pkg-config+default-devel \
"
RDEPENDS:rust-libgit2-sys-devel:aarch64 = " \
 cargo \
 libgit2_1.9-devel \
 rust-cc+default-devel \
 rust-cc+parallel-devel \
 rust-libc+default-devel \
 rust-libz-sys+libc-devel \
 rust-libz-sys-devel \
 rust-pkg-config+default-devel \
"
