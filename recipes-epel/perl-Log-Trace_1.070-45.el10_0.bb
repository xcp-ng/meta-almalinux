# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Log-Trace"
PV = "1.070"
PR = "45.el10_0"
PACKAGES = " \
 perl-Log-Trace \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Log-Trace-1.070-45.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27a2519fb67fa3af3dca9af18fcfc1062f07e0d25866e4f2903380ebae99c205"

URI_x86_64_v2_perl-Log-Trace = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Log-Trace-1.070-45.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Log-Trace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Log-Trace}"
SRC_URI[x86_64_v2_perl-Log-Trace.sha256sum] = "2ca8c15692d60c2097d8b1198f4dc673dcc42d5ed5827cb618d6f5789fc72e36"

URI_aarch64_perl-Log-Trace = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Log-Trace-1.070-45.el10_0.noarch.rpm;name=aarch64_perl-Log-Trace;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Log-Trace}"
SRC_URI[aarch64_perl-Log-Trace.sha256sum] = "3931ff4b6b60f03d8907e31f3692379f156d76b9180409d1b47431957228bc0d"

RDEPENDS:perl-Log-Trace = " \
 perl-Carp \
 perl-Fcntl \
 perl-libs \
 perl-vars \
 "
