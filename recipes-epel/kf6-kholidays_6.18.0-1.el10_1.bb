# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kholidays"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kholidays \
 kf6-kholidays-devel \
 kf6-kholidays-doc \
 kf6-kholidays-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kholidays-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a16d73ac816830415162c0228c64fae803834ce0dc7f9994addc10e460299a9d"

URI_x86_64_v2_kf6-kholidays = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kholidays-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kholidays;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kholidays}"
SRC_URI[x86_64_v2_kf6-kholidays.sha256sum] = "b9210594a7a7263baaac5de13931a93675901d24aae36da016fff7f0295381d6"

URI_x86_64_v2_kf6-kholidays-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kholidays-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kholidays-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kholidays-devel}"
SRC_URI[x86_64_v2_kf6-kholidays-devel.sha256sum] = "4b43992350627b611df3849c6de667417b7e5842174516b2e5425f34caabb345"

URI_x86_64_v2_kf6-kholidays-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kholidays-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kholidays-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kholidays-doc}"
SRC_URI[x86_64_v2_kf6-kholidays-doc.sha256sum] = "a18585793d6828e66fa315f69035ddf940f9e21980c3c51d306ec4c4650c7bad"

URI_x86_64_v2_kf6-kholidays-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kholidays-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kholidays-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kholidays-html}"
SRC_URI[x86_64_v2_kf6-kholidays-html.sha256sum] = "e50bee130cc8b17c8b406229a1c94df89658e386f5a0e774a47869529f1dc043"

URI_aarch64_kf6-kholidays = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kholidays-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kholidays;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kholidays}"
SRC_URI[aarch64_kf6-kholidays.sha256sum] = "c9ca501d17f915af5b320fe159ec592bfc3b177ad0edc89e6f68a9f78018efe2"

URI_aarch64_kf6-kholidays-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kholidays-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kholidays-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kholidays-devel}"
SRC_URI[aarch64_kf6-kholidays-devel.sha256sum] = "fc6ae211c23b89f4a9fc17f5884648cf97bc35ed63dee00a50c4af7fc2eca0d8"

URI_aarch64_kf6-kholidays-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kholidays-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kholidays-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kholidays-doc}"
SRC_URI[aarch64_kf6-kholidays-doc.sha256sum] = "eccadb7744cc0fa1430d2b363d71baf669deff59d681d0ebfc62c32b6b7f49b4"

URI_aarch64_kf6-kholidays-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kholidays-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kholidays-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kholidays-html}"
SRC_URI[aarch64_kf6-kholidays-html.sha256sum] = "78b87cb9c01206e847b0c28f80ffed5f2f2e2cfd5fb48e49fef9a05e59fabcb8"

RDEPENDS:kf6-kholidays = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kholidays-devel = " \
 cmake-filesystem \
 kf6-kholidays \
 "
RDEPENDS:kf6-kholidays-doc = " \
 "
RDEPENDS:kf6-kholidays-html = " \
 "
