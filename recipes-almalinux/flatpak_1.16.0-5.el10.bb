# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "flatpak"
PV = "1.16.0"
PR = "5.el10"
PACKAGES = " \
 flatpak \
 flatpak-devel \
 flatpak-libs \
 flatpak-selinux \
 flatpak-session-helper \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/flatpak-1.16.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55e294911c165f756f7be1731f0f3290f9f6aff8097eb7a1f2893cb664166fe9"

URI_x86_64_v2_flatpak = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/flatpak-1.16.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_flatpak;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flatpak}"
SRC_URI[x86_64_v2_flatpak.sha256sum] = "7787f0a62064f49afe9f7684ee4625d524ac9896634de24c252cdf4b08e2d885"

URI_x86_64_v2_flatpak-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/flatpak-devel-1.16.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_flatpak-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flatpak-devel}"
SRC_URI[x86_64_v2_flatpak-devel.sha256sum] = "21a3330c02644a06be2cafbfda6f12b182ab36d4656e68eb07f0d2be212cf7f8"

URI_x86_64_v2_flatpak-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/flatpak-libs-1.16.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_flatpak-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flatpak-libs}"
SRC_URI[x86_64_v2_flatpak-libs.sha256sum] = "2bda00819d730bd4df06ba525655f6dab38abbaad4b69891e23b369941094ac8"

URI_x86_64_v2_flatpak-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/flatpak-selinux-1.16.0-5.el10.noarch.rpm;name=x86_64_v2_flatpak-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flatpak-selinux}"
SRC_URI[x86_64_v2_flatpak-selinux.sha256sum] = "a6dc6492d0087c5dab9dc6a8613097f98f6eb5d3f2e525f9cf1579b62ddeeabf"

URI_x86_64_v2_flatpak-session-helper = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/flatpak-session-helper-1.16.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_flatpak-session-helper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flatpak-session-helper}"
SRC_URI[x86_64_v2_flatpak-session-helper.sha256sum] = "02c26682412ee49fda65134089401328e8e29892926c90e3463579675565210f"

URI_aarch64_flatpak = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/flatpak-1.16.0-5.el10.aarch64.rpm;name=aarch64_flatpak;unpack=0"
SRC_URI:append = " ${URI_aarch64_flatpak}"
SRC_URI[aarch64_flatpak.sha256sum] = "ab061289d54498d44f81157b7a074ac267dd068edaf1bcb25366763b08444959"

URI_aarch64_flatpak-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/flatpak-devel-1.16.0-5.el10.aarch64.rpm;name=aarch64_flatpak-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_flatpak-devel}"
SRC_URI[aarch64_flatpak-devel.sha256sum] = "2ac1a4c9e64dcc9d7453b5e87b2c47c347ade142d6374da14841a703a70b05da"

URI_aarch64_flatpak-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/flatpak-libs-1.16.0-5.el10.aarch64.rpm;name=aarch64_flatpak-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_flatpak-libs}"
SRC_URI[aarch64_flatpak-libs.sha256sum] = "221c750eda848d80f4dd5380abbf4914e53c3f9fda341ed60cd20ad30276626c"

URI_aarch64_flatpak-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/flatpak-selinux-1.16.0-5.el10.noarch.rpm;name=aarch64_flatpak-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_flatpak-selinux}"
SRC_URI[aarch64_flatpak-selinux.sha256sum] = "a6dc6492d0087c5dab9dc6a8613097f98f6eb5d3f2e525f9cf1579b62ddeeabf"

URI_aarch64_flatpak-session-helper = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/flatpak-session-helper-1.16.0-5.el10.aarch64.rpm;name=aarch64_flatpak-session-helper;unpack=0"
SRC_URI:append = " ${URI_aarch64_flatpak-session-helper}"
SRC_URI[aarch64_flatpak-session-helper.sha256sum] = "24274a1d99f774d90df44a633c0b3e929ec6ae70e3ac94123c2dd35efaafbd12"

RDEPENDS:flatpak:x86_64_v2 = " \
 appstream \
 bash \
 bubblewrap \
 dconf \
 flatpak-selinux \
 flatpak-session-helper \
 fuse3 \
 fuse3-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 json-glib \
 libXau \
 libarchive \
 libgcc \
 librsvg2 \
 libseccomp \
 libwayland-client \
 libxml2 \
 libzstd \
 ostree-libs \
 polkit-libs \
 python3 \
 shadow-utils \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_x86-64__ge_7.29.0 \
 xdg-dbus-proxy \
"
RDEPENDS:flatpak:aarch64 = " \
 appstream \
 bash \
 bubblewrap \
 dconf \
 flatpak-selinux \
 flatpak-session-helper \
 fuse3 \
 fuse3-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 json-glib \
 libXau \
 libarchive \
 libgcc \
 librsvg2 \
 libseccomp \
 libwayland-client \
 libxml2 \
 libzstd \
 ostree-libs \
 polkit-libs \
 python3 \
 shadow-utils \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_aarch-64__ge_7.29.0 \
 xdg-dbus-proxy \
"
RDEPENDS:flatpak-devel = " \
 dconf-devel \
 flatpak \
 flatpak-libs \
 glib2-devel \
 gpgme-devel \
 json-glib-devel \
 libXau-devel \
 libarchive-devel \
 libcurl-devel \
 libseccomp-devel \
 libxml2-devel \
 libzstd-devel \
 ostree-devel \
 pkgconf-pkg-config \
 polkit-devel \
 systemd-devel \
 wayland-devel \
 "
RDEPENDS:flatpak-libs = " \
 bubblewrap \
 dconf \
 glib2 \
 glibc \
 json-glib \
 libXau \
 libarchive \
 libgcc \
 libseccomp \
 libwayland-client \
 libxml2 \
 libzstd \
 ostree-libs \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:flatpak-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 "
RDEPENDS:flatpak-session-helper = " \
 glib2 \
 glibc \
 libgcc \
 systemd \
 "
