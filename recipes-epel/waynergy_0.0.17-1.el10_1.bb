# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "waynergy"
PV = "0.0.17"
PR = "1.el10_1"
PACKAGES = " \
 waynergy \
 waynergy-kde \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/waynergy-0.0.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cca89c8055bcc03e66150c84d29b02c7e81ce43da9e0c9eafa3ddec003bcc2d1"

URI_x86_64_v2_waynergy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/waynergy-0.0.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_waynergy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_waynergy}"
SRC_URI[x86_64_v2_waynergy.sha256sum] = "1d3bd7a560261a8612bcefdd49905bc83e9072c2bf92cac52cb75a8bcfce8536"

URI_x86_64_v2_waynergy-kde = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/waynergy-kde-0.0.17-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_waynergy-kde;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_waynergy-kde}"
SRC_URI[x86_64_v2_waynergy-kde.sha256sum] = "b7d6039cf6c205e0c34f4cf46fefd58d72978cdee6b67d56b6c45831b5821377"

URI_aarch64_waynergy = "${EPEL_MIRROR}/aarch64/Packages/w/waynergy-0.0.17-1.el10_1.aarch64.rpm;name=aarch64_waynergy;unpack=0"
SRC_URI:append = " ${URI_aarch64_waynergy}"
SRC_URI[aarch64_waynergy.sha256sum] = "d7630510d7907c00ade5e3ab47fc9c54f819e7a234e9ee1abaa73977501dc66d"

URI_aarch64_waynergy-kde = "${EPEL_MIRROR}/aarch64/Packages/w/waynergy-kde-0.0.17-1.el10_1.noarch.rpm;name=aarch64_waynergy-kde;unpack=0"
SRC_URI:append = " ${URI_aarch64_waynergy-kde}"
SRC_URI[aarch64_waynergy-kde.sha256sum] = "a4037dff8c03033fea59544e4454acffc6a3efa9a2cc0f92d26ae5cfaca9c96b"

RDEPENDS:waynergy = " \
 glibc \
 libretls \
 libwayland-client \
 libxkbcommon \
 wl-clipboard \
 "
RDEPENDS:waynergy-kde = " \
 waynergy \
 "
