# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-oslo-utils"
PV = "10.0.1"
PR = "1.el10_2"
PACKAGES = " \
 python-oslo-utils-doc \
 python-oslo-utils-lang \
 python3-oslo-utils \
 python3-oslo-utils-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-oslo-utils-10.0.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed691e9c8fe16b5c747c5cb4801d52bd37ccd86e5f1713cbd30b6278ab5a3211"

URI_x86_64_v2_python-oslo-utils-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-oslo-utils-doc-10.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-oslo-utils-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-oslo-utils-doc}"
SRC_URI[x86_64_v2_python-oslo-utils-doc.sha256sum] = "dce89d017fd7e7e13ef15665e0e542fe9af90193f6e24d2984c433cf9ba5a0df"

URI_x86_64_v2_python-oslo-utils-lang = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-oslo-utils-lang-10.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-oslo-utils-lang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-oslo-utils-lang}"
SRC_URI[x86_64_v2_python-oslo-utils-lang.sha256sum] = "248b15d5e8228685d6fee2f9c9770ceb34e42e45d86fc0b60f664702df91ea7a"

URI_x86_64_v2_python3-oslo-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-oslo-utils-10.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-oslo-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-oslo-utils}"
SRC_URI[x86_64_v2_python3-oslo-utils.sha256sum] = "e412d99f961f380e50f1df7e75a28f2ef2b9c7455268c4c0d6b42217d3f101f5"

URI_x86_64_v2_python3-oslo-utils-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-oslo-utils-tests-10.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-oslo-utils-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-oslo-utils-tests}"
SRC_URI[x86_64_v2_python3-oslo-utils-tests.sha256sum] = "fc32562461ff8722f64fe44995907694079c95827edb7c0df9f241fe56b2331f"

URI_aarch64_python-oslo-utils-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-oslo-utils-doc-10.0.1-1.el10_2.noarch.rpm;name=aarch64_python-oslo-utils-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-oslo-utils-doc}"
SRC_URI[aarch64_python-oslo-utils-doc.sha256sum] = "bd4927b6570999dafe0a533bd9f438dc06f452b699ddb4891306dab98621d95e"

URI_aarch64_python-oslo-utils-lang = "${EPEL_MIRROR}/aarch64/Packages/p/python-oslo-utils-lang-10.0.1-1.el10_2.noarch.rpm;name=aarch64_python-oslo-utils-lang;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-oslo-utils-lang}"
SRC_URI[aarch64_python-oslo-utils-lang.sha256sum] = "bed8eddf003915c527b2f7962b26c27c451a8437b73ce871bd7c6516cafa5554"

URI_aarch64_python3-oslo-utils = "${EPEL_MIRROR}/aarch64/Packages/p/python3-oslo-utils-10.0.1-1.el10_2.noarch.rpm;name=aarch64_python3-oslo-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-oslo-utils}"
SRC_URI[aarch64_python3-oslo-utils.sha256sum] = "3768c7ee6ec85a43643db2a31a2cc3bcd364d71defaceeeec23961db375ce49c"

URI_aarch64_python3-oslo-utils-tests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-oslo-utils-tests-10.0.1-1.el10_2.noarch.rpm;name=aarch64_python3-oslo-utils-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-oslo-utils-tests}"
SRC_URI[aarch64_python3-oslo-utils-tests.sha256sum] = "9ed9889953d6bed984840ced05d54143054a220c9b8d135ebc35fbae4beb6f9a"

RDEPENDS:python-oslo-utils-doc = " \
 "
RDEPENDS:python-oslo-utils-lang = " \
 "
RDEPENDS:python3-oslo-utils = " \
 python-oslo-utils-lang \
 python3 \
 python3-debtcollector \
 python3-iso8601 \
 python3-netaddr \
 python3-oslo-i18n \
 python3-packaging \
 python3-pbr \
 python3-psutil \
 python3-pyparsing \
 python3-pyyaml \
 "
RDEPENDS:python3-oslo-utils-tests = " \
 python3 \
 python3-oslo-utils \
 "
