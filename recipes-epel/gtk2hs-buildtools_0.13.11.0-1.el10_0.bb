# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gtk2hs-buildtools"
PV = "0.13.11.0"
PR = "1.el10_0"
PACKAGES = " \
 ghc-gtk2hs-buildtools \
 ghc-gtk2hs-buildtools-devel \
 ghc-gtk2hs-buildtools-doc \
 ghc-gtk2hs-buildtools-prof \
 gtk2hs-buildtools \
 gtk2hs-buildtools-common \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gtk2hs-buildtools-0.13.11.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "735be1c5074a6121bb52cfc3ecc3765702c0ccac45a9532163c0961f5e429732"

URI_x86_64_v2_ghc-gtk2hs-buildtools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-gtk2hs-buildtools-0.13.11.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-gtk2hs-buildtools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-gtk2hs-buildtools}"
SRC_URI[x86_64_v2_ghc-gtk2hs-buildtools.sha256sum] = "2ab89a5dfc8a12456ce858ac6195312c148fff3eb02146369e28acb996d102ac"

URI_x86_64_v2_ghc-gtk2hs-buildtools-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-gtk2hs-buildtools-devel-0.13.11.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-gtk2hs-buildtools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-gtk2hs-buildtools-devel}"
SRC_URI[x86_64_v2_ghc-gtk2hs-buildtools-devel.sha256sum] = "0ff697f217929eca4ce9113c0c4f2fbcd3a964ee5c04cf053219531a693244b9"

URI_x86_64_v2_ghc-gtk2hs-buildtools-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-gtk2hs-buildtools-doc-0.13.11.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-gtk2hs-buildtools-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-gtk2hs-buildtools-doc}"
SRC_URI[x86_64_v2_ghc-gtk2hs-buildtools-doc.sha256sum] = "f598315831c4d09ec7651303def6f8634cc40acd211e76d2e14ce8eaeb97b2ef"

URI_x86_64_v2_ghc-gtk2hs-buildtools-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-gtk2hs-buildtools-prof-0.13.11.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-gtk2hs-buildtools-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-gtk2hs-buildtools-prof}"
SRC_URI[x86_64_v2_ghc-gtk2hs-buildtools-prof.sha256sum] = "ffd5ea073d386a88023125e9f6cfe20a5ff1c56e716296e317dd48e1c8017446"

URI_x86_64_v2_gtk2hs-buildtools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gtk2hs-buildtools-0.13.11.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gtk2hs-buildtools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtk2hs-buildtools}"
SRC_URI[x86_64_v2_gtk2hs-buildtools.sha256sum] = "2e3ce009a513a3eefb1775562a5a64b6c496148022bb7d9099fe86565a1665d7"

URI_x86_64_v2_gtk2hs-buildtools-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gtk2hs-buildtools-common-0.13.11.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gtk2hs-buildtools-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtk2hs-buildtools-common}"
SRC_URI[x86_64_v2_gtk2hs-buildtools-common.sha256sum] = "6920cd25babf7e824c9031e6f00cc16502ffdd788528a78eed115b54c1c73188"

URI_aarch64_ghc-gtk2hs-buildtools = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-gtk2hs-buildtools-0.13.11.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-gtk2hs-buildtools;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-gtk2hs-buildtools}"
SRC_URI[aarch64_ghc-gtk2hs-buildtools.sha256sum] = "40c6dfa065ddd1380e821335ca6f06c5a09cf34407bcd055a8c357b05c6e3bf2"

URI_aarch64_ghc-gtk2hs-buildtools-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-gtk2hs-buildtools-devel-0.13.11.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-gtk2hs-buildtools-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-gtk2hs-buildtools-devel}"
SRC_URI[aarch64_ghc-gtk2hs-buildtools-devel.sha256sum] = "776c8f73da6fd1f6ddf7f6ef7dd4d89e5ea3ddb6188d8e6f63a1b069bf4aace9"

URI_aarch64_ghc-gtk2hs-buildtools-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-gtk2hs-buildtools-doc-0.13.11.0-1.el10_0.noarch.rpm;name=aarch64_ghc-gtk2hs-buildtools-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-gtk2hs-buildtools-doc}"
SRC_URI[aarch64_ghc-gtk2hs-buildtools-doc.sha256sum] = "c75059476e7917a48a674ac61ef3de9a80d7a11be882b80c11d6a2c2158c2807"

URI_aarch64_ghc-gtk2hs-buildtools-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-gtk2hs-buildtools-prof-0.13.11.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-gtk2hs-buildtools-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-gtk2hs-buildtools-prof}"
SRC_URI[aarch64_ghc-gtk2hs-buildtools-prof.sha256sum] = "0d1c68b03f23cf8ce2007229eb1bba90b64aed71269a32100e223489346750e5"

URI_aarch64_gtk2hs-buildtools = "${EPEL_MIRROR}/aarch64/Packages/g/gtk2hs-buildtools-0.13.11.0-1.el10_0.aarch64.rpm;name=aarch64_gtk2hs-buildtools;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtk2hs-buildtools}"
SRC_URI[aarch64_gtk2hs-buildtools.sha256sum] = "e51d9f11d1937c1d5cd936125cb3bc98c4166837d867960cd9a71b0ae5c30f8d"

URI_aarch64_gtk2hs-buildtools-common = "${EPEL_MIRROR}/aarch64/Packages/g/gtk2hs-buildtools-common-0.13.11.0-1.el10_0.noarch.rpm;name=aarch64_gtk2hs-buildtools-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtk2hs-buildtools-common}"
SRC_URI[aarch64_gtk2hs-buildtools-common.sha256sum] = "447de91a544ce848f7cd2d3a28467e0ce14b6c62a327e844601f9a0bf208c643"

RDEPENDS:ghc-gtk2hs-buildtools = " \
 ghc-Cabal \
 ghc-Cabal-syntax \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hashtables \
 ghc-mtl \
 ghc-os-string \
 ghc-parsec \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-splitmix \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 ghc-vector \
 ghc-vector-stream \
 glibc \
 gmp \
 gtk2hs-buildtools-common \
 "
RDEPENDS:ghc-gtk2hs-buildtools-devel = " \
 ghc-Cabal-devel \
 ghc-array-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-directory-devel \
 ghc-filepath-devel \
 ghc-gtk2hs-buildtools \
 ghc-hashtables-devel \
 ghc-pretty-devel \
 ghc-process-devel \
 ghc-random-devel \
 "
RDEPENDS:ghc-gtk2hs-buildtools-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-gtk2hs-buildtools-prof = " \
 ghc-Cabal-prof \
 ghc-array-prof \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-directory-prof \
 ghc-filepath-prof \
 ghc-gtk2hs-buildtools-devel \
 ghc-hashtables-prof \
 ghc-pretty-prof \
 ghc-process-prof \
 ghc-random-prof \
 "
RDEPENDS:gtk2hs-buildtools = " \
 glibc \
 gmp \
 gtk2hs-buildtools-common \
 libffi \
 "
RDEPENDS:gtk2hs-buildtools-common = " \
 "
