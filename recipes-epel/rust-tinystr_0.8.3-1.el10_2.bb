# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tinystr"
PV = "0.8.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-tinystr+alloc-devel \
 rust-tinystr+databake-devel \
 rust-tinystr+default-devel \
 rust-tinystr+serde-devel \
 rust-tinystr+std-devel \
 rust-tinystr+zerovec-devel \
 rust-tinystr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tinystr-0.8.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c5ef2e40a4d215d0a7f0d422362991ba47eb0ec527a6a35f6a1125c626b39b77"

URI_x86_64_v2_rust-tinystr+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr+alloc-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinystr+alloc-devel}"
SRC_URI[x86_64_v2_rust-tinystr+alloc-devel.sha256sum] = "0fca6ea6d9ab798b9cbe55b6c9f5a41f40204f8d498ea35cdceb80c480103379"

URI_x86_64_v2_rust-tinystr+databake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr+databake-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr+databake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinystr+databake-devel}"
SRC_URI[x86_64_v2_rust-tinystr+databake-devel.sha256sum] = "1b2ddb4854d0728af1819d5d2dbc85bae7ea3e6c7e0cfe1a78eba10378b85cef"

URI_x86_64_v2_rust-tinystr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr+default-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinystr+default-devel}"
SRC_URI[x86_64_v2_rust-tinystr+default-devel.sha256sum] = "324abe39c39c6e8eec98180df1ab6f8b1e0da8c6d9a2c208d6698143cadb12d9"

URI_x86_64_v2_rust-tinystr+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr+serde-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinystr+serde-devel}"
SRC_URI[x86_64_v2_rust-tinystr+serde-devel.sha256sum] = "6b6e275cce7ec3c93a8ecbda1054a7b77e1117c23c3f78c51f9144c5a81af78a"

URI_x86_64_v2_rust-tinystr+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr+std-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinystr+std-devel}"
SRC_URI[x86_64_v2_rust-tinystr+std-devel.sha256sum] = "3d5971734f810a9908ad8da4e71f1c9b63dc17cc6735155d86ca51a5ebcc888c"

URI_x86_64_v2_rust-tinystr+zerovec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr+zerovec-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr+zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinystr+zerovec-devel}"
SRC_URI[x86_64_v2_rust-tinystr+zerovec-devel.sha256sum] = "a006e66e1913b0aec69cd5ce48aadf500131213ca1f7a984c92e393b56bba614"

URI_x86_64_v2_rust-tinystr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinystr-devel}"
SRC_URI[x86_64_v2_rust-tinystr-devel.sha256sum] = "70a2e4f068518ccc417482c632bc9ebb8800836e67b0ddad75c776769c058821"

URI_aarch64_rust-tinystr+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr+alloc-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-tinystr+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinystr+alloc-devel}"
SRC_URI[aarch64_rust-tinystr+alloc-devel.sha256sum] = "017692b6927f91e33a09e329cbac5fb9d48c629297e83e90f5b69b20ea88b9b9"

URI_aarch64_rust-tinystr+databake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr+databake-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-tinystr+databake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinystr+databake-devel}"
SRC_URI[aarch64_rust-tinystr+databake-devel.sha256sum] = "2f1b2fcf2422962ff632a33426d490d94037bbe353fce54b668266af2c36544b"

URI_aarch64_rust-tinystr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr+default-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-tinystr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinystr+default-devel}"
SRC_URI[aarch64_rust-tinystr+default-devel.sha256sum] = "61657c7fda2eb1246e9ab46b1226ffc1288d9aef4b0fcd4e57d7bcbe63a7af44"

URI_aarch64_rust-tinystr+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr+serde-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-tinystr+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinystr+serde-devel}"
SRC_URI[aarch64_rust-tinystr+serde-devel.sha256sum] = "189a0cd3e68b7766f72f80f2c360f7f0c99935fbfbcb723273a9ff66bde63e20"

URI_aarch64_rust-tinystr+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr+std-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-tinystr+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinystr+std-devel}"
SRC_URI[aarch64_rust-tinystr+std-devel.sha256sum] = "cd15711d1bb1b9587d7c5f6071881236f3fdbcc1cc5e52f7e7888c3d072c3117"

URI_aarch64_rust-tinystr+zerovec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr+zerovec-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-tinystr+zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinystr+zerovec-devel}"
SRC_URI[aarch64_rust-tinystr+zerovec-devel.sha256sum] = "eaa26dc024c7bc82961bd8589cb658ead8fffae5f4768dc6845913b89078592e"

URI_aarch64_rust-tinystr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-tinystr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinystr-devel}"
SRC_URI[aarch64_rust-tinystr-devel.sha256sum] = "2fd9e933107965ee4915929263ad31216deb42a437794102f11ee1209a9d8e5c"

RDEPENDS:rust-tinystr+alloc-devel = " \
 cargo \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 rust-tinystr-devel \
 rust-zerovec+alloc-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-tinystr+databake-devel = " \
 cargo \
 rust-databake-devel \
 rust-tinystr-devel \
 "
RDEPENDS:rust-tinystr+default-devel = " \
 cargo \
 rust-tinystr+alloc-devel \
 rust-tinystr-devel \
 "
RDEPENDS:rust-tinystr+serde-devel = " \
 cargo \
 rust-serde_core-devel \
 rust-tinystr-devel \
 "
RDEPENDS:rust-tinystr+std-devel = " \
 cargo \
 rust-tinystr-devel \
 "
RDEPENDS:rust-tinystr+zerovec-devel = " \
 cargo \
 rust-tinystr-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-tinystr-devel = " \
 cargo \
 rust \
 rust-displaydoc-devel \
 "
