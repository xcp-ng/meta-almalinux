# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-xml-hamlet"
PV = "0.5.0.2"
PR = "9.el10_0"
PACKAGES = " \
 ghc-xml-hamlet \
 ghc-xml-hamlet-devel \
 ghc-xml-hamlet-doc \
 ghc-xml-hamlet-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-xml-hamlet-0.5.0.2-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6839a941a4fd55b299d70434a038517bc58d703e840518f4fdeab529ed61cf40"

URI_x86_64_v2_ghc-xml-hamlet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-xml-hamlet-0.5.0.2-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-xml-hamlet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-xml-hamlet}"
SRC_URI[x86_64_v2_ghc-xml-hamlet.sha256sum] = "24574b272597a4b6353b77adb1f74912167c509adfcf890f3a6c8aa35fb6ec65"

URI_x86_64_v2_ghc-xml-hamlet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-xml-hamlet-devel-0.5.0.2-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-xml-hamlet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-xml-hamlet-devel}"
SRC_URI[x86_64_v2_ghc-xml-hamlet-devel.sha256sum] = "42f32e67e87d19e7e1f32ec6b796a393cda6e21dc6031254841d472931a68f26"

URI_x86_64_v2_ghc-xml-hamlet-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-xml-hamlet-doc-0.5.0.2-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-xml-hamlet-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-xml-hamlet-doc}"
SRC_URI[x86_64_v2_ghc-xml-hamlet-doc.sha256sum] = "82c8793ec2d8f869f7066889f2c89b6ace0f404f13d5c1839cb09d72be5057ea"

URI_x86_64_v2_ghc-xml-hamlet-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-xml-hamlet-prof-0.5.0.2-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-xml-hamlet-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-xml-hamlet-prof}"
SRC_URI[x86_64_v2_ghc-xml-hamlet-prof.sha256sum] = "fe86e022281aab851e1a32087d96c15b075f79ae314116cd3d0142ae5e80ca8f"

URI_aarch64_ghc-xml-hamlet = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-xml-hamlet-0.5.0.2-9.el10_0.aarch64.rpm;name=aarch64_ghc-xml-hamlet;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-xml-hamlet}"
SRC_URI[aarch64_ghc-xml-hamlet.sha256sum] = "a2626b31f603d62b14b1be2586eb2c5a82ff4fb94a8649c3637d0d5279d94ffb"

URI_aarch64_ghc-xml-hamlet-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-xml-hamlet-devel-0.5.0.2-9.el10_0.aarch64.rpm;name=aarch64_ghc-xml-hamlet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-xml-hamlet-devel}"
SRC_URI[aarch64_ghc-xml-hamlet-devel.sha256sum] = "caad201ad506708630b498a3330ab58239dfe88082478d2ff5775bc69420d3ca"

URI_aarch64_ghc-xml-hamlet-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-xml-hamlet-doc-0.5.0.2-9.el10_0.noarch.rpm;name=aarch64_ghc-xml-hamlet-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-xml-hamlet-doc}"
SRC_URI[aarch64_ghc-xml-hamlet-doc.sha256sum] = "a4ca5a564d0e817680b5756ca2994c46566cc0f4fa20d24766e528c3a729188e"

URI_aarch64_ghc-xml-hamlet-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-xml-hamlet-prof-0.5.0.2-9.el10_0.aarch64.rpm;name=aarch64_ghc-xml-hamlet-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-xml-hamlet-prof}"
SRC_URI[aarch64_ghc-xml-hamlet-prof.sha256sum] = "a3e2c90e5707e8cc991739185fd40d0890d8ed17070cd7cfb64bab5e009e65f3"

RDEPENDS:ghc-xml-hamlet = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-array \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-bytestring \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-file-embed \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-os-string \
 ghc-parsec \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-resourcet \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-shakespeare \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-lift \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-unix \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-witherable \
 ghc-xml-conduit \
 ghc-xml-types \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-xml-hamlet-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-parsec-devel \
 ghc-shakespeare-devel \
 ghc-template-haskell-devel \
 ghc-text-devel \
 ghc-xml-conduit-devel \
 ghc-xml-hamlet \
 "
RDEPENDS:ghc-xml-hamlet-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-xml-hamlet-prof = " \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-parsec-prof \
 ghc-shakespeare-prof \
 ghc-template-haskell-prof \
 ghc-text-prof \
 ghc-xml-conduit-prof \
 ghc-xml-hamlet-devel \
 "
