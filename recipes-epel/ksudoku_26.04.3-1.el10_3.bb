# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksudoku"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 ksudoku \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ksudoku-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ef0063b81edc61fd0cad22fa252899378cedb19463170a6655c8d78351d19fbb"

URI_x86_64_v2_ksudoku = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksudoku-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksudoku;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksudoku}"
SRC_URI[x86_64_v2_ksudoku.sha256sum] = "a92071ed2bf48f72ea3a53ea2d7d7119bdae19a9161269f2e2c2de19fea20acb"

URI_aarch64_ksudoku = "${EPEL_MIRROR}/aarch64/Packages/k/ksudoku-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_ksudoku;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksudoku}"
SRC_URI[aarch64_ksudoku.sha256sum] = "4ba97682f00b526966d30047275f05002a3794592f410f3378ae9ee883041cb5"

RDEPENDS:ksudoku = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libglvnd-opengl \
 libkdegames \
 libstdc++ \
 mesa-libGLU \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
