# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "weechat"
PV = "4.10.1"
PR = "2.el10_3"
PACKAGES = " \
 weechat \
 weechat-devel \
 weechat-php \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/w/weechat-4.10.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e5c46ef2f970c62d054c4e12c5d31dca674838da5017a30d9ff7931578d35c7e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/weechat-4.10.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_weechat;unpack=0"
SRC_URI[x86_64_v2_weechat.sha256sum] = "a7f79d8fd6d3dfd8fb98d454f178214c971f1eaba782321482d13bd2641bed0f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/weechat-devel-4.10.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_weechat-devel;unpack=0"
SRC_URI[x86_64_v2_weechat-devel.sha256sum] = "e42cd52a89e653b7a026d9b130a9d3e63000079ec12009f33185acd256919588"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/weechat-php-4.10.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_weechat-php;unpack=0"
SRC_URI[x86_64_v2_weechat-php.sha256sum] = "f7ac6602ce59d8031d719737f7f53999b27596cf0e182e9cc5a28f2064c1b54c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/weechat-4.10.1-2.el10_3.aarch64.rpm;name=aarch64_weechat;unpack=0"
SRC_URI[aarch64_weechat.sha256sum] = "4c4956733a48284bcab51d621cbbb0f4796230b8bfd9b1bbabda2578d64d3868"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/weechat-devel-4.10.1-2.el10_3.aarch64.rpm;name=aarch64_weechat-devel;unpack=0"
SRC_URI[aarch64_weechat-devel.sha256sum] = "9f91a69e3e88e840fc0e90e6949720705116235bf21bc127287eaa80693bc191"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/weechat-php-4.10.1-2.el10_3.aarch64.rpm;name=aarch64_weechat-php;unpack=0"
SRC_URI[aarch64_weechat-php.sha256sum] = "f050db5f6be4dcb4caa63c716a661ac0aaa651836e393e20c7e34fe9c87ecdf5"

RDEPENDS:weechat = " \
 cjson \
 enchant2 \
 glibc \
 gnutls \
 guile30 \
 hicolor-icon-theme \
 libgcc \
 libgcrypt \
 libzstd \
 lua-libs \
 ncurses-libs \
 perl-libs \
 python3-libs \
 ruby-libs \
 tcl \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:weechat-devel = " \
 pkgconf-pkg-config \
 weechat \
 "
RDEPENDS:weechat-php:x86_64_v2 = " \
 glibc \
 php-embedded \
 weechat \
"
RDEPENDS:weechat-php:aarch64 = " \
 glibc \
 php8.4-embedded \
 weechat \
"
