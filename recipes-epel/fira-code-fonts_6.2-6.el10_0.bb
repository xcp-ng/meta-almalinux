# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fira-code-fonts"
PV = "6.2"
PR = "6.el10_0"
PACKAGES = " \
 fira-code-fonts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fira-code-fonts-6.2-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa2898e0d8e5461553c5b0fce15b8e21a16da6ee2e58ce7b28e3277e74421906"

URI_x86_64_v2_fira-code-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fira-code-fonts-6.2-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fira-code-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fira-code-fonts}"
SRC_URI[x86_64_v2_fira-code-fonts.sha256sum] = "8508ed44536d295611eb36460f1ff8ba893eee57261828bb369d6e3f725bf8ed"

URI_aarch64_fira-code-fonts = "${EPEL_MIRROR}/aarch64/Packages/f/fira-code-fonts-6.2-6.el10_0.noarch.rpm;name=aarch64_fira-code-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_fira-code-fonts}"
SRC_URI[aarch64_fira-code-fonts.sha256sum] = "c1e68da9af43cb29720307f929b1d1072acddcbf7a4c4c2b8700807220a853d0"

RDEPENDS:fira-code-fonts = " \
 fonts-filesystem \
 "
