# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "stockfish"
PV = "17.1"
PR = "1.el10_0"
PACKAGES = " \
 stockfish \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/stockfish-17.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19af73780059c28a3191f6867aa80c701ec73bc0d91b2c9cbeacb3269fc1ecc8"

URI_x86_64_v2_stockfish = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stockfish-17.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stockfish;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stockfish}"
SRC_URI[x86_64_v2_stockfish.sha256sum] = "a9d1bca992493c25eac563c41f77e1c72424cd0e739fea1eee0e0d69f38d0453"

URI_aarch64_stockfish = "${EPEL_MIRROR}/aarch64/Packages/s/stockfish-17.1-1.el10_0.aarch64.rpm;name=aarch64_stockfish;unpack=0"
SRC_URI:append = " ${URI_aarch64_stockfish}"
SRC_URI[aarch64_stockfish.sha256sum] = "89c1e61ac77b179cd8bd8ce97b71f54b80f7d6c403973f4546f8f154f7582fc5"

RDEPENDS:stockfish = " \
 glibc \
 libgcc \
 libstdc++ \
 "
