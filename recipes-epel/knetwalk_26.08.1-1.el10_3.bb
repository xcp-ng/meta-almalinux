# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "knetwalk"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 knetwalk \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/knetwalk-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ceb38e4f56fda352d7791d2134613af371ed5740f82c8e8210bb1484aba2dec8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knetwalk-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knetwalk;unpack=0"
SRC_URI[x86_64_v2_knetwalk.sha256sum] = "13c115e4b76aeac0b2d6aff196c0fea946470265de838906550f7b56bebc83e1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/knetwalk-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_knetwalk;unpack=0"
SRC_URI[aarch64_knetwalk.sha256sum] = "2d6e0c98f76ea0890df65406967e09847921501e42f13be7f94d8a5cdff38b73"

RDEPENDS:knetwalk = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
