# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansible-collection-ansible-utils"
PV = "6.0.1"
PR = "1.el10_1"
PACKAGES = " \
 ansible-collection-ansible-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/ansible-collection-ansible-utils-6.0.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09b8768a0215cc9e030898138b0e7b0e43648c225106f4ecb564ff5dbdff0c3b"

URI_x86_64_v2_ansible-collection-ansible-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ansible-collection-ansible-utils-6.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ansible-collection-ansible-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-collection-ansible-utils}"
SRC_URI[x86_64_v2_ansible-collection-ansible-utils.sha256sum] = "476b02f291be324d873b4f50343d51f4b4a101f8f7249e8d1639953670975973"

URI_aarch64_ansible-collection-ansible-utils = "${EPEL_MIRROR}/aarch64/Packages/a/ansible-collection-ansible-utils-6.0.1-1.el10_1.noarch.rpm;name=aarch64_ansible-collection-ansible-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-collection-ansible-utils}"
SRC_URI[aarch64_ansible-collection-ansible-utils.sha256sum] = "c3271f37e63697b85902ded3a8e48b26424a8d1e380a9e94292cdf6886700f39"

RDEPENDS:ansible-collection-ansible-utils = " \
 ansible-core \
 "
