# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkleo"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 libkleo \
 libkleo-devel \
 libkleo-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkleo-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3cc2f957796d6d401ac5eb701a1219ba4feaf8c6bf13adc0dd41b13e0971ee8"

URI_x86_64_v2_libkleo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkleo-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkleo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkleo}"
SRC_URI[x86_64_v2_libkleo.sha256sum] = "c826284b1861b3547c22514df920d6790ecba2727f99e4dbb37c6c45cdbf1727"

URI_x86_64_v2_libkleo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkleo-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkleo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkleo-devel}"
SRC_URI[x86_64_v2_libkleo-devel.sha256sum] = "1ea8bd827b492968ab1fc73e6ac3ebfb580149164d6120e59bc32fa16f6a3dd7"

URI_x86_64_v2_libkleo-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkleo-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_libkleo-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkleo-doc}"
SRC_URI[x86_64_v2_libkleo-doc.sha256sum] = "8cdbb0b587a369a359bc174a0af6aa123ad97d86619027c6e8bd631d308a35ae"

URI_aarch64_libkleo = "${EPEL_MIRROR}/aarch64/Packages/l/libkleo-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_libkleo;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkleo}"
SRC_URI[aarch64_libkleo.sha256sum] = "8b33265f8d8f9b54bca81c2ea3de427ae14a0952d95b0b078878b1dee8bc61af"

URI_aarch64_libkleo-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkleo-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_libkleo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkleo-devel}"
SRC_URI[aarch64_libkleo-devel.sha256sum] = "56d239990dcea572415a3f72d1033c26f34181419ffb70c94e78a522b0f1f5c3"

URI_aarch64_libkleo-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libkleo-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_libkleo-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkleo-doc}"
SRC_URI[aarch64_libkleo-doc.sha256sum] = "dc30450ef641a6061f4caee913f815222328366aba5e691fdb7399a64bd27791"

RDEPENDS:libkleo = " \
 glibc \
 gpgmepp \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kitemmodels \
 kf6-kwidgetsaddons \
 libgcc \
 libstdc++ \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkleo-devel = " \
 cmake-filesystem \
 gpgmepp-devel \
 libkleo \
 qgpgme-qt6-devel \
 "
RDEPENDS:libkleo-doc = " \
 "
