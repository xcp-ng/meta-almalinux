# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bumpalo"
PV = "3.19.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-bumpalo+allocator-api2-devel \
 rust-bumpalo+allocator_api-devel \
 rust-bumpalo+boxed-devel \
 rust-bumpalo+collections-devel \
 rust-bumpalo+default-devel \
 rust-bumpalo+serde-devel \
 rust-bumpalo+std-devel \
 rust-bumpalo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bumpalo-3.19.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa403315632cca4d8341a01042950f1fc12875657c1cefd3eb4072cda89b3973"

URI_x86_64_v2_rust-bumpalo+allocator-api2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bumpalo+allocator-api2-devel-3.19.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bumpalo+allocator-api2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bumpalo+allocator-api2-devel}"
SRC_URI[x86_64_v2_rust-bumpalo+allocator-api2-devel.sha256sum] = "a3d380477c9605745e860f405949ba4a8b5e1b5761e595275e846f3682b48eda"

URI_x86_64_v2_rust-bumpalo+allocator_api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bumpalo+allocator_api-devel-3.19.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bumpalo+allocator_api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bumpalo+allocator_api-devel}"
SRC_URI[x86_64_v2_rust-bumpalo+allocator_api-devel.sha256sum] = "e5e7ac4a72902a0c3e5925034e5fc3dc531ed937225e726da768f1e51f057915"

URI_x86_64_v2_rust-bumpalo+boxed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bumpalo+boxed-devel-3.19.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bumpalo+boxed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bumpalo+boxed-devel}"
SRC_URI[x86_64_v2_rust-bumpalo+boxed-devel.sha256sum] = "feec4b6487cb079f7ca2dee974ee17820bf09befab035c8b5d3c26c66692de82"

URI_x86_64_v2_rust-bumpalo+collections-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bumpalo+collections-devel-3.19.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bumpalo+collections-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bumpalo+collections-devel}"
SRC_URI[x86_64_v2_rust-bumpalo+collections-devel.sha256sum] = "cbb21bc9d20b9211db572c4034670a4889d29f64b71d684242c781db7330c5de"

URI_x86_64_v2_rust-bumpalo+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bumpalo+default-devel-3.19.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bumpalo+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bumpalo+default-devel}"
SRC_URI[x86_64_v2_rust-bumpalo+default-devel.sha256sum] = "2751f72ccbb9fb37c28ef201cb9acb14a0bbd49d1b66eb9d43425cbd88a16ea3"

URI_x86_64_v2_rust-bumpalo+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bumpalo+serde-devel-3.19.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bumpalo+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bumpalo+serde-devel}"
SRC_URI[x86_64_v2_rust-bumpalo+serde-devel.sha256sum] = "c5b6d9c111482288893d971abd4187270106850effea64aa3f0768c0455f3960"

URI_x86_64_v2_rust-bumpalo+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bumpalo+std-devel-3.19.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bumpalo+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bumpalo+std-devel}"
SRC_URI[x86_64_v2_rust-bumpalo+std-devel.sha256sum] = "34a030a29d970ce08436bbf2b4b5f27c0ad69fc54b8d18e216c4d540e2fb8d41"

URI_x86_64_v2_rust-bumpalo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bumpalo-devel-3.19.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bumpalo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bumpalo-devel}"
SRC_URI[x86_64_v2_rust-bumpalo-devel.sha256sum] = "ee95b6e6e1df6dd8fd7e1719ebb1327d2d0bb5d8700466fed64f6b5a0e900e94"

URI_aarch64_rust-bumpalo+allocator-api2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bumpalo+allocator-api2-devel-3.19.1-1.el10_1.noarch.rpm;name=aarch64_rust-bumpalo+allocator-api2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bumpalo+allocator-api2-devel}"
SRC_URI[aarch64_rust-bumpalo+allocator-api2-devel.sha256sum] = "15a22748daa17e749aa2b5d396c31cf7118d7ee5188cd9b8f1458bf3df58e638"

URI_aarch64_rust-bumpalo+allocator_api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bumpalo+allocator_api-devel-3.19.1-1.el10_1.noarch.rpm;name=aarch64_rust-bumpalo+allocator_api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bumpalo+allocator_api-devel}"
SRC_URI[aarch64_rust-bumpalo+allocator_api-devel.sha256sum] = "0e10b2a2f8f5a34d3eedd69cbcea2e5e9601396405041e908442df015efec807"

URI_aarch64_rust-bumpalo+boxed-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bumpalo+boxed-devel-3.19.1-1.el10_1.noarch.rpm;name=aarch64_rust-bumpalo+boxed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bumpalo+boxed-devel}"
SRC_URI[aarch64_rust-bumpalo+boxed-devel.sha256sum] = "1f2681ed5dc2fae67bbe97593414622a565fe213525752c688cbf10677bc75e1"

URI_aarch64_rust-bumpalo+collections-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bumpalo+collections-devel-3.19.1-1.el10_1.noarch.rpm;name=aarch64_rust-bumpalo+collections-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bumpalo+collections-devel}"
SRC_URI[aarch64_rust-bumpalo+collections-devel.sha256sum] = "2404d38b96a9e749aa1d057e6a29277f060971a16abc034d996bfd536f9e9bdb"

URI_aarch64_rust-bumpalo+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bumpalo+default-devel-3.19.1-1.el10_1.noarch.rpm;name=aarch64_rust-bumpalo+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bumpalo+default-devel}"
SRC_URI[aarch64_rust-bumpalo+default-devel.sha256sum] = "c613542fdfcba78d4f2c984e2b688e6507b00e90eff47564d268cb3789b9e79c"

URI_aarch64_rust-bumpalo+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bumpalo+serde-devel-3.19.1-1.el10_1.noarch.rpm;name=aarch64_rust-bumpalo+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bumpalo+serde-devel}"
SRC_URI[aarch64_rust-bumpalo+serde-devel.sha256sum] = "a044c126663b04a76565913478c30b194ddd56b7062f0b0c7793d75555206b09"

URI_aarch64_rust-bumpalo+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bumpalo+std-devel-3.19.1-1.el10_1.noarch.rpm;name=aarch64_rust-bumpalo+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bumpalo+std-devel}"
SRC_URI[aarch64_rust-bumpalo+std-devel.sha256sum] = "5be2a8f38c3e6fea7a1eb1bebdc58b562adf3c7873ab81afad53c5000f3562cf"

URI_aarch64_rust-bumpalo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bumpalo-devel-3.19.1-1.el10_1.noarch.rpm;name=aarch64_rust-bumpalo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bumpalo-devel}"
SRC_URI[aarch64_rust-bumpalo-devel.sha256sum] = "2ece5a42f118d0950c1603cd4cadb674c1b53d2fe4870db741916c52b6a1961c"

RDEPENDS:rust-bumpalo+allocator-api2-devel = " \
 cargo \
 rust-allocator-api2-devel \
 rust-bumpalo-devel \
 "
RDEPENDS:rust-bumpalo+allocator_api-devel = " \
 cargo \
 rust-bumpalo-devel \
 "
RDEPENDS:rust-bumpalo+boxed-devel = " \
 cargo \
 rust-bumpalo-devel \
 "
RDEPENDS:rust-bumpalo+collections-devel = " \
 cargo \
 rust-bumpalo-devel \
 "
RDEPENDS:rust-bumpalo+default-devel = " \
 cargo \
 rust-bumpalo-devel \
 "
RDEPENDS:rust-bumpalo+serde-devel = " \
 cargo \
 rust-bumpalo-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-bumpalo+std-devel = " \
 cargo \
 rust-bumpalo-devel \
 "
RDEPENDS:rust-bumpalo-devel = " \
 cargo \
 rust \
 "
