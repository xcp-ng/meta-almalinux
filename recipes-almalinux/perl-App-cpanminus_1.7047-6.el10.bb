# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-App-cpanminus"
PV = "1.7047"
PR = "6.el10"
PACKAGES = " \
 perl-App-cpanminus \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-App-cpanminus-1.7047-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa4ebf8c6e83f1c1e680168507cb892f9f816dcf1178a1773c735430c84e6f56"

URI_x86_64_v2_perl-App-cpanminus = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-App-cpanminus-1.7047-6.el10.noarch.rpm;name=x86_64_v2_perl-App-cpanminus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-App-cpanminus}"
SRC_URI[x86_64_v2_perl-App-cpanminus.sha256sum] = "de5bebbfbda01880be77a2be5d82bdcbe19ef9dae08a160132066719a06f91e6"

URI_aarch64_perl-App-cpanminus = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-App-cpanminus-1.7047-6.el10.noarch.rpm;name=aarch64_perl-App-cpanminus;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-App-cpanminus}"
SRC_URI[aarch64_perl-App-cpanminus.sha256sum] = "de5bebbfbda01880be77a2be5d82bdcbe19ef9dae08a160132066719a06f91e6"

RDEPENDS:perl-App-cpanminus = " \
 perl \
 perl-App-cpanminus \
 perl-CPAN-DistnameInfo \
 perl-CPAN-Meta \
 perl-CPAN-Meta-Check \
 perl-CPAN-Meta-Requirements \
 perl-CPAN-Meta-YAML \
 perl-Digest-SHA \
 perl-ExtUtils-Install \
 perl-ExtUtils-MakeMaker \
 perl-ExtUtils-Manifest \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-File-pushd \
 perl-Getopt-Long \
 perl-HTTP-Tiny \
 perl-Module-Build \
 perl-Module-CPANfile \
 perl-Module-CoreList \
 perl-Module-Metadata \
 perl-Parse-PMFile \
 perl-PathTools \
 perl-Safe \
 perl-String-ShellQuote \
 perl-Symbol \
 perl-YAML \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-local-lib \
 perl-version \
 "
