# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ocsinventory-agent"
PV = "2.10.5"
PR = "2.el10_2"
PACKAGES = " \
 ocsinventory-agent \
 perl-Ocsinventory-Agent \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/ocsinventory-agent-2.10.5-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e852bf6dc1ef8f292549952bf0696d4daf37a6d3cf74a4abf1d7e64611e223a7"

URI_x86_64_v2_ocsinventory-agent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ocsinventory-agent-2.10.5-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ocsinventory-agent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ocsinventory-agent}"
SRC_URI[x86_64_v2_ocsinventory-agent.sha256sum] = "04cd8497cc1a78b342fe39cff986ed2cbdbd7ffd1ec84bb82ea9577f018a2cf6"

URI_x86_64_v2_perl-Ocsinventory-Agent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Ocsinventory-Agent-2.10.5-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Ocsinventory-Agent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Ocsinventory-Agent}"
SRC_URI[x86_64_v2_perl-Ocsinventory-Agent.sha256sum] = "e636ffb08210981c7fd1e046dcc45c32d2f1a42e118fb641b5338740b2d2c998"

URI_aarch64_ocsinventory-agent = "${EPEL_MIRROR}/aarch64/Packages/o/ocsinventory-agent-2.10.5-2.el10_2.aarch64.rpm;name=aarch64_ocsinventory-agent;unpack=0"
SRC_URI:append = " ${URI_aarch64_ocsinventory-agent}"
SRC_URI[aarch64_ocsinventory-agent.sha256sum] = "470d1e39d6149b645ff28b62c686d699817e1c93c7ba45d0911005aeede2e034"

URI_aarch64_perl-Ocsinventory-Agent = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Ocsinventory-Agent-2.10.5-2.el10_2.noarch.rpm;name=aarch64_perl-Ocsinventory-Agent;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Ocsinventory-Agent}"
SRC_URI[aarch64_perl-Ocsinventory-Agent.sha256sum] = "139906b5e928f2edbf80eec363d7e853c4c743cfe7906dbd04d353c8a8248ef0"

RDEPENDS:ocsinventory-agent:x86_64_v2 = " \
 bash \
 dmidecode \
 logrotate \
 perl-Ocsinventory-Agent \
 systemd \
"
RDEPENDS:ocsinventory-agent:aarch64 = " \
 bash \
 logrotate \
 perl-Ocsinventory-Agent \
 systemd \
"
RDEPENDS:perl-Ocsinventory-Agent = " \
 net-tools \
 pciutils \
 perl-Carp \
 perl-Data-Dumper \
 perl-Data-UUID \
 perl-Digest-MD5 \
 perl-Encode \
 perl-English \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-FcntlLock \
 perl-File-Path \
 perl-File-Temp \
 perl-File-stat \
 perl-Getopt-Long \
 perl-HTTP-Message \
 perl-IO-Compress \
 perl-IO-Socket-SSL \
 perl-LWP-Protocol-https \
 perl-MIME-Base64 \
 perl-Net-IP \
 perl-Net-Netmask \
 perl-Net-SNMP \
 perl-Net-SSLeay \
 perl-Ocsinventory-Agent \
 perl-POSIX \
 perl-Parse-EDID \
 perl-Socket \
 perl-Sys-Syslog \
 perl-Time-Local \
 perl-XML-Parser \
 perl-XML-Simple \
 perl-constant \
 perl-libs \
 perl-libwww-perl \
 perl-vars \
 smartmontools \
 which \
 "
