# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rgb"
PV = "1.0.6"
PR = "45.el10_0"
PACKAGES = " \
 rgb \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rgb-1.0.6-45.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f29d40e2975c99f129017b194ea9773a8ea01d6542812f2c2ecd01e67271315"

URI_x86_64_v2_rgb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rgb-1.0.6-45.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rgb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rgb}"
SRC_URI[x86_64_v2_rgb.sha256sum] = "de9c8bd1128cc85453f71f8e1c52079f8e7eaf80e0d88dce10c1d8fbbc8979bf"

URI_aarch64_rgb = "${EPEL_MIRROR}/aarch64/Packages/r/rgb-1.0.6-45.el10_0.aarch64.rpm;name=aarch64_rgb;unpack=0"
SRC_URI:append = " ${URI_aarch64_rgb}"
SRC_URI[aarch64_rgb.sha256sum] = "f316953459583989fd0d91a2f638934f59dd06f510b810e1b319ea0ee0d933db"

RDEPENDS:rgb = " \
 glibc \
 "
