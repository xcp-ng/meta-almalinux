# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sdbus-cpp"
PV = "2.1.0"
PR = "1.el10_0"
PACKAGES = " \
 sdbus-cpp \
 sdbus-cpp-devel \
 sdbus-cpp-devel-doc \
 sdbus-cpp-tests \
 sdbus-cpp-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sdbus-cpp-2.1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6da2d0cd8fc3330dcd8ff5417406aa28bf2a64b03c9b3f34e106767313b102c"

URI_x86_64_v2_sdbus-cpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sdbus-cpp-2.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sdbus-cpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sdbus-cpp}"
SRC_URI[x86_64_v2_sdbus-cpp.sha256sum] = "77182a55356481029e520c8d5b8c9c585b23366bf95d9f099694a91d1e11a803"

URI_x86_64_v2_sdbus-cpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sdbus-cpp-devel-2.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sdbus-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sdbus-cpp-devel}"
SRC_URI[x86_64_v2_sdbus-cpp-devel.sha256sum] = "f336130b32c5bde15a63cc16a55a58d7d63b2280858c11384e56228090e2fefe"

URI_x86_64_v2_sdbus-cpp-devel-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sdbus-cpp-devel-doc-2.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_sdbus-cpp-devel-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sdbus-cpp-devel-doc}"
SRC_URI[x86_64_v2_sdbus-cpp-devel-doc.sha256sum] = "a0e7893c2a27c98d2c8afc1e770864ff933caa8c66bb7fd2c320cdb454164d03"

URI_x86_64_v2_sdbus-cpp-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sdbus-cpp-tests-2.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sdbus-cpp-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sdbus-cpp-tests}"
SRC_URI[x86_64_v2_sdbus-cpp-tests.sha256sum] = "3ad8c31a078dd829d9545411c677a9b7100c92f4777466b394f56a0fb3834639"

URI_x86_64_v2_sdbus-cpp-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sdbus-cpp-tools-2.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sdbus-cpp-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sdbus-cpp-tools}"
SRC_URI[x86_64_v2_sdbus-cpp-tools.sha256sum] = "99f1570d9d95f1306392d7353ccbe712e71311cbbe9302f44969b59d1399574e"

URI_aarch64_sdbus-cpp = "${EPEL_MIRROR}/aarch64/Packages/s/sdbus-cpp-2.1.0-1.el10_0.aarch64.rpm;name=aarch64_sdbus-cpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_sdbus-cpp}"
SRC_URI[aarch64_sdbus-cpp.sha256sum] = "8cc044356bfd593c667eb39f5eb43148450ceadf62e836d82b95aa75d29f27cb"

URI_aarch64_sdbus-cpp-devel = "${EPEL_MIRROR}/aarch64/Packages/s/sdbus-cpp-devel-2.1.0-1.el10_0.aarch64.rpm;name=aarch64_sdbus-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sdbus-cpp-devel}"
SRC_URI[aarch64_sdbus-cpp-devel.sha256sum] = "d3fb8337ca562b330d87a08382017b447a4b2e66647e9c7fd8184a3677de17ae"

URI_aarch64_sdbus-cpp-devel-doc = "${EPEL_MIRROR}/aarch64/Packages/s/sdbus-cpp-devel-doc-2.1.0-1.el10_0.noarch.rpm;name=aarch64_sdbus-cpp-devel-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_sdbus-cpp-devel-doc}"
SRC_URI[aarch64_sdbus-cpp-devel-doc.sha256sum] = "3cc37aa422a02c7ca928889277fe3f3f9fbb39b43ba80bfbf7d2a0981a09d8f6"

URI_aarch64_sdbus-cpp-tests = "${EPEL_MIRROR}/aarch64/Packages/s/sdbus-cpp-tests-2.1.0-1.el10_0.aarch64.rpm;name=aarch64_sdbus-cpp-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_sdbus-cpp-tests}"
SRC_URI[aarch64_sdbus-cpp-tests.sha256sum] = "02d96643a111a3e6bce5984164b0023b5bb77970b9eb0050da2106d19973352d"

URI_aarch64_sdbus-cpp-tools = "${EPEL_MIRROR}/aarch64/Packages/s/sdbus-cpp-tools-2.1.0-1.el10_0.aarch64.rpm;name=aarch64_sdbus-cpp-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_sdbus-cpp-tools}"
SRC_URI[aarch64_sdbus-cpp-tools.sha256sum] = "a524d8640f4d8cd40d906985bba52da3002e12b8d4c372a35a7c9bb5a5748953"

RDEPENDS:sdbus-cpp = " \
 glibc \
 libgcc \
 libstdc++ \
 systemd-libs \
 "
RDEPENDS:sdbus-cpp-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 sdbus-cpp \
 systemd-devel \
 "
RDEPENDS:sdbus-cpp-devel-doc = " \
 "
RDEPENDS:sdbus-cpp-tests = " \
 glibc \
 gmock \
 gtest \
 libgcc \
 libstdc++ \
 sdbus-cpp \
 systemd-libs \
 "
RDEPENDS:sdbus-cpp-tools = " \
 cmake-filesystem \
 expat \
 glibc \
 libgcc \
 libstdc++ \
 sdbus-cpp \
 "
