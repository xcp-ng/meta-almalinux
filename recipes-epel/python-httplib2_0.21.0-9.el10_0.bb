# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-httplib2"
PV = "0.21.0"
PR = "9.el10_0"
PACKAGES = " \
 python3-httplib2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-httplib2-0.21.0-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fc74342b2bb5b0267a2342961a71c3b07a3304cf4d5d6563a8ca6b156ee20d79"

URI_x86_64_v2_python3-httplib2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-httplib2-0.21.0-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-httplib2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-httplib2}"
SRC_URI[x86_64_v2_python3-httplib2.sha256sum] = "d0791294560cd253ba7c03826c2a81582386c9daa08cddd0a8d60d2bbeee9ed9"

URI_aarch64_python3-httplib2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-httplib2-0.21.0-9.el10_0.noarch.rpm;name=aarch64_python3-httplib2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-httplib2}"
SRC_URI[aarch64_python3-httplib2.sha256sum] = "e14d74b296b16d9c55d5b79aacfebf27699a895dd79b466afa1d59681fc0a952"

RDEPENDS:python3-httplib2 = " \
 python3 \
 python3-pyparsing \
 "
