# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nbtscan"
PV = "1.7.2"
PR = "4.el10_0"
PACKAGES = " \
 nbtscan \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nbtscan-1.7.2-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed93f3f2381ee6469b533b0edbf9fa22e40dc3bfa6c1fd18e12230a13277704c"

URI_x86_64_v2_nbtscan = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nbtscan-1.7.2-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nbtscan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbtscan}"
SRC_URI[x86_64_v2_nbtscan.sha256sum] = "8ce7948de26713063b3c92d02b101d54c3f836353647a9ccf1f2e90cce4f3bc8"

URI_aarch64_nbtscan = "${EPEL_MIRROR}/aarch64/Packages/n/nbtscan-1.7.2-4.el10_0.aarch64.rpm;name=aarch64_nbtscan;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbtscan}"
SRC_URI[aarch64_nbtscan.sha256sum] = "8a0dbd58811c631a690b2410246f424cff22e6ab5f7855ad8832e32d7a55f5f0"

RDEPENDS:nbtscan = " \
 glibc \
 "
