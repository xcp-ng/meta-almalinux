# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-selinux-sys"
PV = "0.6.15"
PR = "1.el10_2"
PACKAGES = " \
 rust-selinux-sys+default-devel \
 rust-selinux-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-selinux-sys-0.6.15-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b7ca3f3caec8dae8b61b8c44c4719475e416fdb222a6d50a1a5d5ddb87ddfed5"

URI_x86_64_v2_rust-selinux-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-selinux-sys+default-devel-0.6.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-selinux-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-selinux-sys+default-devel}"
SRC_URI[x86_64_v2_rust-selinux-sys+default-devel.sha256sum] = "d28bfbe6ca6b5caac3d3e28306a2d63359c419199a13b31c3becf672c7c2c16b"

URI_x86_64_v2_rust-selinux-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-selinux-sys-devel-0.6.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-selinux-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-selinux-sys-devel}"
SRC_URI[x86_64_v2_rust-selinux-sys-devel.sha256sum] = "d11cd2b8685d0479e3a65dd930dfa9d81a65510c7e754506c0964ed0c310c2f9"

URI_aarch64_rust-selinux-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-selinux-sys+default-devel-0.6.15-1.el10_2.noarch.rpm;name=aarch64_rust-selinux-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-selinux-sys+default-devel}"
SRC_URI[aarch64_rust-selinux-sys+default-devel.sha256sum] = "c23f0f46ae3cd100f1ea576d4b2326576ce2fe0da4aad94a358e27abd9fadd72"

URI_aarch64_rust-selinux-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-selinux-sys-devel-0.6.15-1.el10_2.noarch.rpm;name=aarch64_rust-selinux-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-selinux-sys-devel}"
SRC_URI[aarch64_rust-selinux-sys-devel.sha256sum] = "2b227a91ede90895c0024c0b1507fe920ba91e14eadc09fed73551ce70182012"

RDEPENDS:rust-selinux-sys+default-devel = " \
 cargo \
 rust-selinux-sys-devel \
 "
RDEPENDS:rust-selinux-sys-devel = " \
 cargo \
 libselinux-devel \
 rust-bindgen+default-devel \
 rust-cc+default-devel \
 rust-dunce+default-devel \
 rust-walkdir+default-devel \
 "
