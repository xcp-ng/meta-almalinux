# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-convert_case0.6"
PV = "0.6.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-convert_case0.6+default-devel \
 rust-convert_case0.6+rand-devel \
 rust-convert_case0.6+random-devel \
 rust-convert_case0.6-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-convert_case0.6-0.6.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c45155dab29ce68f1ba8ea4547ce3235148be9ed200c7a869bfb8272e1e840e9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-convert_case0.6+default-devel-0.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-convert_case0.6+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-convert_case0.6+default-devel.sha256sum] = "1e723b2c5e58cc16ec5738aec048c66840040413a8526313e3e02c803b860908"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-convert_case0.6+rand-devel-0.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-convert_case0.6+rand-devel;unpack=0"
SRC_URI[x86_64_v2_rust-convert_case0.6+rand-devel.sha256sum] = "5876a8a025b01205c0cfd7bcd97b824a78e0596614ca6a75bdfc26063ddbe649"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-convert_case0.6+random-devel-0.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-convert_case0.6+random-devel;unpack=0"
SRC_URI[x86_64_v2_rust-convert_case0.6+random-devel.sha256sum] = "dfe9810adca1f642cc99c0c32d5dc6577a913023080c7c89ff148b9b5cbea6db"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-convert_case0.6-devel-0.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-convert_case0.6-devel;unpack=0"
SRC_URI[x86_64_v2_rust-convert_case0.6-devel.sha256sum] = "abc9e9657ff26e7c0b452c7861a80697f6c00ab3e7e6a238e3f8841972547744"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-convert_case0.6+default-devel-0.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-convert_case0.6+default-devel;unpack=0"
SRC_URI[aarch64_rust-convert_case0.6+default-devel.sha256sum] = "70bc4439952815f9e96e1ea7a2aeb8744f28ed2ece01b25f5bf17299df2e8de1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-convert_case0.6+rand-devel-0.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-convert_case0.6+rand-devel;unpack=0"
SRC_URI[aarch64_rust-convert_case0.6+rand-devel.sha256sum] = "7256071df085f126aae5ed0afb0e89af6e48c4e80c5fef30df4a19fa78991913"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-convert_case0.6+random-devel-0.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-convert_case0.6+random-devel;unpack=0"
SRC_URI[aarch64_rust-convert_case0.6+random-devel.sha256sum] = "11de032c65cb24e2b28f561dcbbea966331bf44653a7a0f99ca70e20c7df63ed"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-convert_case0.6-devel-0.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-convert_case0.6-devel;unpack=0"
SRC_URI[aarch64_rust-convert_case0.6-devel.sha256sum] = "fd6f64ed9e6aa77ce90185454836e3a56f6e55ade5bfa7f10d4a87eef3525916"

RDEPENDS:rust-convert_case0.6+default-devel = " \
 cargo \
 rust-convert_case0.6-devel \
 "
RDEPENDS:rust-convert_case0.6+rand-devel = " \
 cargo \
 rust-convert_case0.6-devel \
 rust-rand0.7+default-devel \
 "
RDEPENDS:rust-convert_case0.6+random-devel = " \
 cargo \
 rust-convert_case0.6+rand-devel \
 rust-convert_case0.6-devel \
 "
RDEPENDS:rust-convert_case0.6-devel = " \
 cargo \
 rust-unicode-segmentation+default-devel \
 "
