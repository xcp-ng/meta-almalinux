# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-activities-stats"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 plasma-activities-stats \
 plasma-activities-stats-devel \
 plasma-activities-stats-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-activities-stats-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2489b759e7648c56e13aeeb4119b025557e09057d3dac05ce0a2ea6919743182"

URI_x86_64_v2_plasma-activities-stats = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-activities-stats-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-activities-stats;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-activities-stats}"
SRC_URI[x86_64_v2_plasma-activities-stats.sha256sum] = "961ad67a9839c69dcc150aabdbac37e5fe3b3fbc8e179f849d3f68707e08b7fa"

URI_x86_64_v2_plasma-activities-stats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-activities-stats-devel-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-activities-stats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-activities-stats-devel}"
SRC_URI[x86_64_v2_plasma-activities-stats-devel.sha256sum] = "e36715853b448e8d4610ac66a9453485ba314cf54af4f1e19eb070efbba80243"

URI_x86_64_v2_plasma-activities-stats-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-activities-stats-doc-6.6.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-activities-stats-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-activities-stats-doc}"
SRC_URI[x86_64_v2_plasma-activities-stats-doc.sha256sum] = "105d84e6fa01aabb6657eb52347d33965647c242d80fa278f11eebbd99707cb7"

URI_aarch64_plasma-activities-stats = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-activities-stats-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-activities-stats;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-activities-stats}"
SRC_URI[aarch64_plasma-activities-stats.sha256sum] = "ecce79a9e7a547c21df9ad38ab3c22dd2d269f8421289ff2d687e33709ae68df"

URI_aarch64_plasma-activities-stats-devel = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-activities-stats-devel-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-activities-stats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-activities-stats-devel}"
SRC_URI[aarch64_plasma-activities-stats-devel.sha256sum] = "4b56791a432cfa422b99432f2266156e1aac5266902f5775824557b3a1459562"

URI_aarch64_plasma-activities-stats-doc = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-activities-stats-doc-6.6.4-1.el10_2.noarch.rpm;name=aarch64_plasma-activities-stats-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-activities-stats-doc}"
SRC_URI[aarch64_plasma-activities-stats-doc.sha256sum] = "e2bef4d89b4cc85bf0d4d8069fa23acb8a6ab227868cb4db2e29c2b87e0a7d3b"

RDEPENDS:plasma-activities-stats = " \
 glibc \
 kf6-kconfig \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 "
RDEPENDS:plasma-activities-stats-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 plasma-activities-stats \
 qt6-qtbase-devel \
 "
RDEPENDS:plasma-activities-stats-doc = " \
 "
