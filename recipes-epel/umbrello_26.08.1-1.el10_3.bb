# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "umbrello"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 umbrello \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/u/umbrello-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9125f9ad7329aa2c401b2506436eef0506131ad69b93e5ebcebcc6941fe2d375"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/umbrello-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_umbrello;unpack=0"
SRC_URI[x86_64_v2_umbrello.sha256sum] = "34ae4e99e6e557ba62f770b0ba8da12a52e8f45b7ed169f6030cbe9e98c88198"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/u/umbrello-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_umbrello;unpack=0"
SRC_URI[aarch64_umbrello.sha256sum] = "811f0282d2af5e0d139e49c52e322680e8be1ef201af1d184d1cef6f6790085b"

RDEPENDS:umbrello = " \
 glibc \
 kf6-karchive \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-ktexteditor \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 libxml2 \
 libxslt \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
