# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-cli"
PV = "0.25.10"
PR = "3.el10_3"
PACKAGES = " \
 rust-tree-sitter-cli+default-devel \
 rust-tree-sitter-cli-devel \
 tree-sitter-cli \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-cli-0.25.10-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78442eaaa9b19932f6561412ca999e4b2cf198a6160fd34e9676148601927a76"

URI_x86_64_v2_rust-tree-sitter-cli+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-cli+default-devel-0.25.10-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-cli+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-cli+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-cli+default-devel.sha256sum] = "4aa51acdbb22e894742448ccc1a51cfb53f635a668f5742a4df2d3b9e080b9f5"

URI_x86_64_v2_rust-tree-sitter-cli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-cli-devel-0.25.10-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-cli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-cli-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-cli-devel.sha256sum] = "061940c96f3c14c8507119bc054fb7cade19ec5e2c954bd8dd2e22065178e5e8"

URI_x86_64_v2_tree-sitter-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tree-sitter-cli-0.25.10-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tree-sitter-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tree-sitter-cli}"
SRC_URI[x86_64_v2_tree-sitter-cli.sha256sum] = "9788a6af7ca7ec872b57a21d726da1df9cd71c440397cb05f46fb7e3a5bcb9a8"

URI_aarch64_rust-tree-sitter-cli+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-cli+default-devel-0.25.10-3.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-cli+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-cli+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-cli+default-devel.sha256sum] = "c59c33672ed5ab7788966a2d85e7a700b10d87f179db3ce1669d163851aa202a"

URI_aarch64_rust-tree-sitter-cli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-cli-devel-0.25.10-3.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-cli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-cli-devel}"
SRC_URI[aarch64_rust-tree-sitter-cli-devel.sha256sum] = "daaa3703bd897c7d0fef15f1fbaeb7079e88521f4518bd369584e77219046415"

URI_aarch64_tree-sitter-cli = "${EPEL_MIRROR}/aarch64/Packages/t/tree-sitter-cli-0.25.10-3.el10_3.aarch64.rpm;name=aarch64_tree-sitter-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_tree-sitter-cli}"
SRC_URI[aarch64_tree-sitter-cli.sha256sum] = "9f602a8108e89222361138077500559abb834bf0bacefc74b895eb5dc2b53a28"

RDEPENDS:rust-tree-sitter-cli+default-devel = " \
 cargo \
 rust-tree-sitter-cli-devel \
 "
RDEPENDS:rust-tree-sitter-cli-devel = " \
 cargo \
 rust \
 rust-ansi_colours+default-devel \
 rust-anstyle+default-devel \
 rust-anyhow+default-devel \
 rust-bstr+default-devel \
 rust-clap+cargo-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-clap+env-devel \
 rust-clap+help-devel \
 rust-clap+unstable-styles-devel \
 rust-clap_complete+default-devel \
 rust-clap_complete_nushell+default-devel \
 rust-ctor0.2+default-devel \
 rust-ctrlc+default-devel \
 rust-ctrlc+termination-devel \
 rust-dialoguer+default-devel \
 rust-dialoguer+fuzzy-select-devel \
 rust-filetime+default-devel \
 rust-glob+default-devel \
 rust-heck+default-devel \
 rust-html-escape+default-devel \
 rust-indexmap+default-devel \
 rust-indoc+default-devel \
 rust-log+default-devel \
 rust-log+std-devel \
 rust-memchr+default-devel \
 rust-rand0.8+default-devel \
 rust-regex+default-devel \
 rust-regex-syntax+default-devel \
 rust-rustc-hash+default-devel \
 rust-semver+default-devel \
 rust-semver+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_derive+default-devel \
 rust-serde_json+default-devel \
 rust-serde_json+preserve_order-devel \
 rust-similar2+default-devel \
 rust-smallbitvec+default-devel \
 rust-streaming-iterator+default-devel \
 rust-tiny_http+default-devel \
 rust-topological-sort+default-devel \
 rust-tree-sitter-config+default-devel \
 rust-tree-sitter-generate+default-devel \
 rust-tree-sitter-highlight+default-devel \
 rust-tree-sitter-loader+default-devel \
 rust-tree-sitter-tags+default-devel \
 rust-tree-sitter0.25+default-devel \
 rust-url+default-devel \
 rust-url+serde-devel \
 rust-walkdir+default-devel \
 rust-wasmparser+default-devel \
 rust-webbrowser+default-devel \
 "
RDEPENDS:tree-sitter-cli = " \
 glibc \
 libgcc \
 "
