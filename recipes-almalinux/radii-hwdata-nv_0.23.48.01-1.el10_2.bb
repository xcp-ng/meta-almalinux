# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "radii-hwdata-nv"
PV = "0.23.48.01"
PR = "1.el10_2"
PACKAGES = " \
 radii-hwdata-nv \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/radii-hwdata-nv-0.23.48.01-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b850ca181b94da7e9b4903ac8e95d2cb4a4c0d14edbdf902a1c128aa6dcac4e2"

URI_x86_64_v2_radii-hwdata-nv = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/radii-hwdata-nv-0.23.48.01-1.el10_2.noarch.rpm;name=x86_64_v2_radii-hwdata-nv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_radii-hwdata-nv}"
SRC_URI[x86_64_v2_radii-hwdata-nv.sha256sum] = "5a344975738fa087fe99f06af581ab174f8d216126bbe0192630c88d32674492"

URI_aarch64_radii-hwdata-nv = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/radii-hwdata-nv-0.23.48.01-1.el10_2.noarch.rpm;name=aarch64_radii-hwdata-nv;unpack=0"
SRC_URI:append = " ${URI_aarch64_radii-hwdata-nv}"
SRC_URI[aarch64_radii-hwdata-nv.sha256sum] = "5a344975738fa087fe99f06af581ab174f8d216126bbe0192630c88d32674492"

RDEPENDS:radii-hwdata-nv = " \
 "
