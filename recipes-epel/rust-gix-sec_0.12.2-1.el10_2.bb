# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-sec"
PV = "0.12.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-sec+default-devel \
 rust-gix-sec+document-features-devel \
 rust-gix-sec+serde-devel \
 rust-gix-sec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-sec-0.12.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63260eb541bb721554de4b798e66731d3365e98e474a6ce8c882a051a5bce616"

URI_x86_64_v2_rust-gix-sec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-sec+default-devel-0.12.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-sec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-sec+default-devel}"
SRC_URI[x86_64_v2_rust-gix-sec+default-devel.sha256sum] = "06888af960ecb8ffbc55df04309519a20ef477f427bf2d61338ccf912c79202d"

URI_x86_64_v2_rust-gix-sec+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-sec+document-features-devel-0.12.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-sec+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-sec+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-sec+document-features-devel.sha256sum] = "0ac68ca3c924ce5bb82721ae10b7a19654ca3696f4785ed661a66d78bba86d9b"

URI_x86_64_v2_rust-gix-sec+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-sec+serde-devel-0.12.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-sec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-sec+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-sec+serde-devel.sha256sum] = "c2e4b3768ac7ca886fea16a337b25f20ffb22f13ff4277d933fd7a4573981099"

URI_x86_64_v2_rust-gix-sec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-sec-devel-0.12.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-sec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-sec-devel}"
SRC_URI[x86_64_v2_rust-gix-sec-devel.sha256sum] = "3c5d5f678c4234f566b87a60e46988500e756fbb0a21db62d1787110c3d00937"

URI_aarch64_rust-gix-sec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-sec+default-devel-0.12.2-1.el10_2.noarch.rpm;name=aarch64_rust-gix-sec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-sec+default-devel}"
SRC_URI[aarch64_rust-gix-sec+default-devel.sha256sum] = "8de61cd81438395e809b89ec6369040fc34cb4028996189a5c2daaedfefc4f4a"

URI_aarch64_rust-gix-sec+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-sec+document-features-devel-0.12.2-1.el10_2.noarch.rpm;name=aarch64_rust-gix-sec+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-sec+document-features-devel}"
SRC_URI[aarch64_rust-gix-sec+document-features-devel.sha256sum] = "a87c12d28efc41e977026439ab49c15965715f5caa442babb475224f0a442425"

URI_aarch64_rust-gix-sec+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-sec+serde-devel-0.12.2-1.el10_2.noarch.rpm;name=aarch64_rust-gix-sec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-sec+serde-devel}"
SRC_URI[aarch64_rust-gix-sec+serde-devel.sha256sum] = "49c21b402595f185339596430d3a75c2cc739a8059566d90a9f12779f00655d4"

URI_aarch64_rust-gix-sec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-sec-devel-0.12.2-1.el10_2.noarch.rpm;name=aarch64_rust-gix-sec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-sec-devel}"
SRC_URI[aarch64_rust-gix-sec-devel.sha256sum] = "898d9952c5ea56ff8b8e513a20db19b33a611789f27867a8dec0f9981fa9ca08"

RDEPENDS:rust-gix-sec+default-devel = " \
 cargo \
 rust-gix-sec-devel \
 "
RDEPENDS:rust-gix-sec+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-sec-devel \
 "
RDEPENDS:rust-gix-sec+serde-devel = " \
 cargo \
 rust-bitflags+serde-devel \
 rust-gix-sec-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-sec-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-libc+default-devel \
 "
