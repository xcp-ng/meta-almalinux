# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sieve"
PV = "0.1.9"
PR = "34.el10_0"
PACKAGES = " \
 python3-sieve \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-sieve-0.1.9-34.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6768a1091fdc68261c2d8c1cf535b5421a2fc1d3ee201b33232f9b77b26d0ca6"

URI_x86_64_v2_python3-sieve = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sieve-0.1.9-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sieve;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sieve}"
SRC_URI[x86_64_v2_python3-sieve.sha256sum] = "9c72752e828c37d1a10d3755301a0f1bc60341e319e3ee9cad50d2b26e83abe0"

URI_aarch64_python3-sieve = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sieve-0.1.9-34.el10_0.noarch.rpm;name=aarch64_python3-sieve;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sieve}"
SRC_URI[aarch64_python3-sieve.sha256sum] = "94bd19f7306f170f50413ee2916f53860385db67daf28f2202e9da83db0cebbb"

RDEPENDS:python3-sieve = " \
 python3 \
 python3-lxml \
 python3-markupsafe \
 python3-six \
 "
