# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-yesod-core"
PV = "1.6.25.1"
PR = "1.el10_0"
PACKAGES = " \
 ghc-yesod-core \
 ghc-yesod-core-devel \
 ghc-yesod-core-doc \
 ghc-yesod-core-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-yesod-core-1.6.25.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8de94808a04d446fecebb4e292fa2504e8e4f383612a36a06a53ea37acd3261a"

URI_x86_64_v2_ghc-yesod-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-yesod-core-1.6.25.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-yesod-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-yesod-core}"
SRC_URI[x86_64_v2_ghc-yesod-core.sha256sum] = "f1a90c55ef000e3832fc4266c5b2872819df5da898b41cd06731291d4d05b7e7"

URI_x86_64_v2_ghc-yesod-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-yesod-core-devel-1.6.25.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-yesod-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-yesod-core-devel}"
SRC_URI[x86_64_v2_ghc-yesod-core-devel.sha256sum] = "27ce1d0849db6e0f4965e5f8a01cb4f367ea8c8da3c812d0fde6ae85cec5d90a"

URI_x86_64_v2_ghc-yesod-core-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-yesod-core-doc-1.6.25.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-yesod-core-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-yesod-core-doc}"
SRC_URI[x86_64_v2_ghc-yesod-core-doc.sha256sum] = "d9a544819c7d2127ff1bf62a211a71fc135f61210d9409929ce47c2e2f0ade5c"

URI_x86_64_v2_ghc-yesod-core-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-yesod-core-prof-1.6.25.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-yesod-core-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-yesod-core-prof}"
SRC_URI[x86_64_v2_ghc-yesod-core-prof.sha256sum] = "1377d6a4a53bb810dfd5f6f16104d0109d56c67ed6029285332633369218f64f"

URI_aarch64_ghc-yesod-core = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-yesod-core-1.6.25.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-yesod-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-yesod-core}"
SRC_URI[aarch64_ghc-yesod-core.sha256sum] = "b23213353ba4551ccf4138f0abb360e3d66d3fbf5e1231da405692a86eea9569"

URI_aarch64_ghc-yesod-core-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-yesod-core-devel-1.6.25.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-yesod-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-yesod-core-devel}"
SRC_URI[aarch64_ghc-yesod-core-devel.sha256sum] = "1929ea623f2545d54254668ac5f8cf47fe79df6be3a24911a8704c7a5472e1b0"

URI_aarch64_ghc-yesod-core-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-yesod-core-doc-1.6.25.1-1.el10_0.noarch.rpm;name=aarch64_ghc-yesod-core-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-yesod-core-doc}"
SRC_URI[aarch64_ghc-yesod-core-doc.sha256sum] = "e5f5a9e6e585f6969d66a4da507e9774e08d942e2e7e517d78a039ceeb33bd67"

URI_aarch64_ghc-yesod-core-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-yesod-core-prof-1.6.25.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-yesod-core-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-yesod-core-prof}"
SRC_URI[aarch64_ghc-yesod-core-prof.sha256sum] = "3b808c39a7d879520a6c35700a21da6e8cdd42948c6dee9f8ffb95db370f5697"

RDEPENDS:ghc-yesod-core = " \
 ghc-HUnit \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-appar \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-auto-update \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-basement \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-bsb-http-chunked \
 ghc-byteorder \
 ghc-bytestring \
 ghc-call-stack \
 ghc-case-insensitive \
 ghc-cereal \
 ghc-clientsession \
 ghc-colour \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-crypto-api \
 ghc-crypton \
 ghc-crypton-x509 \
 ghc-cryptonite \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-easy-file \
 ghc-entropy \
 ghc-exceptions \
 ghc-fast-logger \
 ghc-file-embed \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hourglass \
 ghc-http-date \
 ghc-http-types \
 ghc-http2 \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-iproute \
 ghc-lifted-base \
 ghc-memory \
 ghc-monad-control \
 ghc-monad-logger \
 ghc-monad-loops \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-network-byte-order \
 ghc-network-control \
 ghc-old-locale \
 ghc-old-time \
 ghc-os-string \
 ghc-parsec \
 ghc-path-pieces \
 ghc-pem \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-psqueues \
 ghc-random \
 ghc-recv \
 ghc-resourcet \
 ghc-safe-exceptions \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-setenv \
 ghc-shakespeare \
 ghc-simple-sendfile \
 ghc-skein \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-stm-chans \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-lift \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-time-manager \
 ghc-transformers \
 ghc-transformers-base \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-unix \
 ghc-unix-compat \
 ghc-unix-time \
 ghc-unliftio \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vault \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-wai \
 ghc-wai-extra \
 ghc-wai-logger \
 ghc-warp \
 ghc-witherable \
 ghc-word8 \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-yesod-core-devel = " \
 ghc-aeson-devel \
 ghc-auto-update-devel \
 ghc-base-devel \
 ghc-blaze-html-devel \
 ghc-blaze-markup-devel \
 ghc-bytestring-devel \
 ghc-case-insensitive-devel \
 ghc-cereal-devel \
 ghc-clientsession-devel \
 ghc-compiler \
 ghc-conduit-devel \
 ghc-conduit-extra-devel \
 ghc-containers-devel \
 ghc-cookie-devel \
 ghc-deepseq-devel \
 ghc-entropy-devel \
 ghc-fast-logger-devel \
 ghc-http-types-devel \
 ghc-memory-devel \
 ghc-monad-logger-devel \
 ghc-mtl-devel \
 ghc-parsec-devel \
 ghc-path-pieces-devel \
 ghc-primitive-devel \
 ghc-random-devel \
 ghc-resourcet-devel \
 ghc-shakespeare-devel \
 ghc-template-haskell-devel \
 ghc-text-devel \
 ghc-time-devel \
 ghc-transformers-devel \
 ghc-unix-compat-devel \
 ghc-unliftio-devel \
 ghc-unordered-containers-devel \
 ghc-vector-devel \
 ghc-wai-devel \
 ghc-wai-extra-devel \
 ghc-wai-logger-devel \
 ghc-warp-devel \
 ghc-word8-devel \
 ghc-yesod-core \
 "
RDEPENDS:ghc-yesod-core-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-yesod-core-prof = " \
 ghc-aeson-prof \
 ghc-auto-update-prof \
 ghc-base-prof \
 ghc-blaze-html-prof \
 ghc-blaze-markup-prof \
 ghc-bytestring-prof \
 ghc-case-insensitive-prof \
 ghc-cereal-prof \
 ghc-clientsession-prof \
 ghc-conduit-extra-prof \
 ghc-conduit-prof \
 ghc-containers-prof \
 ghc-cookie-prof \
 ghc-deepseq-prof \
 ghc-entropy-prof \
 ghc-fast-logger-prof \
 ghc-http-types-prof \
 ghc-memory-prof \
 ghc-monad-logger-prof \
 ghc-mtl-prof \
 ghc-parsec-prof \
 ghc-path-pieces-prof \
 ghc-primitive-prof \
 ghc-random-prof \
 ghc-resourcet-prof \
 ghc-shakespeare-prof \
 ghc-template-haskell-prof \
 ghc-text-prof \
 ghc-time-prof \
 ghc-transformers-prof \
 ghc-unix-compat-prof \
 ghc-unliftio-prof \
 ghc-unordered-containers-prof \
 ghc-vector-prof \
 ghc-wai-extra-prof \
 ghc-wai-logger-prof \
 ghc-wai-prof \
 ghc-warp-prof \
 ghc-word8-prof \
 ghc-yesod-core-devel \
 "
