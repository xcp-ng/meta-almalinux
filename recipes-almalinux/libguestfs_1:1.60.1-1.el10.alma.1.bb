# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libguestfs"
PE = "1"
PV = "1.60.1"
PR = "1.el10.alma.1"
PACKAGES = " \
 libguestfs \
 libguestfs-appliance \
 libguestfs-bash-completion \
 libguestfs-devel \
 libguestfs-inspect-icons \
 libguestfs-man-pages-ja \
 libguestfs-man-pages-uk \
 libguestfs-rescue \
 libguestfs-rsync \
 libguestfs-xfs \
 ocaml-libguestfs \
 ocaml-libguestfs-devel \
 perl-Sys-Guestfs \
 python3-libguestfs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libguestfs-1.60.1-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e72a4d01fe33d993636e3cc20fe1d583f3ed7eddf336096f461aeabdb3cba45"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - libguestfs-appliance: augeas-libs
# - libguestfs: augeas-libs(x86-64) >= 1.7.0
# - ocaml-libguestfs-devel: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libguestfs-devel: ocaml(CamlinternalOO) = bf3206c1e533a97ee4e00a76bfe1dae6
# - ocaml-libguestfs-devel: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libguestfs-devel: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libguestfs-devel: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libguestfs-devel: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libguestfs-devel: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libguestfs-devel: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827
# - ocaml-libguestfs-devel: ocamlx(CamlinternalOO) = 3bb5173e1a86ae74d96d5b3bc80f14a3
# - ocaml-libguestfs-devel: ocamlx(Stdlib__Array) = b3215f99afe054938b4b66df456093cb
# - ocaml-libguestfs-devel: ocamlx(Stdlib__Callback) = bafc96ea60f2aa399fe753ac0e40f764
# - ocaml-libguestfs-devel: ocamlx(Stdlib__Gc) = 197914694cd716338b4da966236687f4
# - ocaml-libguestfs: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libguestfs: ocaml(CamlinternalOO) = bf3206c1e533a97ee4e00a76bfe1dae6
# - ocaml-libguestfs: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libguestfs: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libguestfs: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libguestfs: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libguestfs: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libguestfs: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - libguestfs-appliance: augeas-libs
# - libguestfs-appliance: libcap
# - libguestfs: augeas-libs(aarch-64) >= 1.7.0
# - libguestfs: libcap(aarch-64)
# - ocaml-libguestfs-devel: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libguestfs-devel: ocaml(CamlinternalOO) = bf3206c1e533a97ee4e00a76bfe1dae6
# - ocaml-libguestfs-devel: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libguestfs-devel: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libguestfs-devel: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libguestfs-devel: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libguestfs-devel: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libguestfs-devel: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827
# - ocaml-libguestfs-devel: ocamlx(CamlinternalOO) = 3bb5173e1a86ae74d96d5b3bc80f14a3
# - ocaml-libguestfs-devel: ocamlx(Stdlib__Array) = b3215f99afe054938b4b66df456093cb
# - ocaml-libguestfs-devel: ocamlx(Stdlib__Callback) = bafc96ea60f2aa399fe753ac0e40f764
# - ocaml-libguestfs-devel: ocamlx(Stdlib__Gc) = 197914694cd716338b4da966236687f4
# - ocaml-libguestfs: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libguestfs: ocaml(CamlinternalOO) = bf3206c1e533a97ee4e00a76bfe1dae6
# - ocaml-libguestfs: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libguestfs: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libguestfs: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libguestfs: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libguestfs: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libguestfs: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827

URI_x86_64_v2_libguestfs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libguestfs-1.60.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libguestfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguestfs}"
SRC_URI[x86_64_v2_libguestfs.sha256sum] = "f33d50274888634f950e6927995b5981461f03d8d6cd6a94efeec4d534adb67f"

URI_x86_64_v2_libguestfs-appliance = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libguestfs-appliance-1.60.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libguestfs-appliance;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguestfs-appliance}"
SRC_URI[x86_64_v2_libguestfs-appliance.sha256sum] = "39ee1a2af34fc4b572e963404aecee88a33c85fa885a273c8e3db6c18594193b"

URI_x86_64_v2_libguestfs-bash-completion = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libguestfs-bash-completion-1.60.1-1.el10.alma.1.noarch.rpm;name=x86_64_v2_libguestfs-bash-completion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguestfs-bash-completion}"
SRC_URI[x86_64_v2_libguestfs-bash-completion.sha256sum] = "f0b94f0d7549fb02beb2924886d1681392aeefb579d14e0afe19474977c80ab1"

URI_x86_64_v2_libguestfs-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libguestfs-devel-1.60.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libguestfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguestfs-devel}"
SRC_URI[x86_64_v2_libguestfs-devel.sha256sum] = "d0eb2e8a8f4c5740e4bafe1e42fa10436186c812e8b112b3cd9e5744a51f2601"

URI_x86_64_v2_libguestfs-inspect-icons = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libguestfs-inspect-icons-1.60.1-1.el10.alma.1.noarch.rpm;name=x86_64_v2_libguestfs-inspect-icons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguestfs-inspect-icons}"
SRC_URI[x86_64_v2_libguestfs-inspect-icons.sha256sum] = "9004afa6ecb27821d24062590fa91fa64fc85fd4d288921451d85638bca6434c"

URI_x86_64_v2_libguestfs-man-pages-ja = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libguestfs-man-pages-ja-1.60.1-1.el10.alma.1.noarch.rpm;name=x86_64_v2_libguestfs-man-pages-ja;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguestfs-man-pages-ja}"
SRC_URI[x86_64_v2_libguestfs-man-pages-ja.sha256sum] = "b5456562a7d80bca783982399a0cc0650b3e184c12be6d458620fe9015994e6c"

URI_x86_64_v2_libguestfs-man-pages-uk = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libguestfs-man-pages-uk-1.60.1-1.el10.alma.1.noarch.rpm;name=x86_64_v2_libguestfs-man-pages-uk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguestfs-man-pages-uk}"
SRC_URI[x86_64_v2_libguestfs-man-pages-uk.sha256sum] = "5d52309fa5d8b950d9a22e611fd9f60725089db094c31fdb24884c1a59561b32"

URI_x86_64_v2_libguestfs-rescue = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libguestfs-rescue-1.60.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libguestfs-rescue;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguestfs-rescue}"
SRC_URI[x86_64_v2_libguestfs-rescue.sha256sum] = "6912de2983c9b49419597c934b6f8fb8ea3f46fefe3feaa423ca046deb88355a"

URI_x86_64_v2_libguestfs-rsync = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libguestfs-rsync-1.60.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libguestfs-rsync;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguestfs-rsync}"
SRC_URI[x86_64_v2_libguestfs-rsync.sha256sum] = "1141fca8e0e4cfd50479ccc8778c8a2bfd420fcaa160661d8ce2a760a9f21695"

URI_x86_64_v2_libguestfs-xfs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libguestfs-xfs-1.60.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libguestfs-xfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguestfs-xfs}"
SRC_URI[x86_64_v2_libguestfs-xfs.sha256sum] = "6af150442d7183d4ed44616349f6d6e88f2514feb28deeaed10be44abad75a22"

URI_x86_64_v2_ocaml-libguestfs = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ocaml-libguestfs-1.60.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_ocaml-libguestfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ocaml-libguestfs}"
SRC_URI[x86_64_v2_ocaml-libguestfs.sha256sum] = "b16748eafe7d7d45aa6b80f8352914ba8d4ef1534e8fe503122f84c79a6313cd"

URI_x86_64_v2_ocaml-libguestfs-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ocaml-libguestfs-devel-1.60.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_ocaml-libguestfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ocaml-libguestfs-devel}"
SRC_URI[x86_64_v2_ocaml-libguestfs-devel.sha256sum] = "9b1e5ffe1edaf595e80f3f52d175b03401580326ad9fa1bbf419a24e8230e35f"

URI_x86_64_v2_perl-Sys-Guestfs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Sys-Guestfs-1.60.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_perl-Sys-Guestfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sys-Guestfs}"
SRC_URI[x86_64_v2_perl-Sys-Guestfs.sha256sum] = "e81d8013427febb8b67d3fe8224b08eab755c15da615d7fd9e361f975e527f55"

URI_x86_64_v2_python3-libguestfs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libguestfs-1.60.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-libguestfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libguestfs}"
SRC_URI[x86_64_v2_python3-libguestfs.sha256sum] = "11b8abb8cf87172789a7faf5f0610cab70c42b06842ae758504d3279e422c68a"

URI_aarch64_libguestfs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libguestfs-1.60.1-1.el10.alma.1.aarch64.rpm;name=aarch64_libguestfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguestfs}"
SRC_URI[aarch64_libguestfs.sha256sum] = "5cb7d18880c07e05f764b29ba37957d68d3ef4d550d1928a8c7dc378c43de09b"

URI_aarch64_libguestfs-appliance = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libguestfs-appliance-1.60.1-1.el10.alma.1.aarch64.rpm;name=aarch64_libguestfs-appliance;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguestfs-appliance}"
SRC_URI[aarch64_libguestfs-appliance.sha256sum] = "ff70cddc43af0f406ad0b2b596ca7d6b97a5d4d6ac9d430e5af6ff7f72703dce"

URI_aarch64_libguestfs-bash-completion = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libguestfs-bash-completion-1.60.1-1.el10.alma.1.noarch.rpm;name=aarch64_libguestfs-bash-completion;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguestfs-bash-completion}"
SRC_URI[aarch64_libguestfs-bash-completion.sha256sum] = "f0b94f0d7549fb02beb2924886d1681392aeefb579d14e0afe19474977c80ab1"

URI_aarch64_libguestfs-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libguestfs-devel-1.60.1-1.el10.alma.1.aarch64.rpm;name=aarch64_libguestfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguestfs-devel}"
SRC_URI[aarch64_libguestfs-devel.sha256sum] = "0575c88f8eec7b0f4d8ae249763dffaa73cdb67f432c9003fc99f5c541397c0b"

URI_aarch64_libguestfs-inspect-icons = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libguestfs-inspect-icons-1.60.1-1.el10.alma.1.noarch.rpm;name=aarch64_libguestfs-inspect-icons;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguestfs-inspect-icons}"
SRC_URI[aarch64_libguestfs-inspect-icons.sha256sum] = "9004afa6ecb27821d24062590fa91fa64fc85fd4d288921451d85638bca6434c"

URI_aarch64_libguestfs-man-pages-ja = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libguestfs-man-pages-ja-1.60.1-1.el10.alma.1.noarch.rpm;name=aarch64_libguestfs-man-pages-ja;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguestfs-man-pages-ja}"
SRC_URI[aarch64_libguestfs-man-pages-ja.sha256sum] = "b5456562a7d80bca783982399a0cc0650b3e184c12be6d458620fe9015994e6c"

URI_aarch64_libguestfs-man-pages-uk = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libguestfs-man-pages-uk-1.60.1-1.el10.alma.1.noarch.rpm;name=aarch64_libguestfs-man-pages-uk;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguestfs-man-pages-uk}"
SRC_URI[aarch64_libguestfs-man-pages-uk.sha256sum] = "5d52309fa5d8b950d9a22e611fd9f60725089db094c31fdb24884c1a59561b32"

URI_aarch64_libguestfs-rescue = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libguestfs-rescue-1.60.1-1.el10.alma.1.aarch64.rpm;name=aarch64_libguestfs-rescue;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguestfs-rescue}"
SRC_URI[aarch64_libguestfs-rescue.sha256sum] = "f059780a0c4b1efd9f038c8e136cdcbc4095bf937cb829f446b28236ce7aa9c0"

URI_aarch64_libguestfs-rsync = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libguestfs-rsync-1.60.1-1.el10.alma.1.aarch64.rpm;name=aarch64_libguestfs-rsync;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguestfs-rsync}"
SRC_URI[aarch64_libguestfs-rsync.sha256sum] = "3e7ceece9ac5d03ab3a68d393bbcc81b628c9489664cd06c7f494f4662e63e6c"

URI_aarch64_libguestfs-xfs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libguestfs-xfs-1.60.1-1.el10.alma.1.aarch64.rpm;name=aarch64_libguestfs-xfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguestfs-xfs}"
SRC_URI[aarch64_libguestfs-xfs.sha256sum] = "d4673d418360a54559d49dcac10a49bcde7bb02dbad73f04833c206412510f3e"

URI_aarch64_ocaml-libguestfs = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ocaml-libguestfs-1.60.1-1.el10.alma.1.aarch64.rpm;name=aarch64_ocaml-libguestfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ocaml-libguestfs}"
SRC_URI[aarch64_ocaml-libguestfs.sha256sum] = "93222d647da8a3b34f9f3089387d1c90f7f9a7c760bf2a17022c9962c650f776"

URI_aarch64_ocaml-libguestfs-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ocaml-libguestfs-devel-1.60.1-1.el10.alma.1.aarch64.rpm;name=aarch64_ocaml-libguestfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ocaml-libguestfs-devel}"
SRC_URI[aarch64_ocaml-libguestfs-devel.sha256sum] = "9a68be8420928d8703cd0bf82a09b35f3ed40708151591a2fabda3e25f083763"

URI_aarch64_perl-Sys-Guestfs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Sys-Guestfs-1.60.1-1.el10.alma.1.aarch64.rpm;name=aarch64_perl-Sys-Guestfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sys-Guestfs}"
SRC_URI[aarch64_perl-Sys-Guestfs.sha256sum] = "cfdd6e00c5a837a0fc8656a38d63e031bd8b8bc982d94be40e9b3a45757cf173"

URI_aarch64_python3-libguestfs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libguestfs-1.60.1-1.el10.alma.1.aarch64.rpm;name=aarch64_python3-libguestfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libguestfs}"
SRC_URI[aarch64_python3-libguestfs.sha256sum] = "ad41e0cfba850b9e121612a3dc3e6363457df31ab1894831e58a1424d8a7835c"

RDEPENDS:libguestfs:x86_64_v2 = " \
 bash \
 fuse \
 fuse-libs \
 glibc \
 grep \
 hexedit \
 hivex-libs \
 json-c \
 less \
 libacl \
 libcap \
 libconfig \
 libgcc \
 libguestfs-appliance \
 libselinux \
 libtirpc \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-secret \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 libxml2 \
 ncurses-libs \
 passt \
 pcre2 \
 qemu-img \
 qemu-kvm-core \
 readline \
 rpm-libs \
 selinux-policy \
 systemd-libs \
 tar \
 vim-minimal \
 virtual//usr/bin/man \
 virtual/coreutils \
 xz \
"
RDEPENDS:libguestfs:aarch64 = " \
 bash \
 edk2-aarch64 \
 fuse \
 fuse-libs \
 glibc \
 grep \
 hexedit \
 hivex-libs \
 json-c \
 less \
 libacl \
 libconfig \
 libgcc \
 libguestfs-appliance \
 libselinux \
 libtirpc \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-secret \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 libxml2 \
 ncurses-libs \
 passt \
 pcre2 \
 qemu-img \
 qemu-kvm-core \
 readline \
 rpm-libs \
 selinux-policy \
 systemd-libs \
 tar \
 vim-minimal \
 virtual//usr/bin/man \
 virtual/coreutils \
 xz \
"
RDEPENDS:libguestfs-appliance:x86_64_v2 = " \
 acl \
 attr \
 bash \
 binutils \
 bzip2 \
 clevis-luks \
 cpio \
 cryptsetup \
 dhcpcd \
 diffutils \
 dosfstools \
 e2fsprogs \
 file \
 findutils \
 gawk \
 glibc \
 glibc-gconv-extra \
 grep \
 gzip \
 hivex-libs \
 iproute \
 json-c \
 kmod \
 less \
 libacl \
 libcap \
 libgcc \
 libselinux \
 libtirpc \
 libxml2 \
 lsscsi \
 lvm2 \
 lzop \
 mdadm \
 parted \
 pcre2 \
 policycoreutils \
 procps-ng \
 psmisc \
 rpm-libs \
 scrub \
 sed \
 supermin \
 systemd \
 systemd-libs \
 systemd-udev \
 tar \
 util-linux \
 virtual/coreutils \
 virtual/kernel \
 xz \
 zstd \
"
RDEPENDS:libguestfs-appliance:aarch64 = " \
 acl \
 attr \
 bash \
 binutils \
 bzip2 \
 clevis-luks \
 cpio \
 cryptsetup \
 dhcpcd \
 diffutils \
 dosfstools \
 e2fsprogs \
 file \
 findutils \
 gawk \
 glibc \
 glibc-gconv-extra \
 grep \
 gzip \
 hivex-libs \
 iproute \
 json-c \
 kmod \
 less \
 libacl \
 libgcc \
 libselinux \
 libtirpc \
 libxml2 \
 lsscsi \
 lvm2 \
 lzop \
 mdadm \
 parted \
 pcre2 \
 policycoreutils \
 procps-ng \
 psmisc \
 rpm-libs \
 scrub \
 sed \
 supermin \
 systemd \
 systemd-libs \
 systemd-udev \
 tar \
 util-linux \
 virtual/coreutils \
 virtual/kernel \
 xz \
 zstd \
"
RDEPENDS:libguestfs-bash-completion = " \
 bash-completion \
 "
RDEPENDS:libguestfs-devel = " \
 libguestfs \
 pkgconf-pkg-config \
 "
RDEPENDS:libguestfs-inspect-icons = " \
 icoutils \
 libguestfs \
 netpbm-progs \
 "
RDEPENDS:libguestfs-man-pages-ja = " \
 libguestfs \
 "
RDEPENDS:libguestfs-man-pages-uk = " \
 libguestfs \
 "
RDEPENDS:libguestfs-rescue = " \
 glibc \
 iputils \
 libconfig \
 libgcc \
 libguestfs \
 libxml2 \
 lsof \
 openssh-clients \
 pciutils \
 strace \
 vim-minimal \
 "
RDEPENDS:libguestfs-rsync = " \
 libguestfs \
 rsync \
 "
RDEPENDS:libguestfs-xfs = " \
 libguestfs \
 xfsprogs \
 "
RDEPENDS:ocaml-libguestfs = " \
 glibc \
 libguestfs \
 "
RDEPENDS:ocaml-libguestfs-devel = " \
 ocaml-libguestfs \
 "
RDEPENDS:perl-Sys-Guestfs = " \
 glibc \
 libguestfs \
 perl-libs \
 perl-vars \
 "
RDEPENDS:python3-libguestfs = " \
 glibc \
 libguestfs \
 python3 \
 "
