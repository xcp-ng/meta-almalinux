# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-blocking"
PV = "1.6.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-blocking+default-devel \
 rust-blocking+tracing-devel \
 rust-blocking-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-blocking-1.6.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6351ec19e15958b3ab953248e3c3a1ce894ddd80e14337d23a1ecf532ce3f26f"

URI_x86_64_v2_rust-blocking+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blocking+default-devel-1.6.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blocking+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blocking+default-devel}"
SRC_URI[x86_64_v2_rust-blocking+default-devel.sha256sum] = "08b3275c675ed675f987542763c7b792a7d6ee2a8694bce82367a220b553e43f"

URI_x86_64_v2_rust-blocking+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blocking+tracing-devel-1.6.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blocking+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blocking+tracing-devel}"
SRC_URI[x86_64_v2_rust-blocking+tracing-devel.sha256sum] = "47d66e7694e82dc8990955d345aa10f0a1c8cbed6852fa34f5892b002a4485d9"

URI_x86_64_v2_rust-blocking-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blocking-devel-1.6.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blocking-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blocking-devel}"
SRC_URI[x86_64_v2_rust-blocking-devel.sha256sum] = "abbffda23cf03f3bf0c17163d451d82513fb14378ff93412a3b7c555d4502be5"

URI_aarch64_rust-blocking+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blocking+default-devel-1.6.2-1.el10_1.noarch.rpm;name=aarch64_rust-blocking+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blocking+default-devel}"
SRC_URI[aarch64_rust-blocking+default-devel.sha256sum] = "a41cce52b01e4bdbfee996988a21675fdfb053148f8cb9f47712b6928d2a6d59"

URI_aarch64_rust-blocking+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blocking+tracing-devel-1.6.2-1.el10_1.noarch.rpm;name=aarch64_rust-blocking+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blocking+tracing-devel}"
SRC_URI[aarch64_rust-blocking+tracing-devel.sha256sum] = "553ff800d969412322a76052aae00f6c78d7932c536029e7a86e62c6c50016cf"

URI_aarch64_rust-blocking-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blocking-devel-1.6.2-1.el10_1.noarch.rpm;name=aarch64_rust-blocking-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blocking-devel}"
SRC_URI[aarch64_rust-blocking-devel.sha256sum] = "d0db89c864e7726f02dd9af3e9ac944b7c3c77dc15156193e95474e859da72ad"

RDEPENDS:rust-blocking+default-devel = " \
 cargo \
 rust-blocking-devel \
 "
RDEPENDS:rust-blocking+tracing-devel = " \
 cargo \
 rust-blocking-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-blocking-devel = " \
 cargo \
 rust \
 rust-async-channel+default-devel \
 rust-async-task+default-devel \
 rust-futures-io+std-devel \
 rust-futures-io-devel \
 rust-futures-lite-devel \
 rust-piper+default-devel \
 "
