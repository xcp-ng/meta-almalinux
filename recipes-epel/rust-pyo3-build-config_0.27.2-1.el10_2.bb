# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-build-config"
PV = "0.27.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-pyo3-build-config+abi3-devel \
 rust-pyo3-build-config+abi3-py310-devel \
 rust-pyo3-build-config+abi3-py311-devel \
 rust-pyo3-build-config+abi3-py312-devel \
 rust-pyo3-build-config+abi3-py313-devel \
 rust-pyo3-build-config+abi3-py314-devel \
 rust-pyo3-build-config+abi3-py37-devel \
 rust-pyo3-build-config+abi3-py38-devel \
 rust-pyo3-build-config+abi3-py39-devel \
 rust-pyo3-build-config+default-devel \
 rust-pyo3-build-config+extension-module-devel \
 rust-pyo3-build-config+resolve-config-devel \
 rust-pyo3-build-config-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-build-config-0.27.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "61b65edaa218982357b7c5afd55e5b4635f180927ba7ba61fd576d9766749c62"

URI_x86_64_v2_rust-pyo3-build-config+abi3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+abi3-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+abi3-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+abi3-devel.sha256sum] = "95ffb1732e313155000f9d288ce501c90d99b72994f229a3fe0eed783eafc5b2"

URI_x86_64_v2_rust-pyo3-build-config+abi3-py310-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+abi3-py310-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+abi3-py310-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+abi3-py310-devel.sha256sum] = "782d3ff01c88127de2b8d622891d7bc23573d57dafb6dc4c4e27f62047f922f4"

URI_x86_64_v2_rust-pyo3-build-config+abi3-py311-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+abi3-py311-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+abi3-py311-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+abi3-py311-devel.sha256sum] = "a4808509456a9f4245aa9e25b28f6e8cd26a6444d4b7989a51d7e8d639dfb129"

URI_x86_64_v2_rust-pyo3-build-config+abi3-py312-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+abi3-py312-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+abi3-py312-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+abi3-py312-devel.sha256sum] = "d6fa51b85539ba4a70124c9244cd86176c6d4f24ae01ef6008505c31268f8bd6"

URI_x86_64_v2_rust-pyo3-build-config+abi3-py313-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+abi3-py313-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+abi3-py313-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+abi3-py313-devel.sha256sum] = "2175b39a86cd4623414f8022b7ef59edb64d72da671100835913024e7bf16d21"

URI_x86_64_v2_rust-pyo3-build-config+abi3-py314-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+abi3-py314-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+abi3-py314-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+abi3-py314-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+abi3-py314-devel.sha256sum] = "09e13eaf76291fa6785151e7fccba14aebe68e8fb52b81d05dcbed0cbb51f523"

URI_x86_64_v2_rust-pyo3-build-config+abi3-py37-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+abi3-py37-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+abi3-py37-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+abi3-py37-devel.sha256sum] = "508cb1c8cd4d113fbe66783c847e23b7836761a35ee059c38e7d25b668209589"

URI_x86_64_v2_rust-pyo3-build-config+abi3-py38-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+abi3-py38-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+abi3-py38-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+abi3-py38-devel.sha256sum] = "6c575ea327ed94f9571380c529415e9e1c02fa1d1761467a4bd338f2d1dcc010"

URI_x86_64_v2_rust-pyo3-build-config+abi3-py39-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+abi3-py39-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+abi3-py39-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+abi3-py39-devel.sha256sum] = "6a4f009dea7bb985a2cd89b231a51c245b758b3b5f5dc3e9e2cf9bdf2ec4a0be"

URI_x86_64_v2_rust-pyo3-build-config+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+default-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+default-devel.sha256sum] = "75090d7f7dbbb9ed9e54696d54653f71affe28d0a3ec738819473f5d299e880a"

URI_x86_64_v2_rust-pyo3-build-config+extension-module-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+extension-module-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+extension-module-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+extension-module-devel.sha256sum] = "128d47f1d95b3bd2c42dbd926572f869a4d77cffb5f31d6926c09a489f3d4fa1"

URI_x86_64_v2_rust-pyo3-build-config+resolve-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+resolve-config-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+resolve-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+resolve-config-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+resolve-config-devel.sha256sum] = "cf97046589d673fcf9d93996d63c5690af4bf825aab7f5d247229487636cd949"

URI_x86_64_v2_rust-pyo3-build-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config-devel.sha256sum] = "233a13fb6ecf2c1d6ffb8650f94832c9d8f1060a4816e977f233f9c69842ec97"

URI_aarch64_rust-pyo3-build-config+abi3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+abi3-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+abi3-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+abi3-devel.sha256sum] = "b5de58d8234895ecb98db69fd5a99e8b379700d0bcb4c845dcb69179fdc9e947"

URI_aarch64_rust-pyo3-build-config+abi3-py310-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+abi3-py310-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+abi3-py310-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+abi3-py310-devel.sha256sum] = "617a74e562348c1618694eecf760855bc6b7dd6e9a059e36b9dc402397b6239a"

URI_aarch64_rust-pyo3-build-config+abi3-py311-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+abi3-py311-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+abi3-py311-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+abi3-py311-devel.sha256sum] = "24758cdfd42632ff65d60d92b04c731b20ddcfe406a1cffe188c7a8f704abf75"

URI_aarch64_rust-pyo3-build-config+abi3-py312-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+abi3-py312-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+abi3-py312-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+abi3-py312-devel.sha256sum] = "adce37c20f9c022918b63077fd06487ba9197bcba35e378a5ad9c860da1fa55f"

URI_aarch64_rust-pyo3-build-config+abi3-py313-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+abi3-py313-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+abi3-py313-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+abi3-py313-devel.sha256sum] = "9727ff554832d77f50a0d7b264daab4a9288d6e4f3ce0f06b6182df547273a40"

URI_aarch64_rust-pyo3-build-config+abi3-py314-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+abi3-py314-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config+abi3-py314-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+abi3-py314-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+abi3-py314-devel.sha256sum] = "8140602d75026dc393ed5d1ca0f431d548d00bae24a4633a5bb10714fc408a39"

URI_aarch64_rust-pyo3-build-config+abi3-py37-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+abi3-py37-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+abi3-py37-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+abi3-py37-devel.sha256sum] = "499ff5c2615a25463420e2f06637b6c73bdd4216b64ae4ff715e3020c8109920"

URI_aarch64_rust-pyo3-build-config+abi3-py38-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+abi3-py38-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+abi3-py38-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+abi3-py38-devel.sha256sum] = "1733ccad07f3abd14eb00904e246da487ceaf7a521e5babcf8bb19b2695dc79b"

URI_aarch64_rust-pyo3-build-config+abi3-py39-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+abi3-py39-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+abi3-py39-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+abi3-py39-devel.sha256sum] = "7123cc7fe0554ce8c86da9d864a4504fd4adc3c6c69baabd5672ed2b828fb8c9"

URI_aarch64_rust-pyo3-build-config+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+default-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+default-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+default-devel.sha256sum] = "f811d705c85d0488ef9fb03df31d432371800fe2f2fa833d34e3ee9a1563c865"

URI_aarch64_rust-pyo3-build-config+extension-module-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+extension-module-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+extension-module-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+extension-module-devel.sha256sum] = "35ff8f9f4773a484738cc45ab5819afc2dbdfbbecd6dbca09103640dcd2bc0f2"

URI_aarch64_rust-pyo3-build-config+resolve-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+resolve-config-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config+resolve-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+resolve-config-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+resolve-config-devel.sha256sum] = "121b7917e5216e547f4f4fdc87be56c16b4140f0164eb07212506da0142c765d"

URI_aarch64_rust-pyo3-build-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config-devel}"
SRC_URI[aarch64_rust-pyo3-build-config-devel.sha256sum] = "09d38f0f04f82956f74efd995563686e038e28a6adfa35ee7b4aeb9f8807c631"

RDEPENDS:rust-pyo3-build-config+abi3-devel = " \
 cargo \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+abi3-py310-devel = " \
 cargo \
 rust-pyo3-build-config+abi3-py311-devel \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+abi3-py311-devel = " \
 cargo \
 rust-pyo3-build-config+abi3-py312-devel \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+abi3-py312-devel = " \
 cargo \
 rust-pyo3-build-config+abi3-py313-devel \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+abi3-py313-devel = " \
 cargo \
 rust-pyo3-build-config+abi3-py314-devel \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+abi3-py314-devel = " \
 cargo \
 rust-pyo3-build-config+abi3-devel \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+abi3-py37-devel = " \
 cargo \
 rust-pyo3-build-config+abi3-py38-devel \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+abi3-py38-devel = " \
 cargo \
 rust-pyo3-build-config+abi3-py39-devel \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+abi3-py39-devel = " \
 cargo \
 rust-pyo3-build-config+abi3-py310-devel \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+default-devel = " \
 cargo \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+extension-module-devel = " \
 cargo \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+resolve-config-devel = " \
 cargo \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config-devel = " \
 cargo \
 python3 \
 rust \
 rust-target-lexicon+default-devel \
 "
