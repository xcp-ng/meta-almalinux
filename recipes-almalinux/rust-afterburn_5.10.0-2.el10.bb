# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-afterburn"
PV = "5.10.0"
PR = "2.el10"
PACKAGES = " \
 afterburn \
 afterburn-dracut \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rust-afterburn-5.10.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d64347879036ad26ae89b502cf43ca484341b08d0d3e43ef72e18df031ee5292"

URI_x86_64_v2_afterburn = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/afterburn-5.10.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_afterburn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_afterburn}"
SRC_URI[x86_64_v2_afterburn.sha256sum] = "ea83e69bd5113ae282db632ef8e37105f5485be43564e0a5f4aa07d4fe050efc"

URI_x86_64_v2_afterburn-dracut = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/afterburn-dracut-5.10.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_afterburn-dracut;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_afterburn-dracut}"
SRC_URI[x86_64_v2_afterburn-dracut.sha256sum] = "5b125bd65f94138c74a89d340c6de010e2c08a1e322e120e9e8c9cf6bcf86f3a"

URI_aarch64_afterburn = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/afterburn-5.10.0-2.el10.aarch64.rpm;name=aarch64_afterburn;unpack=0"
SRC_URI:append = " ${URI_aarch64_afterburn}"
SRC_URI[aarch64_afterburn.sha256sum] = "6762a6a1fd412585c3b6982cc4815ab0877f26c53e7817adef00eba1d5577a88"

URI_aarch64_afterburn-dracut = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/afterburn-dracut-5.10.0-2.el10.aarch64.rpm;name=aarch64_afterburn-dracut;unpack=0"
SRC_URI:append = " ${URI_aarch64_afterburn-dracut}"
SRC_URI[aarch64_afterburn-dracut.sha256sum] = "fae16a09714500f050edda9ba22da0db207b72b1b1bdba2e1ad80efbbf4cc3df"

RDEPENDS:afterburn = " \
 bash \
 glibc \
 libgcc \
 openssl-libs \
 systemd \
 "
RDEPENDS:afterburn-dracut = " \
 afterburn \
 bash \
 dracut \
 dracut-network \
 "
