# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pulp-glue-deb"
PV = "0.4.3"
PR = "2.el10_2"
PACKAGES = " \
 python3-pulp-glue-deb \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pulp-glue-deb-0.4.3-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "331feb9d133d9bf85fe30ef083495a23a4c2021b053916cfdb607e1d4f987112"

URI_x86_64_v2_python3-pulp-glue-deb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pulp-glue-deb-0.4.3-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pulp-glue-deb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pulp-glue-deb}"
SRC_URI[x86_64_v2_python3-pulp-glue-deb.sha256sum] = "f70640986901967601f1e81c1d9c0d794ea179b42377c242e5aa627b5346d8a5"

URI_aarch64_python3-pulp-glue-deb = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pulp-glue-deb-0.4.3-2.el10_2.noarch.rpm;name=aarch64_python3-pulp-glue-deb;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pulp-glue-deb}"
SRC_URI[aarch64_python3-pulp-glue-deb.sha256sum] = "f18f0086c6d1654f530a4795e7351ad122fe671e95eb79fc3a06cef83686a2cd"

RDEPENDS:python3-pulp-glue-deb = " \
 python3 \
 python3-pulp-glue \
 "
