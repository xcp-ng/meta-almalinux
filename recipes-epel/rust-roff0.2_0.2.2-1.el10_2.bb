# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-roff0.2"
PV = "0.2.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-roff0.2+default-devel \
 rust-roff0.2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-roff0.2-0.2.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "418154d3aefca9c653e90da5213d6afd05aa0bac79e6b7f53fbbfbb6e9846ff0"

URI_x86_64_v2_rust-roff0.2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-roff0.2+default-devel-0.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-roff0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-roff0.2+default-devel}"
SRC_URI[x86_64_v2_rust-roff0.2+default-devel.sha256sum] = "e619b14dab592dff15c3e759e90ed9a2b8de845ab8bd8785fb5d4b7217ef02ac"

URI_x86_64_v2_rust-roff0.2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-roff0.2-devel-0.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-roff0.2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-roff0.2-devel}"
SRC_URI[x86_64_v2_rust-roff0.2-devel.sha256sum] = "036a3a17b016d92294392820c0b8eebe20b2e28ad086870b2f4a3e672ddaad80"

URI_aarch64_rust-roff0.2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-roff0.2+default-devel-0.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-roff0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-roff0.2+default-devel}"
SRC_URI[aarch64_rust-roff0.2+default-devel.sha256sum] = "e8526a69ac5ace0349bb569089df41337e60b2175e0d609f0bdf06059a3ab4c8"

URI_aarch64_rust-roff0.2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-roff0.2-devel-0.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-roff0.2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-roff0.2-devel}"
SRC_URI[aarch64_rust-roff0.2-devel.sha256sum] = "4eab24cd3e262382826cd9cc9047e4ad513c23a7968488f37cbd573eb98682bb"

RDEPENDS:rust-roff0.2+default-devel = " \
 cargo \
 rust-roff0.2-devel \
 "
RDEPENDS:rust-roff0.2-devel = " \
 cargo \
 rust \
 "
