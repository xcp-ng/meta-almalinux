# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-getrandom0.2"
PV = "0.2.16"
PR = "1.el10_1"
PACKAGES = " \
 rust-getrandom0.2+custom-devel \
 rust-getrandom0.2+default-devel \
 rust-getrandom0.2+linux_disable_fallback-devel \
 rust-getrandom0.2+rdrand-devel \
 rust-getrandom0.2+std-devel \
 rust-getrandom0.2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-getrandom0.2-0.2.16-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b94072b8adb611af1ffbfa7787437c7d2c832cdb7b9b8a5b531a1351b623cf9f"

URI_x86_64_v2_rust-getrandom0.2+custom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom0.2+custom-devel-0.2.16-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom0.2+custom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom0.2+custom-devel}"
SRC_URI[x86_64_v2_rust-getrandom0.2+custom-devel.sha256sum] = "1db77c9aa6fbeb7e4223301857623d51447ac2998c392ceb0f367171f3509a0c"

URI_x86_64_v2_rust-getrandom0.2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom0.2+default-devel-0.2.16-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom0.2+default-devel}"
SRC_URI[x86_64_v2_rust-getrandom0.2+default-devel.sha256sum] = "5120f44acb4c7771ba916220c7b9f950d8b34b40db2c6415e173f00aa78d137d"

URI_x86_64_v2_rust-getrandom0.2+linux_disable_fallback-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom0.2+linux_disable_fallback-devel-0.2.16-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom0.2+linux_disable_fallback-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom0.2+linux_disable_fallback-devel}"
SRC_URI[x86_64_v2_rust-getrandom0.2+linux_disable_fallback-devel.sha256sum] = "27764ea132ecec104a53024f5bcf70db4a62f8698042b0e9ce4165ecabf6186d"

URI_x86_64_v2_rust-getrandom0.2+rdrand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom0.2+rdrand-devel-0.2.16-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom0.2+rdrand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom0.2+rdrand-devel}"
SRC_URI[x86_64_v2_rust-getrandom0.2+rdrand-devel.sha256sum] = "2e489de2aa399cd563d35f903e5cdf431df9d7efcb48d42b45f69cf088451130"

URI_x86_64_v2_rust-getrandom0.2+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom0.2+std-devel-0.2.16-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom0.2+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom0.2+std-devel}"
SRC_URI[x86_64_v2_rust-getrandom0.2+std-devel.sha256sum] = "b685d262784e7b08722ddf360deeb0841c415708acd5573dd22fad551c97fa51"

URI_x86_64_v2_rust-getrandom0.2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom0.2-devel-0.2.16-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom0.2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom0.2-devel}"
SRC_URI[x86_64_v2_rust-getrandom0.2-devel.sha256sum] = "a5efcc794ff10658101af35aca1a755d9b55e15d65394e42a6d0a1887055f37e"

URI_aarch64_rust-getrandom0.2+custom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom0.2+custom-devel-0.2.16-1.el10_1.noarch.rpm;name=aarch64_rust-getrandom0.2+custom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom0.2+custom-devel}"
SRC_URI[aarch64_rust-getrandom0.2+custom-devel.sha256sum] = "c3be3cc5a63e8510fb8821532ac152f2cfd98f2132014fae00506569c77c3d05"

URI_aarch64_rust-getrandom0.2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom0.2+default-devel-0.2.16-1.el10_1.noarch.rpm;name=aarch64_rust-getrandom0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom0.2+default-devel}"
SRC_URI[aarch64_rust-getrandom0.2+default-devel.sha256sum] = "d5f730f5c46eeb2ef34dfa084a94a8a889622060be3d7d7a9f926876691edbb8"

URI_aarch64_rust-getrandom0.2+linux_disable_fallback-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom0.2+linux_disable_fallback-devel-0.2.16-1.el10_1.noarch.rpm;name=aarch64_rust-getrandom0.2+linux_disable_fallback-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom0.2+linux_disable_fallback-devel}"
SRC_URI[aarch64_rust-getrandom0.2+linux_disable_fallback-devel.sha256sum] = "8e2cce2c15fda8aa546c86e65b578de2c10235e67b85405c3d2576184cc5c060"

URI_aarch64_rust-getrandom0.2+rdrand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom0.2+rdrand-devel-0.2.16-1.el10_1.noarch.rpm;name=aarch64_rust-getrandom0.2+rdrand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom0.2+rdrand-devel}"
SRC_URI[aarch64_rust-getrandom0.2+rdrand-devel.sha256sum] = "668ad3312d405544cf19b47c00c63b4b3fa501b2776ea405f5b8c7884f4a23f9"

URI_aarch64_rust-getrandom0.2+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom0.2+std-devel-0.2.16-1.el10_1.noarch.rpm;name=aarch64_rust-getrandom0.2+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom0.2+std-devel}"
SRC_URI[aarch64_rust-getrandom0.2+std-devel.sha256sum] = "5e1f6c357db097abf2e15c46efd5c92d9a2504a5f63a683859f1adc0c2da903d"

URI_aarch64_rust-getrandom0.2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom0.2-devel-0.2.16-1.el10_1.noarch.rpm;name=aarch64_rust-getrandom0.2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom0.2-devel}"
SRC_URI[aarch64_rust-getrandom0.2-devel.sha256sum] = "60c4de1771d67356d6099671bf67e696e329991e7d11a1b9274dda3b3a03a140"

RDEPENDS:rust-getrandom0.2+custom-devel = " \
 cargo \
 rust-getrandom0.2-devel \
 "
RDEPENDS:rust-getrandom0.2+default-devel = " \
 cargo \
 rust-getrandom0.2-devel \
 "
RDEPENDS:rust-getrandom0.2+linux_disable_fallback-devel = " \
 cargo \
 rust-getrandom0.2-devel \
 "
RDEPENDS:rust-getrandom0.2+rdrand-devel = " \
 cargo \
 rust-getrandom0.2-devel \
 "
RDEPENDS:rust-getrandom0.2+std-devel = " \
 cargo \
 rust-getrandom0.2-devel \
 "
RDEPENDS:rust-getrandom0.2-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 rust-libc-devel \
 "
