# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-potential_utf"
PV = "0.1.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-potential_utf+alloc-devel \
 rust-potential_utf+databake-devel \
 rust-potential_utf+default-devel \
 rust-potential_utf+serde-devel \
 rust-potential_utf+writeable-devel \
 rust-potential_utf+zerovec-devel \
 rust-potential_utf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-potential_utf-0.1.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ac57cb80444b584094431ebbca037c2d571dd044a6b3902332a2ce5e23401cb"

URI_x86_64_v2_rust-potential_utf+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-potential_utf+alloc-devel-0.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-potential_utf+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-potential_utf+alloc-devel}"
SRC_URI[x86_64_v2_rust-potential_utf+alloc-devel.sha256sum] = "0fef68ecb49f32c2740f4f1ce70bcae69f9b828d9b33a7e711fbc3ac0865d65e"

URI_x86_64_v2_rust-potential_utf+databake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-potential_utf+databake-devel-0.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-potential_utf+databake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-potential_utf+databake-devel}"
SRC_URI[x86_64_v2_rust-potential_utf+databake-devel.sha256sum] = "7182dce9b609270cf7d9e8fa2ace4c1cdcf22883f9f49f37a1dfc15822d5d42b"

URI_x86_64_v2_rust-potential_utf+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-potential_utf+default-devel-0.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-potential_utf+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-potential_utf+default-devel}"
SRC_URI[x86_64_v2_rust-potential_utf+default-devel.sha256sum] = "66077639e346020b16232626e7d35f239f5f3117cc46ec0f9d1ab62937758a60"

URI_x86_64_v2_rust-potential_utf+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-potential_utf+serde-devel-0.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-potential_utf+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-potential_utf+serde-devel}"
SRC_URI[x86_64_v2_rust-potential_utf+serde-devel.sha256sum] = "72c0ab21796c132884b9f32fd4588f8ca2a8c14718d54d75f1fbcb7cb842203c"

URI_x86_64_v2_rust-potential_utf+writeable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-potential_utf+writeable-devel-0.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-potential_utf+writeable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-potential_utf+writeable-devel}"
SRC_URI[x86_64_v2_rust-potential_utf+writeable-devel.sha256sum] = "a73a66d0862a69601d6588177ec71428f51dcc515d18a74bc9beabdd3c56283d"

URI_x86_64_v2_rust-potential_utf+zerovec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-potential_utf+zerovec-devel-0.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-potential_utf+zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-potential_utf+zerovec-devel}"
SRC_URI[x86_64_v2_rust-potential_utf+zerovec-devel.sha256sum] = "2156de929b31c3dfe733ba3656775b090bf9f94c048487121e0cdc61ec7dbc25"

URI_x86_64_v2_rust-potential_utf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-potential_utf-devel-0.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-potential_utf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-potential_utf-devel}"
SRC_URI[x86_64_v2_rust-potential_utf-devel.sha256sum] = "5774d0857cbf04d4b5f5f9d1b16f03669fb4572f05d90b0462a55cbecec49bd6"

URI_aarch64_rust-potential_utf+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-potential_utf+alloc-devel-0.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-potential_utf+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-potential_utf+alloc-devel}"
SRC_URI[aarch64_rust-potential_utf+alloc-devel.sha256sum] = "b83fc44ccc0c2a6f1ad82fa66eb948fbb2a2823b66911aae8844fd7047aba23a"

URI_aarch64_rust-potential_utf+databake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-potential_utf+databake-devel-0.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-potential_utf+databake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-potential_utf+databake-devel}"
SRC_URI[aarch64_rust-potential_utf+databake-devel.sha256sum] = "0fefc9f108f9def0c733d341305ec44338c7d587aeffd80ee293d79f88539a12"

URI_aarch64_rust-potential_utf+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-potential_utf+default-devel-0.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-potential_utf+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-potential_utf+default-devel}"
SRC_URI[aarch64_rust-potential_utf+default-devel.sha256sum] = "386c9a47ab77a452ab2add581028bfed3e1ca6c8ed584058466e67c030547230"

URI_aarch64_rust-potential_utf+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-potential_utf+serde-devel-0.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-potential_utf+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-potential_utf+serde-devel}"
SRC_URI[aarch64_rust-potential_utf+serde-devel.sha256sum] = "35e0ad0c1cd11c3dca52d4b629c419e80ce4f010db51a646b43cd5e23e4409aa"

URI_aarch64_rust-potential_utf+writeable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-potential_utf+writeable-devel-0.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-potential_utf+writeable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-potential_utf+writeable-devel}"
SRC_URI[aarch64_rust-potential_utf+writeable-devel.sha256sum] = "e163d249c7ddc8c59abbf9a1cc6fa6827c0e86c6fa0481fe9690fabffd360e5f"

URI_aarch64_rust-potential_utf+zerovec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-potential_utf+zerovec-devel-0.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-potential_utf+zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-potential_utf+zerovec-devel}"
SRC_URI[aarch64_rust-potential_utf+zerovec-devel.sha256sum] = "323e9f5a697c769d2bd0b1063367bd43681f3a182d921b02e5be6ddf339a5317"

URI_aarch64_rust-potential_utf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-potential_utf-devel-0.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-potential_utf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-potential_utf-devel}"
SRC_URI[aarch64_rust-potential_utf-devel.sha256sum] = "cf604c521e596b5cd014f3f657a099fd9e22ab42cba73571a4b355560bf86662"

RDEPENDS:rust-potential_utf+alloc-devel = " \
 cargo \
 rust-potential_utf-devel \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 rust-writeable+alloc-devel \
 rust-writeable-devel \
 rust-zerovec+alloc-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-potential_utf+databake-devel = " \
 cargo \
 rust-databake-devel \
 rust-potential_utf-devel \
 "
RDEPENDS:rust-potential_utf+default-devel = " \
 cargo \
 rust-potential_utf+alloc-devel \
 rust-potential_utf-devel \
 "
RDEPENDS:rust-potential_utf+serde-devel = " \
 cargo \
 rust-potential_utf-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-potential_utf+writeable-devel = " \
 cargo \
 rust-potential_utf-devel \
 rust-writeable-devel \
 "
RDEPENDS:rust-potential_utf+zerovec-devel = " \
 cargo \
 rust-potential_utf-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-potential_utf-devel = " \
 cargo \
 rust \
 "
