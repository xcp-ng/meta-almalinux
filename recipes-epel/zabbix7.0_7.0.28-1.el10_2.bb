# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zabbix7.0"
PV = "7.0.28"
PR = "1.el10_2"
PACKAGES = " \
 zabbix7.0 \
 zabbix7.0-agent \
 zabbix7.0-dbfiles-mysql \
 zabbix7.0-dbfiles-pgsql \
 zabbix7.0-dbfiles-sqlite3 \
 zabbix7.0-proxy \
 zabbix7.0-proxy-mysql \
 zabbix7.0-proxy-pgsql \
 zabbix7.0-proxy-sqlite3 \
 zabbix7.0-selinux \
 zabbix7.0-server \
 zabbix7.0-server-mysql \
 zabbix7.0-server-pgsql \
 zabbix7.0-web \
 zabbix7.0-web-mysql \
 zabbix7.0-web-pgsql \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/z/zabbix7.0-7.0.28-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c8f2161e4de80792831d3b8b5a774e783f320f1380d344a988a6fc2c1e4d125"

URI_x86_64_v2_zabbix7.0 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-7.0.28-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zabbix7.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0}"
SRC_URI[x86_64_v2_zabbix7.0.sha256sum] = "7b4ee744035dfcc0d737747dd8ace5cdd5d27d5616650d8a4dda0b66b38c3960"

URI_x86_64_v2_zabbix7.0-agent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-agent-7.0.28-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zabbix7.0-agent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-agent}"
SRC_URI[x86_64_v2_zabbix7.0-agent.sha256sum] = "1c904690beb7a578e8189888bff3642215ef323874135952e969a59b8336568f"

URI_x86_64_v2_zabbix7.0-dbfiles-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-dbfiles-mysql-7.0.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-dbfiles-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-dbfiles-mysql}"
SRC_URI[x86_64_v2_zabbix7.0-dbfiles-mysql.sha256sum] = "f9b88d065fe8703d9591a35596d6c7d90abf59e2de33cf9b8673221c08431598"

URI_x86_64_v2_zabbix7.0-dbfiles-pgsql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-dbfiles-pgsql-7.0.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-dbfiles-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-dbfiles-pgsql}"
SRC_URI[x86_64_v2_zabbix7.0-dbfiles-pgsql.sha256sum] = "11a0314171b6f670ee0ac32dffe3c5158ea616e119a3f3fa2b9a5874d4164892"

URI_x86_64_v2_zabbix7.0-dbfiles-sqlite3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-dbfiles-sqlite3-7.0.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-dbfiles-sqlite3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-dbfiles-sqlite3}"
SRC_URI[x86_64_v2_zabbix7.0-dbfiles-sqlite3.sha256sum] = "b77e69d58fc16d6914c24daa479df1578a83a7de8879ac118f2a76cf24f5dc9b"

URI_x86_64_v2_zabbix7.0-proxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-proxy-7.0.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-proxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-proxy}"
SRC_URI[x86_64_v2_zabbix7.0-proxy.sha256sum] = "b571c6a68a5f91ad8a895112494c4bf6198915d5f89ce1d5f2051411930eacbf"

URI_x86_64_v2_zabbix7.0-proxy-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-proxy-mysql-7.0.28-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zabbix7.0-proxy-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-proxy-mysql}"
SRC_URI[x86_64_v2_zabbix7.0-proxy-mysql.sha256sum] = "f9fa9f95eadfbfd14c22517d2718d07df44d2438f3c462fc649d4448abe03a56"
RPROVIDES:zabbix7.0-proxy-mysql:x86_64_v2 = "virtual/zabbix7.0-proxy-implementation_eq_7.0.28-1.el10_2.alma_altarch"

URI_x86_64_v2_zabbix7.0-proxy-pgsql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-proxy-pgsql-7.0.28-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zabbix7.0-proxy-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-proxy-pgsql}"
SRC_URI[x86_64_v2_zabbix7.0-proxy-pgsql.sha256sum] = "cdba0be53678fba5023caedfbda4f9189f82b53c6ef88475dc9392aa0a7b8f2f"
RPROVIDES:zabbix7.0-proxy-pgsql:x86_64_v2 = "virtual/zabbix7.0-proxy-implementation_eq_7.0.28-1.el10_2.alma_altarch"

URI_x86_64_v2_zabbix7.0-proxy-sqlite3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-proxy-sqlite3-7.0.28-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zabbix7.0-proxy-sqlite3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-proxy-sqlite3}"
SRC_URI[x86_64_v2_zabbix7.0-proxy-sqlite3.sha256sum] = "bdb229c6ff89f992055e5fb1b1be5abc7f684b4debff964d674e3900d347b2d2"
RPROVIDES:zabbix7.0-proxy-sqlite3:x86_64_v2 = "virtual/zabbix7.0-proxy-implementation_eq_7.0.28-1.el10_2.alma_altarch"

URI_x86_64_v2_zabbix7.0-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-selinux-7.0.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-selinux}"
SRC_URI[x86_64_v2_zabbix7.0-selinux.sha256sum] = "772981730f05de134d8bcbfb2ae3c40114eb74e3c2561e5951c25c90617f5ade"

URI_x86_64_v2_zabbix7.0-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-server-7.0.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-server}"
SRC_URI[x86_64_v2_zabbix7.0-server.sha256sum] = "48988ed2d70789f75e15b38c3ba610cecc7899970263052466ae695e0844bbb0"

URI_x86_64_v2_zabbix7.0-server-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-server-mysql-7.0.28-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zabbix7.0-server-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-server-mysql}"
SRC_URI[x86_64_v2_zabbix7.0-server-mysql.sha256sum] = "c5a4cb477aeaab44448f58ae14d8e1089797b471911cdce622b408df79811b76"
RPROVIDES:zabbix7.0-server-mysql:x86_64_v2 = "virtual/zabbix7.0-server-implementation_eq_7.0.28-1.el10_2.alma_altarch"

URI_x86_64_v2_zabbix7.0-server-pgsql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-server-pgsql-7.0.28-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zabbix7.0-server-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-server-pgsql}"
SRC_URI[x86_64_v2_zabbix7.0-server-pgsql.sha256sum] = "48fc5a24e4abadfbf45a742837b7ad2b29a1614989cb3c25016c8772e64c7897"
RPROVIDES:zabbix7.0-server-pgsql:x86_64_v2 = "virtual/zabbix7.0-server-implementation_eq_7.0.28-1.el10_2.alma_altarch"

URI_x86_64_v2_zabbix7.0-web = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-web-7.0.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-web;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-web}"
SRC_URI[x86_64_v2_zabbix7.0-web.sha256sum] = "a030908f00b9154657064834a7ee8c28dc5e57b24bc7c7b8c6d4ba59a6068a7f"

URI_x86_64_v2_zabbix7.0-web-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-web-mysql-7.0.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-web-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-web-mysql}"
SRC_URI[x86_64_v2_zabbix7.0-web-mysql.sha256sum] = "ae5d25e40baf493143338ad1ac862a25f7c7bdfae8749a2e3af46058930a409c"
RPROVIDES:zabbix7.0-web-mysql:x86_64_v2 = "virtual/zabbix7.0-web-database_eq_7.0.28-1.el10_2.alma_altarch"

URI_x86_64_v2_zabbix7.0-web-pgsql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-web-pgsql-7.0.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-web-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-web-pgsql}"
SRC_URI[x86_64_v2_zabbix7.0-web-pgsql.sha256sum] = "e66ac25988e372aa96ce173faaea8a981a5b744a0e6dddaca440c5e59ebe980a"
RPROVIDES:zabbix7.0-web-pgsql:x86_64_v2 = "virtual/zabbix7.0-web-database_eq_7.0.28-1.el10_2.alma_altarch"

URI_aarch64_zabbix7.0 = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-7.0.28-1.el10_2.aarch64.rpm;name=aarch64_zabbix7.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0}"
SRC_URI[aarch64_zabbix7.0.sha256sum] = "f34ab22f246298925b57c24ddb56d1b3bf3dc11600e821a2ce207677c4b7c8d0"

URI_aarch64_zabbix7.0-agent = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-agent-7.0.28-1.el10_2.aarch64.rpm;name=aarch64_zabbix7.0-agent;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-agent}"
SRC_URI[aarch64_zabbix7.0-agent.sha256sum] = "11d6094caaf23d83b32f04cafa8bea97dcf0e02f5c6423fefe770f629a1f07f8"

URI_aarch64_zabbix7.0-dbfiles-mysql = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-dbfiles-mysql-7.0.28-1.el10_2.noarch.rpm;name=aarch64_zabbix7.0-dbfiles-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-dbfiles-mysql}"
SRC_URI[aarch64_zabbix7.0-dbfiles-mysql.sha256sum] = "f0bccdf9736a7eceb8cecaa7c92af73479c8289df4a3c9c1fabf32f00260a742"

URI_aarch64_zabbix7.0-dbfiles-pgsql = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-dbfiles-pgsql-7.0.28-1.el10_2.noarch.rpm;name=aarch64_zabbix7.0-dbfiles-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-dbfiles-pgsql}"
SRC_URI[aarch64_zabbix7.0-dbfiles-pgsql.sha256sum] = "c74320e6cd0f531578186fcb51669cc32c5d94dba9c3d325e31619daba8173d3"

URI_aarch64_zabbix7.0-dbfiles-sqlite3 = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-dbfiles-sqlite3-7.0.28-1.el10_2.noarch.rpm;name=aarch64_zabbix7.0-dbfiles-sqlite3;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-dbfiles-sqlite3}"
SRC_URI[aarch64_zabbix7.0-dbfiles-sqlite3.sha256sum] = "2ce3d8791fa5a7c70f94a0363ed6cdfa742828e888fd90f70819bfad85d82e1f"

URI_aarch64_zabbix7.0-proxy = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-proxy-7.0.28-1.el10_2.noarch.rpm;name=aarch64_zabbix7.0-proxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-proxy}"
SRC_URI[aarch64_zabbix7.0-proxy.sha256sum] = "420aaaee91a7ef8249f5f8eeb1d4b5f93d0f58fe374af6e029dd7c551376da31"

URI_aarch64_zabbix7.0-proxy-mysql = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-proxy-mysql-7.0.28-1.el10_2.aarch64.rpm;name=aarch64_zabbix7.0-proxy-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-proxy-mysql}"
SRC_URI[aarch64_zabbix7.0-proxy-mysql.sha256sum] = "20c4f8eceaae8a4a059a5364478773cdd46eab9ccda258e89c835791717175b4"
RPROVIDES:zabbix7.0-proxy-mysql:aarch64 = "virtual/zabbix7.0-proxy-implementation_eq_7.0.28-1.el10_2"

URI_aarch64_zabbix7.0-proxy-pgsql = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-proxy-pgsql-7.0.28-1.el10_2.aarch64.rpm;name=aarch64_zabbix7.0-proxy-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-proxy-pgsql}"
SRC_URI[aarch64_zabbix7.0-proxy-pgsql.sha256sum] = "5d5b74d6f833156ea9cbf9b1ad786a70b81d3457dbd84696ed9e51388f268952"
RPROVIDES:zabbix7.0-proxy-pgsql:aarch64 = "virtual/zabbix7.0-proxy-implementation_eq_7.0.28-1.el10_2"

URI_aarch64_zabbix7.0-proxy-sqlite3 = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-proxy-sqlite3-7.0.28-1.el10_2.aarch64.rpm;name=aarch64_zabbix7.0-proxy-sqlite3;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-proxy-sqlite3}"
SRC_URI[aarch64_zabbix7.0-proxy-sqlite3.sha256sum] = "9098f387fe7e6c3eb516d659e8b05d8d1b5909250eab09d5e8be282a35730dab"
RPROVIDES:zabbix7.0-proxy-sqlite3:aarch64 = "virtual/zabbix7.0-proxy-implementation_eq_7.0.28-1.el10_2"

URI_aarch64_zabbix7.0-selinux = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-selinux-7.0.28-1.el10_2.noarch.rpm;name=aarch64_zabbix7.0-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-selinux}"
SRC_URI[aarch64_zabbix7.0-selinux.sha256sum] = "045535e8f014231ffea6ccb766478aa87750f83c44fa44ca6de21fcc564f1c01"

URI_aarch64_zabbix7.0-server = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-server-7.0.28-1.el10_2.noarch.rpm;name=aarch64_zabbix7.0-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-server}"
SRC_URI[aarch64_zabbix7.0-server.sha256sum] = "f08ae1b4d7481403e0e29c26061e63f65c83be6c7a21482e226067a4e59de221"

URI_aarch64_zabbix7.0-server-mysql = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-server-mysql-7.0.28-1.el10_2.aarch64.rpm;name=aarch64_zabbix7.0-server-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-server-mysql}"
SRC_URI[aarch64_zabbix7.0-server-mysql.sha256sum] = "e944dd4ee4e848c1b51a445c7f09a477b78e8c59ab1864f53e8abf4ec1d57d8a"
RPROVIDES:zabbix7.0-server-mysql:aarch64 = "virtual/zabbix7.0-server-implementation_eq_7.0.28-1.el10_2"

URI_aarch64_zabbix7.0-server-pgsql = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-server-pgsql-7.0.28-1.el10_2.aarch64.rpm;name=aarch64_zabbix7.0-server-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-server-pgsql}"
SRC_URI[aarch64_zabbix7.0-server-pgsql.sha256sum] = "abd2b5dd61edfc6905d04645024b404d4652ed847b13c6b2d05d1492da8905c9"
RPROVIDES:zabbix7.0-server-pgsql:aarch64 = "virtual/zabbix7.0-server-implementation_eq_7.0.28-1.el10_2"

URI_aarch64_zabbix7.0-web = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-web-7.0.28-1.el10_2.noarch.rpm;name=aarch64_zabbix7.0-web;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-web}"
SRC_URI[aarch64_zabbix7.0-web.sha256sum] = "8e5c0fb0346a6998f1f1b9d55e4de4941f3ffbbfad892c1124d8125542292d2b"

URI_aarch64_zabbix7.0-web-mysql = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-web-mysql-7.0.28-1.el10_2.noarch.rpm;name=aarch64_zabbix7.0-web-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-web-mysql}"
SRC_URI[aarch64_zabbix7.0-web-mysql.sha256sum] = "323e9996dea01e4b43bd25586398d86036450a0625c0c26e13051d9c23d06277"
RPROVIDES:zabbix7.0-web-mysql:aarch64 = "virtual/zabbix7.0-web-database_eq_7.0.28-1.el10_2"

URI_aarch64_zabbix7.0-web-pgsql = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-web-pgsql-7.0.28-1.el10_2.noarch.rpm;name=aarch64_zabbix7.0-web-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-web-pgsql}"
SRC_URI[aarch64_zabbix7.0-web-pgsql.sha256sum] = "4b0ab809c0476fe2b881df537a9dd2e32f5a92f309818a3b0556c1750e312dd4"
RPROVIDES:zabbix7.0-web-pgsql:aarch64 = "virtual/zabbix7.0-web-database_eq_7.0.28-1.el10_2"

RDEPENDS:zabbix7.0 = " \
 glibc \
 libxml2 \
 logrotate \
 openssl-libs \
 pcre2 \
 virtual/libcurl.so.4___64bit_ \
 zabbix7.0-selinux \
 zlib-ng-compat \
 "
RDEPENDS:zabbix7.0-agent = " \
 bash \
 glibc \
 openldap \
 openssl-libs \
 pcre2 \
 shadow-utils \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 zabbix7.0 \
 zlib-ng-compat \
 "
RDEPENDS:zabbix7.0-dbfiles-mysql = " \
 "
RDEPENDS:zabbix7.0-dbfiles-pgsql = " \
 "
RDEPENDS:zabbix7.0-dbfiles-sqlite3 = " \
 "
RDEPENDS:zabbix7.0-proxy:x86_64_v2 = " \
 bash \
 fping \
 shadow-utils \
 systemd \
 virtual/zabbix7.0-proxy-implementation_eq_7.0.28-1.el10_2.alma_altarch \
 zabbix7.0 \
"
RDEPENDS:zabbix7.0-proxy:aarch64 = " \
 bash \
 fping \
 shadow-utils \
 systemd \
 virtual/zabbix7.0-proxy-implementation_eq_7.0.28-1.el10_2 \
 zabbix7.0 \
"
RDEPENDS:zabbix7.0-proxy-mysql = " \
 OpenIPMI-libs \
 alternatives \
 bash \
 glibc \
 libevent \
 libssh2 \
 libxml2 \
 mariadb-connector-c \
 net-snmp-libs \
 openldap \
 openssl-libs \
 pcre2 \
 unixODBC \
 virtual/libcurl.so.4___64bit_ \
 zabbix7.0-dbfiles-mysql \
 zabbix7.0-proxy \
 zlib-ng-compat \
 "
RDEPENDS:zabbix7.0-proxy-pgsql = " \
 OpenIPMI-libs \
 alternatives \
 bash \
 glibc \
 libevent \
 libpq \
 libssh2 \
 libxml2 \
 net-snmp-libs \
 openldap \
 openssl-libs \
 pcre2 \
 unixODBC \
 virtual/libcurl.so.4___64bit_ \
 zabbix7.0-dbfiles-pgsql \
 zabbix7.0-proxy \
 zlib-ng-compat \
 "
RDEPENDS:zabbix7.0-proxy-sqlite3 = " \
 OpenIPMI-libs \
 alternatives \
 bash \
 glibc \
 libevent \
 libssh2 \
 libxml2 \
 net-snmp-libs \
 openldap \
 openssl-libs \
 pcre2 \
 sqlite-libs \
 unixODBC \
 virtual/libcurl.so.4___64bit_ \
 zabbix7.0-dbfiles-sqlite3 \
 zabbix7.0-proxy \
 zlib-ng-compat \
 "
RDEPENDS:zabbix7.0-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:zabbix7.0-server:x86_64_v2 = " \
 bash \
 fping \
 shadow-utils \
 systemd \
 traceroute \
 virtual/zabbix7.0-server-implementation_eq_7.0.28-1.el10_2.alma_altarch \
 zabbix7.0 \
"
RDEPENDS:zabbix7.0-server:aarch64 = " \
 bash \
 fping \
 shadow-utils \
 systemd \
 traceroute \
 virtual/zabbix7.0-server-implementation_eq_7.0.28-1.el10_2 \
 zabbix7.0 \
"
RDEPENDS:zabbix7.0-server-mysql = " \
 OpenIPMI-libs \
 alternatives \
 bash \
 glibc \
 libevent \
 libssh2 \
 libxml2 \
 mariadb-connector-c \
 net-snmp-libs \
 openldap \
 openssl-libs \
 pcre2 \
 unixODBC \
 virtual/libcurl.so.4___64bit_ \
 zabbix7.0 \
 zabbix7.0-dbfiles-mysql \
 zabbix7.0-server \
 zlib-ng-compat \
 "
RDEPENDS:zabbix7.0-server-pgsql = " \
 OpenIPMI-libs \
 alternatives \
 bash \
 glibc \
 libevent \
 libpq \
 libssh2 \
 libxml2 \
 net-snmp-libs \
 openldap \
 openssl-libs \
 pcre2 \
 unixODBC \
 virtual/libcurl.so.4___64bit_ \
 zabbix7.0 \
 zabbix7.0-dbfiles-pgsql \
 zabbix7.0-server \
 zlib-ng-compat \
 "
RDEPENDS:zabbix7.0-web:x86_64_v2 = " \
 bash \
 dejavu-sans-fonts \
 js-jquery \
 virtual/php-bcmath \
 virtual/php-fpm_ge_8.0 \
 virtual/php-gd \
 virtual/php-gettext \
 virtual/php-json \
 virtual/php-ldap \
 virtual/php-mbstring \
 virtual/php-xml \
 virtual/zabbix7.0-web-database_eq_7.0.28-1.el10_2.alma_altarch \
 zabbix7.0 \
"
RDEPENDS:zabbix7.0-web:aarch64 = " \
 bash \
 dejavu-sans-fonts \
 js-jquery \
 virtual/php-bcmath \
 virtual/php-fpm_ge_8.0 \
 virtual/php-gd \
 virtual/php-gettext \
 virtual/php-json \
 virtual/php-ldap \
 virtual/php-mbstring \
 virtual/php-xml \
 virtual/zabbix7.0-web-database_eq_7.0.28-1.el10_2 \
 zabbix7.0 \
"
RDEPENDS:zabbix7.0-web-mysql = " \
 virtual/php-mysqli \
 zabbix7.0-web \
 "
RDEPENDS:zabbix7.0-web-pgsql = " \
 virtual/php-pgsql \
 zabbix7.0-web \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/zabbix7.0-proxy-implementation_eq_7.0.28-1.el10_2.alma_altarch rpm/virtual/zabbix7.0-server-implementation_eq_7.0.28-1.el10_2.alma_altarch rpm/virtual/zabbix7.0-web-database_eq_7.0.28-1.el10_2.alma_altarch"

PROVIDES:append:aarch64 = " rpm/virtual/zabbix7.0-proxy-implementation_eq_7.0.28-1.el10_2 rpm/virtual/zabbix7.0-server-implementation_eq_7.0.28-1.el10_2 rpm/virtual/zabbix7.0-web-database_eq_7.0.28-1.el10_2"
