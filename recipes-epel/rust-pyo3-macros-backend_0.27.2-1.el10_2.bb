# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-macros-backend"
PV = "0.27.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-pyo3-macros-backend+default-devel \
 rust-pyo3-macros-backend+experimental-async-devel \
 rust-pyo3-macros-backend+experimental-inspect-devel \
 rust-pyo3-macros-backend-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-macros-backend-0.27.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "79adb52b2e7759ba421a3bc448fd699ec3b4a4e23b8dc95968da4d83931db73c"

URI_x86_64_v2_rust-pyo3-macros-backend+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend+default-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend+default-devel.sha256sum] = "7ca6e3402e21eb4dc388bc90001e12e15e3b27668e8397cc259e3782e6f844ae"

URI_x86_64_v2_rust-pyo3-macros-backend+experimental-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend+experimental-async-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend+experimental-async-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend+experimental-async-devel.sha256sum] = "53faff0784ed6a4ca9e39e413df8f849687182a4482e6d60893b2900de5f450b"

URI_x86_64_v2_rust-pyo3-macros-backend+experimental-inspect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend+experimental-inspect-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend+experimental-inspect-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend+experimental-inspect-devel.sha256sum] = "f42b2acc11fc3212c82ef35caf7e8bc665eaecaa7aea4d538b17c6a6b8f9a503"

URI_x86_64_v2_rust-pyo3-macros-backend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend-devel.sha256sum] = "3a67f296752c0380ad38e63265edea8972489d3826607fe936a95c170865810d"

URI_aarch64_rust-pyo3-macros-backend+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend+default-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-macros-backend+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend+default-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend+default-devel.sha256sum] = "a18a7f601521f22c93e20f40c4e84ea655b90666c29f5b24a3ad120054410e13"

URI_aarch64_rust-pyo3-macros-backend+experimental-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend+experimental-async-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-macros-backend+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend+experimental-async-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend+experimental-async-devel.sha256sum] = "4f9cf14f578d00f744ee9923de3d43878632cce8fad3b13478cb3b36ab33e165"

URI_aarch64_rust-pyo3-macros-backend+experimental-inspect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend+experimental-inspect-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-macros-backend+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend+experimental-inspect-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend+experimental-inspect-devel.sha256sum] = "3895b9382c3c2ae59e2b8a1323623a128d59779760ad392bb4f1b55a16300a4a"

URI_aarch64_rust-pyo3-macros-backend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-macros-backend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend-devel.sha256sum] = "e5df0e4f3a6d0b766dbc986cdc5286a95ecf77159104352d41bdea6c143c2e48"

RDEPENDS:rust-pyo3-macros-backend+default-devel = " \
 cargo \
 rust-pyo3-macros-backend-devel \
 "
RDEPENDS:rust-pyo3-macros-backend+experimental-async-devel = " \
 cargo \
 rust-pyo3-macros-backend-devel \
 "
RDEPENDS:rust-pyo3-macros-backend+experimental-inspect-devel = " \
 cargo \
 rust-pyo3-macros-backend-devel \
 "
RDEPENDS:rust-pyo3-macros-backend-devel = " \
 cargo \
 rust \
 rust-heck+default-devel \
 rust-proc-macro2-devel \
 rust-pyo3-build-config+default-devel \
 rust-pyo3-build-config+resolve-config-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+visit-mut-devel \
 rust-syn-devel \
 "
