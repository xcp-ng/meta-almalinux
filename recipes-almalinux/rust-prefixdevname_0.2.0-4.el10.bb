# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-prefixdevname"
PV = "0.2.0"
PR = "4.el10"
PACKAGES = " \
 prefixdevname \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/rust-prefixdevname-0.2.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ef1998f6cecd075cf6a35e5518c0d3ad0543a4e66e9bb21f9479430e6b3b7cbc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/prefixdevname-0.2.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_prefixdevname;unpack=0"
SRC_URI[x86_64_v2_prefixdevname.sha256sum] = "4af828e23461e86ac5c8662ae420a9eb37bcf613bf138ab7d339711dc061f0a4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/prefixdevname-0.2.0-4.el10.aarch64.rpm;name=aarch64_prefixdevname;unpack=0"
SRC_URI[aarch64_prefixdevname.sha256sum] = "c7f5a64b404cade35fe1264b17e61adb53f1218347e95b5f87326366fdfba4f4"

RDEPENDS:prefixdevname = " \
 bash \
 glibc \
 libgcc \
 systemd-libs \
 "
