# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-rake-compiler"
PV = "1.3.0"
PR = "2.el10_2"
PACKAGES = " \
 rubygem-rake-compiler \
 rubygem-rake-compiler-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-rake-compiler-1.3.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6fdc47efb235b9356ba5affe2b2e349f614491905a837d81095dde488c7cd661"

URI_x86_64_v2_rubygem-rake-compiler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-rake-compiler-1.3.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-rake-compiler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rake-compiler}"
SRC_URI[x86_64_v2_rubygem-rake-compiler.sha256sum] = "76416df676a5deb3da841fb31835c02e01625370b47ec8e64d7314a7ff0109e0"

URI_x86_64_v2_rubygem-rake-compiler-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-rake-compiler-doc-1.3.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-rake-compiler-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rake-compiler-doc}"
SRC_URI[x86_64_v2_rubygem-rake-compiler-doc.sha256sum] = "3be2b56e9b64e609b9fa3379feb6c74aa25bc0d7382335dbc4e7df7708f2af9a"

URI_aarch64_rubygem-rake-compiler = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-rake-compiler-1.3.0-2.el10_2.noarch.rpm;name=aarch64_rubygem-rake-compiler;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rake-compiler}"
SRC_URI[aarch64_rubygem-rake-compiler.sha256sum] = "f8c7ecb9d8ae31aaf22319fc8cae4acc864fa73194b587363a17a5fef41db748"

URI_aarch64_rubygem-rake-compiler-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-rake-compiler-doc-1.3.0-2.el10_2.noarch.rpm;name=aarch64_rubygem-rake-compiler-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rake-compiler-doc}"
SRC_URI[aarch64_rubygem-rake-compiler-doc.sha256sum] = "133528f4851424161e5cb95fe1425d02b3d5e7a882fadfa27cf8fb06cb7943c0"

RDEPENDS:rubygem-rake-compiler = " \
 ruby \
 rubygem-rake \
 rubygems \
 virtual/ruby_release_ \
 "
RDEPENDS:rubygem-rake-compiler-doc = " \
 rubygem-rake-compiler \
 "
