# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dl-fedora"
PV = "2.1"
PR = "1.el10_1"
PACKAGES = " \
 dl-fedora \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dl-fedora-2.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "430e1981f2160e4372e44867fd9a575ae245c6bd8b502f64cf4fb69ce9a502db"

URI_x86_64_v2_dl-fedora = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dl-fedora-2.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dl-fedora;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dl-fedora}"
SRC_URI[x86_64_v2_dl-fedora.sha256sum] = "46f0148380555ca24d155180bec110048549b16ce0fbb9437a62985902d64f75"

URI_aarch64_dl-fedora = "${EPEL_MIRROR}/aarch64/Packages/d/dl-fedora-2.1-1.el10_1.aarch64.rpm;name=aarch64_dl-fedora;unpack=0"
SRC_URI:append = " ${URI_aarch64_dl-fedora}"
SRC_URI[aarch64_dl-fedora.sha256sum] = "76fb33a545497dcd67c275ab0a4bdf05384363cf6934004cd7aa6af978cb1a49"

RDEPENDS:dl-fedora = " \
 glibc \
 gmp \
 libffi \
 ncurses-libs \
 zlib-ng-compat \
 "
