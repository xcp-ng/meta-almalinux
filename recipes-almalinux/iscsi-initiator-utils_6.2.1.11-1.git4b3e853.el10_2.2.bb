# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iscsi-initiator-utils"
PV = "6.2.1.11"
PR = "1.git4b3e853.el10_2.2"
PACKAGES = " \
 iscsi-initiator-utils \
 iscsi-initiator-utils-iscsiuio \
 python3-iscsi-initiator-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/iscsi-initiator-utils-6.2.1.11-1.git4b3e853.el10_2.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28f94830535b4cf1503d8e93bf9b4a64e24217a70834dfe0ed89e285f7f40017"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - iscsi-initiator-utils: (fedora-release-common >= 38-0.23 if fedora-release-common)

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - iscsi-initiator-utils: (fedora-release-common >= 38-0.23 if fedora-release-common)

URI_x86_64_v2_iscsi-initiator-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iscsi-initiator-utils-6.2.1.11-1.git4b3e853.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_iscsi-initiator-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iscsi-initiator-utils}"
SRC_URI[x86_64_v2_iscsi-initiator-utils.sha256sum] = "b6cb5e8a32da68c71ebf6bf0734c61635826a99960029ec5bbe5acd09f8eafc0"

URI_x86_64_v2_iscsi-initiator-utils-iscsiuio = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iscsi-initiator-utils-iscsiuio-6.2.1.11-1.git4b3e853.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_iscsi-initiator-utils-iscsiuio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iscsi-initiator-utils-iscsiuio}"
SRC_URI[x86_64_v2_iscsi-initiator-utils-iscsiuio.sha256sum] = "dd8bb7caa5c4ea7d41e52a8548bf45954dbfe4bd6608748b5d448ee03f7f98f5"

URI_x86_64_v2_python3-iscsi-initiator-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-iscsi-initiator-utils-6.2.1.11-1.git4b3e853.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_python3-iscsi-initiator-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-iscsi-initiator-utils}"
SRC_URI[x86_64_v2_python3-iscsi-initiator-utils.sha256sum] = "bace86f45fa9f900229bdd07f2c395dace56953cecdd3f7e27128172be600680"

URI_aarch64_iscsi-initiator-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iscsi-initiator-utils-6.2.1.11-1.git4b3e853.el10_2.2.aarch64.rpm;name=aarch64_iscsi-initiator-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_iscsi-initiator-utils}"
SRC_URI[aarch64_iscsi-initiator-utils.sha256sum] = "fe47d3793b72a0e9badb2017f5bc0a5c5952d90c850e28cac4d4f6dec6415cb9"

URI_aarch64_iscsi-initiator-utils-iscsiuio = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iscsi-initiator-utils-iscsiuio-6.2.1.11-1.git4b3e853.el10_2.2.aarch64.rpm;name=aarch64_iscsi-initiator-utils-iscsiuio;unpack=0"
SRC_URI:append = " ${URI_aarch64_iscsi-initiator-utils-iscsiuio}"
SRC_URI[aarch64_iscsi-initiator-utils-iscsiuio.sha256sum] = "7974fdd5c91167725187485972707a004ef460f4728a8f26b0cf929e03fb27b2"

URI_aarch64_python3-iscsi-initiator-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-iscsi-initiator-utils-6.2.1.11-1.git4b3e853.el10_2.2.aarch64.rpm;name=aarch64_python3-iscsi-initiator-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-iscsi-initiator-utils}"
SRC_URI[aarch64_python3-iscsi-initiator-utils.sha256sum] = "47c889eda97a74d986243fa5883ebabf8417a70d649c92b4be566f6f0e22fffd"

RDEPENDS:iscsi-initiator-utils = " \
 bash \
 glibc \
 iscsi-initiator-utils-iscsiuio \
 isns-utils-libs \
 kmod-libs \
 libmount \
 openssl-libs \
 systemd \
 systemd-libs \
 "
RDEPENDS:iscsi-initiator-utils-iscsiuio = " \
 bash \
 glibc \
 iscsi-initiator-utils \
 libgcc \
 systemd-libs \
 "
RDEPENDS:python3-iscsi-initiator-utils = " \
 glibc \
 iscsi-initiator-utils \
 python3 \
 "
