# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libc"
PV = "0.2.189"
PR = "1.el10_3"
PACKAGES = " \
 rust-libc+align-devel \
 rust-libc+const-extern-fn-devel \
 rust-libc+default-devel \
 rust-libc+extra_traits-devel \
 rust-libc+std-devel \
 rust-libc+use_std-devel \
 rust-libc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libc-0.2.189-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc5728ad654a401baa80635e2e0ce85cee497769e11ece282c0598645e85079b"

URI_x86_64_v2_rust-libc+align-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libc+align-devel-0.2.189-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libc+align-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libc+align-devel}"
SRC_URI[x86_64_v2_rust-libc+align-devel.sha256sum] = "05e0c6fb7fb03ec07a417ed1eb430baa35b088acf5c2e9d526911d504844c9ee"

URI_x86_64_v2_rust-libc+const-extern-fn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libc+const-extern-fn-devel-0.2.189-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libc+const-extern-fn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libc+const-extern-fn-devel}"
SRC_URI[x86_64_v2_rust-libc+const-extern-fn-devel.sha256sum] = "964b9702f17d8c4fa75b8b81408c587252975717ecb75b7df30242ada3341287"

URI_x86_64_v2_rust-libc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libc+default-devel-0.2.189-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libc+default-devel}"
SRC_URI[x86_64_v2_rust-libc+default-devel.sha256sum] = "57ab1b80bb5aa354059ee32474c4529829c86258601909f30fd1fc004aa8ab2b"

URI_x86_64_v2_rust-libc+extra_traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libc+extra_traits-devel-0.2.189-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libc+extra_traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libc+extra_traits-devel}"
SRC_URI[x86_64_v2_rust-libc+extra_traits-devel.sha256sum] = "c8c6e4a22dc4448d2363844de5173ac7f461c686aee0cd2afb55f50d89bea43c"

URI_x86_64_v2_rust-libc+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libc+std-devel-0.2.189-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libc+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libc+std-devel}"
SRC_URI[x86_64_v2_rust-libc+std-devel.sha256sum] = "090a09d22d3a72e01f04315bea79115551af38d98830fad21f5dc1496d2e281a"

URI_x86_64_v2_rust-libc+use_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libc+use_std-devel-0.2.189-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libc+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libc+use_std-devel}"
SRC_URI[x86_64_v2_rust-libc+use_std-devel.sha256sum] = "bbde6ebbc82100095ad6c115491764c750c0d1b2a81daee10b21421b174e6dbf"

URI_x86_64_v2_rust-libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libc-devel-0.2.189-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libc-devel}"
SRC_URI[x86_64_v2_rust-libc-devel.sha256sum] = "f602ed5b6b0ef85c5a140b487df15c18b5d60b7f740a1478d58bf7dd5ed66cf6"

URI_aarch64_rust-libc+align-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libc+align-devel-0.2.189-1.el10_3.noarch.rpm;name=aarch64_rust-libc+align-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libc+align-devel}"
SRC_URI[aarch64_rust-libc+align-devel.sha256sum] = "2620024eea80eced4669655cdc2b34fc163ac84d49e6cf13a34a6d76a07ca9bb"

URI_aarch64_rust-libc+const-extern-fn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libc+const-extern-fn-devel-0.2.189-1.el10_3.noarch.rpm;name=aarch64_rust-libc+const-extern-fn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libc+const-extern-fn-devel}"
SRC_URI[aarch64_rust-libc+const-extern-fn-devel.sha256sum] = "760232f9e534724efad2f21f1b02d83d89a26113905eb48a5bd03076b415cef1"

URI_aarch64_rust-libc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libc+default-devel-0.2.189-1.el10_3.noarch.rpm;name=aarch64_rust-libc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libc+default-devel}"
SRC_URI[aarch64_rust-libc+default-devel.sha256sum] = "3b1d554409d85b3b599bde3011c297f56af34e059450a9c899eed318032cd914"

URI_aarch64_rust-libc+extra_traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libc+extra_traits-devel-0.2.189-1.el10_3.noarch.rpm;name=aarch64_rust-libc+extra_traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libc+extra_traits-devel}"
SRC_URI[aarch64_rust-libc+extra_traits-devel.sha256sum] = "9d26bd4f781ad6218b98bd848d3245256209f0fd3312cbcfbfbd5b0a54ff0016"

URI_aarch64_rust-libc+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libc+std-devel-0.2.189-1.el10_3.noarch.rpm;name=aarch64_rust-libc+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libc+std-devel}"
SRC_URI[aarch64_rust-libc+std-devel.sha256sum] = "94eb215cc174e31a7ff5087c33b57092935041d924523893bd482e955dd8d3c0"

URI_aarch64_rust-libc+use_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libc+use_std-devel-0.2.189-1.el10_3.noarch.rpm;name=aarch64_rust-libc+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libc+use_std-devel}"
SRC_URI[aarch64_rust-libc+use_std-devel.sha256sum] = "e1eb89cfd30a793db9ff2593c849d7345010c90239c8fe3834202d1fd9dea32e"

URI_aarch64_rust-libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libc-devel-0.2.189-1.el10_3.noarch.rpm;name=aarch64_rust-libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libc-devel}"
SRC_URI[aarch64_rust-libc-devel.sha256sum] = "1d5687e1506cb6f4f68988d2824926c17bfa0a828b2e8fb4693b87ec944bf9c3"

RDEPENDS:rust-libc+align-devel = " \
 cargo \
 rust-libc-devel \
 "
RDEPENDS:rust-libc+const-extern-fn-devel = " \
 cargo \
 rust-libc-devel \
 "
RDEPENDS:rust-libc+default-devel = " \
 cargo \
 rust-libc+std-devel \
 rust-libc-devel \
 "
RDEPENDS:rust-libc+extra_traits-devel = " \
 cargo \
 rust-libc-devel \
 "
RDEPENDS:rust-libc+std-devel = " \
 cargo \
 rust-libc-devel \
 "
RDEPENDS:rust-libc+use_std-devel = " \
 cargo \
 rust-libc+std-devel \
 rust-libc-devel \
 "
RDEPENDS:rust-libc-devel = " \
 cargo \
 glibc-devel \
 rust \
 "
