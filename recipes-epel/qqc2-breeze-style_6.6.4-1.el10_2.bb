# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qqc2-breeze-style"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 qqc2-breeze-style \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qqc2-breeze-style-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b8a0fac88369987d21a2490a4e5bfe026894a9457dec2cf2fce3c15132be6af"

URI_x86_64_v2_qqc2-breeze-style = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qqc2-breeze-style-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qqc2-breeze-style;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qqc2-breeze-style}"
SRC_URI[x86_64_v2_qqc2-breeze-style.sha256sum] = "f6ac2f60bb15469dd2b6ea00806a91fd89037bbd82bbfbf489f73e12e9bd7526"

URI_aarch64_qqc2-breeze-style = "${EPEL_MIRROR}/aarch64/Packages/q/qqc2-breeze-style-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_qqc2-breeze-style;unpack=0"
SRC_URI:append = " ${URI_aarch64_qqc2-breeze-style}"
SRC_URI[aarch64_qqc2-breeze-style.sha256sum] = "222b4fecaefd7406fdbdca9d00432f8ab7647262724da6c5638c5b0248423b37"

RDEPENDS:qqc2-breeze-style = " \
 cmake-filesystem \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kguiaddons \
 kf6-kiconthemes \
 kf6-kirigami \
 kf6-kquickcharts \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
