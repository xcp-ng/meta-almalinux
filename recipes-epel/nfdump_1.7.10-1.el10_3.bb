# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nfdump"
PV = "1.7.10"
PR = "1.el10_3"
PACKAGES = " \
 nfdump \
 nfdump-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/n/nfdump-1.7.10-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7faac868878d771b1070ceea68e3331193cdfa9be9bc5b808c787a86cce16c96"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nfdump-1.7.10-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nfdump;unpack=0"
SRC_URI[x86_64_v2_nfdump.sha256sum] = "f253c82f3dff115faa7645c3b06b9bcb2e2d211f92ab9dfc75f9027f8e3ea913"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nfdump-libs-1.7.10-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nfdump-libs;unpack=0"
SRC_URI[x86_64_v2_nfdump-libs.sha256sum] = "e2862c607650aedadbc52d794b3fccca04df1cf3dbcbaf04b5fe8022ef7bae86"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nfdump-1.7.10-1.el10_3.aarch64.rpm;name=aarch64_nfdump;unpack=0"
SRC_URI[aarch64_nfdump.sha256sum] = "2b1fafe6bfe42d655c9d1d518e6830ef4eb5053aba965259b4dd286f4f4de7ea"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nfdump-libs-1.7.10-1.el10_3.aarch64.rpm;name=aarch64_nfdump-libs;unpack=0"
SRC_URI[aarch64_nfdump-libs.sha256sum] = "f11a0d5ab59dd4ba2d1525dbee1ba8c5315bc7398c20a4ed086d4718b61bd702"

RDEPENDS:nfdump = " \
 bash \
 glibc \
 libpcap \
 nfdump-libs \
 rrdtool \
 "
RDEPENDS:nfdump-libs = " \
 bzip2-libs \
 glibc \
 libzstd \
 "
