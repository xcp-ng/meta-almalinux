# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtgrpc"
PV = "6.8.1"
PR = "2.el10_0"
PACKAGES = " \
 qt6-qtgrpc \
 qt6-qtgrpc-devel \
 qt6-qtgrpc-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt6-qtgrpc-6.8.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3160abe4e29e6e02a2f0b87cac1371510a8477600312d1c5b815af324cbe4fac"

URI_x86_64_v2_qt6-qtgrpc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtgrpc-6.8.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtgrpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtgrpc}"
SRC_URI[x86_64_v2_qt6-qtgrpc.sha256sum] = "3b73a44c6483cbc19106232cdbe4e0acf751255d300791168a774fdae5c39fc9"

URI_x86_64_v2_qt6-qtgrpc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtgrpc-devel-6.8.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtgrpc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtgrpc-devel}"
SRC_URI[x86_64_v2_qt6-qtgrpc-devel.sha256sum] = "8fda9be752d3486eebd9235105c72639657185d2b4c601c9312f24c999d8e562"

URI_x86_64_v2_qt6-qtgrpc-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtgrpc-examples-6.8.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtgrpc-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtgrpc-examples}"
SRC_URI[x86_64_v2_qt6-qtgrpc-examples.sha256sum] = "ac908781347ac76b7ec1e5faac90ae06f02ebf301ec828a8a74475b1e19102b9"

URI_aarch64_qt6-qtgrpc = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtgrpc-6.8.1-2.el10_0.aarch64.rpm;name=aarch64_qt6-qtgrpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtgrpc}"
SRC_URI[aarch64_qt6-qtgrpc.sha256sum] = "ec8fe1e611c347a453e37e5623607b504ada1d8f03699d661603530d70e66963"

URI_aarch64_qt6-qtgrpc-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtgrpc-devel-6.8.1-2.el10_0.aarch64.rpm;name=aarch64_qt6-qtgrpc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtgrpc-devel}"
SRC_URI[aarch64_qt6-qtgrpc-devel.sha256sum] = "7e78f65e7a445ac640c827c13385e28852ed2f28d00167e801c89b045c5f38c0"

URI_aarch64_qt6-qtgrpc-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtgrpc-examples-6.8.1-2.el10_0.aarch64.rpm;name=aarch64_qt6-qtgrpc-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtgrpc-examples}"
SRC_URI[aarch64_qt6-qtgrpc-examples.sha256sum] = "62731122b1718a244d99e855bc2d4f94bad43a7a2687cbcb0b84d6ad1e013d89"

RDEPENDS:qt6-qtgrpc = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:qt6-qtgrpc-devel = " \
 cmake-filesystem \
 glibc \
 grpc-devel \
 libgcc \
 libstdc++ \
 pkgconf-pkg-config \
 protobuf \
 protobuf-compiler \
 protobuf-devel \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtgrpc \
 qt6-qtgrpc-devel \
 "
RDEPENDS:qt6-qtgrpc-examples = " \
 glibc \
 grpc \
 grpc-cpp \
 libgcc \
 libstdc++ \
 protobuf \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtgrpc \
 "
