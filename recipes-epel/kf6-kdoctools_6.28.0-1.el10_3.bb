# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kdoctools"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kdoctools \
 kf6-kdoctools-devel \
 kf6-kdoctools-doc \
 kf6-kdoctools-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kdoctools-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96df80a8e12eaf04745d6e3ca7a764ce70e4feb0ac689c822c9762c6b2895468"

URI_x86_64_v2_kf6-kdoctools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdoctools-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdoctools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdoctools}"
SRC_URI[x86_64_v2_kf6-kdoctools.sha256sum] = "6f23e011ddb1d163b8089bec401bbc4c4acdb841de792f0747d0b88947271316"

URI_x86_64_v2_kf6-kdoctools-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdoctools-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdoctools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdoctools-devel}"
SRC_URI[x86_64_v2_kf6-kdoctools-devel.sha256sum] = "d72d9cd98475461a628a30bcb70ee633739a21d40a5d32378aaa52f431179e89"

URI_x86_64_v2_kf6-kdoctools-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdoctools-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdoctools-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdoctools-doc}"
SRC_URI[x86_64_v2_kf6-kdoctools-doc.sha256sum] = "89ff8eab0cda73850436f83b2cee30e7cb93fd9a5f092b3f59b0b8f13dddd46a"

URI_x86_64_v2_kf6-kdoctools-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdoctools-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdoctools-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdoctools-html}"
SRC_URI[x86_64_v2_kf6-kdoctools-html.sha256sum] = "941c8136075b31af617001166419716c9e72c77cfab64c236f9035a5688ea4e2"

URI_aarch64_kf6-kdoctools = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdoctools-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kdoctools;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdoctools}"
SRC_URI[aarch64_kf6-kdoctools.sha256sum] = "9d5538d3b64979222007f214f220bd50a67c27cfd779e0e91abf730e127cc666"

URI_aarch64_kf6-kdoctools-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdoctools-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kdoctools-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdoctools-devel}"
SRC_URI[aarch64_kf6-kdoctools-devel.sha256sum] = "8b62be1fa4589aadd1ce9b9aab63c3d4d4a6499728457a85589d7ae82c185d17"

URI_aarch64_kf6-kdoctools-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdoctools-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kdoctools-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdoctools-doc}"
SRC_URI[aarch64_kf6-kdoctools-doc.sha256sum] = "444df0e89fe196262165ea71f993e5784d71618d4d16e1beae816bd9458103d6"

URI_aarch64_kf6-kdoctools-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdoctools-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kdoctools-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdoctools-html}"
SRC_URI[aarch64_kf6-kdoctools-html.sha256sum] = "118b8cf3f69c5cfc80f3acfe37fdeedc201b929fd37777ba3c9c2c3506c90d24"

RDEPENDS:kf6-kdoctools = " \
 docbook-dtds \
 docbook-style-xsl \
 glibc \
 kf6-karchive \
 libstdc++ \
 libxml2 \
 libxslt \
 qt6-qtbase \
 "
RDEPENDS:kf6-kdoctools-devel = " \
 cmake-filesystem \
 kf6-kdoctools \
 perl-Any-URI-Escape \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kdoctools-doc = " \
 "
RDEPENDS:kf6-kdoctools-html = " \
 "
