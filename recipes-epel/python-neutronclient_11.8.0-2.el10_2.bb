# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-neutronclient"
PV = "11.8.0"
PR = "2.el10_2"
PACKAGES = " \
 python-neutronclient-doc \
 python3-neutronclient \
 python3-neutronclient-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-neutronclient-11.8.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f4c1a345ef7c314b46e3d524204215d1c8b00286aa44575ace30ee615246dec6"

URI_x86_64_v2_python-neutronclient-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-neutronclient-doc-11.8.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-neutronclient-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-neutronclient-doc}"
SRC_URI[x86_64_v2_python-neutronclient-doc.sha256sum] = "a8e2c928cca49c771722a350aacbe390f2760ec3b0338fbae3e6c81b0873c79d"

URI_x86_64_v2_python3-neutronclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-neutronclient-11.8.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-neutronclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-neutronclient}"
SRC_URI[x86_64_v2_python3-neutronclient.sha256sum] = "62b9b01de9a71692d587bbd3c136024a064884cb68f348144c3cdc3aac7f8924"

URI_x86_64_v2_python3-neutronclient-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-neutronclient-tests-11.8.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-neutronclient-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-neutronclient-tests}"
SRC_URI[x86_64_v2_python3-neutronclient-tests.sha256sum] = "01e9f6407cee42abc25688e493a6149644fae2a4ada6014ef75e273c51e11eea"

URI_aarch64_python-neutronclient-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-neutronclient-doc-11.8.0-2.el10_2.noarch.rpm;name=aarch64_python-neutronclient-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-neutronclient-doc}"
SRC_URI[aarch64_python-neutronclient-doc.sha256sum] = "b633f11d709318c3a735fd9ffe6d19c77d1d88cd5819d64610dba91631c4d5ca"

URI_aarch64_python3-neutronclient = "${EPEL_MIRROR}/aarch64/Packages/p/python3-neutronclient-11.8.0-2.el10_2.noarch.rpm;name=aarch64_python3-neutronclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-neutronclient}"
SRC_URI[aarch64_python3-neutronclient.sha256sum] = "43594587ff8033314f7f7723e5a4dc496ae63784d712ce7f56da96e7bd87af94"

URI_aarch64_python3-neutronclient-tests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-neutronclient-tests-11.8.0-2.el10_2.noarch.rpm;name=aarch64_python3-neutronclient-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-neutronclient-tests}"
SRC_URI[aarch64_python3-neutronclient-tests.sha256sum] = "02be3fb50eca689ee0e18e2de7539d07b72adc5556b9115064322553e06ab885"

RDEPENDS:python-neutronclient-doc = " \
 "
RDEPENDS:python3-neutronclient = " \
 python3 \
 python3-cliff \
 python3-debtcollector \
 python3-keystoneauth1 \
 python3-keystoneclient \
 python3-netaddr \
 python3-openstacksdk \
 python3-osc-lib \
 python3-oslo-i18n \
 python3-oslo-log \
 python3-oslo-serialization \
 python3-oslo-utils \
 python3-pbr \
 python3-requests \
 "
RDEPENDS:python3-neutronclient-tests = " \
 python3 \
 python3-neutronclient \
 python3-osc-lib \
 python3-oslotest \
 python3-stestr \
 python3-testscenarios \
 python3-testtools \
 "
