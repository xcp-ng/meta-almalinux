# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-mobile"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 plasma-mobile \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-mobile-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a146709e86726667e95931d0222d12c3e28feb28d11e5d75814010f88377ff5f"

URI_x86_64_v2_plasma-mobile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-mobile-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-mobile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-mobile}"
SRC_URI[x86_64_v2_plasma-mobile.sha256sum] = "7fbcdb198b7ed137d919b4f17f9bd9f695d4384e7046d55b080c8c62abe431df"

URI_aarch64_plasma-mobile = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-mobile-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_plasma-mobile;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-mobile}"
SRC_URI[aarch64_plasma-mobile.sha256sum] = "0fd9bcf0ee6daa286a13cc7519de0a21d3d2e614ad0e5823a4714b48917a10f7"

RDEPENDS:plasma-mobile = " \
 bash \
 glib2 \
 glibc \
 kf6-bluez-qt \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kdeclarative \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kpackage \
 kf6-kservice \
 kf6-kwindowsystem \
 kf6-modemmanager-qt \
 kf6-networkmanager-qt \
 kf6-solid \
 kpipewire \
 kscreen \
 kwayland \
 kwin \
 kwin-libs \
 layer-shell-qt \
 libgcc \
 libkscreen \
 libkworkspace6 \
 libplasma \
 libstdc++ \
 libwayland-client \
 plasma-activities \
 plasma-milou \
 plasma-nano \
 plasma-nm \
 plasma-pa \
 plasma-workspace \
 qcoro-qt6 \
 qqc2-breeze-style \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsensors \
 qt6-qtwayland \
 systemd-libs \
 "
