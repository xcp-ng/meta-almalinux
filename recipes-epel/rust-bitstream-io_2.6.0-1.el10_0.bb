# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bitstream-io"
PV = "2.6.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-bitstream-io+alloc-devel \
 rust-bitstream-io+core2-devel \
 rust-bitstream-io+default-devel \
 rust-bitstream-io+std-devel \
 rust-bitstream-io-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bitstream-io-2.6.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f027358e747b9921aaf3ddf41b7b657faa69c5d0a0e3ce19938c12fbeff5c12d"

URI_x86_64_v2_rust-bitstream-io+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitstream-io+alloc-devel-2.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitstream-io+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitstream-io+alloc-devel}"
SRC_URI[x86_64_v2_rust-bitstream-io+alloc-devel.sha256sum] = "7311bf8f4dd9afe396de5769d4e186523b363dd3b2f71b2a443c71944a7fedb3"

URI_x86_64_v2_rust-bitstream-io+core2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitstream-io+core2-devel-2.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitstream-io+core2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitstream-io+core2-devel}"
SRC_URI[x86_64_v2_rust-bitstream-io+core2-devel.sha256sum] = "502e4ffe9eeee3e0212bc1a19e47e2d5d23af255ffa946d0fdc340e506db9227"

URI_x86_64_v2_rust-bitstream-io+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitstream-io+default-devel-2.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitstream-io+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitstream-io+default-devel}"
SRC_URI[x86_64_v2_rust-bitstream-io+default-devel.sha256sum] = "722f8dac512f63a764f56ed73e96c47b728eb04da7b65e803ad6d4fd7f77ce05"

URI_x86_64_v2_rust-bitstream-io+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitstream-io+std-devel-2.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitstream-io+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitstream-io+std-devel}"
SRC_URI[x86_64_v2_rust-bitstream-io+std-devel.sha256sum] = "9a7ebdba5ad2cbd5b1da5f4f279f0fa190c4d5f3ed2ce074b34cb6722189c4c7"

URI_x86_64_v2_rust-bitstream-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitstream-io-devel-2.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitstream-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitstream-io-devel}"
SRC_URI[x86_64_v2_rust-bitstream-io-devel.sha256sum] = "3a8b1af7047901253b32ffc24d76b22f1b81d2b842e016b6e83c9cac1b3737fb"

URI_aarch64_rust-bitstream-io+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitstream-io+alloc-devel-2.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-bitstream-io+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitstream-io+alloc-devel}"
SRC_URI[aarch64_rust-bitstream-io+alloc-devel.sha256sum] = "6ce5d5ec9f028ba47991b84f34278d8f589baa6489ab46b864574875a72da4b6"

URI_aarch64_rust-bitstream-io+core2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitstream-io+core2-devel-2.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-bitstream-io+core2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitstream-io+core2-devel}"
SRC_URI[aarch64_rust-bitstream-io+core2-devel.sha256sum] = "83d05bdc445507c72127d413fa55e0769c550e623d59a97d03bd5f0da1c5bebc"

URI_aarch64_rust-bitstream-io+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitstream-io+default-devel-2.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-bitstream-io+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitstream-io+default-devel}"
SRC_URI[aarch64_rust-bitstream-io+default-devel.sha256sum] = "80ebc58cdf4a9894d7a416b05fcd72054cf3c940ee7e5afd49c3bd7a3b56ad6c"

URI_aarch64_rust-bitstream-io+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitstream-io+std-devel-2.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-bitstream-io+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitstream-io+std-devel}"
SRC_URI[aarch64_rust-bitstream-io+std-devel.sha256sum] = "fc7e0623fb2c6663d665b0a8895b0ec25377813a85b644898ed72d579aeebdd8"

URI_aarch64_rust-bitstream-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitstream-io-devel-2.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-bitstream-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitstream-io-devel}"
SRC_URI[aarch64_rust-bitstream-io-devel.sha256sum] = "58ea00509ecaeefc3411b81bbb409e97eeecae9d38b36504f68ceb0bfec7af0b"

RDEPENDS:rust-bitstream-io+alloc-devel = " \
 cargo \
 rust-bitstream-io+core2-devel \
 rust-bitstream-io-devel \
 "
RDEPENDS:rust-bitstream-io+core2-devel = " \
 cargo \
 rust-bitstream-io-devel \
 rust-core2+alloc-devel \
 rust-core2-devel \
 "
RDEPENDS:rust-bitstream-io+default-devel = " \
 cargo \
 rust-bitstream-io+std-devel \
 rust-bitstream-io-devel \
 "
RDEPENDS:rust-bitstream-io+std-devel = " \
 cargo \
 rust-bitstream-io-devel \
 "
RDEPENDS:rust-bitstream-io-devel = " \
 cargo \
 rust \
 "
