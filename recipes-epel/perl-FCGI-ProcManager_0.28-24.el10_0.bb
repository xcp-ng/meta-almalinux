# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-FCGI-ProcManager"
PV = "0.28"
PR = "24.el10_0"
PACKAGES = " \
 perl-FCGI-ProcManager \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-FCGI-ProcManager-0.28-24.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72f4f0ff935d4b3b19869461a0acb671f89f038bc51cf001bf797df6cac00656"

URI_x86_64_v2_perl-FCGI-ProcManager = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-FCGI-ProcManager-0.28-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-FCGI-ProcManager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-FCGI-ProcManager}"
SRC_URI[x86_64_v2_perl-FCGI-ProcManager.sha256sum] = "17747c3299b7a6a82d4adba62aa996aeeec33f600a236810e097969847cf23f5"

URI_aarch64_perl-FCGI-ProcManager = "${EPEL_MIRROR}/aarch64/Packages/p/perl-FCGI-ProcManager-0.28-24.el10_0.noarch.rpm;name=aarch64_perl-FCGI-ProcManager;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-FCGI-ProcManager}"
SRC_URI[aarch64_perl-FCGI-ProcManager.sha256sum] = "e2303e1c8a474d19955867ed32e6bc403a522d4649c8a1dda2d184ddd2397f0f"

RDEPENDS:perl-FCGI-ProcManager = " \
 perl-Carp \
 perl-Exporter \
 perl-FCGI-ProcManager \
 perl-POSIX \
 perl-base \
 perl-libs \
 perl-vars \
 "
