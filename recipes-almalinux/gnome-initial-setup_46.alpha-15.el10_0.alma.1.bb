# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-initial-setup"
PV = "46.alpha"
PR = "15.el10_0.alma.1"
PACKAGES = " \
 gnome-initial-setup \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-initial-setup-46.alpha-15.el10_0.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "49b19bae36623fb1b835bd11cef242b713a593bd8079856a3911cd5aef8df005"

URI_x86_64_v2_gnome-initial-setup = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-initial-setup-46.alpha-15.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_gnome-initial-setup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-initial-setup}"
SRC_URI[x86_64_v2_gnome-initial-setup.sha256sum] = "4bdbd659492b52ddf8a82aadf57cd21b90a21ea035d4ad34d9a758ae42e53016"

URI_aarch64_gnome-initial-setup = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-initial-setup-46.alpha-15.el10_0.alma.1.aarch64.rpm;name=aarch64_gnome-initial-setup;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-initial-setup}"
SRC_URI[aarch64_gnome-initial-setup.sha256sum] = "100eae36d0221ca00b0f014b8414d59166cd5397eb1a0b9a3905e3d8e85ab2d4"

RDEPENDS:gnome-initial-setup = " \
 NetworkManager-libnm \
 accountsservice-libs \
 bash \
 cairo \
 fontconfig \
 gdk-pixbuf2 \
 gdm \
 geoclue2-libs \
 geocode-glib \
 glib2 \
 glibc \
 gnome-desktop4 \
 gtk4 \
 ibus-libs \
 krb5-libs \
 libadwaita \
 libgcc \
 libgweather \
 libnma-gtk4 \
 libpwquality \
 libsecret \
 pango \
 polkit \
 polkit-libs \
 shadow-utils \
 tecla \
 "
