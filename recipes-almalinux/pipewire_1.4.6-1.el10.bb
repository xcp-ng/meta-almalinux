# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pipewire"
PV = "1.4.6"
PR = "1.el10"
PACKAGES = " \
 pipewire \
 pipewire-alsa \
 pipewire-devel \
 pipewire-gstreamer \
 pipewire-jack-audio-connection-kit \
 pipewire-jack-audio-connection-kit-devel \
 pipewire-jack-audio-connection-kit-libs \
 pipewire-libs \
 pipewire-module-x11 \
 pipewire-plugin-libcamera \
 pipewire-pulseaudio \
 pipewire-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pipewire-1.4.6-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "daeeead4f7941f120a748f1b20d8b85b66e9d51e8c5906edc1bf3131a169eea2"

URI_x86_64_v2_pipewire = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-1.4.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire}"
SRC_URI[x86_64_v2_pipewire.sha256sum] = "f6aadbc59c04eba0320c7dd8ff724119c9f4b785846a7eb380314e40568e1529"

URI_x86_64_v2_pipewire-alsa = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-alsa-1.4.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-alsa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-alsa}"
SRC_URI[x86_64_v2_pipewire-alsa.sha256sum] = "701c55ec3abaaac9bf1a06aa47267c64e6ce6045214c8f6847ee83a306aced8f"

URI_x86_64_v2_pipewire-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-devel-1.4.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-devel}"
SRC_URI[x86_64_v2_pipewire-devel.sha256sum] = "110c5799e1e5de178e3aa675ad15b1a77667b4a53ca3f4f76729d9d5e6ec1c68"

URI_x86_64_v2_pipewire-gstreamer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-gstreamer-1.4.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-gstreamer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-gstreamer}"
SRC_URI[x86_64_v2_pipewire-gstreamer.sha256sum] = "fbdbd0225224d3c005faa755cbe6cff9426588ded6290ec7d21fc245b210067f"

URI_x86_64_v2_pipewire-jack-audio-connection-kit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-jack-audio-connection-kit-1.4.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-jack-audio-connection-kit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-jack-audio-connection-kit}"
SRC_URI[x86_64_v2_pipewire-jack-audio-connection-kit.sha256sum] = "835a67d0593223bdd4529c4ad9dbe37291fd8f70202eee987973bc7f2c565675"

URI_x86_64_v2_pipewire-jack-audio-connection-kit-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-jack-audio-connection-kit-devel-1.4.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-jack-audio-connection-kit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-jack-audio-connection-kit-devel}"
SRC_URI[x86_64_v2_pipewire-jack-audio-connection-kit-devel.sha256sum] = "5f51487333bdcdb2a7278a0cc46d8ed196322e5af866bae0ec35785bbe534155"

URI_x86_64_v2_pipewire-jack-audio-connection-kit-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-jack-audio-connection-kit-libs-1.4.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-jack-audio-connection-kit-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-jack-audio-connection-kit-libs}"
SRC_URI[x86_64_v2_pipewire-jack-audio-connection-kit-libs.sha256sum] = "de13f6bde06b1898b385a0b22ae2008f5d4dfaa5de2971a86849919dca2c448a"

URI_x86_64_v2_pipewire-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-libs-1.4.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-libs}"
SRC_URI[x86_64_v2_pipewire-libs.sha256sum] = "62d747dd49acfa5b31a40e57afbac9e89a7bf7c19a725191e694da7101341ad0"

URI_x86_64_v2_pipewire-module-x11 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-module-x11-1.4.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-module-x11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-module-x11}"
SRC_URI[x86_64_v2_pipewire-module-x11.sha256sum] = "747e1507c2cbe5248cf55076197f154a24c14ac620d51bb2bf9307a39861c252"

URI_x86_64_v2_pipewire-plugin-libcamera = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-plugin-libcamera-1.4.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-plugin-libcamera;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-plugin-libcamera}"
SRC_URI[x86_64_v2_pipewire-plugin-libcamera.sha256sum] = "0e1e809948df3aa72ddfd2fcf85d03b586258d2a1d8c9f9e5f8efd13d2eac3eb"

URI_x86_64_v2_pipewire-pulseaudio = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-pulseaudio-1.4.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-pulseaudio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-pulseaudio}"
SRC_URI[x86_64_v2_pipewire-pulseaudio.sha256sum] = "4df1789375a29ed6e05e193e3e4b520b6c354b77ce4a2948bcee991ec4974418"

URI_x86_64_v2_pipewire-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-utils-1.4.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-utils}"
SRC_URI[x86_64_v2_pipewire-utils.sha256sum] = "a3c4771cb94e6cc9fe700a6f11df8a3c06fcb0b899ad7e1fc7dec5302b2a6e84"

URI_aarch64_pipewire = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-1.4.6-1.el10.aarch64.rpm;name=aarch64_pipewire;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire}"
SRC_URI[aarch64_pipewire.sha256sum] = "ce029cdbb32c9d9d03510d7b46087e470029e993e051199a015fad5be368be4e"

URI_aarch64_pipewire-alsa = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-alsa-1.4.6-1.el10.aarch64.rpm;name=aarch64_pipewire-alsa;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-alsa}"
SRC_URI[aarch64_pipewire-alsa.sha256sum] = "3aeac65a01dbc9f7024b032c7690d7079aeda2a74773f7c9dae6287de7f70b55"

URI_aarch64_pipewire-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-devel-1.4.6-1.el10.aarch64.rpm;name=aarch64_pipewire-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-devel}"
SRC_URI[aarch64_pipewire-devel.sha256sum] = "593eb5ea73908f28f9888a8bbde3aac0eb176947989862d8674d496a8f5ce0dd"

URI_aarch64_pipewire-gstreamer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-gstreamer-1.4.6-1.el10.aarch64.rpm;name=aarch64_pipewire-gstreamer;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-gstreamer}"
SRC_URI[aarch64_pipewire-gstreamer.sha256sum] = "6f0a39230747eadd55d20e264f2146ea1e429ae798e26f2757a552a7efa51eae"

URI_aarch64_pipewire-jack-audio-connection-kit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-jack-audio-connection-kit-1.4.6-1.el10.aarch64.rpm;name=aarch64_pipewire-jack-audio-connection-kit;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-jack-audio-connection-kit}"
SRC_URI[aarch64_pipewire-jack-audio-connection-kit.sha256sum] = "6ce1605b3757cd284c1948bb0c9b2a97d0c955c787ac229f9126ac879f9e02a4"

URI_aarch64_pipewire-jack-audio-connection-kit-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-jack-audio-connection-kit-devel-1.4.6-1.el10.aarch64.rpm;name=aarch64_pipewire-jack-audio-connection-kit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-jack-audio-connection-kit-devel}"
SRC_URI[aarch64_pipewire-jack-audio-connection-kit-devel.sha256sum] = "070dfdb881fc4f191bf2ed6598d777007312285b105c0b4d3311f793936bc78a"

URI_aarch64_pipewire-jack-audio-connection-kit-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-jack-audio-connection-kit-libs-1.4.6-1.el10.aarch64.rpm;name=aarch64_pipewire-jack-audio-connection-kit-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-jack-audio-connection-kit-libs}"
SRC_URI[aarch64_pipewire-jack-audio-connection-kit-libs.sha256sum] = "b91cf3a06395d1cb9880bfdbcb604cee9019878375b763e21a0a33568db9d9df"

URI_aarch64_pipewire-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-libs-1.4.6-1.el10.aarch64.rpm;name=aarch64_pipewire-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-libs}"
SRC_URI[aarch64_pipewire-libs.sha256sum] = "affdc8a9ca815053f8bff92e7313573bd6ebebdb0011a5c03a071d4104b93deb"

URI_aarch64_pipewire-module-x11 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-module-x11-1.4.6-1.el10.aarch64.rpm;name=aarch64_pipewire-module-x11;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-module-x11}"
SRC_URI[aarch64_pipewire-module-x11.sha256sum] = "b9b016a369b33651cd6a0592b3b54d58ac2056711e72d187b22371481c7924d0"

URI_aarch64_pipewire-plugin-libcamera = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-plugin-libcamera-1.4.6-1.el10.aarch64.rpm;name=aarch64_pipewire-plugin-libcamera;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-plugin-libcamera}"
SRC_URI[aarch64_pipewire-plugin-libcamera.sha256sum] = "1391421e4578fede5b083c989d78cf47b914a396778607feac0d9f43a5b4774c"

URI_aarch64_pipewire-pulseaudio = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-pulseaudio-1.4.6-1.el10.aarch64.rpm;name=aarch64_pipewire-pulseaudio;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-pulseaudio}"
SRC_URI[aarch64_pipewire-pulseaudio.sha256sum] = "9af991b1b33bd4266623eb6a88c02721576813e78d27dc9f1b3b9bd535538ac4"

URI_aarch64_pipewire-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-utils-1.4.6-1.el10.aarch64.rpm;name=aarch64_pipewire-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-utils}"
SRC_URI[aarch64_pipewire-utils.sha256sum] = "e7c52aec3a7ea3624b79ca4ad16ab025ef859ffcc8784b778b70bc77447edc95"

RDEPENDS:pipewire = " \
 bash \
 glibc \
 pipewire-libs \
 rtkit \
 systemd \
 wireplumber \
 "
RDEPENDS:pipewire-alsa = " \
 alsa-lib \
 glibc \
 pipewire-libs \
 "
RDEPENDS:pipewire-devel = " \
 pipewire-devel \
 pipewire-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:pipewire-gstreamer = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 libgcc \
 pipewire-libs \
 "
RDEPENDS:pipewire-jack-audio-connection-kit = " \
 pipewire-jack-audio-connection-kit-libs \
 "
RDEPENDS:pipewire-jack-audio-connection-kit-devel = " \
 pipewire-jack-audio-connection-kit-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:pipewire-jack-audio-connection-kit-libs = " \
 bash \
 glibc \
 pipewire-jack-audio-connection-kit \
 pipewire-libs \
 "
RDEPENDS:pipewire-libs = " \
 alsa-lib \
 avahi-libs \
 bluez-libs \
 dbus-libs \
 fdk-aac-free \
 fftw-libs-single \
 glib2 \
 glibc \
 libgcc \
 liblc3 \
 libldac \
 libsbc \
 libselinux \
 libsndfile \
 libstdc++ \
 libusb1 \
 openssl-libs \
 opus \
 pulseaudio-libs \
 systemd-libs \
 webrtc-audio-processing \
 "
RDEPENDS:pipewire-module-x11 = " \
 glibc \
 libX11 \
 libXfixes \
 libcanberra \
 pipewire-libs \
 "
RDEPENDS:pipewire-plugin-libcamera = " \
 glibc \
 libcamera \
 libdrm \
 libgcc \
 libstdc++ \
 pipewire-libs \
 "
RDEPENDS:pipewire-pulseaudio = " \
 avahi-libs \
 bash \
 dbus-libs \
 glib2 \
 glibc \
 libgcc \
 pipewire-libs \
 systemd-libs \
 "
RDEPENDS:pipewire-utils = " \
 alsa-lib \
 dbus-libs \
 glibc \
 libgcc \
 libsndfile \
 ncurses-libs \
 pipewire \
 pipewire-libs \
 readline \
 "
