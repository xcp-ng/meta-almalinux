# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fyi"
PV = "1.0.3"
PR = "2.el10_0"
PACKAGES = " \
 fyi \
 fyi-bash-completion \
 fyi-fish-completion \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fyi-1.0.3-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a47fab10aeb39a15dfbad0a7f0408901a859677bd619eac7c9396b748525825"

URI_x86_64_v2_fyi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fyi-1.0.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fyi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fyi}"
SRC_URI[x86_64_v2_fyi.sha256sum] = "f147a568bc5d9ea9856c66bde3f2b9b25947a89eca191e4f0bd61852949a9a94"

URI_x86_64_v2_fyi-bash-completion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fyi-bash-completion-1.0.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fyi-bash-completion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fyi-bash-completion}"
SRC_URI[x86_64_v2_fyi-bash-completion.sha256sum] = "e655f9c7c339c28344edf8c9abe75cf3378f29f7ffc347784d73146a267b1ee1"

URI_x86_64_v2_fyi-fish-completion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fyi-fish-completion-1.0.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fyi-fish-completion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fyi-fish-completion}"
SRC_URI[x86_64_v2_fyi-fish-completion.sha256sum] = "3d8748d99c4d4e8704795fb05cf9c834f87b866a39686c7805a87d62c8ff6cec"

URI_aarch64_fyi = "${EPEL_MIRROR}/aarch64/Packages/f/fyi-1.0.3-2.el10_0.aarch64.rpm;name=aarch64_fyi;unpack=0"
SRC_URI:append = " ${URI_aarch64_fyi}"
SRC_URI[aarch64_fyi.sha256sum] = "6543535b381176b827681c7ff7fc37a09be033e3bc85de30bf30b75cc8dda4a1"

URI_aarch64_fyi-bash-completion = "${EPEL_MIRROR}/aarch64/Packages/f/fyi-bash-completion-1.0.3-2.el10_0.noarch.rpm;name=aarch64_fyi-bash-completion;unpack=0"
SRC_URI:append = " ${URI_aarch64_fyi-bash-completion}"
SRC_URI[aarch64_fyi-bash-completion.sha256sum] = "a0cb2684adab575c81f5eddfc29e40a75a1511b38241f9fbde777c23d04a0cf1"

URI_aarch64_fyi-fish-completion = "${EPEL_MIRROR}/aarch64/Packages/f/fyi-fish-completion-1.0.3-2.el10_0.noarch.rpm;name=aarch64_fyi-fish-completion;unpack=0"
SRC_URI:append = " ${URI_aarch64_fyi-fish-completion}"
SRC_URI[aarch64_fyi-fish-completion.sha256sum] = "b155d5cfa1c2a2e0361884f987a6bf732159e8ca1519e51fedf348cd85447762"

RDEPENDS:fyi = " \
 dbus-libs \
 glibc \
 "
RDEPENDS:fyi-bash-completion = " \
 bash-completion \
 fyi \
 "
RDEPENDS:fyi-fish-completion = " \
 fish \
 fyi \
 "
