# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nsd"
PV = "4.15.2"
PR = "1.el10_2"
PACKAGES = " \
 nsd \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/n/nsd-4.15.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ca091b4b3696910c1b7a18653e7b3e792b9868850b42ee1993ba1cb6b2f9cd97"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nsd-4.15.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nsd;unpack=0"
SRC_URI[x86_64_v2_nsd.sha256sum] = "2d7100009b7454c9ab957add1fa7e338f088dab51516fbb8d192987ebb1bc7ad"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nsd-4.15.2-1.el10_2.aarch64.rpm;name=aarch64_nsd;unpack=0"
SRC_URI[aarch64_nsd.sha256sum] = "527b73d8456791211d2598981417fdbd5990053ca96f837a1f8bf3b69ea3643b"

RDEPENDS:nsd = " \
 bash \
 fstrm \
 glibc \
 libevent \
 openssl-libs \
 protobuf-c \
 systemd-libs \
 "
