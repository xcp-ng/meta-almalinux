# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-extensions-app"
PV = "46.2"
PR = "4.el10"
PACKAGES = " \
 gnome-extensions-app \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-extensions-app-46.2-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d40869259647f5c054702f42a406f80359a1b1e374d1677fd8712de0fbe23c0"

URI_x86_64_v2_gnome-extensions-app = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-extensions-app-46.2-4.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-extensions-app;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-extensions-app}"
SRC_URI[x86_64_v2_gnome-extensions-app.sha256sum] = "f9f98943df4c91de736b347956395c6ecbdf6710f6546e2db26de50cc41518df"

URI_aarch64_gnome-extensions-app = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-extensions-app-46.2-4.el10.aarch64.rpm;name=aarch64_gnome-extensions-app;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-extensions-app}"
SRC_URI[aarch64_gnome-extensions-app.sha256sum] = "0d921e5d5deace325e0ef9fe057340b109c34934e8fecb409186b687e453de0d"

RDEPENDS:gnome-extensions-app = " \
 bash \
 gjs \
 glib2 \
 glibc \
 gtk4 \
 libX11 \
 libadwaita \
 libgcc \
 "
