# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "most"
PV = "5.2.0"
PR = "8.el10_0"
PACKAGES = " \
 most \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/m/most-5.2.0-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cd3762e2fc364228d6313b15836011ed29a3d349cdb6c93f0b86e34ced1a54ed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/most-5.2.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_most;unpack=0"
SRC_URI[x86_64_v2_most.sha256sum] = "4f2d30124720bfe811dd43bf27e8fef492426e10a3047c8e7f8d9e02675fc969"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/most-5.2.0-8.el10_0.aarch64.rpm;name=aarch64_most;unpack=0"
SRC_URI[aarch64_most.sha256sum] = "64d8e83b092928a9163393a2a946cfbf0be62eb8761970c6f446334caaa7bf28"

RDEPENDS:most = " \
 glibc \
 slang \
 "
