# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-memo-map"
PV = "0.3.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-memo-map+default-devel \
 rust-memo-map-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-memo-map-0.3.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2812bf8230ce20e3c03e4733de6f04b58c5c14f5a8e2b65b1ee2bdec40c478da"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memo-map+default-devel-0.3.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memo-map+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-memo-map+default-devel.sha256sum] = "78fb81f6746c2f75b0b720960d92f16d450cf20b27d85c0b004b8e89f1c54619"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memo-map-devel-0.3.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memo-map-devel;unpack=0"
SRC_URI[x86_64_v2_rust-memo-map-devel.sha256sum] = "9e60ca9b580649c428a1c84b7a06300320251d1c393179dd0c6bba8dedc37454"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-memo-map+default-devel-0.3.4-1.el10_2.noarch.rpm;name=aarch64_rust-memo-map+default-devel;unpack=0"
SRC_URI[aarch64_rust-memo-map+default-devel.sha256sum] = "38caa99b82d92e128d987ce0c1276db66f2f198ed4b6eac55bd2d8c311f6c05f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-memo-map-devel-0.3.4-1.el10_2.noarch.rpm;name=aarch64_rust-memo-map-devel;unpack=0"
SRC_URI[aarch64_rust-memo-map-devel.sha256sum] = "ce6dda1cdcbb21fe9e24584f3bc6df9841937e32c5fc3528a595f73389cc1d83"

RDEPENDS:rust-memo-map+default-devel = " \
 cargo \
 rust-memo-map-devel \
 "
RDEPENDS:rust-memo-map-devel = " \
 cargo \
 rust \
 "
