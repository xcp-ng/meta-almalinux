# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openblas"
PV = "0.3.29"
PR = "2.el10"
PACKAGES = " \
 openblas \
 openblas-devel \
 openblas-openmp \
 openblas-openmp64 \
 openblas-openmp64_ \
 openblas-serial \
 openblas-serial64 \
 openblas-serial64_ \
 openblas-static \
 openblas-threads \
 openblas-threads64 \
 openblas-threads64_ \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/openblas-0.3.29-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e5a48c2e970d64bde0e5af20fe556ce8bfc60ec5eee79fd48e1db99f48921ad2"

URI_x86_64_v2_openblas = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openblas-0.3.29-2.el10.x86_64_v2.rpm;name=x86_64_v2_openblas;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openblas}"
SRC_URI[x86_64_v2_openblas.sha256sum] = "3efcfb8a5339446ce5a658424baad2a0c752376cc031b2ff20d3ba062b16b927"

URI_x86_64_v2_openblas-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openblas-devel-0.3.29-2.el10.x86_64_v2.rpm;name=x86_64_v2_openblas-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openblas-devel}"
SRC_URI[x86_64_v2_openblas-devel.sha256sum] = "95d46111a39b956c936b15ebd1f8d1109b757c38b641d45e08d3963f93702c52"

URI_x86_64_v2_openblas-openmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openblas-openmp-0.3.29-2.el10.x86_64_v2.rpm;name=x86_64_v2_openblas-openmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openblas-openmp}"
SRC_URI[x86_64_v2_openblas-openmp.sha256sum] = "650f362ddd729a32f5de5db0533d15c8ad9d7a55b38ff5fb6159391a30077ac6"

URI_x86_64_v2_openblas-openmp64 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openblas-openmp64-0.3.29-2.el10.x86_64_v2.rpm;name=x86_64_v2_openblas-openmp64;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openblas-openmp64}"
SRC_URI[x86_64_v2_openblas-openmp64.sha256sum] = "78bb0c272e970f2cb2eecabb0711fe5184f3aa09621c24b9c6c8fc36d69e1c28"

URI_x86_64_v2_openblas-openmp64_ = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openblas-openmp64_-0.3.29-2.el10.x86_64_v2.rpm;name=x86_64_v2_openblas-openmp64_;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openblas-openmp64_}"
SRC_URI[x86_64_v2_openblas-openmp64_.sha256sum] = "7aba9596743282078f26c407fb936c178a713c9ff27efcdc0769b13f5dde0fae"

URI_x86_64_v2_openblas-serial = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openblas-serial-0.3.29-2.el10.x86_64_v2.rpm;name=x86_64_v2_openblas-serial;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openblas-serial}"
SRC_URI[x86_64_v2_openblas-serial.sha256sum] = "76caaad2d776ba72f0ce008909776bf4a0bd3f11576573898003debd7f770eac"

URI_x86_64_v2_openblas-serial64 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openblas-serial64-0.3.29-2.el10.x86_64_v2.rpm;name=x86_64_v2_openblas-serial64;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openblas-serial64}"
SRC_URI[x86_64_v2_openblas-serial64.sha256sum] = "8cbe76c3bfcf4fb083f0d7d2e91a419e17f764adc676b7fbe294bbea3e484425"

URI_x86_64_v2_openblas-serial64_ = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openblas-serial64_-0.3.29-2.el10.x86_64_v2.rpm;name=x86_64_v2_openblas-serial64_;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openblas-serial64_}"
SRC_URI[x86_64_v2_openblas-serial64_.sha256sum] = "a859030a1feb5333034c3364539c266d782a588e3c97ec626b96ba845875d066"

URI_x86_64_v2_openblas-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openblas-static-0.3.29-2.el10.x86_64_v2.rpm;name=x86_64_v2_openblas-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openblas-static}"
SRC_URI[x86_64_v2_openblas-static.sha256sum] = "65249a871445a5a097e457e8af2f87e7b2b2cddddffae7ecab7f49f6cef89e0a"

URI_x86_64_v2_openblas-threads = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openblas-threads-0.3.29-2.el10.x86_64_v2.rpm;name=x86_64_v2_openblas-threads;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openblas-threads}"
SRC_URI[x86_64_v2_openblas-threads.sha256sum] = "16d525aa2746a7a397dd26fbe74219c985dc39c393253c08c7229e3243ce0e94"

URI_x86_64_v2_openblas-threads64 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openblas-threads64-0.3.29-2.el10.x86_64_v2.rpm;name=x86_64_v2_openblas-threads64;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openblas-threads64}"
SRC_URI[x86_64_v2_openblas-threads64.sha256sum] = "1b72df6a99941b8ae749bde73acb546ba0f21f48b53b773125864b0cdcc9a93c"

URI_x86_64_v2_openblas-threads64_ = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openblas-threads64_-0.3.29-2.el10.x86_64_v2.rpm;name=x86_64_v2_openblas-threads64_;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openblas-threads64_}"
SRC_URI[x86_64_v2_openblas-threads64_.sha256sum] = "dcaddaa32905ebb87dccc0df6e3082eae30c93a8f68563f9751d5f0de484752e"

URI_aarch64_openblas = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openblas-0.3.29-2.el10.aarch64.rpm;name=aarch64_openblas;unpack=0"
SRC_URI:append = " ${URI_aarch64_openblas}"
SRC_URI[aarch64_openblas.sha256sum] = "fc17e3ab1b2a7aee71a39b0a2bf6a14db90ecfd0492aea5383736879b33c2d86"

URI_aarch64_openblas-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openblas-devel-0.3.29-2.el10.aarch64.rpm;name=aarch64_openblas-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openblas-devel}"
SRC_URI[aarch64_openblas-devel.sha256sum] = "abf5711a9659d62f9c2b0b7933d0446659904cae8330b76da150e04470c48185"

URI_aarch64_openblas-openmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openblas-openmp-0.3.29-2.el10.aarch64.rpm;name=aarch64_openblas-openmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_openblas-openmp}"
SRC_URI[aarch64_openblas-openmp.sha256sum] = "f478a41f5382cdea55e84d4d946b8cb683918275c69ec5ca30d985262730da1f"

URI_aarch64_openblas-openmp64 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openblas-openmp64-0.3.29-2.el10.aarch64.rpm;name=aarch64_openblas-openmp64;unpack=0"
SRC_URI:append = " ${URI_aarch64_openblas-openmp64}"
SRC_URI[aarch64_openblas-openmp64.sha256sum] = "ff696fa47086d3b31ffbebac50e3402ab34c20b30bff40a432d2ec8008805a05"

URI_aarch64_openblas-openmp64_ = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openblas-openmp64_-0.3.29-2.el10.aarch64.rpm;name=aarch64_openblas-openmp64_;unpack=0"
SRC_URI:append = " ${URI_aarch64_openblas-openmp64_}"
SRC_URI[aarch64_openblas-openmp64_.sha256sum] = "0fceed0e22e0485aa1e8fe2a0f30c40d9196ba78391522c7e558ddb3957b2b5c"

URI_aarch64_openblas-serial = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openblas-serial-0.3.29-2.el10.aarch64.rpm;name=aarch64_openblas-serial;unpack=0"
SRC_URI:append = " ${URI_aarch64_openblas-serial}"
SRC_URI[aarch64_openblas-serial.sha256sum] = "a709360d32d7f1663b27a7f6fc518ee86b5d8befeed7fbf5af8599a43c5d1075"

URI_aarch64_openblas-serial64 = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openblas-serial64-0.3.29-2.el10.aarch64.rpm;name=aarch64_openblas-serial64;unpack=0"
SRC_URI:append = " ${URI_aarch64_openblas-serial64}"
SRC_URI[aarch64_openblas-serial64.sha256sum] = "0c45e75d5fce592cd09140c20d165873da3379605a030ef3e69ff8a868bc3f94"

URI_aarch64_openblas-serial64_ = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openblas-serial64_-0.3.29-2.el10.aarch64.rpm;name=aarch64_openblas-serial64_;unpack=0"
SRC_URI:append = " ${URI_aarch64_openblas-serial64_}"
SRC_URI[aarch64_openblas-serial64_.sha256sum] = "55d9d1ea3309b9889bba49349c95f492a8625742666a10443456d4c90be085d5"

URI_aarch64_openblas-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openblas-static-0.3.29-2.el10.aarch64.rpm;name=aarch64_openblas-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_openblas-static}"
SRC_URI[aarch64_openblas-static.sha256sum] = "1f6dfa03c9b8c039317255ae43e972757025290a78173344a400765cba915a27"

URI_aarch64_openblas-threads = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openblas-threads-0.3.29-2.el10.aarch64.rpm;name=aarch64_openblas-threads;unpack=0"
SRC_URI:append = " ${URI_aarch64_openblas-threads}"
SRC_URI[aarch64_openblas-threads.sha256sum] = "b44e15e6304acadcf5857a372e904ff826d5ed2d7b195165fcac04d0f0112d68"

URI_aarch64_openblas-threads64 = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openblas-threads64-0.3.29-2.el10.aarch64.rpm;name=aarch64_openblas-threads64;unpack=0"
SRC_URI:append = " ${URI_aarch64_openblas-threads64}"
SRC_URI[aarch64_openblas-threads64.sha256sum] = "77f62edd865545e980ed646345d500c3d0a236d7cb127f6518bb972631f5cfa0"

URI_aarch64_openblas-threads64_ = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openblas-threads64_-0.3.29-2.el10.aarch64.rpm;name=aarch64_openblas-threads64_;unpack=0"
SRC_URI:append = " ${URI_aarch64_openblas-threads64_}"
SRC_URI[aarch64_openblas-threads64_.sha256sum] = "73a0403aa1b093eba678d253d11f78af1bb1521ce9d19e2f9dc753029e54d51b"

RDEPENDS:openblas = " \
 "
RDEPENDS:openblas-devel = " \
 openblas \
 openblas-openmp \
 openblas-openmp64 \
 openblas-openmp64_ \
 openblas-serial \
 openblas-serial64 \
 openblas-serial64_ \
 openblas-srpm-macros \
 openblas-threads \
 openblas-threads64 \
 openblas-threads64_ \
 pkgconf-pkg-config \
 "
RDEPENDS:openblas-openmp = " \
 glibc \
 libgcc \
 libgfortran \
 libgomp \
 openblas \
 "
RDEPENDS:openblas-openmp64 = " \
 glibc \
 libgcc \
 libgfortran \
 libgomp \
 openblas \
 "
RDEPENDS:openblas-openmp64_ = " \
 glibc \
 libgcc \
 libgfortran \
 libgomp \
 openblas \
 "
RDEPENDS:openblas-serial = " \
 glibc \
 libgfortran \
 openblas \
 "
RDEPENDS:openblas-serial64 = " \
 glibc \
 libgfortran \
 openblas \
 "
RDEPENDS:openblas-serial64_ = " \
 glibc \
 libgfortran \
 openblas \
 "
RDEPENDS:openblas-static = " \
 openblas-devel \
 "
RDEPENDS:openblas-threads = " \
 glibc \
 libgfortran \
 openblas \
 "
RDEPENDS:openblas-threads64 = " \
 glibc \
 libgfortran \
 openblas \
 "
RDEPENDS:openblas-threads64_ = " \
 glibc \
 libgfortran \
 openblas \
 "
