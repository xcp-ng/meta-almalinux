# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-regex"
PV = "1.12.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-regex+default-devel \
 rust-regex+logging-devel \
 rust-regex+pattern-devel \
 rust-regex+perf-backtrack-devel \
 rust-regex+perf-cache-devel \
 rust-regex+perf-devel \
 rust-regex+perf-dfa-devel \
 rust-regex+perf-dfa-full-devel \
 rust-regex+perf-inline-devel \
 rust-regex+perf-literal-devel \
 rust-regex+perf-onepass-devel \
 rust-regex+std-devel \
 rust-regex+unicode-age-devel \
 rust-regex+unicode-bool-devel \
 rust-regex+unicode-case-devel \
 rust-regex+unicode-devel \
 rust-regex+unicode-gencat-devel \
 rust-regex+unicode-perl-devel \
 rust-regex+unicode-script-devel \
 rust-regex+unicode-segment-devel \
 rust-regex+unstable-devel \
 rust-regex+use_std-devel \
 rust-regex-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-regex-1.12.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "913fc21ac92945f405ddc307c1f0cc55c7998158f8cccabcc1448baad871c64a"

URI_x86_64_v2_rust-regex+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+default-devel-1.12.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+default-devel}"
SRC_URI[x86_64_v2_rust-regex+default-devel.sha256sum] = "40e8e73946424c75bda6b458e9281fd189b474a2932b612a878783a6435b5fd7"

URI_x86_64_v2_rust-regex+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+logging-devel-1.12.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+logging-devel}"
SRC_URI[x86_64_v2_rust-regex+logging-devel.sha256sum] = "8dac0ebeae906e5ae2959e994c290de4f335040328916cd43ddba8c6f8f9c9a1"

URI_x86_64_v2_rust-regex+pattern-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+pattern-devel-1.12.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+pattern-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+pattern-devel}"
SRC_URI[x86_64_v2_rust-regex+pattern-devel.sha256sum] = "2b437c6bc35c43c2345f3a01adf8be419076a8732d80f81ee0b519a31b54c0a1"

URI_x86_64_v2_rust-regex+perf-backtrack-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+perf-backtrack-devel-1.12.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+perf-backtrack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+perf-backtrack-devel}"
SRC_URI[x86_64_v2_rust-regex+perf-backtrack-devel.sha256sum] = "504c9205d198b8d5a71f8c502d72f9e2baf84f310387247d8da21a8ac75279ef"

URI_x86_64_v2_rust-regex+perf-cache-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+perf-cache-devel-1.12.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+perf-cache-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+perf-cache-devel}"
SRC_URI[x86_64_v2_rust-regex+perf-cache-devel.sha256sum] = "0ad660fbadd73c3466b9f5afeb163a31f22640be5f110493be1b0ed414126bec"

URI_x86_64_v2_rust-regex+perf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+perf-devel-1.12.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+perf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+perf-devel}"
SRC_URI[x86_64_v2_rust-regex+perf-devel.sha256sum] = "825f858172e69073f00e7e122d8d0e3cc6f92756d06e7cd3d60078ff7c33e76e"

URI_x86_64_v2_rust-regex+perf-dfa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+perf-dfa-devel-1.12.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+perf-dfa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+perf-dfa-devel}"
SRC_URI[x86_64_v2_rust-regex+perf-dfa-devel.sha256sum] = "19baa9c18665171ffab39378eb809e00bde5d60c5dc1404dbb3155af23448a69"

URI_x86_64_v2_rust-regex+perf-dfa-full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+perf-dfa-full-devel-1.12.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+perf-dfa-full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+perf-dfa-full-devel}"
SRC_URI[x86_64_v2_rust-regex+perf-dfa-full-devel.sha256sum] = "2394ab0275c78a7c68e74bdd2aeee80ad63c86f966a9257fd6f290e3c75fad3f"

URI_x86_64_v2_rust-regex+perf-inline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+perf-inline-devel-1.12.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+perf-inline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+perf-inline-devel}"
SRC_URI[x86_64_v2_rust-regex+perf-inline-devel.sha256sum] = "6ad66b6736e490bf0c14fe685100b9c8259f0cb4b358ff33b5a0c7b6dc509fbf"

URI_x86_64_v2_rust-regex+perf-literal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+perf-literal-devel-1.12.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+perf-literal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+perf-literal-devel}"
SRC_URI[x86_64_v2_rust-regex+perf-literal-devel.sha256sum] = "283e9b78cb2d9556a413b75739ce6377e77a69e9a900d9c2c58cb28efa827fd0"

URI_x86_64_v2_rust-regex+perf-onepass-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+perf-onepass-devel-1.12.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+perf-onepass-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+perf-onepass-devel}"
SRC_URI[x86_64_v2_rust-regex+perf-onepass-devel.sha256sum] = "6b2696990727181aa539e73693c0725bf2e0840b11d18750a94544bfe4056d1f"

URI_x86_64_v2_rust-regex+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+std-devel-1.12.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+std-devel}"
SRC_URI[x86_64_v2_rust-regex+std-devel.sha256sum] = "57a3ed65d637a800d2113526ae51f16dea705d33e2bb5a5f6ef3f860d877ae51"

URI_x86_64_v2_rust-regex+unicode-age-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unicode-age-devel-1.12.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unicode-age-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unicode-age-devel}"
SRC_URI[x86_64_v2_rust-regex+unicode-age-devel.sha256sum] = "0d43f353d9a4a93aef670656d3055a661cc2ef4b5721c5153ed20143cd50e80d"

URI_x86_64_v2_rust-regex+unicode-bool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unicode-bool-devel-1.12.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unicode-bool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unicode-bool-devel}"
SRC_URI[x86_64_v2_rust-regex+unicode-bool-devel.sha256sum] = "f6e30da3503e94e9d80d56a7d57b61f5f1b1e2fb8d625dd1abe28f87cb896450"

URI_x86_64_v2_rust-regex+unicode-case-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unicode-case-devel-1.12.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unicode-case-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unicode-case-devel}"
SRC_URI[x86_64_v2_rust-regex+unicode-case-devel.sha256sum] = "3ccc72fea5b44188e9f98669ab3f92ba0752eff15deda0fd66c72284b8c2500f"

URI_x86_64_v2_rust-regex+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unicode-devel-1.12.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unicode-devel}"
SRC_URI[x86_64_v2_rust-regex+unicode-devel.sha256sum] = "98ce947f4322cc8cec28f03b8fa6aa7aa34997e7c66a6311eb60cf29302182d8"

URI_x86_64_v2_rust-regex+unicode-gencat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unicode-gencat-devel-1.12.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unicode-gencat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unicode-gencat-devel}"
SRC_URI[x86_64_v2_rust-regex+unicode-gencat-devel.sha256sum] = "7abb7fdda596cb039daf40c278ad48f33c9bdb416d04a86d1de8b9e00b6437cb"

URI_x86_64_v2_rust-regex+unicode-perl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unicode-perl-devel-1.12.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unicode-perl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unicode-perl-devel}"
SRC_URI[x86_64_v2_rust-regex+unicode-perl-devel.sha256sum] = "17adf72bbd502cb35a9b8f8f6c70a66d0b9ed1c3eaa5c3ce36d2b9e9b1b8ac38"

URI_x86_64_v2_rust-regex+unicode-script-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unicode-script-devel-1.12.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unicode-script-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unicode-script-devel}"
SRC_URI[x86_64_v2_rust-regex+unicode-script-devel.sha256sum] = "fb89280be7bcda64b33dafde480dbf86dc30fef1747deb9afcf260f61c07b682"

URI_x86_64_v2_rust-regex+unicode-segment-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unicode-segment-devel-1.12.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unicode-segment-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unicode-segment-devel}"
SRC_URI[x86_64_v2_rust-regex+unicode-segment-devel.sha256sum] = "b8730e5046c39a4cb9eccbd4eddcb025b4f22003d8f70700d5f0220d7fda3d04"

URI_x86_64_v2_rust-regex+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unstable-devel-1.12.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unstable-devel}"
SRC_URI[x86_64_v2_rust-regex+unstable-devel.sha256sum] = "ec2f8eb4fc298bf4524450090513bc484c49a6f55f8571066bb092acee83f62e"

URI_x86_64_v2_rust-regex+use_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+use_std-devel-1.12.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+use_std-devel}"
SRC_URI[x86_64_v2_rust-regex+use_std-devel.sha256sum] = "4c377587afb15bc5f351816ed5d8135228f152be954a0f03f45dbc0616fd3a94"

URI_x86_64_v2_rust-regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-devel-1.12.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-devel}"
SRC_URI[x86_64_v2_rust-regex-devel.sha256sum] = "f679725670b4023269cf3b5b0733305e0d853bfaded9866091cb66ae1f3f9253"

URI_aarch64_rust-regex+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+default-devel-1.12.2-1.el10_1.noarch.rpm;name=aarch64_rust-regex+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+default-devel}"
SRC_URI[aarch64_rust-regex+default-devel.sha256sum] = "b302008909aeba2792b2fc4f482c458ffdb513f35a9ec1160a3a25f52e3d26ff"

URI_aarch64_rust-regex+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+logging-devel-1.12.2-1.el10_1.noarch.rpm;name=aarch64_rust-regex+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+logging-devel}"
SRC_URI[aarch64_rust-regex+logging-devel.sha256sum] = "8b554698641f6b9ef5061f2ec39bff01c85af34c0dd892dd2b6c3d4dfbd452cf"

URI_aarch64_rust-regex+pattern-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+pattern-devel-1.12.2-1.el10_1.noarch.rpm;name=aarch64_rust-regex+pattern-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+pattern-devel}"
SRC_URI[aarch64_rust-regex+pattern-devel.sha256sum] = "4ff379ec7cf3a638eb95f42667c5cbfb0c474c2ed3893a892b3fcde92fe34fff"

URI_aarch64_rust-regex+perf-backtrack-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+perf-backtrack-devel-1.12.2-1.el10_1.noarch.rpm;name=aarch64_rust-regex+perf-backtrack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+perf-backtrack-devel}"
SRC_URI[aarch64_rust-regex+perf-backtrack-devel.sha256sum] = "cd0aa6496b2e36ccf6d606f3fbcb474fd42a11ca49d79799daf9d1ff9d101153"

URI_aarch64_rust-regex+perf-cache-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+perf-cache-devel-1.12.2-1.el10_1.noarch.rpm;name=aarch64_rust-regex+perf-cache-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+perf-cache-devel}"
SRC_URI[aarch64_rust-regex+perf-cache-devel.sha256sum] = "29f24c732b2c74cafbca0d136bc01834422ba3e7aead2acf6524e7a3fb296ac4"

URI_aarch64_rust-regex+perf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+perf-devel-1.12.2-1.el10_1.noarch.rpm;name=aarch64_rust-regex+perf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+perf-devel}"
SRC_URI[aarch64_rust-regex+perf-devel.sha256sum] = "c2e09d2d346c0406b8476f3851b9539f8e672993281fed43a9894384699e28c6"

URI_aarch64_rust-regex+perf-dfa-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+perf-dfa-devel-1.12.2-1.el10_1.noarch.rpm;name=aarch64_rust-regex+perf-dfa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+perf-dfa-devel}"
SRC_URI[aarch64_rust-regex+perf-dfa-devel.sha256sum] = "ff7540716037f0a18ed064fb73b539d5aadebaea89bbc86734e62757c6c95046"

URI_aarch64_rust-regex+perf-dfa-full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+perf-dfa-full-devel-1.12.2-1.el10_1.noarch.rpm;name=aarch64_rust-regex+perf-dfa-full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+perf-dfa-full-devel}"
SRC_URI[aarch64_rust-regex+perf-dfa-full-devel.sha256sum] = "585bb9d9df70da42ecdc2c619e180d8b2036e3b8d24a4882d32bb769e5726066"

URI_aarch64_rust-regex+perf-inline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+perf-inline-devel-1.12.2-1.el10_1.noarch.rpm;name=aarch64_rust-regex+perf-inline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+perf-inline-devel}"
SRC_URI[aarch64_rust-regex+perf-inline-devel.sha256sum] = "2946d1aff6559ce5306d5b894d20b484a20fa598928ad507902ec83a5e665c4f"

URI_aarch64_rust-regex+perf-literal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+perf-literal-devel-1.12.2-1.el10_1.noarch.rpm;name=aarch64_rust-regex+perf-literal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+perf-literal-devel}"
SRC_URI[aarch64_rust-regex+perf-literal-devel.sha256sum] = "25c6a56eb2bb4b87b08eac20bbe3acbb19c932317a3b58b9f6f9f5b1dd141f91"

URI_aarch64_rust-regex+perf-onepass-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+perf-onepass-devel-1.12.2-1.el10_1.noarch.rpm;name=aarch64_rust-regex+perf-onepass-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+perf-onepass-devel}"
SRC_URI[aarch64_rust-regex+perf-onepass-devel.sha256sum] = "2734610ddd578ccd74658f472eb436f1962a7e6866007f0e02af30ceec6d04e4"

URI_aarch64_rust-regex+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+std-devel-1.12.2-1.el10_1.noarch.rpm;name=aarch64_rust-regex+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+std-devel}"
SRC_URI[aarch64_rust-regex+std-devel.sha256sum] = "98555f9c5f6bb14b2005ef8476101f8ce895e223daf46c5ebdb43df529b36ad5"

URI_aarch64_rust-regex+unicode-age-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unicode-age-devel-1.12.2-1.el10_1.noarch.rpm;name=aarch64_rust-regex+unicode-age-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unicode-age-devel}"
SRC_URI[aarch64_rust-regex+unicode-age-devel.sha256sum] = "f30e2102ad0b62ae9110306156fd9495f72f7a62d43e4dc86e3035ec3223ec94"

URI_aarch64_rust-regex+unicode-bool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unicode-bool-devel-1.12.2-1.el10_1.noarch.rpm;name=aarch64_rust-regex+unicode-bool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unicode-bool-devel}"
SRC_URI[aarch64_rust-regex+unicode-bool-devel.sha256sum] = "f4b2abfcc766982ab0bfc058e3205544f76e7874208bf953b43a12e752c2f867"

URI_aarch64_rust-regex+unicode-case-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unicode-case-devel-1.12.2-1.el10_1.noarch.rpm;name=aarch64_rust-regex+unicode-case-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unicode-case-devel}"
SRC_URI[aarch64_rust-regex+unicode-case-devel.sha256sum] = "68cf24f2ec7d157e98a968c5681932a1846d4f83d91a09045e7321384e3e44cd"

URI_aarch64_rust-regex+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unicode-devel-1.12.2-1.el10_1.noarch.rpm;name=aarch64_rust-regex+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unicode-devel}"
SRC_URI[aarch64_rust-regex+unicode-devel.sha256sum] = "7a6f0fe6c6a15b70ef11a68581211543b21074b63d680fa31a817b85103dbc94"

URI_aarch64_rust-regex+unicode-gencat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unicode-gencat-devel-1.12.2-1.el10_1.noarch.rpm;name=aarch64_rust-regex+unicode-gencat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unicode-gencat-devel}"
SRC_URI[aarch64_rust-regex+unicode-gencat-devel.sha256sum] = "b19c0156103a3a95ee982f1a80fd35b304648dd42b2ed5db1274d7de66dfd229"

URI_aarch64_rust-regex+unicode-perl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unicode-perl-devel-1.12.2-1.el10_1.noarch.rpm;name=aarch64_rust-regex+unicode-perl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unicode-perl-devel}"
SRC_URI[aarch64_rust-regex+unicode-perl-devel.sha256sum] = "35d7100be0d1d6dafd5b75724477b5bece70b1921cc460b8bae95de677463281"

URI_aarch64_rust-regex+unicode-script-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unicode-script-devel-1.12.2-1.el10_1.noarch.rpm;name=aarch64_rust-regex+unicode-script-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unicode-script-devel}"
SRC_URI[aarch64_rust-regex+unicode-script-devel.sha256sum] = "854f367d170ecec6516a22e7392ad97cb7f6fa9691f5282235796f02f2434d04"

URI_aarch64_rust-regex+unicode-segment-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unicode-segment-devel-1.12.2-1.el10_1.noarch.rpm;name=aarch64_rust-regex+unicode-segment-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unicode-segment-devel}"
SRC_URI[aarch64_rust-regex+unicode-segment-devel.sha256sum] = "657673b144cd44ac610e5bc78e7b56507a13ba35526ef553ec608a8063f5ae8c"

URI_aarch64_rust-regex+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unstable-devel-1.12.2-1.el10_1.noarch.rpm;name=aarch64_rust-regex+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unstable-devel}"
SRC_URI[aarch64_rust-regex+unstable-devel.sha256sum] = "bb29c7144503c8489f0ad684be6ac4e4735d99145be83c86e206f23b85546f64"

URI_aarch64_rust-regex+use_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+use_std-devel-1.12.2-1.el10_1.noarch.rpm;name=aarch64_rust-regex+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+use_std-devel}"
SRC_URI[aarch64_rust-regex+use_std-devel.sha256sum] = "14bf4af39598e6aef37cae41cffe95cb5484aa7b83fdd1d8c66cc4c755a9ec66"

URI_aarch64_rust-regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-devel-1.12.2-1.el10_1.noarch.rpm;name=aarch64_rust-regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-devel}"
SRC_URI[aarch64_rust-regex-devel.sha256sum] = "447c435e35baba04573ade0df6c040481542a5f1530b4250dfb8a4cc3401a257"

RDEPENDS:rust-regex+default-devel = " \
 cargo \
 rust-regex+perf-devel \
 rust-regex+std-devel \
 rust-regex+unicode-devel \
 rust-regex-devel \
 rust-regex-syntax+default-devel \
 "
RDEPENDS:rust-regex+logging-devel = " \
 cargo \
 rust-aho-corasick+logging-devel \
 rust-aho-corasick-devel \
 rust-memchr+logging-devel \
 rust-memchr-devel \
 rust-regex-automata+logging-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+pattern-devel = " \
 cargo \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+perf-backtrack-devel = " \
 cargo \
 rust-regex-automata+nfa-backtrack-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+perf-cache-devel = " \
 cargo \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+perf-devel = " \
 cargo \
 rust-regex+perf-backtrack-devel \
 rust-regex+perf-cache-devel \
 rust-regex+perf-dfa-devel \
 rust-regex+perf-inline-devel \
 rust-regex+perf-literal-devel \
 rust-regex+perf-onepass-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+perf-dfa-devel = " \
 cargo \
 rust-regex-automata+hybrid-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+perf-dfa-full-devel = " \
 cargo \
 rust-regex-automata+dfa-build-devel \
 rust-regex-automata+dfa-search-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+perf-inline-devel = " \
 cargo \
 rust-regex-automata+perf-inline-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+perf-literal-devel = " \
 cargo \
 rust-aho-corasick-devel \
 rust-memchr-devel \
 rust-regex-automata+perf-literal-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+perf-onepass-devel = " \
 cargo \
 rust-regex-automata+dfa-onepass-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+std-devel = " \
 cargo \
 rust-aho-corasick+std-devel \
 rust-aho-corasick-devel \
 rust-memchr+std-devel \
 rust-memchr-devel \
 rust-regex-automata+std-devel \
 rust-regex-devel \
 rust-regex-syntax+std-devel \
 "
RDEPENDS:rust-regex+unicode-age-devel = " \
 cargo \
 rust-regex-automata+unicode-age-devel \
 rust-regex-devel \
 rust-regex-syntax+unicode-age-devel \
 "
RDEPENDS:rust-regex+unicode-bool-devel = " \
 cargo \
 rust-regex-automata+unicode-bool-devel \
 rust-regex-devel \
 rust-regex-syntax+unicode-bool-devel \
 "
RDEPENDS:rust-regex+unicode-case-devel = " \
 cargo \
 rust-regex-automata+unicode-case-devel \
 rust-regex-devel \
 rust-regex-syntax+unicode-case-devel \
 "
RDEPENDS:rust-regex+unicode-devel = " \
 cargo \
 rust-regex+unicode-age-devel \
 rust-regex+unicode-bool-devel \
 rust-regex+unicode-case-devel \
 rust-regex+unicode-gencat-devel \
 rust-regex+unicode-perl-devel \
 rust-regex+unicode-script-devel \
 rust-regex+unicode-segment-devel \
 rust-regex-automata+unicode-devel \
 rust-regex-devel \
 rust-regex-syntax+unicode-devel \
 "
RDEPENDS:rust-regex+unicode-gencat-devel = " \
 cargo \
 rust-regex-automata+unicode-gencat-devel \
 rust-regex-devel \
 rust-regex-syntax+unicode-gencat-devel \
 "
RDEPENDS:rust-regex+unicode-perl-devel = " \
 cargo \
 rust-regex-automata+unicode-perl-devel \
 rust-regex-automata+unicode-word-boundary-devel \
 rust-regex-devel \
 rust-regex-syntax+unicode-perl-devel \
 "
RDEPENDS:rust-regex+unicode-script-devel = " \
 cargo \
 rust-regex-automata+unicode-script-devel \
 rust-regex-devel \
 rust-regex-syntax+unicode-script-devel \
 "
RDEPENDS:rust-regex+unicode-segment-devel = " \
 cargo \
 rust-regex-automata+unicode-segment-devel \
 rust-regex-devel \
 rust-regex-syntax+unicode-segment-devel \
 "
RDEPENDS:rust-regex+unstable-devel = " \
 cargo \
 rust-regex+pattern-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+use_std-devel = " \
 cargo \
 rust-regex+std-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex-devel = " \
 bash \
 cargo \
 rust \
 rust-regex-automata+alloc-devel \
 rust-regex-automata+meta-devel \
 rust-regex-automata+nfa-pikevm-devel \
 rust-regex-automata+syntax-devel \
 rust-regex-automata-devel \
 rust-regex-syntax-devel \
 "
