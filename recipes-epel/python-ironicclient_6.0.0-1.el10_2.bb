# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ironicclient"
PV = "6.0.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-ironicclient \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-ironicclient-6.0.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f30be5e78f9cd75883ab5d39222f1c6494c686581345c6e29e408d0fce46406a"

URI_x86_64_v2_python3-ironicclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ironicclient-6.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ironicclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ironicclient}"
SRC_URI[x86_64_v2_python3-ironicclient.sha256sum] = "12755b015f620fd56fc33ca06eed042801ae85b056865f2c2d4b8b063801aff9"

URI_aarch64_python3-ironicclient = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ironicclient-6.0.0-1.el10_2.noarch.rpm;name=aarch64_python3-ironicclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ironicclient}"
SRC_URI[aarch64_python3-ironicclient.sha256sum] = "aa0522b2428e766646bed9ba7172d98d3d5d721351416d4425cb230ce4887a63"

RDEPENDS:python3-ironicclient = " \
 python3 \
 python3-cliff \
 python3-dogpile-cache \
 python3-jsonschema \
 python3-keystoneauth1 \
 python3-openstacksdk \
 python3-osc-lib \
 python3-oslo-utils \
 python3-pbr \
 python3-platformdirs \
 python3-pyyaml \
 python3-requests \
 python3-stevedore \
 xorriso \
 "
