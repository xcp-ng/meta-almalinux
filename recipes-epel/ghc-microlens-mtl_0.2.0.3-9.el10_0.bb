# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-microlens-mtl"
PV = "0.2.0.3"
PR = "9.el10_0"
PACKAGES = " \
 ghc-microlens-mtl \
 ghc-microlens-mtl-devel \
 ghc-microlens-mtl-doc \
 ghc-microlens-mtl-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-microlens-mtl-0.2.0.3-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9b391d41210f2775b1c1d27e1c896e68b6dfc68ecf2afbae29a66f8af13f56ae"

URI_x86_64_v2_ghc-microlens-mtl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-microlens-mtl-0.2.0.3-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-microlens-mtl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-microlens-mtl}"
SRC_URI[x86_64_v2_ghc-microlens-mtl.sha256sum] = "894fe498af0bfa923464012ecea30064f248b751266dc2c76600c8b1547966ca"

URI_x86_64_v2_ghc-microlens-mtl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-microlens-mtl-devel-0.2.0.3-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-microlens-mtl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-microlens-mtl-devel}"
SRC_URI[x86_64_v2_ghc-microlens-mtl-devel.sha256sum] = "2f42b9c5533675fd9995272323f61be96a554873a00089ba652c3d598bb84d10"

URI_x86_64_v2_ghc-microlens-mtl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-microlens-mtl-doc-0.2.0.3-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-microlens-mtl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-microlens-mtl-doc}"
SRC_URI[x86_64_v2_ghc-microlens-mtl-doc.sha256sum] = "0556f8a89c21c4e12c968720fe042fd7bdcb1314e300fe53296682a26d592e68"

URI_x86_64_v2_ghc-microlens-mtl-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-microlens-mtl-prof-0.2.0.3-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-microlens-mtl-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-microlens-mtl-prof}"
SRC_URI[x86_64_v2_ghc-microlens-mtl-prof.sha256sum] = "9502492a996b322867ef50f4d7aa0e7fdbcb2e138aef2b72b399acb613a05865"

URI_aarch64_ghc-microlens-mtl = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-microlens-mtl-0.2.0.3-9.el10_0.aarch64.rpm;name=aarch64_ghc-microlens-mtl;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-microlens-mtl}"
SRC_URI[aarch64_ghc-microlens-mtl.sha256sum] = "9804e4585a4ea4a7499865875bcff7093829eb00caec1c55b1cb4a430f4faa40"

URI_aarch64_ghc-microlens-mtl-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-microlens-mtl-devel-0.2.0.3-9.el10_0.aarch64.rpm;name=aarch64_ghc-microlens-mtl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-microlens-mtl-devel}"
SRC_URI[aarch64_ghc-microlens-mtl-devel.sha256sum] = "67695df01aa879764704c8d9611b5ad643add8f189a7883a6014ba1903c899bc"

URI_aarch64_ghc-microlens-mtl-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-microlens-mtl-doc-0.2.0.3-9.el10_0.noarch.rpm;name=aarch64_ghc-microlens-mtl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-microlens-mtl-doc}"
SRC_URI[aarch64_ghc-microlens-mtl-doc.sha256sum] = "63a5f5257f5d504c3f0480527474c20851a8f08b95811438cea083b53deafa99"

URI_aarch64_ghc-microlens-mtl-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-microlens-mtl-prof-0.2.0.3-9.el10_0.aarch64.rpm;name=aarch64_ghc-microlens-mtl-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-microlens-mtl-prof}"
SRC_URI[aarch64_ghc-microlens-mtl-prof.sha256sum] = "cd8d275f99f1318d3cd16324e857b6a3b179cb539ac9c99d8b5323ba06fb11f8"

RDEPENDS:ghc-microlens-mtl = " \
 ghc-base \
 ghc-ghc-bignum \
 ghc-microlens \
 ghc-mtl \
 ghc-transformers \
 ghc-transformers-compat \
 glibc \
 gmp \
 "
RDEPENDS:ghc-microlens-mtl-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-microlens-devel \
 ghc-microlens-mtl \
 ghc-mtl-devel \
 ghc-transformers-compat-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-microlens-mtl-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-microlens-mtl-prof = " \
 ghc-base-prof \
 ghc-microlens-mtl-devel \
 ghc-microlens-prof \
 ghc-mtl-prof \
 ghc-transformers-compat-prof \
 ghc-transformers-prof \
 "
