# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libssh"
PV = "0.11.1"
PR = "4.el10_0"
PACKAGES = " \
 libssh \
 libssh-config \
 libssh-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libssh-0.11.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8bec2151ca3674a5ded7b159a0582b3586bb80d7489f494935879bbe7a7ab120"

URI_x86_64_v2_libssh = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libssh-0.11.1-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_libssh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libssh}"
SRC_URI[x86_64_v2_libssh.sha256sum] = "d2f3a8949eee22bb49cb43e9136d54bf680f9ea4ad72a2b2b678b517234a9014"

URI_x86_64_v2_libssh-config = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libssh-config-0.11.1-4.el10_0.noarch.rpm;name=x86_64_v2_libssh-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libssh-config}"
SRC_URI[x86_64_v2_libssh-config.sha256sum] = "158aff84c7b644acf712580e0a52436c02cadb8efba212801e2ca5582b162eb6"

URI_x86_64_v2_libssh-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libssh-devel-0.11.1-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_libssh-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libssh-devel}"
SRC_URI[x86_64_v2_libssh-devel.sha256sum] = "47a2295c873fb1f928a756647a39a5c04ce183fbe58b6a775321cf168802e01f"

URI_aarch64_libssh = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libssh-0.11.1-4.el10_0.aarch64.rpm;name=aarch64_libssh;unpack=0"
SRC_URI:append = " ${URI_aarch64_libssh}"
SRC_URI[aarch64_libssh.sha256sum] = "f6eb3c014dc5c1beeea1f66ee6a4c4fbe194c8b58d2c93bca55b7b245e9d33b5"

URI_aarch64_libssh-config = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libssh-config-0.11.1-4.el10_0.noarch.rpm;name=aarch64_libssh-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_libssh-config}"
SRC_URI[aarch64_libssh-config.sha256sum] = "158aff84c7b644acf712580e0a52436c02cadb8efba212801e2ca5582b162eb6"

URI_aarch64_libssh-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libssh-devel-0.11.1-4.el10_0.aarch64.rpm;name=aarch64_libssh-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libssh-devel}"
SRC_URI[aarch64_libssh-devel.sha256sum] = "e5e5f60e5b61ef02c0b1a525aa9b7b9b151e42b466aea20d7fb46047a8c6d401"

RDEPENDS:libssh = " \
 glibc \
 krb5-libs \
 libssh-config \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:libssh-config = " \
 "
RDEPENDS:libssh-devel = " \
 cmake-filesystem \
 libssh \
 pkgconf-pkg-config \
 "
