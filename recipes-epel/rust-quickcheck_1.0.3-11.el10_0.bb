# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-quickcheck"
PV = "1.0.3"
PR = "11.el10_0"
PACKAGES = " \
 rust-quickcheck+default-devel \
 rust-quickcheck+env_logger-devel \
 rust-quickcheck+log-devel \
 rust-quickcheck+regex-devel \
 rust-quickcheck+use_logging-devel \
 rust-quickcheck-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-quickcheck-1.0.3-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "42ac69c4d74c0ed535ec9e2db202cdb7a9d6b845b96ed1174e1561d1c8108304"

URI_x86_64_v2_rust-quickcheck+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quickcheck+default-devel-1.0.3-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quickcheck+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quickcheck+default-devel}"
SRC_URI[x86_64_v2_rust-quickcheck+default-devel.sha256sum] = "0c957158ad9f13023cfa70c3a7165011326293b5aa5f36b700e405ce72fd4422"

URI_x86_64_v2_rust-quickcheck+env_logger-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quickcheck+env_logger-devel-1.0.3-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quickcheck+env_logger-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quickcheck+env_logger-devel}"
SRC_URI[x86_64_v2_rust-quickcheck+env_logger-devel.sha256sum] = "7578f6e21248cff111ed65366bb8086a2386ccb42edf2656e2af9cd3023a5e18"

URI_x86_64_v2_rust-quickcheck+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quickcheck+log-devel-1.0.3-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quickcheck+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quickcheck+log-devel}"
SRC_URI[x86_64_v2_rust-quickcheck+log-devel.sha256sum] = "d208853611961614e3ef0c1ef7387602eb2b251215cd74080201f726dd229368"

URI_x86_64_v2_rust-quickcheck+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quickcheck+regex-devel-1.0.3-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quickcheck+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quickcheck+regex-devel}"
SRC_URI[x86_64_v2_rust-quickcheck+regex-devel.sha256sum] = "9101ce1c7169bfe966f845c011472ce8562e8c9780e8f84f0e7a5c6e7cfe6680"

URI_x86_64_v2_rust-quickcheck+use_logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quickcheck+use_logging-devel-1.0.3-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quickcheck+use_logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quickcheck+use_logging-devel}"
SRC_URI[x86_64_v2_rust-quickcheck+use_logging-devel.sha256sum] = "56b8367635a0937e5268e835c44ec4ea185586efd702c981e67cbd04f6cf35ab"

URI_x86_64_v2_rust-quickcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quickcheck-devel-1.0.3-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quickcheck-devel}"
SRC_URI[x86_64_v2_rust-quickcheck-devel.sha256sum] = "722778c36f2ef46f09039f48ce4e3fcf52a7c03d19ca6dba28eb7b9295a3c78f"

URI_aarch64_rust-quickcheck+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quickcheck+default-devel-1.0.3-11.el10_0.noarch.rpm;name=aarch64_rust-quickcheck+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quickcheck+default-devel}"
SRC_URI[aarch64_rust-quickcheck+default-devel.sha256sum] = "ce817860780bf6356f1a97374acd1c91ca97ee11c1570a6f7ca4f6671e88fc43"

URI_aarch64_rust-quickcheck+env_logger-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quickcheck+env_logger-devel-1.0.3-11.el10_0.noarch.rpm;name=aarch64_rust-quickcheck+env_logger-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quickcheck+env_logger-devel}"
SRC_URI[aarch64_rust-quickcheck+env_logger-devel.sha256sum] = "c5517df9f3f56b3c04e7862a574864f2222adcebbe25a870062a78b07d3ee4bb"

URI_aarch64_rust-quickcheck+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quickcheck+log-devel-1.0.3-11.el10_0.noarch.rpm;name=aarch64_rust-quickcheck+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quickcheck+log-devel}"
SRC_URI[aarch64_rust-quickcheck+log-devel.sha256sum] = "3ab1ebbe730e52f5a7898a31b1f7f5da9c5655867af7c10a6fd2c989b6f49768"

URI_aarch64_rust-quickcheck+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quickcheck+regex-devel-1.0.3-11.el10_0.noarch.rpm;name=aarch64_rust-quickcheck+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quickcheck+regex-devel}"
SRC_URI[aarch64_rust-quickcheck+regex-devel.sha256sum] = "a444df75710bcdcdef56c45ed9ff61f194c774c687c7d6ca74684e371100a132"

URI_aarch64_rust-quickcheck+use_logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quickcheck+use_logging-devel-1.0.3-11.el10_0.noarch.rpm;name=aarch64_rust-quickcheck+use_logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quickcheck+use_logging-devel}"
SRC_URI[aarch64_rust-quickcheck+use_logging-devel.sha256sum] = "2b5396fc77d8126635cf8ca1fa7e9f80c15245cc368e0875b8a089708006491d"

URI_aarch64_rust-quickcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quickcheck-devel-1.0.3-11.el10_0.noarch.rpm;name=aarch64_rust-quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quickcheck-devel}"
SRC_URI[aarch64_rust-quickcheck-devel.sha256sum] = "c208f47c65850dae18bd0276d0466a7c4f36515d834dde1bdd863bc793b3cd78"

RDEPENDS:rust-quickcheck+default-devel = " \
 cargo \
 rust-quickcheck+regex-devel \
 rust-quickcheck+use_logging-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-quickcheck+env_logger-devel = " \
 cargo \
 rust-env_logger0.8-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-quickcheck+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-quickcheck+regex-devel = " \
 cargo \
 rust-env_logger0.8+regex-devel \
 rust-env_logger0.8-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-quickcheck+use_logging-devel = " \
 cargo \
 rust-quickcheck+env_logger-devel \
 rust-quickcheck+log-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-quickcheck-devel = " \
 cargo \
 rust-rand0.8+getrandom-devel \
 rust-rand0.8+small_rng-devel \
 rust-rand0.8-devel \
 "
