# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-util"
PV = "0.2.18"
PR = "1.el10_0"
PACKAGES = " \
 rust-cargo-util+default-devel \
 rust-cargo-util-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-util-0.2.18-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "66b0bbfa42fe8050d92e8267deb90722af1bee87bf44bc9475b29fdbd9c045f3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-util+default-devel-0.2.18-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-util+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cargo-util+default-devel.sha256sum] = "a076994b3a01a6efb53ff8998e6a1f3d38dd02d814aa268ef9d401d66e51538e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-util-devel-0.2.18-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-util-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cargo-util-devel.sha256sum] = "e0190ae6fc4fa2d0563c0a87235bd97059b8a33eb1e579bd063f1008f833069d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-util+default-devel-0.2.18-1.el10_0.noarch.rpm;name=aarch64_rust-cargo-util+default-devel;unpack=0"
SRC_URI[aarch64_rust-cargo-util+default-devel.sha256sum] = "8503faaf1dea54d45ebfbc21fe6225e5d81ff0eb8262d7d6f95ac4eb8a14d89b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-util-devel-0.2.18-1.el10_0.noarch.rpm;name=aarch64_rust-cargo-util-devel;unpack=0"
SRC_URI[aarch64_rust-cargo-util-devel.sha256sum] = "b78ae3c0f5d297d2802317058c467428979ac59e7a5431ab30383fd57548ef95"

RDEPENDS:rust-cargo-util+default-devel = " \
 cargo \
 rust-cargo-util-devel \
 "
RDEPENDS:rust-cargo-util-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-filetime+default-devel \
 rust-hex+default-devel \
 rust-ignore+default-devel \
 rust-jobserver+default-devel \
 rust-libc+default-devel \
 rust-same-file+default-devel \
 rust-sha2+default-devel \
 rust-shell-escape+default-devel \
 rust-tempfile+default-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 rust-walkdir+default-devel \
 "
