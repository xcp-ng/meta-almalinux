# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-features"
PV = "0.40.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-features+cache-efficiency-debug-devel \
 rust-gix-features+crc32-devel \
 rust-gix-features+default-devel \
 rust-gix-features+document-features-devel \
 rust-gix-features+fast-sha1-devel \
 rust-gix-features+fs-read-dir-devel \
 rust-gix-features+fs-walkdir-parallel-devel \
 rust-gix-features+io-pipe-devel \
 rust-gix-features+once_cell-devel \
 rust-gix-features+parallel-devel \
 rust-gix-features+prodash-devel \
 rust-gix-features+progress-devel \
 rust-gix-features+progress-unit-bytes-devel \
 rust-gix-features+progress-unit-human-numbers-devel \
 rust-gix-features+rustsha1-devel \
 rust-gix-features+tracing-detail-devel \
 rust-gix-features+tracing-devel \
 rust-gix-features+walkdir-devel \
 rust-gix-features+zlib-devel \
 rust-gix-features+zlib-ng-devel \
 rust-gix-features+zlib-rust-backend-devel \
 rust-gix-features+zlib-stock-devel \
 rust-gix-features-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-features-0.40.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a74e82d056cf48acc0c6813cd4ea60a42c9a7e10b71617a679f3a852e9ae875"

URI_x86_64_v2_rust-gix-features+cache-efficiency-debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+cache-efficiency-debug-devel-0.40.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+cache-efficiency-debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+cache-efficiency-debug-devel}"
SRC_URI[x86_64_v2_rust-gix-features+cache-efficiency-debug-devel.sha256sum] = "559106b515a75a2c401a714755c908fe874577308106baa20f3ca05ebb57d854"

URI_x86_64_v2_rust-gix-features+crc32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+crc32-devel-0.40.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+crc32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+crc32-devel}"
SRC_URI[x86_64_v2_rust-gix-features+crc32-devel.sha256sum] = "8e76e528b2d824c9c0eb4b1e175431b99b7701e00728af8e3230aac6c6b13674"

URI_x86_64_v2_rust-gix-features+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+default-devel-0.40.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+default-devel}"
SRC_URI[x86_64_v2_rust-gix-features+default-devel.sha256sum] = "2c2a002b96e005a244a505b1d44ff4cbd07283ca311a6f0c59733bc11e5013ef"

URI_x86_64_v2_rust-gix-features+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+document-features-devel-0.40.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-features+document-features-devel.sha256sum] = "954f13419275299c1544d22ef469eb2501956d73b2a968abe68fadb1aca664e6"

URI_x86_64_v2_rust-gix-features+fast-sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+fast-sha1-devel-0.40.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+fast-sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+fast-sha1-devel}"
SRC_URI[x86_64_v2_rust-gix-features+fast-sha1-devel.sha256sum] = "b9d8148a289bd3d1134e6771ee2badd98a777154a25db4721ea2a7bf27170eaa"

URI_x86_64_v2_rust-gix-features+fs-read-dir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+fs-read-dir-devel-0.40.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+fs-read-dir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+fs-read-dir-devel}"
SRC_URI[x86_64_v2_rust-gix-features+fs-read-dir-devel.sha256sum] = "e61370fd221cdba127bfb921712eeea06073e69b95820f94e204c5644d2bb7be"

URI_x86_64_v2_rust-gix-features+fs-walkdir-parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+fs-walkdir-parallel-devel-0.40.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+fs-walkdir-parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+fs-walkdir-parallel-devel}"
SRC_URI[x86_64_v2_rust-gix-features+fs-walkdir-parallel-devel.sha256sum] = "92a5c28c9d63a41c85b371ab81a26a938616dea622b76afcf8361ea7c640059b"

URI_x86_64_v2_rust-gix-features+io-pipe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+io-pipe-devel-0.40.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+io-pipe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+io-pipe-devel}"
SRC_URI[x86_64_v2_rust-gix-features+io-pipe-devel.sha256sum] = "6d60853fd63cb60bacc53101b2a39a66160e2e83c1dfccc33854581a9ced4725"

URI_x86_64_v2_rust-gix-features+once_cell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+once_cell-devel-0.40.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+once_cell-devel}"
SRC_URI[x86_64_v2_rust-gix-features+once_cell-devel.sha256sum] = "ed9b81be6c61374756e86f0a6819bae10a803296935c99b9bda1b9546ae94826"

URI_x86_64_v2_rust-gix-features+parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+parallel-devel-0.40.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+parallel-devel}"
SRC_URI[x86_64_v2_rust-gix-features+parallel-devel.sha256sum] = "aac732f5a680fb565d71976aa266b1b4a5ae3762320b0551b3210ecce237877b"

URI_x86_64_v2_rust-gix-features+prodash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+prodash-devel-0.40.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+prodash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+prodash-devel}"
SRC_URI[x86_64_v2_rust-gix-features+prodash-devel.sha256sum] = "7e5cb1f8e0276ad11149b7a208c0a9f13517deeb76f1e9b523dd5d42c03ecbf0"

URI_x86_64_v2_rust-gix-features+progress-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+progress-devel-0.40.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+progress-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+progress-devel}"
SRC_URI[x86_64_v2_rust-gix-features+progress-devel.sha256sum] = "3df83255cc1c14fce3092a0821bdbdb3099560cad1440986d790a072fcce54f3"

URI_x86_64_v2_rust-gix-features+progress-unit-bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+progress-unit-bytes-devel-0.40.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+progress-unit-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+progress-unit-bytes-devel}"
SRC_URI[x86_64_v2_rust-gix-features+progress-unit-bytes-devel.sha256sum] = "7088826871160874794eaeb6228fb85985b605e0f9b922a26914f20312b7ffce"

URI_x86_64_v2_rust-gix-features+progress-unit-human-numbers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+progress-unit-human-numbers-devel-0.40.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+progress-unit-human-numbers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+progress-unit-human-numbers-devel}"
SRC_URI[x86_64_v2_rust-gix-features+progress-unit-human-numbers-devel.sha256sum] = "eb33a79ba50bba89d0f13672d183f16e08f9ffc0ed0594d2a56b126e244c4689"

URI_x86_64_v2_rust-gix-features+rustsha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+rustsha1-devel-0.40.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+rustsha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+rustsha1-devel}"
SRC_URI[x86_64_v2_rust-gix-features+rustsha1-devel.sha256sum] = "b7f8f0027bfec030c4c765332745ced611843c8d1a99cafff4b23bcdebae1e38"

URI_x86_64_v2_rust-gix-features+tracing-detail-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+tracing-detail-devel-0.40.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+tracing-detail-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+tracing-detail-devel}"
SRC_URI[x86_64_v2_rust-gix-features+tracing-detail-devel.sha256sum] = "2eb455e37a75e3043062ee1a16367a6c90c4fc5a0a6565a3d186a24c7f0ed5e8"

URI_x86_64_v2_rust-gix-features+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+tracing-devel-0.40.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+tracing-devel}"
SRC_URI[x86_64_v2_rust-gix-features+tracing-devel.sha256sum] = "013dc85cc50fd81bc0e463b0b446761bf9debc0045c56124fc3207292f75009e"

URI_x86_64_v2_rust-gix-features+walkdir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+walkdir-devel-0.40.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+walkdir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+walkdir-devel}"
SRC_URI[x86_64_v2_rust-gix-features+walkdir-devel.sha256sum] = "b8c1cd672e76c63a731283438ed3dce83b8f987812f644362627ed6d66b77e4b"

URI_x86_64_v2_rust-gix-features+zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+zlib-devel-0.40.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+zlib-devel}"
SRC_URI[x86_64_v2_rust-gix-features+zlib-devel.sha256sum] = "d8014247a553d76d2d0aabad5c0ba41e45b80d78390e09a14f7005d512e07d6a"

URI_x86_64_v2_rust-gix-features+zlib-ng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+zlib-ng-devel-0.40.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+zlib-ng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+zlib-ng-devel}"
SRC_URI[x86_64_v2_rust-gix-features+zlib-ng-devel.sha256sum] = "fe70945e5621ebbde48a2144bbd6482ddb69f335d560f9d259fc8158f11aae36"

URI_x86_64_v2_rust-gix-features+zlib-rust-backend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+zlib-rust-backend-devel-0.40.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+zlib-rust-backend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+zlib-rust-backend-devel}"
SRC_URI[x86_64_v2_rust-gix-features+zlib-rust-backend-devel.sha256sum] = "b86afbef3f973602879095279f3002f67249c8583562a6c2cad54daf21f40089"

URI_x86_64_v2_rust-gix-features+zlib-stock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+zlib-stock-devel-0.40.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+zlib-stock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+zlib-stock-devel}"
SRC_URI[x86_64_v2_rust-gix-features+zlib-stock-devel.sha256sum] = "e3369fd17e987bd1d2ae3bb9b47b7cbc92a858b0336cb06830e472d1e89c3348"

URI_x86_64_v2_rust-gix-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features-devel-0.40.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features-devel}"
SRC_URI[x86_64_v2_rust-gix-features-devel.sha256sum] = "a83795a8f736d4258549d72c66e67719aa51ecc476f5a1062eb96b27d10991a2"

URI_aarch64_rust-gix-features+cache-efficiency-debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+cache-efficiency-debug-devel-0.40.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-features+cache-efficiency-debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+cache-efficiency-debug-devel}"
SRC_URI[aarch64_rust-gix-features+cache-efficiency-debug-devel.sha256sum] = "1c3799f7a5213f557f7d76be42545597109b016e2f7e1e2a8609ce33a089ef5c"

URI_aarch64_rust-gix-features+crc32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+crc32-devel-0.40.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-features+crc32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+crc32-devel}"
SRC_URI[aarch64_rust-gix-features+crc32-devel.sha256sum] = "ede54443ae14f71045472d6a3b3ee47dd690317d78cd6fb6ac778e4f16433d44"

URI_aarch64_rust-gix-features+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+default-devel-0.40.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-features+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+default-devel}"
SRC_URI[aarch64_rust-gix-features+default-devel.sha256sum] = "e00547e013aa72253e12ed956c9277217be17a40418548262d42dd3ceb20deed"

URI_aarch64_rust-gix-features+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+document-features-devel-0.40.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-features+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+document-features-devel}"
SRC_URI[aarch64_rust-gix-features+document-features-devel.sha256sum] = "16ff57c61f3fafae8a3be15d586ef29ed6d2297a30707c54a37522bd72ef2308"

URI_aarch64_rust-gix-features+fast-sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+fast-sha1-devel-0.40.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-features+fast-sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+fast-sha1-devel}"
SRC_URI[aarch64_rust-gix-features+fast-sha1-devel.sha256sum] = "7f421d114eeb3ff7e3cf620f409cd1d0bf7caab48c5e9ea9500a3856fa898e63"

URI_aarch64_rust-gix-features+fs-read-dir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+fs-read-dir-devel-0.40.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-features+fs-read-dir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+fs-read-dir-devel}"
SRC_URI[aarch64_rust-gix-features+fs-read-dir-devel.sha256sum] = "491fb584f602dcecd5209dbdf9d29855521d94ed89fa2b1f6703e4bd6e684509"

URI_aarch64_rust-gix-features+fs-walkdir-parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+fs-walkdir-parallel-devel-0.40.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-features+fs-walkdir-parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+fs-walkdir-parallel-devel}"
SRC_URI[aarch64_rust-gix-features+fs-walkdir-parallel-devel.sha256sum] = "e65521053616f1ecd544e51c24fe6fc09a436cede00b97315c23f279e7a4acbb"

URI_aarch64_rust-gix-features+io-pipe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+io-pipe-devel-0.40.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-features+io-pipe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+io-pipe-devel}"
SRC_URI[aarch64_rust-gix-features+io-pipe-devel.sha256sum] = "665dda1d2c60ba3699ae6f91f6a82236a7eebba20f7cd0c0e12a7b64dfa4cd35"

URI_aarch64_rust-gix-features+once_cell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+once_cell-devel-0.40.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-features+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+once_cell-devel}"
SRC_URI[aarch64_rust-gix-features+once_cell-devel.sha256sum] = "2c8eca5a67a5b346aea313ad10dbf7ae46bf13f2c845001fb1b397915abbe119"

URI_aarch64_rust-gix-features+parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+parallel-devel-0.40.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-features+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+parallel-devel}"
SRC_URI[aarch64_rust-gix-features+parallel-devel.sha256sum] = "3c690734919bb92d1f9dd944f70757953cbcea04e4ba75061b03457ef693182b"

URI_aarch64_rust-gix-features+prodash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+prodash-devel-0.40.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-features+prodash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+prodash-devel}"
SRC_URI[aarch64_rust-gix-features+prodash-devel.sha256sum] = "adfedf5da1990c4ed34c01df5132866cd334282616463e4cd519fbc25efcb86a"

URI_aarch64_rust-gix-features+progress-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+progress-devel-0.40.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-features+progress-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+progress-devel}"
SRC_URI[aarch64_rust-gix-features+progress-devel.sha256sum] = "bc39a5ea48d8fc66abd3cc4dae97361a2f862e6412e35e11c70c5549f8cb5525"

URI_aarch64_rust-gix-features+progress-unit-bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+progress-unit-bytes-devel-0.40.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-features+progress-unit-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+progress-unit-bytes-devel}"
SRC_URI[aarch64_rust-gix-features+progress-unit-bytes-devel.sha256sum] = "43e76cbf1d68914ed7d1e78af5e6b3d918363088e4cc9ad5bf96b2031f38d387"

URI_aarch64_rust-gix-features+progress-unit-human-numbers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+progress-unit-human-numbers-devel-0.40.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-features+progress-unit-human-numbers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+progress-unit-human-numbers-devel}"
SRC_URI[aarch64_rust-gix-features+progress-unit-human-numbers-devel.sha256sum] = "f1907eebd95aa17c1df73fe3bbc6e76a3f9a4021f89d82b28ea6f5f3c886a1de"

URI_aarch64_rust-gix-features+rustsha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+rustsha1-devel-0.40.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-features+rustsha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+rustsha1-devel}"
SRC_URI[aarch64_rust-gix-features+rustsha1-devel.sha256sum] = "c1c3a497353115827fb00a0acffab0b7e1cf762bc4324a47e9976c543311a274"

URI_aarch64_rust-gix-features+tracing-detail-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+tracing-detail-devel-0.40.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-features+tracing-detail-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+tracing-detail-devel}"
SRC_URI[aarch64_rust-gix-features+tracing-detail-devel.sha256sum] = "6869a4c591283c567b9f57c097eefa6946b283be622579a0fe9dbd1ef664bf99"

URI_aarch64_rust-gix-features+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+tracing-devel-0.40.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-features+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+tracing-devel}"
SRC_URI[aarch64_rust-gix-features+tracing-devel.sha256sum] = "064b2de0214b6e7b786023ab1489bf253b3a505e8ec89cbbc857e1a59e8a5b6f"

URI_aarch64_rust-gix-features+walkdir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+walkdir-devel-0.40.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-features+walkdir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+walkdir-devel}"
SRC_URI[aarch64_rust-gix-features+walkdir-devel.sha256sum] = "3b25a345572dcf39a052cbb2e005b29de9dab66e4573869fef5b541040e1f75c"

URI_aarch64_rust-gix-features+zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+zlib-devel-0.40.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-features+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+zlib-devel}"
SRC_URI[aarch64_rust-gix-features+zlib-devel.sha256sum] = "732e7fd54bf7f290ceef69c68a05f7939a158fb08c2a5c6b43828e0e1d4131d7"

URI_aarch64_rust-gix-features+zlib-ng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+zlib-ng-devel-0.40.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-features+zlib-ng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+zlib-ng-devel}"
SRC_URI[aarch64_rust-gix-features+zlib-ng-devel.sha256sum] = "da4aeb6082f7f4ffe64181714a65940be2576cf5834aba80bc44e25a6f534896"

URI_aarch64_rust-gix-features+zlib-rust-backend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+zlib-rust-backend-devel-0.40.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-features+zlib-rust-backend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+zlib-rust-backend-devel}"
SRC_URI[aarch64_rust-gix-features+zlib-rust-backend-devel.sha256sum] = "8492baff0e9dc3ecad1e1fe2b38b72b2d5595a652c52f8b70f1aaee7734d8a2f"

URI_aarch64_rust-gix-features+zlib-stock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+zlib-stock-devel-0.40.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-features+zlib-stock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+zlib-stock-devel}"
SRC_URI[aarch64_rust-gix-features+zlib-stock-devel.sha256sum] = "a169cd803a38e169097e284e3249d6fb2503be0305b6e6e1524af05d5aa85f44"

URI_aarch64_rust-gix-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features-devel-0.40.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features-devel}"
SRC_URI[aarch64_rust-gix-features-devel.sha256sum] = "96c635d214cc20493095b15fd80303dafa95a4b40af0c4e3068ac25f503293a9"

RDEPENDS:rust-gix-features+cache-efficiency-debug-devel = " \
 cargo \
 rust-gix-features-devel \
 "
RDEPENDS:rust-gix-features+crc32-devel = " \
 cargo \
 rust-crc32fast+default-devel \
 rust-gix-features-devel \
 "
RDEPENDS:rust-gix-features+default-devel = " \
 cargo \
 rust-gix-features-devel \
 "
RDEPENDS:rust-gix-features+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-features-devel \
 "
RDEPENDS:rust-gix-features+fast-sha1-devel = " \
 cargo \
 rust-gix-features-devel \
 rust-sha1+asm-devel \
 rust-sha1+default-devel \
 "
RDEPENDS:rust-gix-features+fs-read-dir-devel = " \
 cargo \
 rust-gix-features-devel \
 rust-gix-utils+default-devel \
 "
RDEPENDS:rust-gix-features+fs-walkdir-parallel-devel = " \
 cargo \
 rust-gix-features-devel \
 rust-gix-utils+default-devel \
 rust-jwalk+default-devel \
 "
RDEPENDS:rust-gix-features+io-pipe-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-gix-features-devel \
 "
RDEPENDS:rust-gix-features+once_cell-devel = " \
 cargo \
 rust-gix-features-devel \
 rust-once_cell+default-devel \
 "
RDEPENDS:rust-gix-features+parallel-devel = " \
 cargo \
 rust-crossbeam-channel+default-devel \
 rust-gix-features-devel \
 rust-parking_lot-devel \
 "
RDEPENDS:rust-gix-features+prodash-devel = " \
 cargo \
 rust-gix-features-devel \
 rust-prodash+default-devel \
 "
RDEPENDS:rust-gix-features+progress-devel = " \
 cargo \
 rust-gix-features+prodash-devel \
 rust-gix-features-devel \
 "
RDEPENDS:rust-gix-features+progress-unit-bytes-devel = " \
 cargo \
 rust-bytesize+default-devel \
 rust-gix-features-devel \
 rust-prodash+default-devel \
 rust-prodash+unit-bytes-devel \
 "
RDEPENDS:rust-gix-features+progress-unit-human-numbers-devel = " \
 cargo \
 rust-gix-features-devel \
 rust-prodash+default-devel \
 rust-prodash+unit-human-devel \
 "
RDEPENDS:rust-gix-features+rustsha1-devel = " \
 cargo \
 rust-gix-features-devel \
 rust-sha1_smol+default-devel \
 "
RDEPENDS:rust-gix-features+tracing-detail-devel = " \
 cargo \
 rust-gix-features-devel \
 rust-gix-trace+tracing-detail-devel \
 "
RDEPENDS:rust-gix-features+tracing-devel = " \
 cargo \
 rust-gix-features-devel \
 rust-gix-trace+tracing-devel \
 "
RDEPENDS:rust-gix-features+walkdir-devel = " \
 cargo \
 rust-gix-features-devel \
 rust-gix-utils+default-devel \
 rust-walkdir+default-devel \
 "
RDEPENDS:rust-gix-features+zlib-devel = " \
 cargo \
 rust-flate2+rust_backend-devel \
 rust-flate2-devel \
 rust-gix-features-devel \
 rust-thiserror+default-devel \
 "
RDEPENDS:rust-gix-features+zlib-ng-devel = " \
 cargo \
 rust-flate2+zlib-ng-devel \
 rust-flate2-devel \
 rust-gix-features+zlib-devel \
 rust-gix-features-devel \
 "
RDEPENDS:rust-gix-features+zlib-rust-backend-devel = " \
 cargo \
 rust-flate2+rust_backend-devel \
 rust-flate2-devel \
 rust-gix-features+zlib-devel \
 rust-gix-features-devel \
 "
RDEPENDS:rust-gix-features+zlib-stock-devel = " \
 cargo \
 rust-flate2+zlib-devel \
 rust-flate2-devel \
 rust-gix-features+zlib-devel \
 rust-gix-features-devel \
 "
RDEPENDS:rust-gix-features-devel = " \
 cargo \
 rust \
 rust-gix-hash+default-devel \
 rust-gix-trace+default-devel \
 rust-libc+default-devel \
 "
