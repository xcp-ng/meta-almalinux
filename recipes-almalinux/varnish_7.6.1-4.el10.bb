# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "varnish"
PV = "7.6.1"
PR = "4.el10"
PACKAGES = " \
 varnish \
 varnish-devel \
 varnish-docs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/varnish-7.6.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a0118e4dcba975ad6755765b263fdc777e62d1a96aa14e225db7d5b282f856c"

URI_x86_64_v2_varnish = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/varnish-7.6.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_varnish;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_varnish}"
SRC_URI[x86_64_v2_varnish.sha256sum] = "c01eb875e903aea440a2e76321cd991878442916e59add53b23daad89336522c"

URI_x86_64_v2_varnish-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/varnish-devel-7.6.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_varnish-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_varnish-devel}"
SRC_URI[x86_64_v2_varnish-devel.sha256sum] = "f6a5766d2f62c32546760e4c204ed9918d576794dab597504350f1f71fa76785"

URI_x86_64_v2_varnish-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/varnish-docs-7.6.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_varnish-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_varnish-docs}"
SRC_URI[x86_64_v2_varnish-docs.sha256sum] = "57c91bef5239702853a413d03125c4b71646a239919e1bdef99da94de1c7cab8"

URI_aarch64_varnish = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/varnish-7.6.1-4.el10.aarch64.rpm;name=aarch64_varnish;unpack=0"
SRC_URI:append = " ${URI_aarch64_varnish}"
SRC_URI[aarch64_varnish.sha256sum] = "dc250f61ae4aad05c52d273201b4ad9bb63a09f5e756fe8c798c997fd71e2c36"

URI_aarch64_varnish-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/varnish-devel-7.6.1-4.el10.aarch64.rpm;name=aarch64_varnish-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_varnish-devel}"
SRC_URI[aarch64_varnish-devel.sha256sum] = "5ef8d575bf0b9c16a8466b739494c01f1dc1518c5a40ad33f85c559b38d3a199"

URI_aarch64_varnish-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/varnish-docs-7.6.1-4.el10.aarch64.rpm;name=aarch64_varnish-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_varnish-docs}"
SRC_URI[aarch64_varnish-docs.sha256sum] = "63c163cb6e3cec4905973908a24b3c1374643ffcb65a08057650927dbe1fd7c9"

RDEPENDS:varnish = " \
 bash \
 gcc \
 glibc \
 libedit \
 libgcc \
 libstdc++ \
 logrotate \
 ncurses \
 ncurses-libs \
 pcre2 \
 redhat-rpm-config \
 shadow-utils \
 systemd \
 util-linux \
 "
RDEPENDS:varnish-devel = " \
 pkgconf-pkg-config \
 python3 \
 varnish \
 "
RDEPENDS:varnish-docs = " \
 "
