# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gtkglext"
PV = "1.2.0"
PR = "50.el10_1"
PACKAGES = " \
 gtkglext-devel \
 gtkglext-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gtkglext-1.2.0-50.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "75914e381d65791c5de8df25fdde94bcaa7b426d938cb058f27edf800261efbc"

URI_x86_64_v2_gtkglext-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gtkglext-devel-1.2.0-50.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gtkglext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtkglext-devel}"
SRC_URI[x86_64_v2_gtkglext-devel.sha256sum] = "e2086fa3d485c05b16b8addfbe6a08c91b786aa43ab166fb34c5213e3171e9d3"

URI_x86_64_v2_gtkglext-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gtkglext-libs-1.2.0-50.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gtkglext-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtkglext-libs}"
SRC_URI[x86_64_v2_gtkglext-libs.sha256sum] = "acd30ba5d97bed3ab16d3dd1e7d3434236bccb522293a4ef63bcbf9a35c51cc6"

URI_aarch64_gtkglext-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gtkglext-devel-1.2.0-50.el10_1.aarch64.rpm;name=aarch64_gtkglext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtkglext-devel}"
SRC_URI[aarch64_gtkglext-devel.sha256sum] = "9010ba4de5c6bcac1fa73ad84e51ab29184ad460d20582c8891a0310eb26cc0a"

URI_aarch64_gtkglext-libs = "${EPEL_MIRROR}/aarch64/Packages/g/gtkglext-libs-1.2.0-50.el10_1.aarch64.rpm;name=aarch64_gtkglext-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtkglext-libs}"
SRC_URI[aarch64_gtkglext-libs.sha256sum] = "914bfd5b82bf2f816431963ee40b327082e48c541b445b1dc8e56790e89fa1f0"

RDEPENDS:gtkglext-devel = " \
 glib2-devel \
 gtk2-devel \
 gtkglext-devel \
 gtkglext-libs \
 libXmu-devel \
 mesa-libGL-devel \
 mesa-libGLU-devel \
 pango-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:gtkglext-libs = " \
 atk \
 cairo \
 fontconfig \
 freetype \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk2 \
 harfbuzz \
 libICE \
 libSM \
 libXmu \
 libXt \
 libglvnd-glx \
 mesa-libGLU \
 pango \
 "
