# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "massif-visualizer"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 massif-visualizer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/massif-visualizer-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a707730d6bdff0bf3c1f2a4255edfac9f19f0912f942034b203ce8d9b2d92da"

URI_x86_64_v2_massif-visualizer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/massif-visualizer-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_massif-visualizer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_massif-visualizer}"
SRC_URI[x86_64_v2_massif-visualizer.sha256sum] = "43d7936890db54e734b1ed317837bd22e7996e292c0be13baae9df5a21c74fdc"

URI_aarch64_massif-visualizer = "${EPEL_MIRROR}/aarch64/Packages/m/massif-visualizer-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_massif-visualizer;unpack=0"
SRC_URI:append = " ${URI_aarch64_massif-visualizer}"
SRC_URI[aarch64_massif-visualizer.sha256sum] = "158b4bb1e4e9282606fa4a968264181750328369ac3447f3e772d743460e31ed"

RDEPENDS:massif-visualizer = " \
 glibc \
 kdiagram \
 kf6-filesystem \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
