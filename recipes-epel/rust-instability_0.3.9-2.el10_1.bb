# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-instability"
PV = "0.3.9"
PR = "2.el10_1"
PACKAGES = " \
 rust-instability+default-devel \
 rust-instability-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-instability-0.3.9-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69d90e2d87b7bbd02382059b1699a46af1051ec3fec528c88ebbbf7c41d16e13"

URI_x86_64_v2_rust-instability+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-instability+default-devel-0.3.9-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-instability+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-instability+default-devel}"
SRC_URI[x86_64_v2_rust-instability+default-devel.sha256sum] = "f42ad3054e0119fd4509fafa19a7d32777d33398229636cce8af525c363ac9b5"

URI_x86_64_v2_rust-instability-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-instability-devel-0.3.9-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-instability-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-instability-devel}"
SRC_URI[x86_64_v2_rust-instability-devel.sha256sum] = "fd9a162e6640621b79e5a5182fb207bece80710456e1e9bc01a321ed0d38eb4c"

URI_aarch64_rust-instability+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-instability+default-devel-0.3.9-2.el10_1.noarch.rpm;name=aarch64_rust-instability+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-instability+default-devel}"
SRC_URI[aarch64_rust-instability+default-devel.sha256sum] = "c2d74f48882583e2cfea6ae02ee2e0726cc6a5c2602a726e3e4cd91f16fb0d42"

URI_aarch64_rust-instability-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-instability-devel-0.3.9-2.el10_1.noarch.rpm;name=aarch64_rust-instability-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-instability-devel}"
SRC_URI[aarch64_rust-instability-devel.sha256sum] = "50faec31ef4b777d41b6c677e76ad382bcb572c07ca39d024d34b891b0318d48"

RDEPENDS:rust-instability+default-devel = " \
 cargo \
 rust-instability-devel \
 "
RDEPENDS:rust-instability-devel = " \
 cargo \
 rust \
 rust-darling+default-devel \
 rust-indoc+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+derive-devel \
 rust-syn+full-devel \
 "
