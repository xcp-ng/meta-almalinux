# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkdcraw"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 libkdcraw \
 libkdcraw-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkdcraw-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1452bfcdfc73b6defde1d5376c6503b36f6a845380e527f88cf44a7278ecf912"

URI_x86_64_v2_libkdcraw = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdcraw-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkdcraw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkdcraw}"
SRC_URI[x86_64_v2_libkdcraw.sha256sum] = "83567471cca91b7358e8a5c2acc3755290ca4c71e7906dbd2452fd1c5a70ea12"

URI_x86_64_v2_libkdcraw-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdcraw-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkdcraw-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkdcraw-devel}"
SRC_URI[x86_64_v2_libkdcraw-devel.sha256sum] = "0d16b6611bdda585a7b4ef9a114c460c31b03b6a211f293fd141cce4039a860f"

URI_aarch64_libkdcraw = "${EPEL_MIRROR}/aarch64/Packages/l/libkdcraw-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_libkdcraw;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkdcraw}"
SRC_URI[aarch64_libkdcraw.sha256sum] = "a0171dd941ef8e442e8a2541ebd3e05b459e5ff3a5983bf31875149d0b5f325c"

URI_aarch64_libkdcraw-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkdcraw-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_libkdcraw-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkdcraw-devel}"
SRC_URI[aarch64_libkdcraw-devel.sha256sum] = "4eb18737f07c2c78b95eb86b0b855755aacc8c92b3e7eedd630ce4557f561119"

RDEPENDS:libkdcraw = " \
 LibRaw \
 glibc \
 kf6-filesystem \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkdcraw-devel = " \
 cmake-filesystem \
 libkdcraw \
 qt6-qtbase-devel \
 "
