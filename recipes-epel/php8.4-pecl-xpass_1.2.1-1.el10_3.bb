# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php8.4-pecl-xpass"
PV = "1.2.1"
PR = "1.el10_3"
PACKAGES = " \
 php8.4-pecl-xpass \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php8.4-pecl-xpass-1.2.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63c0638851504660f6f95948870b7b1405c8a985390f098f57c14225ca126979"

URI_x86_64_v2_php8.4-pecl-xpass = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php8.4-pecl-xpass-1.2.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php8.4-pecl-xpass;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-pecl-xpass}"
SRC_URI[x86_64_v2_php8.4-pecl-xpass.sha256sum] = "9d8ccdafd5b0634239426848cc738bc0de552b6e28e23aeceac29113be57136f"

URI_aarch64_php8.4-pecl-xpass = "${EPEL_MIRROR}/aarch64/Packages/p/php8.4-pecl-xpass-1.2.1-1.el10_3.aarch64.rpm;name=aarch64_php8.4-pecl-xpass;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-pecl-xpass}"
SRC_URI[aarch64_php8.4-pecl-xpass.sha256sum] = "93f933abec70a9befb79bb48b8d28ad4cb338cb833d4d707970ee57611535c9e"

RDEPENDS:php8.4-pecl-xpass = " \
 glibc \
 libxcrypt \
 php8.4-common \
 "
