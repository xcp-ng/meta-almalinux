# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mod_authnz_external"
PV = "3.3.3"
PR = "11.el10_0"
PACKAGES = " \
 mod_authnz_external \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mod_authnz_external-3.3.3-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "189d321041957bf62c3b9b8c442efe110e016fe02466a5c56d99144cbd627f64"

URI_x86_64_v2_mod_authnz_external = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mod_authnz_external-3.3.3-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mod_authnz_external;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_authnz_external}"
SRC_URI[x86_64_v2_mod_authnz_external.sha256sum] = "1e4183117fe488afdc32edf726bb71747881ff4e152edfec920f11e27729f02e"

URI_aarch64_mod_authnz_external = "${EPEL_MIRROR}/aarch64/Packages/m/mod_authnz_external-3.3.3-11.el10_0.aarch64.rpm;name=aarch64_mod_authnz_external;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_authnz_external}"
SRC_URI[aarch64_mod_authnz_external.sha256sum] = "63bcef07f0055904c3ff8fe39b4bfd8c995207ada450daccbbbaa3fe7905f37e"

RDEPENDS:mod_authnz_external = " \
 glibc \
 httpd-core \
 pwauth \
 "
