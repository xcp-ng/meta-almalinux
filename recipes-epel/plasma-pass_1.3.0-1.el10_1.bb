# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-pass"
PV = "1.3.0"
PR = "1.el10_1"
PACKAGES = " \
 plasma-pass \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-pass-1.3.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f4120580628d38a9628516cbb64ac82652a013da4cefc39ccf7ab8dc4558794b"

URI_x86_64_v2_plasma-pass = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-pass-1.3.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-pass;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-pass}"
SRC_URI[x86_64_v2_plasma-pass.sha256sum] = "0b201cb9ed70ad30d00441fce96598e23f70f1836a7f820e7ca95a3f5afe4a99"

URI_aarch64_plasma-pass = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-pass-1.3.0-1.el10_1.aarch64.rpm;name=aarch64_plasma-pass;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-pass}"
SRC_URI[aarch64_plasma-pass.sha256sum] = "3e593234a745a3e8756139b726baf8b94c8d05dc6b28e07108e5b339f505ab9d"

RDEPENDS:plasma-pass = " \
 glibc \
 gnupg2 \
 gpgmepp \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kitemmodels \
 liboath \
 libstdc++ \
 plasma-desktop \
 plasma5support \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
