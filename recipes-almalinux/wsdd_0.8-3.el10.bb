# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wsdd"
PV = "0.8"
PR = "3.el10"
PACKAGES = " \
 wsdd \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/wsdd-0.8-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "801b515a84eafcbb477d367a2c6c1428560c2841c9c9baa62a7fe608cc12458b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/wsdd-0.8-3.el10.noarch.rpm;name=x86_64_v2_wsdd;unpack=0"
SRC_URI[x86_64_v2_wsdd.sha256sum] = "4fb2bb72fd4dce963d1e959f24a7d7cf2646ee67eacd8b99c65d4afc9d58f343"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/wsdd-0.8-3.el10.noarch.rpm;name=aarch64_wsdd;unpack=0"
SRC_URI[aarch64_wsdd.sha256sum] = "4fb2bb72fd4dce963d1e959f24a7d7cf2646ee67eacd8b99c65d4afc9d58f343"

RDEPENDS:wsdd = " \
 bash \
 python3 \
 shadow-utils \
 "
