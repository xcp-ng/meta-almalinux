# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-inotify"
PV = "0.9.6"
PR = "36.el10"
PACKAGES = " \
 python3-inotify \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python-inotify-0.9.6-36.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2c5a47cc2af10a2c8f8fd5051768de7fa8d04688a66fcba364953758c60b3e4a"

URI_x86_64_v2_python3-inotify = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-inotify-0.9.6-36.el10.noarch.rpm;name=x86_64_v2_python3-inotify;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-inotify}"
SRC_URI[x86_64_v2_python3-inotify.sha256sum] = "28b73262fc82f92ec01e96ae0cc6266423d1510df0399b496ec2debb1c4df557"

URI_aarch64_python3-inotify = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-inotify-0.9.6-36.el10.noarch.rpm;name=aarch64_python3-inotify;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-inotify}"
SRC_URI[aarch64_python3-inotify.sha256sum] = "28b73262fc82f92ec01e96ae0cc6266423d1510df0399b496ec2debb1c4df557"

RDEPENDS:python3-inotify = " \
 python3 \
 "
