# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerofrom-derive"
PV = "0.1.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-zerofrom-derive+default-devel \
 rust-zerofrom-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zerofrom-derive-0.1.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "32a8d9774fd89bff92de9ccabf6a3b0158bfbfd8f893cc0bf3abf3c91d57a499"

URI_x86_64_v2_rust-zerofrom-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerofrom-derive+default-devel-0.1.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerofrom-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerofrom-derive+default-devel}"
SRC_URI[x86_64_v2_rust-zerofrom-derive+default-devel.sha256sum] = "840580a8a1317dead15cafc509c1c1a7683a8d4d24f4d9798d9dec762f3c69b5"

URI_x86_64_v2_rust-zerofrom-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerofrom-derive-devel-0.1.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerofrom-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerofrom-derive-devel}"
SRC_URI[x86_64_v2_rust-zerofrom-derive-devel.sha256sum] = "2b2ad0ebc49f2acba2fa86455b635a8c13d5531ffc23036778aa8bd0c1d9c313"

URI_aarch64_rust-zerofrom-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerofrom-derive+default-devel-0.1.6-1.el10_0.noarch.rpm;name=aarch64_rust-zerofrom-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerofrom-derive+default-devel}"
SRC_URI[aarch64_rust-zerofrom-derive+default-devel.sha256sum] = "7c5abd05b92b43fff9b8f45118dbe22807962053687ac6f9a379380f1bc1fa99"

URI_aarch64_rust-zerofrom-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerofrom-derive-devel-0.1.6-1.el10_0.noarch.rpm;name=aarch64_rust-zerofrom-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerofrom-derive-devel}"
SRC_URI[aarch64_rust-zerofrom-derive-devel.sha256sum] = "883ba41eeca378400bd859c76710b4a35298358a258105766b503c1e719d0a26"

RDEPENDS:rust-zerofrom-derive+default-devel = " \
 cargo \
 rust-zerofrom-derive-devel \
 "
RDEPENDS:rust-zerofrom-derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+fold-devel \
 rust-synstructure+default-devel \
 "
