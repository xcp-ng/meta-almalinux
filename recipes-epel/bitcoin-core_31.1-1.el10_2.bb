# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bitcoin-core"
PV = "31.1"
PR = "1.el10_2"
PACKAGES = " \
 bitcoin-core \
 bitcoin-core-desktop \
 bitcoin-core-server \
 bitcoin-core-utils \
 libbitcoinkernel \
 libbitcoinkernel-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bitcoin-core-31.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "17e7abbdb740bc9bbd275c560e1d7c0668a735eac438ae9b3d36c30a118afcc5"

URI_x86_64_v2_bitcoin-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bitcoin-core-31.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bitcoin-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bitcoin-core}"
SRC_URI[x86_64_v2_bitcoin-core.sha256sum] = "aa66212cdb1997448c55332658878047ad623efaa8735d454991b8cbfc23ccbc"

URI_x86_64_v2_bitcoin-core-desktop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bitcoin-core-desktop-31.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bitcoin-core-desktop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bitcoin-core-desktop}"
SRC_URI[x86_64_v2_bitcoin-core-desktop.sha256sum] = "ffd53ac9f9e6bb6002806074e56e7906b438e1ede409d8ded16afdb7d7487ed0"

URI_x86_64_v2_bitcoin-core-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bitcoin-core-server-31.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bitcoin-core-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bitcoin-core-server}"
SRC_URI[x86_64_v2_bitcoin-core-server.sha256sum] = "a4462967b58008439360694acda296e12b5d1a08b3c86eda27cef9d533598593"

URI_x86_64_v2_bitcoin-core-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bitcoin-core-utils-31.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bitcoin-core-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bitcoin-core-utils}"
SRC_URI[x86_64_v2_bitcoin-core-utils.sha256sum] = "be7b0afe47237316fa4d14a6ccfaa4776012e850508e57c62585f05fcb82ef02"

URI_x86_64_v2_libbitcoinkernel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbitcoinkernel-31.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libbitcoinkernel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbitcoinkernel}"
SRC_URI[x86_64_v2_libbitcoinkernel.sha256sum] = "2c9a6a25081d686bf725d9790835591504a2be70f11d0cbe0ebf172f96805f2d"

URI_x86_64_v2_libbitcoinkernel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbitcoinkernel-devel-31.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libbitcoinkernel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbitcoinkernel-devel}"
SRC_URI[x86_64_v2_libbitcoinkernel-devel.sha256sum] = "de782f631dd84cfc93d59555679fe1b6ee48fc6e53982a87c02ce68028b6f94c"

URI_aarch64_bitcoin-core = "${EPEL_MIRROR}/aarch64/Packages/b/bitcoin-core-31.1-1.el10_2.aarch64.rpm;name=aarch64_bitcoin-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_bitcoin-core}"
SRC_URI[aarch64_bitcoin-core.sha256sum] = "ea8e4705bf6ad3c10da16a572fa0cd0aabd924e58c60f53d7cca539589f7b4bb"

URI_aarch64_bitcoin-core-desktop = "${EPEL_MIRROR}/aarch64/Packages/b/bitcoin-core-desktop-31.1-1.el10_2.aarch64.rpm;name=aarch64_bitcoin-core-desktop;unpack=0"
SRC_URI:append = " ${URI_aarch64_bitcoin-core-desktop}"
SRC_URI[aarch64_bitcoin-core-desktop.sha256sum] = "f7375bf72b01e109b4ea32dbb0797b3e64f623790d362549d71a965a1cf32f7c"

URI_aarch64_bitcoin-core-server = "${EPEL_MIRROR}/aarch64/Packages/b/bitcoin-core-server-31.1-1.el10_2.aarch64.rpm;name=aarch64_bitcoin-core-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_bitcoin-core-server}"
SRC_URI[aarch64_bitcoin-core-server.sha256sum] = "0e6b0278a6719ccb91867a5d2ac95a87ec1298d91acccb06791b5500a5d30d12"

URI_aarch64_bitcoin-core-utils = "${EPEL_MIRROR}/aarch64/Packages/b/bitcoin-core-utils-31.1-1.el10_2.aarch64.rpm;name=aarch64_bitcoin-core-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_bitcoin-core-utils}"
SRC_URI[aarch64_bitcoin-core-utils.sha256sum] = "14d43b9f5593d551b0a70fb7fcc8f7ad27f06cc71d2476248c7797dd532ad336"

URI_aarch64_libbitcoinkernel = "${EPEL_MIRROR}/aarch64/Packages/l/libbitcoinkernel-31.1-1.el10_2.aarch64.rpm;name=aarch64_libbitcoinkernel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbitcoinkernel}"
SRC_URI[aarch64_libbitcoinkernel.sha256sum] = "21126b5ef9c9c63cf18ca34f598276a5251b0cf4fec57dfab7544b125d2fdfb2"

URI_aarch64_libbitcoinkernel-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libbitcoinkernel-devel-31.1-1.el10_2.aarch64.rpm;name=aarch64_libbitcoinkernel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbitcoinkernel-devel}"
SRC_URI[aarch64_libbitcoinkernel-devel.sha256sum] = "fa50f79c2e2bb5e742c52e338249a46f6237d4b1d274f28937e0a27871d4ee2d"

RDEPENDS:bitcoin-core = " \
 bash \
 bitcoin-core-desktop \
 bitcoin-core-server \
 bitcoin-core-utils \
 capnproto-libs \
 glibc \
 libbitcoinkernel \
 libevent \
 libgcc \
 libstdc++ \
 qrencode-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 sqlite-libs \
 zeromq \
 "
RDEPENDS:bitcoin-core-desktop = " \
 glibc \
 libevent \
 libgcc \
 libstdc++ \
 qrencode-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 sqlite-libs \
 zeromq \
 "
RDEPENDS:bitcoin-core-server = " \
 bash \
 bitcoin-core-selinux \
 glibc \
 libevent \
 libgcc \
 libstdc++ \
 shadow-utils \
 sqlite-libs \
 zeromq \
 "
RDEPENDS:bitcoin-core-utils = " \
 glibc \
 libevent \
 libgcc \
 libstdc++ \
 sqlite-libs \
 "
RDEPENDS:libbitcoinkernel = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libbitcoinkernel-devel = " \
 glibc \
 libbitcoinkernel \
 libgcc \
 libstdc++ \
 pkgconf-pkg-config \
 "
