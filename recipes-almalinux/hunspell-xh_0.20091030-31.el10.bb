# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-xh"
PV = "0.20091030"
PR = "31.el10"
PACKAGES = " \
 hunspell-xh \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-xh-0.20091030-31.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "816881035013149721d825b923ecd2eefb6ec28c171cf20f62c44fce084dfe43"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-xh-0.20091030-31.el10.noarch.rpm;name=x86_64_v2_hunspell-xh;unpack=0"
SRC_URI[x86_64_v2_hunspell-xh.sha256sum] = "4586706e7775bd5175265a5340296929e71d7b60b4fae3af144738fed44e5f7b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-xh-0.20091030-31.el10.noarch.rpm;name=aarch64_hunspell-xh;unpack=0"
SRC_URI[aarch64_hunspell-xh.sha256sum] = "4586706e7775bd5175265a5340296929e71d7b60b4fae3af144738fed44e5f7b"

RDEPENDS:hunspell-xh = " \
 hunspell-filesystem \
 "
