# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-swiftclient"
PV = "4.10.0"
PR = "1.el10_3"
PACKAGES = " \
 python-swiftclient-doc \
 python3-swiftclient \
 python3-swiftclient+keystone \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-swiftclient-4.10.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ac029b684cbbdfdcdaf23adc64fd93556e601bf3d0c74bdc4c2784f3785ba29"

URI_x86_64_v2_python-swiftclient-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-swiftclient-doc-4.10.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-swiftclient-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-swiftclient-doc}"
SRC_URI[x86_64_v2_python-swiftclient-doc.sha256sum] = "b4c97a87a1af42e1494c8b433e8b326e69e74a7099f682a3e8124809cf70ea88"

URI_x86_64_v2_python3-swiftclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-swiftclient-4.10.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-swiftclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-swiftclient}"
SRC_URI[x86_64_v2_python3-swiftclient.sha256sum] = "966f290aa8508bad1b8d4bb856d79f61082621209f4aea0909891a290e4ca63e"

URI_x86_64_v2_python3-swiftclient+keystone = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-swiftclient+keystone-4.10.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-swiftclient+keystone;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-swiftclient+keystone}"
SRC_URI[x86_64_v2_python3-swiftclient+keystone.sha256sum] = "e1bdf22b3c28f1865a4fc04d7c7a34e746c8fd579eadd5c62f89b8cbd237b183"

URI_aarch64_python-swiftclient-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-swiftclient-doc-4.10.0-1.el10_3.noarch.rpm;name=aarch64_python-swiftclient-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-swiftclient-doc}"
SRC_URI[aarch64_python-swiftclient-doc.sha256sum] = "0407618ba07136e2759883abc59164231feb143717b918db2adc08d2ba3afb4c"

URI_aarch64_python3-swiftclient = "${EPEL_MIRROR}/aarch64/Packages/p/python3-swiftclient-4.10.0-1.el10_3.noarch.rpm;name=aarch64_python3-swiftclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-swiftclient}"
SRC_URI[aarch64_python3-swiftclient.sha256sum] = "f9a4b85c3bd7070997eef265374f1aaa4cc0ed3ed45ef1ecfe939d10d04ac647"

URI_aarch64_python3-swiftclient+keystone = "${EPEL_MIRROR}/aarch64/Packages/p/python3-swiftclient+keystone-4.10.0-1.el10_3.noarch.rpm;name=aarch64_python3-swiftclient+keystone;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-swiftclient+keystone}"
SRC_URI[aarch64_python3-swiftclient+keystone.sha256sum] = "e9086f048790d8a8bd7bdf1e3863097417edecd0efc6b84111b7c819a5b9422f"

RDEPENDS:python-swiftclient-doc = " \
 "
RDEPENDS:python3-swiftclient = " \
 python3 \
 python3-requests \
 python3-swiftclient+keystone \
 "
RDEPENDS:python3-swiftclient+keystone = " \
 python3 \
 python3-keystoneclient \
 python3-swiftclient \
 "
