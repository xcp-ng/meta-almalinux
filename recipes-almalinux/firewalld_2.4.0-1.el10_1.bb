# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "firewalld"
PV = "2.4.0"
PR = "1.el10_1"
PACKAGES = " \
 firewall-applet \
 firewall-config \
 firewalld \
 firewalld-filesystem \
 python3-firewall \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/firewalld-2.4.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "60a834a431ea5ab16600819f9682dfbecf31d321bbcf84fd09348d8ba493bbad"

URI_x86_64_v2_firewall-applet = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/firewall-applet-2.4.0-1.el10_1.noarch.rpm;name=x86_64_v2_firewall-applet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_firewall-applet}"
SRC_URI[x86_64_v2_firewall-applet.sha256sum] = "fd7bfddfc9b9b5bac3877d3557c39cdfe5ad74bdf81664fcab547b986507dc89"

URI_x86_64_v2_firewall-config = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/firewall-config-2.4.0-1.el10_1.noarch.rpm;name=x86_64_v2_firewall-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_firewall-config}"
SRC_URI[x86_64_v2_firewall-config.sha256sum] = "8d4ef6ebf0049e606d2b6a7e438ef71737b9a21956afdafeaca7f4c4b203d1cd"

URI_x86_64_v2_firewalld = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/firewalld-2.4.0-1.el10_1.noarch.rpm;name=x86_64_v2_firewalld;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_firewalld}"
SRC_URI[x86_64_v2_firewalld.sha256sum] = "83cd5b78383e4a61f2923409cbff4390dd24424f1ea82bb2173f97658f2843fd"

URI_x86_64_v2_firewalld-filesystem = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/firewalld-filesystem-2.4.0-1.el10_1.noarch.rpm;name=x86_64_v2_firewalld-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_firewalld-filesystem}"
SRC_URI[x86_64_v2_firewalld-filesystem.sha256sum] = "d24aaf5395b5eb278f09df7ee57d064772ffcc1c1950f5b97b9f2118f73f3154"

URI_x86_64_v2_python3-firewall = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-firewall-2.4.0-1.el10_1.noarch.rpm;name=x86_64_v2_python3-firewall;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-firewall}"
SRC_URI[x86_64_v2_python3-firewall.sha256sum] = "44edaf36281fd1c919e07e5640e3dc344f11fe96272f99303261479f7cbc966b"

URI_aarch64_firewall-applet = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/firewall-applet-2.4.0-1.el10_1.noarch.rpm;name=aarch64_firewall-applet;unpack=0"
SRC_URI:append = " ${URI_aarch64_firewall-applet}"
SRC_URI[aarch64_firewall-applet.sha256sum] = "fd7bfddfc9b9b5bac3877d3557c39cdfe5ad74bdf81664fcab547b986507dc89"

URI_aarch64_firewall-config = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/firewall-config-2.4.0-1.el10_1.noarch.rpm;name=aarch64_firewall-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_firewall-config}"
SRC_URI[aarch64_firewall-config.sha256sum] = "8d4ef6ebf0049e606d2b6a7e438ef71737b9a21956afdafeaca7f4c4b203d1cd"

URI_aarch64_firewalld = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/firewalld-2.4.0-1.el10_1.noarch.rpm;name=aarch64_firewalld;unpack=0"
SRC_URI:append = " ${URI_aarch64_firewalld}"
SRC_URI[aarch64_firewalld.sha256sum] = "83cd5b78383e4a61f2923409cbff4390dd24424f1ea82bb2173f97658f2843fd"

URI_aarch64_firewalld-filesystem = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/firewalld-filesystem-2.4.0-1.el10_1.noarch.rpm;name=aarch64_firewalld-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_firewalld-filesystem}"
SRC_URI[aarch64_firewalld-filesystem.sha256sum] = "d24aaf5395b5eb278f09df7ee57d064772ffcc1c1950f5b97b9f2118f73f3154"

URI_aarch64_python3-firewall = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-firewall-2.4.0-1.el10_1.noarch.rpm;name=aarch64_python3-firewall;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-firewall}"
SRC_URI[aarch64_python3-firewall.sha256sum] = "44edaf36281fd1c919e07e5640e3dc344f11fe96272f99303261479f7cbc966b"

RDEPENDS:firewall-applet = " \
 NetworkManager-libnm \
 dbus-x11 \
 firewall-config \
 firewalld \
 hicolor-icon-theme \
 libnotify \
 python3 \
 python3-firewall \
 python3-gobject \
 python3-pyqt6-base \
 "
RDEPENDS:firewall-config = " \
 NetworkManager-libnm \
 dbus-x11 \
 firewalld \
 gtk3 \
 hicolor-icon-theme \
 python3 \
 python3-firewall \
 python3-gobject \
 "
RDEPENDS:firewalld = " \
 bash \
 firewalld-filesystem \
 python3 \
 python3-firewall \
 systemd \
 "
RDEPENDS:firewalld-filesystem = " \
 "
RDEPENDS:python3-firewall = " \
 python3 \
 python3-dbus \
 python3-gobject-base \
 python3-nftables \
 "
