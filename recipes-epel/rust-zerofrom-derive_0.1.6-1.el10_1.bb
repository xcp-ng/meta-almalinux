# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerofrom-derive"
PV = "0.1.6"
PR = "1.el10_1"
PACKAGES = " \
 rust-zerofrom-derive+default-devel \
 rust-zerofrom-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zerofrom-derive-0.1.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "798eededccda773f5ddd0236cef31699d5308bb9f1820c4e3cf1c4735375d3e8"

URI_x86_64_v2_rust-zerofrom-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerofrom-derive+default-devel-0.1.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerofrom-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerofrom-derive+default-devel}"
SRC_URI[x86_64_v2_rust-zerofrom-derive+default-devel.sha256sum] = "8a3c8b2f08504ebb387c0cc89ac4a4e2c18fcd277b3e67dab65bf4332d70a838"

URI_x86_64_v2_rust-zerofrom-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerofrom-derive-devel-0.1.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerofrom-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerofrom-derive-devel}"
SRC_URI[x86_64_v2_rust-zerofrom-derive-devel.sha256sum] = "ece45e9296ebfee60f9be238f6be4b1e3a6a065e36b9f274f807c6167c4a4fa0"

URI_aarch64_rust-zerofrom-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerofrom-derive+default-devel-0.1.6-1.el10_1.noarch.rpm;name=aarch64_rust-zerofrom-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerofrom-derive+default-devel}"
SRC_URI[aarch64_rust-zerofrom-derive+default-devel.sha256sum] = "8c964ee27fcf44f6889aac4796976f7a375d0e2faf831b96dd435bddbb14c491"

URI_aarch64_rust-zerofrom-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerofrom-derive-devel-0.1.6-1.el10_1.noarch.rpm;name=aarch64_rust-zerofrom-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerofrom-derive-devel}"
SRC_URI[aarch64_rust-zerofrom-derive-devel.sha256sum] = "d4a885dfdd0ba2233e92474eccb5961ecd2457e54ad7db9107de8fdc14029986"

RDEPENDS:rust-zerofrom-derive+default-devel = " \
 cargo \
 rust-zerofrom-derive-devel \
 "
RDEPENDS:rust-zerofrom-derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+fold-devel \
 rust-synstructure+default-devel \
 "
