# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Image-ExifTool"
PV = "13.10"
PR = "1.el10_0"
PACKAGES = " \
 perl-Image-ExifTool \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Image-ExifTool-13.10-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "05e2ae8f2573610feeeb5d26b7a177eee589b4a52594b95cbf59d0f04f2f1704"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Image-ExifTool-13.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Image-ExifTool;unpack=0"
SRC_URI[x86_64_v2_perl-Image-ExifTool.sha256sum] = "06485a28469d5b7c6830ee58dadbb3169cb7e2725b817fac1f8b8f662e84852c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Image-ExifTool-13.10-1.el10_0.noarch.rpm;name=aarch64_perl-Image-ExifTool;unpack=0"
SRC_URI[aarch64_perl-Image-ExifTool.sha256sum] = "f6dbc45906ee8e7eb39d0883a67d510744ac2c699c3df27d5726d3735ae5575d"

RDEPENDS:perl-Image-ExifTool = " \
 perl-Exporter \
 perl-FileHandle \
 perl-Image-ExifTool \
 perl-interpreter \
 perl-libs \
 perl-overload \
 perl-vars \
 "
