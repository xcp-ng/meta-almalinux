# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-azure-common"
PE = "1"
PV = "1.1.28"
PR = "15.el10_2"
PACKAGES = " \
 python3-azure-common \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-azure-common-1.1.28-15.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9b871689e0bdbf35e7f59e65507d6beedf50a5d148340700665a59f012cc7a3"

URI_x86_64_v2_python3-azure-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-azure-common-1.1.28-15.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-azure-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-azure-common}"
SRC_URI[x86_64_v2_python3-azure-common.sha256sum] = "e909dac124f64eaf2567a7ddb3e2c736f465db4c80c2c9a67c5a4fa9b1964e40"

URI_aarch64_python3-azure-common = "${EPEL_MIRROR}/aarch64/Packages/p/python3-azure-common-1.1.28-15.el10_2.noarch.rpm;name=aarch64_python3-azure-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-azure-common}"
SRC_URI[aarch64_python3-azure-common.sha256sum] = "2603a6bc47ecbfde78bf3f4447e30eda8673fda5308fc25d010941de0684bd12"

RDEPENDS:python3-azure-common = " \
 python3 \
 "
