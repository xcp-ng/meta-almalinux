# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-heapless0.7"
PV = "0.7.17"
PR = "2.el10_0"
PACKAGES = " \
 rust-heapless0.7+cas-devel \
 rust-heapless0.7+default-devel \
 rust-heapless0.7+mpmc_large-devel \
 rust-heapless0.7+serde-devel \
 rust-heapless0.7+ufmt-impl-devel \
 rust-heapless0.7+ufmt-write-devel \
 rust-heapless0.7+x86-sync-pool-devel \
 rust-heapless0.7-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-heapless0.7-0.7.17-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c8e016d018a6b063d496c6aca8e34fcc4a040d05a86c25a3e990ba77e16ddd4d"

URI_x86_64_v2_rust-heapless0.7+cas-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapless0.7+cas-devel-0.7.17-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapless0.7+cas-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapless0.7+cas-devel}"
SRC_URI[x86_64_v2_rust-heapless0.7+cas-devel.sha256sum] = "9a7a68150b3711cb64184f1090209e61c1da0a8e1d8067a45b48e67106c2d66f"

URI_x86_64_v2_rust-heapless0.7+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapless0.7+default-devel-0.7.17-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapless0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapless0.7+default-devel}"
SRC_URI[x86_64_v2_rust-heapless0.7+default-devel.sha256sum] = "3d620dea2c8f0bd19b79bf2a21692d028b4f070001a91e2a6cc77b313bbb5944"
RPROVIDES:rust-heapless0.7+default-devel:append:x86_64_v2 = " virtual/crate_heapless/default__ge_0.0.0_with_crate_heapless/default__lt_1.0.0~"

URI_x86_64_v2_rust-heapless0.7+mpmc_large-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapless0.7+mpmc_large-devel-0.7.17-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapless0.7+mpmc_large-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapless0.7+mpmc_large-devel}"
SRC_URI[x86_64_v2_rust-heapless0.7+mpmc_large-devel.sha256sum] = "41592ac98d4762219866b07ae83989183fd1439c9649e80c1ab64f0db67d7dcc"

URI_x86_64_v2_rust-heapless0.7+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapless0.7+serde-devel-0.7.17-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapless0.7+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapless0.7+serde-devel}"
SRC_URI[x86_64_v2_rust-heapless0.7+serde-devel.sha256sum] = "bc064ff5d15c73cde087c409e1daff85aa18f7a36d5b07a438c40ad8ddfc21aa"

URI_x86_64_v2_rust-heapless0.7+ufmt-impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapless0.7+ufmt-impl-devel-0.7.17-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapless0.7+ufmt-impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapless0.7+ufmt-impl-devel}"
SRC_URI[x86_64_v2_rust-heapless0.7+ufmt-impl-devel.sha256sum] = "7a99d1eebd149223d8e49e44b02be12f7983e8f98c38abf3508c2afc1f9d50cb"

URI_x86_64_v2_rust-heapless0.7+ufmt-write-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapless0.7+ufmt-write-devel-0.7.17-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapless0.7+ufmt-write-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapless0.7+ufmt-write-devel}"
SRC_URI[x86_64_v2_rust-heapless0.7+ufmt-write-devel.sha256sum] = "8a461b928fe15e0aa873360f6ba6c058ebdcfca5d03f676d4e29aac36d05c142"

URI_x86_64_v2_rust-heapless0.7+x86-sync-pool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapless0.7+x86-sync-pool-devel-0.7.17-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapless0.7+x86-sync-pool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapless0.7+x86-sync-pool-devel}"
SRC_URI[x86_64_v2_rust-heapless0.7+x86-sync-pool-devel.sha256sum] = "6475de51e3c7473d64b2af5741c32490db0b9dec253380aa707c32f1c4955c7a"

URI_x86_64_v2_rust-heapless0.7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapless0.7-devel-0.7.17-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapless0.7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapless0.7-devel}"
SRC_URI[x86_64_v2_rust-heapless0.7-devel.sha256sum] = "476726eb37ca29a4e27c41864b61611ae1661a9790519db21ad6140388d76834"

URI_aarch64_rust-heapless0.7+cas-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapless0.7+cas-devel-0.7.17-2.el10_0.noarch.rpm;name=aarch64_rust-heapless0.7+cas-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapless0.7+cas-devel}"
SRC_URI[aarch64_rust-heapless0.7+cas-devel.sha256sum] = "5876e6f7b32b545be249efb81c9cd05700e0ac7153834f906965738fd09e33c0"

URI_aarch64_rust-heapless0.7+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapless0.7+default-devel-0.7.17-2.el10_0.noarch.rpm;name=aarch64_rust-heapless0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapless0.7+default-devel}"
SRC_URI[aarch64_rust-heapless0.7+default-devel.sha256sum] = "1c90e78abce3d2029c8ab408f393b4cd42ae58e020d51ab1388978f77de2fd9b"
RPROVIDES:rust-heapless0.7+default-devel:append:aarch64 = " virtual/crate_heapless/default__ge_0.0.0_with_crate_heapless/default__lt_1.0.0~"

URI_aarch64_rust-heapless0.7+mpmc_large-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapless0.7+mpmc_large-devel-0.7.17-2.el10_0.noarch.rpm;name=aarch64_rust-heapless0.7+mpmc_large-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapless0.7+mpmc_large-devel}"
SRC_URI[aarch64_rust-heapless0.7+mpmc_large-devel.sha256sum] = "213ff9ea3776175f0ca6cf764f4b0de72bcc68453376ba041c7ac9df1bbd5377"

URI_aarch64_rust-heapless0.7+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapless0.7+serde-devel-0.7.17-2.el10_0.noarch.rpm;name=aarch64_rust-heapless0.7+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapless0.7+serde-devel}"
SRC_URI[aarch64_rust-heapless0.7+serde-devel.sha256sum] = "9814ab847a85338af1b64147b5feae427644e110e9dfb357ecf38ac6ef38cf21"

URI_aarch64_rust-heapless0.7+ufmt-impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapless0.7+ufmt-impl-devel-0.7.17-2.el10_0.noarch.rpm;name=aarch64_rust-heapless0.7+ufmt-impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapless0.7+ufmt-impl-devel}"
SRC_URI[aarch64_rust-heapless0.7+ufmt-impl-devel.sha256sum] = "efe762058f77af861f9c77fde6c6d3caccee12292e2b63e61708bf475323b606"

URI_aarch64_rust-heapless0.7+ufmt-write-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapless0.7+ufmt-write-devel-0.7.17-2.el10_0.noarch.rpm;name=aarch64_rust-heapless0.7+ufmt-write-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapless0.7+ufmt-write-devel}"
SRC_URI[aarch64_rust-heapless0.7+ufmt-write-devel.sha256sum] = "d41164e0ad98900a1294f21a646af250224eaafbd4781385a8fe27f6f5828557"

URI_aarch64_rust-heapless0.7+x86-sync-pool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapless0.7+x86-sync-pool-devel-0.7.17-2.el10_0.noarch.rpm;name=aarch64_rust-heapless0.7+x86-sync-pool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapless0.7+x86-sync-pool-devel}"
SRC_URI[aarch64_rust-heapless0.7+x86-sync-pool-devel.sha256sum] = "a2828dc4fa349b038c54abd08d267d8051ff3203b0d9c536d0f79a3c4045bc16"

URI_aarch64_rust-heapless0.7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapless0.7-devel-0.7.17-2.el10_0.noarch.rpm;name=aarch64_rust-heapless0.7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapless0.7-devel}"
SRC_URI[aarch64_rust-heapless0.7-devel.sha256sum] = "5bdcad9e90d73b89906e53e91e73648eb20bc129fa1e3f0319acede7a4614094"

RDEPENDS:rust-heapless0.7+cas-devel = " \
 cargo \
 rust-heapless0.7-devel \
 "
RDEPENDS:rust-heapless0.7+default-devel = " \
 cargo \
 rust-heapless0.7+cas-devel \
 rust-heapless0.7-devel \
 "
RDEPENDS:rust-heapless0.7+mpmc_large-devel = " \
 cargo \
 rust-heapless0.7-devel \
 "
RDEPENDS:rust-heapless0.7+serde-devel = " \
 cargo \
 rust-heapless0.7-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-heapless0.7+ufmt-impl-devel = " \
 cargo \
 rust-heapless0.7+ufmt-write-devel \
 rust-heapless0.7-devel \
 "
RDEPENDS:rust-heapless0.7+ufmt-write-devel = " \
 cargo \
 rust-heapless0.7-devel \
 rust-ufmt-write+default-devel \
 "
RDEPENDS:rust-heapless0.7+x86-sync-pool-devel = " \
 cargo \
 rust-heapless0.7-devel \
 "
RDEPENDS:rust-heapless0.7-devel = " \
 cargo \
 rust-hash32_0.2+default-devel \
 rust-rustc_version+default-devel \
 rust-spin+default-devel \
 rust-stable_deref_trait-devel \
 "
