# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cobs"
PV = "0.3.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-cobs+alloc-devel \
 rust-cobs+default-devel \
 rust-cobs+serde-devel \
 rust-cobs+std-devel \
 rust-cobs+use_std-devel \
 rust-cobs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cobs-0.3.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "178d90ac5ab0efef2204195d084aee60dd80287cba06cd187dd1f9e602626992"

URI_x86_64_v2_rust-cobs+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cobs+alloc-devel-0.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cobs+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cobs+alloc-devel}"
SRC_URI[x86_64_v2_rust-cobs+alloc-devel.sha256sum] = "3ed0de16342b7866df63a25339af5110130bdaba878992a39ca68c1001b96320"

URI_x86_64_v2_rust-cobs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cobs+default-devel-0.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cobs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cobs+default-devel}"
SRC_URI[x86_64_v2_rust-cobs+default-devel.sha256sum] = "410b0cfb353fc44a3e9235b755ba84f58d83decea22fef14d1bfdcb3a87f2b43"

URI_x86_64_v2_rust-cobs+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cobs+serde-devel-0.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cobs+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cobs+serde-devel}"
SRC_URI[x86_64_v2_rust-cobs+serde-devel.sha256sum] = "dda31b3f2b9d8f497417e68a5c4db7fd37250270bf4b9c56f9d1b7c88dbda37c"

URI_x86_64_v2_rust-cobs+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cobs+std-devel-0.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cobs+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cobs+std-devel}"
SRC_URI[x86_64_v2_rust-cobs+std-devel.sha256sum] = "da776ba5234a308c83904afc167ddf1923554158928fd22f3b55790c9ac70a6c"

URI_x86_64_v2_rust-cobs+use_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cobs+use_std-devel-0.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cobs+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cobs+use_std-devel}"
SRC_URI[x86_64_v2_rust-cobs+use_std-devel.sha256sum] = "64f9476ec7fb03f0aa604c4bc1f5ebb903cbd3984ba50c319cad090a6bfaa194"

URI_x86_64_v2_rust-cobs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cobs-devel-0.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cobs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cobs-devel}"
SRC_URI[x86_64_v2_rust-cobs-devel.sha256sum] = "4266e259aa8a7855a9f4c2fb1d74f9b8e361da2c2af10ea8bede5f0a9b54843f"

URI_aarch64_rust-cobs+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cobs+alloc-devel-0.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-cobs+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cobs+alloc-devel}"
SRC_URI[aarch64_rust-cobs+alloc-devel.sha256sum] = "828479a4cc407a74f025df02afabfb4aefc0026b74f02cc844a88fec6738d024"

URI_aarch64_rust-cobs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cobs+default-devel-0.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-cobs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cobs+default-devel}"
SRC_URI[aarch64_rust-cobs+default-devel.sha256sum] = "f69869a91d972da8d63f257bab0b22740526840b1cfeb905d656586e139badfe"

URI_aarch64_rust-cobs+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cobs+serde-devel-0.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-cobs+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cobs+serde-devel}"
SRC_URI[aarch64_rust-cobs+serde-devel.sha256sum] = "8df8dcec9ae0155775dfb76d44420f7ca3388c0a16fedca681d415b027f1adcd"

URI_aarch64_rust-cobs+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cobs+std-devel-0.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-cobs+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cobs+std-devel}"
SRC_URI[aarch64_rust-cobs+std-devel.sha256sum] = "72441342c5d1735c856b1a3a2c6a875fa1d695ad5c1f7ab21f6ef590df230512"

URI_aarch64_rust-cobs+use_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cobs+use_std-devel-0.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-cobs+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cobs+use_std-devel}"
SRC_URI[aarch64_rust-cobs+use_std-devel.sha256sum] = "d688ca8ccee8285252bd8d4af455c29819756c179abdf94f39902cb06df865a3"

URI_aarch64_rust-cobs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cobs-devel-0.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-cobs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cobs-devel}"
SRC_URI[aarch64_rust-cobs-devel.sha256sum] = "e7e04606e8b7f3a9852867555f3fea0a91cd73a35a2c30a455d5886bab60f973"

RDEPENDS:rust-cobs+alloc-devel = " \
 cargo \
 rust-cobs-devel \
 "
RDEPENDS:rust-cobs+default-devel = " \
 cargo \
 rust-cobs+std-devel \
 rust-cobs-devel \
 "
RDEPENDS:rust-cobs+serde-devel = " \
 cargo \
 rust-cobs-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-cobs+std-devel = " \
 cargo \
 rust-cobs+alloc-devel \
 rust-cobs-devel \
 rust-thiserror+std-devel \
 "
RDEPENDS:rust-cobs+use_std-devel = " \
 cargo \
 rust-cobs+std-devel \
 rust-cobs-devel \
 "
RDEPENDS:rust-cobs-devel = " \
 cargo \
 rust-thiserror-devel \
 "
