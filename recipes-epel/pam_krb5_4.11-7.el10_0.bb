# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pam_krb5"
PV = "4.11"
PR = "7.el10_0"
PACKAGES = " \
 pam_krb5 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pam_krb5-4.11-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad1a73003d9e5037b501c83f3a68e7d4f30c063ae8a757c77c2ea91b0d7d2c48"

URI_x86_64_v2_pam_krb5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pam_krb5-4.11-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pam_krb5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam_krb5}"
SRC_URI[x86_64_v2_pam_krb5.sha256sum] = "f49f23cc10e957e3f041bb09833367d348508c9e307be2d58a091e7bcc9e80bf"

URI_aarch64_pam_krb5 = "${EPEL_MIRROR}/aarch64/Packages/p/pam_krb5-4.11-7.el10_0.aarch64.rpm;name=aarch64_pam_krb5;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam_krb5}"
SRC_URI[aarch64_pam_krb5.sha256sum] = "cee3671a2f5518b76a92c1beaa14bc53896b798d71e3e956d0bc9c7ce605d8d5"

RDEPENDS:pam_krb5 = " \
 glibc \
 krb5-libs \
 libcom_err \
 pam \
 pam-libs \
 "
