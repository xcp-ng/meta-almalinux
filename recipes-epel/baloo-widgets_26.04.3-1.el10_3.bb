# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "baloo-widgets"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 baloo-widgets \
 baloo-widgets-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/baloo-widgets-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d61311aed98f74d3cc04d0069ed40a3984836121aa6204ae7a1cc9c1a8efcb96"

URI_x86_64_v2_baloo-widgets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baloo-widgets-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baloo-widgets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baloo-widgets}"
SRC_URI[x86_64_v2_baloo-widgets.sha256sum] = "96a6592239c61002cc4023d46fb4282f6be2e9ad60bb41c94c2eebfbab61393e"

URI_x86_64_v2_baloo-widgets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baloo-widgets-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baloo-widgets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baloo-widgets-devel}"
SRC_URI[x86_64_v2_baloo-widgets-devel.sha256sum] = "8e623b6f9e4cfd3ce1fee62c0a70fdbc29f78cae72a3a2218675c3851c2d7682"

URI_aarch64_baloo-widgets = "${EPEL_MIRROR}/aarch64/Packages/b/baloo-widgets-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_baloo-widgets;unpack=0"
SRC_URI:append = " ${URI_aarch64_baloo-widgets}"
SRC_URI[aarch64_baloo-widgets.sha256sum] = "a30115fbe2234b32f3bc2f7dbc56ba36c07faf3ad23f5506813162dd4639e07a"

URI_aarch64_baloo-widgets-devel = "${EPEL_MIRROR}/aarch64/Packages/b/baloo-widgets-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_baloo-widgets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_baloo-widgets-devel}"
SRC_URI[aarch64_baloo-widgets-devel.sha256sum] = "43c8f2754275c1b2a22926728ba2ccdfe21faea529201b155003d7e03db40866"

RDEPENDS:baloo-widgets = " \
 glibc \
 kf6-baloo-libs \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kservice \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:baloo-widgets-devel = " \
 baloo-widgets \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kf6-kio-devel \
 qt6-qtbase-devel \
 "
