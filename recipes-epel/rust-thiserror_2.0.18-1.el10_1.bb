# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-thiserror"
PV = "2.0.18"
PR = "1.el10_1"
PACKAGES = " \
 rust-thiserror+default-devel \
 rust-thiserror+std-devel \
 rust-thiserror-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-thiserror-2.0.18-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "663ae45e6779931baebb15e7dd283b38dfc9927c8628e52b72f4e8b485627e1a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thiserror+default-devel-2.0.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thiserror+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-thiserror+default-devel.sha256sum] = "6d333af861ce054a1286181d1c22ab33bf32574c2c244efcb5c2176a1968b505"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thiserror+std-devel-2.0.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thiserror+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-thiserror+std-devel.sha256sum] = "d8af58f94a0b462bf83863e0ad70d77506a6ffdbd5952b4961fe5c3f985ba991"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thiserror-devel-2.0.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thiserror-devel;unpack=0"
SRC_URI[x86_64_v2_rust-thiserror-devel.sha256sum] = "a48f3889cfb92a6bed7fe19cab761876a63591a2127f1874d67441f4e59fb7ca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-thiserror+default-devel-2.0.18-1.el10_1.noarch.rpm;name=aarch64_rust-thiserror+default-devel;unpack=0"
SRC_URI[aarch64_rust-thiserror+default-devel.sha256sum] = "255b22c685005107e52715e04650d44f361f64becd516ce678cd7473ad9b6c81"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-thiserror+std-devel-2.0.18-1.el10_1.noarch.rpm;name=aarch64_rust-thiserror+std-devel;unpack=0"
SRC_URI[aarch64_rust-thiserror+std-devel.sha256sum] = "e6b19dcd255bf504b97df58500fbf8f7e2e41cbe9826a0f9e840371728d6a93e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-thiserror-devel-2.0.18-1.el10_1.noarch.rpm;name=aarch64_rust-thiserror-devel;unpack=0"
SRC_URI[aarch64_rust-thiserror-devel.sha256sum] = "b360a845bf59558ff277ac4839944ed57b49de96c1d4e97cc15c099f3e643d22"

RDEPENDS:rust-thiserror+default-devel = " \
 cargo \
 rust-thiserror+std-devel \
 rust-thiserror-devel \
 "
RDEPENDS:rust-thiserror+std-devel = " \
 cargo \
 rust-thiserror-devel \
 "
RDEPENDS:rust-thiserror-devel = " \
 cargo \
 rust \
 rust-thiserror-impl+default-devel \
 "
