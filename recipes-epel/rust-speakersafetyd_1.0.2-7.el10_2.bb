# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-speakersafetyd"
PV = "1.0.2"
PR = "7.el10_2"
PACKAGES = " \
 speakersafetyd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-speakersafetyd-1.0.2-7.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f1b0b4b4d3300ec488a6a3777b2c54791efde311f5c393366fa30747ee5f9784"

URI_x86_64_v2_speakersafetyd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/speakersafetyd-1.0.2-7.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_speakersafetyd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_speakersafetyd}"
SRC_URI[x86_64_v2_speakersafetyd.sha256sum] = "aeb76374dcdb179433a60080b57c06efd6add5450448e7fa3345f38e2950d7e1"

URI_aarch64_speakersafetyd = "${EPEL_MIRROR}/aarch64/Packages/s/speakersafetyd-1.0.2-7.el10_2.aarch64.rpm;name=aarch64_speakersafetyd;unpack=0"
SRC_URI:append = " ${URI_aarch64_speakersafetyd}"
SRC_URI[aarch64_speakersafetyd.sha256sum] = "6513d1ebd9cce0f571862523d1d9acfe069de787dd163f796aa8b54d508c85d5"

RDEPENDS:speakersafetyd = " \
 alsa-lib \
 bash \
 glibc \
 libgcc \
 systemd-udev \
 "
