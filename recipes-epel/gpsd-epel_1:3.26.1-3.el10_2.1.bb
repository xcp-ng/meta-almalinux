# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gpsd-epel"
PE = "1"
PV = "3.26.1"
PR = "3.el10_2.1"
PACKAGES = " \
 gpsd-devel \
 gpsd-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gpsd-epel-3.26.1-3.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "71f78a874ed39fba32263cb45d42beed7a9bcb21199286784119ab53016dedaf"

URI_aarch64_gpsd-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gpsd-devel-3.26.1-3.el10_2.1.aarch64.rpm;name=aarch64_gpsd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpsd-devel}"
SRC_URI[aarch64_gpsd-devel.sha256sum] = "d1af675e6e58326b85f72b17efc25e5d62f01d4a85b871af7da979fff18c21ae"

URI_aarch64_gpsd-libs = "${EPEL_MIRROR}/aarch64/Packages/g/gpsd-libs-3.26.1-3.el10_2.1.aarch64.rpm;name=aarch64_gpsd-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpsd-libs}"
SRC_URI[aarch64_gpsd-libs.sha256sum] = "198a30010e6a6690c0634899e99ed317ad8aa08e81383d7c5feba771920aa328"

RDEPENDS:gpsd-devel = " \
 gpsd-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:gpsd-libs = " \
 dbus-libs \
 glibc \
 "
