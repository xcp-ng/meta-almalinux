# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-kr-text"
PV = "0.2.0"
PR = "18.el10_0"
PACKAGES = " \
 golang-github-kr-text \
 golang-github-kr-text-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-kr-text-0.2.0-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "17a31d14d90800d6268713137eb2d5be366fe57e48cbc48204215ecf2b508c68"

URI_x86_64_v2_golang-github-kr-text = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-kr-text-0.2.0-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_golang-github-kr-text;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-kr-text}"
SRC_URI[x86_64_v2_golang-github-kr-text.sha256sum] = "1963a8e3dd44fe26a2b944819131146e6d16e3614043c10b31463b07bb87ac5d"

URI_x86_64_v2_golang-github-kr-text-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-kr-text-devel-0.2.0-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-kr-text-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-kr-text-devel}"
SRC_URI[x86_64_v2_golang-github-kr-text-devel.sha256sum] = "5083db634a9b96062c9e8e18b51e7d36b6bb962dbf53167c4cf4b53ad9fd3b26"

URI_aarch64_golang-github-kr-text = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-kr-text-0.2.0-18.el10_0.aarch64.rpm;name=aarch64_golang-github-kr-text;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-kr-text}"
SRC_URI[aarch64_golang-github-kr-text.sha256sum] = "f18530876341be593c357abf34baf7b20a1dd03a7a8a1d2bf8bb2339373e21de"

URI_aarch64_golang-github-kr-text-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-kr-text-devel-0.2.0-18.el10_0.noarch.rpm;name=aarch64_golang-github-kr-text-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-kr-text-devel}"
SRC_URI[aarch64_golang-github-kr-text-devel.sha256sum] = "0f5301ece747330d30560d4f50fd7bd7522d604a1d3334e155c6bcb0006f1224"

RDEPENDS:golang-github-kr-text = " \
 glibc \
 "
RDEPENDS:golang-github-kr-text-devel = " \
 go-filesystem \
 golang-github-creack-pty-devel \
 "
