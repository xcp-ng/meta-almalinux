# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-gi-gobject"
PV = "2.0.31"
PR = "1.el10_0"
PACKAGES = " \
 ghc-gi-gobject \
 ghc-gi-gobject-devel \
 ghc-gi-gobject-doc \
 ghc-gi-gobject-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-gi-gobject-2.0.31-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "457296fcf3ec1ad1e337a80d8f98f124e44fb301f951062937c33397b13626f0"

URI_x86_64_v2_ghc-gi-gobject = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-gi-gobject-2.0.31-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-gi-gobject;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-gi-gobject}"
SRC_URI[x86_64_v2_ghc-gi-gobject.sha256sum] = "beae99d4ae0034e8ac548374ef19cafec2d2d3140871029526faee39a4078154"

URI_x86_64_v2_ghc-gi-gobject-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-gi-gobject-devel-2.0.31-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-gi-gobject-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-gi-gobject-devel}"
SRC_URI[x86_64_v2_ghc-gi-gobject-devel.sha256sum] = "e165affb7731406e921603818ef350c51d927e44f3967bc9f8abc4cda684e590"

URI_x86_64_v2_ghc-gi-gobject-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-gi-gobject-doc-2.0.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-gi-gobject-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-gi-gobject-doc}"
SRC_URI[x86_64_v2_ghc-gi-gobject-doc.sha256sum] = "24ef0cabfa802b933ec50352d4e0e53d7d42df658470c1515d9f95354813b632"

URI_x86_64_v2_ghc-gi-gobject-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-gi-gobject-prof-2.0.31-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-gi-gobject-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-gi-gobject-prof}"
SRC_URI[x86_64_v2_ghc-gi-gobject-prof.sha256sum] = "7fa81f6df8000ddd9151feb06ec8bad8d1ea1d6dda062a158fdee0c028846130"

URI_aarch64_ghc-gi-gobject = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-gi-gobject-2.0.31-1.el10_0.aarch64.rpm;name=aarch64_ghc-gi-gobject;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-gi-gobject}"
SRC_URI[aarch64_ghc-gi-gobject.sha256sum] = "2e1eeb4af5595cf4a7e9e6c4bd644eb5e67adb2cabc8f39fc756b386a6273de3"

URI_aarch64_ghc-gi-gobject-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-gi-gobject-devel-2.0.31-1.el10_0.aarch64.rpm;name=aarch64_ghc-gi-gobject-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-gi-gobject-devel}"
SRC_URI[aarch64_ghc-gi-gobject-devel.sha256sum] = "3dd3793e1921e4daf8cbea4dcc2212aebd9178cdddb20a0f817de1bc9098b793"

URI_aarch64_ghc-gi-gobject-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-gi-gobject-doc-2.0.31-1.el10_0.noarch.rpm;name=aarch64_ghc-gi-gobject-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-gi-gobject-doc}"
SRC_URI[aarch64_ghc-gi-gobject-doc.sha256sum] = "c60746b8dc7243dc53cb32f726487a08396c6c764d37a5f432181746870024d3"

URI_aarch64_ghc-gi-gobject-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-gi-gobject-prof-2.0.31-1.el10_0.aarch64.rpm;name=aarch64_ghc-gi-gobject-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-gi-gobject-prof}"
SRC_URI[aarch64_ghc-gi-gobject-prof.sha256sum] = "7e8522e0e558bebfb5fa167042298bdbf5530533f3d98217211db718f9cb029e"

RDEPENDS:ghc-gi-gobject = " \
 ghc-Cabal \
 ghc-Cabal-syntax \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-array \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-bytestring \
 ghc-colour \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-data-default-class \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-gi-glib \
 ghc-hashable \
 ghc-haskell-gi \
 ghc-haskell-gi-base \
 ghc-haskell-lexer \
 ghc-integer-logarithms \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-os-string \
 ghc-parsec \
 ghc-pretty \
 ghc-pretty-show \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-regex-base \
 ghc-regex-tdfa \
 ghc-resourcet \
 ghc-safe \
 ghc-scientific \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-typed-process \
 ghc-unix \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-xdg-basedir \
 ghc-xml-conduit \
 ghc-xml-types \
 ghc-zlib \
 glib2 \
 glibc \
 gmp \
 gobject-introspection \
 zlib-ng-compat \
 "
RDEPENDS:ghc-gi-gobject-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-gi-glib-devel \
 ghc-gi-gobject \
 ghc-haskell-gi-base-devel \
 ghc-haskell-gi-devel \
 ghc-haskell-gi-overloading-devel \
 ghc-text-devel \
 ghc-transformers-devel \
 glib2-devel \
 "
RDEPENDS:ghc-gi-gobject-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-gi-gobject-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-gi-glib-prof \
 ghc-gi-gobject-devel \
 ghc-haskell-gi-base-prof \
 ghc-haskell-gi-prof \
 ghc-text-prof \
 ghc-transformers-prof \
 "
