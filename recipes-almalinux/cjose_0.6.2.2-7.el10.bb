# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cjose"
PV = "0.6.2.2"
PR = "7.el10"
PACKAGES = " \
 cjose \
 cjose-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cjose-0.6.2.2-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e00078ed201a0d1ee80533c354843316e4e1ab57288c4a7f19ff7a4f9b3effc5"

URI_x86_64_v2_cjose = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cjose-0.6.2.2-7.el10.x86_64_v2.rpm;name=x86_64_v2_cjose;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cjose}"
SRC_URI[x86_64_v2_cjose.sha256sum] = "8907d7d3bd39cc783fd3ad5d3584470fdef0efb7c93c4bbcb601c009b0b605e2"

URI_x86_64_v2_cjose-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/cjose-devel-0.6.2.2-7.el10.x86_64_v2.rpm;name=x86_64_v2_cjose-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cjose-devel}"
SRC_URI[x86_64_v2_cjose-devel.sha256sum] = "6840b0b6c91acd67127f48fc384537032321c68d4363ffab6a47675830a2ee6f"

URI_aarch64_cjose = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cjose-0.6.2.2-7.el10.aarch64.rpm;name=aarch64_cjose;unpack=0"
SRC_URI:append = " ${URI_aarch64_cjose}"
SRC_URI[aarch64_cjose.sha256sum] = "43c80e05f9a7caa5820b63c05b705710279d60ae4daf4fd353fa7a7de82e4f4c"

URI_aarch64_cjose-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/cjose-devel-0.6.2.2-7.el10.aarch64.rpm;name=aarch64_cjose-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cjose-devel}"
SRC_URI[aarch64_cjose-devel.sha256sum] = "302bb1a8f2024b91338032acdbe8072bf24a1fdf3a569f0f1e51058271d5caa8"

RDEPENDS:cjose = " \
 glibc \
 jansson \
 openssl-libs \
 "
RDEPENDS:cjose-devel = " \
 cjose \
 jansson-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
