# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rpm-sequoia"
PV = "1.9.0.3"
PR = "1.el10_1"
PACKAGES = " \
 rpm-sequoia \
 rpm-sequoia-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/rust-rpm-sequoia-1.9.0.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "29e065af35d4f70630699da97cbdd3f830422c914ea60aa1480ca671ba96af1f"

URI_x86_64_v2_rpm-sequoia = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rpm-sequoia-1.9.0.3-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_rpm-sequoia;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-sequoia}"
SRC_URI[x86_64_v2_rpm-sequoia.sha256sum] = "dbd968d569a57b96f49815f4a042db0cf63ca54a87f7df051b462271a31d16c1"

URI_x86_64_v2_rpm-sequoia-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rpm-sequoia-devel-1.9.0.3-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_rpm-sequoia-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-sequoia-devel}"
SRC_URI[x86_64_v2_rpm-sequoia-devel.sha256sum] = "ce1a5e8fcc7e71f4d772010758b39866864ead95e492a73bb82f744737b09611"

URI_aarch64_rpm-sequoia = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rpm-sequoia-1.9.0.3-1.el10_1.aarch64.rpm;name=aarch64_rpm-sequoia;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-sequoia}"
SRC_URI[aarch64_rpm-sequoia.sha256sum] = "f9415abd5c0c5511c3d2cf7e484eb36b0c7b79c784ef7dd1bab13033e42f5a82"

URI_aarch64_rpm-sequoia-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rpm-sequoia-devel-1.9.0.3-1.el10_1.aarch64.rpm;name=aarch64_rpm-sequoia-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-sequoia-devel}"
SRC_URI[aarch64_rpm-sequoia-devel.sha256sum] = "e6b80d65341d6ae4beaca655c9097de22e5df7ebbc55957cfcd5d8699e057ea7"

RDEPENDS:rpm-sequoia = " \
 glibc \
 libgcc \
 openssl-libs \
 "
RDEPENDS:rpm-sequoia-devel = " \
 openssl-devel \
 pkgconf-pkg-config \
 rpm-sequoia \
 "
