# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-time-macros"
PV = "0.2.27"
PR = "1.el10_2"
PACKAGES = " \
 rust-time-macros+default-devel \
 rust-time-macros+formatting-devel \
 rust-time-macros+large-dates-devel \
 rust-time-macros+parsing-devel \
 rust-time-macros+serde-devel \
 rust-time-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-time-macros-0.2.27-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f2a4ee130a2998a805ca149beb02f02fd26edd194fb0fab125ebaa70d12c6997"

URI_x86_64_v2_rust-time-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time-macros+default-devel-0.2.27-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time-macros+default-devel}"
SRC_URI[x86_64_v2_rust-time-macros+default-devel.sha256sum] = "a62973cec22759a9d346e7264291c6928b7456be658e2467349af13dbc0b0fe5"

URI_x86_64_v2_rust-time-macros+formatting-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time-macros+formatting-devel-0.2.27-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time-macros+formatting-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time-macros+formatting-devel}"
SRC_URI[x86_64_v2_rust-time-macros+formatting-devel.sha256sum] = "8e49b06212312412cd955de2ef618e36ffca02c1783ec31a71888e46c776f1e1"

URI_x86_64_v2_rust-time-macros+large-dates-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time-macros+large-dates-devel-0.2.27-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time-macros+large-dates-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time-macros+large-dates-devel}"
SRC_URI[x86_64_v2_rust-time-macros+large-dates-devel.sha256sum] = "3936460b5236596c143aa401582f3c5bf723f2da7887b7c24331b810c08625e8"

URI_x86_64_v2_rust-time-macros+parsing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time-macros+parsing-devel-0.2.27-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time-macros+parsing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time-macros+parsing-devel}"
SRC_URI[x86_64_v2_rust-time-macros+parsing-devel.sha256sum] = "e71261d6fea7df797e6fd19f81d5bee10f84f6c166274dd0caa81cf6846f9d2b"

URI_x86_64_v2_rust-time-macros+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time-macros+serde-devel-0.2.27-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time-macros+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time-macros+serde-devel}"
SRC_URI[x86_64_v2_rust-time-macros+serde-devel.sha256sum] = "d5a51dc948ca518609d23b2a63c71ca3dc943e256a839f4ee1bcee13bd31b0d3"

URI_x86_64_v2_rust-time-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time-macros-devel-0.2.27-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time-macros-devel}"
SRC_URI[x86_64_v2_rust-time-macros-devel.sha256sum] = "68b65b725f6c4b64d5a922765485b7b457a6c265d585a1b09702d2d06cc22198"

URI_aarch64_rust-time-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time-macros+default-devel-0.2.27-1.el10_2.noarch.rpm;name=aarch64_rust-time-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time-macros+default-devel}"
SRC_URI[aarch64_rust-time-macros+default-devel.sha256sum] = "26a83ef7dfbabbe7b31f91742e79db54f779ae75f69579a792aab5519524a737"

URI_aarch64_rust-time-macros+formatting-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time-macros+formatting-devel-0.2.27-1.el10_2.noarch.rpm;name=aarch64_rust-time-macros+formatting-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time-macros+formatting-devel}"
SRC_URI[aarch64_rust-time-macros+formatting-devel.sha256sum] = "63cb42408110fedb4110c2255ee0705cfae8da611b363cc3a3b1fad84476a35e"

URI_aarch64_rust-time-macros+large-dates-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time-macros+large-dates-devel-0.2.27-1.el10_2.noarch.rpm;name=aarch64_rust-time-macros+large-dates-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time-macros+large-dates-devel}"
SRC_URI[aarch64_rust-time-macros+large-dates-devel.sha256sum] = "447a45aef125862a4a495da678e569c41eaf41b0bb77ff64820c18adfeac3c2d"

URI_aarch64_rust-time-macros+parsing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time-macros+parsing-devel-0.2.27-1.el10_2.noarch.rpm;name=aarch64_rust-time-macros+parsing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time-macros+parsing-devel}"
SRC_URI[aarch64_rust-time-macros+parsing-devel.sha256sum] = "fc77375087c1f5ab641c41d429ec438d3d89e103a21cba2fa69f954359c4fa68"

URI_aarch64_rust-time-macros+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time-macros+serde-devel-0.2.27-1.el10_2.noarch.rpm;name=aarch64_rust-time-macros+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time-macros+serde-devel}"
SRC_URI[aarch64_rust-time-macros+serde-devel.sha256sum] = "d9a990bc3543e5e76f8f1f3015340a8eecf778e691346b6928f5fb39a6db479e"

URI_aarch64_rust-time-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time-macros-devel-0.2.27-1.el10_2.noarch.rpm;name=aarch64_rust-time-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time-macros-devel}"
SRC_URI[aarch64_rust-time-macros-devel.sha256sum] = "54610407f9f004e7f5a7d553dcc7c90028836f617eb923c0216e43cf62a9e2ca"

RDEPENDS:rust-time-macros+default-devel = " \
 cargo \
 rust-time-macros-devel \
 "
RDEPENDS:rust-time-macros+formatting-devel = " \
 cargo \
 rust-time-macros-devel \
 "
RDEPENDS:rust-time-macros+large-dates-devel = " \
 cargo \
 rust-time-macros-devel \
 "
RDEPENDS:rust-time-macros+parsing-devel = " \
 cargo \
 rust-time-macros-devel \
 "
RDEPENDS:rust-time-macros+serde-devel = " \
 cargo \
 rust-time-macros-devel \
 "
RDEPENDS:rust-time-macros-devel = " \
 cargo \
 rust \
 rust-num-conv+default-devel \
 rust-time-core+default-devel \
 "
