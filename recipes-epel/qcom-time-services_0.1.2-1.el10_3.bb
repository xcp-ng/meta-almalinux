# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qcom-time-services"
PV = "0.1.2"
PR = "1.el10_3"
PACKAGES = " \
 qcom-time-services \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/q/qcom-time-services-0.1.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7886183e693d64b68f4b9a816ca3348c99d7eb78f579fa5bc1a1269f0b0ed827"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qcom-time-services-0.1.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qcom-time-services;unpack=0"
SRC_URI[x86_64_v2_qcom-time-services.sha256sum] = "679137684ceb66cd0abf02a0467582104eff4e07214a4aed04094e0e231e4b8b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qcom-time-services-0.1.2-1.el10_3.aarch64.rpm;name=aarch64_qcom-time-services;unpack=0"
SRC_URI[aarch64_qcom-time-services.sha256sum] = "b3a8ab12e6bfa84ebd9bdd4967aa1ce9b9e696e213e0bcc806b64e1e4f7d6178"

RDEPENDS:qcom-time-services = " \
 bash \
 glibc \
 qmi-framework \
 "
