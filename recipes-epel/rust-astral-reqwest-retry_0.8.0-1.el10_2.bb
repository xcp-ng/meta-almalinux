# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-astral-reqwest-retry"
PV = "0.8.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-astral-reqwest-retry+default-devel \
 rust-astral-reqwest-retry+tracing-devel \
 rust-astral-reqwest-retry-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-astral-reqwest-retry-0.8.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "31d31a45a258cb1e085eb663943d5724a09248bfedaa44c95d07e73f01af6787"

URI_x86_64_v2_rust-astral-reqwest-retry+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-reqwest-retry+default-devel-0.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-reqwest-retry+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-reqwest-retry+default-devel}"
SRC_URI[x86_64_v2_rust-astral-reqwest-retry+default-devel.sha256sum] = "c08aa36641b1d030504995a01331f1679d153ba095cfad1416d817e3fdf246ed"

URI_x86_64_v2_rust-astral-reqwest-retry+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-reqwest-retry+tracing-devel-0.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-reqwest-retry+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-reqwest-retry+tracing-devel}"
SRC_URI[x86_64_v2_rust-astral-reqwest-retry+tracing-devel.sha256sum] = "466a8ec991995ca15f216f57a45c91655802a03f20971dfc16379690194479b5"

URI_x86_64_v2_rust-astral-reqwest-retry-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-reqwest-retry-devel-0.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-reqwest-retry-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-reqwest-retry-devel}"
SRC_URI[x86_64_v2_rust-astral-reqwest-retry-devel.sha256sum] = "1e33c7523f4300272dff248ef889d8dcf776daadbc9b9c303cfc74d27f2441fb"

URI_aarch64_rust-astral-reqwest-retry+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-reqwest-retry+default-devel-0.8.0-1.el10_2.noarch.rpm;name=aarch64_rust-astral-reqwest-retry+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-reqwest-retry+default-devel}"
SRC_URI[aarch64_rust-astral-reqwest-retry+default-devel.sha256sum] = "0b24981b0091a6f3a3c2971ab01c4883d8b967e4d6b5ac87e068940f3d331255"

URI_aarch64_rust-astral-reqwest-retry+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-reqwest-retry+tracing-devel-0.8.0-1.el10_2.noarch.rpm;name=aarch64_rust-astral-reqwest-retry+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-reqwest-retry+tracing-devel}"
SRC_URI[aarch64_rust-astral-reqwest-retry+tracing-devel.sha256sum] = "a0ee524cd315e20de0b55f61426c9a6fd0f58e8a8969a66bca8da307700527a9"

URI_aarch64_rust-astral-reqwest-retry-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-reqwest-retry-devel-0.8.0-1.el10_2.noarch.rpm;name=aarch64_rust-astral-reqwest-retry-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-reqwest-retry-devel}"
SRC_URI[aarch64_rust-astral-reqwest-retry-devel.sha256sum] = "59b74c24bf0c48287051ee06935365000cb02b8d05db5433c4dec0cd3c1f4ed8"

RDEPENDS:rust-astral-reqwest-retry+default-devel = " \
 cargo \
 rust-astral-reqwest-retry+tracing-devel \
 rust-astral-reqwest-retry-devel \
 "
RDEPENDS:rust-astral-reqwest-retry+tracing-devel = " \
 cargo \
 rust-astral-reqwest-retry-devel \
 rust-tracing+default-devel \
 "
RDEPENDS:rust-astral-reqwest-retry-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-astral-reqwest-middleware+default-devel \
 rust-async-trait+default-devel \
 rust-futures+default-devel \
 rust-http+default-devel \
 rust-hyper+default-devel \
 rust-reqwest0.12-devel \
 rust-retry-policies+default-devel \
 rust-thiserror+default-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 "
