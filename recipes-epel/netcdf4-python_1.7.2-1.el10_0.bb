# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "netcdf4-python"
PV = "1.7.2"
PR = "1.el10_0"
PACKAGES = " \
 netcdf4-python \
 python3-netcdf4 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/netcdf4-python-1.7.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "081f6a5ef5bcc1c73bb222a8077286ce8be678da1e75e8f10646d65d86913a23"

URI_x86_64_v2_netcdf4-python = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcdf4-python-1.7.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcdf4-python;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcdf4-python}"
SRC_URI[x86_64_v2_netcdf4-python.sha256sum] = "f862d6ed1d1d0a6d4c9b121c88ae9969ef90f6ea0d15a337d7a0435aaf7832ff"

URI_x86_64_v2_python3-netcdf4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-netcdf4-1.7.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-netcdf4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-netcdf4}"
SRC_URI[x86_64_v2_python3-netcdf4.sha256sum] = "1716b591dea6be4b2dac216d41ed478df1b165cb6a326d1a11962f72ec543ea5"

URI_aarch64_netcdf4-python = "${EPEL_MIRROR}/aarch64/Packages/n/netcdf4-python-1.7.2-1.el10_0.aarch64.rpm;name=aarch64_netcdf4-python;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcdf4-python}"
SRC_URI[aarch64_netcdf4-python.sha256sum] = "cfbbf3a69e5dede2f110bbb7d65872d6cf59adf1d3d1ec37a1e82ae34cff88bc"

URI_aarch64_python3-netcdf4 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-netcdf4-1.7.2-1.el10_0.aarch64.rpm;name=aarch64_python3-netcdf4;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-netcdf4}"
SRC_URI[aarch64_python3-netcdf4.sha256sum] = "740733f6745e3821df410b77491c7fcffe7b96430cc41676e2447563ec3458b8"

RDEPENDS:netcdf4-python = " \
 python3 \
 python3-netcdf4 \
 "
RDEPENDS:python3-netcdf4 = " \
 glibc \
 netcdf \
 python3 \
 python3-certifi \
 python3-cftime \
 python3-cython \
 python3-numpy \
 "
