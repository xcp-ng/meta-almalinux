# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-xi-unicode"
PV = "0.3.0"
PR = "11.el10_0"
PACKAGES = " \
 rust-xi-unicode+default-devel \
 rust-xi-unicode-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-xi-unicode-0.3.0-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5887bc812ee7a5572d1e5577d0cb72441257cc5efdae135ff33890b03e4eb60f"

URI_x86_64_v2_rust-xi-unicode+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xi-unicode+default-devel-0.3.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xi-unicode+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xi-unicode+default-devel}"
SRC_URI[x86_64_v2_rust-xi-unicode+default-devel.sha256sum] = "b713e13c5f78fa6e3c6a07aaeeaa05eb94e1f6a4ec67112fbe403472e4af8eb7"

URI_x86_64_v2_rust-xi-unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xi-unicode-devel-0.3.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xi-unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xi-unicode-devel}"
SRC_URI[x86_64_v2_rust-xi-unicode-devel.sha256sum] = "744f9e6c561a51f1f786d4197fe8e8c5dbb253d1104956f687e70eaf3e7bedf1"

URI_aarch64_rust-xi-unicode+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xi-unicode+default-devel-0.3.0-11.el10_0.noarch.rpm;name=aarch64_rust-xi-unicode+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xi-unicode+default-devel}"
SRC_URI[aarch64_rust-xi-unicode+default-devel.sha256sum] = "4821dd4fe38d15861aaed3849900cef28893df5d2baf4de4cc7f2dfa986199cf"

URI_aarch64_rust-xi-unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xi-unicode-devel-0.3.0-11.el10_0.noarch.rpm;name=aarch64_rust-xi-unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xi-unicode-devel}"
SRC_URI[aarch64_rust-xi-unicode-devel.sha256sum] = "55d73e91a5cf3df1d13a929d826e1aa794f51187329967c34e16254ae557d859"

RDEPENDS:rust-xi-unicode+default-devel = " \
 cargo \
 rust-xi-unicode-devel \
 "
RDEPENDS:rust-xi-unicode-devel = " \
 cargo \
 "
