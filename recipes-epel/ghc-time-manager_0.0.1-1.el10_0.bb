# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-time-manager"
PV = "0.0.1"
PR = "1.el10_0"
PACKAGES = " \
 ghc-time-manager \
 ghc-time-manager-devel \
 ghc-time-manager-doc \
 ghc-time-manager-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-time-manager-0.0.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eb5742db0e7806bbdb149848569810a1a3863914a1c7293e6ef4dacd513d2a54"

URI_x86_64_v2_ghc-time-manager = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-time-manager-0.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-time-manager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-time-manager}"
SRC_URI[x86_64_v2_ghc-time-manager.sha256sum] = "a9428bb590904881e53e0ce03832e8f85f978c374976211255de1135f4cdcc98"

URI_x86_64_v2_ghc-time-manager-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-time-manager-devel-0.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-time-manager-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-time-manager-devel}"
SRC_URI[x86_64_v2_ghc-time-manager-devel.sha256sum] = "781af3951bdd824f37187eab89fe22351e31b3019c494efb2c72d6cbd364e551"

URI_x86_64_v2_ghc-time-manager-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-time-manager-doc-0.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-time-manager-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-time-manager-doc}"
SRC_URI[x86_64_v2_ghc-time-manager-doc.sha256sum] = "24f1e493e400cc2d1ab7e3ebb86ca2b14f2b99decf8e6d1217a9448eb3992623"

URI_x86_64_v2_ghc-time-manager-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-time-manager-prof-0.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-time-manager-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-time-manager-prof}"
SRC_URI[x86_64_v2_ghc-time-manager-prof.sha256sum] = "638b65a23169556d371b03398838e7dcb353572a322ed4cc23dae086321d4c06"

URI_aarch64_ghc-time-manager = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-time-manager-0.0.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-time-manager;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-time-manager}"
SRC_URI[aarch64_ghc-time-manager.sha256sum] = "e196ba8d3712bf78c78f4986757a557f06c7878e69e82352d6309d5d3d6e10b8"

URI_aarch64_ghc-time-manager-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-time-manager-devel-0.0.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-time-manager-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-time-manager-devel}"
SRC_URI[aarch64_ghc-time-manager-devel.sha256sum] = "7f83064a345656448c314c3d8c136a65f5fe2730ceb41bd3c03e1dc91d75b72e"

URI_aarch64_ghc-time-manager-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-time-manager-doc-0.0.1-1.el10_0.noarch.rpm;name=aarch64_ghc-time-manager-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-time-manager-doc}"
SRC_URI[aarch64_ghc-time-manager-doc.sha256sum] = "1a8b3eda83f709dd5adbd8ce3789d8afd77e81e4e8552eeb47f6548c8d0e9962"

URI_aarch64_ghc-time-manager-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-time-manager-prof-0.0.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-time-manager-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-time-manager-prof}"
SRC_URI[aarch64_ghc-time-manager-prof.sha256sum] = "ae3f0ebc1ddc1c042c57836826e6d12dcc7e0bca607fbce7b8f98bf5aab26b7f"

RDEPENDS:ghc-time-manager = " \
 ghc-array \
 ghc-async \
 ghc-auto-update \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-process \
 ghc-safe-exceptions \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 ghc-unliftio \
 ghc-unliftio-core \
 glibc \
 gmp \
 "
RDEPENDS:ghc-time-manager-devel = " \
 ghc-auto-update-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-time-manager \
 ghc-unliftio-devel \
 "
RDEPENDS:ghc-time-manager-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-time-manager-prof = " \
 ghc-auto-update-prof \
 ghc-base-prof \
 ghc-time-manager-devel \
 ghc-unliftio-prof \
 "
