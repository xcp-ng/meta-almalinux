# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ipa"
PV = "4.13.4"
PR = "1.el10_2"
PACKAGES = " \
 ipa-client \
 ipa-client-common \
 ipa-client-encrypted-dns \
 ipa-client-epn \
 ipa-client-samba \
 ipa-common \
 ipa-selinux \
 ipa-selinux-luna \
 ipa-selinux-nfast \
 ipa-server \
 ipa-server-common \
 ipa-server-dns \
 ipa-server-encrypted-dns \
 ipa-server-trust-ad \
 python3-ipaclient \
 python3-ipalib \
 python3-ipaserver \
 python3-ipatests \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ipa-4.13.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3dfdd7a79dd82578dce714be49a8b9eddf581d33712c03623edd6c43ba05c4c8"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - python3-ipaclient: augeas-libs >= 1.12.1-0
# - python3-ipaserver: augeas-libs >= 1.12.1-0

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - python3-ipaclient: augeas-libs >= 1.12.1-0
# - python3-ipaserver: augeas-libs >= 1.12.1-0

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-client-4.13.4-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_ipa-client;unpack=0"
SRC_URI[x86_64_v2_ipa-client.sha256sum] = "ef1ff600b097a5836b498d3900b38556ff92312fde26b7fcdaa4947b8c687ad0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-client-common-4.13.4-1.el10_2.noarch.rpm;name=x86_64_v2_ipa-client-common;unpack=0"
SRC_URI[x86_64_v2_ipa-client-common.sha256sum] = "99ad0482c8eaf5ea6a943447eaac1ba10950f97cd551e3ce6c2793f1832e41a8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-client-encrypted-dns-4.13.4-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_ipa-client-encrypted-dns;unpack=0"
SRC_URI[x86_64_v2_ipa-client-encrypted-dns.sha256sum] = "5e89761faa24a7ab7e0dafe887ca674fd8498dfcaf7bda1e0954af6def1913c8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-client-epn-4.13.4-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_ipa-client-epn;unpack=0"
SRC_URI[x86_64_v2_ipa-client-epn.sha256sum] = "34a74679e17dc967dcbda630cabacc1292686739f269f2383e12a51243350307"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-client-samba-4.13.4-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_ipa-client-samba;unpack=0"
SRC_URI[x86_64_v2_ipa-client-samba.sha256sum] = "41e77c012b1a4e71380017ab4515817d6eaf7ea6f16d042f7fa0cdd1859e2e3f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-common-4.13.4-1.el10_2.noarch.rpm;name=x86_64_v2_ipa-common;unpack=0"
SRC_URI[x86_64_v2_ipa-common.sha256sum] = "4144c11a83aecac08226230567deedacef7facf17ce0a31efefe1a2ad9aaa0a1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-selinux-4.13.4-1.el10_2.noarch.rpm;name=x86_64_v2_ipa-selinux;unpack=0"
SRC_URI[x86_64_v2_ipa-selinux.sha256sum] = "3bbaaa21c4182fda1a5241bb0f5fc945b4dd8f1295609aea9cabfc4dc827688a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-selinux-luna-4.13.4-1.el10_2.noarch.rpm;name=x86_64_v2_ipa-selinux-luna;unpack=0"
SRC_URI[x86_64_v2_ipa-selinux-luna.sha256sum] = "d6c79b60b49a1f8f4c6f9bdf660fa53d2910a7593dbace5e93e486cb87b288ea"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-selinux-nfast-4.13.4-1.el10_2.noarch.rpm;name=x86_64_v2_ipa-selinux-nfast;unpack=0"
SRC_URI[x86_64_v2_ipa-selinux-nfast.sha256sum] = "898e7d3623722553f2ba1cd2b4a473f852a3e0790749aa320403d269e7a0a24a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-server-4.13.4-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_ipa-server;unpack=0"
SRC_URI[x86_64_v2_ipa-server.sha256sum] = "7ebeaf411988194b0947516c28561ad9206faa9a077950ab43f5ac719363b033"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-server-common-4.13.4-1.el10_2.noarch.rpm;name=x86_64_v2_ipa-server-common;unpack=0"
SRC_URI[x86_64_v2_ipa-server-common.sha256sum] = "e77c01557668023ac072b330d723c4dd1555495797742ca39c2e7fef063bc959"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-server-dns-4.13.4-1.el10_2.noarch.rpm;name=x86_64_v2_ipa-server-dns;unpack=0"
SRC_URI[x86_64_v2_ipa-server-dns.sha256sum] = "b51948fbd1e5414a345dd9a8a33d2f5c4e174fa72168bdc2518a48180e3894e1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-server-encrypted-dns-4.13.4-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_ipa-server-encrypted-dns;unpack=0"
SRC_URI[x86_64_v2_ipa-server-encrypted-dns.sha256sum] = "69f0156467fa565e4604dd6c871d243330a899a4ab4d458d95142f54198558ff"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-server-trust-ad-4.13.4-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_ipa-server-trust-ad;unpack=0"
SRC_URI[x86_64_v2_ipa-server-trust-ad.sha256sum] = "c97ec1ee85894164f2fa0db097683d2649bdb8c8fa5761f43d9f77ec3fdead53"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-ipaclient-4.13.4-1.el10_2.noarch.rpm;name=x86_64_v2_python3-ipaclient;unpack=0"
SRC_URI[x86_64_v2_python3-ipaclient.sha256sum] = "75d3397f9faa033046ebf837c3173a3b93b02cb7b7be5d66ee746e74cea35086"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-ipalib-4.13.4-1.el10_2.noarch.rpm;name=x86_64_v2_python3-ipalib;unpack=0"
SRC_URI[x86_64_v2_python3-ipalib.sha256sum] = "4becc4f5c6c2c8d32741a3600b8b75f350754d326439bba74ab74eec92cbbde3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-ipaserver-4.13.4-1.el10_2.noarch.rpm;name=x86_64_v2_python3-ipaserver;unpack=0"
SRC_URI[x86_64_v2_python3-ipaserver.sha256sum] = "0fd7500513d74955796c1d0fee7ecba945a8e28ace17bbdab27b6aaa886ae8c1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-ipatests-4.13.4-1.el10_2.noarch.rpm;name=x86_64_v2_python3-ipatests;unpack=0"
SRC_URI[x86_64_v2_python3-ipatests.sha256sum] = "aada4129cc2eba155e636ed8ca940c21802b27bb54ac8e78f0bc8727067509f5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-client-4.13.4-1.el10_2.aarch64.rpm;name=aarch64_ipa-client;unpack=0"
SRC_URI[aarch64_ipa-client.sha256sum] = "87f4b242d15411726772444ab0a782c64e6fbcca21fb75d43938f3f9b5d2bde7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-client-common-4.13.4-1.el10_2.noarch.rpm;name=aarch64_ipa-client-common;unpack=0"
SRC_URI[aarch64_ipa-client-common.sha256sum] = "99ad0482c8eaf5ea6a943447eaac1ba10950f97cd551e3ce6c2793f1832e41a8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-client-encrypted-dns-4.13.4-1.el10_2.aarch64.rpm;name=aarch64_ipa-client-encrypted-dns;unpack=0"
SRC_URI[aarch64_ipa-client-encrypted-dns.sha256sum] = "155e5f6c54388b81e2d897b1b37b3093ee6f54a4cabeb666f1a99ef94f7ad764"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-client-epn-4.13.4-1.el10_2.aarch64.rpm;name=aarch64_ipa-client-epn;unpack=0"
SRC_URI[aarch64_ipa-client-epn.sha256sum] = "6d98a1a1dd15fdf12c174b1f54e26bd1772d8530144a0b54b79bf085203d9324"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-client-samba-4.13.4-1.el10_2.aarch64.rpm;name=aarch64_ipa-client-samba;unpack=0"
SRC_URI[aarch64_ipa-client-samba.sha256sum] = "9353b8bca27d241c437e6bd27bb0eb290364a23426ab8caf35e9ff14c5969834"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-common-4.13.4-1.el10_2.noarch.rpm;name=aarch64_ipa-common;unpack=0"
SRC_URI[aarch64_ipa-common.sha256sum] = "4144c11a83aecac08226230567deedacef7facf17ce0a31efefe1a2ad9aaa0a1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-selinux-4.13.4-1.el10_2.noarch.rpm;name=aarch64_ipa-selinux;unpack=0"
SRC_URI[aarch64_ipa-selinux.sha256sum] = "3bbaaa21c4182fda1a5241bb0f5fc945b4dd8f1295609aea9cabfc4dc827688a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-selinux-luna-4.13.4-1.el10_2.noarch.rpm;name=aarch64_ipa-selinux-luna;unpack=0"
SRC_URI[aarch64_ipa-selinux-luna.sha256sum] = "d6c79b60b49a1f8f4c6f9bdf660fa53d2910a7593dbace5e93e486cb87b288ea"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-selinux-nfast-4.13.4-1.el10_2.noarch.rpm;name=aarch64_ipa-selinux-nfast;unpack=0"
SRC_URI[aarch64_ipa-selinux-nfast.sha256sum] = "898e7d3623722553f2ba1cd2b4a473f852a3e0790749aa320403d269e7a0a24a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-server-4.13.4-1.el10_2.aarch64.rpm;name=aarch64_ipa-server;unpack=0"
SRC_URI[aarch64_ipa-server.sha256sum] = "ff213304f6147b173f79e3f1d35833837e48473bffe59c9c11f37e69bddb3528"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-server-common-4.13.4-1.el10_2.noarch.rpm;name=aarch64_ipa-server-common;unpack=0"
SRC_URI[aarch64_ipa-server-common.sha256sum] = "e77c01557668023ac072b330d723c4dd1555495797742ca39c2e7fef063bc959"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-server-dns-4.13.4-1.el10_2.noarch.rpm;name=aarch64_ipa-server-dns;unpack=0"
SRC_URI[aarch64_ipa-server-dns.sha256sum] = "b51948fbd1e5414a345dd9a8a33d2f5c4e174fa72168bdc2518a48180e3894e1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-server-encrypted-dns-4.13.4-1.el10_2.aarch64.rpm;name=aarch64_ipa-server-encrypted-dns;unpack=0"
SRC_URI[aarch64_ipa-server-encrypted-dns.sha256sum] = "10e392eef79c8ad51db62f0c114127a7dfebf5fd2b9e21f7c187ef70a6824a01"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-server-trust-ad-4.13.4-1.el10_2.aarch64.rpm;name=aarch64_ipa-server-trust-ad;unpack=0"
SRC_URI[aarch64_ipa-server-trust-ad.sha256sum] = "2765a8d625daf07f5a4e43a37694cce9787940cc8bf47e6e01609e9d18897baf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-ipaclient-4.13.4-1.el10_2.noarch.rpm;name=aarch64_python3-ipaclient;unpack=0"
SRC_URI[aarch64_python3-ipaclient.sha256sum] = "75d3397f9faa033046ebf837c3173a3b93b02cb7b7be5d66ee746e74cea35086"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-ipalib-4.13.4-1.el10_2.noarch.rpm;name=aarch64_python3-ipalib;unpack=0"
SRC_URI[aarch64_python3-ipalib.sha256sum] = "4becc4f5c6c2c8d32741a3600b8b75f350754d326439bba74ab74eec92cbbde3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-ipaserver-4.13.4-1.el10_2.noarch.rpm;name=aarch64_python3-ipaserver;unpack=0"
SRC_URI[aarch64_python3-ipaserver.sha256sum] = "0fd7500513d74955796c1d0fee7ecba945a8e28ace17bbdab27b6aaa886ae8c1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-ipatests-4.13.4-1.el10_2.noarch.rpm;name=aarch64_python3-ipatests;unpack=0"
SRC_URI[aarch64_python3-ipatests.sha256sum] = "aada4129cc2eba155e636ed8ca940c21802b27bb54ac8e78f0bc8727067509f5"

RDEPENDS:ipa-client = " \
 authselect \
 autofs \
 bash \
 bind-utils \
 certmonger \
 chrony \
 curl \
 cyrus-sasl-gssapi \
 glibc \
 hostname \
 ipa-client-common \
 ipa-common \
 jansson \
 krb5-libs \
 krb5-pkinit \
 krb5-workstation \
 libcom_err \
 libini_config \
 libnfsidmap \
 libsss_autofs \
 libsss_sudo \
 nss-tools \
 oddjob-mkhomedir \
 openldap \
 openssl-libs \
 policycoreutils \
 popt \
 python3 \
 python3-gssapi \
 python3-ipaclient \
 python3-ldap \
 python3-sssdconfig \
 sssd-idp \
 sssd-ipa \
 sssd-krb5 \
 sssd-tools \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_ge_7.21.7-2 \
 virtual/nfs-utils_or_nfsv4-client-utils \
 "
RDEPENDS:ipa-client-common = " \
 "
RDEPENDS:ipa-client-encrypted-dns = " \
 unbound \
 "
RDEPENDS:ipa-client-epn = " \
 bash \
 ipa-client \
 python3 \
 systemd \
 "
RDEPENDS:ipa-client-samba = " \
 cifs-utils \
 ipa-client \
 python3 \
 python3-samba \
 samba \
 samba-client \
 samba-common-tools \
 samba-winbind \
 sssd-winbind-idmap \
 tdb-tools \
 "
RDEPENDS:ipa-common = " \
 ipa-selinux \
 "
RDEPENDS:ipa-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:ipa-selinux-luna = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:ipa-selinux-nfast = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:ipa-server = " \
 389-ds-base \
 acl \
 bash \
 certmonger \
 chrony \
 cracklib-dicts \
 cyrus-sasl-gssapi \
 fontawesome4-fonts \
 glibc \
 gssproxy \
 gzip \
 httpd \
 idm-pki-acme \
 idm-pki-ca \
 idm-pki-kra \
 ipa-client \
 ipa-common \
 ipa-server-common \
 jansson \
 krb5-libs \
 krb5-server \
 libcom_err \
 libgcc \
 libpwquality \
 libsss_certmap \
 libsss_nss_idmap \
 libtalloc \
 libtevent \
 libunistring \
 libuuid \
 libverto \
 mod_auth_gssapi \
 mod_lookup_identity \
 mod_session \
 mod_ssl \
 nss-tools \
 oddjob \
 open-sans-fonts \
 openldap \
 openldap-clients \
 openssl \
 openssl-libs \
 p11-kit \
 policycoreutils \
 popt \
 python3 \
 python3-gssapi \
 python3-ipaserver \
 python3-ldap \
 python3-mod_wsgi \
 python3-systemd \
 samba-client-libs \
 selinux-policy \
 shadow-utils \
 slapi-nis \
 softhsm \
 sssd-dbus \
 systemd \
 tar \
 "
RDEPENDS:ipa-server-common = " \
 almalinux-logos-ipa \
 httpd \
 ipa-client-common \
 systemd \
 "
RDEPENDS:ipa-server-dns = " \
 bash \
 bind \
 bind-dnssec-utils \
 bind-dyndb-ldap \
 bind-utils \
 ipa-server \
 opendnssec \
 pkcs11-provider \
 python3 \
 softhsm \
 systemd \
 "
RDEPENDS:ipa-server-encrypted-dns = " \
 bind-dyndb-ldap \
 ipa-client-encrypted-dns \
 "
RDEPENDS:ipa-server-trust-ad = " \
 alternatives \
 bash \
 glibc \
 ipa-common \
 ipa-server \
 krb5-libs \
 libcom_err \
 libpwquality \
 libsss_idmap \
 libtalloc \
 libtevent \
 openldap \
 openssl-libs \
 python3 \
 python3-libsss_nss_idmap \
 python3-samba \
 python3-sss \
 samba \
 samba-client-libs \
 samba-winbind \
 sssd-winbind-idmap \
 "
RDEPENDS:python3-ipaclient = " \
 ipa-client-common \
 ipa-common \
 python3 \
 python3-augeas \
 python3-cryptography \
 python3-dns \
 python3-ipalib \
 python3-jinja2 \
 python3-qrcode \
 python3-six \
 "
RDEPENDS:python3-ipalib = " \
 gnupg2 \
 ipa-common \
 keyutils \
 python3 \
 python3-argcomplete \
 python3-cffi \
 python3-cryptography \
 python3-dateutil \
 python3-dbus \
 python3-dns \
 python3-gssapi \
 python3-ifaddr \
 python3-jwcrypto \
 python3-ldap \
 python3-libipa_hbac \
 python3-netaddr \
 python3-packaging \
 python3-pyasn1 \
 python3-pyasn1-modules \
 python3-pyusb \
 python3-qrcode \
 python3-requests \
 python3-six \
 python3-sss-murmur \
 python3-systemd \
 python3-urllib3 \
 python3-yubico \
 "
RDEPENDS:python3-ipaserver = " \
 ipa-common \
 ipa-server-common \
 python3 \
 python3-augeas \
 python3-cryptography \
 python3-dbus \
 python3-dns \
 python3-gssapi \
 python3-idm-pki \
 python3-ipaclient \
 python3-ipalib \
 python3-jwcrypto \
 python3-kdcproxy \
 python3-ldap \
 python3-lxml \
 python3-netaddr \
 python3-psutil \
 python3-pyasn1 \
 python3-requests \
 python3-six \
 python3-sssdconfig \
 python3-urllib3 \
 rpm-libs \
 "
RDEPENDS:python3-ipatests = " \
 iptables-nft \
 openssh-clients \
 python3-cryptography \
 python3-ipaclient \
 python3-ipaserver \
 python3-sssdconfig \
 tar \
 xz \
 "
