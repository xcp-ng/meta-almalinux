# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "audacious"
PV = "4.4.2"
PR = "2.el10_0"
PACKAGES = " \
 audacious \
 audacious-devel \
 audacious-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/audacious-4.4.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "418f0374d2e17bac74bf39e99e80155b34434add400746a51ba23aee7dd7bcc2"

URI_x86_64_v2_audacious = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/audacious-4.4.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_audacious;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audacious}"
SRC_URI[x86_64_v2_audacious.sha256sum] = "abdcc74962d2fbd85e066634c5edf235fdb51722d4761732a547f4b37e6f7986"

URI_x86_64_v2_audacious-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/audacious-devel-4.4.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_audacious-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audacious-devel}"
SRC_URI[x86_64_v2_audacious-devel.sha256sum] = "0b3f65fb482c477e8ea7714eb352aaf9dc971ca1d6e593dbf6c271bad3b1e6e7"

URI_x86_64_v2_audacious-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/audacious-libs-4.4.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_audacious-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audacious-libs}"
SRC_URI[x86_64_v2_audacious-libs.sha256sum] = "3fb34adb2b6f4fd619be9751bf6a4fb83a0738546dbdde786daec93443bc7f5c"

URI_aarch64_audacious = "${EPEL_MIRROR}/aarch64/Packages/a/audacious-4.4.2-2.el10_0.aarch64.rpm;name=aarch64_audacious;unpack=0"
SRC_URI:append = " ${URI_aarch64_audacious}"
SRC_URI[aarch64_audacious.sha256sum] = "3fafe15d3083029ff43c7c18834d969654c7aa2824ed0ee6dc4b51b5b94c4854"

URI_aarch64_audacious-devel = "${EPEL_MIRROR}/aarch64/Packages/a/audacious-devel-4.4.2-2.el10_0.aarch64.rpm;name=aarch64_audacious-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_audacious-devel}"
SRC_URI[aarch64_audacious-devel.sha256sum] = "062c48061501668d2d562ac31145d6ce7847748e57576f1ccde84552e6a0326e"

URI_aarch64_audacious-libs = "${EPEL_MIRROR}/aarch64/Packages/a/audacious-libs-4.4.2-2.el10_0.aarch64.rpm;name=aarch64_audacious-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_audacious-libs}"
SRC_URI[aarch64_audacious-libs.sha256sum] = "510fd710a2e21a7b058e385d65d359257ab59bba76b580a6adfb6d00a6653b04"

RDEPENDS:audacious = " \
 audacious-libs \
 audacious-plugins \
 glib2 \
 glibc \
 hicolor-icon-theme \
 libgcc \
 libstdc++ \
 qt6-qtsvg \
 "
RDEPENDS:audacious-devel = " \
 audacious-libs \
 glib2-devel \
 gtk3-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:audacious-libs = " \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 libgcc \
 libstdc++ \
 pango \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
