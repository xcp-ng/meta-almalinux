# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdeplasma-addons"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 kate-krunner-plugin \
 kdeplasma-addons \
 kdeplasma-addons-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdeplasma-addons-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "11b71f792f059a2c469b110866c1969d3103cb38f8b3866010a2e588aecb9789"

URI_x86_64_v2_kate-krunner-plugin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kate-krunner-plugin-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kate-krunner-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kate-krunner-plugin}"
SRC_URI[x86_64_v2_kate-krunner-plugin.sha256sum] = "ffe3ff71bf3e8a5e68a913ef7c4cb143b3041bcfac00af8a4140d5e2b0257b3e"

URI_x86_64_v2_kdeplasma-addons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdeplasma-addons-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdeplasma-addons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdeplasma-addons}"
SRC_URI[x86_64_v2_kdeplasma-addons.sha256sum] = "19a6c8241dca5efac9e98b7ecf087ed31a2ad9f51ac2c744da76b4af8348d73f"

URI_x86_64_v2_kdeplasma-addons-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdeplasma-addons-devel-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdeplasma-addons-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdeplasma-addons-devel}"
SRC_URI[x86_64_v2_kdeplasma-addons-devel.sha256sum] = "aa0da5c9216113c3086cccb06f8615ee2af587aca4ff1c0cd4f0c17ba27eee65"

URI_aarch64_kate-krunner-plugin = "${EPEL_MIRROR}/aarch64/Packages/k/kate-krunner-plugin-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_kate-krunner-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_kate-krunner-plugin}"
SRC_URI[aarch64_kate-krunner-plugin.sha256sum] = "06247c1c4ddd8a608898093b9915163ed53f3fdfe3d128725b3c02aa36d77eb9"

URI_aarch64_kdeplasma-addons = "${EPEL_MIRROR}/aarch64/Packages/k/kdeplasma-addons-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_kdeplasma-addons;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdeplasma-addons}"
SRC_URI[aarch64_kdeplasma-addons.sha256sum] = "82e5877ee1b6fd609e26826f824e09957dae2758b649c9080c105539457b29cd"

URI_aarch64_kdeplasma-addons-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kdeplasma-addons-devel-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_kdeplasma-addons-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdeplasma-addons-devel}"
SRC_URI[aarch64_kdeplasma-addons-devel.sha256sum] = "1321999d461a28e053c7c797bc010fff13db68f41beeef6360a5e1fdbe47b639"

RDEPENDS:kate-krunner-plugin = " \
 glibc \
 kate \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-krunner \
 kf6-kservice \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kdeplasma-addons = " \
 glibc \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kdeclarative \
 kf6-kglobalaccel \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kpackage \
 kf6-krunner \
 kf6-kservice \
 kf6-ksvg \
 kf6-kunitconversion \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 libicu \
 libplasma \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtquick3d \
 qt6-qtwebengine \
 "
RDEPENDS:kdeplasma-addons-devel = " \
 cmake-filesystem \
 kdeplasma-addons \
 kf6-kcoreaddons-devel \
 qt6-qtbase-devel \
 "
