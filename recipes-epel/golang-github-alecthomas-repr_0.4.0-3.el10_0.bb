# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-alecthomas-repr"
PV = "0.4.0"
PR = "3.el10_0"
PACKAGES = " \
 golang-github-alecthomas-repr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-alecthomas-repr-0.4.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fcce4a3c02a3a369a43d790dc5c3c87cc70a2d75f8d470b46606dccad6dc97ee"

URI_x86_64_v2_golang-github-alecthomas-repr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-alecthomas-repr-devel-0.4.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-alecthomas-repr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-alecthomas-repr-devel}"
SRC_URI[x86_64_v2_golang-github-alecthomas-repr-devel.sha256sum] = "0cfd3c224781eb78360bcf597a03075797f815f464e65e2c23d9a5010b54f703"

URI_aarch64_golang-github-alecthomas-repr-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-alecthomas-repr-devel-0.4.0-3.el10_0.noarch.rpm;name=aarch64_golang-github-alecthomas-repr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-alecthomas-repr-devel}"
SRC_URI[aarch64_golang-github-alecthomas-repr-devel.sha256sum] = "6873545f5342ea0ac464414ee70284e500e603a256d140708214bfebbde851e1"

RDEPENDS:golang-github-alecthomas-repr-devel = " \
 go-filesystem \
 "
