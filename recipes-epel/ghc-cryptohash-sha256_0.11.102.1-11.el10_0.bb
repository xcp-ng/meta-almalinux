# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-cryptohash-sha256"
PV = "0.11.102.1"
PR = "11.el10_0"
PACKAGES = " \
 ghc-cryptohash-sha256 \
 ghc-cryptohash-sha256-devel \
 ghc-cryptohash-sha256-doc \
 ghc-cryptohash-sha256-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-cryptohash-sha256-0.11.102.1-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "015c4bb731963510c6a2e8b63be5cbe459b5499308e8d579b3159e71f9a5b0a2"

URI_x86_64_v2_ghc-cryptohash-sha256 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cryptohash-sha256-0.11.102.1-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cryptohash-sha256;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cryptohash-sha256}"
SRC_URI[x86_64_v2_ghc-cryptohash-sha256.sha256sum] = "cee7fa849ffaf23d17208a4f7c1b5104bdfbcbbe7fbb7975703534bde805a71e"

URI_x86_64_v2_ghc-cryptohash-sha256-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cryptohash-sha256-devel-0.11.102.1-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cryptohash-sha256-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cryptohash-sha256-devel}"
SRC_URI[x86_64_v2_ghc-cryptohash-sha256-devel.sha256sum] = "79fc9c079eddafa7cfc09345a6da572c55e7e78adb9bcf70117ba73672084408"

URI_x86_64_v2_ghc-cryptohash-sha256-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cryptohash-sha256-doc-0.11.102.1-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-cryptohash-sha256-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cryptohash-sha256-doc}"
SRC_URI[x86_64_v2_ghc-cryptohash-sha256-doc.sha256sum] = "4c1f2652c0838ce7a10d4217c040ab7de495a32dd0c50672042d05f4387ee7ec"

URI_x86_64_v2_ghc-cryptohash-sha256-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cryptohash-sha256-prof-0.11.102.1-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cryptohash-sha256-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cryptohash-sha256-prof}"
SRC_URI[x86_64_v2_ghc-cryptohash-sha256-prof.sha256sum] = "b5c041afd2d1e1e426eceb9e7d582172ca5bf6a164093e7dbbcfbc6683905b77"

URI_aarch64_ghc-cryptohash-sha256 = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cryptohash-sha256-0.11.102.1-11.el10_0.aarch64.rpm;name=aarch64_ghc-cryptohash-sha256;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cryptohash-sha256}"
SRC_URI[aarch64_ghc-cryptohash-sha256.sha256sum] = "d30a5a38241629988cab2d04f97dade96b31683236dd92e10ad24f6a6df00fc7"

URI_aarch64_ghc-cryptohash-sha256-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cryptohash-sha256-devel-0.11.102.1-11.el10_0.aarch64.rpm;name=aarch64_ghc-cryptohash-sha256-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cryptohash-sha256-devel}"
SRC_URI[aarch64_ghc-cryptohash-sha256-devel.sha256sum] = "1752e2d43c01f5bae852b4725f5c8337276bf1d562a6d8762a3fbc89fb02569f"

URI_aarch64_ghc-cryptohash-sha256-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cryptohash-sha256-doc-0.11.102.1-11.el10_0.noarch.rpm;name=aarch64_ghc-cryptohash-sha256-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cryptohash-sha256-doc}"
SRC_URI[aarch64_ghc-cryptohash-sha256-doc.sha256sum] = "2e25764204eaf6f85f5f398f7bd9150c33f099058889f222dccdfce7b03f5c1d"

URI_aarch64_ghc-cryptohash-sha256-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cryptohash-sha256-prof-0.11.102.1-11.el10_0.aarch64.rpm;name=aarch64_ghc-cryptohash-sha256-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cryptohash-sha256-prof}"
SRC_URI[aarch64_ghc-cryptohash-sha256-prof.sha256sum] = "80adc0c2b3ab85eca9bd70a9e510e173f7022ffc258c1230a5e5791273a79346"

RDEPENDS:ghc-cryptohash-sha256 = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-cryptohash-sha256-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-cryptohash-sha256 \
 "
RDEPENDS:ghc-cryptohash-sha256-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-cryptohash-sha256-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-cryptohash-sha256-devel \
 "
