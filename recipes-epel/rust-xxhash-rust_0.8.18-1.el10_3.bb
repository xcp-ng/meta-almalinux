# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-xxhash-rust"
PV = "0.8.18"
PR = "1.el10_3"
PACKAGES = " \
 rust-xxhash-rust+const_xxh3-devel \
 rust-xxhash-rust+const_xxh32-devel \
 rust-xxhash-rust+const_xxh64-devel \
 rust-xxhash-rust+default-devel \
 rust-xxhash-rust+std-devel \
 rust-xxhash-rust+xxh3-devel \
 rust-xxhash-rust+xxh32-devel \
 rust-xxhash-rust+xxh64-devel \
 rust-xxhash-rust-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-xxhash-rust-0.8.18-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fbaa2fe58bbcc1883c84338bd8fe157428cc815bf1d13458a133fa9886e3e4d2"

URI_x86_64_v2_rust-xxhash-rust+const_xxh3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xxhash-rust+const_xxh3-devel-0.8.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xxhash-rust+const_xxh3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xxhash-rust+const_xxh3-devel}"
SRC_URI[x86_64_v2_rust-xxhash-rust+const_xxh3-devel.sha256sum] = "c761e24ecbb2a4ee11bb4e9ff462e79f805ff4388be4a5a2970e5b0142ad28a1"

URI_x86_64_v2_rust-xxhash-rust+const_xxh32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xxhash-rust+const_xxh32-devel-0.8.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xxhash-rust+const_xxh32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xxhash-rust+const_xxh32-devel}"
SRC_URI[x86_64_v2_rust-xxhash-rust+const_xxh32-devel.sha256sum] = "8b97c55f8cabf6a98983b8e34bc9a207d83cf453450fd1f7b173a273db77f150"

URI_x86_64_v2_rust-xxhash-rust+const_xxh64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xxhash-rust+const_xxh64-devel-0.8.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xxhash-rust+const_xxh64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xxhash-rust+const_xxh64-devel}"
SRC_URI[x86_64_v2_rust-xxhash-rust+const_xxh64-devel.sha256sum] = "a6a04275a374785cc31f8c4976455fbf860ea62aee0493e5d2d9d8f4f0387d88"

URI_x86_64_v2_rust-xxhash-rust+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xxhash-rust+default-devel-0.8.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xxhash-rust+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xxhash-rust+default-devel}"
SRC_URI[x86_64_v2_rust-xxhash-rust+default-devel.sha256sum] = "bda3f0eb94d15d5e38a62c178591553045cb9da6e915ddc55a6608dc18240384"

URI_x86_64_v2_rust-xxhash-rust+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xxhash-rust+std-devel-0.8.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xxhash-rust+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xxhash-rust+std-devel}"
SRC_URI[x86_64_v2_rust-xxhash-rust+std-devel.sha256sum] = "1e37eddb99f2e69658ca7b0907841fa78411c835151169702ca6aacb5ff63181"

URI_x86_64_v2_rust-xxhash-rust+xxh3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xxhash-rust+xxh3-devel-0.8.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xxhash-rust+xxh3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xxhash-rust+xxh3-devel}"
SRC_URI[x86_64_v2_rust-xxhash-rust+xxh3-devel.sha256sum] = "eab4050d37606531b7df81fb6b95440aa3d5743270f1cbc627c868eb945df079"

URI_x86_64_v2_rust-xxhash-rust+xxh32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xxhash-rust+xxh32-devel-0.8.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xxhash-rust+xxh32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xxhash-rust+xxh32-devel}"
SRC_URI[x86_64_v2_rust-xxhash-rust+xxh32-devel.sha256sum] = "e98d52611351c880486109d058f228e4049a94d6efd366bee437739d929c644b"

URI_x86_64_v2_rust-xxhash-rust+xxh64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xxhash-rust+xxh64-devel-0.8.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xxhash-rust+xxh64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xxhash-rust+xxh64-devel}"
SRC_URI[x86_64_v2_rust-xxhash-rust+xxh64-devel.sha256sum] = "5b376cd5c93bdc33525de6a2e8cecab2e37f9f3f316ff2084220b465b2acf3c9"

URI_x86_64_v2_rust-xxhash-rust-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xxhash-rust-devel-0.8.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xxhash-rust-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xxhash-rust-devel}"
SRC_URI[x86_64_v2_rust-xxhash-rust-devel.sha256sum] = "3b2c502e56846832f6b787c2c0f7d6d56be661d01621d1caf1994fd3138bfa27"

URI_aarch64_rust-xxhash-rust+const_xxh3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xxhash-rust+const_xxh3-devel-0.8.18-1.el10_3.noarch.rpm;name=aarch64_rust-xxhash-rust+const_xxh3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xxhash-rust+const_xxh3-devel}"
SRC_URI[aarch64_rust-xxhash-rust+const_xxh3-devel.sha256sum] = "f9c02e30930b051fb5368c99fda0770ddf0da38354d1b0dbd0b1da8d30b2579d"

URI_aarch64_rust-xxhash-rust+const_xxh32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xxhash-rust+const_xxh32-devel-0.8.18-1.el10_3.noarch.rpm;name=aarch64_rust-xxhash-rust+const_xxh32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xxhash-rust+const_xxh32-devel}"
SRC_URI[aarch64_rust-xxhash-rust+const_xxh32-devel.sha256sum] = "74e09e419abdd000e9b487566b5719d054ad4fc0ffea648ac47ad5b4274fe68a"

URI_aarch64_rust-xxhash-rust+const_xxh64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xxhash-rust+const_xxh64-devel-0.8.18-1.el10_3.noarch.rpm;name=aarch64_rust-xxhash-rust+const_xxh64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xxhash-rust+const_xxh64-devel}"
SRC_URI[aarch64_rust-xxhash-rust+const_xxh64-devel.sha256sum] = "96ca53d5c0baf9c343b21c423ac71f838a593e16cfb3411a5008bd9ca431a30c"

URI_aarch64_rust-xxhash-rust+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xxhash-rust+default-devel-0.8.18-1.el10_3.noarch.rpm;name=aarch64_rust-xxhash-rust+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xxhash-rust+default-devel}"
SRC_URI[aarch64_rust-xxhash-rust+default-devel.sha256sum] = "c4d301e98524727a1cfa7f48751c4e34f0109e75567ee8fed8a3f9f5f5f7f5b7"

URI_aarch64_rust-xxhash-rust+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xxhash-rust+std-devel-0.8.18-1.el10_3.noarch.rpm;name=aarch64_rust-xxhash-rust+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xxhash-rust+std-devel}"
SRC_URI[aarch64_rust-xxhash-rust+std-devel.sha256sum] = "7c920acc273f7308c2042dfab37f0084ae1eaa22c055df37ec56e7b17b71347e"

URI_aarch64_rust-xxhash-rust+xxh3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xxhash-rust+xxh3-devel-0.8.18-1.el10_3.noarch.rpm;name=aarch64_rust-xxhash-rust+xxh3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xxhash-rust+xxh3-devel}"
SRC_URI[aarch64_rust-xxhash-rust+xxh3-devel.sha256sum] = "a9fe3c0abc7fd77d6227fff0071f0373731b38e63dd02f57c8eb58723e084d4c"

URI_aarch64_rust-xxhash-rust+xxh32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xxhash-rust+xxh32-devel-0.8.18-1.el10_3.noarch.rpm;name=aarch64_rust-xxhash-rust+xxh32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xxhash-rust+xxh32-devel}"
SRC_URI[aarch64_rust-xxhash-rust+xxh32-devel.sha256sum] = "77705c7017af534ee40da147eb95c7b72f2e554e3388da34edea3c77b53562a1"

URI_aarch64_rust-xxhash-rust+xxh64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xxhash-rust+xxh64-devel-0.8.18-1.el10_3.noarch.rpm;name=aarch64_rust-xxhash-rust+xxh64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xxhash-rust+xxh64-devel}"
SRC_URI[aarch64_rust-xxhash-rust+xxh64-devel.sha256sum] = "2776d601e699f6cf473e199c6eea7f1d94a1c46b7aeed8ae70fc949aa6d0d747"

URI_aarch64_rust-xxhash-rust-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xxhash-rust-devel-0.8.18-1.el10_3.noarch.rpm;name=aarch64_rust-xxhash-rust-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xxhash-rust-devel}"
SRC_URI[aarch64_rust-xxhash-rust-devel.sha256sum] = "2c70b7c66121dac23972a7c70bfccc7f9a725f7bedf6db7885431e88fce0578e"

RDEPENDS:rust-xxhash-rust+const_xxh3-devel = " \
 cargo \
 rust-xxhash-rust-devel \
 "
RDEPENDS:rust-xxhash-rust+const_xxh32-devel = " \
 cargo \
 rust-xxhash-rust-devel \
 "
RDEPENDS:rust-xxhash-rust+const_xxh64-devel = " \
 cargo \
 rust-xxhash-rust-devel \
 "
RDEPENDS:rust-xxhash-rust+default-devel = " \
 cargo \
 rust-xxhash-rust-devel \
 "
RDEPENDS:rust-xxhash-rust+std-devel = " \
 cargo \
 rust-xxhash-rust-devel \
 "
RDEPENDS:rust-xxhash-rust+xxh3-devel = " \
 cargo \
 rust-xxhash-rust-devel \
 "
RDEPENDS:rust-xxhash-rust+xxh32-devel = " \
 cargo \
 rust-xxhash-rust-devel \
 "
RDEPENDS:rust-xxhash-rust+xxh64-devel = " \
 cargo \
 rust-xxhash-rust-devel \
 "
RDEPENDS:rust-xxhash-rust-devel = " \
 cargo \
 "
