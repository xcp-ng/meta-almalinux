# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sse2neon"
PV = "1.8.0"
PR = "3.el10_1"
PACKAGES:x86_64_v2 = " \
  \
"
PACKAGES:aarch64 = " \
 sse2neon-devel \
"

URI_src = "${EPELSRC_MIRROR}/Packages/s/sse2neon-1.8.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3b354f04a2d1b7670d95e300938d2060ec5226c8ff3d6607f71b69296610fbe"

URI_aarch64_sse2neon-devel = "${EPEL_MIRROR}/aarch64/Packages/s/sse2neon-devel-1.8.0-3.el10_1.aarch64.rpm;name=aarch64_sse2neon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sse2neon-devel}"
SRC_URI[aarch64_sse2neon-devel.sha256sum] = "348e249dacd62e2b1838cb7d8406a509d4a75e4d9dbfd6ac0df5021b89af3c00"

RDEPENDS:sse2neon-devel = " \
 "
