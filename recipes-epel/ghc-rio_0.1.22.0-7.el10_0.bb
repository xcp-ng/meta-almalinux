# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-rio"
PV = "0.1.22.0"
PR = "7.el10_0"
PACKAGES = " \
 ghc-rio \
 ghc-rio-devel \
 ghc-rio-doc \
 ghc-rio-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-rio-0.1.22.0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74915a35f5f3a12497dae042f7b175fcb55f3eeeab05ad728601452b0effa4a5"

URI_x86_64_v2_ghc-rio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-rio-0.1.22.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-rio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-rio}"
SRC_URI[x86_64_v2_ghc-rio.sha256sum] = "8494a32a2a09d2c9fbb19a8a56ade2d12f942383d1f28b3875eb6ed5d6b6b396"

URI_x86_64_v2_ghc-rio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-rio-devel-0.1.22.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-rio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-rio-devel}"
SRC_URI[x86_64_v2_ghc-rio-devel.sha256sum] = "c1ebca7b8e0fae4e2ae86dc0a0224a1196521aa9586ff57fb2a851346d0a401c"

URI_x86_64_v2_ghc-rio-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-rio-doc-0.1.22.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-rio-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-rio-doc}"
SRC_URI[x86_64_v2_ghc-rio-doc.sha256sum] = "42321db275f60bc364ae74200ec49edf6ee40471b24cdcb023c4ac147f893393"

URI_x86_64_v2_ghc-rio-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-rio-prof-0.1.22.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-rio-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-rio-prof}"
SRC_URI[x86_64_v2_ghc-rio-prof.sha256sum] = "d89562a581070876ea76fd9707bb6ec79b20a708becf55ce7a2e9194f65df3a9"

URI_aarch64_ghc-rio = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-rio-0.1.22.0-7.el10_0.aarch64.rpm;name=aarch64_ghc-rio;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-rio}"
SRC_URI[aarch64_ghc-rio.sha256sum] = "93f7e3dc1e5b3875bc88ef778117331e641e1c654107cd50efa1526ffc577510"

URI_aarch64_ghc-rio-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-rio-devel-0.1.22.0-7.el10_0.aarch64.rpm;name=aarch64_ghc-rio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-rio-devel}"
SRC_URI[aarch64_ghc-rio-devel.sha256sum] = "09a829a647d1d07d4c2cd49115bf0d48c7905e1366ceb3686b8865545b0251c0"

URI_aarch64_ghc-rio-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-rio-doc-0.1.22.0-7.el10_0.noarch.rpm;name=aarch64_ghc-rio-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-rio-doc}"
SRC_URI[aarch64_ghc-rio-doc.sha256sum] = "3baab1021f79263eb7f2e63eb5ea2efdf1af85bab57da161fd0476eae2309726"

URI_aarch64_ghc-rio-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-rio-prof-0.1.22.0-7.el10_0.aarch64.rpm;name=aarch64_ghc-rio-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-rio-prof}"
SRC_URI[aarch64_ghc-rio-prof.sha256sum] = "2f08131be558c39a8d0984bc800b1f07ef6d7bd0b65cc4b712231f6fea09ccde"

RDEPENDS:ghc-rio = " \
 ghc-array \
 ghc-async \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-microlens \
 ghc-microlens-mtl \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-safe-exceptions \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-unix \
 ghc-unliftio \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-vector \
 ghc-vector-stream \
 glibc \
 gmp \
 "
RDEPENDS:ghc-rio-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-deepseq-devel \
 ghc-directory-devel \
 ghc-exceptions-devel \
 ghc-filepath-devel \
 ghc-hashable-devel \
 ghc-microlens-devel \
 ghc-microlens-mtl-devel \
 ghc-mtl-devel \
 ghc-primitive-devel \
 ghc-process-devel \
 ghc-rio \
 ghc-text-devel \
 ghc-time-devel \
 ghc-typed-process-devel \
 ghc-unix-devel \
 ghc-unliftio-core-devel \
 ghc-unliftio-devel \
 ghc-unordered-containers-devel \
 ghc-vector-devel \
 "
RDEPENDS:ghc-rio-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-rio-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-deepseq-prof \
 ghc-directory-prof \
 ghc-exceptions-prof \
 ghc-filepath-prof \
 ghc-hashable-prof \
 ghc-microlens-mtl-prof \
 ghc-microlens-prof \
 ghc-mtl-prof \
 ghc-primitive-prof \
 ghc-process-prof \
 ghc-rio-devel \
 ghc-text-prof \
 ghc-time-prof \
 ghc-typed-process-prof \
 ghc-unix-prof \
 ghc-unliftio-core-prof \
 ghc-unliftio-prof \
 ghc-unordered-containers-prof \
 ghc-vector-prof \
 "
