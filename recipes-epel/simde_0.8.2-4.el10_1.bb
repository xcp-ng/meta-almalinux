# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "simde"
PV = "0.8.2"
PR = "4.el10_1"
PACKAGES = " \
 simde-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/simde-0.8.2-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c42c69bb8b661387889c1a0db75f3e0b3b939b05fa12a989dcb63b074799194"

URI_x86_64_v2_simde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/simde-devel-0.8.2-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_simde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_simde-devel}"
SRC_URI[x86_64_v2_simde-devel.sha256sum] = "be3855bce5a165f497e8ea6cf1fb8ba22b936fd40433078fac3a35b464fc069c"

URI_aarch64_simde-devel = "${EPEL_MIRROR}/aarch64/Packages/s/simde-devel-0.8.2-4.el10_1.noarch.rpm;name=aarch64_simde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_simde-devel}"
SRC_URI[aarch64_simde-devel.sha256sum] = "9107778b16c0dec60fba62757d859aba4884eb084f71aa205d80048cfedffe15"

RDEPENDS:simde-devel = " \
 hedley-devel \
 "
