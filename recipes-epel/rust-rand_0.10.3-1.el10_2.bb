# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand"
PV = "0.10.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-rand+alloc-devel \
 rust-rand+chacha-devel \
 rust-rand+default-devel \
 rust-rand+log-devel \
 rust-rand+serde-devel \
 rust-rand+std-devel \
 rust-rand+std_rng-devel \
 rust-rand+sys_rng-devel \
 rust-rand+thread_rng-devel \
 rust-rand+unbiased-devel \
 rust-rand-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-rand-0.10.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3ab63dbec7755c3a7853d476f75d500189cd5bcf46d4a8fcda4a7da8563d3e70"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+alloc-devel-0.10.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand+alloc-devel.sha256sum] = "c011fe12048c705761095827c7e181cd4e6c50e0a8d7538f7b206b87a4e79840"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+chacha-devel-0.10.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+chacha-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand+chacha-devel.sha256sum] = "2353579bd30529809e6baa17de06881db0cd1f7c9ac83c3d715848bb91ac26f8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+default-devel-0.10.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand+default-devel.sha256sum] = "2a5e779d583229f73a3503a4200e83f4ef37080d315e28d71f12ae5051e3ca71"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+log-devel-0.10.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+log-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand+log-devel.sha256sum] = "528cef850461307b20add1010eb6618ffdd944df255f90260aa5405ca06a4ae7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+serde-devel-0.10.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand+serde-devel.sha256sum] = "f3f0069911bdf252ee8896f53ec6ae4325cd03199320cae122843ee462893036"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+std-devel-0.10.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand+std-devel.sha256sum] = "84ee030faf8f66509394d76d64eff7e35661071bb3d36c330335316287d21d8d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+std_rng-devel-0.10.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+std_rng-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand+std_rng-devel.sha256sum] = "93cd60ab926d8d3d670a7acd11d4bc2075da117faff0c0183fec6e5845d6ec27"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+sys_rng-devel-0.10.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+sys_rng-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand+sys_rng-devel.sha256sum] = "edb0f59c08789c42b023c82f06b3140b81d128d6b044c9d41cdbe8962fc364e1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+thread_rng-devel-0.10.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+thread_rng-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand+thread_rng-devel.sha256sum] = "c111ba0dff60b12a4d64d73668f2eaceb308aaf6b0ff7b065bee972aa48f5d8d"
RPROVIDES:rust-rand+thread_rng-devel:append:x86_64_v2 = " virtual/crate_rand/thread_rng__ge_0.9.0_with_crate_rand/thread_rng__le_0.11.0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+unbiased-devel-0.10.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+unbiased-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand+unbiased-devel.sha256sum] = "f6040413723c22d2543158744d9519d590936d22a724fd54b4d9d50c830d668e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand-devel-0.10.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand-devel.sha256sum] = "cf7084a7392be4db461093a6c0da8bc172b9bbcd3f18b7b7fd9688fbb36f1139"
RPROVIDES:rust-rand-devel:append:x86_64_v2 = " virtual/crate_rand__ge_0.9.0_with_crate_rand__le_0.11.0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+alloc-devel-0.10.3-1.el10_2.noarch.rpm;name=aarch64_rust-rand+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-rand+alloc-devel.sha256sum] = "551f755b8b073be9d51e028877007a0329f0e4292fe012fcf86f47c4cf830271"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+chacha-devel-0.10.3-1.el10_2.noarch.rpm;name=aarch64_rust-rand+chacha-devel;unpack=0"
SRC_URI[aarch64_rust-rand+chacha-devel.sha256sum] = "f7a1ea69bcffee3f7366370b541828ac68d32c0067ad3d90c0fc14e67997f2ad"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+default-devel-0.10.3-1.el10_2.noarch.rpm;name=aarch64_rust-rand+default-devel;unpack=0"
SRC_URI[aarch64_rust-rand+default-devel.sha256sum] = "3a130f63aef6aaaaeeda8ce2a520ae1d0ef2cacf74f454e5729e99e06cd6501b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+log-devel-0.10.3-1.el10_2.noarch.rpm;name=aarch64_rust-rand+log-devel;unpack=0"
SRC_URI[aarch64_rust-rand+log-devel.sha256sum] = "754179f71ad9874773740b425ee65673c6a515426fb8c6e1cf92dbe947b22eb4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+serde-devel-0.10.3-1.el10_2.noarch.rpm;name=aarch64_rust-rand+serde-devel;unpack=0"
SRC_URI[aarch64_rust-rand+serde-devel.sha256sum] = "ee84b4e67877a42b9f4f157b5a47ada4948f30ef1410bd2afa60e2878908f1f1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+std-devel-0.10.3-1.el10_2.noarch.rpm;name=aarch64_rust-rand+std-devel;unpack=0"
SRC_URI[aarch64_rust-rand+std-devel.sha256sum] = "362543f55fddda705e8926323c00c44628e757441d41f115bae12c0d10fab389"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+std_rng-devel-0.10.3-1.el10_2.noarch.rpm;name=aarch64_rust-rand+std_rng-devel;unpack=0"
SRC_URI[aarch64_rust-rand+std_rng-devel.sha256sum] = "f55b1d7745b43aa10352e160582a62f80a5b813aa3b600fc81d15d7431f8c505"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+sys_rng-devel-0.10.3-1.el10_2.noarch.rpm;name=aarch64_rust-rand+sys_rng-devel;unpack=0"
SRC_URI[aarch64_rust-rand+sys_rng-devel.sha256sum] = "aae40c7e3971cd972e2910dcd8e4e0d3d5dcf248de1ce32e32ea169060b72f18"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+thread_rng-devel-0.10.3-1.el10_2.noarch.rpm;name=aarch64_rust-rand+thread_rng-devel;unpack=0"
SRC_URI[aarch64_rust-rand+thread_rng-devel.sha256sum] = "21457afdce6bdecfc28a1130891ac9e97d9fe2d4efddae158c494e8ca4ded4ac"
RPROVIDES:rust-rand+thread_rng-devel:append:aarch64 = " virtual/crate_rand/thread_rng__ge_0.9.0_with_crate_rand/thread_rng__le_0.11.0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+unbiased-devel-0.10.3-1.el10_2.noarch.rpm;name=aarch64_rust-rand+unbiased-devel;unpack=0"
SRC_URI[aarch64_rust-rand+unbiased-devel.sha256sum] = "29aa0786b38430891061cc91a67ecd397ff34b781ef29018e4b1acf9aef6a9cf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand-devel-0.10.3-1.el10_2.noarch.rpm;name=aarch64_rust-rand-devel;unpack=0"
SRC_URI[aarch64_rust-rand-devel.sha256sum] = "d1f417b892b17ccf4c1da913ccc24c3ff9a18dadad701279f954f6aa3b3d9db6"
RPROVIDES:rust-rand-devel:append:aarch64 = " virtual/crate_rand__ge_0.9.0_with_crate_rand__le_0.11.0"

RDEPENDS:rust-rand+alloc-devel = " \
 cargo \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+chacha-devel = " \
 cargo \
 rust-chacha20+rng-devel \
 rust-chacha20-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+default-devel = " \
 cargo \
 rust-rand+std-devel \
 rust-rand+std_rng-devel \
 rust-rand+sys_rng-devel \
 rust-rand+thread_rng-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+log-devel = " \
 cargo \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+serde-devel = " \
 cargo \
 rust-rand-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand+std-devel = " \
 cargo \
 rust-getrandom+default-devel \
 rust-getrandom+std-devel \
 rust-rand+alloc-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+std_rng-devel = " \
 cargo \
 rust-chacha20+rng-devel \
 rust-chacha20-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+sys_rng-devel = " \
 cargo \
 rust-getrandom+default-devel \
 rust-getrandom+sys_rng-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+thread_rng-devel = " \
 cargo \
 rust-rand+std-devel \
 rust-rand+std_rng-devel \
 rust-rand+sys_rng-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+unbiased-devel = " \
 cargo \
 rust-rand-devel \
 "
RDEPENDS:rust-rand-devel = " \
 cargo \
 rust \
 rust-rand_core-devel \
 "
