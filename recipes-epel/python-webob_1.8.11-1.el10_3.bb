# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-webob"
PV = "1.8.11"
PR = "1.el10_3"
PACKAGES = " \
 python3-webob \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-webob-1.8.11-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c17d8877d967f3ce16a632638812e0e4195c3a3f5d8b970c68ad26de72b6150f"

URI_x86_64_v2_python3-webob = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-webob-1.8.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-webob;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-webob}"
SRC_URI[x86_64_v2_python3-webob.sha256sum] = "9123baa611d4f987fed3b387f188c3102cb1e018676964ec232d97eeae0be16f"

URI_aarch64_python3-webob = "${EPEL_MIRROR}/aarch64/Packages/p/python3-webob-1.8.11-1.el10_3.noarch.rpm;name=aarch64_python3-webob;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-webob}"
SRC_URI[aarch64_python3-webob.sha256sum] = "e11b0966ae9302087f624529f6afde712805faf8dcdc3bcdc054962961577be4"

RDEPENDS:python3-webob = " \
 python3 \
 "
