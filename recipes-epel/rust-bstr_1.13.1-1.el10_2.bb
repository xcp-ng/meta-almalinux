# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bstr"
PV = "1.13.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-bstr+alloc-devel \
 rust-bstr+default-devel \
 rust-bstr+serde-devel \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-bstr-1.13.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bc9ff3d1b4b876363de109ed13b1ffb02b8bfa3bcfc235a7dc167089b808b008"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr+alloc-devel-1.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bstr+alloc-devel.sha256sum] = "62d26dc6672fc6ad54e518da04b8b8e40d0842be72ca0ebc746725fa34c5e307"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr+default-devel-1.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bstr+default-devel.sha256sum] = "6948f9f0ef23d36c07fcd8e2596abf4c064b8411e3304f4bb0e052ac98b7d540"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr+serde-devel-1.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bstr+serde-devel.sha256sum] = "a9fc742e65880e0dcfc473929e1838a38aea9dd9fb6d908c3f1063fd73fef8e2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr+std-devel-1.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bstr+std-devel.sha256sum] = "4ea98fd7d95f38913485a17b58ca0d994f6bc308be88a62c8e1eb6328f415d68"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr+unicode-devel-1.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr+unicode-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bstr+unicode-devel.sha256sum] = "f635fd7c3e59a47f0c7551c4ef79d9a4e01b8f24066103cec10fdfe2fb47bd70"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr-devel-1.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bstr-devel.sha256sum] = "14d2896f38cbda2ba1bec89d79f3bd9bcce9e6a941a0fd26a573f8bd383f2a63"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr+alloc-devel-1.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-bstr+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-bstr+alloc-devel.sha256sum] = "1b8dd264c3265b25f245c024f663ef200ac0fe6b5ad10ae6801d4c8cfdc1ac4c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr+default-devel-1.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-bstr+default-devel;unpack=0"
SRC_URI[aarch64_rust-bstr+default-devel.sha256sum] = "d007bdda8dbd8a3a45c768db962d8cb11d95ffb06e5a90ba66b26ef0894d7a86"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr+serde-devel-1.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-bstr+serde-devel;unpack=0"
SRC_URI[aarch64_rust-bstr+serde-devel.sha256sum] = "abe768d66092d9414100eae3a114d1d73a956effec6e121e35d18109dfb811a8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr+std-devel-1.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-bstr+std-devel;unpack=0"
SRC_URI[aarch64_rust-bstr+std-devel.sha256sum] = "d850f897e3cc5c01a33bd2174881e292bd7436b15d07902ed5efda03b9cc6f68"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr+unicode-devel-1.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-bstr+unicode-devel;unpack=0"
SRC_URI[aarch64_rust-bstr+unicode-devel.sha256sum] = "6879eab939918c5bc1e733acc8bf3b1bceff504d9d075b9d60808cdd5feccbe6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr-devel-1.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-bstr-devel;unpack=0"
SRC_URI[aarch64_rust-bstr-devel.sha256sum] = "e40b0d58738d42b84334d87de71751404c23a0e061fabe220905cae081da9e49"

RDEPENDS:rust-bstr+alloc-devel = " \
 cargo \
 rust-bstr-devel \
 rust-memchr+alloc-devel \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-bstr+default-devel = " \
 cargo \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 "
RDEPENDS:rust-bstr+serde-devel = " \
 cargo \
 rust-bstr-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-bstr+std-devel = " \
 cargo \
 rust-bstr+alloc-devel \
 rust-bstr-devel \
 rust-memchr+std-devel \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-bstr+unicode-devel = " \
 cargo \
 rust-bstr-devel \
 rust-regex-automata+dfa-search-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-bstr-devel = " \
 cargo \
 rust \
 rust-memchr-devel \
 "
