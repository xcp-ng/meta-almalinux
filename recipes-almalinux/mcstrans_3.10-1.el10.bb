# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mcstrans"
PV = "3.10"
PR = "1.el10"
PACKAGES = " \
 mcstrans \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/mcstrans-3.10-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15613b68911b74ac6f755eb013f308af7fb45650100531982bfa90f1615d605a"

URI_x86_64_v2_mcstrans = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mcstrans-3.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_mcstrans;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mcstrans}"
SRC_URI[x86_64_v2_mcstrans.sha256sum] = "807a5ce4e67e6838d98059c878255382bf5b5f1711ec65c0018c043c4ed53d78"

URI_aarch64_mcstrans = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mcstrans-3.10-1.el10.aarch64.rpm;name=aarch64_mcstrans;unpack=0"
SRC_URI:append = " ${URI_aarch64_mcstrans}"
SRC_URI[aarch64_mcstrans.sha256sum] = "849d7e0466e24012c3287e11fafce7d0d8f7e247ac22d7b2d8ac6b16f379e743"

RDEPENDS:mcstrans = " \
 bash \
 glibc \
 libcap \
 libselinux \
 pcre2 \
 systemd \
 "
