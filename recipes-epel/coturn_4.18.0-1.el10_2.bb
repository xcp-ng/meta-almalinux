# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "coturn"
PV = "4.18.0"
PR = "1.el10_2"
PACKAGES = " \
 coturn \
 coturn-client-devel \
 coturn-client-libs \
 coturn-utils \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/coturn-4.18.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f9710c57a09a01610aae01b2190f5ca2ee03deb9df908a1f84dc45b0c2d0d49d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/coturn-4.18.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_coturn;unpack=0"
SRC_URI[x86_64_v2_coturn.sha256sum] = "08fb83da89c8ad63ca7a601c6485b572d89a4ce854a2cea2121c47ad0c5779b6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/coturn-client-devel-4.18.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_coturn-client-devel;unpack=0"
SRC_URI[x86_64_v2_coturn-client-devel.sha256sum] = "42589a8a906432692809d2c593cfd5cdaf6f48a3c12c87673ba8050ccf5aa2bd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/coturn-client-libs-4.18.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_coturn-client-libs;unpack=0"
SRC_URI[x86_64_v2_coturn-client-libs.sha256sum] = "5e25162ed64227a746d693fcd880cd16c2704615e038d999ea97f602939c2f33"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/coturn-utils-4.18.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_coturn-utils;unpack=0"
SRC_URI[x86_64_v2_coturn-utils.sha256sum] = "a3688b79236f79e9f22e51b68e1aedca967f73faf4fce8e25a91871b7e034db7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/coturn-4.18.0-1.el10_2.aarch64.rpm;name=aarch64_coturn;unpack=0"
SRC_URI[aarch64_coturn.sha256sum] = "3580776e8cd0c20e0453021ba9c60a5b1f4e9875a6172be01c07827d7fb91d59"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/coturn-client-devel-4.18.0-1.el10_2.aarch64.rpm;name=aarch64_coturn-client-devel;unpack=0"
SRC_URI[aarch64_coturn-client-devel.sha256sum] = "01d120aea512a85becb7878d4e8fe3047c3e7ddb0c468c6ba181696f2d635cd7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/coturn-client-libs-4.18.0-1.el10_2.aarch64.rpm;name=aarch64_coturn-client-libs;unpack=0"
SRC_URI[aarch64_coturn-client-libs.sha256sum] = "e54d6dfe7bb219e0cb18676a78bdd3aff93a0d88448801807f5c8b5e8a97d319"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/coturn-utils-4.18.0-1.el10_2.aarch64.rpm;name=aarch64_coturn-utils;unpack=0"
SRC_URI[aarch64_coturn-utils.sha256sum] = "241603904e5f0429551f7fb928dccf46ae34bc32830439368a5581641671aa81"

RDEPENDS:coturn = " \
 bash \
 glibc \
 hiredis \
 libevent \
 libmicrohttpd \
 libpq \
 mariadb-connector-c \
 openssl-libs \
 shadow-utils \
 sqlite-libs \
 systemd \
 systemd-libs \
 "
RDEPENDS:coturn-client-devel = " \
 "
RDEPENDS:coturn-client-libs = " \
 "
RDEPENDS:coturn-utils = " \
 glibc \
 libevent \
 openssl-libs \
 "
