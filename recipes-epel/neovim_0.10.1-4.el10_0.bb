# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "neovim"
PV = "0.10.1"
PR = "4.el10_0"
PACKAGES = " \
 neovim \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/neovim-0.10.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d96af4c8ff3e542c536de75d9139d8c0c0264a7998eb278e5f4d28e69bc73784"

URI_x86_64_v2_neovim = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/neovim-0.10.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_neovim;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_neovim}"
SRC_URI[x86_64_v2_neovim.sha256sum] = "e9e316718c7988f9d59230823b3c203efabda81c5900dabdcbfa919e6efdbb3e"

URI_aarch64_neovim = "${EPEL_MIRROR}/aarch64/Packages/n/neovim-0.10.1-4.el10_0.aarch64.rpm;name=aarch64_neovim;unpack=0"
SRC_URI:append = " ${URI_aarch64_neovim}"
SRC_URI[aarch64_neovim.sha256sum] = "3caef3ec82c5612f8ec6a76cdc7da203834b453a03625fe865c5035fb7333428"

RDEPENDS:neovim = " \
 bash \
 glibc \
 libluv \
 libuv \
 libvterm \
 lua5.1-lpeg \
 luajit \
 luajit2.1-luv \
 msgpack \
 unibilium \
 "
