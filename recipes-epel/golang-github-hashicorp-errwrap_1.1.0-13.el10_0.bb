# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-hashicorp-errwrap"
PV = "1.1.0"
PR = "13.el10_0"
PACKAGES = " \
 golang-github-hashicorp-errwrap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-hashicorp-errwrap-1.1.0-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "76b9e2352799d83961a5bc549162efc066e7427647f85d5083a5eee2b0761ff7"

URI_x86_64_v2_golang-github-hashicorp-errwrap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-hashicorp-errwrap-devel-1.1.0-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-hashicorp-errwrap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-hashicorp-errwrap-devel}"
SRC_URI[x86_64_v2_golang-github-hashicorp-errwrap-devel.sha256sum] = "06d0b9ef766ca19072fc91c3b3d73c9d253bf1caed56c419d25761fc77d70742"

URI_aarch64_golang-github-hashicorp-errwrap-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-hashicorp-errwrap-devel-1.1.0-13.el10_0.noarch.rpm;name=aarch64_golang-github-hashicorp-errwrap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-hashicorp-errwrap-devel}"
SRC_URI[aarch64_golang-github-hashicorp-errwrap-devel.sha256sum] = "62a12fa3907f47879d2fa120635beb397761a69258ef9e78769eb032e758735c"

RDEPENDS:golang-github-hashicorp-errwrap-devel = " \
 go-filesystem \
 "
