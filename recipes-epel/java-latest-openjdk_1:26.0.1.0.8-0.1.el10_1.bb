# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "java-latest-openjdk"
PE = "1"
PV = "26.0.1.0.8"
PR = "0.1.el10_1"
PACKAGES = " \
 java-latest-openjdk \
 java-latest-openjdk-crypto-adapter \
 java-latest-openjdk-crypto-adapter-fastdebug \
 java-latest-openjdk-crypto-adapter-slowdebug \
 java-latest-openjdk-demo \
 java-latest-openjdk-demo-fastdebug \
 java-latest-openjdk-demo-slowdebug \
 java-latest-openjdk-devel \
 java-latest-openjdk-devel-fastdebug \
 java-latest-openjdk-devel-slowdebug \
 java-latest-openjdk-fastdebug \
 java-latest-openjdk-headless \
 java-latest-openjdk-headless-fastdebug \
 java-latest-openjdk-headless-slowdebug \
 java-latest-openjdk-javadoc \
 java-latest-openjdk-javadoc-zip \
 java-latest-openjdk-jmods \
 java-latest-openjdk-jmods-fastdebug \
 java-latest-openjdk-jmods-slowdebug \
 java-latest-openjdk-slowdebug \
 java-latest-openjdk-src \
 java-latest-openjdk-src-fastdebug \
 java-latest-openjdk-src-slowdebug \
 java-latest-openjdk-static-libs \
 java-latest-openjdk-static-libs-fastdebug \
 java-latest-openjdk-static-libs-slowdebug \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/java-latest-openjdk-26.0.1.0.8-0.1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b8e03392b70f5cc03efb80876d2478d4eff851104343efd1ebb4db903ca2c68"

URI_x86_64_v2_java-latest-openjdk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-26.0.1.0.8-0.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk}"
SRC_URI[x86_64_v2_java-latest-openjdk.sha256sum] = "ab4a46176f144289d8f2c8192988fcbe0e059742f619b009a182abad713e8d8e"

URI_x86_64_v2_java-latest-openjdk-crypto-adapter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-crypto-adapter-26.0.1.0.8-0.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-crypto-adapter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-crypto-adapter}"
SRC_URI[x86_64_v2_java-latest-openjdk-crypto-adapter.sha256sum] = "2e28d0a20ee8c7f7887a7637c41564b408af150f59b33bbfbe932ff9dacd6d5a"

URI_x86_64_v2_java-latest-openjdk-crypto-adapter-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-crypto-adapter-fastdebug-26.0.1.0.8-0.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-crypto-adapter-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-crypto-adapter-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-crypto-adapter-fastdebug.sha256sum] = "553e1a8f13728383ca1ada6d76edcf32f59ede92a38e93b06cb02caf56496d7f"

URI_x86_64_v2_java-latest-openjdk-crypto-adapter-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-crypto-adapter-slowdebug-26.0.1.0.8-0.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-crypto-adapter-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-crypto-adapter-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-crypto-adapter-slowdebug.sha256sum] = "280685dc9ec2765d1895488a9be4d4d8cd00e4d210acf10ac64659f8b6ac5caf"

URI_x86_64_v2_java-latest-openjdk-demo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-demo-26.0.1.0.8-0.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-demo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-demo}"
SRC_URI[x86_64_v2_java-latest-openjdk-demo.sha256sum] = "33cd871b3cb59028d91e67fe949370c66c97bbb4ba83f93171fe58393741fcf0"

URI_x86_64_v2_java-latest-openjdk-demo-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-demo-fastdebug-26.0.1.0.8-0.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-demo-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-demo-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-demo-fastdebug.sha256sum] = "c379427086164d0c2b0bd8c822941fa75e59bbd2041a83df94008b36201d17d7"

URI_x86_64_v2_java-latest-openjdk-demo-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-demo-slowdebug-26.0.1.0.8-0.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-demo-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-demo-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-demo-slowdebug.sha256sum] = "15f93e43cd7854eec5d82f64008f776aee82b9655104972e7c1acb0b236dd19f"

URI_x86_64_v2_java-latest-openjdk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-devel-26.0.1.0.8-0.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-devel}"
SRC_URI[x86_64_v2_java-latest-openjdk-devel.sha256sum] = "e864fdc0fa552f6582b48f823f3a02fd8e69b6d1795e667588be93afff71e9da"

URI_x86_64_v2_java-latest-openjdk-devel-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-devel-fastdebug-26.0.1.0.8-0.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-devel-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-devel-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-devel-fastdebug.sha256sum] = "9bc620428e13d86b4dbe13626b7cf272269f2fd52e2c3794cc8b5291d3d24b83"

URI_x86_64_v2_java-latest-openjdk-devel-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-devel-slowdebug-26.0.1.0.8-0.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-devel-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-devel-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-devel-slowdebug.sha256sum] = "16c095aedddb554dfe30f1154c83209a9990e19e4537730aa11fd5138c6e0df5"

URI_x86_64_v2_java-latest-openjdk-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-fastdebug-26.0.1.0.8-0.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-fastdebug.sha256sum] = "1c4460e5de62d322aa2b4353a44bfc99bc9a8d2b012821048cfa5c09be44c301"

URI_x86_64_v2_java-latest-openjdk-headless = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-headless-26.0.1.0.8-0.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-headless;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-headless}"
SRC_URI[x86_64_v2_java-latest-openjdk-headless.sha256sum] = "ac887363b828593cb5db8841aab348158658a7faf4afb3bcda510acbd1d94955"

URI_x86_64_v2_java-latest-openjdk-headless-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-headless-fastdebug-26.0.1.0.8-0.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-headless-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-headless-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-headless-fastdebug.sha256sum] = "42486667cbc0fb6a561f6aee9551d0e097ba5f7aa407cca3d8b4a6c544b9c950"

URI_x86_64_v2_java-latest-openjdk-headless-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-headless-slowdebug-26.0.1.0.8-0.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-headless-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-headless-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-headless-slowdebug.sha256sum] = "669b86fb31e38df54803d50cc84c733bf2be3a5db21949fc4475ff3a3ced2746"

URI_x86_64_v2_java-latest-openjdk-javadoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-javadoc-26.0.1.0.8-0.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-javadoc}"
SRC_URI[x86_64_v2_java-latest-openjdk-javadoc.sha256sum] = "d57cecefa7c65bd39946dc7352c1028a10effd6abe1b3d5d030e54c4ca76de42"

URI_x86_64_v2_java-latest-openjdk-javadoc-zip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-javadoc-zip-26.0.1.0.8-0.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-javadoc-zip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-javadoc-zip}"
SRC_URI[x86_64_v2_java-latest-openjdk-javadoc-zip.sha256sum] = "2b176ffc3cee7f774aefc8f241ea8c57e9b48424f8aa538a6c5ae14dd2465907"

URI_x86_64_v2_java-latest-openjdk-jmods = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-jmods-26.0.1.0.8-0.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-jmods;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-jmods}"
SRC_URI[x86_64_v2_java-latest-openjdk-jmods.sha256sum] = "0369d4d7124f8f1a698c79fc69f837343d72d5a5e8feeb7076bdbacb3fb8f08c"

URI_x86_64_v2_java-latest-openjdk-jmods-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-jmods-fastdebug-26.0.1.0.8-0.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-jmods-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-jmods-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-jmods-fastdebug.sha256sum] = "49e1d55154f0c10425fbd9e605271be525c8fbb0d48d8c4a505ea95c444dbb29"

URI_x86_64_v2_java-latest-openjdk-jmods-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-jmods-slowdebug-26.0.1.0.8-0.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-jmods-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-jmods-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-jmods-slowdebug.sha256sum] = "6df2211bd99ce6df9474de28fd285d86c7e2d017a136d67618ba0b8dadd41589"

URI_x86_64_v2_java-latest-openjdk-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-slowdebug-26.0.1.0.8-0.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-slowdebug.sha256sum] = "2d5c1e7690a6e0761ccfcd071459e1aaf748b95051626d270a387a2ea6832e4e"

URI_x86_64_v2_java-latest-openjdk-src = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-src-26.0.1.0.8-0.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-src;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-src}"
SRC_URI[x86_64_v2_java-latest-openjdk-src.sha256sum] = "00e2f1abfd7ddc7add8728360a6a51938e61178839363f65cca86ec3c5ca15a3"

URI_x86_64_v2_java-latest-openjdk-src-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-src-fastdebug-26.0.1.0.8-0.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-src-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-src-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-src-fastdebug.sha256sum] = "becec6482de671b063700ab8090a9530651c82ff9e95fb04d4ec7d51ceccb694"

URI_x86_64_v2_java-latest-openjdk-src-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-src-slowdebug-26.0.1.0.8-0.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-src-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-src-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-src-slowdebug.sha256sum] = "ba48ab4ac60b5b62f8de9886c71b238a9a73502a9d59c722a50c62db48a624bb"

URI_x86_64_v2_java-latest-openjdk-static-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-static-libs-26.0.1.0.8-0.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-static-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-static-libs}"
SRC_URI[x86_64_v2_java-latest-openjdk-static-libs.sha256sum] = "90debb7f64340e40c29f4973044643c5bf7d74a5a1472ae7199b1d0b53b32aaa"

URI_x86_64_v2_java-latest-openjdk-static-libs-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-static-libs-fastdebug-26.0.1.0.8-0.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-static-libs-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-static-libs-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-static-libs-fastdebug.sha256sum] = "0e98279cf171b404538b3cd020cadfe6ba33d73e6ae8b6f45f76c773dd489c12"

URI_x86_64_v2_java-latest-openjdk-static-libs-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-static-libs-slowdebug-26.0.1.0.8-0.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-static-libs-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-static-libs-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-static-libs-slowdebug.sha256sum] = "2942c091b2fb6aea2ee7cc92310c9f1dddb912da5778cc713599017e89e93c54"

URI_aarch64_java-latest-openjdk = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-26.0.1.0.8-0.1.el10_1.aarch64.rpm;name=aarch64_java-latest-openjdk;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk}"
SRC_URI[aarch64_java-latest-openjdk.sha256sum] = "e5bf5150cb041976a56c5aa73d54d7d062c275de7a6e9e360ba9d286b39205eb"

URI_aarch64_java-latest-openjdk-crypto-adapter = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-crypto-adapter-26.0.1.0.8-0.1.el10_1.aarch64.rpm;name=aarch64_java-latest-openjdk-crypto-adapter;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-crypto-adapter}"
SRC_URI[aarch64_java-latest-openjdk-crypto-adapter.sha256sum] = "f9d1d08dfe6394d72769424fd2f0ee151664038154eff4b4f25dd75049046c8a"

URI_aarch64_java-latest-openjdk-crypto-adapter-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-crypto-adapter-fastdebug-26.0.1.0.8-0.1.el10_1.aarch64.rpm;name=aarch64_java-latest-openjdk-crypto-adapter-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-crypto-adapter-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-crypto-adapter-fastdebug.sha256sum] = "c0f2e6ece1a715595bcf0f183f675ed4e1879822cb16ed3c95cfe13a1e019251"

URI_aarch64_java-latest-openjdk-crypto-adapter-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-crypto-adapter-slowdebug-26.0.1.0.8-0.1.el10_1.aarch64.rpm;name=aarch64_java-latest-openjdk-crypto-adapter-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-crypto-adapter-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-crypto-adapter-slowdebug.sha256sum] = "e07f82b4077f56ea59ca8aff7c8630328043222604c700fe6987c04e20531aea"

URI_aarch64_java-latest-openjdk-demo = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-demo-26.0.1.0.8-0.1.el10_1.aarch64.rpm;name=aarch64_java-latest-openjdk-demo;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-demo}"
SRC_URI[aarch64_java-latest-openjdk-demo.sha256sum] = "c89fb68a5e7fc3775bb7c3d48a24dbe99131134d7a7e4c089f61a50a52202b16"

URI_aarch64_java-latest-openjdk-demo-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-demo-fastdebug-26.0.1.0.8-0.1.el10_1.aarch64.rpm;name=aarch64_java-latest-openjdk-demo-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-demo-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-demo-fastdebug.sha256sum] = "94d9895d3ce113c24990d580ec90472e97597c719b6faf65fdef94322e17d6bf"

URI_aarch64_java-latest-openjdk-demo-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-demo-slowdebug-26.0.1.0.8-0.1.el10_1.aarch64.rpm;name=aarch64_java-latest-openjdk-demo-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-demo-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-demo-slowdebug.sha256sum] = "378d8ab3a05b83b6ee82bd6287cc3ff9f9e3fbc65bff60b320415ee1e904c49f"

URI_aarch64_java-latest-openjdk-devel = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-devel-26.0.1.0.8-0.1.el10_1.aarch64.rpm;name=aarch64_java-latest-openjdk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-devel}"
SRC_URI[aarch64_java-latest-openjdk-devel.sha256sum] = "0524cbf432f5a9b42be26bfb59142982015764ae18b7e4277b1fe34d871ff14b"

URI_aarch64_java-latest-openjdk-devel-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-devel-fastdebug-26.0.1.0.8-0.1.el10_1.aarch64.rpm;name=aarch64_java-latest-openjdk-devel-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-devel-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-devel-fastdebug.sha256sum] = "fde2cf0ef5dc0219ba5b0cd012efb3d978494ca6202db54b25b33a80ff8e317e"

URI_aarch64_java-latest-openjdk-devel-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-devel-slowdebug-26.0.1.0.8-0.1.el10_1.aarch64.rpm;name=aarch64_java-latest-openjdk-devel-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-devel-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-devel-slowdebug.sha256sum] = "8ded58a21063465e1f70f8f284285bc6542d376c34b7e9321699c8410f206ddd"

URI_aarch64_java-latest-openjdk-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-fastdebug-26.0.1.0.8-0.1.el10_1.aarch64.rpm;name=aarch64_java-latest-openjdk-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-fastdebug.sha256sum] = "1d9c81d7218fd2b953991619a03e3c09c1dc0a49f36c45036f05fa82d1f03d25"

URI_aarch64_java-latest-openjdk-headless = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-headless-26.0.1.0.8-0.1.el10_1.aarch64.rpm;name=aarch64_java-latest-openjdk-headless;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-headless}"
SRC_URI[aarch64_java-latest-openjdk-headless.sha256sum] = "2314fdb1b5d71cf65c2af6e3324710d987468852d839f9a3f2591754ca4cc2d8"

URI_aarch64_java-latest-openjdk-headless-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-headless-fastdebug-26.0.1.0.8-0.1.el10_1.aarch64.rpm;name=aarch64_java-latest-openjdk-headless-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-headless-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-headless-fastdebug.sha256sum] = "d98a03d1ef7bf54beac19b18e5fc276524776fbfd01f3f6df763d2e1f80e6131"

URI_aarch64_java-latest-openjdk-headless-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-headless-slowdebug-26.0.1.0.8-0.1.el10_1.aarch64.rpm;name=aarch64_java-latest-openjdk-headless-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-headless-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-headless-slowdebug.sha256sum] = "b76d3b0dc988c36426a3f17f53a1e02206ddeeca925e06b72564738a8e10df62"

URI_aarch64_java-latest-openjdk-javadoc = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-javadoc-26.0.1.0.8-0.1.el10_1.aarch64.rpm;name=aarch64_java-latest-openjdk-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-javadoc}"
SRC_URI[aarch64_java-latest-openjdk-javadoc.sha256sum] = "f59fdcdb5a445dc5e038241b7ae0303e2acc828136e25b749928dc05a215a8e6"

URI_aarch64_java-latest-openjdk-javadoc-zip = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-javadoc-zip-26.0.1.0.8-0.1.el10_1.aarch64.rpm;name=aarch64_java-latest-openjdk-javadoc-zip;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-javadoc-zip}"
SRC_URI[aarch64_java-latest-openjdk-javadoc-zip.sha256sum] = "989cb1c1c777fbbd89963eec23da8efe3d77379b94b931208d80113968d21b63"

URI_aarch64_java-latest-openjdk-jmods = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-jmods-26.0.1.0.8-0.1.el10_1.aarch64.rpm;name=aarch64_java-latest-openjdk-jmods;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-jmods}"
SRC_URI[aarch64_java-latest-openjdk-jmods.sha256sum] = "d72ef9e3cf4d450d09624d495f831a67a37698959131c6be8e276c29439fc7f1"

URI_aarch64_java-latest-openjdk-jmods-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-jmods-fastdebug-26.0.1.0.8-0.1.el10_1.aarch64.rpm;name=aarch64_java-latest-openjdk-jmods-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-jmods-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-jmods-fastdebug.sha256sum] = "4d4d953bbd3aabf7b67054e521ddb3b9c45ce915eacf275ec5fa972d9d80ab15"

URI_aarch64_java-latest-openjdk-jmods-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-jmods-slowdebug-26.0.1.0.8-0.1.el10_1.aarch64.rpm;name=aarch64_java-latest-openjdk-jmods-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-jmods-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-jmods-slowdebug.sha256sum] = "9117cf93e5ad2bd9c57afcbf69db8807accd46d34f128875f269e732275c9dec"

URI_aarch64_java-latest-openjdk-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-slowdebug-26.0.1.0.8-0.1.el10_1.aarch64.rpm;name=aarch64_java-latest-openjdk-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-slowdebug.sha256sum] = "ead587ec91e8a724c85f2efb2125c008b9ddd34be127a6eb2e82c21c0586dc34"

URI_aarch64_java-latest-openjdk-src = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-src-26.0.1.0.8-0.1.el10_1.aarch64.rpm;name=aarch64_java-latest-openjdk-src;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-src}"
SRC_URI[aarch64_java-latest-openjdk-src.sha256sum] = "bb1e12aa647a83475deef62c7e7637262ce686a153bf18c8c3406e16b87ae34b"

URI_aarch64_java-latest-openjdk-src-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-src-fastdebug-26.0.1.0.8-0.1.el10_1.aarch64.rpm;name=aarch64_java-latest-openjdk-src-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-src-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-src-fastdebug.sha256sum] = "55af194b55477bcea35ae2684a28f94dd4fa789c70a302cbb731da3329866b4a"

URI_aarch64_java-latest-openjdk-src-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-src-slowdebug-26.0.1.0.8-0.1.el10_1.aarch64.rpm;name=aarch64_java-latest-openjdk-src-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-src-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-src-slowdebug.sha256sum] = "b215e98ee7c5dfb86e76aa73098fa571b6ec5eb290a6ad343ad6372132749544"

URI_aarch64_java-latest-openjdk-static-libs = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-static-libs-26.0.1.0.8-0.1.el10_1.aarch64.rpm;name=aarch64_java-latest-openjdk-static-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-static-libs}"
SRC_URI[aarch64_java-latest-openjdk-static-libs.sha256sum] = "2faf3707da81f345885ee6d1eac6784db3111c78dac43747ef07c2bb35bcb6bc"

URI_aarch64_java-latest-openjdk-static-libs-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-static-libs-fastdebug-26.0.1.0.8-0.1.el10_1.aarch64.rpm;name=aarch64_java-latest-openjdk-static-libs-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-static-libs-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-static-libs-fastdebug.sha256sum] = "d76771c2b01453991138eba504875c8a4e71b60e51afb0a61595bafc62c60af5"

URI_aarch64_java-latest-openjdk-static-libs-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-static-libs-slowdebug-26.0.1.0.8-0.1.el10_1.aarch64.rpm;name=aarch64_java-latest-openjdk-static-libs-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-static-libs-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-static-libs-slowdebug.sha256sum] = "32739ac6a13f106f5976f7912972d3deee10707f7d9b57573cf0a63e359c204c"

RDEPENDS:java-latest-openjdk = " \
 bash \
 fontconfig \
 glibc \
 java-latest-openjdk-headless \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-latest-openjdk-crypto-adapter = " \
 glibc \
 nss \
 nss-softokn \
 "
RDEPENDS:java-latest-openjdk-crypto-adapter-fastdebug = " \
 glibc \
 nss \
 nss-softokn \
 "
RDEPENDS:java-latest-openjdk-crypto-adapter-slowdebug = " \
 glibc \
 nss \
 nss-softokn \
 "
RDEPENDS:java-latest-openjdk-demo = " \
 java-latest-openjdk \
 "
RDEPENDS:java-latest-openjdk-demo-fastdebug = " \
 java-latest-openjdk-fastdebug \
 "
RDEPENDS:java-latest-openjdk-demo-slowdebug = " \
 java-latest-openjdk-slowdebug \
 "
RDEPENDS:java-latest-openjdk-devel = " \
 alternatives \
 bash \
 glibc \
 java-latest-openjdk \
 "
RDEPENDS:java-latest-openjdk-devel-fastdebug = " \
 alternatives \
 bash \
 glibc \
 java-latest-openjdk-fastdebug \
 "
RDEPENDS:java-latest-openjdk-devel-slowdebug = " \
 alternatives \
 bash \
 glibc \
 java-latest-openjdk-slowdebug \
 "
RDEPENDS:java-latest-openjdk-fastdebug = " \
 bash \
 fontconfig \
 glibc \
 java-latest-openjdk-headless-fastdebug \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-latest-openjdk-headless = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 java-latest-openjdk-crypto-adapter \
 javapackages-filesystem \
 lksctp-tools \
 nss \
 tzdata-java \
 "
RDEPENDS:java-latest-openjdk-headless-fastdebug = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 java-latest-openjdk-crypto-adapter-fastdebug \
 javapackages-filesystem \
 lksctp-tools \
 nss \
 tzdata-java \
 "
RDEPENDS:java-latest-openjdk-headless-slowdebug = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 java-latest-openjdk-crypto-adapter-slowdebug \
 javapackages-filesystem \
 lksctp-tools \
 nss \
 tzdata-java \
 "
RDEPENDS:java-latest-openjdk-javadoc = " \
 alternatives \
 bash \
 javapackages-filesystem \
 "
RDEPENDS:java-latest-openjdk-javadoc-zip = " \
 alternatives \
 bash \
 javapackages-filesystem \
 "
RDEPENDS:java-latest-openjdk-jmods = " \
 java-latest-openjdk-devel \
 "
RDEPENDS:java-latest-openjdk-jmods-fastdebug = " \
 java-latest-openjdk-devel-fastdebug \
 "
RDEPENDS:java-latest-openjdk-jmods-slowdebug = " \
 java-latest-openjdk-devel-slowdebug \
 "
RDEPENDS:java-latest-openjdk-slowdebug = " \
 bash \
 fontconfig \
 glibc \
 java-latest-openjdk-headless-slowdebug \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-latest-openjdk-src = " \
 java-latest-openjdk-headless \
 "
RDEPENDS:java-latest-openjdk-src-fastdebug = " \
 java-latest-openjdk-headless-fastdebug \
 "
RDEPENDS:java-latest-openjdk-src-slowdebug = " \
 java-latest-openjdk-headless-slowdebug \
 "
RDEPENDS:java-latest-openjdk-static-libs = " \
 java-latest-openjdk-devel \
 "
RDEPENDS:java-latest-openjdk-static-libs-fastdebug = " \
 java-latest-openjdk-devel-fastdebug \
 "
RDEPENDS:java-latest-openjdk-static-libs-slowdebug = " \
 java-latest-openjdk-devel-slowdebug \
 "
