# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-frameworkintegration"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-frameworkintegration \
 kf6-frameworkintegration-devel \
 kf6-frameworkintegration-doc \
 kf6-frameworkintegration-html \
 kf6-frameworkintegration-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-frameworkintegration-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cfa512293208a9a468060ee172dbf229d48b4b34d950b3df160c1b6eef796e2d"

URI_x86_64_v2_kf6-frameworkintegration = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-frameworkintegration-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-frameworkintegration;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-frameworkintegration}"
SRC_URI[x86_64_v2_kf6-frameworkintegration.sha256sum] = "3668f07740f062dd7ffb2726283f2d2a49719a2c9587ca2e7db2ad3cd140e15a"

URI_x86_64_v2_kf6-frameworkintegration-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-frameworkintegration-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-frameworkintegration-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-frameworkintegration-devel}"
SRC_URI[x86_64_v2_kf6-frameworkintegration-devel.sha256sum] = "4aba0d6a7b547e77503b713c37d6b05a83dea9b3680b32855c0de77f7845ea75"

URI_x86_64_v2_kf6-frameworkintegration-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-frameworkintegration-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-frameworkintegration-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-frameworkintegration-doc}"
SRC_URI[x86_64_v2_kf6-frameworkintegration-doc.sha256sum] = "fcbcce4dbe5b2498ac6084560b18b64ff8ed7bcb831d5d143527570b4b96b833"

URI_x86_64_v2_kf6-frameworkintegration-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-frameworkintegration-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-frameworkintegration-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-frameworkintegration-html}"
SRC_URI[x86_64_v2_kf6-frameworkintegration-html.sha256sum] = "dc6598e8b4bba847b123f33e62b09d5f265ae125d27432e98e4806401cd7bec2"

URI_x86_64_v2_kf6-frameworkintegration-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-frameworkintegration-libs-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-frameworkintegration-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-frameworkintegration-libs}"
SRC_URI[x86_64_v2_kf6-frameworkintegration-libs.sha256sum] = "50a46eee658fa9de6ba6696fe611fec8707708f8fa28ddb1ac05a49700b2bff5"

URI_aarch64_kf6-frameworkintegration = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-frameworkintegration-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-frameworkintegration;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-frameworkintegration}"
SRC_URI[aarch64_kf6-frameworkintegration.sha256sum] = "d2d0e3f8654e1bb00e64cb30d310e1500d5a2c6ef80cf4e0f002316900f97921"

URI_aarch64_kf6-frameworkintegration-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-frameworkintegration-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-frameworkintegration-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-frameworkintegration-devel}"
SRC_URI[aarch64_kf6-frameworkintegration-devel.sha256sum] = "4aa417e679f7a2b96de16b0343632ecca67ff0345c9dfcf7f0b437d6aa0b88ab"

URI_aarch64_kf6-frameworkintegration-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-frameworkintegration-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-frameworkintegration-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-frameworkintegration-doc}"
SRC_URI[aarch64_kf6-frameworkintegration-doc.sha256sum] = "d2eed339e9eff13784989231b087c3e47fcbaf6691e177709e038fa749a6df0c"

URI_aarch64_kf6-frameworkintegration-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-frameworkintegration-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-frameworkintegration-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-frameworkintegration-html}"
SRC_URI[aarch64_kf6-frameworkintegration-html.sha256sum] = "b7ca126577e61d1bc72ba669afe886406e355a82c318a2fe8e1f4c41626ab4d5"

URI_aarch64_kf6-frameworkintegration-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-frameworkintegration-libs-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-frameworkintegration-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-frameworkintegration-libs}"
SRC_URI[aarch64_kf6-frameworkintegration-libs.sha256sum] = "4af4437bd484c9fb262c1da72ff2a78af066e5767174b774edc620ee78ff30ea"

RDEPENDS:kf6-frameworkintegration = " \
 glibc \
 kf6-filesystem \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-knotifications \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-frameworkintegration-devel = " \
 cmake-filesystem \
 kf6-frameworkintegration-libs \
 kf6-kconfigwidgets-devel \
 kf6-kiconthemes-devel \
 "
RDEPENDS:kf6-frameworkintegration-doc = " \
 "
RDEPENDS:kf6-frameworkintegration-html = " \
 "
RDEPENDS:kf6-frameworkintegration-libs = " \
 PackageKit-Qt6 \
 appstream-qt \
 glibc \
 kf6-frameworkintegration \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kiconthemes \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
