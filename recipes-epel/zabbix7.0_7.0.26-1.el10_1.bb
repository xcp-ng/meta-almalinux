# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zabbix7.0"
PV = "7.0.26"
PR = "1.el10_1"
PACKAGES = " \
 zabbix7.0 \
 zabbix7.0-agent \
 zabbix7.0-dbfiles-mysql \
 zabbix7.0-dbfiles-pgsql \
 zabbix7.0-dbfiles-sqlite3 \
 zabbix7.0-proxy \
 zabbix7.0-proxy-mysql \
 zabbix7.0-proxy-pgsql \
 zabbix7.0-proxy-sqlite3 \
 zabbix7.0-selinux \
 zabbix7.0-server \
 zabbix7.0-server-mysql \
 zabbix7.0-server-pgsql \
 zabbix7.0-web \
 zabbix7.0-web-mysql \
 zabbix7.0-web-pgsql \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/z/zabbix7.0-7.0.26-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7aa8329535e82f01421aaeecd0398106639df656a8c5eeb018c1dda4837d413f"

URI_x86_64_v2_zabbix7.0 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-7.0.26-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zabbix7.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0}"
SRC_URI[x86_64_v2_zabbix7.0.sha256sum] = "97314deef8f0aeb4c7f0f611b16d77a20969b2c79cfcc8f113c3226bd2f32fb0"

URI_x86_64_v2_zabbix7.0-agent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-agent-7.0.26-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zabbix7.0-agent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-agent}"
SRC_URI[x86_64_v2_zabbix7.0-agent.sha256sum] = "bd5ad19bb362c9b677399cd1388771d60174930be1c1f557385f4d587c0eb0d9"

URI_x86_64_v2_zabbix7.0-dbfiles-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-dbfiles-mysql-7.0.26-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-dbfiles-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-dbfiles-mysql}"
SRC_URI[x86_64_v2_zabbix7.0-dbfiles-mysql.sha256sum] = "598f879132b81d6da8b3283219cfe3c2feeb8257d0b578fc8834d2d8f3585ec5"

URI_x86_64_v2_zabbix7.0-dbfiles-pgsql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-dbfiles-pgsql-7.0.26-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-dbfiles-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-dbfiles-pgsql}"
SRC_URI[x86_64_v2_zabbix7.0-dbfiles-pgsql.sha256sum] = "dd57d602385d56c12d7698419a711783957aef69de3d7a876bc04ec62f225994"

URI_x86_64_v2_zabbix7.0-dbfiles-sqlite3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-dbfiles-sqlite3-7.0.26-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-dbfiles-sqlite3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-dbfiles-sqlite3}"
SRC_URI[x86_64_v2_zabbix7.0-dbfiles-sqlite3.sha256sum] = "5fdb90e73cdf649de13ffd9e4e15940cd8e0a2228e51900bf3ae7bc1faeec197"

URI_x86_64_v2_zabbix7.0-proxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-proxy-7.0.26-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-proxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-proxy}"
SRC_URI[x86_64_v2_zabbix7.0-proxy.sha256sum] = "73ae4effeeccc6b1f3bfd944bfccbc5bfff416ed0101e8710f66c76d132a349b"

URI_x86_64_v2_zabbix7.0-proxy-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-proxy-mysql-7.0.26-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zabbix7.0-proxy-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-proxy-mysql}"
SRC_URI[x86_64_v2_zabbix7.0-proxy-mysql.sha256sum] = "aea3d88ca3bede5b1bcf2665c6659f834a252b61bdb2e3f1a7649bfcc0c5c4b6"
RPROVIDES:zabbix7.0-proxy-mysql:append:x86_64_v2 = " virtual/zabbix7.0-proxy-implementation_eq_7.0.26-1.el10_1.alma_altarch"

URI_x86_64_v2_zabbix7.0-proxy-pgsql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-proxy-pgsql-7.0.26-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zabbix7.0-proxy-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-proxy-pgsql}"
SRC_URI[x86_64_v2_zabbix7.0-proxy-pgsql.sha256sum] = "708cabf414ac0c1ae2da2a6edbd4c30aadaff6f6f104e3408070c2c362a7dcf5"
RPROVIDES:zabbix7.0-proxy-pgsql:append:x86_64_v2 = " virtual/zabbix7.0-proxy-implementation_eq_7.0.26-1.el10_1.alma_altarch"

URI_x86_64_v2_zabbix7.0-proxy-sqlite3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-proxy-sqlite3-7.0.26-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zabbix7.0-proxy-sqlite3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-proxy-sqlite3}"
SRC_URI[x86_64_v2_zabbix7.0-proxy-sqlite3.sha256sum] = "2f0b97c171b81335a8717e88f97e3208b95b68695cb561c9eed13b3e46a67314"
RPROVIDES:zabbix7.0-proxy-sqlite3:append:x86_64_v2 = " virtual/zabbix7.0-proxy-implementation_eq_7.0.26-1.el10_1.alma_altarch"

URI_x86_64_v2_zabbix7.0-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-selinux-7.0.26-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-selinux}"
SRC_URI[x86_64_v2_zabbix7.0-selinux.sha256sum] = "0db110e732d321bd13e170de46978ebdb09d0288ced2b0099039bc4dc5cd368e"

URI_x86_64_v2_zabbix7.0-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-server-7.0.26-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-server}"
SRC_URI[x86_64_v2_zabbix7.0-server.sha256sum] = "ff5a1f4aaebe37911b223d3bc63e4de0d5232674a44822cd0871eae75b462bda"

URI_x86_64_v2_zabbix7.0-server-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-server-mysql-7.0.26-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zabbix7.0-server-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-server-mysql}"
SRC_URI[x86_64_v2_zabbix7.0-server-mysql.sha256sum] = "e469fd9dee1a1faf149d894b4f54a09824f05a63ff788804aa5d1ff01438f16f"
RPROVIDES:zabbix7.0-server-mysql:append:x86_64_v2 = " virtual/zabbix7.0-server-implementation_eq_7.0.26-1.el10_1.alma_altarch"

URI_x86_64_v2_zabbix7.0-server-pgsql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-server-pgsql-7.0.26-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zabbix7.0-server-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-server-pgsql}"
SRC_URI[x86_64_v2_zabbix7.0-server-pgsql.sha256sum] = "77856e55b3207eff3e98f75574e8de39ba3f3a129d517c7bfd28b48830ad0199"
RPROVIDES:zabbix7.0-server-pgsql:append:x86_64_v2 = " virtual/zabbix7.0-server-implementation_eq_7.0.26-1.el10_1.alma_altarch"

URI_x86_64_v2_zabbix7.0-web = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-web-7.0.26-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-web;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-web}"
SRC_URI[x86_64_v2_zabbix7.0-web.sha256sum] = "dc1a1443c9bdadd2294eba207e17b4e6f0e4b098fd61fd50b9b1e687a96bfa4b"

URI_x86_64_v2_zabbix7.0-web-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-web-mysql-7.0.26-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-web-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-web-mysql}"
SRC_URI[x86_64_v2_zabbix7.0-web-mysql.sha256sum] = "b92720c556a68ebf2a017c0ca8ab1521a9edce89477907a96e3c752177995c3d"
RPROVIDES:zabbix7.0-web-mysql:append:x86_64_v2 = " virtual/zabbix7.0-web-database_eq_7.0.26-1.el10_1.alma_altarch"

URI_x86_64_v2_zabbix7.0-web-pgsql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-web-pgsql-7.0.26-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-web-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-web-pgsql}"
SRC_URI[x86_64_v2_zabbix7.0-web-pgsql.sha256sum] = "89a6e3a425ba5ab7eb03c1fa95a6393fa8ad08aff450fadab6c12326053e0086"
RPROVIDES:zabbix7.0-web-pgsql:append:x86_64_v2 = " virtual/zabbix7.0-web-database_eq_7.0.26-1.el10_1.alma_altarch"

URI_aarch64_zabbix7.0 = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-7.0.26-1.el10_1.aarch64.rpm;name=aarch64_zabbix7.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0}"
SRC_URI[aarch64_zabbix7.0.sha256sum] = "d4bf27d0a3f85d523ac6239fac1b76014d8aed1be8dbaf2e0f56ed61b4829720"

URI_aarch64_zabbix7.0-agent = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-agent-7.0.26-1.el10_1.aarch64.rpm;name=aarch64_zabbix7.0-agent;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-agent}"
SRC_URI[aarch64_zabbix7.0-agent.sha256sum] = "a378eb7442c27c10aa02790551e61de2046caaa2bfdd0920628f0de201f702e5"

URI_aarch64_zabbix7.0-dbfiles-mysql = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-dbfiles-mysql-7.0.26-1.el10_1.noarch.rpm;name=aarch64_zabbix7.0-dbfiles-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-dbfiles-mysql}"
SRC_URI[aarch64_zabbix7.0-dbfiles-mysql.sha256sum] = "bc803472cf4fd948bc8504b039cd5ecbe2dc21797e1bd86cfdeacaf0ce712b07"

URI_aarch64_zabbix7.0-dbfiles-pgsql = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-dbfiles-pgsql-7.0.26-1.el10_1.noarch.rpm;name=aarch64_zabbix7.0-dbfiles-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-dbfiles-pgsql}"
SRC_URI[aarch64_zabbix7.0-dbfiles-pgsql.sha256sum] = "606e19f34354c58c63d5080a05f4afe0936f0e6f2d9a2fa4db2d6267bd9a3377"

URI_aarch64_zabbix7.0-dbfiles-sqlite3 = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-dbfiles-sqlite3-7.0.26-1.el10_1.noarch.rpm;name=aarch64_zabbix7.0-dbfiles-sqlite3;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-dbfiles-sqlite3}"
SRC_URI[aarch64_zabbix7.0-dbfiles-sqlite3.sha256sum] = "4582930f83e7b5dda6727eb58e3a0ca7e3f8745f3975dbd2db712d35a386b860"

URI_aarch64_zabbix7.0-proxy = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-proxy-7.0.26-1.el10_1.noarch.rpm;name=aarch64_zabbix7.0-proxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-proxy}"
SRC_URI[aarch64_zabbix7.0-proxy.sha256sum] = "9cba4b7d4b7841b9367aafbf0504f565848aacd31ae5ce4601b537547321452e"

URI_aarch64_zabbix7.0-proxy-mysql = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-proxy-mysql-7.0.26-1.el10_1.aarch64.rpm;name=aarch64_zabbix7.0-proxy-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-proxy-mysql}"
SRC_URI[aarch64_zabbix7.0-proxy-mysql.sha256sum] = "c0cf500731faf83ace56566e1cdd4bf30d3c38584035c4670e9c0dd280d2e035"
RPROVIDES:zabbix7.0-proxy-mysql:append:aarch64 = " virtual/zabbix7.0-proxy-implementation_eq_7.0.26-1.el10_1"

URI_aarch64_zabbix7.0-proxy-pgsql = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-proxy-pgsql-7.0.26-1.el10_1.aarch64.rpm;name=aarch64_zabbix7.0-proxy-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-proxy-pgsql}"
SRC_URI[aarch64_zabbix7.0-proxy-pgsql.sha256sum] = "24c6de440dd4c2ab1ffe6cb197686de0ad36b3ec7bb54a0ece3d7ff7a79626bd"
RPROVIDES:zabbix7.0-proxy-pgsql:append:aarch64 = " virtual/zabbix7.0-proxy-implementation_eq_7.0.26-1.el10_1"

URI_aarch64_zabbix7.0-proxy-sqlite3 = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-proxy-sqlite3-7.0.26-1.el10_1.aarch64.rpm;name=aarch64_zabbix7.0-proxy-sqlite3;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-proxy-sqlite3}"
SRC_URI[aarch64_zabbix7.0-proxy-sqlite3.sha256sum] = "9e513963796e466e4241559e51ab0da1a21ba567622758a073c69184b8cc3804"
RPROVIDES:zabbix7.0-proxy-sqlite3:append:aarch64 = " virtual/zabbix7.0-proxy-implementation_eq_7.0.26-1.el10_1"

URI_aarch64_zabbix7.0-selinux = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-selinux-7.0.26-1.el10_1.noarch.rpm;name=aarch64_zabbix7.0-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-selinux}"
SRC_URI[aarch64_zabbix7.0-selinux.sha256sum] = "6f61e5b607cfe81ec1c6aceedaee2a63549da9a7e20fbe7c8a0674c6e6ed8073"

URI_aarch64_zabbix7.0-server = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-server-7.0.26-1.el10_1.noarch.rpm;name=aarch64_zabbix7.0-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-server}"
SRC_URI[aarch64_zabbix7.0-server.sha256sum] = "0e7d2ba5287fd1ad06c78339dd5ea8e727ee72015122b955edf98438295516e9"

URI_aarch64_zabbix7.0-server-mysql = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-server-mysql-7.0.26-1.el10_1.aarch64.rpm;name=aarch64_zabbix7.0-server-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-server-mysql}"
SRC_URI[aarch64_zabbix7.0-server-mysql.sha256sum] = "03c74f83881214dbbd521871dc25b3dd0e40b945a5e9fe47777b7db193273c60"
RPROVIDES:zabbix7.0-server-mysql:append:aarch64 = " virtual/zabbix7.0-server-implementation_eq_7.0.26-1.el10_1"

URI_aarch64_zabbix7.0-server-pgsql = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-server-pgsql-7.0.26-1.el10_1.aarch64.rpm;name=aarch64_zabbix7.0-server-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-server-pgsql}"
SRC_URI[aarch64_zabbix7.0-server-pgsql.sha256sum] = "cf8bad9f92e6524341bb742f97c0a7617ee1c7947f8bec87d7aa5e1f4bf6590b"
RPROVIDES:zabbix7.0-server-pgsql:append:aarch64 = " virtual/zabbix7.0-server-implementation_eq_7.0.26-1.el10_1"

URI_aarch64_zabbix7.0-web = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-web-7.0.26-1.el10_1.noarch.rpm;name=aarch64_zabbix7.0-web;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-web}"
SRC_URI[aarch64_zabbix7.0-web.sha256sum] = "2baf9155e7be45fbc79b7a5dfcfad3abc1c9cac6ad01a8e1119e86450416b0bf"

URI_aarch64_zabbix7.0-web-mysql = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-web-mysql-7.0.26-1.el10_1.noarch.rpm;name=aarch64_zabbix7.0-web-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-web-mysql}"
SRC_URI[aarch64_zabbix7.0-web-mysql.sha256sum] = "a999fe48065dc4f144738dafbc60b729bc703fad71850e6259a358fd0f982113"
RPROVIDES:zabbix7.0-web-mysql:append:aarch64 = " virtual/zabbix7.0-web-database_eq_7.0.26-1.el10_1"

URI_aarch64_zabbix7.0-web-pgsql = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-web-pgsql-7.0.26-1.el10_1.noarch.rpm;name=aarch64_zabbix7.0-web-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-web-pgsql}"
SRC_URI[aarch64_zabbix7.0-web-pgsql.sha256sum] = "a9c59a2b5baf2453d1c1c413e85214cae412c38f140a248139052dd339953e17"
RPROVIDES:zabbix7.0-web-pgsql:append:aarch64 = " virtual/zabbix7.0-web-database_eq_7.0.26-1.el10_1"

RDEPENDS:zabbix7.0 = " \
 glibc \
 libxml2 \
 logrotate \
 openssl-libs \
 pcre2 \
 virtual/libcurl.so.4___64bit_ \
 zabbix7.0-selinux \
 zlib-ng-compat \
 "
RDEPENDS:zabbix7.0-agent = " \
 bash \
 glibc \
 openldap \
 openssl-libs \
 pcre2 \
 shadow-utils \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 zabbix7.0 \
 zlib-ng-compat \
 "
RDEPENDS:zabbix7.0-dbfiles-mysql = " \
 "
RDEPENDS:zabbix7.0-dbfiles-pgsql = " \
 "
RDEPENDS:zabbix7.0-dbfiles-sqlite3 = " \
 "
RDEPENDS:zabbix7.0-proxy:x86_64_v2 = " \
 bash \
 fping \
 shadow-utils \
 systemd \
 virtual/zabbix7.0-proxy-implementation_eq_7.0.26-1.el10_1.alma_altarch \
 zabbix7.0 \
"
RDEPENDS:zabbix7.0-proxy:aarch64 = " \
 bash \
 fping \
 shadow-utils \
 systemd \
 virtual/zabbix7.0-proxy-implementation_eq_7.0.26-1.el10_1 \
 zabbix7.0 \
"
RDEPENDS:zabbix7.0-proxy-mysql = " \
 OpenIPMI-libs \
 alternatives \
 bash \
 glibc \
 libevent \
 libssh2 \
 libxml2 \
 mariadb-connector-c \
 net-snmp-libs \
 openldap \
 openssl-libs \
 pcre2 \
 unixODBC \
 virtual/libcurl.so.4___64bit_ \
 zabbix7.0-dbfiles-mysql \
 zabbix7.0-proxy \
 zlib-ng-compat \
 "
RDEPENDS:zabbix7.0-proxy-pgsql = " \
 OpenIPMI-libs \
 alternatives \
 bash \
 glibc \
 libevent \
 libpq \
 libssh2 \
 libxml2 \
 net-snmp-libs \
 openldap \
 openssl-libs \
 pcre2 \
 unixODBC \
 virtual/libcurl.so.4___64bit_ \
 zabbix7.0-dbfiles-pgsql \
 zabbix7.0-proxy \
 zlib-ng-compat \
 "
RDEPENDS:zabbix7.0-proxy-sqlite3 = " \
 OpenIPMI-libs \
 alternatives \
 bash \
 glibc \
 libevent \
 libssh2 \
 libxml2 \
 net-snmp-libs \
 openldap \
 openssl-libs \
 pcre2 \
 sqlite-libs \
 unixODBC \
 virtual/libcurl.so.4___64bit_ \
 zabbix7.0-dbfiles-sqlite3 \
 zabbix7.0-proxy \
 zlib-ng-compat \
 "
RDEPENDS:zabbix7.0-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:zabbix7.0-server:x86_64_v2 = " \
 bash \
 fping \
 shadow-utils \
 systemd \
 traceroute \
 virtual/zabbix7.0-server-implementation_eq_7.0.26-1.el10_1.alma_altarch \
 zabbix7.0 \
"
RDEPENDS:zabbix7.0-server:aarch64 = " \
 bash \
 fping \
 shadow-utils \
 systemd \
 traceroute \
 virtual/zabbix7.0-server-implementation_eq_7.0.26-1.el10_1 \
 zabbix7.0 \
"
RDEPENDS:zabbix7.0-server-mysql = " \
 OpenIPMI-libs \
 alternatives \
 bash \
 glibc \
 libevent \
 libssh2 \
 libxml2 \
 mariadb-connector-c \
 net-snmp-libs \
 openldap \
 openssl-libs \
 pcre2 \
 unixODBC \
 virtual/libcurl.so.4___64bit_ \
 zabbix7.0 \
 zabbix7.0-dbfiles-mysql \
 zabbix7.0-server \
 zlib-ng-compat \
 "
RDEPENDS:zabbix7.0-server-pgsql = " \
 OpenIPMI-libs \
 alternatives \
 bash \
 glibc \
 libevent \
 libpq \
 libssh2 \
 libxml2 \
 net-snmp-libs \
 openldap \
 openssl-libs \
 pcre2 \
 unixODBC \
 virtual/libcurl.so.4___64bit_ \
 zabbix7.0 \
 zabbix7.0-dbfiles-pgsql \
 zabbix7.0-server \
 zlib-ng-compat \
 "
RDEPENDS:zabbix7.0-web:x86_64_v2 = " \
 bash \
 dejavu-sans-fonts \
 js-jquery \
 php-bcmath \
 php-common \
 php-fpm \
 php-gd \
 php-ldap \
 php-mbstring \
 php-xml \
 virtual/zabbix7.0-web-database_eq_7.0.26-1.el10_1.alma_altarch \
 zabbix7.0 \
"
RDEPENDS:zabbix7.0-web:aarch64 = " \
 bash \
 dejavu-sans-fonts \
 js-jquery \
 php-bcmath \
 php-common \
 php-fpm \
 php-gd \
 php-ldap \
 php-mbstring \
 php-xml \
 virtual/zabbix7.0-web-database_eq_7.0.26-1.el10_1 \
 zabbix7.0 \
"
RDEPENDS:zabbix7.0-web-mysql = " \
 php-mysqlnd \
 zabbix7.0-web \
 "
RDEPENDS:zabbix7.0-web-pgsql = " \
 php-pgsql \
 zabbix7.0-web \
 "
