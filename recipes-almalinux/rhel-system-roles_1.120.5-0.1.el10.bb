# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rhel-system-roles"
PV = "1.120.5"
PR = "0.1.el10"
PACKAGES = " \
 rhel-system-roles \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rhel-system-roles-1.120.5-0.1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ffefc7cfa17abd64d7e56113c9235690b90c937fb8aa38bcf054bd4deaf150f"

URI_x86_64_v2_rhel-system-roles = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rhel-system-roles-1.120.5-0.1.el10.noarch.rpm;name=x86_64_v2_rhel-system-roles;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rhel-system-roles}"
SRC_URI[x86_64_v2_rhel-system-roles.sha256sum] = "a6f192c227498515966d9b5caab6931674c071727d593f05938f4281d02c04ed"

URI_aarch64_rhel-system-roles = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rhel-system-roles-1.120.5-0.1.el10.noarch.rpm;name=aarch64_rhel-system-roles;unpack=0"
SRC_URI:append = " ${URI_aarch64_rhel-system-roles}"
SRC_URI[aarch64_rhel-system-roles.sha256sum] = "a6f192c227498515966d9b5caab6931674c071727d593f05938f4281d02c04ed"

RDEPENDS:rhel-system-roles = " \
 ansible-core \
 bash \
 python-unversioned-command \
 virtual//usr/bin/env \
 "
