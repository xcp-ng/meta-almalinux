# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apache-commons-beanutils"
PV = "1.9.4"
PR = "21.el10"
PACKAGES = " \
 apache-commons-beanutils \
 apache-commons-beanutils-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/apache-commons-beanutils-1.9.4-21.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca2ca00d8f64d9d8fa5ae439c31ed0d81ab3ee76b5c4c0e48d7740741a395da0"

URI_x86_64_v2_apache-commons-beanutils = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/apache-commons-beanutils-1.9.4-21.el10.noarch.rpm;name=x86_64_v2_apache-commons-beanutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apache-commons-beanutils}"
SRC_URI[x86_64_v2_apache-commons-beanutils.sha256sum] = "36c125783994b15e9d5c3c46a637d12646cf677f8a149a2f90a4f315eed12ffd"

URI_x86_64_v2_apache-commons-beanutils-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/apache-commons-beanutils-javadoc-1.9.4-21.el10.noarch.rpm;name=x86_64_v2_apache-commons-beanutils-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apache-commons-beanutils-javadoc}"
SRC_URI[x86_64_v2_apache-commons-beanutils-javadoc.sha256sum] = "ce48a95ded25d0db4728baef17de39f041e8a21b3c1005b8392ec7739b667aca"

URI_aarch64_apache-commons-beanutils = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/apache-commons-beanutils-1.9.4-21.el10.noarch.rpm;name=aarch64_apache-commons-beanutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_apache-commons-beanutils}"
SRC_URI[aarch64_apache-commons-beanutils.sha256sum] = "36c125783994b15e9d5c3c46a637d12646cf677f8a149a2f90a4f315eed12ffd"

URI_aarch64_apache-commons-beanutils-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/apache-commons-beanutils-javadoc-1.9.4-21.el10.noarch.rpm;name=aarch64_apache-commons-beanutils-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_apache-commons-beanutils-javadoc}"
SRC_URI[aarch64_apache-commons-beanutils-javadoc.sha256sum] = "ce48a95ded25d0db4728baef17de39f041e8a21b3c1005b8392ec7739b667aca"

RDEPENDS:apache-commons-beanutils = " \
 apache-commons-collections \
 apache-commons-logging \
 javapackages-filesystem \
 "
RDEPENDS:apache-commons-beanutils-javadoc = " \
 javapackages-filesystem \
 "
