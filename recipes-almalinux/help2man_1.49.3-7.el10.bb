# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "help2man"
PV = "1.49.3"
PR = "7.el10"
PACKAGES = " \
 help2man \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/help2man-1.49.3-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3337be1d4e91af105a8485490b360802b435d45b55f47c03ed81a38b68ad1ec9"

URI_x86_64_v2_help2man = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/help2man-1.49.3-7.el10.noarch.rpm;name=x86_64_v2_help2man;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_help2man}"
SRC_URI[x86_64_v2_help2man.sha256sum] = "710c2c5f4fcb96d6e29d182e2eaf9edf341e31c5f683ab406d0614be502337b3"

URI_aarch64_help2man = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/help2man-1.49.3-7.el10.noarch.rpm;name=aarch64_help2man;unpack=0"
SRC_URI:append = " ${URI_aarch64_help2man}"
SRC_URI[aarch64_help2man.sha256sum] = "710c2c5f4fcb96d6e29d182e2eaf9edf341e31c5f683ab406d0614be502337b3"

RDEPENDS:help2man = " \
 perl-Getopt-Long \
 perl-POSIX \
 perl-Text-ParseWords \
 perl-Text-Tabs+Wrap \
 perl-interpreter \
 perl-libs \
 "
