# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clamav"
PV = "1.4.3"
PR = "3.el10_2"
PACKAGES = " \
 clamav \
 clamav-data \
 clamav-devel \
 clamav-doc \
 clamav-filesystem \
 clamav-freshclam \
 clamav-lib \
 clamav-milter \
 clamd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/clamav-1.4.3-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "39183f00729f594bab2cdaea9b32885f2c2110f3567d52d272627e772b993882"

URI_x86_64_v2_clamav = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-1.4.3-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamav;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamav}"
SRC_URI[x86_64_v2_clamav.sha256sum] = "b935e4eeb81d0cb207da1ed92feac6706f29bf05b8b172fba4b203bcd36594cb"

URI_x86_64_v2_clamav-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-data-1.4.3-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_clamav-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamav-data}"
SRC_URI[x86_64_v2_clamav-data.sha256sum] = "7dd07ec49fe4686c0add075bf2219e7a1fdd1b6b84ac998dd0ebeaf9169d7338"
RPROVIDES:clamav-data:x86_64_v2 = "virtual/data_clamav_"

URI_x86_64_v2_clamav-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-devel-1.4.3-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamav-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamav-devel}"
SRC_URI[x86_64_v2_clamav-devel.sha256sum] = "718815ec1038766bad458e6be2d660868c7c4d112db2fed4e2f24169b03899b3"

URI_x86_64_v2_clamav-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-doc-1.4.3-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_clamav-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamav-doc}"
SRC_URI[x86_64_v2_clamav-doc.sha256sum] = "edc3cae4aea4e624f94466ab060298f51a9fa60916aa92c21a5be00d493106dd"

URI_x86_64_v2_clamav-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-filesystem-1.4.3-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_clamav-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamav-filesystem}"
SRC_URI[x86_64_v2_clamav-filesystem.sha256sum] = "587ef64185ef6acbcd682327658f151887e4fc46c13966b644ad34a24d83dc51"

URI_x86_64_v2_clamav-freshclam = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-freshclam-1.4.3-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamav-freshclam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamav-freshclam}"
SRC_URI[x86_64_v2_clamav-freshclam.sha256sum] = "cafc42816bfb8577aacb5d5dc7a6901bb137b461106fcdec34ca677d4c3367df"
RPROVIDES:clamav-freshclam:x86_64_v2 = "virtual/data_clamav_"

URI_x86_64_v2_clamav-lib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-lib-1.4.3-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamav-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamav-lib}"
SRC_URI[x86_64_v2_clamav-lib.sha256sum] = "ee3405b654a6dc2ff42705c608dba93505606640f920ef979388a4db179d4e32"

URI_x86_64_v2_clamav-milter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-milter-1.4.3-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamav-milter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamav-milter}"
SRC_URI[x86_64_v2_clamav-milter.sha256sum] = "7863a748ed7f23af0a808bf3712bcff4d57d0295e36dc281165ab062cfdadfed"

URI_x86_64_v2_clamd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamd-1.4.3-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamd}"
SRC_URI[x86_64_v2_clamd.sha256sum] = "f0e918445cab73f8fd48232e3a810908ea86e132822ebcb4adc57f222567e4e0"

URI_aarch64_clamav = "${EPEL_MIRROR}/aarch64/Packages/c/clamav-1.4.3-3.el10_2.aarch64.rpm;name=aarch64_clamav;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamav}"
SRC_URI[aarch64_clamav.sha256sum] = "3be782f0d35d4f2bb0da33d53dd8b893cd2906e37a0d059abe919c40d6fde8fb"

URI_aarch64_clamav-data = "${EPEL_MIRROR}/aarch64/Packages/c/clamav-data-1.4.3-3.el10_2.noarch.rpm;name=aarch64_clamav-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamav-data}"
SRC_URI[aarch64_clamav-data.sha256sum] = "d0562ec6e8e5b4253c1576a17760603af5ecd6f738f464a18939f2a084469137"
RPROVIDES:clamav-data:aarch64 = "virtual/data_clamav_"

URI_aarch64_clamav-devel = "${EPEL_MIRROR}/aarch64/Packages/c/clamav-devel-1.4.3-3.el10_2.aarch64.rpm;name=aarch64_clamav-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamav-devel}"
SRC_URI[aarch64_clamav-devel.sha256sum] = "a53252c5ce237de5c4d286e21158229086a002f8c8e2da799005280a518103df"

URI_aarch64_clamav-doc = "${EPEL_MIRROR}/aarch64/Packages/c/clamav-doc-1.4.3-3.el10_2.noarch.rpm;name=aarch64_clamav-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamav-doc}"
SRC_URI[aarch64_clamav-doc.sha256sum] = "fb41892fac901d3cd671b0a86e272494de9aaff051a5c0c339b043ad117d06d7"

URI_aarch64_clamav-filesystem = "${EPEL_MIRROR}/aarch64/Packages/c/clamav-filesystem-1.4.3-3.el10_2.noarch.rpm;name=aarch64_clamav-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamav-filesystem}"
SRC_URI[aarch64_clamav-filesystem.sha256sum] = "7660c18818d2bb9088ea7bfd8ed19519d7e01b4b82e210e847262be5d8c43797"

URI_aarch64_clamav-freshclam = "${EPEL_MIRROR}/aarch64/Packages/c/clamav-freshclam-1.4.3-3.el10_2.aarch64.rpm;name=aarch64_clamav-freshclam;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamav-freshclam}"
SRC_URI[aarch64_clamav-freshclam.sha256sum] = "619a2462f6fa1f9603d484012e0a59451d32d310e86630ec5de134d4921a1cb1"
RPROVIDES:clamav-freshclam:aarch64 = "virtual/data_clamav_"

URI_aarch64_clamav-lib = "${EPEL_MIRROR}/aarch64/Packages/c/clamav-lib-1.4.3-3.el10_2.aarch64.rpm;name=aarch64_clamav-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamav-lib}"
SRC_URI[aarch64_clamav-lib.sha256sum] = "4ac34f83ebd33123edf932b54b25b3833d6032fd29c7373ac17c8087c7ead2c6"

URI_aarch64_clamav-milter = "${EPEL_MIRROR}/aarch64/Packages/c/clamav-milter-1.4.3-3.el10_2.aarch64.rpm;name=aarch64_clamav-milter;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamav-milter}"
SRC_URI[aarch64_clamav-milter.sha256sum] = "131d1498fd5242ecaa8c4c5d999f1822f5b01d532e635c34b4b41537fbea0d33"

URI_aarch64_clamd = "${EPEL_MIRROR}/aarch64/Packages/c/clamd-1.4.3-3.el10_2.aarch64.rpm;name=aarch64_clamd;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamd}"
SRC_URI[aarch64_clamd.sha256sum] = "e119bed6919ffd1ea3038ff1766c7cb3e9bb597dd826408a63e482f1673d3d9d"

RDEPENDS:clamav = " \
 bash \
 clamav-filesystem \
 clamav-lib \
 glibc \
 json-c \
 libgcc \
 ncurses-libs \
 systemd \
 virtual/data_clamav_ \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:clamav-data = " \
 bash \
 clamav-filesystem \
 "
RDEPENDS:clamav-devel = " \
 bash \
 clamav-filesystem \
 clamav-freshclam \
 clamav-lib \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:clamav-doc = " \
 clamav-filesystem \
 "
RDEPENDS:clamav-filesystem = " \
 "
RDEPENDS:clamav-freshclam = " \
 bash \
 clamav-filesystem \
 clamav-lib \
 glibc \
 libgcc \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:clamav-lib = " \
 bzip2-libs \
 glibc \
 json-c \
 libgcc \
 libxml2 \
 openssl-libs \
 pcre2 \
 zlib-ng-compat \
 "
RDEPENDS:clamav-milter = " \
 bash \
 clamav-filesystem \
 clamav-lib \
 clamd \
 glibc \
 sendmail-milter \
 "
RDEPENDS:clamd = " \
 bash \
 clamav-filesystem \
 clamav-lib \
 glibc \
 systemd-libs \
 virtual/coreutils \
 virtual/data_clamav_ \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/data_clamav_"

PROVIDES:append:aarch64 = " rpm/virtual/data_clamav_"
