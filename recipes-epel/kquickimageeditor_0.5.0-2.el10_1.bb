# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kquickimageeditor"
PV = "0.5.0"
PR = "2.el10_1"
PACKAGES = " \
 kquickimageeditor-qt6 \
 kquickimageeditor-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kquickimageeditor-0.5.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "57ff728e6b1c8f76a4d0737b8be203d8cd36be9c9cc44bdd9147580ad73563a5"

URI_x86_64_v2_kquickimageeditor-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kquickimageeditor-qt6-0.5.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kquickimageeditor-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kquickimageeditor-qt6}"
SRC_URI[x86_64_v2_kquickimageeditor-qt6.sha256sum] = "0b82be0ee4b40a80d56e2dc43ab61d792100f301e243a69abe7bf0b7bcb0f498"

URI_x86_64_v2_kquickimageeditor-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kquickimageeditor-qt6-devel-0.5.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kquickimageeditor-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kquickimageeditor-qt6-devel}"
SRC_URI[x86_64_v2_kquickimageeditor-qt6-devel.sha256sum] = "eb313d2797ea1132b9b44e55ed2ea32267979a08295bae81d69e06dcb4bd8b99"

URI_aarch64_kquickimageeditor-qt6 = "${EPEL_MIRROR}/aarch64/Packages/k/kquickimageeditor-qt6-0.5.0-2.el10_1.aarch64.rpm;name=aarch64_kquickimageeditor-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_kquickimageeditor-qt6}"
SRC_URI[aarch64_kquickimageeditor-qt6.sha256sum] = "4973153877c4fe054ac23a4fec7721b5821dd71f22f1a91b516e87dc68538aab"

URI_aarch64_kquickimageeditor-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kquickimageeditor-qt6-devel-0.5.0-2.el10_1.aarch64.rpm;name=aarch64_kquickimageeditor-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kquickimageeditor-qt6-devel}"
SRC_URI[aarch64_kquickimageeditor-qt6-devel.sha256sum] = "0639d2d2a7472cc33a731dc7f74832b11de878d337b9fd4f120b54640524efae"

RDEPENDS:kquickimageeditor-qt6 = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kquickimageeditor-qt6-devel = " \
 cmake-filesystem \
 kquickimageeditor-qt6 \
 "
