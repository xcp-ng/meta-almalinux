# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-makefun"
PV = "1.16.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-makefun \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-makefun-1.16.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3b241ecb2f299c28ed10e7dbff84827863b696aa046b3119739faedebc98c5f3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-makefun-1.16.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-makefun;unpack=0"
SRC_URI[x86_64_v2_python3-makefun.sha256sum] = "81608df1833e70bf958d3881fe1b763ace73d552f355ad401d921c38347389d3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-makefun-1.16.0-1.el10_3.noarch.rpm;name=aarch64_python3-makefun;unpack=0"
SRC_URI[aarch64_python3-makefun.sha256sum] = "bd84cbcd46ee7a21e2685feecdcce836d7f4df87fb4a1dd3e2f2ac3024d95d23"

RDEPENDS:python3-makefun = " \
 python3 \
 "
