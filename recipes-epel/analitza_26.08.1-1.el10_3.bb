# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "analitza"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 analitza \
 analitza-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/analitza-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0e1fd9ce1805cfbedc7f8e7274ec3cc676061328da0bbe91ebdcbe249deca8fe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/analitza-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_analitza;unpack=0"
SRC_URI[x86_64_v2_analitza.sha256sum] = "180266ee8e846944441cbadae6d1acfe2ec2b2d05bb9b2b8ccefb46dec9d0e71"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/analitza-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_analitza-devel;unpack=0"
SRC_URI[x86_64_v2_analitza-devel.sha256sum] = "af21efad8197a74fa7a872b1aef46520c2545fb1a8e44587dd7fbb4b84c4306f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/analitza-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_analitza;unpack=0"
SRC_URI[aarch64_analitza.sha256sum] = "dcbb00d00bd812ec0b5a88908880394ab1cad17c142938aaad1e32a7717bfa04"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/analitza-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_analitza-devel;unpack=0"
SRC_URI[aarch64_analitza-devel.sha256sum] = "d0730ed6ffea92adc3d3dd5741e55be72f4a1ec3ae529ad281020fdf026f8a5b"

RDEPENDS:analitza = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 "
RDEPENDS:analitza-devel = " \
 analitza \
 cmake-filesystem \
 "
