# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-IO-stringy"
PV = "2.113"
PR = "17.el10"
PACKAGES = " \
 perl-IO-stringy \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-IO-stringy-2.113-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "755b117242a1dadbf55b1ca4db43846f95cb3daba02961cc658f27352c6b8970"

URI_x86_64_v2_perl-IO-stringy = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-IO-stringy-2.113-17.el10.noarch.rpm;name=x86_64_v2_perl-IO-stringy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-IO-stringy}"
SRC_URI[x86_64_v2_perl-IO-stringy.sha256sum] = "b8a57808ace94c261130fac5cefdb13c5a2115200d9b96eab9867e769e38c0ea"

URI_aarch64_perl-IO-stringy = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-IO-stringy-2.113-17.el10.noarch.rpm;name=aarch64_perl-IO-stringy;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-IO-stringy}"
SRC_URI[aarch64_perl-IO-stringy.sha256sum] = "b8a57808ace94c261130fac5cefdb13c5a2115200d9b96eab9867e769e38c0ea"

RDEPENDS:perl-IO-stringy = " \
 perl-Carp \
 perl-Exporter \
 perl-FileHandle \
 perl-IO \
 perl-IO-stringy \
 perl-Symbol \
 perl-libs \
 perl-overload \
 perl-parent \
 perl-vars \
 "
