# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-initial-setup"
PV = "46.7"
PR = "3.el10.alma.3"
PACKAGES = " \
 gnome-initial-setup \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-initial-setup-46.7-3.el10.alma.3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63cda13bb1447fafb012c81c4ab9044fc381f92a7c7dde96e9850851dc1bd89c"

URI_x86_64_v2_gnome-initial-setup = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-initial-setup-46.7-3.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_gnome-initial-setup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-initial-setup}"
SRC_URI[x86_64_v2_gnome-initial-setup.sha256sum] = "a9cc45f59f5135366a1949c8408159fcd06a6cc33eba29c54afffe0fe2e00085"

URI_aarch64_gnome-initial-setup = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-initial-setup-46.7-3.el10.alma.3.aarch64.rpm;name=aarch64_gnome-initial-setup;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-initial-setup}"
SRC_URI[aarch64_gnome-initial-setup.sha256sum] = "a6360528628884e61f5b3dd6250f5dc96a771baa66b69b57134f9a6436eab20c"

RDEPENDS:gnome-initial-setup = " \
 NetworkManager-libnm \
 accountsservice-libs \
 bash \
 fontconfig \
 gdk-pixbuf2 \
 gdm \
 geoclue2-libs \
 geocode-glib \
 glib2 \
 glibc \
 gnome-desktop4 \
 gtk4 \
 harfbuzz \
 ibus-libs \
 krb5-libs \
 libadwaita \
 libgcc \
 libgweather \
 libnma-gtk4 \
 libpwquality \
 libsecret \
 pango \
 polkit \
 polkit-libs \
 shadow-utils \
 tecla \
 "
