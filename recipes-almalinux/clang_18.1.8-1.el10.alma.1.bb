# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clang"
PV = "18.1.8"
PR = "1.el10.alma.1"
PACKAGES = " \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/clang-18.1.8-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c20d7da70684c631c197405e67ab62590e01b3f35adeee22a9cca44b4c8aaaa1"

