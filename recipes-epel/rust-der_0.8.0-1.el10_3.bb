# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-der"
PV = "0.8.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-der+alloc-devel \
 rust-der+arbitrary-devel \
 rust-der+ber-devel \
 rust-der+bytes-devel \
 rust-der+default-devel \
 rust-der+derive-devel \
 rust-der+flagset-devel \
 rust-der+heapless-devel \
 rust-der+oid-devel \
 rust-der+pem-devel \
 rust-der+real-devel \
 rust-der+std-devel \
 rust-der+time-devel \
 rust-der+zeroize-devel \
 rust-der-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-der-0.8.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "598394148c2dbd242f4a653082821a165517049dc7971b33c2fc0804b21831d5"

URI_x86_64_v2_rust-der+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+alloc-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+alloc-devel}"
SRC_URI[x86_64_v2_rust-der+alloc-devel.sha256sum] = "93a4a0f012873e53153f9630e15ff9f8ee686e4a2e10e2e13620328b92c10927"

URI_x86_64_v2_rust-der+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+arbitrary-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-der+arbitrary-devel.sha256sum] = "7142a9255fc6c06db58759447479a60104881089be20fc126857400c54620de9"

URI_x86_64_v2_rust-der+ber-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+ber-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+ber-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+ber-devel}"
SRC_URI[x86_64_v2_rust-der+ber-devel.sha256sum] = "82be890a623aee00713ed5fa725ccfbe21bedbdd6242b379c1d1c7c5f6722988"

URI_x86_64_v2_rust-der+bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+bytes-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+bytes-devel}"
SRC_URI[x86_64_v2_rust-der+bytes-devel.sha256sum] = "5603af5c9c1bed76c2e728b35b7c33b33ba848d72384198214e7d264ebabb688"

URI_x86_64_v2_rust-der+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+default-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+default-devel}"
SRC_URI[x86_64_v2_rust-der+default-devel.sha256sum] = "7cb127e262cc30aaaead9a26074369561aa8f5b802eff3267cf8acaff5f08648"

URI_x86_64_v2_rust-der+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+derive-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+derive-devel}"
SRC_URI[x86_64_v2_rust-der+derive-devel.sha256sum] = "14a882e5663a4dad81a2abac34ca64f9386689bbb658e8f242d4b6a75570349a"

URI_x86_64_v2_rust-der+flagset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+flagset-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+flagset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+flagset-devel}"
SRC_URI[x86_64_v2_rust-der+flagset-devel.sha256sum] = "6e2d3edb5fb5b0010a2e62073c883189c2bd75507088b6a8359c91c443a8d772"

URI_x86_64_v2_rust-der+heapless-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+heapless-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+heapless-devel}"
SRC_URI[x86_64_v2_rust-der+heapless-devel.sha256sum] = "9709dbdd2631c511ca7e8a1f305fdb09e7f2faf3a383b73b0b2331f2f8b1d08c"

URI_x86_64_v2_rust-der+oid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+oid-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+oid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+oid-devel}"
SRC_URI[x86_64_v2_rust-der+oid-devel.sha256sum] = "a9693ded2d7aa551e01f38f9db828d628362679bf6f7c010b54e44efab4b162f"

URI_x86_64_v2_rust-der+pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+pem-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+pem-devel}"
SRC_URI[x86_64_v2_rust-der+pem-devel.sha256sum] = "4f31c39a4d0952ca3ab3ec6128696784ec1fc974973ffaaf8208db72d4984573"

URI_x86_64_v2_rust-der+real-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+real-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+real-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+real-devel}"
SRC_URI[x86_64_v2_rust-der+real-devel.sha256sum] = "639d9d145d5bbf092605481c3efd85aed15fa5f8f0f46e537865a7ce937fb3ac"

URI_x86_64_v2_rust-der+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+std-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+std-devel}"
SRC_URI[x86_64_v2_rust-der+std-devel.sha256sum] = "4244624b152e7ee6cd98c8e777586a5585c64f9f07e330b5b7713c7d5945b489"

URI_x86_64_v2_rust-der+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+time-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+time-devel}"
SRC_URI[x86_64_v2_rust-der+time-devel.sha256sum] = "88b6c490a2982d6be18b05c95b36923e50946ba75febe32a834cec0838f816a3"

URI_x86_64_v2_rust-der+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+zeroize-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+zeroize-devel}"
SRC_URI[x86_64_v2_rust-der+zeroize-devel.sha256sum] = "d986e8ebf96ccc97c8745132cbdb5dc8067d86b8e92e433b8af12514d4296d4b"

URI_x86_64_v2_rust-der-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der-devel}"
SRC_URI[x86_64_v2_rust-der-devel.sha256sum] = "bb7447c6b419285f97a24f965919f1e2159cb09a3c3b2fa6994988ecbcd63a97"

URI_aarch64_rust-der+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+alloc-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-der+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+alloc-devel}"
SRC_URI[aarch64_rust-der+alloc-devel.sha256sum] = "4ff1e6f9db0555d262a441f3164254849d4074d3bc61033f0e31a813d45d9921"

URI_aarch64_rust-der+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+arbitrary-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-der+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+arbitrary-devel}"
SRC_URI[aarch64_rust-der+arbitrary-devel.sha256sum] = "b711cc7668fc70104bcc4e5f952bc2bacdfe2cd60249fa1b4b0a19d9e2de1fb5"

URI_aarch64_rust-der+ber-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+ber-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-der+ber-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+ber-devel}"
SRC_URI[aarch64_rust-der+ber-devel.sha256sum] = "c54b4b31a22d32b3458fb12a212bff308fb1deb8090c38e94e92fc9fa8474f8e"

URI_aarch64_rust-der+bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+bytes-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-der+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+bytes-devel}"
SRC_URI[aarch64_rust-der+bytes-devel.sha256sum] = "63de2e5976fb02622b904e294af3985f0429f1576310d4eb5d3163d084c37fcb"

URI_aarch64_rust-der+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+default-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-der+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+default-devel}"
SRC_URI[aarch64_rust-der+default-devel.sha256sum] = "758a70edc828a70dbc5a1f49fcef16f7224c23e1fe89b50e0c07d4695ea2816d"

URI_aarch64_rust-der+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+derive-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-der+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+derive-devel}"
SRC_URI[aarch64_rust-der+derive-devel.sha256sum] = "8c35a966f5136fe38b9b78c86f0b45ada7e0961b49919db6fedc168f647e3ff4"

URI_aarch64_rust-der+flagset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+flagset-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-der+flagset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+flagset-devel}"
SRC_URI[aarch64_rust-der+flagset-devel.sha256sum] = "38e0fec8c8da90cd4182835ce1aecfdb1ec28ea8b2e9a0403c86cb91c03ec026"

URI_aarch64_rust-der+heapless-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+heapless-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-der+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+heapless-devel}"
SRC_URI[aarch64_rust-der+heapless-devel.sha256sum] = "c35a3cc11694f907e95086912cfbda520e2ecb0d73e4ca030e7a51c0219bcee7"

URI_aarch64_rust-der+oid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+oid-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-der+oid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+oid-devel}"
SRC_URI[aarch64_rust-der+oid-devel.sha256sum] = "c6f40eb6b3945686cb760fac0df9bd6c043d86efa4739c04d5044349d8697f53"

URI_aarch64_rust-der+pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+pem-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-der+pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+pem-devel}"
SRC_URI[aarch64_rust-der+pem-devel.sha256sum] = "0539b4c3495eeabe593d5719a12e847eb07a293d59501ac1087ba02803fcb31d"

URI_aarch64_rust-der+real-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+real-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-der+real-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+real-devel}"
SRC_URI[aarch64_rust-der+real-devel.sha256sum] = "4e43c1849ee459634ce34461f7e7e66cfc14198dd68bac4ba9fac7194231d62a"

URI_aarch64_rust-der+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+std-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-der+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+std-devel}"
SRC_URI[aarch64_rust-der+std-devel.sha256sum] = "23122297bfa3098117aec79efc129d3a6e3010e020e1b8f9b73d96e2760c7d6b"

URI_aarch64_rust-der+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+time-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-der+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+time-devel}"
SRC_URI[aarch64_rust-der+time-devel.sha256sum] = "e754d84196549a0e5b7973a65b1cf131f5b2c38fe7fc263a5bc92296e14f37ca"

URI_aarch64_rust-der+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+zeroize-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-der+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+zeroize-devel}"
SRC_URI[aarch64_rust-der+zeroize-devel.sha256sum] = "d2e0f640725b6aa3ec343487c196494bd7e7859fe516d31c0e441b7948916f4b"

URI_aarch64_rust-der-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-der-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der-devel}"
SRC_URI[aarch64_rust-der-devel.sha256sum] = "e1bbf80818c7d80bb1724b58e5c354a99128b5a95157304f24ef932971147e20"

RDEPENDS:rust-der+alloc-devel = " \
 cargo \
 rust-der-devel \
 rust-zeroize+alloc-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-der+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-const-oid+arbitrary-devel \
 rust-const-oid+default-devel \
 rust-der+std-devel \
 rust-der-devel \
 "
RDEPENDS:rust-der+ber-devel = " \
 cargo \
 rust-der-devel \
 "
RDEPENDS:rust-der+bytes-devel = " \
 cargo \
 rust-bytes-devel \
 rust-der+alloc-devel \
 rust-der-devel \
 "
RDEPENDS:rust-der+default-devel = " \
 cargo \
 rust-der-devel \
 "
RDEPENDS:rust-der+derive-devel = " \
 cargo \
 rust-der-devel \
 rust-der_derive+default-devel \
 "
RDEPENDS:rust-der+flagset-devel = " \
 cargo \
 rust-der-devel \
 rust-flagset+default-devel \
 "
RDEPENDS:rust-der+heapless-devel = " \
 cargo \
 rust-der-devel \
 rust-heapless-devel \
 "
RDEPENDS:rust-der+oid-devel = " \
 cargo \
 rust-const-oid+default-devel \
 rust-der-devel \
 "
RDEPENDS:rust-der+pem-devel = " \
 cargo \
 rust-der+alloc-devel \
 rust-der+zeroize-devel \
 rust-der-devel \
 rust-pem-rfc7468+alloc-devel \
 rust-pem-rfc7468+default-devel \
 "
RDEPENDS:rust-der+real-devel = " \
 cargo \
 rust-der-devel \
 "
RDEPENDS:rust-der+std-devel = " \
 cargo \
 rust-der+alloc-devel \
 rust-der-devel \
 "
RDEPENDS:rust-der+time-devel = " \
 cargo \
 rust-der-devel \
 rust-time-devel \
 "
RDEPENDS:rust-der+zeroize-devel = " \
 cargo \
 rust-der-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-der-devel = " \
 cargo \
 rust \
 "
