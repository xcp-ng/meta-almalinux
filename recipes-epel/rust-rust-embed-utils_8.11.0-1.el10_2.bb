# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rust-embed-utils"
PV = "8.11.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-rust-embed-utils+debug-embed-devel \
 rust-rust-embed-utils+default-devel \
 rust-rust-embed-utils+globset-devel \
 rust-rust-embed-utils+include-exclude-devel \
 rust-rust-embed-utils-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rust-embed-utils-8.11.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d91ae78812f5175fa024cc9d81a02c5ab8b2ac6bee907787dc1f6befb5bafd0c"

URI_x86_64_v2_rust-rust-embed-utils+debug-embed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-utils+debug-embed-devel-8.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-utils+debug-embed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-utils+debug-embed-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-utils+debug-embed-devel.sha256sum] = "4a52910d90e628a9f5916a2601e2e2535076f4ba189ce1ff84101be95ba9b414"

URI_x86_64_v2_rust-rust-embed-utils+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-utils+default-devel-8.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-utils+default-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-utils+default-devel.sha256sum] = "72f324e7d21903bd56a10ea0519897fc3d57ec6886d8a09c85a86cea13f5cb26"

URI_x86_64_v2_rust-rust-embed-utils+globset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-utils+globset-devel-8.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-utils+globset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-utils+globset-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-utils+globset-devel.sha256sum] = "4194016e1cd461e5a0e7da14fa2fa91a2129a169680ae9ba4e13c7e8089735eb"

URI_x86_64_v2_rust-rust-embed-utils+include-exclude-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-utils+include-exclude-devel-8.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-utils+include-exclude-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-utils+include-exclude-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-utils+include-exclude-devel.sha256sum] = "a1ea9fc94b7087463fcce1c2b4296a023262b9914a75310474dc72f9c277cf48"

URI_x86_64_v2_rust-rust-embed-utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-utils-devel-8.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-utils-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-utils-devel.sha256sum] = "2c53dc0246946e5f56afb23d677a91f7fd07b0b78e840afc9cc8aa0b62cacff1"

URI_aarch64_rust-rust-embed-utils+debug-embed-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-utils+debug-embed-devel-8.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust-embed-utils+debug-embed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-utils+debug-embed-devel}"
SRC_URI[aarch64_rust-rust-embed-utils+debug-embed-devel.sha256sum] = "68fd9f4426a12c6565bde72a0e4ad8a9dcdd9deab702ac5f6c832c55abc1eaae"

URI_aarch64_rust-rust-embed-utils+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-utils+default-devel-8.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust-embed-utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-utils+default-devel}"
SRC_URI[aarch64_rust-rust-embed-utils+default-devel.sha256sum] = "017a60e79af4e7f04f7ec9dd9517940fe240f8c133037f03ce0d5ef560d46a76"

URI_aarch64_rust-rust-embed-utils+globset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-utils+globset-devel-8.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust-embed-utils+globset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-utils+globset-devel}"
SRC_URI[aarch64_rust-rust-embed-utils+globset-devel.sha256sum] = "c1dcd20d47c564da4be80e703c11e8d140161857a2ad45f03fc988d4ff2d95f5"

URI_aarch64_rust-rust-embed-utils+include-exclude-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-utils+include-exclude-devel-8.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust-embed-utils+include-exclude-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-utils+include-exclude-devel}"
SRC_URI[aarch64_rust-rust-embed-utils+include-exclude-devel.sha256sum] = "47076a6a03eb32e09eca6fef65b70df399c074fe96051d81a80e2304459fb28d"

URI_aarch64_rust-rust-embed-utils-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-utils-devel-8.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust-embed-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-utils-devel}"
SRC_URI[aarch64_rust-rust-embed-utils-devel.sha256sum] = "40f68c54cf754c91315dbe2ccad4d8a090cbde003eea1555416a2261fdadac26"

RDEPENDS:rust-rust-embed-utils+debug-embed-devel = " \
 cargo \
 rust-rust-embed-utils-devel \
 "
RDEPENDS:rust-rust-embed-utils+default-devel = " \
 cargo \
 rust-rust-embed-utils-devel \
 "
RDEPENDS:rust-rust-embed-utils+globset-devel = " \
 cargo \
 rust-globset+default-devel \
 rust-rust-embed-utils-devel \
 "
RDEPENDS:rust-rust-embed-utils+include-exclude-devel = " \
 cargo \
 rust-rust-embed-utils+globset-devel \
 rust-rust-embed-utils-devel \
 "
RDEPENDS:rust-rust-embed-utils-devel = " \
 cargo \
 rust-sha2_0.10+default-devel \
 rust-walkdir+default-devel \
 "
