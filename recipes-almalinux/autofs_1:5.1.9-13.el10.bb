# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "autofs"
PE = "1"
PV = "5.1.9"
PR = "13.el10"
PACKAGES = " \
 autofs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/autofs-5.1.9-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "83eab5c6cbeb22984e83f7236fa772355754c1809bf41756098255e762b74004"

URI_x86_64_v2_autofs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/autofs-5.1.9-13.el10.x86_64_v2.rpm;name=x86_64_v2_autofs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_autofs}"
SRC_URI[x86_64_v2_autofs.sha256sum] = "d41b85d891a7a0fb616ce07250014b238c9d8c38f95e45a11edccc7b2eb2310a"

URI_aarch64_autofs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/autofs-5.1.9-13.el10.aarch64.rpm;name=aarch64_autofs;unpack=0"
SRC_URI:append = " ${URI_aarch64_autofs}"
SRC_URI[aarch64_autofs.sha256sum] = "a60c74e099531caccece6aa050d06a6f85289a8ffb16f7948f228e3a996b56c3"

RDEPENDS:autofs = " \
 bash \
 cyrus-sasl-lib \
 gawk \
 glibc \
 grep \
 kmod \
 krb5-libs \
 libcom_err \
 libgcc \
 libtirpc \
 libxml2 \
 openldap \
 procps-ng \
 sed \
 systemd \
 systemd-libs \
 virtual/coreutils \
 "
