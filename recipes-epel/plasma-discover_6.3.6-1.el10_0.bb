# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-discover"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 plasma-discover \
 plasma-discover-flatpak \
 plasma-discover-libs \
 plasma-discover-notifier \
 plasma-discover-offline-updates \
 plasma-discover-packagekit \
 plasma-discover-snap \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-discover-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0bd12fd52698208330d1fd34b8f170d905f2b979623cc1224610d451239b2423"

URI_x86_64_v2_plasma-discover = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-discover-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-discover;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-discover}"
SRC_URI[x86_64_v2_plasma-discover.sha256sum] = "896a7edba4c9276d78bf364a7e907f87dd1bc0a07e1558c697dc5b80eb8f17a0"

URI_x86_64_v2_plasma-discover-flatpak = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-discover-flatpak-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-discover-flatpak;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-discover-flatpak}"
SRC_URI[x86_64_v2_plasma-discover-flatpak.sha256sum] = "6f035e4728ce5ad36e84bbf348e3ce7c5649595d3383ae52c90c020ac6b8bef6"

URI_x86_64_v2_plasma-discover-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-discover-libs-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-discover-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-discover-libs}"
SRC_URI[x86_64_v2_plasma-discover-libs.sha256sum] = "b1837fb6a1a90d98ca7868cc00142d20ee13459b1c1ba5144814935785aa4b63"

URI_x86_64_v2_plasma-discover-notifier = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-discover-notifier-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-discover-notifier;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-discover-notifier}"
SRC_URI[x86_64_v2_plasma-discover-notifier.sha256sum] = "f8773ee9c8478a75bfdb6f8512c67655c947b8a40cb4f1bfa02d1a2a7ea92a8c"

URI_x86_64_v2_plasma-discover-offline-updates = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-discover-offline-updates-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-discover-offline-updates;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-discover-offline-updates}"
SRC_URI[x86_64_v2_plasma-discover-offline-updates.sha256sum] = "fbbdff220f07e0b7d1a32f1dbe2feb83c3008db09f7de00be8d5cfa897d123d5"

URI_x86_64_v2_plasma-discover-packagekit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-discover-packagekit-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-discover-packagekit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-discover-packagekit}"
SRC_URI[x86_64_v2_plasma-discover-packagekit.sha256sum] = "8f1c62c7e2761316bc7ab356132bfdd37ef241873126f6f23c6e7c7c9aa029e6"

URI_x86_64_v2_plasma-discover-snap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-discover-snap-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-discover-snap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-discover-snap}"
SRC_URI[x86_64_v2_plasma-discover-snap.sha256sum] = "5714ee26ee77fe120bcd65bd6322e340df5fd7b87aa77e5c524f958983da5330"

URI_aarch64_plasma-discover = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-discover-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-discover;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-discover}"
SRC_URI[aarch64_plasma-discover.sha256sum] = "90135855fe79cfb7399e8029f646d4949776f8075caeaf062488492234a0f5d5"

URI_aarch64_plasma-discover-flatpak = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-discover-flatpak-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-discover-flatpak;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-discover-flatpak}"
SRC_URI[aarch64_plasma-discover-flatpak.sha256sum] = "6d8a65861808a0b8a5c08745f376017da1b71b9da4ddfb47550fe56daa8311ad"

URI_aarch64_plasma-discover-libs = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-discover-libs-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-discover-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-discover-libs}"
SRC_URI[aarch64_plasma-discover-libs.sha256sum] = "0b7f948a784e890c68dea96b0e2b744b0a92befd6ee0efcb5ed1f414f00baebb"

URI_aarch64_plasma-discover-notifier = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-discover-notifier-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-discover-notifier;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-discover-notifier}"
SRC_URI[aarch64_plasma-discover-notifier.sha256sum] = "134f06f1531e60ef5fef477434d6acd6d994ad86cd1722ca49271aedaf68d78c"

URI_aarch64_plasma-discover-offline-updates = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-discover-offline-updates-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-discover-offline-updates;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-discover-offline-updates}"
SRC_URI[aarch64_plasma-discover-offline-updates.sha256sum] = "45ce00a4654a2de9c8bee70b9e404d23a5ff88ce4f3148aaa99e6b0bd653d757"

URI_aarch64_plasma-discover-packagekit = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-discover-packagekit-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-discover-packagekit;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-discover-packagekit}"
SRC_URI[aarch64_plasma-discover-packagekit.sha256sum] = "978cc76eb1fa3548263467733c29d3d343a53c1c529e0f43ef13b1d9b03d0ccb"

URI_aarch64_plasma-discover-snap = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-discover-snap-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-discover-snap;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-discover-snap}"
SRC_URI[aarch64_plasma-discover-snap.sha256sum] = "a3307273e3c31053671249d26ed2d2e234f6d128772d8838d71431c3dc9b05e5"

RDEPENDS:plasma-discover = " \
 glibc \
 kf6-kauth \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kirigami \
 kf6-kitemmodels \
 kf6-kjobwidgets \
 kf6-kstatusnotifieritem \
 kf6-kwindowsystem \
 kf6-purpose \
 kf6-qqc2-desktop-style \
 libstdc++ \
 plasma-discover-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebview \
 "
RDEPENDS:plasma-discover-flatpak = " \
 appstream-qt \
 flatpak \
 flatpak-kcm \
 flatpak-libs \
 glib2 \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kservice \
 libgcc \
 libstdc++ \
 plasma-discover \
 plasma-discover-libs \
 qcoro-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-discover-libs = " \
 appstream-qt \
 fwupd \
 glib2 \
 glibc \
 kf6-attica \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-knewstuff \
 kf6-kwidgetsaddons \
 libgcc \
 libstdc++ \
 qcoro-qt6 \
 qt5-qtquickcontrols2 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:plasma-discover-notifier = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kidletime \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 libstdc++ \
 plasma-discover \
 plasma-discover-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-discover-offline-updates = " \
 plasma-discover \
 "
RDEPENDS:plasma-discover-packagekit = " \
 PackageKit \
 PackageKit-Qt6 \
 appstream-qt \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-knotifications \
 kf6-kservice \
 libgcc \
 libmarkdown \
 libstdc++ \
 plasma-discover \
 plasma-discover-libs \
 qcoro-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-discover-snap = " \
 glibc \
 kf6-kauth \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 plasma-discover \
 plasma-discover-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 snapd \
 snapd-qt \
 "
