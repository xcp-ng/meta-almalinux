# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-universal-hash"
PV = "0.6.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-universal-hash+default-devel \
 rust-universal-hash-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-universal-hash-0.6.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c294148c7c6b69ba059a3b4a7888117ea4ba2dd46a418213c6dd432a28823e9"

URI_x86_64_v2_rust-universal-hash+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-universal-hash+default-devel-0.6.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-universal-hash+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-universal-hash+default-devel}"
SRC_URI[x86_64_v2_rust-universal-hash+default-devel.sha256sum] = "d6c7f960fdd6b84a7855696fc149504840f2656c34cf95d92b42bece95942f49"

URI_x86_64_v2_rust-universal-hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-universal-hash-devel-0.6.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-universal-hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-universal-hash-devel}"
SRC_URI[x86_64_v2_rust-universal-hash-devel.sha256sum] = "07654fb314dae66881aeeeae33ae850f2404bab184239be5e164403e6e4779ae"

URI_aarch64_rust-universal-hash+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-universal-hash+default-devel-0.6.1-1.el10_3.noarch.rpm;name=aarch64_rust-universal-hash+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-universal-hash+default-devel}"
SRC_URI[aarch64_rust-universal-hash+default-devel.sha256sum] = "b977e8d376c30e2498e52f9f2618933c4437ed06d27c77434ecd9a82ab921eba"

URI_aarch64_rust-universal-hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-universal-hash-devel-0.6.1-1.el10_3.noarch.rpm;name=aarch64_rust-universal-hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-universal-hash-devel}"
SRC_URI[aarch64_rust-universal-hash-devel.sha256sum] = "4ab2baf5f696a068328b2c87290040e08fd0311adbf2eefbcdf4cd5b8c83d3cf"

RDEPENDS:rust-universal-hash+default-devel = " \
 cargo \
 rust-universal-hash-devel \
 "
RDEPENDS:rust-universal-hash-devel = " \
 cargo \
 rust \
 rust-crypto-common+default-devel \
 rust-ctutils+default-devel \
 "
