# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_collator"
PV = "2.2.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-icu_collator+compiled_data-devel \
 rust-icu_collator+datagen-devel \
 rust-icu_collator+default-devel \
 rust-icu_collator+latin1-devel \
 rust-icu_collator+serde-devel \
 rust-icu_collator-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_collator-2.2.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "683d99ae07461db88c44d17ef533a257e1d500a347b186e9450a1cbdf4077947"

URI_x86_64_v2_rust-icu_collator+compiled_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collator+compiled_data-devel-2.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collator+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collator+compiled_data-devel}"
SRC_URI[x86_64_v2_rust-icu_collator+compiled_data-devel.sha256sum] = "d5167a6fa50e6108c729608bed3b6a0307fe7f0f2d3dc82bea8367a4ba324121"

URI_x86_64_v2_rust-icu_collator+datagen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collator+datagen-devel-2.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collator+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collator+datagen-devel}"
SRC_URI[x86_64_v2_rust-icu_collator+datagen-devel.sha256sum] = "4e81a63cef812c59fb39bd61e8b233e32b822c4f9d22b15f2bdf79599d69ebd8"

URI_x86_64_v2_rust-icu_collator+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collator+default-devel-2.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collator+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collator+default-devel}"
SRC_URI[x86_64_v2_rust-icu_collator+default-devel.sha256sum] = "c4e1153e90d71aae75cee96faaca0a42f6cd6f079b7901a96bb051009f209d2d"

URI_x86_64_v2_rust-icu_collator+latin1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collator+latin1-devel-2.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collator+latin1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collator+latin1-devel}"
SRC_URI[x86_64_v2_rust-icu_collator+latin1-devel.sha256sum] = "6339fe259cfe3a635e7a024050c4095089e98a816cdd852a04225fb63f19be01"

URI_x86_64_v2_rust-icu_collator+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collator+serde-devel-2.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collator+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collator+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_collator+serde-devel.sha256sum] = "a5547ca6563693d6d468aa0ef208fa90328cbb0afc6df6da2e8a8962b430b539"

URI_x86_64_v2_rust-icu_collator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collator-devel-2.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collator-devel}"
SRC_URI[x86_64_v2_rust-icu_collator-devel.sha256sum] = "0a017b966cbdc5848ad1e28bb45e4a6bb5ac3d296983fea6733af75fde53fe0b"

URI_aarch64_rust-icu_collator+compiled_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collator+compiled_data-devel-2.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-icu_collator+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collator+compiled_data-devel}"
SRC_URI[aarch64_rust-icu_collator+compiled_data-devel.sha256sum] = "6744974945adcb6868cf59c4767762bc9c09cf37358cea43f7c6231c78ac3fb8"

URI_aarch64_rust-icu_collator+datagen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collator+datagen-devel-2.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-icu_collator+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collator+datagen-devel}"
SRC_URI[aarch64_rust-icu_collator+datagen-devel.sha256sum] = "0f839e8222da7b06fdc4a44889a43632c5e90624547dc2ec3b35906bdc2b2fdf"

URI_aarch64_rust-icu_collator+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collator+default-devel-2.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-icu_collator+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collator+default-devel}"
SRC_URI[aarch64_rust-icu_collator+default-devel.sha256sum] = "f9370df21e6fc9ea6b274d8b1b6eb4d1de98783caed0e4b430c81428661ccb80"

URI_aarch64_rust-icu_collator+latin1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collator+latin1-devel-2.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-icu_collator+latin1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collator+latin1-devel}"
SRC_URI[aarch64_rust-icu_collator+latin1-devel.sha256sum] = "ebebe09a553516c659a6e2319cfff135290b16d30d1eaacbcfb0a7368170e48b"

URI_aarch64_rust-icu_collator+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collator+serde-devel-2.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-icu_collator+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collator+serde-devel}"
SRC_URI[aarch64_rust-icu_collator+serde-devel.sha256sum] = "4f9b217e9b020d77b0eb3e63cba642ba42219eb669a3713c3ffebd5901fdcdaf"

URI_aarch64_rust-icu_collator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collator-devel-2.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-icu_collator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collator-devel}"
SRC_URI[aarch64_rust-icu_collator-devel.sha256sum] = "2dcb09ad378810ae6aa28c2cc4abe9e083818cb7e92754fe7a75c58e0df8bb00"

RDEPENDS:rust-icu_collator+compiled_data-devel = " \
 cargo \
 rust-icu_collator-devel \
 rust-icu_collator_data-devel \
 rust-icu_locale+compiled_data-devel \
 rust-icu_locale-devel \
 rust-icu_normalizer+compiled_data-devel \
 rust-icu_provider+baked-devel \
 "
RDEPENDS:rust-icu_collator+datagen-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-icu_collator+serde-devel \
 rust-icu_collator-devel \
 rust-icu_collections+databake-devel \
 rust-icu_normalizer+datagen-devel \
 rust-icu_properties+datagen-devel \
 rust-icu_provider+export-devel \
 rust-zerovec+databake-devel \
 "
RDEPENDS:rust-icu_collator+default-devel = " \
 cargo \
 rust-icu_collator+compiled_data-devel \
 rust-icu_collator-devel \
 "
RDEPENDS:rust-icu_collator+latin1-devel = " \
 cargo \
 rust-icu_collator-devel \
 "
RDEPENDS:rust-icu_collator+serde-devel = " \
 cargo \
 rust-icu_collator-devel \
 rust-icu_collections+serde-devel \
 rust-icu_normalizer+serde-devel \
 rust-icu_properties+serde-devel \
 rust-icu_provider+serde-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerovec+serde-devel \
 "
RDEPENDS:rust-icu_collator-devel = " \
 cargo \
 rust \
 rust-icu_collections-devel \
 rust-icu_locale_core+alloc-devel \
 rust-icu_locale_core-devel \
 rust-icu_normalizer+utf16_iter-devel \
 rust-icu_normalizer+utf8_iter-devel \
 rust-icu_normalizer-devel \
 rust-icu_properties-devel \
 rust-icu_provider-devel \
 rust-smallvec+const_generics-devel \
 rust-smallvec+const_new-devel \
 rust-smallvec+union-devel \
 rust-smallvec-devel \
 rust-utf16_iter-devel \
 rust-utf8_iter-devel \
 rust-zerovec-devel \
 "
