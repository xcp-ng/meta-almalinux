# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kcalutils"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kcalutils \
 kcalutils-devel \
 kcalutils-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kcalutils-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d26cfedd6e31fc59ddf4b027ee7d2ca2fe6b48b227b6f4032514b153e082cf09"

URI_x86_64_v2_kcalutils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcalutils-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcalutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcalutils}"
SRC_URI[x86_64_v2_kcalutils.sha256sum] = "40be00cfc45a25a6440a4a0d83aa79c769c26bbc050e74100fd1a8bb69a304dc"

URI_x86_64_v2_kcalutils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcalutils-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcalutils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcalutils-devel}"
SRC_URI[x86_64_v2_kcalutils-devel.sha256sum] = "613982b643431eb266c99420e95a0485114ee8b8cd7626353c3911d5a27080c9"

URI_x86_64_v2_kcalutils-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcalutils-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kcalutils-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcalutils-doc}"
SRC_URI[x86_64_v2_kcalutils-doc.sha256sum] = "3d37f32f5ceb0b62e09d1993740feb529b0a33bb566e0ba1721ac8467e4e9a4c"

URI_aarch64_kcalutils = "${EPEL_MIRROR}/aarch64/Packages/k/kcalutils-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kcalutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcalutils}"
SRC_URI[aarch64_kcalutils.sha256sum] = "3b5165d4a369e8f97e56390c986b8b5b09ba52e4fec396b61b5d591d089f1f55"

URI_aarch64_kcalutils-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kcalutils-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kcalutils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcalutils-devel}"
SRC_URI[aarch64_kcalutils-devel.sha256sum] = "497bbb41ffb654180ac11ec5d5d54d4bb3ad5c3c64182fb8e9a9cb66fa21d035"

URI_aarch64_kcalutils-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kcalutils-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_kcalutils-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcalutils-doc}"
SRC_URI[aarch64_kcalutils-doc.sha256sum] = "993e8cf179aaee0ab94c67ae3bb4fab8ffc43c05844db74104d124ff3a226a58"

RDEPENDS:kcalutils = " \
 glibc \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-ktexttemplate \
 kf6-kwidgetsaddons \
 kidentitymanagement \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kcalutils-devel = " \
 cmake-filesystem \
 kcalutils \
 kf6-kcalendarcore-devel \
 kf6-kcoreaddons-devel \
 "
RDEPENDS:kcalutils-doc = " \
 "
