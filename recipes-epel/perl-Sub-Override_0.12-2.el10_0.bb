# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sub-Override"
PV = "0.12"
PR = "2.el10_0"
PACKAGES = " \
 perl-Sub-Override \
 perl-Sub-Override-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Sub-Override-0.12-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a682e60e39da5858cbfc645d31e0bbfaf8d3e46fc1a8091a3aa1f6d4384b4db"

URI_x86_64_v2_perl-Sub-Override = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sub-Override-0.12-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Sub-Override;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sub-Override}"
SRC_URI[x86_64_v2_perl-Sub-Override.sha256sum] = "31c83c3dcb4a334f9efcab49babd15caffa91cbcf0808179761929c2477b3bb0"

URI_x86_64_v2_perl-Sub-Override-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sub-Override-tests-0.12-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Sub-Override-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sub-Override-tests}"
SRC_URI[x86_64_v2_perl-Sub-Override-tests.sha256sum] = "e65de2cf2530191446c40e1aa1aa36ec628d2bd50432562e07ec76f32a878e96"

URI_aarch64_perl-Sub-Override = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Sub-Override-0.12-2.el10_0.noarch.rpm;name=aarch64_perl-Sub-Override;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sub-Override}"
SRC_URI[aarch64_perl-Sub-Override.sha256sum] = "b5cc43ee5536758ebac4b4fd97cd54ddbc58f4e9bb4072def67133d6572c001e"

URI_aarch64_perl-Sub-Override-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Sub-Override-tests-0.12-2.el10_0.noarch.rpm;name=aarch64_perl-Sub-Override-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sub-Override-tests}"
SRC_URI[aarch64_perl-Sub-Override-tests.sha256sum] = "af5aeb024778201ebd21dc7ff65d7187611e83e90e2bb7ee903941f192008f66"

RDEPENDS:perl-Sub-Override = " \
 perl-Carp \
 perl-Scalar-List-Utils \
 perl-libs \
 "
RDEPENDS:perl-Sub-Override-tests = " \
 bash \
 perl-Sub-Override \
 perl-Test-Fatal \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-lib \
 perl-libs \
 "
