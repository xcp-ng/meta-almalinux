# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "unzboot"
PV = "0.1~git.20250530.3ccaa1a"
PR = "2.el10_2"
PACKAGES = " \
 unzboot \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/unzboot-0.1~git.20250530.3ccaa1a-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "247253afb389399df73fc30d3bfa54ac221ea1cf8a413d800ec5e89ada17e1d6"

URI_x86_64_v2_unzboot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/unzboot-0.1~git.20250530.3ccaa1a-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_unzboot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unzboot}"
SRC_URI[x86_64_v2_unzboot.sha256sum] = "6770c92652aa4ade7fe70c9862d1e5b84fd3a61fd60d3e9484f22b14e16c1b1d"

URI_aarch64_unzboot = "${EPEL_MIRROR}/aarch64/Packages/u/unzboot-0.1~git.20250530.3ccaa1a-2.el10_2.aarch64.rpm;name=aarch64_unzboot;unpack=0"
SRC_URI:append = " ${URI_aarch64_unzboot}"
SRC_URI[aarch64_unzboot.sha256sum] = "c530b919d298b8389b3d2255a72512c21060c60faa627a6af1b07468cfe32bca"

RDEPENDS:unzboot = " \
 glib2 \
 glibc \
 libzstd \
 zlib-ng-compat \
 "
