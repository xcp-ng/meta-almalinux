# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qrencode"
PV = "4.1.1"
PR = "9.el10_0"
PACKAGES = " \
 qrencode \
 qrencode-devel \
 qrencode-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qrencode-4.1.1-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7ddd54abb49eddc353e11fc39da9cfaaac90756e7b2f5592de071af9803c7fb"

URI_x86_64_v2_qrencode = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qrencode-4.1.1-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qrencode;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qrencode}"
SRC_URI[x86_64_v2_qrencode.sha256sum] = "368b33eca2abf89054e951013e092931a90d571370b4050c2a512463823c3763"

URI_x86_64_v2_qrencode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qrencode-devel-4.1.1-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qrencode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qrencode-devel}"
SRC_URI[x86_64_v2_qrencode-devel.sha256sum] = "0ff5b6b8ab79143880280e842431429972904cc2600f37f019115be217a59912"

URI_x86_64_v2_qrencode-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qrencode-libs-4.1.1-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qrencode-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qrencode-libs}"
SRC_URI[x86_64_v2_qrencode-libs.sha256sum] = "9581b27642cf25cb2af5b6de2007f1142dcd5979cbc94f26576515db9a3d646f"

URI_aarch64_qrencode = "${EPEL_MIRROR}/aarch64/Packages/q/qrencode-4.1.1-9.el10_0.aarch64.rpm;name=aarch64_qrencode;unpack=0"
SRC_URI:append = " ${URI_aarch64_qrencode}"
SRC_URI[aarch64_qrencode.sha256sum] = "6df6484f934f14aea999d9a1f28fcd9e8bf6c18ed2bb2e1fd92c88141661f5a8"

URI_aarch64_qrencode-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qrencode-devel-4.1.1-9.el10_0.aarch64.rpm;name=aarch64_qrencode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qrencode-devel}"
SRC_URI[aarch64_qrencode-devel.sha256sum] = "bebeecccf841e6908a45ed658d1869af31a28e51144c1de655ab9a4fd055c25f"

URI_aarch64_qrencode-libs = "${EPEL_MIRROR}/aarch64/Packages/q/qrencode-libs-4.1.1-9.el10_0.aarch64.rpm;name=aarch64_qrencode-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_qrencode-libs}"
SRC_URI[aarch64_qrencode-libs.sha256sum] = "afc5552ae2535dd9f30376871373422c7f6accc2c9c4f03f40f53a9fe936e39b"

RDEPENDS:qrencode = " \
 glibc \
 libpng \
 qrencode-libs \
 "
RDEPENDS:qrencode-devel = " \
 pkgconf-pkg-config \
 qrencode-libs \
 "
RDEPENDS:qrencode-libs = " \
 glibc \
 "
