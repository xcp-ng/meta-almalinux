# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "orca"
PV = "48.0"
PR = "1.el10"
PACKAGES = " \
 orca \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/orca-48.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "32a6122684572b3ca0c374ba8729557e8514e5fc083378b3556c88ab54bf9296"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/orca-48.0-1.el10.noarch.rpm;name=x86_64_v2_orca;unpack=0"
SRC_URI[x86_64_v2_orca.sha256sum] = "b4b3aa717e24c1054667f0dc7f1afb3e94f4ee1ed98c35454dfd2026d7db25f8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/orca-48.0-1.el10.noarch.rpm;name=aarch64_orca;unpack=0"
SRC_URI[aarch64_orca.sha256sum] = "b4b3aa717e24c1054667f0dc7f1afb3e94f4ee1ed98c35454dfd2026d7db25f8"

RDEPENDS:orca = " \
 libwnck3 \
 python3 \
 python3-brlapi \
 python3-louis \
 python3-pyatspi \
 python3-speechd \
 speech-dispatcher \
 "
