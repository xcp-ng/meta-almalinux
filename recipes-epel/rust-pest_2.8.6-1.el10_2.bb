# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pest"
PV = "2.8.6"
PR = "1.el10_2"
PACKAGES = " \
 rust-pest+const_prec_climber-devel \
 rust-pest+default-devel \
 rust-pest+memchr-devel \
 rust-pest+miette-error-devel \
 rust-pest+pretty-print-devel \
 rust-pest+std-devel \
 rust-pest-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pest-2.8.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b13521831e0310d056b62b28b0db6eeb04e64c88794165528782fa41dbd784f"

URI_x86_64_v2_rust-pest+const_prec_climber-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest+const_prec_climber-devel-2.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest+const_prec_climber-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest+const_prec_climber-devel}"
SRC_URI[x86_64_v2_rust-pest+const_prec_climber-devel.sha256sum] = "9ee0d661bcf6e6c02b5caed1ac332f0a160430d3e34d9fbc3ee3dcc2fc7dee4b"

URI_x86_64_v2_rust-pest+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest+default-devel-2.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest+default-devel}"
SRC_URI[x86_64_v2_rust-pest+default-devel.sha256sum] = "06d76719fb871f42683848fc96d5920ddb247a01e0dbb265c60db0ff6c8a9068"

URI_x86_64_v2_rust-pest+memchr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest+memchr-devel-2.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest+memchr-devel}"
SRC_URI[x86_64_v2_rust-pest+memchr-devel.sha256sum] = "8754185043f19e6e2733193e2306f40feed1c358568fcc16b081b0a77409028b"

URI_x86_64_v2_rust-pest+miette-error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest+miette-error-devel-2.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest+miette-error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest+miette-error-devel}"
SRC_URI[x86_64_v2_rust-pest+miette-error-devel.sha256sum] = "38c9b3112acd3dcc7aa61c33b5154e1060f4117ca4e35d0f081df319226acb67"

URI_x86_64_v2_rust-pest+pretty-print-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest+pretty-print-devel-2.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest+pretty-print-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest+pretty-print-devel}"
SRC_URI[x86_64_v2_rust-pest+pretty-print-devel.sha256sum] = "94675f6bcbef83362368d9057a00be1145b343ea7f654288769ee8f74bc4d0b9"

URI_x86_64_v2_rust-pest+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest+std-devel-2.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest+std-devel}"
SRC_URI[x86_64_v2_rust-pest+std-devel.sha256sum] = "c73f63539541cb9bf087e38925304c68281b784a67c845299dbe452879996f68"

URI_x86_64_v2_rust-pest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest-devel-2.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest-devel}"
SRC_URI[x86_64_v2_rust-pest-devel.sha256sum] = "c2927e0513c2f29ba7aee83d949c86d42f1c6dbc7b35b11338f26e5c8548f306"

URI_aarch64_rust-pest+const_prec_climber-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest+const_prec_climber-devel-2.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-pest+const_prec_climber-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest+const_prec_climber-devel}"
SRC_URI[aarch64_rust-pest+const_prec_climber-devel.sha256sum] = "75a802c8caf17443fac6b1ea6fc2fc03b006db3883fb183cc21f8305a114b8a0"

URI_aarch64_rust-pest+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest+default-devel-2.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-pest+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest+default-devel}"
SRC_URI[aarch64_rust-pest+default-devel.sha256sum] = "0884790de6937de7fe4628211716b1951483e9b6133803ee6ed99ad2a12d0b33"

URI_aarch64_rust-pest+memchr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest+memchr-devel-2.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-pest+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest+memchr-devel}"
SRC_URI[aarch64_rust-pest+memchr-devel.sha256sum] = "97fad227ba684339b0bb69996beac998426b2eff96580a9b30073ee72d120b39"

URI_aarch64_rust-pest+miette-error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest+miette-error-devel-2.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-pest+miette-error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest+miette-error-devel}"
SRC_URI[aarch64_rust-pest+miette-error-devel.sha256sum] = "77209640073c1662dc0d169d9bf0189fe4bb7ce5370ac420bd7d2d2b322ae24b"

URI_aarch64_rust-pest+pretty-print-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest+pretty-print-devel-2.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-pest+pretty-print-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest+pretty-print-devel}"
SRC_URI[aarch64_rust-pest+pretty-print-devel.sha256sum] = "01e5e7c9599074fa2712335c86ae97b00bae0161f3a9725839c860ed478afdc3"

URI_aarch64_rust-pest+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest+std-devel-2.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-pest+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest+std-devel}"
SRC_URI[aarch64_rust-pest+std-devel.sha256sum] = "5752d94415a4330fc1f46b189497ed50c13e95bf43175d170b0ee3385e3ba2bf"

URI_aarch64_rust-pest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest-devel-2.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-pest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest-devel}"
SRC_URI[aarch64_rust-pest-devel.sha256sum] = "872f6540af7e11725ace1448c45dd554cad1bf805f14d360abad39ab11e1e934"

RDEPENDS:rust-pest+const_prec_climber-devel = " \
 cargo \
 rust-pest-devel \
 "
RDEPENDS:rust-pest+default-devel = " \
 cargo \
 rust-pest+memchr-devel \
 rust-pest+std-devel \
 rust-pest-devel \
 "
RDEPENDS:rust-pest+memchr-devel = " \
 cargo \
 rust-memchr+default-devel \
 rust-pest-devel \
 "
RDEPENDS:rust-pest+miette-error-devel = " \
 cargo \
 rust-miette+default-devel \
 rust-miette+fancy-devel \
 rust-pest+pretty-print-devel \
 rust-pest+std-devel \
 rust-pest-devel \
 "
RDEPENDS:rust-pest+pretty-print-devel = " \
 cargo \
 rust-pest-devel \
 rust-serde+default-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-pest+std-devel = " \
 cargo \
 rust-pest-devel \
 rust-ucd-trie+std-devel \
 "
RDEPENDS:rust-pest-devel = " \
 cargo \
 rust \
 rust-ucd-trie-devel \
 "
