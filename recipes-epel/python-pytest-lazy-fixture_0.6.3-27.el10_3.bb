# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-lazy-fixture"
PV = "0.6.3"
PR = "27.el10_3"
PACKAGES = " \
 python3-pytest-lazy-fixture \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-lazy-fixture-0.6.3-27.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a2f8e21f9909ad06b58b0f5f025d128f626dc943643d0d8e9e9cc8374e9fec79"

URI_x86_64_v2_python3-pytest-lazy-fixture = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-lazy-fixture-0.6.3-27.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-lazy-fixture;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-lazy-fixture}"
SRC_URI[x86_64_v2_python3-pytest-lazy-fixture.sha256sum] = "d15239dcc90c427d0bd7ffef0826ce124425cc2f90a2615ffc8c7c889194ff02"

URI_aarch64_python3-pytest-lazy-fixture = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-lazy-fixture-0.6.3-27.el10_3.noarch.rpm;name=aarch64_python3-pytest-lazy-fixture;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-lazy-fixture}"
SRC_URI[aarch64_python3-pytest-lazy-fixture.sha256sum] = "d48b96417a4d56cb85bf25168db0e989f21de928240025b0c02bbd652fc1365a"

RDEPENDS:python3-pytest-lazy-fixture = " \
 python3 \
 python3-pytest \
 "
