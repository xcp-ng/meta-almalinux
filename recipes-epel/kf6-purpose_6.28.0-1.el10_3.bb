# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-purpose"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-purpose \
 kf6-purpose-devel \
 kf6-purpose-doc \
 kf6-purpose-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-purpose-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3992481dc4ea7d031b9d1987a6c108fbc5d60d1c38f8a3b4897cfd248d723fbb"

URI_x86_64_v2_kf6-purpose = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-purpose-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-purpose;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-purpose}"
SRC_URI[x86_64_v2_kf6-purpose.sha256sum] = "b03651ec97fc54f032a85ad2cfd671a021b87b3e9702e5e38a3de2c8e01f4657"

URI_x86_64_v2_kf6-purpose-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-purpose-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-purpose-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-purpose-devel}"
SRC_URI[x86_64_v2_kf6-purpose-devel.sha256sum] = "c478363dd7946b45bec45ba0edf65b759574eee2f1ec7bc88bbc307105f71fb8"

URI_x86_64_v2_kf6-purpose-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-purpose-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-purpose-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-purpose-doc}"
SRC_URI[x86_64_v2_kf6-purpose-doc.sha256sum] = "0241fba13609c996b73fdf958cd95ed75cef5a5a59059894ec49f1626984dd3a"

URI_x86_64_v2_kf6-purpose-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-purpose-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-purpose-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-purpose-html}"
SRC_URI[x86_64_v2_kf6-purpose-html.sha256sum] = "cfaf2681a258f84a3c53206d227e8b9d9e23f9e1b6319f8cc498434d8a593e5f"

URI_aarch64_kf6-purpose = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-purpose-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-purpose;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-purpose}"
SRC_URI[aarch64_kf6-purpose.sha256sum] = "acfe752e63af0434c1a4ba08069751354991f5342f7b4d13099fcf94c55fbee1"

URI_aarch64_kf6-purpose-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-purpose-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-purpose-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-purpose-devel}"
SRC_URI[aarch64_kf6-purpose-devel.sha256sum] = "a48c70364d6b91baa65457dca407ac30180b9f43634df30ff32142916bdbbcf6"

URI_aarch64_kf6-purpose-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-purpose-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-purpose-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-purpose-doc}"
SRC_URI[aarch64_kf6-purpose-doc.sha256sum] = "df922bee4e3ce07e20183e0fe65f6c4a0e9365430829156d10dfa0fd6b0f5b60"

URI_aarch64_kf6-purpose-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-purpose-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-purpose-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-purpose-html}"
SRC_URI[aarch64_kf6-purpose-html.sha256sum] = "9187894780bfd314be067de2f2bce4b93c40bc24fe05eac6c9e5d41b58fddc8d"

RDEPENDS:kf6-purpose = " \
 accounts-qml-module-qt6 \
 glibc \
 hicolor-icon-theme \
 kaccounts-integration-qt6 \
 kf6-bluez-qt \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdeclarative \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-knotifications \
 kf6-kservice \
 kf6-prison \
 libaccounts-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-purpose-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kf6-purpose \
 "
RDEPENDS:kf6-purpose-doc = " \
 "
RDEPENDS:kf6-purpose-html = " \
 "
