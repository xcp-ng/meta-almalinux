# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xq"
PV = "1.4.0"
PR = "2.el10_1"
PACKAGES = " \
 xq \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xq-1.4.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e3dcc8752f11a163354de448321ba1136686de75d3c497acb99c6333b3c795f"

URI_x86_64_v2_xq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xq-1.4.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xq}"
SRC_URI[x86_64_v2_xq.sha256sum] = "2a67a2dd2fe8415a00e770039e4d028fcfaf36c08a14ea4b696622cc7287136d"

URI_aarch64_xq = "${EPEL_MIRROR}/aarch64/Packages/x/xq-1.4.0-2.el10_1.aarch64.rpm;name=aarch64_xq;unpack=0"
SRC_URI:append = " ${URI_aarch64_xq}"
SRC_URI[aarch64_xq.sha256sum] = "797c2e55497ba5afd88a34271b61d77f7bc9ad71855b562513985b4c7991f344"

RDEPENDS:xq = " \
 glibc \
 "
