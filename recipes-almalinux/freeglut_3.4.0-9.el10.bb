# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "freeglut"
PV = "3.4.0"
PR = "9.el10"
PACKAGES = " \
 freeglut \
 freeglut-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/freeglut-3.4.0-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e438f7e62e71c86e2e96851ff503dcc00b35d2c671790e8df1e3ccf9304acdd"

URI_x86_64_v2_freeglut = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeglut-3.4.0-9.el10.x86_64_v2.rpm;name=x86_64_v2_freeglut;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeglut}"
SRC_URI[x86_64_v2_freeglut.sha256sum] = "6d67f9e203d1324a977e52787606a69622e2e782bf0daec94ff08df106749925"

URI_x86_64_v2_freeglut-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeglut-devel-3.4.0-9.el10.x86_64_v2.rpm;name=x86_64_v2_freeglut-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeglut-devel}"
SRC_URI[x86_64_v2_freeglut-devel.sha256sum] = "a7626e5b3bb390de4c40c2d4f03a7955adf63068165c88f061021a647a6d6d3c"

URI_aarch64_freeglut = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeglut-3.4.0-9.el10.aarch64.rpm;name=aarch64_freeglut;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeglut}"
SRC_URI[aarch64_freeglut.sha256sum] = "c169a31ac6d7e64887e609c6cc7432e1fc63bf3f764ab9ffcad7ffa7497aa5f4"

URI_aarch64_freeglut-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeglut-devel-3.4.0-9.el10.aarch64.rpm;name=aarch64_freeglut-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeglut-devel}"
SRC_URI[aarch64_freeglut-devel.sha256sum] = "666ddcc79495f46d0da30217b4ff48cf0289e5a721d3f0862927fcd7ac06c311"

RDEPENDS:freeglut = " \
 glibc \
 libX11 \
 libXi \
 libglvnd-glx \
 "
RDEPENDS:freeglut-devel = " \
 cmake-filesystem \
 freeglut \
 mesa-libGL-devel \
 mesa-libGLU-devel \
 pkgconf-pkg-config \
 "
