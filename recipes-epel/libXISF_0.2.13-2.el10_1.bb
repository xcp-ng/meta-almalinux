# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libXISF"
PV = "0.2.13"
PR = "2.el10_1"
PACKAGES = " \
 libXISF \
 libXISF-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libXISF-0.2.13-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4842f24cff33b6918d9ae1a4067e6aee4fa431e1050a92bfe84099da882191ed"

URI_x86_64_v2_libXISF = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libXISF-0.2.13-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libXISF;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXISF}"
SRC_URI[x86_64_v2_libXISF.sha256sum] = "e09fed520b31ea7fbd42e4d0f59a24002a9c2c31d3c88becceda020bd5dc60ea"

URI_x86_64_v2_libXISF-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libXISF-devel-0.2.13-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libXISF-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXISF-devel}"
SRC_URI[x86_64_v2_libXISF-devel.sha256sum] = "ce3da7a54067a2c5d7c794969ace1159f6428aecf43d7031c9cfab9b4f1e39c4"

URI_aarch64_libXISF = "${EPEL_MIRROR}/aarch64/Packages/l/libXISF-0.2.13-2.el10_1.aarch64.rpm;name=aarch64_libXISF;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXISF}"
SRC_URI[aarch64_libXISF.sha256sum] = "5444645e9299a84c8331a344a6e4c0487c22eb7748441aabcf1c4d8cc0f21460"

URI_aarch64_libXISF-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libXISF-devel-0.2.13-2.el10_1.aarch64.rpm;name=aarch64_libXISF-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXISF-devel}"
SRC_URI[aarch64_libXISF-devel.sha256sum] = "e67e97a48372061cfebf42f35e2b456d466a30f13303704c63c4f8240659a1ed"

RDEPENDS:libXISF = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 lz4-libs \
 pugixml \
 zlib-ng-compat \
 "
RDEPENDS:libXISF-devel = " \
 libXISF \
 lz4-devel \
 pkgconf-pkg-config \
 pugixml-devel \
 zlib-ng-compat-devel \
 "
