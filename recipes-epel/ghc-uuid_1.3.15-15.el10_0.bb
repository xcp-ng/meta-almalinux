# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-uuid"
PV = "1.3.15"
PR = "15.el10_0"
PACKAGES = " \
 ghc-uuid \
 ghc-uuid-devel \
 ghc-uuid-doc \
 ghc-uuid-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-uuid-1.3.15-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f21e2fc93fdcb67cce9c26052874674a409365dabbe77649c4077f225ffef76"

URI_x86_64_v2_ghc-uuid = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-uuid-1.3.15-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-uuid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-uuid}"
SRC_URI[x86_64_v2_ghc-uuid.sha256sum] = "b073d4a4b95271e4cd94aab3d1083b7be51352c0fae5abced2119efec7bfe25e"

URI_x86_64_v2_ghc-uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-uuid-devel-1.3.15-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-uuid-devel}"
SRC_URI[x86_64_v2_ghc-uuid-devel.sha256sum] = "1f9bcf62adc3233f88303a27e57d61724d461ddd597fb7177be209ed3e94436f"

URI_x86_64_v2_ghc-uuid-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-uuid-doc-1.3.15-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-uuid-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-uuid-doc}"
SRC_URI[x86_64_v2_ghc-uuid-doc.sha256sum] = "afd06b89e924fd0823d935c981956a695dc508b63738032ad94d313fb53c8735"

URI_x86_64_v2_ghc-uuid-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-uuid-prof-1.3.15-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-uuid-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-uuid-prof}"
SRC_URI[x86_64_v2_ghc-uuid-prof.sha256sum] = "bd8898f6bf45124b62ef4e64b43a44c8939cf82865690ad0fff8de609eb892d7"

URI_aarch64_ghc-uuid = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-uuid-1.3.15-15.el10_0.aarch64.rpm;name=aarch64_ghc-uuid;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-uuid}"
SRC_URI[aarch64_ghc-uuid.sha256sum] = "fd4ef8158cae08af56e1543a0e9a862142c53778f138c04c9d0336de33af1713"

URI_aarch64_ghc-uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-uuid-devel-1.3.15-15.el10_0.aarch64.rpm;name=aarch64_ghc-uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-uuid-devel}"
SRC_URI[aarch64_ghc-uuid-devel.sha256sum] = "eb1fc0d5e4d3e69783c85789c62783bfa0d67827c4801cc4c6f1a9110a2ad43c"

URI_aarch64_ghc-uuid-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-uuid-doc-1.3.15-15.el10_0.noarch.rpm;name=aarch64_ghc-uuid-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-uuid-doc}"
SRC_URI[aarch64_ghc-uuid-doc.sha256sum] = "3750bb3a8027df54fa521091305cb9b016c03a0ee71e83f24ca0a2b73cad0902"

URI_aarch64_ghc-uuid-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-uuid-prof-1.3.15-15.el10_0.aarch64.rpm;name=aarch64_ghc-uuid-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-uuid-prof}"
SRC_URI[aarch64_ghc-uuid-prof.sha256sum] = "084ca99d5ed0d5e619b182748ff3006a461f5d6b6bd6f40757fc9914a0e8b19d"

RDEPENDS:ghc-uuid = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-cryptohash-md5 \
 ghc-cryptohash-sha1 \
 ghc-deepseq \
 ghc-entropy \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-mtl \
 ghc-network-info \
 ghc-os-string \
 ghc-pretty \
 ghc-random \
 ghc-splitmix \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 ghc-uuid-types \
 glibc \
 gmp \
 "
RDEPENDS:ghc-uuid-devel = " \
 ghc-base-devel \
 ghc-binary-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-cryptohash-md5-devel \
 ghc-cryptohash-sha1-devel \
 ghc-entropy-devel \
 ghc-network-info-devel \
 ghc-random-devel \
 ghc-text-devel \
 ghc-time-devel \
 ghc-uuid \
 ghc-uuid-types-devel \
 "
RDEPENDS:ghc-uuid-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-uuid-prof = " \
 ghc-base-prof \
 ghc-binary-prof \
 ghc-bytestring-prof \
 ghc-cryptohash-md5-prof \
 ghc-cryptohash-sha1-prof \
 ghc-entropy-prof \
 ghc-network-info-prof \
 ghc-random-prof \
 ghc-text-prof \
 ghc-time-prof \
 ghc-uuid-devel \
 ghc-uuid-types-prof \
 "
