# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-munge_macro"
PV = "0.4.7"
PR = "1.el10_1"
PACKAGES = " \
 rust-munge_macro+default-devel \
 rust-munge_macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-munge_macro-0.4.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b808f9281f310c19caaa343cb9cf54a5b88a6133b837a08cad9de61d10c35b2"

URI_x86_64_v2_rust-munge_macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-munge_macro+default-devel-0.4.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-munge_macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-munge_macro+default-devel}"
SRC_URI[x86_64_v2_rust-munge_macro+default-devel.sha256sum] = "8e9d20e381d4c2284a01d8fb48d3de4c4923bab1361d606245696dc5384f1bb6"

URI_x86_64_v2_rust-munge_macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-munge_macro-devel-0.4.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-munge_macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-munge_macro-devel}"
SRC_URI[x86_64_v2_rust-munge_macro-devel.sha256sum] = "120e929710b4354adc44403989e513328465a2eb4623c7acdfb5d9d1f6a048aa"

URI_aarch64_rust-munge_macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-munge_macro+default-devel-0.4.7-1.el10_1.noarch.rpm;name=aarch64_rust-munge_macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-munge_macro+default-devel}"
SRC_URI[aarch64_rust-munge_macro+default-devel.sha256sum] = "76c91a35584ceb4f9ed7689ca859eb8fbd0b14e796ae30edb93d98c89578ad9b"

URI_aarch64_rust-munge_macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-munge_macro-devel-0.4.7-1.el10_1.noarch.rpm;name=aarch64_rust-munge_macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-munge_macro-devel}"
SRC_URI[aarch64_rust-munge_macro-devel.sha256sum] = "242c4f2a53eabf9038f521a0ce9982468a60a1b4e5964e3bacab512634eb1081"

RDEPENDS:rust-munge_macro+default-devel = " \
 cargo \
 rust-munge_macro-devel \
 "
RDEPENDS:rust-munge_macro-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
