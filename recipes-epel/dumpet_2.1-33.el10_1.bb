# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dumpet"
PV = "2.1"
PR = "33.el10_1"
PACKAGES = " \
 dumpet \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dumpet-2.1-33.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "20ddc357e5d73d74e77b0a1f1c1548eaf071febc42d760c0182438309e467135"

URI_x86_64_v2_dumpet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dumpet-2.1-33.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dumpet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dumpet}"
SRC_URI[x86_64_v2_dumpet.sha256sum] = "25a4ed09591c6da26f313b216d777077d6e5aa9a4a1bfcc778b5990f5fb045b2"

URI_aarch64_dumpet = "${EPEL_MIRROR}/aarch64/Packages/d/dumpet-2.1-33.el10_1.aarch64.rpm;name=aarch64_dumpet;unpack=0"
SRC_URI:append = " ${URI_aarch64_dumpet}"
SRC_URI[aarch64_dumpet.sha256sum] = "395fd18f9f8120ac783ba8f1131be9a2c15eb8574cd45fdb9f3912aa06d5f26e"

RDEPENDS:dumpet = " \
 glibc \
 libxml2 \
 popt \
 "
