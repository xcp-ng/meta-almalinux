# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-matrixcompare-core"
PV = "0.1.0"
PR = "11.el10_1"
PACKAGES = " \
 rust-matrixcompare-core+default-devel \
 rust-matrixcompare-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-matrixcompare-core-0.1.0-11.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e130ebc6a07e7e6af4cc4c2f2341dc6dc9fc5f8b3c1b884886d9fd0657aaeec7"

URI_x86_64_v2_rust-matrixcompare-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matrixcompare-core+default-devel-0.1.0-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matrixcompare-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matrixcompare-core+default-devel}"
SRC_URI[x86_64_v2_rust-matrixcompare-core+default-devel.sha256sum] = "a2ec7cf5ba1293cd6a769cf65adc4bf6e441d3035669184ba8b0e7bfdea8de3f"

URI_x86_64_v2_rust-matrixcompare-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matrixcompare-core-devel-0.1.0-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matrixcompare-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matrixcompare-core-devel}"
SRC_URI[x86_64_v2_rust-matrixcompare-core-devel.sha256sum] = "f2449b7f223a877edfc050294447cde9dac8037b34674938d0c604cb977dbe3d"

URI_aarch64_rust-matrixcompare-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matrixcompare-core+default-devel-0.1.0-11.el10_1.noarch.rpm;name=aarch64_rust-matrixcompare-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matrixcompare-core+default-devel}"
SRC_URI[aarch64_rust-matrixcompare-core+default-devel.sha256sum] = "6e774c6ab560ee6257d56b9580f98eb2f021c02526880dc49fbc6524dad34141"

URI_aarch64_rust-matrixcompare-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matrixcompare-core-devel-0.1.0-11.el10_1.noarch.rpm;name=aarch64_rust-matrixcompare-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matrixcompare-core-devel}"
SRC_URI[aarch64_rust-matrixcompare-core-devel.sha256sum] = "036e34a2c86f31740a76faaeb0cd60222997997171b2c14f4ff4c64d7da67ffd"

RDEPENDS:rust-matrixcompare-core+default-devel = " \
 cargo \
 rust-matrixcompare-core-devel \
 "
RDEPENDS:rust-matrixcompare-core-devel = " \
 cargo \
 "
