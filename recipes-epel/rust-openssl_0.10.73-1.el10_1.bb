# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-openssl"
PV = "0.10.73"
PR = "1.el10_1"
PACKAGES = " \
 rust-openssl+bindgen-devel \
 rust-openssl+default-devel \
 rust-openssl+v101-devel \
 rust-openssl+v102-devel \
 rust-openssl+v110-devel \
 rust-openssl+v111-devel \
 rust-openssl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-openssl-0.10.73-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25f962bc3f2a25c41935d31bcd11041a099ac0679cc67fdd60e26c133aa1314d"

URI_x86_64_v2_rust-openssl+bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl+bindgen-devel-0.10.73-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl+bindgen-devel}"
SRC_URI[x86_64_v2_rust-openssl+bindgen-devel.sha256sum] = "0525953a09a4a98a148075af06c50133fe3fb1891b8983ee2723a6bb261701bc"

URI_x86_64_v2_rust-openssl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl+default-devel-0.10.73-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl+default-devel}"
SRC_URI[x86_64_v2_rust-openssl+default-devel.sha256sum] = "ddc36f6c947f9af9de5fd54a706cfbe387751cae4e2f0ea5e6a7b2f67acc105b"

URI_x86_64_v2_rust-openssl+v101-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl+v101-devel-0.10.73-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl+v101-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl+v101-devel}"
SRC_URI[x86_64_v2_rust-openssl+v101-devel.sha256sum] = "681dd7a2e13f451710cda9a5c23d07496b322f9d80a792522fa0c4e02eeacc18"

URI_x86_64_v2_rust-openssl+v102-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl+v102-devel-0.10.73-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl+v102-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl+v102-devel}"
SRC_URI[x86_64_v2_rust-openssl+v102-devel.sha256sum] = "c00edfc1c6aea68db33890d2ee9f8b634f47450402e70e0429a6dd31dfd37169"

URI_x86_64_v2_rust-openssl+v110-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl+v110-devel-0.10.73-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl+v110-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl+v110-devel}"
SRC_URI[x86_64_v2_rust-openssl+v110-devel.sha256sum] = "291b47daad5d5d1d75ee1dd8d388a56853d7eb0aab946465ece33b90691a9dcd"

URI_x86_64_v2_rust-openssl+v111-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl+v111-devel-0.10.73-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl+v111-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl+v111-devel}"
SRC_URI[x86_64_v2_rust-openssl+v111-devel.sha256sum] = "a3fb3fdfc02d63f37beaaf0ca6874c5fd2fac8704f2989a72109283760e256bc"

URI_x86_64_v2_rust-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl-devel-0.10.73-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl-devel}"
SRC_URI[x86_64_v2_rust-openssl-devel.sha256sum] = "e2d9e399dab0a887fcd03c031fb15d4ffb966906d5fbb45bc1f956a2e7cdd849"

URI_aarch64_rust-openssl+bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl+bindgen-devel-0.10.73-1.el10_1.noarch.rpm;name=aarch64_rust-openssl+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl+bindgen-devel}"
SRC_URI[aarch64_rust-openssl+bindgen-devel.sha256sum] = "f1e7585f7dce05e9e1ca0e21c9655289dcc7e08e00bd0f47bd4f1845278b9420"

URI_aarch64_rust-openssl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl+default-devel-0.10.73-1.el10_1.noarch.rpm;name=aarch64_rust-openssl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl+default-devel}"
SRC_URI[aarch64_rust-openssl+default-devel.sha256sum] = "379efbbeae067cc63c6d88404b457f34c588855e12317e35a06dec21581b061d"

URI_aarch64_rust-openssl+v101-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl+v101-devel-0.10.73-1.el10_1.noarch.rpm;name=aarch64_rust-openssl+v101-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl+v101-devel}"
SRC_URI[aarch64_rust-openssl+v101-devel.sha256sum] = "57095f08e8104568ae941021e71f17c1c08ecc270d8a8281430da393249af941"

URI_aarch64_rust-openssl+v102-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl+v102-devel-0.10.73-1.el10_1.noarch.rpm;name=aarch64_rust-openssl+v102-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl+v102-devel}"
SRC_URI[aarch64_rust-openssl+v102-devel.sha256sum] = "527791bf2bad71526f3677960a107975d18ea85256d3dc2a6d720cd8ecdc49e4"

URI_aarch64_rust-openssl+v110-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl+v110-devel-0.10.73-1.el10_1.noarch.rpm;name=aarch64_rust-openssl+v110-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl+v110-devel}"
SRC_URI[aarch64_rust-openssl+v110-devel.sha256sum] = "9d687825467650d179fd120ac8914cf2bbf6fbadd47179f9a300c1048f9515e1"

URI_aarch64_rust-openssl+v111-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl+v111-devel-0.10.73-1.el10_1.noarch.rpm;name=aarch64_rust-openssl+v111-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl+v111-devel}"
SRC_URI[aarch64_rust-openssl+v111-devel.sha256sum] = "2d9b428c5ded3143511164009b1fc9c8173bd77fc1d35456ffb160ac5a22d705"

URI_aarch64_rust-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl-devel-0.10.73-1.el10_1.noarch.rpm;name=aarch64_rust-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl-devel}"
SRC_URI[aarch64_rust-openssl-devel.sha256sum] = "158455f67f91489a36cecfddbd10c2f59c72513c792860b45bdc84960b6b2aef"

RDEPENDS:rust-openssl+bindgen-devel = " \
 cargo \
 rust-openssl-devel \
 rust-openssl-sys+bindgen-devel \
 "
RDEPENDS:rust-openssl+default-devel = " \
 cargo \
 rust-openssl-devel \
 "
RDEPENDS:rust-openssl+v101-devel = " \
 cargo \
 rust-openssl-devel \
 "
RDEPENDS:rust-openssl+v102-devel = " \
 cargo \
 rust-openssl-devel \
 "
RDEPENDS:rust-openssl+v110-devel = " \
 cargo \
 rust-openssl-devel \
 "
RDEPENDS:rust-openssl+v111-devel = " \
 cargo \
 rust-openssl-devel \
 "
RDEPENDS:rust-openssl-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-cfg-if+default-devel \
 rust-foreign-types0.3+default-devel \
 rust-libc+default-devel \
 rust-once_cell+default-devel \
 rust-openssl-macros+default-devel \
 rust-openssl-sys+default-devel \
 "
