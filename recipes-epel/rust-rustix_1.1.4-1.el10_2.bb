# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustix"
PV = "1.1.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-rustix+all-apis-devel \
 rust-rustix+alloc-devel \
 rust-rustix+default-devel \
 rust-rustix+event-devel \
 rust-rustix+fs-devel \
 rust-rustix+io_uring-devel \
 rust-rustix+libc-devel \
 rust-rustix+libc_errno-devel \
 rust-rustix+linux_4_11-devel \
 rust-rustix+linux_5_1-devel \
 rust-rustix+linux_5_11-devel \
 rust-rustix+linux_latest-devel \
 rust-rustix+mm-devel \
 rust-rustix+mount-devel \
 rust-rustix+net-devel \
 rust-rustix+param-devel \
 rust-rustix+pipe-devel \
 rust-rustix+process-devel \
 rust-rustix+pty-devel \
 rust-rustix+rand-devel \
 rust-rustix+runtime-devel \
 rust-rustix+shm-devel \
 rust-rustix+std-devel \
 rust-rustix+stdio-devel \
 rust-rustix+system-devel \
 rust-rustix+termios-devel \
 rust-rustix+thread-devel \
 rust-rustix+time-devel \
 rust-rustix+try_close-devel \
 rust-rustix+use-explicitly-provided-auxv-devel \
 rust-rustix+use-libc-auxv-devel \
 rust-rustix+use-libc-devel \
 rust-rustix-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustix-1.1.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c84e1c63323406f6f00b24ec288ca6eb4224b1f808c0682932bc2537eaaff5f2"

URI_x86_64_v2_rust-rustix+all-apis-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+all-apis-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+all-apis-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+all-apis-devel}"
SRC_URI[x86_64_v2_rust-rustix+all-apis-devel.sha256sum] = "84afcdc15c80cd8ad218fd7fff49cf4ae4aef2ec150916120d9c4262fdc0dc1f"

URI_x86_64_v2_rust-rustix+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+alloc-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+alloc-devel}"
SRC_URI[x86_64_v2_rust-rustix+alloc-devel.sha256sum] = "c564c502d36c22a5d4931022e3b231cbff7534a1c208b8452a5463f3e335b95d"

URI_x86_64_v2_rust-rustix+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+default-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+default-devel}"
SRC_URI[x86_64_v2_rust-rustix+default-devel.sha256sum] = "ab4e85e8d509d2aea0824fb0a1b793cbc43e4b419974660c10ca719291c018d9"

URI_x86_64_v2_rust-rustix+event-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+event-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+event-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+event-devel}"
SRC_URI[x86_64_v2_rust-rustix+event-devel.sha256sum] = "3d6dcb4b9b776bab37f518796da23040ff8df2a19739ddf3e0bd1632f7df1fc1"

URI_x86_64_v2_rust-rustix+fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+fs-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+fs-devel}"
SRC_URI[x86_64_v2_rust-rustix+fs-devel.sha256sum] = "80793c4c0960e18c40de7d379c3fa15cf2c2a4acfa465f382ab647c834d832db"

URI_x86_64_v2_rust-rustix+io_uring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+io_uring-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+io_uring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+io_uring-devel}"
SRC_URI[x86_64_v2_rust-rustix+io_uring-devel.sha256sum] = "a784d364eaa30f011ab1c2b913e80bcad56655f5d939c76ee6b4b918ae1b2a7c"

URI_x86_64_v2_rust-rustix+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+libc-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+libc-devel}"
SRC_URI[x86_64_v2_rust-rustix+libc-devel.sha256sum] = "9156dbdc32837d89cebddf7d6c8c5d4998f486147ac87627b3c0995821640860"

URI_x86_64_v2_rust-rustix+libc_errno-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+libc_errno-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+libc_errno-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+libc_errno-devel}"
SRC_URI[x86_64_v2_rust-rustix+libc_errno-devel.sha256sum] = "5fd05d0f4115452e01f81765a6d5c08d482ffb4cadf574951eff711f324eb15e"

URI_x86_64_v2_rust-rustix+linux_4_11-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+linux_4_11-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+linux_4_11-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+linux_4_11-devel}"
SRC_URI[x86_64_v2_rust-rustix+linux_4_11-devel.sha256sum] = "2fb8a94a907e211d7e9d11079befdfd356dcdf7c17a48f1ff7cedc6db9d6817e"

URI_x86_64_v2_rust-rustix+linux_5_1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+linux_5_1-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+linux_5_1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+linux_5_1-devel}"
SRC_URI[x86_64_v2_rust-rustix+linux_5_1-devel.sha256sum] = "4336e1f7e6c28ed7fb78304709d1a6f56b60ca646213b044b56ead21cdbcbc5a"

URI_x86_64_v2_rust-rustix+linux_5_11-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+linux_5_11-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+linux_5_11-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+linux_5_11-devel}"
SRC_URI[x86_64_v2_rust-rustix+linux_5_11-devel.sha256sum] = "8d8178d4f1961a644096ff90cb643d4f47b439082dfcf745c62f86f4e159d57d"

URI_x86_64_v2_rust-rustix+linux_latest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+linux_latest-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+linux_latest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+linux_latest-devel}"
SRC_URI[x86_64_v2_rust-rustix+linux_latest-devel.sha256sum] = "10ad83e50e4ae7f1fef13fc3fcbd25f3922baf68c7e2ab035b980868af3b3938"

URI_x86_64_v2_rust-rustix+mm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+mm-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+mm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+mm-devel}"
SRC_URI[x86_64_v2_rust-rustix+mm-devel.sha256sum] = "1053b1e789af9d04a2e398cf15bc7ea828674feb732fd8b6b3271936b9ac615e"

URI_x86_64_v2_rust-rustix+mount-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+mount-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+mount-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+mount-devel}"
SRC_URI[x86_64_v2_rust-rustix+mount-devel.sha256sum] = "bd7a0114f0db664f2f57edf071147eb0bf1372ba998f468c77e84e1c751c341d"

URI_x86_64_v2_rust-rustix+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+net-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+net-devel}"
SRC_URI[x86_64_v2_rust-rustix+net-devel.sha256sum] = "71bf9423e5195059c2b97d0aecd40377923f6d1348cf7746ffa59abb5252f14c"

URI_x86_64_v2_rust-rustix+param-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+param-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+param-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+param-devel}"
SRC_URI[x86_64_v2_rust-rustix+param-devel.sha256sum] = "978f45bb3c7a0416861cb533d442a6f6c40e7c40fdaf6317e4d35cd5cbb1d277"

URI_x86_64_v2_rust-rustix+pipe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+pipe-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+pipe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+pipe-devel}"
SRC_URI[x86_64_v2_rust-rustix+pipe-devel.sha256sum] = "fee02666740e559fbbb9befb43568512b710d9f3d8424c26e0029fb755079cd2"

URI_x86_64_v2_rust-rustix+process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+process-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+process-devel}"
SRC_URI[x86_64_v2_rust-rustix+process-devel.sha256sum] = "03f116ae6bc7a177be614e90960bc68af2b656434400426ce43eed0379a7fc35"

URI_x86_64_v2_rust-rustix+pty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+pty-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+pty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+pty-devel}"
SRC_URI[x86_64_v2_rust-rustix+pty-devel.sha256sum] = "1620774c067f53659bbbbe8f82c99a334ee2b63bd376a0115cd9d6ed02b619a5"

URI_x86_64_v2_rust-rustix+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+rand-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+rand-devel}"
SRC_URI[x86_64_v2_rust-rustix+rand-devel.sha256sum] = "17dbd661b4ac13c8ec13cd06460abe8300a422b560396b5c646c1b5a9c157804"

URI_x86_64_v2_rust-rustix+runtime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+runtime-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+runtime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+runtime-devel}"
SRC_URI[x86_64_v2_rust-rustix+runtime-devel.sha256sum] = "09767ff867a536d729a60b8ecb4245c535db9c997dd142b5b18dbda626cb0315"

URI_x86_64_v2_rust-rustix+shm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+shm-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+shm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+shm-devel}"
SRC_URI[x86_64_v2_rust-rustix+shm-devel.sha256sum] = "2a6c7b5ec761787394656a37d99eed611cf4b246ea5ead4324af33da1888fae9"

URI_x86_64_v2_rust-rustix+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+std-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+std-devel}"
SRC_URI[x86_64_v2_rust-rustix+std-devel.sha256sum] = "45560cc801a51cfdf36681b62c570c45e659e724e07a3c78e415b1c8c449ceca"

URI_x86_64_v2_rust-rustix+stdio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+stdio-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+stdio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+stdio-devel}"
SRC_URI[x86_64_v2_rust-rustix+stdio-devel.sha256sum] = "0cacb210d92aeb29b98a6302f7fcf927538d50771456c0447e5bc0e2aa0ef04d"

URI_x86_64_v2_rust-rustix+system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+system-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+system-devel}"
SRC_URI[x86_64_v2_rust-rustix+system-devel.sha256sum] = "a8c8720fef330ce626f7efd67cfe1b0cf2e5266af5ab38f37df6ba2d9ade960d"

URI_x86_64_v2_rust-rustix+termios-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+termios-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+termios-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+termios-devel}"
SRC_URI[x86_64_v2_rust-rustix+termios-devel.sha256sum] = "c4e7fc6d66245144d672612b83f758a2355895f2d7b514ba208975b1eaa01c89"

URI_x86_64_v2_rust-rustix+thread-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+thread-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+thread-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+thread-devel}"
SRC_URI[x86_64_v2_rust-rustix+thread-devel.sha256sum] = "f1aeddc1badfdee22a8fd7904b527b1a1e39baf856e923bf1757337319d0c19f"

URI_x86_64_v2_rust-rustix+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+time-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+time-devel}"
SRC_URI[x86_64_v2_rust-rustix+time-devel.sha256sum] = "280d7f9a1bd57f4976032b62b92deb77a8c992a13444949c05cbb094baa2fce3"

URI_x86_64_v2_rust-rustix+try_close-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+try_close-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+try_close-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+try_close-devel}"
SRC_URI[x86_64_v2_rust-rustix+try_close-devel.sha256sum] = "074d2b8a1bcdb69ddd982e6ab87859e387e1796e8469bfce2475d3d75d12f799"

URI_x86_64_v2_rust-rustix+use-explicitly-provided-auxv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+use-explicitly-provided-auxv-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+use-explicitly-provided-auxv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+use-explicitly-provided-auxv-devel}"
SRC_URI[x86_64_v2_rust-rustix+use-explicitly-provided-auxv-devel.sha256sum] = "47eba05fdc716f41f6a44d7e0344a9b18baa669b649a23d4724362e24ef90c83"

URI_x86_64_v2_rust-rustix+use-libc-auxv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+use-libc-auxv-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+use-libc-auxv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+use-libc-auxv-devel}"
SRC_URI[x86_64_v2_rust-rustix+use-libc-auxv-devel.sha256sum] = "fccb212008038d6eb8757b1a8054e3ce9a88d40c435fd71db9182b77f1144c2e"

URI_x86_64_v2_rust-rustix+use-libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+use-libc-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+use-libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+use-libc-devel}"
SRC_URI[x86_64_v2_rust-rustix+use-libc-devel.sha256sum] = "456ed6db14e65f4c3d969d8a75ca27e2ffb52aa7eda041293f837584567c1927"

URI_x86_64_v2_rust-rustix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix-devel-1.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix-devel}"
SRC_URI[x86_64_v2_rust-rustix-devel.sha256sum] = "20309c6770306e30ced73ec49c0a4ec1b5607914716c9f59af19346b6d697b50"

URI_aarch64_rust-rustix+all-apis-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+all-apis-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+all-apis-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+all-apis-devel}"
SRC_URI[aarch64_rust-rustix+all-apis-devel.sha256sum] = "1073f43c97ef020ad310bdec0d11350c0fc0af782d7bec178a43cf7daf7a3dd1"

URI_aarch64_rust-rustix+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+alloc-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+alloc-devel}"
SRC_URI[aarch64_rust-rustix+alloc-devel.sha256sum] = "71fe0834f3a2842286325ac50b17b8710c8e3392e38d094e49e94ec05331b94e"

URI_aarch64_rust-rustix+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+default-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+default-devel}"
SRC_URI[aarch64_rust-rustix+default-devel.sha256sum] = "36838d44b43d0716ac1a1d5eddda0544923f4ba3e5320f79be0649d1284c196d"

URI_aarch64_rust-rustix+event-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+event-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+event-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+event-devel}"
SRC_URI[aarch64_rust-rustix+event-devel.sha256sum] = "f675b205d89b813a0346b21af290e83b8e8d5b2abfcbd2191e7f4caa66904654"

URI_aarch64_rust-rustix+fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+fs-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+fs-devel}"
SRC_URI[aarch64_rust-rustix+fs-devel.sha256sum] = "7b9ecfd20c179157c42d4a88d79bb3a393765d48ea2c0646436402601b4faa3b"

URI_aarch64_rust-rustix+io_uring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+io_uring-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+io_uring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+io_uring-devel}"
SRC_URI[aarch64_rust-rustix+io_uring-devel.sha256sum] = "01d1f664bcf7df74cfa53b26effac84133c39efedf28274e7c7a22d56a9170b4"

URI_aarch64_rust-rustix+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+libc-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+libc-devel}"
SRC_URI[aarch64_rust-rustix+libc-devel.sha256sum] = "8a2fe22266963403d5a43f1ed37804d13fd9321884aee88562af25052f9d6602"

URI_aarch64_rust-rustix+libc_errno-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+libc_errno-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+libc_errno-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+libc_errno-devel}"
SRC_URI[aarch64_rust-rustix+libc_errno-devel.sha256sum] = "9198a00a808839015009f8d32eda2001660944393f594f4e96f478651697340e"

URI_aarch64_rust-rustix+linux_4_11-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+linux_4_11-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+linux_4_11-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+linux_4_11-devel}"
SRC_URI[aarch64_rust-rustix+linux_4_11-devel.sha256sum] = "02d2c7ea2f85fc7d7b2c0bde8fa2fcda4dc5fee3ad28686c80ee49ca4ccea6c2"

URI_aarch64_rust-rustix+linux_5_1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+linux_5_1-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+linux_5_1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+linux_5_1-devel}"
SRC_URI[aarch64_rust-rustix+linux_5_1-devel.sha256sum] = "7152dcbbeb3cd24a492cc9b35943ddbe699d8c662c0ed434274b6510d355bc2c"

URI_aarch64_rust-rustix+linux_5_11-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+linux_5_11-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+linux_5_11-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+linux_5_11-devel}"
SRC_URI[aarch64_rust-rustix+linux_5_11-devel.sha256sum] = "2d8e0837b8b3585ecb15a8c88d089b4aa373f787323a3efbfd13a1cb6df2b53a"

URI_aarch64_rust-rustix+linux_latest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+linux_latest-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+linux_latest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+linux_latest-devel}"
SRC_URI[aarch64_rust-rustix+linux_latest-devel.sha256sum] = "0774141df7e649242b9ab4842cbf728110eac5780945d8e51acc37f613fb4556"

URI_aarch64_rust-rustix+mm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+mm-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+mm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+mm-devel}"
SRC_URI[aarch64_rust-rustix+mm-devel.sha256sum] = "b477a30eb9c7ade436363b43bcbe2959df1b80cc0de26d6a46e47d6c42e1b684"

URI_aarch64_rust-rustix+mount-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+mount-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+mount-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+mount-devel}"
SRC_URI[aarch64_rust-rustix+mount-devel.sha256sum] = "25d8e0009ea05f1de58310b36cca23850fdd2190ed3432febe55473b3810e052"

URI_aarch64_rust-rustix+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+net-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+net-devel}"
SRC_URI[aarch64_rust-rustix+net-devel.sha256sum] = "2d5a2ee83cd4e31a04eec21ffbb8c9c469b5cb03e7461b890498356954cffe9c"

URI_aarch64_rust-rustix+param-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+param-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+param-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+param-devel}"
SRC_URI[aarch64_rust-rustix+param-devel.sha256sum] = "01bb7838e95e8708169ab5e00d4fd2ee65aa81a025dae0272910ac6b2cea7143"

URI_aarch64_rust-rustix+pipe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+pipe-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+pipe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+pipe-devel}"
SRC_URI[aarch64_rust-rustix+pipe-devel.sha256sum] = "4987219d46eebb55fd6d88bb123ea18ef2655ee700f0b426ee835ef3d1e4e0a5"

URI_aarch64_rust-rustix+process-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+process-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+process-devel}"
SRC_URI[aarch64_rust-rustix+process-devel.sha256sum] = "7c6a1254547a2190e711f634e0868d2afe8a31f946c3b6abda97a8fc2f5eebf0"

URI_aarch64_rust-rustix+pty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+pty-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+pty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+pty-devel}"
SRC_URI[aarch64_rust-rustix+pty-devel.sha256sum] = "aed8e2740534b83c89d9faf03ed274babe4a523fdf06523a18e8c83dc806eca2"

URI_aarch64_rust-rustix+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+rand-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+rand-devel}"
SRC_URI[aarch64_rust-rustix+rand-devel.sha256sum] = "481e01a12edf17d08bca8bf15d620c107816a1d1ddab4f28e77c025043c5f98d"

URI_aarch64_rust-rustix+runtime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+runtime-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+runtime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+runtime-devel}"
SRC_URI[aarch64_rust-rustix+runtime-devel.sha256sum] = "d1aab4e9c5edd999f2334485ad62cd43277ef49a8216f87c5cc4d86d4dece2b6"

URI_aarch64_rust-rustix+shm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+shm-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+shm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+shm-devel}"
SRC_URI[aarch64_rust-rustix+shm-devel.sha256sum] = "9e2df1a623dcda42a6c6660b2fa36b5e2704bd62da8a58a6a4a2e0539876fdd7"

URI_aarch64_rust-rustix+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+std-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+std-devel}"
SRC_URI[aarch64_rust-rustix+std-devel.sha256sum] = "f1859619d281f5d529f7333c9ba50532162becd14c480d7d3d6a2ae6f1017239"

URI_aarch64_rust-rustix+stdio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+stdio-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+stdio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+stdio-devel}"
SRC_URI[aarch64_rust-rustix+stdio-devel.sha256sum] = "c0e8dd67271cbf036b5790013e79bf641796a820b233e20a1cfa1519b407bda1"

URI_aarch64_rust-rustix+system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+system-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+system-devel}"
SRC_URI[aarch64_rust-rustix+system-devel.sha256sum] = "65f359f9c8669b70eb94243f4ff624f14d47752509dac40a3a379af853a8723e"

URI_aarch64_rust-rustix+termios-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+termios-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+termios-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+termios-devel}"
SRC_URI[aarch64_rust-rustix+termios-devel.sha256sum] = "a0ce4dfafbaca4b97aee7224ae7c0fbe520a8b320c36c0dce17de045240abcc0"

URI_aarch64_rust-rustix+thread-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+thread-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+thread-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+thread-devel}"
SRC_URI[aarch64_rust-rustix+thread-devel.sha256sum] = "04417cd9eb3fdd6c41c9ae07386e68b4edee2aca9c5780394ef56f95fd1af436"

URI_aarch64_rust-rustix+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+time-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+time-devel}"
SRC_URI[aarch64_rust-rustix+time-devel.sha256sum] = "f92f03a30eef09a581ef716972846bd7b5de450e6663bf948498f5edfd9be0d8"

URI_aarch64_rust-rustix+try_close-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+try_close-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+try_close-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+try_close-devel}"
SRC_URI[aarch64_rust-rustix+try_close-devel.sha256sum] = "a0ab26a5ad16a7e79bf974fae932a0070a4ad92f1ff5816bcc797460673a0cf7"

URI_aarch64_rust-rustix+use-explicitly-provided-auxv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+use-explicitly-provided-auxv-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+use-explicitly-provided-auxv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+use-explicitly-provided-auxv-devel}"
SRC_URI[aarch64_rust-rustix+use-explicitly-provided-auxv-devel.sha256sum] = "758b38b61658851edb8c90bddba0b48dd651003829da52895656ee3e7932cddf"

URI_aarch64_rust-rustix+use-libc-auxv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+use-libc-auxv-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+use-libc-auxv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+use-libc-auxv-devel}"
SRC_URI[aarch64_rust-rustix+use-libc-auxv-devel.sha256sum] = "a3927683edacdde5da7feba22fe19558f8e74475795f8352551dc8df0f462c61"

URI_aarch64_rust-rustix+use-libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+use-libc-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+use-libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+use-libc-devel}"
SRC_URI[aarch64_rust-rustix+use-libc-devel.sha256sum] = "a131968bd97657d85eceb85912a7289e0700aeedaf0133e54b7d87bf4de53c5a"

URI_aarch64_rust-rustix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix-devel-1.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix-devel}"
SRC_URI[aarch64_rust-rustix-devel.sha256sum] = "3144d837d68d10f49687947917574ebe39e367738f98642f1db103e4b0c524d6"

RDEPENDS:rust-rustix+all-apis-devel = " \
 cargo \
 rust-rustix+event-devel \
 rust-rustix+fs-devel \
 rust-rustix+io_uring-devel \
 rust-rustix+mm-devel \
 rust-rustix+mount-devel \
 rust-rustix+net-devel \
 rust-rustix+param-devel \
 rust-rustix+pipe-devel \
 rust-rustix+process-devel \
 rust-rustix+pty-devel \
 rust-rustix+rand-devel \
 rust-rustix+runtime-devel \
 rust-rustix+shm-devel \
 rust-rustix+stdio-devel \
 rust-rustix+system-devel \
 rust-rustix+termios-devel \
 rust-rustix+thread-devel \
 rust-rustix+time-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+alloc-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+default-devel = " \
 cargo \
 rust-rustix+std-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+event-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+fs-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+io_uring-devel = " \
 cargo \
 rust-linux-raw-sys+io_uring-devel \
 rust-rustix+event-devel \
 rust-rustix+fs-devel \
 rust-rustix+net-devel \
 rust-rustix+thread-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+libc-devel = " \
 cargo \
 rust-libc-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+libc_errno-devel = " \
 cargo \
 rust-errno-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+linux_4_11-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+linux_5_1-devel = " \
 cargo \
 rust-rustix+linux_4_11-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+linux_5_11-devel = " \
 cargo \
 rust-rustix+linux_5_1-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+linux_latest-devel = " \
 cargo \
 rust-rustix+linux_5_11-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+mm-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+mount-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+net-devel = " \
 cargo \
 rust-linux-raw-sys+if_ether-devel \
 rust-linux-raw-sys+net-devel \
 rust-linux-raw-sys+netlink-devel \
 rust-linux-raw-sys+xdp-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+param-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+pipe-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+process-devel = " \
 cargo \
 rust-linux-raw-sys+prctl-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+pty-devel = " \
 cargo \
 rust-rustix+fs-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+rand-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+runtime-devel = " \
 cargo \
 rust-linux-raw-sys+prctl-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+shm-devel = " \
 cargo \
 rust-rustix+fs-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+std-devel = " \
 cargo \
 rust-bitflags+std-devel \
 rust-errno+std-devel \
 rust-errno-devel \
 rust-libc+std-devel \
 rust-libc-devel \
 rust-rustix+alloc-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+stdio-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+system-devel = " \
 cargo \
 rust-linux-raw-sys+system-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+termios-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+thread-devel = " \
 cargo \
 rust-linux-raw-sys+prctl-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+time-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+try_close-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+use-explicitly-provided-auxv-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+use-libc-auxv-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+use-libc-devel = " \
 cargo \
 rust-rustix+libc-devel \
 rust-rustix+libc_errno-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix-devel = " \
 cargo \
 rust \
 rust-bitflags-devel \
 rust-errno-devel \
 rust-libc-devel \
 rust-linux-raw-sys+auxvec-devel \
 rust-linux-raw-sys+elf-devel \
 rust-linux-raw-sys+errno-devel \
 rust-linux-raw-sys+general-devel \
 rust-linux-raw-sys+ioctl-devel \
 rust-linux-raw-sys+no_std-devel \
 rust-linux-raw-sys-devel \
 "
