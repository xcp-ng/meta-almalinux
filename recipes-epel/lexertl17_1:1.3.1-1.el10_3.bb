# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lexertl17"
PE = "1"
PV = "1.3.1"
PR = "1.el10_3"
PACKAGES = " \
 lexertl17-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/lexertl17-1.3.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "682d610e969a979518f77a50bc7f047ec08e46275013f34ed201ab6205f58ef1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lexertl17-devel-1.3.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lexertl17-devel;unpack=0"
SRC_URI[x86_64_v2_lexertl17-devel.sha256sum] = "33507c3c83004deb67586ba72c748961682fd0be7f2cd05ea914369567a23e5b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lexertl17-devel-1.3.1-1.el10_3.aarch64.rpm;name=aarch64_lexertl17-devel;unpack=0"
SRC_URI[aarch64_lexertl17-devel.sha256sum] = "98444398bd924434f1be3520a0ce993ffeab7ab0fc3fcf11e9eb7719bb01cf4b"

RDEPENDS:lexertl17-devel = " \
 cmake-filesystem \
 "
