# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gpgverify"
PV = "1"
PR = "1.el10_1"
PACKAGES = " \
 gpgverify \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gpgverify-1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "355a6d53cd1a2cd86699d42a5da8a812f4256b67d7b894b1935ab5ce17bd6fa4"

URI_x86_64_v2_gpgverify = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gpgverify-1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_gpgverify;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpgverify}"
SRC_URI[x86_64_v2_gpgverify.sha256sum] = "1362064472abe491a5f6784111c2aa867e0c302c6cf8bfb8fc59351aa00ca537"

URI_aarch64_gpgverify = "${EPEL_MIRROR}/aarch64/Packages/g/gpgverify-1-1.el10_1.noarch.rpm;name=aarch64_gpgverify;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpgverify}"
SRC_URI[aarch64_gpgverify.sha256sum] = "f3dabf0e9f15f4e378f5a7828fed0e6d0675e33387dfff33c35f1d5c55a56485"

RDEPENDS:gpgverify = " \
 gnupg2 \
 redhat-rpm-config \
 "
