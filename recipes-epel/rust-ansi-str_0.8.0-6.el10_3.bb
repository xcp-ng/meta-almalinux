# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ansi-str"
PV = "0.8.0"
PR = "6.el10_3"
PACKAGES = " \
 rust-ansi-str+default-devel \
 rust-ansi-str-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ansi-str-0.8.0-6.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1201e5da4301d376fa541325eb7ddf982130e5192f72930f967e3dfe9f4d90e4"

URI_x86_64_v2_rust-ansi-str+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ansi-str+default-devel-0.8.0-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ansi-str+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ansi-str+default-devel}"
SRC_URI[x86_64_v2_rust-ansi-str+default-devel.sha256sum] = "7e7c32f5d4770c9f3deb5ce7bb2926e7895a203d45528700308e02329fd3a876"

URI_x86_64_v2_rust-ansi-str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ansi-str-devel-0.8.0-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ansi-str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ansi-str-devel}"
SRC_URI[x86_64_v2_rust-ansi-str-devel.sha256sum] = "25ddc117697d988e91701f9d6953b1613c8e6cc577bab0a6c2801c23fdf92343"

URI_aarch64_rust-ansi-str+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ansi-str+default-devel-0.8.0-6.el10_3.noarch.rpm;name=aarch64_rust-ansi-str+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ansi-str+default-devel}"
SRC_URI[aarch64_rust-ansi-str+default-devel.sha256sum] = "e917e3a7e325fffdad52f40608f02fcd75f6be1a71b550dd91be63f636a593d4"

URI_aarch64_rust-ansi-str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ansi-str-devel-0.8.0-6.el10_3.noarch.rpm;name=aarch64_rust-ansi-str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ansi-str-devel}"
SRC_URI[aarch64_rust-ansi-str-devel.sha256sum] = "662004a8347f2e9b0ce20b5a3e64819a091592d4309724f0e1cb4bcb71e7a0be"

RDEPENDS:rust-ansi-str+default-devel = " \
 cargo \
 rust-ansi-str-devel \
 "
RDEPENDS:rust-ansi-str-devel = " \
 cargo \
 rust-ansitok+default-devel \
 "
