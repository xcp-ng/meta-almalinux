# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdenlive"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kdenlive \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdenlive-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6d0930608eab648d05060ef8ea2902991b6f3589fefebdd74d930687c0d8c29"

URI_x86_64_v2_kdenlive = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdenlive-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdenlive;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdenlive}"
SRC_URI[x86_64_v2_kdenlive.sha256sum] = "66c8401f9c18e3b01af3de849589b54206b060fd476bb50d8093e18c3e36123b"

URI_aarch64_kdenlive = "${EPEL_MIRROR}/aarch64/Packages/k/kdenlive-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kdenlive;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdenlive}"
SRC_URI[aarch64_kdenlive.sha256sum] = "f6a4e3f9c7c5a0281b216cb0f229c76afaa481fe102da8d899249b0aef7aedb2"

RDEPENDS:kdenlive = " \
 OpenTimelineIO \
 dvdauthor \
 ffmpeg-free \
 frei0r-plugins \
 glibc \
 kddockwidgets-qt6 \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kfilemetadata \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kitemviews \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-purpose \
 kf6-qqc2-desktop-style \
 kf6-solid \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libstdc++ \
 libswresample-free \
 mlt \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 qt6-qtnetworkauth \
 qt6-qtsvg \
 "
