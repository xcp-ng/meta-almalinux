# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-process"
PV = "2.5.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-async-process+default-devel \
 rust-async-process+tracing-devel \
 rust-async-process-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-process-2.5.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "46b4c7b262ea90254682e8b77b95a486c77c9de0e5d343a97893355d5474bf47"

URI_x86_64_v2_rust-async-process+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-process+default-devel-2.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-process+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-process+default-devel}"
SRC_URI[x86_64_v2_rust-async-process+default-devel.sha256sum] = "621138332ed43f8e6dcdb8811097ccd4b79ffffe514ffc246a263ed4579e5bc3"

URI_x86_64_v2_rust-async-process+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-process+tracing-devel-2.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-process+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-process+tracing-devel}"
SRC_URI[x86_64_v2_rust-async-process+tracing-devel.sha256sum] = "b2979e1fd0efdd638dbefe63ea0a2137ca75e5fcb69a8ac4d1feea1d9fab49e8"

URI_x86_64_v2_rust-async-process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-process-devel-2.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-process-devel}"
SRC_URI[x86_64_v2_rust-async-process-devel.sha256sum] = "823e3711688e85db773717f598ce06e46c68baa63aaefbec4b86e24355a086c2"

URI_aarch64_rust-async-process+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-process+default-devel-2.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-async-process+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-process+default-devel}"
SRC_URI[aarch64_rust-async-process+default-devel.sha256sum] = "e8ccc2b7f9f1a90c9d085b12aa9ff2fc03c29ce41fdecc3bcb16d092724d9f96"

URI_aarch64_rust-async-process+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-process+tracing-devel-2.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-async-process+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-process+tracing-devel}"
SRC_URI[aarch64_rust-async-process+tracing-devel.sha256sum] = "07466825e0a7e6ee37d48987614275e627c3e61aa5ba349beb47f6ab9fcd4786"

URI_aarch64_rust-async-process-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-process-devel-2.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-async-process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-process-devel}"
SRC_URI[aarch64_rust-async-process-devel.sha256sum] = "c38dde1742b77edfd51e9273e50edd4d5584bb38a95bd3d3a9cf0a1d9f9f0729"

RDEPENDS:rust-async-process+default-devel = " \
 cargo \
 rust-async-process-devel \
 "
RDEPENDS:rust-async-process+tracing-devel = " \
 cargo \
 rust-async-process-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-async-process-devel = " \
 cargo \
 rust \
 rust-async-channel+default-devel \
 rust-async-io+default-devel \
 rust-async-lock+default-devel \
 rust-async-signal+default-devel \
 rust-async-task+default-devel \
 rust-cfg-if+default-devel \
 rust-event-listener+default-devel \
 rust-futures-lite+default-devel \
 rust-rustix+fs-devel \
 rust-rustix+process-devel \
 rust-rustix+std-devel \
 rust-rustix-devel \
 "
