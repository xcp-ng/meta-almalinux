# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pydantic"
PV = "2.9.2"
PR = "4.el10_0"
PACKAGES = " \
 python-pydantic-doc \
 python3-pydantic \
 python3-pydantic+email \
 python3-pydantic+timezone \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pydantic-2.9.2-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b628337192ee8fdf7fc9981dc54efe08a8adadadc64998fa79e1d021fb2e47ce"

URI_x86_64_v2_python-pydantic-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-pydantic-doc-2.9.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-pydantic-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-pydantic-doc}"
SRC_URI[x86_64_v2_python-pydantic-doc.sha256sum] = "9537c41553f8d8e8c9601486473fdd8f032b7ae1ce0f050c0f8d71f9791be4e0"

URI_x86_64_v2_python3-pydantic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pydantic-2.9.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pydantic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pydantic}"
SRC_URI[x86_64_v2_python3-pydantic.sha256sum] = "c365611392a73e53e6e445d054e3f79549e89dd61ab1dc489071d62b09f9f131"

URI_x86_64_v2_python3-pydantic+email = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pydantic+email-2.9.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pydantic+email;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pydantic+email}"
SRC_URI[x86_64_v2_python3-pydantic+email.sha256sum] = "e2a41a8f856304257ccd9ce125b34b6d88979218ebfea3d00906ea195678d3de"

URI_x86_64_v2_python3-pydantic+timezone = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pydantic+timezone-2.9.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pydantic+timezone;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pydantic+timezone}"
SRC_URI[x86_64_v2_python3-pydantic+timezone.sha256sum] = "b6d973fa4420a3cf3cf6c1e10c1ae7b1256871d77a424ee66129edd002949b7f"

URI_aarch64_python-pydantic-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-pydantic-doc-2.9.2-4.el10_0.noarch.rpm;name=aarch64_python-pydantic-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-pydantic-doc}"
SRC_URI[aarch64_python-pydantic-doc.sha256sum] = "4e70fd521335e8ccc621f9c696b09bed7e13d7a1d558a0ccf65b6297741ce4e8"

URI_aarch64_python3-pydantic = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pydantic-2.9.2-4.el10_0.noarch.rpm;name=aarch64_python3-pydantic;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pydantic}"
SRC_URI[aarch64_python3-pydantic.sha256sum] = "443824f425b605981e155eaafe9238f5113b5371d389cd4229125cfe4aae86e9"

URI_aarch64_python3-pydantic+email = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pydantic+email-2.9.2-4.el10_0.noarch.rpm;name=aarch64_python3-pydantic+email;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pydantic+email}"
SRC_URI[aarch64_python3-pydantic+email.sha256sum] = "43a8c850a4cbb26159d1581bc2a69109b4b97e705e746776360d26ac69ef3677"

URI_aarch64_python3-pydantic+timezone = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pydantic+timezone-2.9.2-4.el10_0.noarch.rpm;name=aarch64_python3-pydantic+timezone;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pydantic+timezone}"
SRC_URI[aarch64_python3-pydantic+timezone.sha256sum] = "e80e8020e7e99e02549cee130d7bab319c44ff12a078d51614a0c127b46cf6b5"

RDEPENDS:python-pydantic-doc = " \
 "
RDEPENDS:python3-pydantic = " \
 python3 \
 python3-annotated-types \
 python3-pydantic-core \
 python3-typing-extensions \
 "
RDEPENDS:python3-pydantic+email = " \
 python3 \
 python3-email-validator \
 python3-pydantic \
 "
RDEPENDS:python3-pydantic+timezone = " \
 python3 \
 python3-pydantic \
 "
