# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nvmetcli"
PV = "0.8"
PR = "1.el10"
PACKAGES = " \
 nvmetcli \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/nvmetcli-0.8-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "db5e68dbd8fa01fbf581d71a5f85efba80632ede4eb8da51296946aad36d8736"

URI_x86_64_v2_nvmetcli = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/nvmetcli-0.8-1.el10.noarch.rpm;name=x86_64_v2_nvmetcli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nvmetcli}"
SRC_URI[x86_64_v2_nvmetcli.sha256sum] = "b7865f7b9e84d4c9344b61b6c0de05dc4f157e0c64b57704569f523b410f9da3"

URI_aarch64_nvmetcli = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/nvmetcli-0.8-1.el10.noarch.rpm;name=aarch64_nvmetcli;unpack=0"
SRC_URI:append = " ${URI_aarch64_nvmetcli}"
SRC_URI[aarch64_nvmetcli.sha256sum] = "b7865f7b9e84d4c9344b61b6c0de05dc4f157e0c64b57704569f523b410f9da3"

RDEPENDS:nvmetcli = " \
 bash \
 python3 \
 python3-configshell \
 python3-kmod \
 systemd \
 "
