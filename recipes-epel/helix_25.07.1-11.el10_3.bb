# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "helix"
PV = "25.07.1"
PR = "11.el10_3"
PACKAGES = " \
 helix \
 helix-parsers \
 helix-themes \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/helix-25.07.1-11.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3acfdb6530cbe65288d72674accafe0c5ded668ffae74f219783bb9c3e762014"

URI_x86_64_v2_helix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/helix-25.07.1-11.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_helix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_helix}"
SRC_URI[x86_64_v2_helix.sha256sum] = "c440dabcc885235d718b6dd0f5f4096af4180350aec7c22f6cf9b979f4189f2b"

URI_x86_64_v2_helix-parsers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/helix-parsers-25.07.1-11.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_helix-parsers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_helix-parsers}"
SRC_URI[x86_64_v2_helix-parsers.sha256sum] = "e06b177d6e419cdc4797294b5c9a6fae44b7728d8501b0169ef5a6b8fdde2de2"

URI_x86_64_v2_helix-themes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/helix-themes-25.07.1-11.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_helix-themes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_helix-themes}"
SRC_URI[x86_64_v2_helix-themes.sha256sum] = "bdb3bc3614a0a7bd6a67f4d6c2e357b50b5586e1607181bbcb4bee3e7974abbc"

URI_aarch64_helix = "${EPEL_MIRROR}/aarch64/Packages/h/helix-25.07.1-11.el10_3.aarch64.rpm;name=aarch64_helix;unpack=0"
SRC_URI:append = " ${URI_aarch64_helix}"
SRC_URI[aarch64_helix.sha256sum] = "b52d033bddc2f56aa8001fa6296c906cf71f4e671a3ae323d90c5038c4d8c530"

URI_aarch64_helix-parsers = "${EPEL_MIRROR}/aarch64/Packages/h/helix-parsers-25.07.1-11.el10_3.aarch64.rpm;name=aarch64_helix-parsers;unpack=0"
SRC_URI:append = " ${URI_aarch64_helix-parsers}"
SRC_URI[aarch64_helix-parsers.sha256sum] = "aafd2f0a39ae90bcd72c362f92500d41b0286ab87886758440466a9473086b61"

URI_aarch64_helix-themes = "${EPEL_MIRROR}/aarch64/Packages/h/helix-themes-25.07.1-11.el10_3.aarch64.rpm;name=aarch64_helix-themes;unpack=0"
SRC_URI:append = " ${URI_aarch64_helix-themes}"
SRC_URI[aarch64_helix-themes.sha256sum] = "0ea3c8382e1efcf6121c96595e031cad7c7ebde93502cf7a7d5e04bb52f6a80b"

RDEPENDS:helix = " \
 glibc \
 libgcc \
 "
RDEPENDS:helix-parsers = " \
 glibc \
 helix \
 libgcc \
 libstdc++ \
 "
RDEPENDS:helix-themes = " \
 helix \
 "
