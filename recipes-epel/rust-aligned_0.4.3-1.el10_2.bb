# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-aligned"
PV = "0.4.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-aligned+default-devel \
 rust-aligned-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-aligned-0.4.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9a73631f4216c62bed19df726d64e9b0665e85ce3cf45bdbbc6f8e8ca0edad0e"

URI_x86_64_v2_rust-aligned+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aligned+default-devel-0.4.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aligned+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aligned+default-devel}"
SRC_URI[x86_64_v2_rust-aligned+default-devel.sha256sum] = "b1ea5e33f46a895d265f4e19f71dae280a59cdfc545ab549a8f6226fb4c32c5b"

URI_x86_64_v2_rust-aligned-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aligned-devel-0.4.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aligned-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aligned-devel}"
SRC_URI[x86_64_v2_rust-aligned-devel.sha256sum] = "09214aa4e6a94273bbf06ddff94fc30d6c98105c143ba0317a4ace09564299a2"

URI_aarch64_rust-aligned+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aligned+default-devel-0.4.3-1.el10_2.noarch.rpm;name=aarch64_rust-aligned+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aligned+default-devel}"
SRC_URI[aarch64_rust-aligned+default-devel.sha256sum] = "56944a118dfba0fb2432e37e409c3372625ef3094973194982916cbf6be5964d"

URI_aarch64_rust-aligned-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aligned-devel-0.4.3-1.el10_2.noarch.rpm;name=aarch64_rust-aligned-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aligned-devel}"
SRC_URI[aarch64_rust-aligned-devel.sha256sum] = "db973e1cde9e03a96c5ba93784558d77b78d9271de0bce91927070c22aa40557"

RDEPENDS:rust-aligned+default-devel = " \
 cargo \
 rust-aligned-devel \
 "
RDEPENDS:rust-aligned-devel = " \
 cargo \
 rust-as-slice+default-devel \
 "
