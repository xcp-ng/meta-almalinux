# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-speaklater"
PV = "1.3"
PR = "36.el10_0"
PACKAGES = " \
 python3-speaklater \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-speaklater-1.3-36.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "308683f58e4aa64b391023fbd59000c68eb8685118683b40889a2d7eff87e9f9"

URI_x86_64_v2_python3-speaklater = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-speaklater-1.3-36.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-speaklater;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-speaklater}"
SRC_URI[x86_64_v2_python3-speaklater.sha256sum] = "f6a5c3223de73d43fdf0e4b0012e906221404d7eeca2c9174183464ed4d01799"

URI_aarch64_python3-speaklater = "${EPEL_MIRROR}/aarch64/Packages/p/python3-speaklater-1.3-36.el10_0.noarch.rpm;name=aarch64_python3-speaklater;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-speaklater}"
SRC_URI[aarch64_python3-speaklater.sha256sum] = "92a6a84e2f1956ff400cde462f014044b8e8d8c6146d0ecf6315b5147a1f3a1b"

RDEPENDS:python3-speaklater = " \
 python3 \
 "
