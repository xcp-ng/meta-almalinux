# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ncurses"
PV = "6.4"
PR = "14.20240127.el10"
PACKAGES = " \
 ncurses \
 ncurses-base \
 ncurses-c++-libs \
 ncurses-devel \
 ncurses-libs \
 ncurses-term \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/ncurses-6.4-14.20240127.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d4f2d6593ef2bd6bfc7a2c9f0ae4659d3fc24a15a84041305aad3e99d2419593"

URI_x86_64_v2_ncurses = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ncurses-6.4-14.20240127.el10.x86_64_v2.rpm;name=x86_64_v2_ncurses;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ncurses}"
SRC_URI[x86_64_v2_ncurses.sha256sum] = "7a4e0995bfc9f238743999de6e12d97ae82d184f756714cc5100fbfbfe0124a7"

URI_x86_64_v2_ncurses-base = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ncurses-base-6.4-14.20240127.el10.noarch.rpm;name=x86_64_v2_ncurses-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ncurses-base}"
SRC_URI[x86_64_v2_ncurses-base.sha256sum] = "b02d6198626d507fe2a25e5b3e03065b50cbd5a2e6f4f469663856cb51907ed3"

URI_x86_64_v2_ncurses-c++-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ncurses-c++-libs-6.4-14.20240127.el10.x86_64_v2.rpm;name=x86_64_v2_ncurses-c++-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ncurses-c++-libs}"
SRC_URI[x86_64_v2_ncurses-c++-libs.sha256sum] = "f6b8be082471d259020c1707656db664c2631f6aef94e7f52ff6d9fb9b7e25b4"

URI_x86_64_v2_ncurses-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ncurses-devel-6.4-14.20240127.el10.x86_64_v2.rpm;name=x86_64_v2_ncurses-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ncurses-devel}"
SRC_URI[x86_64_v2_ncurses-devel.sha256sum] = "464ea640ea01faf152ea2718456c8d9d1b76c9d86d4b59b6292fbe17c45cddef"

URI_x86_64_v2_ncurses-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ncurses-libs-6.4-14.20240127.el10.x86_64_v2.rpm;name=x86_64_v2_ncurses-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ncurses-libs}"
SRC_URI[x86_64_v2_ncurses-libs.sha256sum] = "8a5282b6aa1febea5d7adbd33a81195fdb77375c80c6f611381620476e7fa693"

URI_x86_64_v2_ncurses-term = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ncurses-term-6.4-14.20240127.el10.noarch.rpm;name=x86_64_v2_ncurses-term;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ncurses-term}"
SRC_URI[x86_64_v2_ncurses-term.sha256sum] = "6dc263325cae6f91f7e93cfbdacaf48bc82d6ccf57d40b55b9dfa1703645d6a5"

URI_aarch64_ncurses = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ncurses-6.4-14.20240127.el10.aarch64.rpm;name=aarch64_ncurses;unpack=0"
SRC_URI:append = " ${URI_aarch64_ncurses}"
SRC_URI[aarch64_ncurses.sha256sum] = "a50298965b0a8cd0757896424103166473970c918f7999254784400ecb39d80e"

URI_aarch64_ncurses-base = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ncurses-base-6.4-14.20240127.el10.noarch.rpm;name=aarch64_ncurses-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_ncurses-base}"
SRC_URI[aarch64_ncurses-base.sha256sum] = "b02d6198626d507fe2a25e5b3e03065b50cbd5a2e6f4f469663856cb51907ed3"

URI_aarch64_ncurses-c++-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ncurses-c++-libs-6.4-14.20240127.el10.aarch64.rpm;name=aarch64_ncurses-c++-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ncurses-c++-libs}"
SRC_URI[aarch64_ncurses-c++-libs.sha256sum] = "6eb13171e85477fd1d6053f77f8ebba52a9803b8b519fc1bcef5e86a26d52400"

URI_aarch64_ncurses-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ncurses-devel-6.4-14.20240127.el10.aarch64.rpm;name=aarch64_ncurses-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ncurses-devel}"
SRC_URI[aarch64_ncurses-devel.sha256sum] = "acdf7913567cdf5886820d95f3b639eec6f90bb410bebeb12325954f9028fb24"

URI_aarch64_ncurses-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ncurses-libs-6.4-14.20240127.el10.aarch64.rpm;name=aarch64_ncurses-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ncurses-libs}"
SRC_URI[aarch64_ncurses-libs.sha256sum] = "b673f46c107a170382c3b585e5282a07a1c4813f0551c9f25e797478b58d827e"

URI_aarch64_ncurses-term = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ncurses-term-6.4-14.20240127.el10.noarch.rpm;name=aarch64_ncurses-term;unpack=0"
SRC_URI:append = " ${URI_aarch64_ncurses-term}"
SRC_URI[aarch64_ncurses-term.sha256sum] = "6dc263325cae6f91f7e93cfbdacaf48bc82d6ccf57d40b55b9dfa1703645d6a5"

RDEPENDS:ncurses = " \
 glibc \
 ncurses-libs \
 "
RDEPENDS:ncurses-base = " \
 "
RDEPENDS:ncurses-c++-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 ncurses-libs \
 "
RDEPENDS:ncurses-devel = " \
 bash \
 ncurses-c++-libs \
 ncurses-devel \
 ncurses-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:ncurses-libs = " \
 glibc \
 ncurses-base \
 "
RDEPENDS:ncurses-term = " \
 ncurses-base \
 "
