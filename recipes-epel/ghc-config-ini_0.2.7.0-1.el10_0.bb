# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-config-ini"
PV = "0.2.7.0"
PR = "1.el10_0"
PACKAGES = " \
 ghc-config-ini \
 ghc-config-ini-devel \
 ghc-config-ini-doc \
 ghc-config-ini-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-config-ini-0.2.7.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eb13f12e0b8a3454e0f0f27b4f759bae5ca865508e89388a03f8b31b5cad82d5"

URI_x86_64_v2_ghc-config-ini = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-config-ini-0.2.7.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-config-ini;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-config-ini}"
SRC_URI[x86_64_v2_ghc-config-ini.sha256sum] = "5d315d3352a7b898a708dae88b116a9a48dca6313040e065792a3b7cac96a61e"

URI_x86_64_v2_ghc-config-ini-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-config-ini-devel-0.2.7.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-config-ini-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-config-ini-devel}"
SRC_URI[x86_64_v2_ghc-config-ini-devel.sha256sum] = "4e92dc49f9708b291fed844a0fb7a46e79f5e1ba660d57e827cdef3225a38b82"

URI_x86_64_v2_ghc-config-ini-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-config-ini-doc-0.2.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-config-ini-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-config-ini-doc}"
SRC_URI[x86_64_v2_ghc-config-ini-doc.sha256sum] = "fcc94243ea309a6f7b52ffb1806400ca535c177d4b8a3263194da99efebaa9c4"

URI_x86_64_v2_ghc-config-ini-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-config-ini-prof-0.2.7.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-config-ini-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-config-ini-prof}"
SRC_URI[x86_64_v2_ghc-config-ini-prof.sha256sum] = "7d31d27a6a07037385dc3b8abfff979570c4c2629c38c999660303a2e7b5b494"

URI_aarch64_ghc-config-ini = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-config-ini-0.2.7.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-config-ini;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-config-ini}"
SRC_URI[aarch64_ghc-config-ini.sha256sum] = "ecc43a9777225d241804b4557a7a356cabae8933c9ec9b9bdf7b45c71101ae78"

URI_aarch64_ghc-config-ini-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-config-ini-devel-0.2.7.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-config-ini-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-config-ini-devel}"
SRC_URI[aarch64_ghc-config-ini-devel.sha256sum] = "063c501f86fe9b17dbefb122dfa5a1d4ab8cfc988787543b8f7b353dd1e7a317"

URI_aarch64_ghc-config-ini-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-config-ini-doc-0.2.7.0-1.el10_0.noarch.rpm;name=aarch64_ghc-config-ini-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-config-ini-doc}"
SRC_URI[aarch64_ghc-config-ini-doc.sha256sum] = "ccf1bfd9dbc331f97c26369eddb4f5c12cf4214637791cc4734e8c6b45e1d647"

URI_aarch64_ghc-config-ini-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-config-ini-prof-0.2.7.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-config-ini-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-config-ini-prof}"
SRC_URI[aarch64_ghc-config-ini-prof.sha256sum] = "65babef019b7a32f4d837babb9f534d176fc24002116efcd8d616a0deff30475"

RDEPENDS:ghc-config-ini = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-integer-logarithms \
 ghc-megaparsec \
 ghc-mtl \
 ghc-os-string \
 ghc-parser-combinators \
 ghc-pretty \
 ghc-primitive \
 ghc-scientific \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 ghc-unordered-containers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-config-ini-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-config-ini \
 ghc-containers-devel \
 ghc-megaparsec-devel \
 ghc-text-devel \
 ghc-transformers-devel \
 ghc-unordered-containers-devel \
 "
RDEPENDS:ghc-config-ini-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-config-ini-prof = " \
 ghc-base-prof \
 ghc-config-ini-devel \
 ghc-containers-prof \
 ghc-megaparsec-prof \
 ghc-text-prof \
 ghc-transformers-prof \
 ghc-unordered-containers-prof \
 "
