# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ostree"
PV = "2025.7"
PR = "1.el10"
PACKAGES = " \
 ostree \
 ostree-devel \
 ostree-grub2 \
 ostree-libs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ostree-2025.7-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1cf0a8dee9d7b126abd8b012c8e243b8f3512d65cf6a2dbdebaf71e125a634d1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ostree-2025.7-1.el10.x86_64_v2.rpm;name=x86_64_v2_ostree;unpack=0"
SRC_URI[x86_64_v2_ostree.sha256sum] = "246a1fb4d3a69dcb653988959cb5c5b9de45c0507e3ae4de54aed96ffc1337dc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ostree-devel-2025.7-1.el10.x86_64_v2.rpm;name=x86_64_v2_ostree-devel;unpack=0"
SRC_URI[x86_64_v2_ostree-devel.sha256sum] = "3c276d3c73ad418a159d0cf899015f5b5571011a9289a86cc20da7130a75f6b5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ostree-grub2-2025.7-1.el10.x86_64_v2.rpm;name=x86_64_v2_ostree-grub2;unpack=0"
SRC_URI[x86_64_v2_ostree-grub2.sha256sum] = "4f6ffe639412e7cde701bab916c2685577e10224694c7e8cae5cf4951b43e50c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ostree-libs-2025.7-1.el10.x86_64_v2.rpm;name=x86_64_v2_ostree-libs;unpack=0"
SRC_URI[x86_64_v2_ostree-libs.sha256sum] = "19ec9297819c0fd52985a4e98de0f7382c9d05febda4b648c8362b5f9f26ce23"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ostree-2025.7-1.el10.aarch64.rpm;name=aarch64_ostree;unpack=0"
SRC_URI[aarch64_ostree.sha256sum] = "84e55f69b40fd0fad3a8541a65116adaa8402ee4395f509405290ea6d22961ae"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ostree-devel-2025.7-1.el10.aarch64.rpm;name=aarch64_ostree-devel;unpack=0"
SRC_URI[aarch64_ostree-devel.sha256sum] = "e551f35f9b88c31d1192f32fc6e9d1ec5c89c143ba2e3149d198860d43bf84c4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ostree-grub2-2025.7-1.el10.aarch64.rpm;name=aarch64_ostree-grub2;unpack=0"
SRC_URI[aarch64_ostree-grub2.sha256sum] = "0698132e43c60b8b59f8656e15b330434936df3ec159b1ef9ad7f8eca639dd1e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ostree-libs-2025.7-1.el10.aarch64.rpm;name=aarch64_ostree-libs;unpack=0"
SRC_URI[aarch64_ostree-libs.sha256sum] = "b8edfe7417c62488bd4c281e711c1f2056bcac9e3d2b1303b2fa1e0a583395f3"

RDEPENDS:ostree = " \
 bash \
 composefs \
 composefs-libs \
 dracut \
 fuse-libs \
 glib2 \
 glibc \
 gnupg2 \
 libarchive \
 libgcc \
 libselinux \
 openssl-libs \
 ostree-libs \
 systemd \
 systemd-libs \
 "
RDEPENDS:ostree-devel = " \
 composefs-devel \
 glib2-devel \
 gpgme-devel \
 libarchive-devel \
 libcurl-devel \
 libgpg-error-devel \
 libselinux-devel \
 openssl-devel \
 ostree-libs \
 pkgconf-pkg-config \
 systemd-devel \
 xz-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:ostree-grub2:x86_64_v2 = " \
 bash \
 grub2-pc \
 ostree \
"
RDEPENDS:ostree-grub2:aarch64 = " \
 bash \
 grub2-efi-aa64 \
 ostree \
"
RDEPENDS:ostree-libs = " \
 composefs-libs \
 glib2 \
 glibc \
 gpgme \
 libarchive \
 libgcc \
 libgpg-error \
 libmount \
 libselinux \
 openssl-libs \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 zlib-ng-compat \
 "
