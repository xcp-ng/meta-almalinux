# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "PDAL"
PV = "2.8.3"
PR = "1.el10_0"
PACKAGES = " \
 PDAL \
 PDAL-devel \
 PDAL-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/PDAL-2.8.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b48309cbfe686f05d2dca3f1ac7253ad988f45ce60381786b93b393645599166"

URI_x86_64_v2_PDAL = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/PDAL-2.8.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_PDAL;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_PDAL}"
SRC_URI[x86_64_v2_PDAL.sha256sum] = "3c78eb97cf60f8bd1735b75000c955a3e0dc9df9821db4ec91523dc99012649b"

URI_x86_64_v2_PDAL-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/PDAL-devel-2.8.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_PDAL-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_PDAL-devel}"
SRC_URI[x86_64_v2_PDAL-devel.sha256sum] = "3686f19f26c788847a765f27cce4141990032badbfeee842a53145a0d74d4e9a"

URI_x86_64_v2_PDAL-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/PDAL-libs-2.8.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_PDAL-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_PDAL-libs}"
SRC_URI[x86_64_v2_PDAL-libs.sha256sum] = "cd5677d26f527a3a6a2ac41f140517ffbca97c9d1ef253d3a34406349e3ffdc3"

URI_aarch64_PDAL = "${EPEL_MIRROR}/aarch64/Packages/p/PDAL-2.8.3-1.el10_0.aarch64.rpm;name=aarch64_PDAL;unpack=0"
SRC_URI:append = " ${URI_aarch64_PDAL}"
SRC_URI[aarch64_PDAL.sha256sum] = "dd49d01fd154c7e4d4661e1bc644ca09120a9f5f28ac320542f12d5fe5b85fbd"

URI_aarch64_PDAL-devel = "${EPEL_MIRROR}/aarch64/Packages/p/PDAL-devel-2.8.3-1.el10_0.aarch64.rpm;name=aarch64_PDAL-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_PDAL-devel}"
SRC_URI[aarch64_PDAL-devel.sha256sum] = "0bb84b443baf53032b20cff3f2e6a517dec1fb7e7ed69db652ee9b329a61ec0a"

URI_aarch64_PDAL-libs = "${EPEL_MIRROR}/aarch64/Packages/p/PDAL-libs-2.8.3-1.el10_0.aarch64.rpm;name=aarch64_PDAL-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_PDAL-libs}"
SRC_URI[aarch64_PDAL-libs.sha256sum] = "4257faa10c2611ca1975b9daf7c1ab90efce3366878e6faa14bfd54c1dd98ebb"

RDEPENDS:PDAL = " \
 PDAL-libs \
 bash-completion \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:PDAL-devel = " \
 PDAL-libs \
 bash \
 cmake-filesystem \
 libxml2-devel \
 pkgconf-pkg-config \
 virtual/pkgconfig_gdal_ \
 "
RDEPENDS:PDAL-libs = " \
 gdal-libs \
 glibc \
 libgcc \
 libgeotiff \
 libpq \
 libstdc++ \
 libxml2 \
 libzstd \
 openssl-libs \
 proj \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
