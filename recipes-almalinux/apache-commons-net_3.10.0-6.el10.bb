# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apache-commons-net"
PV = "3.10.0"
PR = "6.el10"
PACKAGES = " \
 apache-commons-net \
 apache-commons-net-javadoc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/apache-commons-net-3.10.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "112cfb77da5ba6211253ae634de4260cffc749094d6f2c61d83bfbf4c072756f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apache-commons-net-3.10.0-6.el10.noarch.rpm;name=x86_64_v2_apache-commons-net;unpack=0"
SRC_URI[x86_64_v2_apache-commons-net.sha256sum] = "c0969edda9a00ea4295604555bbb84f3c1638403c72f9e9a856f0c19b4fd7640"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/apache-commons-net-javadoc-3.10.0-6.el10.noarch.rpm;name=x86_64_v2_apache-commons-net-javadoc;unpack=0"
SRC_URI[x86_64_v2_apache-commons-net-javadoc.sha256sum] = "dd569c470bd314cda672bf9a03ce7037880daf2c0c6620ca1b7db39b6bf61ab5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apache-commons-net-3.10.0-6.el10.noarch.rpm;name=aarch64_apache-commons-net;unpack=0"
SRC_URI[aarch64_apache-commons-net.sha256sum] = "c0969edda9a00ea4295604555bbb84f3c1638403c72f9e9a856f0c19b4fd7640"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/apache-commons-net-javadoc-3.10.0-6.el10.noarch.rpm;name=aarch64_apache-commons-net-javadoc;unpack=0"
SRC_URI[aarch64_apache-commons-net-javadoc.sha256sum] = "dd569c470bd314cda672bf9a03ce7037880daf2c0c6620ca1b7db39b6bf61ab5"

RDEPENDS:apache-commons-net = " \
 javapackages-filesystem \
 "
RDEPENDS:apache-commons-net-javadoc = " \
 javapackages-filesystem \
 "
