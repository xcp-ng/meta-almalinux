# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-compression"
PV = "0.4.19"
PR = "4.el10_2"
PACKAGES = " \
 rust-async-compression+all-algorithms-devel \
 rust-async-compression+all-devel \
 rust-async-compression+all-implementations-devel \
 rust-async-compression+brotli-devel \
 rust-async-compression+bzip2-devel \
 rust-async-compression+default-devel \
 rust-async-compression+deflate-devel \
 rust-async-compression+deflate64-devel \
 rust-async-compression+flate2-devel \
 rust-async-compression+futures-io-devel \
 rust-async-compression+gzip-devel \
 rust-async-compression+libzstd-devel \
 rust-async-compression+lzma-devel \
 rust-async-compression+tokio-devel \
 rust-async-compression+xz-devel \
 rust-async-compression+xz2-devel \
 rust-async-compression+zlib-devel \
 rust-async-compression+zstd-devel \
 rust-async-compression+zstd-safe-devel \
 rust-async-compression+zstdmt-devel \
 rust-async-compression-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-compression-0.4.19-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "667e86b0bd4e8dc27fe4d447ca154dd65900169be263a6ad24b1e43a1633f55e"

URI_x86_64_v2_rust-async-compression+all-algorithms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+all-algorithms-devel-0.4.19-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+all-algorithms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+all-algorithms-devel}"
SRC_URI[x86_64_v2_rust-async-compression+all-algorithms-devel.sha256sum] = "e8265d259194f2e3b809db8933ba75f60b70d95adc65f59239a8272e3a078790"

URI_x86_64_v2_rust-async-compression+all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+all-devel-0.4.19-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+all-devel}"
SRC_URI[x86_64_v2_rust-async-compression+all-devel.sha256sum] = "1fad26d50ba9949a1aa474b4188d5fbeeef2cd541c2489408f604745d1bd9e25"

URI_x86_64_v2_rust-async-compression+all-implementations-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+all-implementations-devel-0.4.19-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+all-implementations-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+all-implementations-devel}"
SRC_URI[x86_64_v2_rust-async-compression+all-implementations-devel.sha256sum] = "588628f739b2cce46a021222bf9c43106d2512b4010b09ec9de1962e39eafe75"

URI_x86_64_v2_rust-async-compression+brotli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+brotli-devel-0.4.19-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+brotli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+brotli-devel}"
SRC_URI[x86_64_v2_rust-async-compression+brotli-devel.sha256sum] = "796bd96270ec1fe86d88e1a32e8f2c2b1bd9ca8e5581167075b639aee7f696cf"

URI_x86_64_v2_rust-async-compression+bzip2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+bzip2-devel-0.4.19-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+bzip2-devel}"
SRC_URI[x86_64_v2_rust-async-compression+bzip2-devel.sha256sum] = "6f5be8b83759b59d02c05adf9cbbff3abcf90a311a66985c4b0ec7df77b006e8"

URI_x86_64_v2_rust-async-compression+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+default-devel-0.4.19-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+default-devel}"
SRC_URI[x86_64_v2_rust-async-compression+default-devel.sha256sum] = "63c75b76eda4f68263ced0921499326e37e8617dab20b248c71301759f6e19e1"

URI_x86_64_v2_rust-async-compression+deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+deflate-devel-0.4.19-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+deflate-devel}"
SRC_URI[x86_64_v2_rust-async-compression+deflate-devel.sha256sum] = "cfa9eb73cd209b4296108f2f7ac6ffaec62b0c7470a9409932d4a46cb3980cb5"

URI_x86_64_v2_rust-async-compression+deflate64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+deflate64-devel-0.4.19-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+deflate64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+deflate64-devel}"
SRC_URI[x86_64_v2_rust-async-compression+deflate64-devel.sha256sum] = "56f71e5cf496157f8a78467d6d792084158550d2d28fb678c3a6f66a2e7cc396"

URI_x86_64_v2_rust-async-compression+flate2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+flate2-devel-0.4.19-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+flate2-devel}"
SRC_URI[x86_64_v2_rust-async-compression+flate2-devel.sha256sum] = "f0b6b5900e54ec9bd2151c571f7c0b2ea9aee3e64511819f243e8a8a77b779d2"

URI_x86_64_v2_rust-async-compression+futures-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+futures-io-devel-0.4.19-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+futures-io-devel}"
SRC_URI[x86_64_v2_rust-async-compression+futures-io-devel.sha256sum] = "60cd910c737293362c93a5d4e1cd70c1588d99d4e001f9764e3f6ad89a042464"

URI_x86_64_v2_rust-async-compression+gzip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+gzip-devel-0.4.19-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+gzip-devel}"
SRC_URI[x86_64_v2_rust-async-compression+gzip-devel.sha256sum] = "65dadb0e9bd78b79ad9a3fc3c7dfd970f84082b407a7ff0e633ccf0d0965223c"

URI_x86_64_v2_rust-async-compression+libzstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+libzstd-devel-0.4.19-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+libzstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+libzstd-devel}"
SRC_URI[x86_64_v2_rust-async-compression+libzstd-devel.sha256sum] = "80683573955d6a1e19e57e7cbd0293e8d5d164180997cd791920329cabe0e602"

URI_x86_64_v2_rust-async-compression+lzma-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+lzma-devel-0.4.19-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+lzma-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+lzma-devel}"
SRC_URI[x86_64_v2_rust-async-compression+lzma-devel.sha256sum] = "58f378752491404be3570a0a9face42e11bc550d2e226dd2e68d1b2d5762af0a"

URI_x86_64_v2_rust-async-compression+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+tokio-devel-0.4.19-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+tokio-devel}"
SRC_URI[x86_64_v2_rust-async-compression+tokio-devel.sha256sum] = "19387d70cc080a71e248df3d67e49da44aa5274f50bf3c3edc8b856190dbccca"

URI_x86_64_v2_rust-async-compression+xz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+xz-devel-0.4.19-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+xz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+xz-devel}"
SRC_URI[x86_64_v2_rust-async-compression+xz-devel.sha256sum] = "35607c68411456edae6f4880fb1e45b21fb8b9a0466b8ba93fef8fc1c909809e"

URI_x86_64_v2_rust-async-compression+xz2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+xz2-devel-0.4.19-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+xz2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+xz2-devel}"
SRC_URI[x86_64_v2_rust-async-compression+xz2-devel.sha256sum] = "cd1a006965624913dd7e69616c497b471253a6e3cd56843671746d98e2d602ab"

URI_x86_64_v2_rust-async-compression+zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+zlib-devel-0.4.19-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+zlib-devel}"
SRC_URI[x86_64_v2_rust-async-compression+zlib-devel.sha256sum] = "49322235c7fb59f92e578f9951c9cd453b6b702459b65fff53161629fad97507"

URI_x86_64_v2_rust-async-compression+zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+zstd-devel-0.4.19-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+zstd-devel}"
SRC_URI[x86_64_v2_rust-async-compression+zstd-devel.sha256sum] = "2190cfb644a883a9694fe4ac185f00ea7774d59df96dfb9d1c8efb51e2c20d0b"

URI_x86_64_v2_rust-async-compression+zstd-safe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+zstd-safe-devel-0.4.19-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+zstd-safe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+zstd-safe-devel}"
SRC_URI[x86_64_v2_rust-async-compression+zstd-safe-devel.sha256sum] = "5c7abf97e0dff5f5bca0104f1b6903ff0e006d83ab988a8b8e55bf9c6cf9fd1c"

URI_x86_64_v2_rust-async-compression+zstdmt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+zstdmt-devel-0.4.19-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+zstdmt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+zstdmt-devel}"
SRC_URI[x86_64_v2_rust-async-compression+zstdmt-devel.sha256sum] = "171482d7212f7c51c7949bb79d0eaa246f2b49439143ef64f3a2d189435b4708"

URI_x86_64_v2_rust-async-compression-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression-devel-0.4.19-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression-devel}"
SRC_URI[x86_64_v2_rust-async-compression-devel.sha256sum] = "b6f6e58593caa1714349b28d4f9299e6a778a2c70009774e87c9eab2cf655de2"

URI_aarch64_rust-async-compression+all-algorithms-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+all-algorithms-devel-0.4.19-4.el10_2.noarch.rpm;name=aarch64_rust-async-compression+all-algorithms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+all-algorithms-devel}"
SRC_URI[aarch64_rust-async-compression+all-algorithms-devel.sha256sum] = "51fbd7b34446a244b5e023a44b7b971aa98b9c860d240daf89519bd3db2681c0"

URI_aarch64_rust-async-compression+all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+all-devel-0.4.19-4.el10_2.noarch.rpm;name=aarch64_rust-async-compression+all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+all-devel}"
SRC_URI[aarch64_rust-async-compression+all-devel.sha256sum] = "316d478d7d1527229ebb032a63bb2c2ca74a11b5869fa9911d4d1963e283e77e"

URI_aarch64_rust-async-compression+all-implementations-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+all-implementations-devel-0.4.19-4.el10_2.noarch.rpm;name=aarch64_rust-async-compression+all-implementations-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+all-implementations-devel}"
SRC_URI[aarch64_rust-async-compression+all-implementations-devel.sha256sum] = "6ff97fa13f694fafff38c4e6c461d057c2bd9ce568ec7144d9ae15775a48c262"

URI_aarch64_rust-async-compression+brotli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+brotli-devel-0.4.19-4.el10_2.noarch.rpm;name=aarch64_rust-async-compression+brotli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+brotli-devel}"
SRC_URI[aarch64_rust-async-compression+brotli-devel.sha256sum] = "8b8d402d4a0ee9ecce4e764d5f9b603ff750e0f9a1dcd301db5378f88664f95b"

URI_aarch64_rust-async-compression+bzip2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+bzip2-devel-0.4.19-4.el10_2.noarch.rpm;name=aarch64_rust-async-compression+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+bzip2-devel}"
SRC_URI[aarch64_rust-async-compression+bzip2-devel.sha256sum] = "7b6c807eef7f8186f4ca7f2000184cb575175f6eb98cb3bd38b3b42de946bfcf"

URI_aarch64_rust-async-compression+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+default-devel-0.4.19-4.el10_2.noarch.rpm;name=aarch64_rust-async-compression+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+default-devel}"
SRC_URI[aarch64_rust-async-compression+default-devel.sha256sum] = "e1d575a94ab978feaa3f4da201254ddeee6221c293ec31bb305162b2e57ab87e"

URI_aarch64_rust-async-compression+deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+deflate-devel-0.4.19-4.el10_2.noarch.rpm;name=aarch64_rust-async-compression+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+deflate-devel}"
SRC_URI[aarch64_rust-async-compression+deflate-devel.sha256sum] = "31201f7373b288bd4b26a56bd6f07f1f59a8b27f50beb39a33d31983d53450cd"

URI_aarch64_rust-async-compression+deflate64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+deflate64-devel-0.4.19-4.el10_2.noarch.rpm;name=aarch64_rust-async-compression+deflate64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+deflate64-devel}"
SRC_URI[aarch64_rust-async-compression+deflate64-devel.sha256sum] = "794957c86121cabc5dd86ea4ae08855fb228136a87ce4b61ba2e201baf91480c"

URI_aarch64_rust-async-compression+flate2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+flate2-devel-0.4.19-4.el10_2.noarch.rpm;name=aarch64_rust-async-compression+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+flate2-devel}"
SRC_URI[aarch64_rust-async-compression+flate2-devel.sha256sum] = "816c06e9f5bdb00a707a8b9f40cc69b59b11c1d2a6570bed944a705cef2906cf"

URI_aarch64_rust-async-compression+futures-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+futures-io-devel-0.4.19-4.el10_2.noarch.rpm;name=aarch64_rust-async-compression+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+futures-io-devel}"
SRC_URI[aarch64_rust-async-compression+futures-io-devel.sha256sum] = "25843dc1ba508030901b7e7288c4cf7ea50a1242f2eb8bf67a8486f50aee0582"

URI_aarch64_rust-async-compression+gzip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+gzip-devel-0.4.19-4.el10_2.noarch.rpm;name=aarch64_rust-async-compression+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+gzip-devel}"
SRC_URI[aarch64_rust-async-compression+gzip-devel.sha256sum] = "47b796448a749c044c39bb3430490488b3ecdf000b8a0e31d5a5aab892d97ab0"

URI_aarch64_rust-async-compression+libzstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+libzstd-devel-0.4.19-4.el10_2.noarch.rpm;name=aarch64_rust-async-compression+libzstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+libzstd-devel}"
SRC_URI[aarch64_rust-async-compression+libzstd-devel.sha256sum] = "c066f068764e2210540ae80a648bc734ead913d6c349fdd0f6710fabfd78f306"

URI_aarch64_rust-async-compression+lzma-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+lzma-devel-0.4.19-4.el10_2.noarch.rpm;name=aarch64_rust-async-compression+lzma-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+lzma-devel}"
SRC_URI[aarch64_rust-async-compression+lzma-devel.sha256sum] = "8b374ca8408f8bdc59ab93df68e42cc37c2080cd4c063e3a94b206a89981c7bf"

URI_aarch64_rust-async-compression+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+tokio-devel-0.4.19-4.el10_2.noarch.rpm;name=aarch64_rust-async-compression+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+tokio-devel}"
SRC_URI[aarch64_rust-async-compression+tokio-devel.sha256sum] = "732cea88b44435813b66cd3e5646d431a34350f8f067615d9a098ad67a0e7fe8"

URI_aarch64_rust-async-compression+xz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+xz-devel-0.4.19-4.el10_2.noarch.rpm;name=aarch64_rust-async-compression+xz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+xz-devel}"
SRC_URI[aarch64_rust-async-compression+xz-devel.sha256sum] = "b9479caeab6148230869b4208f4a02989641f19e973d8b9b2c9d7e0ac693f96c"

URI_aarch64_rust-async-compression+xz2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+xz2-devel-0.4.19-4.el10_2.noarch.rpm;name=aarch64_rust-async-compression+xz2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+xz2-devel}"
SRC_URI[aarch64_rust-async-compression+xz2-devel.sha256sum] = "95e0f24c9e2e60ac8ae1257b0e14cb99cc8ba599f5c0f92152e95d27ab6dfcdf"

URI_aarch64_rust-async-compression+zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+zlib-devel-0.4.19-4.el10_2.noarch.rpm;name=aarch64_rust-async-compression+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+zlib-devel}"
SRC_URI[aarch64_rust-async-compression+zlib-devel.sha256sum] = "9926900aaa9103eed681d5f64c83a3e814ef56506b48e554d04bf1feea02e9af"

URI_aarch64_rust-async-compression+zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+zstd-devel-0.4.19-4.el10_2.noarch.rpm;name=aarch64_rust-async-compression+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+zstd-devel}"
SRC_URI[aarch64_rust-async-compression+zstd-devel.sha256sum] = "eb234c5bc9faca72a23c32d1add76fb5ef4469274a2058a27f9c6bf251072dc0"

URI_aarch64_rust-async-compression+zstd-safe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+zstd-safe-devel-0.4.19-4.el10_2.noarch.rpm;name=aarch64_rust-async-compression+zstd-safe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+zstd-safe-devel}"
SRC_URI[aarch64_rust-async-compression+zstd-safe-devel.sha256sum] = "03b6aa197ae5e0fcc495229536bbfb199bb95bb6ac50a2cb42f102c8768bb6e8"

URI_aarch64_rust-async-compression+zstdmt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+zstdmt-devel-0.4.19-4.el10_2.noarch.rpm;name=aarch64_rust-async-compression+zstdmt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+zstdmt-devel}"
SRC_URI[aarch64_rust-async-compression+zstdmt-devel.sha256sum] = "0da5455167cd6cf85aa45a6792370893996a686efcf9affb9716158907271fa3"

URI_aarch64_rust-async-compression-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression-devel-0.4.19-4.el10_2.noarch.rpm;name=aarch64_rust-async-compression-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression-devel}"
SRC_URI[aarch64_rust-async-compression-devel.sha256sum] = "5356007023029490b5bbdc1de9c856318f1829e034b69ef5a1e40379018e5f2d"

RDEPENDS:rust-async-compression+all-algorithms-devel = " \
 cargo \
 rust-async-compression+brotli-devel \
 rust-async-compression+bzip2-devel \
 rust-async-compression+deflate-devel \
 rust-async-compression+deflate64-devel \
 rust-async-compression+gzip-devel \
 rust-async-compression+lzma-devel \
 rust-async-compression+xz-devel \
 rust-async-compression+zlib-devel \
 rust-async-compression+zstd-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-async-compression+all-devel = " \
 cargo \
 rust-async-compression+all-algorithms-devel \
 rust-async-compression+all-implementations-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-async-compression+all-implementations-devel = " \
 cargo \
 rust-async-compression+futures-io-devel \
 rust-async-compression+tokio-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-async-compression+brotli-devel = " \
 cargo \
 rust-async-compression-devel \
 rust-brotli+default-devel \
 "
RDEPENDS:rust-async-compression+bzip2-devel = " \
 cargo \
 rust-async-compression-devel \
 rust-bzip2+default-devel \
 "
RDEPENDS:rust-async-compression+default-devel = " \
 cargo \
 rust-async-compression-devel \
 "
RDEPENDS:rust-async-compression+deflate-devel = " \
 cargo \
 rust-async-compression+flate2-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-async-compression+deflate64-devel = " \
 cargo \
 rust-async-compression-devel \
 rust-deflate64+default-devel \
 "
RDEPENDS:rust-async-compression+flate2-devel = " \
 cargo \
 rust-async-compression-devel \
 rust-flate2+default-devel \
 "
RDEPENDS:rust-async-compression+futures-io-devel = " \
 cargo \
 rust-async-compression-devel \
 rust-futures-io+std-devel \
 rust-futures-io-devel \
 "
RDEPENDS:rust-async-compression+gzip-devel = " \
 cargo \
 rust-async-compression+flate2-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-async-compression+libzstd-devel = " \
 cargo \
 rust-async-compression-devel \
 rust-zstd-devel \
 "
RDEPENDS:rust-async-compression+lzma-devel = " \
 cargo \
 rust-async-compression+xz2-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-async-compression+tokio-devel = " \
 cargo \
 rust-async-compression-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-async-compression+xz-devel = " \
 cargo \
 rust-async-compression+xz2-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-async-compression+xz2-devel = " \
 cargo \
 rust-async-compression-devel \
 rust-xz2+default-devel \
 "
RDEPENDS:rust-async-compression+zlib-devel = " \
 cargo \
 rust-async-compression+flate2-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-async-compression+zstd-devel = " \
 cargo \
 rust-async-compression+libzstd-devel \
 rust-async-compression+zstd-safe-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-async-compression+zstd-safe-devel = " \
 cargo \
 rust-async-compression-devel \
 rust-zstd-safe-devel \
 "
RDEPENDS:rust-async-compression+zstdmt-devel = " \
 cargo \
 rust-async-compression+zstd-devel \
 rust-async-compression-devel \
 rust-zstd-safe+zstdmt-devel \
 rust-zstd-safe-devel \
 "
RDEPENDS:rust-async-compression-devel = " \
 cargo \
 rust-futures-core-devel \
 rust-memchr+default-devel \
 rust-pin-project-lite+default-devel \
 "
