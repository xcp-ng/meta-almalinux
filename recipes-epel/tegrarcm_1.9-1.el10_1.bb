# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tegrarcm"
PV = "1.9"
PR = "1.el10_1"
PACKAGES = " \
 tegrarcm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tegrarcm-1.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6cba43d1921b3d71e00eec7a2fa5ba8ed8b47779c8305a28335c6ba87c753ec"

URI_x86_64_v2_tegrarcm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tegrarcm-1.9-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tegrarcm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tegrarcm}"
SRC_URI[x86_64_v2_tegrarcm.sha256sum] = "8a71c1e0dc28e54f33724bf2b04b71bd6968aa8d2ce46865819ffe6ed3399a83"

URI_aarch64_tegrarcm = "${EPEL_MIRROR}/aarch64/Packages/t/tegrarcm-1.9-1.el10_1.aarch64.rpm;name=aarch64_tegrarcm;unpack=0"
SRC_URI:append = " ${URI_aarch64_tegrarcm}"
SRC_URI[aarch64_tegrarcm.sha256sum] = "d523a9bea04a011aecf547e7537dab43569dde6f739ec0a95e92794aa067f4bf"

RDEPENDS:tegrarcm = " \
 cryptopp \
 glibc \
 libgcc \
 libstdc++ \
 libusb1 \
 "
