# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-ktextwidgets"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-ktextwidgets \
 kf6-ktextwidgets-devel \
 kf6-ktextwidgets-doc \
 kf6-ktextwidgets-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-ktextwidgets-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1e6a0db41dce42486bd9ce506e855da907ec06145974670a46e173556e81c8c"

URI_x86_64_v2_kf6-ktextwidgets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktextwidgets-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ktextwidgets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktextwidgets}"
SRC_URI[x86_64_v2_kf6-ktextwidgets.sha256sum] = "9bbe5c50abc637c0cf6a2f998234570871bbc2e018f0ff1f2751db25fa8858e5"

URI_x86_64_v2_kf6-ktextwidgets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktextwidgets-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ktextwidgets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktextwidgets-devel}"
SRC_URI[x86_64_v2_kf6-ktextwidgets-devel.sha256sum] = "d2ed90d4ee76b578e21924bc07608d96a8ca0b17cfec8918244c0b2d5255b042"

URI_x86_64_v2_kf6-ktextwidgets-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktextwidgets-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ktextwidgets-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktextwidgets-doc}"
SRC_URI[x86_64_v2_kf6-ktextwidgets-doc.sha256sum] = "3744155466f05495706926e48de278938bf8cf98ce5d069c012009b7e17dbeaa"

URI_x86_64_v2_kf6-ktextwidgets-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktextwidgets-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ktextwidgets-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktextwidgets-html}"
SRC_URI[x86_64_v2_kf6-ktextwidgets-html.sha256sum] = "b1d95da60b49ed44c47a0984f36c8165b3ef36805741e6d416dc0d1bbf367353"

URI_aarch64_kf6-ktextwidgets = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktextwidgets-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-ktextwidgets;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktextwidgets}"
SRC_URI[aarch64_kf6-ktextwidgets.sha256sum] = "954a5c6997ecdf85ca421794bb29e9cec9df8145c9c2a5fcebf16c6a6a569738"

URI_aarch64_kf6-ktextwidgets-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktextwidgets-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-ktextwidgets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktextwidgets-devel}"
SRC_URI[aarch64_kf6-ktextwidgets-devel.sha256sum] = "444008b22fc10dec740986c1466dd2c90ad3938f24c00530ee8a200ade9a3392"

URI_aarch64_kf6-ktextwidgets-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktextwidgets-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-ktextwidgets-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktextwidgets-doc}"
SRC_URI[aarch64_kf6-ktextwidgets-doc.sha256sum] = "1ebdeb1999ff054500290ca25112f6d7b11d95b6168b39fbe38bbf3622c2b83b"

URI_aarch64_kf6-ktextwidgets-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktextwidgets-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-ktextwidgets-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktextwidgets-html}"
SRC_URI[aarch64_kf6-ktextwidgets-html.sha256sum] = "a16166306ac13a70eaca2a641588665f1efae9254783aa550db1a5bc46ed3f04"

RDEPENDS:kf6-ktextwidgets = " \
 glibc \
 kf6-filesystem \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtspeech \
 "
RDEPENDS:kf6-ktextwidgets-devel = " \
 cmake-filesystem \
 glibc \
 kf6-ki18n-devel \
 kf6-ktextwidgets \
 kf6-sonnet-devel \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-ktextwidgets-doc = " \
 "
RDEPENDS:kf6-ktextwidgets-html = " \
 "
