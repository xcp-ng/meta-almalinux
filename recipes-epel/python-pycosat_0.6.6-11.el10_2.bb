# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pycosat"
PV = "0.6.6"
PR = "11.el10_2"
PACKAGES = " \
 python3-pycosat \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pycosat-0.6.6-11.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fcee1f37651ff206f6fc93370a6036a8fcfd346e549c22bea9021e16639bcbbf"

URI_x86_64_v2_python3-pycosat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pycosat-0.6.6-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pycosat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pycosat}"
SRC_URI[x86_64_v2_python3-pycosat.sha256sum] = "76b610bc9568a3bcee466cf02194774a3cac5dd4aff9615673ae770d3911ad7f"

URI_aarch64_python3-pycosat = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pycosat-0.6.6-11.el10_2.aarch64.rpm;name=aarch64_python3-pycosat;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pycosat}"
SRC_URI[aarch64_python3-pycosat.sha256sum] = "ccf2955e280eab8b358081c9c2c991e72e4e4726251b0514f90bef273b306377"

RDEPENDS:python3-pycosat = " \
 glibc \
 picosat-libs \
 python3 \
 "
