# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tuned"
PV = "2.27.0"
PR = "2.el10"
PACKAGES = " \
 tuned \
 tuned-gtk \
 tuned-ppd \
 tuned-profiles-atomic \
 tuned-profiles-cpu-partitioning \
 tuned-profiles-mssql \
 tuned-profiles-oracle \
 tuned-profiles-postgresql \
 tuned-profiles-spectrumscale \
 tuned-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/tuned-2.27.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a013642046441037771aed4003d51ca9679eb2305c90b3565359ff3a596850b2"

URI_x86_64_v2_tuned = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tuned-2.27.0-2.el10.noarch.rpm;name=x86_64_v2_tuned;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned}"
SRC_URI[x86_64_v2_tuned.sha256sum] = "d3f9aaa1a7adfb4896cb178887ba3f9501d109341b3ad8a67e813af89438a915"

URI_x86_64_v2_tuned-gtk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-gtk-2.27.0-2.el10.noarch.rpm;name=x86_64_v2_tuned-gtk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-gtk}"
SRC_URI[x86_64_v2_tuned-gtk.sha256sum] = "78b2c45f42d30ac8b572f7162f808268c087f9344a9424e9fb6de6893d041f0a"

URI_x86_64_v2_tuned-ppd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-ppd-2.27.0-2.el10.noarch.rpm;name=x86_64_v2_tuned-ppd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-ppd}"
SRC_URI[x86_64_v2_tuned-ppd.sha256sum] = "23193fcd5cb2864d2052d677baa4bce3c7e877c422de2507b00ff0ecf4efafdc"

URI_x86_64_v2_tuned-profiles-atomic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-profiles-atomic-2.27.0-2.el10.noarch.rpm;name=x86_64_v2_tuned-profiles-atomic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-profiles-atomic}"
SRC_URI[x86_64_v2_tuned-profiles-atomic.sha256sum] = "b66440c460df5f927b6b71d63b0eee304d871a552e559bf120714fafd13bf4e0"

URI_x86_64_v2_tuned-profiles-cpu-partitioning = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tuned-profiles-cpu-partitioning-2.27.0-2.el10.noarch.rpm;name=x86_64_v2_tuned-profiles-cpu-partitioning;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-profiles-cpu-partitioning}"
SRC_URI[x86_64_v2_tuned-profiles-cpu-partitioning.sha256sum] = "179ef22184c94d37ccc6902423a9a60b4d233ac83e3538c133d88326c80afb95"

URI_x86_64_v2_tuned-profiles-mssql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-profiles-mssql-2.27.0-2.el10.noarch.rpm;name=x86_64_v2_tuned-profiles-mssql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-profiles-mssql}"
SRC_URI[x86_64_v2_tuned-profiles-mssql.sha256sum] = "f1c001315079e5991ad680b0f6f26fec65a9db29013fb415a9d26c33d66b5a2c"

URI_x86_64_v2_tuned-profiles-oracle = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-profiles-oracle-2.27.0-2.el10.noarch.rpm;name=x86_64_v2_tuned-profiles-oracle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-profiles-oracle}"
SRC_URI[x86_64_v2_tuned-profiles-oracle.sha256sum] = "8c545dc0a70e3656d3f9871289cef9053b2dc7301a08856aef964793cc89ed1c"

URI_x86_64_v2_tuned-profiles-postgresql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-profiles-postgresql-2.27.0-2.el10.noarch.rpm;name=x86_64_v2_tuned-profiles-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-profiles-postgresql}"
SRC_URI[x86_64_v2_tuned-profiles-postgresql.sha256sum] = "e6e30aaf2a4e9cef68b127ccb048b15d9d7edada55dbb099032099833a5194c7"

URI_x86_64_v2_tuned-profiles-spectrumscale = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-profiles-spectrumscale-2.27.0-2.el10.noarch.rpm;name=x86_64_v2_tuned-profiles-spectrumscale;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-profiles-spectrumscale}"
SRC_URI[x86_64_v2_tuned-profiles-spectrumscale.sha256sum] = "e210274836703c0e6727e14dc69d7da7e1e87d7bb53ffb102ca2bf5af54a5741"

URI_x86_64_v2_tuned-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-utils-2.27.0-2.el10.noarch.rpm;name=x86_64_v2_tuned-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-utils}"
SRC_URI[x86_64_v2_tuned-utils.sha256sum] = "250843c256dd42d3ac35f6a21308ec77c19a1fbb65ef27cb7fb05575aff2ce17"

URI_aarch64_tuned = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tuned-2.27.0-2.el10.noarch.rpm;name=aarch64_tuned;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned}"
SRC_URI[aarch64_tuned.sha256sum] = "d3f9aaa1a7adfb4896cb178887ba3f9501d109341b3ad8a67e813af89438a915"

URI_aarch64_tuned-gtk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-gtk-2.27.0-2.el10.noarch.rpm;name=aarch64_tuned-gtk;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-gtk}"
SRC_URI[aarch64_tuned-gtk.sha256sum] = "78b2c45f42d30ac8b572f7162f808268c087f9344a9424e9fb6de6893d041f0a"

URI_aarch64_tuned-ppd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-ppd-2.27.0-2.el10.noarch.rpm;name=aarch64_tuned-ppd;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-ppd}"
SRC_URI[aarch64_tuned-ppd.sha256sum] = "23193fcd5cb2864d2052d677baa4bce3c7e877c422de2507b00ff0ecf4efafdc"

URI_aarch64_tuned-profiles-atomic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-profiles-atomic-2.27.0-2.el10.noarch.rpm;name=aarch64_tuned-profiles-atomic;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-profiles-atomic}"
SRC_URI[aarch64_tuned-profiles-atomic.sha256sum] = "b66440c460df5f927b6b71d63b0eee304d871a552e559bf120714fafd13bf4e0"

URI_aarch64_tuned-profiles-cpu-partitioning = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tuned-profiles-cpu-partitioning-2.27.0-2.el10.noarch.rpm;name=aarch64_tuned-profiles-cpu-partitioning;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-profiles-cpu-partitioning}"
SRC_URI[aarch64_tuned-profiles-cpu-partitioning.sha256sum] = "179ef22184c94d37ccc6902423a9a60b4d233ac83e3538c133d88326c80afb95"

URI_aarch64_tuned-profiles-mssql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-profiles-mssql-2.27.0-2.el10.noarch.rpm;name=aarch64_tuned-profiles-mssql;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-profiles-mssql}"
SRC_URI[aarch64_tuned-profiles-mssql.sha256sum] = "f1c001315079e5991ad680b0f6f26fec65a9db29013fb415a9d26c33d66b5a2c"

URI_aarch64_tuned-profiles-oracle = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-profiles-oracle-2.27.0-2.el10.noarch.rpm;name=aarch64_tuned-profiles-oracle;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-profiles-oracle}"
SRC_URI[aarch64_tuned-profiles-oracle.sha256sum] = "8c545dc0a70e3656d3f9871289cef9053b2dc7301a08856aef964793cc89ed1c"

URI_aarch64_tuned-profiles-postgresql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-profiles-postgresql-2.27.0-2.el10.noarch.rpm;name=aarch64_tuned-profiles-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-profiles-postgresql}"
SRC_URI[aarch64_tuned-profiles-postgresql.sha256sum] = "e6e30aaf2a4e9cef68b127ccb048b15d9d7edada55dbb099032099833a5194c7"

URI_aarch64_tuned-profiles-spectrumscale = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-profiles-spectrumscale-2.27.0-2.el10.noarch.rpm;name=aarch64_tuned-profiles-spectrumscale;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-profiles-spectrumscale}"
SRC_URI[aarch64_tuned-profiles-spectrumscale.sha256sum] = "e210274836703c0e6727e14dc69d7da7e1e87d7bb53ffb102ca2bf5af54a5741"

URI_aarch64_tuned-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-utils-2.27.0-2.el10.noarch.rpm;name=aarch64_tuned-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-utils}"
SRC_URI[aarch64_tuned-utils.sha256sum] = "250843c256dd42d3ac35f6a21308ec77c19a1fbb65ef27cb7fb05575aff2ce17"

RDEPENDS:tuned = " \
 bash \
 dbus \
 ethtool \
 gawk \
 hdparm \
 iproute \
 kmod \
 polkit \
 python3 \
 python3-dbus \
 python3-gobject-base \
 python3-inotify \
 python3-linux-procfs \
 python3-pyudev \
 systemd \
 util-linux \
 virt-what \
 "
RDEPENDS:tuned-gtk = " \
 polkit \
 powertop \
 python3 \
 python3-gobject-base \
 tuned \
 "
RDEPENDS:tuned-ppd = " \
 bash \
 python3 \
 tuned \
 "
RDEPENDS:tuned-profiles-atomic = " \
 tuned \
 "
RDEPENDS:tuned-profiles-cpu-partitioning = " \
 bash \
 tuned \
 "
RDEPENDS:tuned-profiles-mssql = " \
 tuned \
 "
RDEPENDS:tuned-profiles-oracle = " \
 tuned \
 "
RDEPENDS:tuned-profiles-postgresql = " \
 tuned \
 "
RDEPENDS:tuned-profiles-spectrumscale = " \
 tuned \
 "
RDEPENDS:tuned-utils = " \
 powertop \
 python3 \
 tuned \
 "
