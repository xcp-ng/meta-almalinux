# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iverilog"
PV = "13.0"
PR = "7.el10_3"
PACKAGES = " \
 iverilog \
 iverilog-devel \
 iverilog-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/iverilog-13.0-7.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7530dacdba7c91de5d6f93a44bd3cce544afd8c13b75ebb07848d4284b17d1fb"

URI_x86_64_v2_iverilog = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/iverilog-13.0-7.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_iverilog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iverilog}"
SRC_URI[x86_64_v2_iverilog.sha256sum] = "cb9462c746d9f0222a35ae96cf59720d6e12990a00087e3e89fe57aef119fca3"

URI_x86_64_v2_iverilog-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/iverilog-devel-13.0-7.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_iverilog-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iverilog-devel}"
SRC_URI[x86_64_v2_iverilog-devel.sha256sum] = "407f1a694897b3c647b83f1707fc8d1c633edc5426d2ae74d854ff22a7ba42bf"

URI_x86_64_v2_iverilog-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/iverilog-static-13.0-7.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_iverilog-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iverilog-static}"
SRC_URI[x86_64_v2_iverilog-static.sha256sum] = "a3b81e9e9dc29bb1f3635b93e2c042ffe3ac02d0437cc4529d6a0603dc4ea58a"

URI_aarch64_iverilog = "${EPEL_MIRROR}/aarch64/Packages/i/iverilog-13.0-7.el10_3.aarch64.rpm;name=aarch64_iverilog;unpack=0"
SRC_URI:append = " ${URI_aarch64_iverilog}"
SRC_URI[aarch64_iverilog.sha256sum] = "364d74cf926e9806541193b2864591b4192c749b8eb3c33857564ae80932da62"

URI_aarch64_iverilog-devel = "${EPEL_MIRROR}/aarch64/Packages/i/iverilog-devel-13.0-7.el10_3.aarch64.rpm;name=aarch64_iverilog-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_iverilog-devel}"
SRC_URI[aarch64_iverilog-devel.sha256sum] = "6c60aa8762eb2d654e41c425d4f1af3259ee5bf4b143b723e48b420c032609e5"

URI_aarch64_iverilog-static = "${EPEL_MIRROR}/aarch64/Packages/i/iverilog-static-13.0-7.el10_3.aarch64.rpm;name=aarch64_iverilog-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_iverilog-static}"
SRC_URI[aarch64_iverilog-static.sha256sum] = "99faf7ea5bc2a601ae089f68d5831169400c449514e486e9262e373b612c04c9"

RDEPENDS:iverilog = " \
 bash \
 bzip2-libs \
 glibc \
 libgcc \
 libstdc++ \
 readline \
 zlib-ng-compat \
 "
RDEPENDS:iverilog-devel = " \
 iverilog \
 "
RDEPENDS:iverilog-static = " \
 iverilog-devel \
 "
