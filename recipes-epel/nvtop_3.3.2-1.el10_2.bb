# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nvtop"
PV = "3.3.2"
PR = "1.el10_2"
PACKAGES = " \
 nvtop \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nvtop-3.3.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "907e3e1129d05bf5090e603e515b64011fab5f0083e249c2fd0ef58989480e47"

URI_x86_64_v2_nvtop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nvtop-3.3.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nvtop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nvtop}"
SRC_URI[x86_64_v2_nvtop.sha256sum] = "bd0ae10dbdc337f52dcbb59827d667aeba360876ed68a8cf60e12864352dbc0e"

URI_aarch64_nvtop = "${EPEL_MIRROR}/aarch64/Packages/n/nvtop-3.3.2-1.el10_2.aarch64.rpm;name=aarch64_nvtop;unpack=0"
SRC_URI:append = " ${URI_aarch64_nvtop}"
SRC_URI[aarch64_nvtop.sha256sum] = "ca597048a5d74beb84f0482d532861cf874b3e25888d8f82a1bf1ace02ef022a"

RDEPENDS:nvtop = " \
 glibc \
 hicolor-icon-theme \
 ncurses-libs \
 systemd-libs \
 "
