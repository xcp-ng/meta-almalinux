# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-X11-Protocol"
PV = "0.56"
PR = "49.el10_1"
PACKAGES = " \
 perl-X11-Protocol \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-X11-Protocol-0.56-49.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a4671cf34c2507610f0bf61bad3a739e26d38025d3326ce8466d5d24237b63e4"

URI_x86_64_v2_perl-X11-Protocol = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-X11-Protocol-0.56-49.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-X11-Protocol;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-X11-Protocol}"
SRC_URI[x86_64_v2_perl-X11-Protocol.sha256sum] = "42cb66fdeb9b8ad1e68634094758d0a9517fecece5b39f588453fd279835704b"

URI_aarch64_perl-X11-Protocol = "${EPEL_MIRROR}/aarch64/Packages/p/perl-X11-Protocol-0.56-49.el10_1.noarch.rpm;name=aarch64_perl-X11-Protocol;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-X11-Protocol}"
SRC_URI[aarch64_perl-X11-Protocol.sha256sum] = "ac12e5365697094be3990a76f62b0084f3692a0dcc4c19b0eace13e58dc45a04"

RDEPENDS:perl-X11-Protocol = " \
 perl-Carp \
 perl-Exporter \
 perl-FileHandle \
 perl-IO \
 perl-Socket \
 perl-X11-Protocol \
 perl-libs \
 perl-vars \
 "
