# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pam_yubico"
PV = "2.27"
PR = "7.el10_1"
PACKAGES = " \
 pam_yubico \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pam_yubico-2.27-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df5cd1b7198b7829bee9693a8542619596deebf09bddd58718036f743d4f335c"

URI_x86_64_v2_pam_yubico = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pam_yubico-2.27-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pam_yubico;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam_yubico}"
SRC_URI[x86_64_v2_pam_yubico.sha256sum] = "76298fcd14954c4403f7dbf788771d64c947f7449c5491dca681ee5546f9c52a"

URI_aarch64_pam_yubico = "${EPEL_MIRROR}/aarch64/Packages/p/pam_yubico-2.27-7.el10_1.aarch64.rpm;name=aarch64_pam_yubico;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam_yubico}"
SRC_URI[aarch64_pam_yubico.sha256sum] = "b3f27e0778fdbf5432f01649125e57174b00defc792942e33d1325a806cd9cc8"

RDEPENDS:pam_yubico = " \
 glibc \
 libyubikey \
 openldap \
 pam \
 pam-libs \
 ykclient \
 ykpers \
 "
