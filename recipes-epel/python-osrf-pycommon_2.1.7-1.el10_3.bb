# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-osrf-pycommon"
PV = "2.1.7"
PR = "1.el10_3"
PACKAGES = " \
 python-osrf-pycommon-doc \
 python3-osrf-pycommon \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-osrf-pycommon-2.1.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "11bfde26a1a58c2b90557b071ef69dfcb7ceb545dc4c3c1aed020aa9982b77f2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-osrf-pycommon-doc-2.1.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-osrf-pycommon-doc;unpack=0"
SRC_URI[x86_64_v2_python-osrf-pycommon-doc.sha256sum] = "5b80d841e29f8fbdc1bbd8c2590a8969fbe73d8be31c209ec2ce2eb1e15898c0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-osrf-pycommon-2.1.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-osrf-pycommon;unpack=0"
SRC_URI[x86_64_v2_python3-osrf-pycommon.sha256sum] = "7f790ff89381aab39f3ee0b8bc5bfe87eb4ca62b34ebd5afc5d98b48a3314eae"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-osrf-pycommon-doc-2.1.7-1.el10_3.noarch.rpm;name=aarch64_python-osrf-pycommon-doc;unpack=0"
SRC_URI[aarch64_python-osrf-pycommon-doc.sha256sum] = "895484b830b3e6300cba9c35e0402e6ca58199e28a865f944105432a510dbe0c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-osrf-pycommon-2.1.7-1.el10_3.noarch.rpm;name=aarch64_python3-osrf-pycommon;unpack=0"
SRC_URI[aarch64_python3-osrf-pycommon.sha256sum] = "b9f49ab4ebca01ff1b877618981b2640b9f8dda93010d4aab58039627f4448a7"

RDEPENDS:python-osrf-pycommon-doc = " \
 "
RDEPENDS:python3-osrf-pycommon = " \
 python3 \
 "
