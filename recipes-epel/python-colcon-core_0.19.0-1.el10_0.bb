# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-core"
PV = "0.19.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-colcon-core \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-core-0.19.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d7f3b91abbf8967c22840ec76df455c845af6bdae589ee68e8ab5d9bb15ca4a"

URI_x86_64_v2_python3-colcon-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-core-0.19.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-core}"
SRC_URI[x86_64_v2_python3-colcon-core.sha256sum] = "f2389b3073e5f76e96aa7741d67add868603de4f787d0e5e59f0d697ad7f4e77"

URI_aarch64_python3-colcon-core = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-core-0.19.0-1.el10_0.noarch.rpm;name=aarch64_python3-colcon-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-core}"
SRC_URI[aarch64_python3-colcon-core.sha256sum] = "c210f3bec7bb3212468b20540d70c411e300213c84f97ad0b1e4bd9c1e44e050"

RDEPENDS:python3-colcon-core = " \
 python3 \
 python3-distlib \
 python3-empy \
 python3-packaging \
 python3-setuptools \
 "
