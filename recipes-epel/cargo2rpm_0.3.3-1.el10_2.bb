# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cargo2rpm"
PV = "0.3.3"
PR = "1.el10_2"
PACKAGES = " \
 cargo2rpm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cargo2rpm-0.3.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6a86a7ef8e70fe76bd6a46f650ebe55e29a76e567465e93735f1c725e484a69"

URI_x86_64_v2_cargo2rpm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cargo2rpm-0.3.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_cargo2rpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cargo2rpm}"
SRC_URI[x86_64_v2_cargo2rpm.sha256sum] = "3fd5821100c5e840cb17798b3f096f3277ae437b500631fe7e6e9c1a58fc37d5"

URI_aarch64_cargo2rpm = "${EPEL_MIRROR}/aarch64/Packages/c/cargo2rpm-0.3.3-1.el10_2.noarch.rpm;name=aarch64_cargo2rpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_cargo2rpm}"
SRC_URI[aarch64_cargo2rpm.sha256sum] = "f6a7e17391b434e3337e86d288ad3d96c91cdbc2dee6f173e7daccd7548658d9"

RDEPENDS:cargo2rpm = " \
 cargo \
 python3 \
 "
