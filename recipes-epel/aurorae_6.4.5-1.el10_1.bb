# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aurorae"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 aurorae \
 aurorae-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/aurorae-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0d179c9dd1a4eea56050512ac8a5ddc027f9e91c6b2b9eb7a9467af011887b66"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aurorae-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aurorae;unpack=0"
SRC_URI[x86_64_v2_aurorae.sha256sum] = "1f60312977ac8e9371ee8afe84890a301da7cb477f3cec5f74c6c1fcbb90fe93"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aurorae-devel-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aurorae-devel;unpack=0"
SRC_URI[x86_64_v2_aurorae-devel.sha256sum] = "25b898791f2647cb5bd0abc3da60ef6eef2137048337f192d2d5edf7d5652fbb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/aurorae-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_aurorae;unpack=0"
SRC_URI[aarch64_aurorae.sha256sum] = "b59aa626e68a063f16f40eda90786b3e9c47f1e503c6907aabfb645c19270160"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/aurorae-devel-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_aurorae-devel;unpack=0"
SRC_URI[aarch64_aurorae-devel.sha256sum] = "64fd2e0c45bcc985b1a1288155e48055c6f22ddb6dabafcc0d57b88bffba81f8"

RDEPENDS:aurorae = " \
 bash \
 glibc \
 kdecoration \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kpackage \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qttools \
 "
RDEPENDS:aurorae-devel = " \
 aurorae \
 cmake-filesystem \
 "
