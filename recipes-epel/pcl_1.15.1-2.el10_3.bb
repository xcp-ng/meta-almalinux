# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pcl"
PV = "1.15.1"
PR = "2.el10_3"
PACKAGES = " \
 pcl \
 pcl-devel \
 pcl-doc \
 pcl-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pcl-1.15.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "749f39840e34ffc0e532252536167bb7d9813a068e0c822c04f864f6b347e3a0"

URI_x86_64_v2_pcl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pcl-1.15.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pcl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcl}"
SRC_URI[x86_64_v2_pcl.sha256sum] = "ca5a34474fc4a5cd257e329a72899cddbbc8e1f52621efd23a6a32c960798dcb"

URI_x86_64_v2_pcl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pcl-devel-1.15.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pcl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcl-devel}"
SRC_URI[x86_64_v2_pcl-devel.sha256sum] = "2768bad5311e1c14b25fd690ddc17da37b8d254fcf72a8b9b0867b8fd92854cd"

URI_x86_64_v2_pcl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pcl-doc-1.15.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_pcl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcl-doc}"
SRC_URI[x86_64_v2_pcl-doc.sha256sum] = "347980a42b6e497b1bdf6d689d74bce59353d1fc68eaab5a44b9c39eccade830"

URI_x86_64_v2_pcl-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pcl-tools-1.15.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pcl-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcl-tools}"
SRC_URI[x86_64_v2_pcl-tools.sha256sum] = "9aec9268d012fb8b8e42665f5dea8bdd9a51c79cf31751adf401a2bf3242ed59"

URI_aarch64_pcl = "${EPEL_MIRROR}/aarch64/Packages/p/pcl-1.15.1-2.el10_3.aarch64.rpm;name=aarch64_pcl;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcl}"
SRC_URI[aarch64_pcl.sha256sum] = "981ba2e933e767fa913360ba9eb59503060d4d6fdaeee23c88fe031e8a9f6bec"

URI_aarch64_pcl-devel = "${EPEL_MIRROR}/aarch64/Packages/p/pcl-devel-1.15.1-2.el10_3.aarch64.rpm;name=aarch64_pcl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcl-devel}"
SRC_URI[aarch64_pcl-devel.sha256sum] = "c64d9fec6863f944383b72e4b92993e01a8b770d0981b8028d7b9f749e8274c1"

URI_aarch64_pcl-doc = "${EPEL_MIRROR}/aarch64/Packages/p/pcl-doc-1.15.1-2.el10_3.noarch.rpm;name=aarch64_pcl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcl-doc}"
SRC_URI[aarch64_pcl-doc.sha256sum] = "67014c88c7dbabd5e9b92d455f098d124e2041388487bbc6d905e4badc5879cc"

URI_aarch64_pcl-tools = "${EPEL_MIRROR}/aarch64/Packages/p/pcl-tools-1.15.1-2.el10_3.aarch64.rpm;name=aarch64_pcl-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcl-tools}"
SRC_URI[aarch64_pcl-tools.sha256sum] = "8d0c471bdde89e153564b086413593ef4ac9dd5e4b9e1e2de36e6aaa8fd61b1b"

RDEPENDS:pcl:x86_64_v2 = " \
 boost-iostreams \
 glibc \
 libgcc \
 libgomp \
 libpcap \
 libqhull_r \
 libstdc++ \
 libusb1 \
 lz4-libs \
 openni \
"
RDEPENDS:pcl:aarch64 = " \
 boost-iostreams \
 glibc \
 libgcc \
 libgomp \
 libpcap \
 libqhull_r \
 libstdc++ \
 libusb1 \
 lz4-libs \
"
RDEPENDS:pcl-devel:x86_64_v2 = " \
 cmake-filesystem \
 eigen3-devel \
 flann-devel \
 libusb1-devel \
 openni-devel \
 pcl \
 pcl-devel \
 pkgconf-pkg-config \
 qhull-devel \
"
RDEPENDS:pcl-devel:aarch64 = " \
 cmake-filesystem \
 eigen3-devel \
 flann-devel \
 libusb1-devel \
 pcl \
 pcl-devel \
 pkgconf-pkg-config \
 qhull-devel \
"
RDEPENDS:pcl-doc = " \
 "
RDEPENDS:pcl-tools:x86_64_v2 = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 openni \
 pcl \
"
RDEPENDS:pcl-tools:aarch64 = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 pcl \
"
