# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-below-gpu-stats"
PV = "0.9.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-below-gpu-stats+default-devel \
 rust-below-gpu-stats-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-below-gpu-stats-0.9.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d961f3bb6270fc85a64c74a3d5d3a14e4fac8ae7997b5fd6d9047c6296cc0864"

URI_x86_64_v2_rust-below-gpu-stats+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-gpu-stats+default-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-gpu-stats+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-gpu-stats+default-devel}"
SRC_URI[x86_64_v2_rust-below-gpu-stats+default-devel.sha256sum] = "2f77fad70f2bea43439cefc2b708b42113f42770f6d6c4ba5d4e749c5fddeaf6"

URI_x86_64_v2_rust-below-gpu-stats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-gpu-stats-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-gpu-stats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-gpu-stats-devel}"
SRC_URI[x86_64_v2_rust-below-gpu-stats-devel.sha256sum] = "84bc5bbf289b6d7cacde8b404c404fcb763847114f8bac9a4c0a2bb199650063"

URI_aarch64_rust-below-gpu-stats+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-gpu-stats+default-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-below-gpu-stats+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-gpu-stats+default-devel}"
SRC_URI[aarch64_rust-below-gpu-stats+default-devel.sha256sum] = "11af5adb5e021da3c7e692e104c6f531fa1a5301085190204d65c657e103a350"

URI_aarch64_rust-below-gpu-stats-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-gpu-stats-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-below-gpu-stats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-gpu-stats-devel}"
SRC_URI[aarch64_rust-below-gpu-stats-devel.sha256sum] = "18f72168d1ee028d4cda52c1e10743a0ff1437344341ecd38ce1358620df885f"

RDEPENDS:rust-below-gpu-stats+default-devel = " \
 cargo \
 rust-below-gpu-stats-devel \
 "
RDEPENDS:rust-below-gpu-stats-devel = " \
 cargo \
 rust-below-common+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 "
