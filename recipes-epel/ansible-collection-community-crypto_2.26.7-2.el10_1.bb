# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansible-collection-community-crypto"
PV = "2.26.7"
PR = "2.el10_1"
PACKAGES = " \
 ansible-collection-community-crypto \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/ansible-collection-community-crypto-2.26.7-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f4145b3ce6a6991c2ca25a6ca6f3924112f98ab1d7836c7a257e829d8a8e4274"

URI_x86_64_v2_ansible-collection-community-crypto = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ansible-collection-community-crypto-2.26.7-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ansible-collection-community-crypto;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-collection-community-crypto}"
SRC_URI[x86_64_v2_ansible-collection-community-crypto.sha256sum] = "69d7398ccd125edf6fe36440332bc18a1f8633a585d10e248720cb44383a1b47"

URI_aarch64_ansible-collection-community-crypto = "${EPEL_MIRROR}/aarch64/Packages/a/ansible-collection-community-crypto-2.26.7-2.el10_1.noarch.rpm;name=aarch64_ansible-collection-community-crypto;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-collection-community-crypto}"
SRC_URI[aarch64_ansible-collection-community-crypto.sha256sum] = "c7ccc36b561f21943f377273e237275b58eb62736df94706cd52428a977f4ebe"

RDEPENDS:ansible-collection-community-crypto = " \
 ansible-core \
 "
