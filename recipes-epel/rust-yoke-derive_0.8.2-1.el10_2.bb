# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-yoke-derive"
PV = "0.8.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-yoke-derive+default-devel \
 rust-yoke-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-yoke-derive-0.8.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "38550d0c5cabbcdbfec63c4393c8daec4d9232758aa029a47dbb660e20cb4a7f"

URI_x86_64_v2_rust-yoke-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yoke-derive+default-devel-0.8.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yoke-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yoke-derive+default-devel}"
SRC_URI[x86_64_v2_rust-yoke-derive+default-devel.sha256sum] = "1432e0e239208596fcd090c5a00592d6edaa5913eed5958e54510163fc3b9f87"

URI_x86_64_v2_rust-yoke-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yoke-derive-devel-0.8.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yoke-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yoke-derive-devel}"
SRC_URI[x86_64_v2_rust-yoke-derive-devel.sha256sum] = "2003219368f939f753582a422bf8131929c21d698e9f1921c50af9885649167f"

URI_aarch64_rust-yoke-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yoke-derive+default-devel-0.8.2-1.el10_2.noarch.rpm;name=aarch64_rust-yoke-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yoke-derive+default-devel}"
SRC_URI[aarch64_rust-yoke-derive+default-devel.sha256sum] = "16bebe267bb69be027bcd947eef2160c25269fd346a4791bb9abe98127d34f98"

URI_aarch64_rust-yoke-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yoke-derive-devel-0.8.2-1.el10_2.noarch.rpm;name=aarch64_rust-yoke-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yoke-derive-devel}"
SRC_URI[aarch64_rust-yoke-derive-devel.sha256sum] = "6048256da3a623a873a215c7dc6c86a0c7be9f2b9e2052fc758b63b3ff9ddae2"

RDEPENDS:rust-yoke-derive+default-devel = " \
 cargo \
 rust-yoke-derive-devel \
 "
RDEPENDS:rust-yoke-derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+fold-devel \
 rust-synstructure+default-devel \
 "
