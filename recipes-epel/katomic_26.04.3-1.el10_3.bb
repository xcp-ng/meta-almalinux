# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "katomic"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 katomic \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/katomic-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9896ed94ba25ab63e8c1d744869b2d843fad473f04ff212aa8225b3550cbed99"

URI_x86_64_v2_katomic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/katomic-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_katomic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_katomic}"
SRC_URI[x86_64_v2_katomic.sha256sum] = "1b1cdf7f76feacea7e65aeeb13eb6781149a1c65de7d03cbce6e21d787a7b177"

URI_aarch64_katomic = "${EPEL_MIRROR}/aarch64/Packages/k/katomic-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_katomic;unpack=0"
SRC_URI:append = " ${URI_aarch64_katomic}"
SRC_URI[aarch64_katomic.sha256sum] = "c59a24cd3e94a2e88bc0594523e7e17cbdfd903d28a0998929f41559d018c61a"

RDEPENDS:katomic = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-knewstuff \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
