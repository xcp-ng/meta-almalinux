# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-predicates-core"
PV = "1.0.10"
PR = "1.el10_3"
PACKAGES = " \
 rust-predicates-core+default-devel \
 rust-predicates-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-predicates-core-1.0.10-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62782a36cfccd59d525056ad49d6ce069c87edae23ce5013c569a6ff22bfeefb"

URI_x86_64_v2_rust-predicates-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates-core+default-devel-1.0.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates-core+default-devel}"
SRC_URI[x86_64_v2_rust-predicates-core+default-devel.sha256sum] = "27a6d4540d11485e8e139b1c23dfc126635ce992e72c6255bcd37d336ce1cb03"

URI_x86_64_v2_rust-predicates-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates-core-devel-1.0.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates-core-devel}"
SRC_URI[x86_64_v2_rust-predicates-core-devel.sha256sum] = "7989fd22c4706fef3898613a4ee4dc5b23ee676ba29bcd5ccddcfbd364ae5c76"

URI_aarch64_rust-predicates-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates-core+default-devel-1.0.10-1.el10_3.noarch.rpm;name=aarch64_rust-predicates-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates-core+default-devel}"
SRC_URI[aarch64_rust-predicates-core+default-devel.sha256sum] = "730f216dcea34660d86b009515a13bc9ca23a9fdaa941b1b0f207711e0f21b56"

URI_aarch64_rust-predicates-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates-core-devel-1.0.10-1.el10_3.noarch.rpm;name=aarch64_rust-predicates-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates-core-devel}"
SRC_URI[aarch64_rust-predicates-core-devel.sha256sum] = "c43b63fc8afcc416149b06d16b6f3c136601b181b3b472c8be29e2f882214981"

RDEPENDS:rust-predicates-core+default-devel = " \
 cargo \
 rust-predicates-core-devel \
 "
RDEPENDS:rust-predicates-core-devel = " \
 cargo \
 rust \
 "
