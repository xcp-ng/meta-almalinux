# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-mwc-random"
PV = "0.15.1.0"
PR = "1.el10_0"
PACKAGES = " \
 ghc-mwc-random \
 ghc-mwc-random-devel \
 ghc-mwc-random-doc \
 ghc-mwc-random-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-mwc-random-0.15.1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ed955a8b5daa7697ed8cd6a96af8a4a026f2e87c2a2b46260d70d8b0de7627a"

URI_x86_64_v2_ghc-mwc-random = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-mwc-random-0.15.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-mwc-random;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-mwc-random}"
SRC_URI[x86_64_v2_ghc-mwc-random.sha256sum] = "c36f7429023088e00561055e54752f4bd06f47d1044f938a0615d2f75abcca11"

URI_x86_64_v2_ghc-mwc-random-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-mwc-random-devel-0.15.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-mwc-random-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-mwc-random-devel}"
SRC_URI[x86_64_v2_ghc-mwc-random-devel.sha256sum] = "230e0826c93ffb2f2c25639de18bcbcd15b77ffcf10059ebd443a6deda17a7fe"

URI_x86_64_v2_ghc-mwc-random-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-mwc-random-doc-0.15.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-mwc-random-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-mwc-random-doc}"
SRC_URI[x86_64_v2_ghc-mwc-random-doc.sha256sum] = "449cc1c3f7e0e4da8dd3bdb0afddf9bcd5484aa6d8789f6c774e5a3bbac1e3e6"

URI_x86_64_v2_ghc-mwc-random-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-mwc-random-prof-0.15.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-mwc-random-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-mwc-random-prof}"
SRC_URI[x86_64_v2_ghc-mwc-random-prof.sha256sum] = "1af62ffc2f0d86678e94dfc178f233445f87fea93ae969d93aa7431974cf2cf4"

URI_aarch64_ghc-mwc-random = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-mwc-random-0.15.1.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-mwc-random;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-mwc-random}"
SRC_URI[aarch64_ghc-mwc-random.sha256sum] = "0c15581aeadbd8b4a42733122095792eb24623abe10fdd41f105d4cf77c0c3fb"

URI_aarch64_ghc-mwc-random-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-mwc-random-devel-0.15.1.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-mwc-random-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-mwc-random-devel}"
SRC_URI[aarch64_ghc-mwc-random-devel.sha256sum] = "b278b0f7d5760def88a3300d32880d3efb58de99ca5936293363da99d74cdb45"

URI_aarch64_ghc-mwc-random-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-mwc-random-doc-0.15.1.0-1.el10_0.noarch.rpm;name=aarch64_ghc-mwc-random-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-mwc-random-doc}"
SRC_URI[aarch64_ghc-mwc-random-doc.sha256sum] = "67988b3da680c562c50de7567fad33e3fb162f076e57ba112bbf8d3ad4b16d5a"

URI_aarch64_ghc-mwc-random-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-mwc-random-prof-0.15.1.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-mwc-random-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-mwc-random-prof}"
SRC_URI[aarch64_ghc-mwc-random-prof.sha256sum] = "5908a7d87e2666d9c372249478cbfbf1dcddfc70a5e3043957179126eded5e6e"

RDEPENDS:ghc-mwc-random = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-data-default-class \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-math-functions \
 ghc-mtl \
 ghc-pretty \
 ghc-primitive \
 ghc-random \
 ghc-splitmix \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-vector \
 ghc-vector-stream \
 glibc \
 gmp \
 "
RDEPENDS:ghc-mwc-random-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-math-functions-devel \
 ghc-mwc-random \
 ghc-primitive-devel \
 ghc-random-devel \
 ghc-time-devel \
 ghc-vector-devel \
 "
RDEPENDS:ghc-mwc-random-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-mwc-random-prof = " \
 ghc-base-prof \
 ghc-math-functions-prof \
 ghc-mwc-random-devel \
 ghc-primitive-prof \
 ghc-random-prof \
 ghc-time-prof \
 ghc-vector-prof \
 "
