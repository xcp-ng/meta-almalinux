# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-contacts"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 akonadi-contacts \
 akonadi-contacts-devel \
 akonadi-contacts-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akonadi-contacts-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3450efc13cdc56bf5f27c8677ae3da3de926ec96f36f19b0ec4ba12f6cc5c748"

URI_x86_64_v2_akonadi-contacts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-contacts-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-contacts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-contacts}"
SRC_URI[x86_64_v2_akonadi-contacts.sha256sum] = "711d8ff60af93664cb57d578969dc95cf013e35eef2f5fdb5e74dc90e4fc70d4"

URI_x86_64_v2_akonadi-contacts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-contacts-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-contacts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-contacts-devel}"
SRC_URI[x86_64_v2_akonadi-contacts-devel.sha256sum] = "f47643152b0425c5052ee09fadffae81227c761773c33db9129778b2c6e17fd9"

URI_x86_64_v2_akonadi-contacts-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-contacts-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_akonadi-contacts-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-contacts-doc}"
SRC_URI[x86_64_v2_akonadi-contacts-doc.sha256sum] = "2d18edc77b287bdff3a01c31461aea95e5d9c7abe830a345b1accbe6ec750615"

URI_aarch64_akonadi-contacts = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-contacts-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_akonadi-contacts;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-contacts}"
SRC_URI[aarch64_akonadi-contacts.sha256sum] = "99679dee7580e039399243b3abbb647fbaa8ec7aa1e0f79e5c1c8283b3eedee9"

URI_aarch64_akonadi-contacts-devel = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-contacts-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_akonadi-contacts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-contacts-devel}"
SRC_URI[aarch64_akonadi-contacts-devel.sha256sum] = "1d19cdfbb8d271d97cda4edcf044358a9602775c85a09c830567be27169d5b5b"

URI_aarch64_akonadi-contacts-doc = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-contacts-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_akonadi-contacts-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-contacts-doc}"
SRC_URI[aarch64_akonadi-contacts-doc.sha256sum] = "35b994cece6feed9d3ed54270d0e8ad6ebbc766608586c52ed735dddf4e590a2"

RDEPENDS:akonadi-contacts = " \
 akonadi-server \
 glibc \
 grantleetheme \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-ktexttemplate \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-prison \
 kmime \
 ktextaddons-qt6 \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:akonadi-contacts-devel = " \
 akonadi-contacts \
 akonadi-server-devel \
 cmake-filesystem \
 grantleetheme-devel \
 kf6-kcontacts-devel \
 "
RDEPENDS:akonadi-contacts-doc = " \
 "
