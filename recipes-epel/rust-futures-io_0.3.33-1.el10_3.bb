# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-io"
PV = "0.3.33"
PR = "1.el10_3"
PACKAGES = " \
 rust-futures-io+default-devel \
 rust-futures-io+std-devel \
 rust-futures-io+unstable-devel \
 rust-futures-io-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-io-0.3.33-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b28288a7c6821b353b9c91e239b02145b4108693a5b8546a42098e7fb7cfab8f"

URI_x86_64_v2_rust-futures-io+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-io+default-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-io+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-io+default-devel}"
SRC_URI[x86_64_v2_rust-futures-io+default-devel.sha256sum] = "213ddfcdff4d37adb3f40e7607da4d4b9a84ffc50464b804e77dc21a03284ba5"

URI_x86_64_v2_rust-futures-io+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-io+std-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-io+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-io+std-devel}"
SRC_URI[x86_64_v2_rust-futures-io+std-devel.sha256sum] = "d2238e7e632ebc8aadcc36aa11987f6a51a60aee8182e88ad8bf3988522425a4"

URI_x86_64_v2_rust-futures-io+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-io+unstable-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-io+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-io+unstable-devel}"
SRC_URI[x86_64_v2_rust-futures-io+unstable-devel.sha256sum] = "69c611af952ab2df4456c8da90927c594a1ea8ed61869350b5379ff13af8f807"

URI_x86_64_v2_rust-futures-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-io-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-io-devel}"
SRC_URI[x86_64_v2_rust-futures-io-devel.sha256sum] = "f414e968a92506f4d5a49d043bba1306e3ea5f43aed826fa0add136e36bb110e"

URI_aarch64_rust-futures-io+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-io+default-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-io+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-io+default-devel}"
SRC_URI[aarch64_rust-futures-io+default-devel.sha256sum] = "d32c0773a09226b387963b4c1c35c46837df02955a4d1dc28f04fc2f3be28d7e"

URI_aarch64_rust-futures-io+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-io+std-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-io+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-io+std-devel}"
SRC_URI[aarch64_rust-futures-io+std-devel.sha256sum] = "7054871a7872cef73686fd482d1f7276edfad122cd6ddd556a97fc1e95fe61bc"

URI_aarch64_rust-futures-io+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-io+unstable-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-io+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-io+unstable-devel}"
SRC_URI[aarch64_rust-futures-io+unstable-devel.sha256sum] = "39c1183b31c518eacb26c93eedd9cccd1b55264a9e805e0cfcfd0d7f2b36274b"

URI_aarch64_rust-futures-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-io-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-io-devel}"
SRC_URI[aarch64_rust-futures-io-devel.sha256sum] = "de5ac592e62a10ba87c3598d4484f78748d2fd33431af9e753696abb372f1ff8"

RDEPENDS:rust-futures-io+default-devel = " \
 cargo \
 rust-futures-io+std-devel \
 rust-futures-io-devel \
 "
RDEPENDS:rust-futures-io+std-devel = " \
 cargo \
 rust-futures-io-devel \
 "
RDEPENDS:rust-futures-io+unstable-devel = " \
 cargo \
 rust-futures-io-devel \
 "
RDEPENDS:rust-futures-io-devel = " \
 cargo \
 rust \
 "
