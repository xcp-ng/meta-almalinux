# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-servo_arc"
PV = "0.4.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-servo_arc+default-devel \
 rust-servo_arc+gecko_refcount_logging-devel \
 rust-servo_arc+serde-devel \
 rust-servo_arc+servo-devel \
 rust-servo_arc+track_alloc_size-devel \
 rust-servo_arc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-servo_arc-0.4.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2828a3015bd30e01f87b11ccae0772c8cf47566493f6f4273aaf401238b69e59"

URI_x86_64_v2_rust-servo_arc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-servo_arc+default-devel-0.4.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-servo_arc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-servo_arc+default-devel}"
SRC_URI[x86_64_v2_rust-servo_arc+default-devel.sha256sum] = "aed2a574b2ac64abcd6291ce22ee5fb805105182fb64bd030f71ff012017041f"

URI_x86_64_v2_rust-servo_arc+gecko_refcount_logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-servo_arc+gecko_refcount_logging-devel-0.4.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-servo_arc+gecko_refcount_logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-servo_arc+gecko_refcount_logging-devel}"
SRC_URI[x86_64_v2_rust-servo_arc+gecko_refcount_logging-devel.sha256sum] = "7e94e9c277eabc687582574a5d245b25c7e843a2f2f08a3b60cec945144127b6"

URI_x86_64_v2_rust-servo_arc+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-servo_arc+serde-devel-0.4.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-servo_arc+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-servo_arc+serde-devel}"
SRC_URI[x86_64_v2_rust-servo_arc+serde-devel.sha256sum] = "426dda4bb05c95c47695e1fdee5dce8e601d33165070e50ef554ccf690c38242"

URI_x86_64_v2_rust-servo_arc+servo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-servo_arc+servo-devel-0.4.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-servo_arc+servo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-servo_arc+servo-devel}"
SRC_URI[x86_64_v2_rust-servo_arc+servo-devel.sha256sum] = "9a7eb1a2eb546b8a3663e7c5eba3957a0cec49f020145ef17d30ac28dcfe4c9d"

URI_x86_64_v2_rust-servo_arc+track_alloc_size-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-servo_arc+track_alloc_size-devel-0.4.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-servo_arc+track_alloc_size-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-servo_arc+track_alloc_size-devel}"
SRC_URI[x86_64_v2_rust-servo_arc+track_alloc_size-devel.sha256sum] = "0501a2a7081cc3b18f80bdda28c0f06a14596924a8691d2dbd61d4bb5833f710"

URI_x86_64_v2_rust-servo_arc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-servo_arc-devel-0.4.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-servo_arc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-servo_arc-devel}"
SRC_URI[x86_64_v2_rust-servo_arc-devel.sha256sum] = "dcff08234e0ceea464a0cb15ee1a0c626d8b4fca6ab1a5ed3135c7f67c76555b"

URI_aarch64_rust-servo_arc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-servo_arc+default-devel-0.4.3-1.el10_3.noarch.rpm;name=aarch64_rust-servo_arc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-servo_arc+default-devel}"
SRC_URI[aarch64_rust-servo_arc+default-devel.sha256sum] = "9955886acdc243d0d3cd69ce3bb1f9536b2d8824302ec812fb116ad24330ed72"

URI_aarch64_rust-servo_arc+gecko_refcount_logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-servo_arc+gecko_refcount_logging-devel-0.4.3-1.el10_3.noarch.rpm;name=aarch64_rust-servo_arc+gecko_refcount_logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-servo_arc+gecko_refcount_logging-devel}"
SRC_URI[aarch64_rust-servo_arc+gecko_refcount_logging-devel.sha256sum] = "3a2345bf240b40c2f8728f98879c2ac7d475ab59fbc1900e7517c884790245c6"

URI_aarch64_rust-servo_arc+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-servo_arc+serde-devel-0.4.3-1.el10_3.noarch.rpm;name=aarch64_rust-servo_arc+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-servo_arc+serde-devel}"
SRC_URI[aarch64_rust-servo_arc+serde-devel.sha256sum] = "ab691ff1ff9c9853e83c4d27f1b3b593fed11346a7a89e8284f29bfcc35570ee"

URI_aarch64_rust-servo_arc+servo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-servo_arc+servo-devel-0.4.3-1.el10_3.noarch.rpm;name=aarch64_rust-servo_arc+servo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-servo_arc+servo-devel}"
SRC_URI[aarch64_rust-servo_arc+servo-devel.sha256sum] = "7a98f987b9d91a3582b4b1ec6675d1da119605bcb5afadf777836b49965d17ef"

URI_aarch64_rust-servo_arc+track_alloc_size-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-servo_arc+track_alloc_size-devel-0.4.3-1.el10_3.noarch.rpm;name=aarch64_rust-servo_arc+track_alloc_size-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-servo_arc+track_alloc_size-devel}"
SRC_URI[aarch64_rust-servo_arc+track_alloc_size-devel.sha256sum] = "79da79271e5b1697fdfedd07eae11d05d0fb96b5e3de273b5c6883fbeb84b1c4"

URI_aarch64_rust-servo_arc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-servo_arc-devel-0.4.3-1.el10_3.noarch.rpm;name=aarch64_rust-servo_arc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-servo_arc-devel}"
SRC_URI[aarch64_rust-servo_arc-devel.sha256sum] = "ad06d0acc4bda9cc404b2d79b7c3f0f267a6230fb54eb97c4f2bf3d10faccc2f"

RDEPENDS:rust-servo_arc+default-devel = " \
 cargo \
 rust-servo_arc+track_alloc_size-devel \
 rust-servo_arc-devel \
 "
RDEPENDS:rust-servo_arc+gecko_refcount_logging-devel = " \
 cargo \
 rust-servo_arc-devel \
 "
RDEPENDS:rust-servo_arc+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-servo_arc-devel \
 "
RDEPENDS:rust-servo_arc+servo-devel = " \
 cargo \
 rust-servo_arc+serde-devel \
 rust-servo_arc+track_alloc_size-devel \
 rust-servo_arc-devel \
 "
RDEPENDS:rust-servo_arc+track_alloc_size-devel = " \
 cargo \
 rust-servo_arc-devel \
 "
RDEPENDS:rust-servo_arc-devel = " \
 cargo \
 rust-stable_deref_trait+default-devel \
 "
