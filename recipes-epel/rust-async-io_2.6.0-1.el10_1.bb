# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-io"
PV = "2.6.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-async-io+default-devel \
 rust-async-io+tracing-devel \
 rust-async-io-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-io-2.6.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "175cf39de618e722f01a8ae4c22f10e19d7f603f87f9ad728dd8181f4b115662"

URI_x86_64_v2_rust-async-io+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-io+default-devel-2.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-io+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-io+default-devel}"
SRC_URI[x86_64_v2_rust-async-io+default-devel.sha256sum] = "dc45050ab6ba85d17092864d479ca6906926f514f6c0c816f377f25682d5ce9f"

URI_x86_64_v2_rust-async-io+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-io+tracing-devel-2.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-io+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-io+tracing-devel}"
SRC_URI[x86_64_v2_rust-async-io+tracing-devel.sha256sum] = "b7375fb8028204642310f20572ce945590e399e5c76603c107c7fd63566a2e2e"

URI_x86_64_v2_rust-async-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-io-devel-2.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-io-devel}"
SRC_URI[x86_64_v2_rust-async-io-devel.sha256sum] = "b608a87a0ce323dfd0e0923670a1f44333e97e0561dc9b5bde288ef1610ff2e9"

URI_aarch64_rust-async-io+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-io+default-devel-2.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-async-io+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-io+default-devel}"
SRC_URI[aarch64_rust-async-io+default-devel.sha256sum] = "5b30c645f49860791a9461c02aec13e3968f8f0bb1c85cd796fe3c9936b78a04"

URI_aarch64_rust-async-io+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-io+tracing-devel-2.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-async-io+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-io+tracing-devel}"
SRC_URI[aarch64_rust-async-io+tracing-devel.sha256sum] = "20eaf3e6949facd1ae099fdb45f6a6d77c110e6aaf565e8d18a9857b33232b56"

URI_aarch64_rust-async-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-io-devel-2.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-async-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-io-devel}"
SRC_URI[aarch64_rust-async-io-devel.sha256sum] = "80c466a24bd68753bcf74709f55d256e6646ce0aba70595def71db9e9a436a41"

RDEPENDS:rust-async-io+default-devel = " \
 cargo \
 rust-async-io-devel \
 "
RDEPENDS:rust-async-io+tracing-devel = " \
 cargo \
 rust-async-io-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-async-io-devel = " \
 cargo \
 rust \
 rust-autocfg+default-devel \
 rust-cfg-if+default-devel \
 rust-concurrent-queue+default-devel \
 rust-futures-io+std-devel \
 rust-futures-io-devel \
 rust-futures-lite-devel \
 rust-parking+default-devel \
 rust-polling+default-devel \
 rust-rustix+fs-devel \
 rust-rustix+net-devel \
 rust-rustix+std-devel \
 rust-rustix-devel \
 rust-slab+default-devel \
 "
