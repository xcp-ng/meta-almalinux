# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-hspec-megaparsec"
PV = "2.2.1"
PR = "1.el10_0"
PACKAGES = " \
 ghc-hspec-megaparsec \
 ghc-hspec-megaparsec-devel \
 ghc-hspec-megaparsec-doc \
 ghc-hspec-megaparsec-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-hspec-megaparsec-2.2.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "006beee5f79ce5e1d0cebcbce210b499bd64e07bb59266d56eca21fd7f215e32"

URI_x86_64_v2_ghc-hspec-megaparsec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hspec-megaparsec-2.2.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hspec-megaparsec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hspec-megaparsec}"
SRC_URI[x86_64_v2_ghc-hspec-megaparsec.sha256sum] = "17725dbbfa2a8a766e7354c0cfa0cc2cebb309e390074180a9e8e54fadf8aff4"

URI_x86_64_v2_ghc-hspec-megaparsec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hspec-megaparsec-devel-2.2.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hspec-megaparsec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hspec-megaparsec-devel}"
SRC_URI[x86_64_v2_ghc-hspec-megaparsec-devel.sha256sum] = "7fec7cdb99e8becf82d8e9b3a76add92910feb3dca6c6e02a275a70964892436"

URI_x86_64_v2_ghc-hspec-megaparsec-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hspec-megaparsec-doc-2.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hspec-megaparsec-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hspec-megaparsec-doc}"
SRC_URI[x86_64_v2_ghc-hspec-megaparsec-doc.sha256sum] = "5948a39b9396dc2edddb0f4d39d59915008c2081a2a1d148a20aeb1739b023c6"

URI_x86_64_v2_ghc-hspec-megaparsec-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hspec-megaparsec-prof-2.2.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hspec-megaparsec-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hspec-megaparsec-prof}"
SRC_URI[x86_64_v2_ghc-hspec-megaparsec-prof.sha256sum] = "89354d303dabb4d8b732390161982777d0f8ad5c613f134f645674dc9113446d"

URI_aarch64_ghc-hspec-megaparsec = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hspec-megaparsec-2.2.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-hspec-megaparsec;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hspec-megaparsec}"
SRC_URI[aarch64_ghc-hspec-megaparsec.sha256sum] = "f8d20f27b81f9c906ae9abff15ab5320f2b3c4672581450c44c4119a93a3541e"

URI_aarch64_ghc-hspec-megaparsec-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hspec-megaparsec-devel-2.2.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-hspec-megaparsec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hspec-megaparsec-devel}"
SRC_URI[aarch64_ghc-hspec-megaparsec-devel.sha256sum] = "830af14fb5c06ab3b832828a899f34a3111cce02e2899dff33badcdc95d5cd4a"

URI_aarch64_ghc-hspec-megaparsec-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hspec-megaparsec-doc-2.2.1-1.el10_0.noarch.rpm;name=aarch64_ghc-hspec-megaparsec-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hspec-megaparsec-doc}"
SRC_URI[aarch64_ghc-hspec-megaparsec-doc.sha256sum] = "ee4e33a423d7e07a1fccb1db80e6e215b16cddb15637ae1a348407a7540e06a9"

URI_aarch64_ghc-hspec-megaparsec-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hspec-megaparsec-prof-2.2.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-hspec-megaparsec-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hspec-megaparsec-prof}"
SRC_URI[aarch64_ghc-hspec-megaparsec-prof.sha256sum] = "2311c2c666cb49c232021d1a77ab4e9a13a9098fbfbec8facb60ad36c9eef8ae"

RDEPENDS:ghc-hspec-megaparsec = " \
 ghc-HUnit \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-call-stack \
 ghc-case-insensitive \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hspec-expectations \
 ghc-integer-logarithms \
 ghc-megaparsec \
 ghc-mtl \
 ghc-os-string \
 ghc-parser-combinators \
 ghc-pretty \
 ghc-primitive \
 ghc-scientific \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hspec-megaparsec-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-hspec-expectations-devel \
 ghc-hspec-megaparsec \
 ghc-megaparsec-devel \
 "
RDEPENDS:ghc-hspec-megaparsec-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hspec-megaparsec-prof = " \
 ghc-base-prof \
 ghc-hspec-expectations-prof \
 ghc-hspec-megaparsec-devel \
 ghc-megaparsec-prof \
 "
