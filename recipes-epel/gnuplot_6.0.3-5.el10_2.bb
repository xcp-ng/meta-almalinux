# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnuplot"
PV = "6.0.3"
PR = "5.el10_2"
PACKAGES = " \
 gnuplot \
 gnuplot-common \
 gnuplot-doc \
 gnuplot-latex \
 gnuplot-minimal \
 gnuplot-wx \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gnuplot-6.0.3-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b74e57c569d89d87cab903bb60212f0d88df7401aecad811b079dd43ad986f0"

URI_x86_64_v2_gnuplot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnuplot-6.0.3-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gnuplot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnuplot}"
SRC_URI[x86_64_v2_gnuplot.sha256sum] = "7a3d19f7e879fd9f8a43fc48a5f16c34de3d727a859af745bf385e00a4453603"
RPROVIDES:gnuplot:x86_64_v2 = "virtual/gnuplot virtual/gnuplot_eq_6.0.3-5.el10_2.alma_altarch"

URI_x86_64_v2_gnuplot-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnuplot-common-6.0.3-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gnuplot-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnuplot-common}"
SRC_URI[x86_64_v2_gnuplot-common.sha256sum] = "fb4294ed1c0273bbbafa3451488ff6986e2ce8b4f910f20f15597098c5076521"

URI_x86_64_v2_gnuplot-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnuplot-doc-6.0.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_gnuplot-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnuplot-doc}"
SRC_URI[x86_64_v2_gnuplot-doc.sha256sum] = "85b45fe3446f4e9a4f1692747739ca7868525cea2bc34bb049d9e3409679a3ea"

URI_x86_64_v2_gnuplot-latex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnuplot-latex-6.0.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_gnuplot-latex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnuplot-latex}"
SRC_URI[x86_64_v2_gnuplot-latex.sha256sum] = "54468e4a58ea2fc5c03c522c7d2d3156b1b7b2c6d9592909b18a0122e6ba7cbf"

URI_x86_64_v2_gnuplot-minimal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnuplot-minimal-6.0.3-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gnuplot-minimal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnuplot-minimal}"
SRC_URI[x86_64_v2_gnuplot-minimal.sha256sum] = "7656096212496b857a12a2831fc0032795394472bd966f6de6735f43e532877e"

URI_x86_64_v2_gnuplot-wx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnuplot-wx-6.0.3-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gnuplot-wx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnuplot-wx}"
SRC_URI[x86_64_v2_gnuplot-wx.sha256sum] = "ec0a2c95796f9c1275f6c389881fc1f892e867080ea666d9928036979dbb3f76"
RPROVIDES:gnuplot-wx:x86_64_v2 = "virtual/gnuplot virtual/gnuplot_eq_6.0.3-5.el10_2.alma_altarch"

URI_aarch64_gnuplot = "${EPEL_MIRROR}/aarch64/Packages/g/gnuplot-6.0.3-5.el10_2.aarch64.rpm;name=aarch64_gnuplot;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnuplot}"
SRC_URI[aarch64_gnuplot.sha256sum] = "b7ed5ea309b18314cb8e72096ba5616814545eb5f6f7a54744836b4241fdee9b"
RPROVIDES:gnuplot:aarch64 = "virtual/gnuplot virtual/gnuplot_eq_6.0.3-5.el10_2"

URI_aarch64_gnuplot-common = "${EPEL_MIRROR}/aarch64/Packages/g/gnuplot-common-6.0.3-5.el10_2.aarch64.rpm;name=aarch64_gnuplot-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnuplot-common}"
SRC_URI[aarch64_gnuplot-common.sha256sum] = "02898f62515b5f3314ac67512948c02c0f06f2e7d6758f097075ffd9b7c0563b"

URI_aarch64_gnuplot-doc = "${EPEL_MIRROR}/aarch64/Packages/g/gnuplot-doc-6.0.3-5.el10_2.noarch.rpm;name=aarch64_gnuplot-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnuplot-doc}"
SRC_URI[aarch64_gnuplot-doc.sha256sum] = "9dd17cdcd678d2a280d6183df41a0f9a29230e35726344f3a544ecf1c6f8c21d"

URI_aarch64_gnuplot-latex = "${EPEL_MIRROR}/aarch64/Packages/g/gnuplot-latex-6.0.3-5.el10_2.noarch.rpm;name=aarch64_gnuplot-latex;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnuplot-latex}"
SRC_URI[aarch64_gnuplot-latex.sha256sum] = "ace6cf1f1e8f4664748b33fbce47fe5e314c1535d6b96c854538be9918f220c8"

URI_aarch64_gnuplot-minimal = "${EPEL_MIRROR}/aarch64/Packages/g/gnuplot-minimal-6.0.3-5.el10_2.aarch64.rpm;name=aarch64_gnuplot-minimal;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnuplot-minimal}"
SRC_URI[aarch64_gnuplot-minimal.sha256sum] = "164feb0c14cb5aca785d78a5d539b3a24e4ddd623c35f71df6d9fde6fa60bbbc"

URI_aarch64_gnuplot-wx = "${EPEL_MIRROR}/aarch64/Packages/g/gnuplot-wx-6.0.3-5.el10_2.aarch64.rpm;name=aarch64_gnuplot-wx;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnuplot-wx}"
SRC_URI[aarch64_gnuplot-wx.sha256sum] = "10b16f38abe4c7571962d948db7f5a6d0443fa50a3a22b1b67408f96ca62a13b"
RPROVIDES:gnuplot-wx:aarch64 = "virtual/gnuplot virtual/gnuplot_eq_6.0.3-5.el10_2"

RDEPENDS:gnuplot = " \
 alternatives \
 bash \
 cairo \
 dejavu-sans-fonts \
 gd \
 glib2 \
 glibc \
 gnuplot-common \
 libcerf \
 libgcc \
 libstdc++ \
 libwebp \
 lua-libs \
 openspecfun \
 pango \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
RDEPENDS:gnuplot-common = " \
 glibc \
 libX11 \
 "
RDEPENDS:gnuplot-doc = " \
 "
RDEPENDS:gnuplot-latex:x86_64_v2 = " \
 bash \
 tex-preview \
 texlive-cm-super \
 texlive-collection-latexrecommended \
 texlive-ec \
 texlive-ucs \
 virtual/gnuplot_eq_6.0.3-5.el10_2.alma_altarch \
"
RDEPENDS:gnuplot-latex:aarch64 = " \
 bash \
 tex-preview \
 texlive-cm-super \
 texlive-collection-latexrecommended \
 texlive-ec \
 texlive-ucs \
 virtual/gnuplot_eq_6.0.3-5.el10_2 \
"
RDEPENDS:gnuplot-minimal = " \
 alternatives \
 bash \
 cairo \
 gd \
 glib2 \
 glibc \
 gnuplot-common \
 libcerf \
 libgcc \
 libwebp \
 lua-libs \
 openspecfun \
 pango \
 "
RDEPENDS:gnuplot-wx = " \
 alternatives \
 bash \
 cairo \
 gd \
 glib2 \
 glibc \
 gnuplot-common \
 gtk3 \
 libcerf \
 libgcc \
 libstdc++ \
 libwebp \
 lua-libs \
 openspecfun \
 pango \
 wxBase \
 wxGTK \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/gnuplot rpm/virtual/gnuplot_eq_6.0.3-5.el10_2.alma_altarch"

PROVIDES:append:aarch64 = " rpm/virtual/gnuplot rpm/virtual/gnuplot_eq_6.0.3-5.el10_2"
