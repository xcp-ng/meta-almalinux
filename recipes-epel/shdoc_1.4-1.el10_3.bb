# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "shdoc"
PV = "1.4"
PR = "1.el10_3"
PACKAGES = " \
 shdoc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/shdoc-1.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "722524d4d35331fb1de310355817515a097e1bd4d9cc55871502eedb8e79d3b5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/shdoc-1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_shdoc;unpack=0"
SRC_URI[x86_64_v2_shdoc.sha256sum] = "6cebc561bf5fb80e354ac61156ea659dc16d0283e6b832aa03aa11c480848fb5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/shdoc-1.4-1.el10_3.noarch.rpm;name=aarch64_shdoc;unpack=0"
SRC_URI[aarch64_shdoc.sha256sum] = "3de7942218a978cbaa55ce839376611e6be4b8f0c1e72b926f326dae174ceea1"

RDEPENDS:shdoc = " \
 gawk \
 vim-filesystem \
 "
