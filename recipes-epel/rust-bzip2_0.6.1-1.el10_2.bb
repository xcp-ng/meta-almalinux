# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bzip2"
PV = "0.6.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-bzip2+bzip2-sys-devel \
 rust-bzip2+default-devel \
 rust-bzip2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bzip2-0.6.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf2f93d787372e7cf2e205c61dc0fc95be1228e141f3e6d61ebc9b28913cd79f"

URI_x86_64_v2_rust-bzip2+bzip2-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bzip2+bzip2-sys-devel-0.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bzip2+bzip2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bzip2+bzip2-sys-devel}"
SRC_URI[x86_64_v2_rust-bzip2+bzip2-sys-devel.sha256sum] = "da9a5f37dcee512d63c20703b2bd8de02f65825a70dfb0941cd3c3d3cde18cd4"

URI_x86_64_v2_rust-bzip2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bzip2+default-devel-0.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bzip2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bzip2+default-devel}"
SRC_URI[x86_64_v2_rust-bzip2+default-devel.sha256sum] = "24dd72b1ed9db23544dfdbda8a067959096b382f65a9c27da56f926bbf1008f1"

URI_x86_64_v2_rust-bzip2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bzip2-devel-0.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bzip2-devel}"
SRC_URI[x86_64_v2_rust-bzip2-devel.sha256sum] = "50c75c75d03e2f45c735446521a2fd1a9f26f6ab81b48d76f6aae1bdec846834"

URI_aarch64_rust-bzip2+bzip2-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bzip2+bzip2-sys-devel-0.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-bzip2+bzip2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bzip2+bzip2-sys-devel}"
SRC_URI[aarch64_rust-bzip2+bzip2-sys-devel.sha256sum] = "08f14562448456115e677db75cfc4897fac518e4bc1d9ede8c64d4249da26c58"

URI_aarch64_rust-bzip2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bzip2+default-devel-0.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-bzip2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bzip2+default-devel}"
SRC_URI[aarch64_rust-bzip2+default-devel.sha256sum] = "02dae6469f5d7eec50c7874a3d0fa65bbb3a87d915b20b125f14c9a33ee1b039"

URI_aarch64_rust-bzip2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bzip2-devel-0.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bzip2-devel}"
SRC_URI[aarch64_rust-bzip2-devel.sha256sum] = "5157b226f0076f36e73704b18a4a1476e92e44d16472d33dbef4b9bfe82c347f"

RDEPENDS:rust-bzip2+bzip2-sys-devel = " \
 cargo \
 rust-bzip2-devel \
 rust-bzip2-sys+default-devel \
 "
RDEPENDS:rust-bzip2+default-devel = " \
 cargo \
 rust-bzip2-devel \
 rust-libbz2-rs-sys+rust-allocator-devel \
 rust-libbz2-rs-sys-devel \
 "
RDEPENDS:rust-bzip2-devel = " \
 cargo \
 rust \
 "
