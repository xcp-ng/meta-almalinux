# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_expand"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_expand+default-devel \
 rust-uu_expand-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_expand-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2fbb6034d3f63d391a951c8f539ef863eb3bb5447d07c26d4c3e507e21d28d3"

URI_x86_64_v2_rust-uu_expand+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_expand+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_expand+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_expand+default-devel}"
SRC_URI[x86_64_v2_rust-uu_expand+default-devel.sha256sum] = "b7bd5f86ce7cd0c632fb51186da9758ff965c676f46cf98d385ae9784c7e3f58"

URI_x86_64_v2_rust-uu_expand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_expand-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_expand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_expand-devel}"
SRC_URI[x86_64_v2_rust-uu_expand-devel.sha256sum] = "c74576d6a3ccd1e8ce5891a0ae41a5a7d1ad97bfae3efa91dd20c9c73b610b1f"

URI_aarch64_rust-uu_expand+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_expand+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_expand+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_expand+default-devel}"
SRC_URI[aarch64_rust-uu_expand+default-devel.sha256sum] = "7c71f54e7c4fdc1d04341ee5e8692352f2bc2e1243f9f8ba7fe309985355fe58"

URI_aarch64_rust-uu_expand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_expand-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_expand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_expand-devel}"
SRC_URI[aarch64_rust-uu_expand-devel.sha256sum] = "b1e4eec28fd977c8f8876b97409a8c9ac34fdbdf3008b65948a1f457871acf3d"

RDEPENDS:rust-uu_expand+default-devel = " \
 cargo \
 rust-uu_expand-devel \
 "
RDEPENDS:rust-uu_expand-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-thiserror+default-devel \
 rust-unicode-width+default-devel \
 rust-uucore+default-devel \
 "
