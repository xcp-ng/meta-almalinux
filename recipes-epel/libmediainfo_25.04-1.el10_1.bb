# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmediainfo"
PV = "25.04"
PR = "1.el10_1"
PACKAGES = " \
 libmediainfo \
 libmediainfo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libmediainfo-25.04-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6cd9093eac8def1e75938ddd939b6f5fac84fd6ee2e69b567e09ebb82784e343"

URI_x86_64_v2_libmediainfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmediainfo-25.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmediainfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmediainfo}"
SRC_URI[x86_64_v2_libmediainfo.sha256sum] = "ce40675055e0c4802ff68c5a06a23094d8d528ba9c2ccb91ec21f513b88ebb2e"

URI_x86_64_v2_libmediainfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmediainfo-devel-25.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmediainfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmediainfo-devel}"
SRC_URI[x86_64_v2_libmediainfo-devel.sha256sum] = "cd085077d98dbe204ccce93caf580fa58a0cf87c547e693b1a93fb6c8477375b"

URI_aarch64_libmediainfo = "${EPEL_MIRROR}/aarch64/Packages/l/libmediainfo-25.04-1.el10_1.aarch64.rpm;name=aarch64_libmediainfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmediainfo}"
SRC_URI[aarch64_libmediainfo.sha256sum] = "1763e42690d8afabf60b56cf608c1d196787031ef00ee7db3bd0c571673c1445"

URI_aarch64_libmediainfo-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libmediainfo-devel-25.04-1.el10_1.aarch64.rpm;name=aarch64_libmediainfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmediainfo-devel}"
SRC_URI[aarch64_libmediainfo-devel.sha256sum] = "08972eaf2842b4b2ccb464f620868ce57e6b2fb08bad063e20d603b5ade08935"

RDEPENDS:libmediainfo = " \
 glibc \
 libgcc \
 libstdc++ \
 libzen \
 tinyxml2 \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:libmediainfo-devel = " \
 cmake-filesystem \
 libcurl-devel \
 libmediainfo \
 libzen-devel \
 pkgconf-pkg-config \
 "
