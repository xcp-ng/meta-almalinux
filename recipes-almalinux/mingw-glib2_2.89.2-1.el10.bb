# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mingw-glib2"
PV = "2.89.2"
PR = "1.el10"
PACKAGES = " \
 mingw32-glib2 \
 mingw32-glib2-static \
 mingw64-glib2 \
 mingw64-glib2-static \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/mingw-glib2-2.89.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6aa377ad19afe66bb34bd27f4dc417cdcf34cbd58bf6cd4603adb16ae28aeae5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw32-glib2-2.89.2-1.el10.noarch.rpm;name=x86_64_v2_mingw32-glib2;unpack=0"
SRC_URI[x86_64_v2_mingw32-glib2.sha256sum] = "0bd3cfae652307ca2d63ef88a95ad100bbd53e7194d5d7dcb7382680d993d3eb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw32-glib2-static-2.89.2-1.el10.noarch.rpm;name=x86_64_v2_mingw32-glib2-static;unpack=0"
SRC_URI[x86_64_v2_mingw32-glib2-static.sha256sum] = "33f78aaa076b9833e01a317d0604471c41fe99bcb9597f73ed3977ecb6639e9c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw64-glib2-2.89.2-1.el10.noarch.rpm;name=x86_64_v2_mingw64-glib2;unpack=0"
SRC_URI[x86_64_v2_mingw64-glib2.sha256sum] = "27e1bf000d759c2195322c103acadf45504e70b53e92a3e0fc3e79bdfdb16f22"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw64-glib2-static-2.89.2-1.el10.noarch.rpm;name=x86_64_v2_mingw64-glib2-static;unpack=0"
SRC_URI[x86_64_v2_mingw64-glib2-static.sha256sum] = "5acce04eb0ac5bff34e4e328524bb86b87c1a2321bff7c91aa32f01a396e68a0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw32-glib2-2.89.2-1.el10.noarch.rpm;name=aarch64_mingw32-glib2;unpack=0"
SRC_URI[aarch64_mingw32-glib2.sha256sum] = "0bd3cfae652307ca2d63ef88a95ad100bbd53e7194d5d7dcb7382680d993d3eb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw32-glib2-static-2.89.2-1.el10.noarch.rpm;name=aarch64_mingw32-glib2-static;unpack=0"
SRC_URI[aarch64_mingw32-glib2-static.sha256sum] = "33f78aaa076b9833e01a317d0604471c41fe99bcb9597f73ed3977ecb6639e9c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw64-glib2-2.89.2-1.el10.noarch.rpm;name=aarch64_mingw64-glib2;unpack=0"
SRC_URI[aarch64_mingw64-glib2.sha256sum] = "27e1bf000d759c2195322c103acadf45504e70b53e92a3e0fc3e79bdfdb16f22"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw64-glib2-static-2.89.2-1.el10.noarch.rpm;name=aarch64_mingw64-glib2-static;unpack=0"
SRC_URI[aarch64_mingw64-glib2-static.sha256sum] = "5acce04eb0ac5bff34e4e328524bb86b87c1a2321bff7c91aa32f01a396e68a0"

RDEPENDS:mingw32-glib2 = " \
 bash \
 mingw32-crt \
 mingw32-filesystem \
 mingw32-gettext \
 mingw32-libffi \
 mingw32-libgcc \
 mingw32-pcre2 \
 mingw32-zlib \
 python3 \
 "
RDEPENDS:mingw32-glib2-static = " \
 mingw32-gettext-static \
 mingw32-glib2 \
 "
RDEPENDS:mingw64-glib2 = " \
 bash \
 mingw64-crt \
 mingw64-filesystem \
 mingw64-gettext \
 mingw64-libffi \
 mingw64-pcre2 \
 mingw64-zlib \
 python3 \
 "
RDEPENDS:mingw64-glib2-static = " \
 mingw64-gettext-static \
 mingw64-glib2 \
 "
