# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "powerdevil"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 powerdevil \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/powerdevil-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5c8ed4de773ee6a4b739e05126a567b7faffc198b8b9d77edc08b1bb6dc638f6"

URI_x86_64_v2_powerdevil = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/powerdevil-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_powerdevil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_powerdevil}"
SRC_URI[x86_64_v2_powerdevil.sha256sum] = "5dc0980c65a6f02ee058c4d9d5edfee5b89ad79ae25df8186c024f93391f6f41"

URI_aarch64_powerdevil = "${EPEL_MIRROR}/aarch64/Packages/p/powerdevil-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_powerdevil;unpack=0"
SRC_URI:append = " ${URI_aarch64_powerdevil}"
SRC_URI[aarch64_powerdevil.sha256sum] = "f74a68cabf72552c214bb05bad016b1510681d048d00c0318463ad4368ad6aeb"

RDEPENDS:powerdevil = " \
 ddcutil \
 glibc \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kidletime \
 kf6-kirigami \
 kf6-knotifications \
 kf6-kpackage \
 kf6-krunner \
 kf6-kservice \
 kf6-kxmlgui \
 kf6-solid \
 libddcutil \
 libkscreen \
 libkworkspace6 \
 libplasma \
 libstdc++ \
 libwayland-client \
 libxcb \
 plasma-activities \
 qcoro-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 systemd-libs \
 "
