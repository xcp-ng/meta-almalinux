# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cpufeatures0.2"
PV = "0.2.17"
PR = "1.el10_2"
PACKAGES = " \
 rust-cpufeatures0.2+default-devel \
 rust-cpufeatures0.2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cpufeatures0.2-0.2.17-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e69274b99077b56257adf37da03384a7cdac6b396782eaf4732ed45061f7daf"

URI_x86_64_v2_rust-cpufeatures0.2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cpufeatures0.2+default-devel-0.2.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cpufeatures0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cpufeatures0.2+default-devel}"
SRC_URI[x86_64_v2_rust-cpufeatures0.2+default-devel.sha256sum] = "d2bdcf769c4a9d98ef99fb8aa2877289865f31d0a9ac8806b6e0e27bc3449bdc"

URI_x86_64_v2_rust-cpufeatures0.2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cpufeatures0.2-devel-0.2.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cpufeatures0.2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cpufeatures0.2-devel}"
SRC_URI[x86_64_v2_rust-cpufeatures0.2-devel.sha256sum] = "7608e57a2baac25c1bfe98c00c969cfd20e6efbe525c28e21d47e5b16d4b1c25"

URI_aarch64_rust-cpufeatures0.2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cpufeatures0.2+default-devel-0.2.17-1.el10_2.noarch.rpm;name=aarch64_rust-cpufeatures0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cpufeatures0.2+default-devel}"
SRC_URI[aarch64_rust-cpufeatures0.2+default-devel.sha256sum] = "f618d5135d9d1c8ed00c405683a0f4b8eec01b1035039125dd9754633ff80479"

URI_aarch64_rust-cpufeatures0.2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cpufeatures0.2-devel-0.2.17-1.el10_2.noarch.rpm;name=aarch64_rust-cpufeatures0.2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cpufeatures0.2-devel}"
SRC_URI[aarch64_rust-cpufeatures0.2-devel.sha256sum] = "d6b69c1b54827562b1252afdb8c74a4f2d087d5986a1ae96185b1679d1dc4c87"

RDEPENDS:rust-cpufeatures0.2+default-devel = " \
 cargo \
 rust-cpufeatures0.2-devel \
 "
RDEPENDS:rust-cpufeatures0.2-devel = " \
 cargo \
 rust-libc-devel \
 "
