# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mongo-c-driver"
PV = "2.5.4"
PR = "1.el10_3"
PACKAGES = " \
 libbson \
 libbson-devel \
 mongo-c-driver \
 mongo-c-driver-devel \
 mongo-c-driver-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/m/mongo-c-driver-2.5.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f5f3b4d270c88aeacc923b884c586d36cd9db16a2d76e0e07b933a4318b5ba06"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbson-2.5.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libbson;unpack=0"
SRC_URI[x86_64_v2_libbson.sha256sum] = "c6ef1767348349ea178fe4bb14208b68da42a9d69f8286167af9a446f76ee56b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbson-devel-2.5.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libbson-devel;unpack=0"
SRC_URI[x86_64_v2_libbson-devel.sha256sum] = "3ceceb3e5a145f6d21198ebdb5bde684226c3a5a3e9a7ceabd82d728cf7162d0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mongo-c-driver-2.5.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mongo-c-driver;unpack=0"
SRC_URI[x86_64_v2_mongo-c-driver.sha256sum] = "ffaf4c6a16a37a7cb95e3981226f956a9aa9b2bdeb3d3187cfae12f77ad2e74e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mongo-c-driver-devel-2.5.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mongo-c-driver-devel;unpack=0"
SRC_URI[x86_64_v2_mongo-c-driver-devel.sha256sum] = "d92d79dcd773f311ff0f34f2a11983f2b6c64655ab7acfc0bc9d6978d39cced4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mongo-c-driver-libs-2.5.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mongo-c-driver-libs;unpack=0"
SRC_URI[x86_64_v2_mongo-c-driver-libs.sha256sum] = "4c441fa2f416bb797a39736205c79a7ec90387fed25ff71ade963e3bdeb347a8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libbson-2.5.4-1.el10_3.aarch64.rpm;name=aarch64_libbson;unpack=0"
SRC_URI[aarch64_libbson.sha256sum] = "c2c9e09215a9a4d1ca8798b56f5a62826de6a2ab525dfc10e71810db698ac320"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libbson-devel-2.5.4-1.el10_3.aarch64.rpm;name=aarch64_libbson-devel;unpack=0"
SRC_URI[aarch64_libbson-devel.sha256sum] = "8a9001266d0ba9ccf3db625581078858c64e82f8e2001d995eb5f3c39921ead3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/mongo-c-driver-2.5.4-1.el10_3.aarch64.rpm;name=aarch64_mongo-c-driver;unpack=0"
SRC_URI[aarch64_mongo-c-driver.sha256sum] = "191550ea67a5073b9ff9e86e225e670eb45e03812ed9fc79581e1eb4c47b1cdf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/mongo-c-driver-devel-2.5.4-1.el10_3.aarch64.rpm;name=aarch64_mongo-c-driver-devel;unpack=0"
SRC_URI[aarch64_mongo-c-driver-devel.sha256sum] = "df8825745d5b754e1e35ddac90e469aaa2843d2b94d79c1620baa7b69091e911"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/mongo-c-driver-libs-2.5.4-1.el10_3.aarch64.rpm;name=aarch64_mongo-c-driver-libs;unpack=0"
SRC_URI[aarch64_mongo-c-driver-libs.sha256sum] = "1a4fbf74bd066066471394e96ed5c099887b060a1a8a0b38bdfb750662526ae1"

RDEPENDS:libbson = " \
 glibc \
 "
RDEPENDS:libbson-devel = " \
 cmake-filesystem \
 libbson \
 pkgconf-pkg-config \
 "
RDEPENDS:mongo-c-driver = " \
 glibc \
 mongo-c-driver-libs \
 "
RDEPENDS:mongo-c-driver-devel = " \
 cmake-filesystem \
 cyrus-sasl-devel \
 libbson-devel \
 libmongocrypt-devel \
 libzstd-devel \
 mongo-c-driver \
 mongo-c-driver-libs \
 openssl-devel \
 pkgconf-pkg-config \
 utf8proc-devel \
 "
RDEPENDS:mongo-c-driver-libs = " \
 cyrus-sasl-lib \
 glibc \
 libbson \
 libmongocrypt \
 libzstd \
 openssl-libs \
 snappy \
 utf8proc \
 zlib-ng-compat \
 "
