# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cramjam"
PV = "2.11.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-cramjam \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cramjam-2.11.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a036fccf15fbc624b90407553f662c9fae6539082534bc597e2c9491aa21ae3a"

URI_x86_64_v2_python3-cramjam = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cramjam-2.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-cramjam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cramjam}"
SRC_URI[x86_64_v2_python3-cramjam.sha256sum] = "96c5c6833d2771a44f2339ee4ca246db44e393c7adf25914b27d7de6a4cbc90f"

URI_aarch64_python3-cramjam = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cramjam-2.11.0-1.el10_2.aarch64.rpm;name=aarch64_python3-cramjam;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cramjam}"
SRC_URI[aarch64_python3-cramjam.sha256sum] = "1eee84cffe8d317b00e923d02f129401a9bfebe369e25ae5d8a27074bb11fd6e"

RDEPENDS:python3-cramjam = " \
 glibc \
 libgcc \
 libzstd \
 lz4-libs \
 python3 \
 xz-libs \
 "
