# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmahjongg"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kmahjongg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmahjongg-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7307d651cb344427ff4c6fe67f3ccd09e042d7f8edaae294c8d4abd1dfb7a04"

URI_x86_64_v2_kmahjongg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmahjongg-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmahjongg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmahjongg}"
SRC_URI[x86_64_v2_kmahjongg.sha256sum] = "14618d322432af54eb147409c8d55b151e26e5dc63547846d698955668436051"

URI_aarch64_kmahjongg = "${EPEL_MIRROR}/aarch64/Packages/k/kmahjongg-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kmahjongg;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmahjongg}"
SRC_URI[aarch64_kmahjongg.sha256sum] = "ba4207eaf0f652d23bf5560beb81dd5fd7087ddcee2b5a54d75da36b1cb3939c"

RDEPENDS:kmahjongg = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libkmahjongg \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
