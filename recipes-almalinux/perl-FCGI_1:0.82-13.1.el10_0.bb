# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-FCGI"
PE = "1"
PV = "0.82"
PR = "13.1.el10_0"
PACKAGES = " \
 perl-FCGI \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-FCGI-0.82-13.1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "763910aaab544157aebb283d82cb5c705a422b612ebe03cbffc87ecbe289b483"

URI_x86_64_v2_perl-FCGI = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-FCGI-0.82-13.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_perl-FCGI;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-FCGI}"
SRC_URI[x86_64_v2_perl-FCGI.sha256sum] = "a5aac25e139f067c863b62f6ea84cbcf1c39635d0c7e23235c61e9c10b861719"

URI_aarch64_perl-FCGI = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-FCGI-0.82-13.1.el10_0.aarch64.rpm;name=aarch64_perl-FCGI;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-FCGI}"
SRC_URI[aarch64_perl-FCGI.sha256sum] = "288978763d0c46684bf049acae290be2903da1ea4c5c3c62c5d7d749394bfdeb"

RDEPENDS:perl-FCGI = " \
 glibc \
 perl-Carp \
 perl-libs \
 "
