# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "virtiofsd"
PV = "1.13.3"
PR = "1.el10.alma.1"
PACKAGES = " \
 virtiofsd \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/virtiofsd-1.13.3-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a1c5895dab1f5423cd50f7eb8d4b8d8bac19cbdd412809f86d3521c8e3fbab88"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/virtiofsd-1.13.3-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_virtiofsd;unpack=0"
SRC_URI[x86_64_v2_virtiofsd.sha256sum] = "a69b8549b9c7eb5152b452f9898f37ad38e8e66be6ec18990fcd9c09020fa72b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/virtiofsd-1.13.3-1.el10.alma.1.aarch64.rpm;name=aarch64_virtiofsd;unpack=0"
SRC_URI[aarch64_virtiofsd.sha256sum] = "01ee861c937a21d403aabc41f2858cbfabfabc97c4310631467513cf3972a099"

RDEPENDS:virtiofsd = " \
 glibc \
 libcap-ng \
 libgcc \
 libseccomp \
 qemu-kvm-common \
 shadow-utils \
 "
