# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-discover"
PV = "0.41.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-discover+default-devel \
 rust-gix-discover-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-discover-0.41.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd28b383fc14df259c7a22ba0c7380805570b4a6038de72f28e478960c44d840"

URI_x86_64_v2_rust-gix-discover+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-discover+default-devel-0.41.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-discover+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-discover+default-devel}"
SRC_URI[x86_64_v2_rust-gix-discover+default-devel.sha256sum] = "a75a222a4764f9694405e86d8347c24cc396bdf06f2c3381b5b5318b5dade637"

URI_x86_64_v2_rust-gix-discover-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-discover-devel-0.41.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-discover-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-discover-devel}"
SRC_URI[x86_64_v2_rust-gix-discover-devel.sha256sum] = "d1cd4abac53d5044d4e4d8ee46990cd1ba9b5ff04ce1461678ff906570015bff"

URI_aarch64_rust-gix-discover+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-discover+default-devel-0.41.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-discover+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-discover+default-devel}"
SRC_URI[aarch64_rust-gix-discover+default-devel.sha256sum] = "65a2ec201f2e78b292905baea5bc09490dec64309abfb9fac7eaee85b7fcb883"

URI_aarch64_rust-gix-discover-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-discover-devel-0.41.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-discover-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-discover-devel}"
SRC_URI[aarch64_rust-gix-discover-devel.sha256sum] = "dce6b362d75e43e7301755cd1c23f2f885fba76717446fc16465d0f1675d705a"

RDEPENDS:rust-gix-discover+default-devel = " \
 cargo \
 rust-gix-discover-devel \
 "
RDEPENDS:rust-gix-discover-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-fs+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-path+default-devel \
 rust-gix-ref+default-devel \
 rust-gix-sec+default-devel \
 rust-thiserror+default-devel \
 "
