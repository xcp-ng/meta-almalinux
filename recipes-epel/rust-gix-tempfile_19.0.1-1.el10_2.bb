# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-tempfile"
PV = "19.0.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-tempfile+default-devel \
 rust-gix-tempfile+document-features-devel \
 rust-gix-tempfile+hp-hashmap-devel \
 rust-gix-tempfile+signals-devel \
 rust-gix-tempfile-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-tempfile-19.0.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f5974069c818a152dced3c15e59ebfc00c235b280ad36ecd721ccba105cd8624"

URI_x86_64_v2_rust-gix-tempfile+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-tempfile+default-devel-19.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-tempfile+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-tempfile+default-devel}"
SRC_URI[x86_64_v2_rust-gix-tempfile+default-devel.sha256sum] = "7209bdfd2af115fb0c53c42ed1db5ae91a86d120d224e05302026dc8c3335e05"

URI_x86_64_v2_rust-gix-tempfile+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-tempfile+document-features-devel-19.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-tempfile+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-tempfile+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-tempfile+document-features-devel.sha256sum] = "4edc76dd0eecaef619bfe6f8f1a7e40a29c16b1a5d364c9463d859d65731c766"

URI_x86_64_v2_rust-gix-tempfile+hp-hashmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-tempfile+hp-hashmap-devel-19.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-tempfile+hp-hashmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-tempfile+hp-hashmap-devel}"
SRC_URI[x86_64_v2_rust-gix-tempfile+hp-hashmap-devel.sha256sum] = "ad229178e80b14ab24dd9211b8986b731b7ed50a2133dee73734f423da674db7"

URI_x86_64_v2_rust-gix-tempfile+signals-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-tempfile+signals-devel-19.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-tempfile+signals-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-tempfile+signals-devel}"
SRC_URI[x86_64_v2_rust-gix-tempfile+signals-devel.sha256sum] = "eb06c95fbac2cf5261282c0b17eeac1f7012676fb3b0584fc3ac548c2a4fab2e"

URI_x86_64_v2_rust-gix-tempfile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-tempfile-devel-19.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-tempfile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-tempfile-devel}"
SRC_URI[x86_64_v2_rust-gix-tempfile-devel.sha256sum] = "fcea1f3f649567abb02f3be5598b7f61d7c1df5b6aa1271d5bd7789a65e8087a"

URI_aarch64_rust-gix-tempfile+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-tempfile+default-devel-19.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-tempfile+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-tempfile+default-devel}"
SRC_URI[aarch64_rust-gix-tempfile+default-devel.sha256sum] = "1b167603030e207fbd8af972bbc795ac9069b78186f424df4f11bab2b3a4afaf"

URI_aarch64_rust-gix-tempfile+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-tempfile+document-features-devel-19.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-tempfile+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-tempfile+document-features-devel}"
SRC_URI[aarch64_rust-gix-tempfile+document-features-devel.sha256sum] = "09bec29ae3c129d05a49a8855bea0e8c3518a2bdb4880948f18d3b837e8c4756"

URI_aarch64_rust-gix-tempfile+hp-hashmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-tempfile+hp-hashmap-devel-19.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-tempfile+hp-hashmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-tempfile+hp-hashmap-devel}"
SRC_URI[aarch64_rust-gix-tempfile+hp-hashmap-devel.sha256sum] = "668564390b4730f0f854128059538e2538ce5799a647040ded8d90585bbce73a"

URI_aarch64_rust-gix-tempfile+signals-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-tempfile+signals-devel-19.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-tempfile+signals-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-tempfile+signals-devel}"
SRC_URI[aarch64_rust-gix-tempfile+signals-devel.sha256sum] = "e58e5eeba3e16d44dc7a23a84b402a942db61c7c7d50dadf567994e3ac998389"

URI_aarch64_rust-gix-tempfile-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-tempfile-devel-19.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-tempfile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-tempfile-devel}"
SRC_URI[aarch64_rust-gix-tempfile-devel.sha256sum] = "c6d7970d7c8e4673048156d74d0c4d011659b8f2ab20c568b379e1b80440f44a"

RDEPENDS:rust-gix-tempfile+default-devel = " \
 cargo \
 rust-gix-tempfile+hp-hashmap-devel \
 rust-gix-tempfile-devel \
 "
RDEPENDS:rust-gix-tempfile+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-tempfile-devel \
 "
RDEPENDS:rust-gix-tempfile+hp-hashmap-devel = " \
 cargo \
 rust-dashmap+default-devel \
 rust-gix-tempfile-devel \
 "
RDEPENDS:rust-gix-tempfile+signals-devel = " \
 cargo \
 rust-gix-tempfile-devel \
 rust-signal-hook-devel \
 rust-signal-hook-registry+default-devel \
 "
RDEPENDS:rust-gix-tempfile-devel = " \
 cargo \
 rust \
 rust-gix-fs+default-devel \
 rust-libc-devel \
 rust-parking_lot+default-devel \
 rust-tempfile+default-devel \
 "
