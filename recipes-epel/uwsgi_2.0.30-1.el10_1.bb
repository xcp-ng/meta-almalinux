# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "uwsgi"
PV = "2.0.30"
PR = "1.el10_1"
PACKAGES = " \
 python3-uwsgidecorators \
 python3.12-uwsgidecorators \
 uwsgi \
 uwsgi-alarm-curl \
 uwsgi-devel \
 uwsgi-docs \
 uwsgi-emperor-amqp \
 uwsgi-emperor-pg \
 uwsgi-log-encoder-msgpack \
 uwsgi-logger-crypto \
 uwsgi-logger-file \
 uwsgi-logger-graylog2 \
 uwsgi-logger-pipe \
 uwsgi-logger-redis \
 uwsgi-logger-rsyslog \
 uwsgi-logger-socket \
 uwsgi-logger-syslog \
 uwsgi-logger-systemd \
 uwsgi-plugin-airbrake \
 uwsgi-plugin-cache \
 uwsgi-plugin-carbon \
 uwsgi-plugin-cheaper-busyness \
 uwsgi-plugin-common \
 uwsgi-plugin-cplusplus \
 uwsgi-plugin-curl-cron \
 uwsgi-plugin-dumbloop \
 uwsgi-plugin-dummy \
 uwsgi-plugin-fiber \
 uwsgi-plugin-ldap \
 uwsgi-plugin-lua \
 uwsgi-plugin-nagios \
 uwsgi-plugin-notfound \
 uwsgi-plugin-pam \
 uwsgi-plugin-php \
 uwsgi-plugin-psgi \
 uwsgi-plugin-pty \
 uwsgi-plugin-python3 \
 uwsgi-plugin-python3-gevent \
 uwsgi-plugin-python3-tornado \
 uwsgi-plugin-python312 \
 uwsgi-plugin-python312-gevent \
 uwsgi-plugin-rack \
 uwsgi-plugin-rbthreads \
 uwsgi-plugin-rpc \
 uwsgi-plugin-rrdtool \
 uwsgi-plugin-ruby \
 uwsgi-plugin-spooler \
 uwsgi-plugin-sqlite3 \
 uwsgi-plugin-ssi \
 uwsgi-plugin-ugreen \
 uwsgi-plugin-webdav \
 uwsgi-plugin-xattr \
 uwsgi-plugin-xslt \
 uwsgi-plugin-zergpool \
 uwsgi-router-basicauth \
 uwsgi-router-cache \
 uwsgi-router-expires \
 uwsgi-router-fast \
 uwsgi-router-forkpty \
 uwsgi-router-hash \
 uwsgi-router-http \
 uwsgi-router-memcached \
 uwsgi-router-metrics \
 uwsgi-router-radius \
 uwsgi-router-raw \
 uwsgi-router-redirect \
 uwsgi-router-redis \
 uwsgi-router-rewrite \
 uwsgi-router-spnego \
 uwsgi-router-ssl \
 uwsgi-router-static \
 uwsgi-router-tuntap \
 uwsgi-router-uwsgi \
 uwsgi-router-xmldir \
 uwsgi-stats-pusher-file \
 uwsgi-stats-pusher-socket \
 uwsgi-stats-pusher-statsd \
 uwsgi-stats-pusher-zabbix \
 uwsgi-transformation-chunked \
 uwsgi-transformation-gzip \
 uwsgi-transformation-offload \
 uwsgi-transformation-template \
 uwsgi-transformation-tofile \
 uwsgi-transformation-toupper \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/uwsgi-2.0.30-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "639984ddbdb49af9ecd4fe802028a45c647de6cc2f25fdc303fe0c187516c996"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - uwsgi: libcap.so.2()(64bit)

URI_x86_64_v2_python3-uwsgidecorators = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-uwsgidecorators-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-uwsgidecorators;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-uwsgidecorators}"
SRC_URI[x86_64_v2_python3-uwsgidecorators.sha256sum] = "d0b2a2eb9322213f149b7bca659d924c46b2a4dbb90b85db3c5f6fc76a78b035"

URI_x86_64_v2_python3.12-uwsgidecorators = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.12-uwsgidecorators-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3.12-uwsgidecorators;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.12-uwsgidecorators}"
SRC_URI[x86_64_v2_python3.12-uwsgidecorators.sha256sum] = "7d7b216d042cb25cdcf0c7cc6fab5554113c0dd4c03488e7bfe95277cdef3909"

URI_x86_64_v2_uwsgi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi}"
SRC_URI[x86_64_v2_uwsgi.sha256sum] = "b6538c41b0cc0ffbf0c748bfefc0e7bd27d8988c6a65592522163e01453539fd"

URI_x86_64_v2_uwsgi-alarm-curl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-alarm-curl-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-alarm-curl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-alarm-curl}"
SRC_URI[x86_64_v2_uwsgi-alarm-curl.sha256sum] = "0ba1599378c10a3f20cc94fd75c204eac883f747ef7d3c6570d7357ce1bbc698"

URI_x86_64_v2_uwsgi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-devel-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-devel}"
SRC_URI[x86_64_v2_uwsgi-devel.sha256sum] = "271c72bd3d86ad6d68cb26cfc6cc56134e9f78da141931d0b5eba44d67f4da5c"

URI_x86_64_v2_uwsgi-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-docs-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-docs}"
SRC_URI[x86_64_v2_uwsgi-docs.sha256sum] = "2def9c3b37a6bf348dd5f84acf75f3d4e1f6f5d19963274120b2383749d19472"

URI_x86_64_v2_uwsgi-emperor-amqp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-emperor-amqp-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-emperor-amqp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-emperor-amqp}"
SRC_URI[x86_64_v2_uwsgi-emperor-amqp.sha256sum] = "55e75651ebee7ca87a3415ff35d85d1a86bf8fc821a93dc99f3746cbbb9ee1f8"

URI_x86_64_v2_uwsgi-emperor-pg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-emperor-pg-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-emperor-pg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-emperor-pg}"
SRC_URI[x86_64_v2_uwsgi-emperor-pg.sha256sum] = "b4d528450614f7691f22c9e8ab20f0d75fa44c72b90b65bb97fc5cd6bb4f1559"

URI_x86_64_v2_uwsgi-log-encoder-msgpack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-log-encoder-msgpack-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-log-encoder-msgpack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-log-encoder-msgpack}"
SRC_URI[x86_64_v2_uwsgi-log-encoder-msgpack.sha256sum] = "2450a4ebec6930bcad9533fb72cd86b9c8a8382b1c555c057dfe56c56680a725"

URI_x86_64_v2_uwsgi-logger-crypto = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-logger-crypto-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-logger-crypto;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-logger-crypto}"
SRC_URI[x86_64_v2_uwsgi-logger-crypto.sha256sum] = "cb5693c7866409942c6083fc3e18c70db7e7b7e27362cc588477908f91d81aa9"

URI_x86_64_v2_uwsgi-logger-file = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-logger-file-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-logger-file;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-logger-file}"
SRC_URI[x86_64_v2_uwsgi-logger-file.sha256sum] = "b25c0e9255637e2bf25f858850461da00320bdfa176962c683bea7428a522acc"

URI_x86_64_v2_uwsgi-logger-graylog2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-logger-graylog2-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-logger-graylog2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-logger-graylog2}"
SRC_URI[x86_64_v2_uwsgi-logger-graylog2.sha256sum] = "49e50775e042ad413553fe1243dae9388f7e49247f8c216e6bc496d60f712137"

URI_x86_64_v2_uwsgi-logger-pipe = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-logger-pipe-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-logger-pipe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-logger-pipe}"
SRC_URI[x86_64_v2_uwsgi-logger-pipe.sha256sum] = "1d026281aadf21239df3a7e90750421de11839d41cd1f89f1d0d6282b36c2377"

URI_x86_64_v2_uwsgi-logger-redis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-logger-redis-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-logger-redis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-logger-redis}"
SRC_URI[x86_64_v2_uwsgi-logger-redis.sha256sum] = "6d0980016d09350d9dc407970fb55019142a3553fbcdae2748a0bc04aaa5add7"

URI_x86_64_v2_uwsgi-logger-rsyslog = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-logger-rsyslog-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-logger-rsyslog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-logger-rsyslog}"
SRC_URI[x86_64_v2_uwsgi-logger-rsyslog.sha256sum] = "9b3be5107f20b516c07f611fa6445e52216194d708f0aefbb4015db26252bb7f"

URI_x86_64_v2_uwsgi-logger-socket = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-logger-socket-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-logger-socket;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-logger-socket}"
SRC_URI[x86_64_v2_uwsgi-logger-socket.sha256sum] = "3782f664b462008911292fb7596e6bd43d33c001c32cfc1f9c9ec6a0f93e3d1d"

URI_x86_64_v2_uwsgi-logger-syslog = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-logger-syslog-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-logger-syslog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-logger-syslog}"
SRC_URI[x86_64_v2_uwsgi-logger-syslog.sha256sum] = "57531b55fd4879c4f1d4b0a32bbccdbb325408314e5b2f2578f4e604ab4bbd70"

URI_x86_64_v2_uwsgi-logger-systemd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-logger-systemd-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-logger-systemd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-logger-systemd}"
SRC_URI[x86_64_v2_uwsgi-logger-systemd.sha256sum] = "39eb3ca2d59992403207bb1380e35a23968f7e59ce24c32575892ba4aa0de05b"

URI_x86_64_v2_uwsgi-plugin-airbrake = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-airbrake-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-airbrake;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-airbrake}"
SRC_URI[x86_64_v2_uwsgi-plugin-airbrake.sha256sum] = "844bf7e23cd5469d1472f238f5147a727dd70e8e5eaa27de98a018ccc457d6e7"

URI_x86_64_v2_uwsgi-plugin-cache = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-cache-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-cache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-cache}"
SRC_URI[x86_64_v2_uwsgi-plugin-cache.sha256sum] = "3c47a19a12ca142b75e73d9d6a19b69b7f4961c1cfa95701288b26a2f7c90f0a"

URI_x86_64_v2_uwsgi-plugin-carbon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-carbon-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-carbon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-carbon}"
SRC_URI[x86_64_v2_uwsgi-plugin-carbon.sha256sum] = "82d0715d2606524ada80bd3cfc20fa696cb16794b26ef755faf303adf58188a7"

URI_x86_64_v2_uwsgi-plugin-cheaper-busyness = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-cheaper-busyness-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-cheaper-busyness;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-cheaper-busyness}"
SRC_URI[x86_64_v2_uwsgi-plugin-cheaper-busyness.sha256sum] = "f25235299e3608fd2817f65a2a272f25e549098364e8e2ad105ae21185ec6582"

URI_x86_64_v2_uwsgi-plugin-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-common-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-common}"
SRC_URI[x86_64_v2_uwsgi-plugin-common.sha256sum] = "cada9c65d5310ead57278492c103c17dcf163ee60787085bf624e0e26799600e"

URI_x86_64_v2_uwsgi-plugin-cplusplus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-cplusplus-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-cplusplus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-cplusplus}"
SRC_URI[x86_64_v2_uwsgi-plugin-cplusplus.sha256sum] = "16c6e5d266a9582394cf12131e27d90d2fdbf42b966b8c62781197d9aadfe061"

URI_x86_64_v2_uwsgi-plugin-curl-cron = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-curl-cron-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-curl-cron;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-curl-cron}"
SRC_URI[x86_64_v2_uwsgi-plugin-curl-cron.sha256sum] = "95f138b8f6a12b303b5f079739c02509bf1ac386564a0b8a9aa9b9bf024643ca"

URI_x86_64_v2_uwsgi-plugin-dumbloop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-dumbloop-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-dumbloop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-dumbloop}"
SRC_URI[x86_64_v2_uwsgi-plugin-dumbloop.sha256sum] = "faa26cc9cf176f02d5245334b23b03e4a814201aeb44256f271e566ce3d80664"

URI_x86_64_v2_uwsgi-plugin-dummy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-dummy-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-dummy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-dummy}"
SRC_URI[x86_64_v2_uwsgi-plugin-dummy.sha256sum] = "4e53e20799ebef18835fd15e0c8234343b3ee487cd34db98c5a892b692aaee05"

URI_x86_64_v2_uwsgi-plugin-fiber = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-fiber-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-fiber;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-fiber}"
SRC_URI[x86_64_v2_uwsgi-plugin-fiber.sha256sum] = "3e7d68d5d73d16435ee95020059a01f32d7cc7de5c058fe2996b2f021980bf43"

URI_x86_64_v2_uwsgi-plugin-ldap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-ldap-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-ldap}"
SRC_URI[x86_64_v2_uwsgi-plugin-ldap.sha256sum] = "8138c07b4e8dc0c5207a75b7c7c83bbc90c202cceadac43dfb4fe69a5d66f55a"

URI_x86_64_v2_uwsgi-plugin-lua = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-lua-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-lua;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-lua}"
SRC_URI[x86_64_v2_uwsgi-plugin-lua.sha256sum] = "73da12c59cbb3ea3c41c15ec7c9c538927cd23cc127b9d2a0771b122d30bcb2c"

URI_x86_64_v2_uwsgi-plugin-nagios = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-nagios-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-nagios;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-nagios}"
SRC_URI[x86_64_v2_uwsgi-plugin-nagios.sha256sum] = "fb8df9abf55045c081d9be02df0cb28db4c8671f2cfeb0fd36e81827c53dc2aa"

URI_x86_64_v2_uwsgi-plugin-notfound = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-notfound-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-notfound;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-notfound}"
SRC_URI[x86_64_v2_uwsgi-plugin-notfound.sha256sum] = "2ab5c262c31421e0b1c2a9bfe3044952b1fc72c75876583b962e0c7e58b055e3"

URI_x86_64_v2_uwsgi-plugin-pam = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-pam-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-pam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-pam}"
SRC_URI[x86_64_v2_uwsgi-plugin-pam.sha256sum] = "77dc760b9a20b16801db5832055b1c151049c9ab63a091324da4bc2ebd20c50c"

URI_x86_64_v2_uwsgi-plugin-php = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-php-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-php;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-php}"
SRC_URI[x86_64_v2_uwsgi-plugin-php.sha256sum] = "5c51f63c0ebf9ff6a881f217c7f66f1116b0cc5cf2d93ef2a87620366001d77c"

URI_x86_64_v2_uwsgi-plugin-psgi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-psgi-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-psgi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-psgi}"
SRC_URI[x86_64_v2_uwsgi-plugin-psgi.sha256sum] = "2328e5c9fd1dc08b55eb92ab7a940a97baa0eb03bf9258b899b0bc0ed1c1ef7f"

URI_x86_64_v2_uwsgi-plugin-pty = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-pty-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-pty;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-pty}"
SRC_URI[x86_64_v2_uwsgi-plugin-pty.sha256sum] = "a59c27ef0ab5da55d2173f5fea379205a47d3862d9e8b0f636b42cddf9160ae6"

URI_x86_64_v2_uwsgi-plugin-python3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-python3-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-python3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-python3}"
SRC_URI[x86_64_v2_uwsgi-plugin-python3.sha256sum] = "c3772bf21f7dab63c3ab4e17e13a46a6fa2f86928d30eeda4aa9644bd700c220"

URI_x86_64_v2_uwsgi-plugin-python3-gevent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-python3-gevent-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-python3-gevent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-python3-gevent}"
SRC_URI[x86_64_v2_uwsgi-plugin-python3-gevent.sha256sum] = "7bff07416bccd45868f7bcfaab76b53d534196bba4ac374fa3a13a90405eb179"

URI_x86_64_v2_uwsgi-plugin-python3-tornado = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-python3-tornado-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-python3-tornado;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-python3-tornado}"
SRC_URI[x86_64_v2_uwsgi-plugin-python3-tornado.sha256sum] = "d229fab29eb5275c851f55ace14aad65d3bc9acad4292b7461d62695b73c57e6"

URI_x86_64_v2_uwsgi-plugin-python312 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-python312-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-python312;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-python312}"
SRC_URI[x86_64_v2_uwsgi-plugin-python312.sha256sum] = "29319404cad80acc5f0a979bb0cc8cbde3146f8538a79e879456f07c34b4a753"

URI_x86_64_v2_uwsgi-plugin-python312-gevent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-python312-gevent-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-python312-gevent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-python312-gevent}"
SRC_URI[x86_64_v2_uwsgi-plugin-python312-gevent.sha256sum] = "6eea53052d35a9b1227800cb3a123fe06aa87b64c451719fb214dd81b194c071"

URI_x86_64_v2_uwsgi-plugin-rack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-rack-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-rack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-rack}"
SRC_URI[x86_64_v2_uwsgi-plugin-rack.sha256sum] = "b949a989d591d14a79af74b75c14417b6e81f40951ed664dd48a48e4c2c40f51"

URI_x86_64_v2_uwsgi-plugin-rbthreads = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-rbthreads-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-rbthreads;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-rbthreads}"
SRC_URI[x86_64_v2_uwsgi-plugin-rbthreads.sha256sum] = "1d01ac4b3cb901ad2c54f7d67fe7e47831cd4591924eb76a0a3e63f75ce64a3b"

URI_x86_64_v2_uwsgi-plugin-rpc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-rpc-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-rpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-rpc}"
SRC_URI[x86_64_v2_uwsgi-plugin-rpc.sha256sum] = "6840b459b0f208b37ebe9c19adba5f01b5f6e6ad2be6a632a000a95bbaa3c4e3"

URI_x86_64_v2_uwsgi-plugin-rrdtool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-rrdtool-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-rrdtool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-rrdtool}"
SRC_URI[x86_64_v2_uwsgi-plugin-rrdtool.sha256sum] = "313414d875bf8526001baa693ea5ae3d2016bbe71d117763e4ba64b7ec4068bf"

URI_x86_64_v2_uwsgi-plugin-ruby = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-ruby-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-ruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-ruby}"
SRC_URI[x86_64_v2_uwsgi-plugin-ruby.sha256sum] = "2e340976bad87ecc695914cf597fa2dc7247542d8efaf60cab6271b2bab191ac"

URI_x86_64_v2_uwsgi-plugin-spooler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-spooler-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-spooler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-spooler}"
SRC_URI[x86_64_v2_uwsgi-plugin-spooler.sha256sum] = "af5bc9a92e6822d6be0d3976c5355700e6907d8b005a8b7dc1a346c0fe54ccee"

URI_x86_64_v2_uwsgi-plugin-sqlite3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-sqlite3-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-sqlite3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-sqlite3}"
SRC_URI[x86_64_v2_uwsgi-plugin-sqlite3.sha256sum] = "da59a2ab9598625c06e5ccbfaf129a886ca722aa545108d09d47c2a9b5bd1b4b"

URI_x86_64_v2_uwsgi-plugin-ssi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-ssi-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-ssi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-ssi}"
SRC_URI[x86_64_v2_uwsgi-plugin-ssi.sha256sum] = "f3fee419adbca9140af15fb72c6c40182c3e14776bf24d89574742bc857e37de"

URI_x86_64_v2_uwsgi-plugin-ugreen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-ugreen-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-ugreen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-ugreen}"
SRC_URI[x86_64_v2_uwsgi-plugin-ugreen.sha256sum] = "426656318b5e2368fc9d6983be2714f4cc0a887af9d9bcd810860713d99f68dd"

URI_x86_64_v2_uwsgi-plugin-webdav = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-webdav-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-webdav;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-webdav}"
SRC_URI[x86_64_v2_uwsgi-plugin-webdav.sha256sum] = "9d39e93231b8b1ff3f6697a2e076db8162bf3a474c87ddfaa82e3e738ced53db"

URI_x86_64_v2_uwsgi-plugin-xattr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-xattr-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-xattr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-xattr}"
SRC_URI[x86_64_v2_uwsgi-plugin-xattr.sha256sum] = "99040df79bb8e6c167b02dd62c66cc4b6677ca285de483cadf07ec4021c4b404"

URI_x86_64_v2_uwsgi-plugin-xslt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-xslt-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-xslt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-xslt}"
SRC_URI[x86_64_v2_uwsgi-plugin-xslt.sha256sum] = "e6326ba314207233f973c6caf86dfd5106933100e284abd917c357829343755b"

URI_x86_64_v2_uwsgi-plugin-zergpool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-zergpool-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-zergpool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-zergpool}"
SRC_URI[x86_64_v2_uwsgi-plugin-zergpool.sha256sum] = "ec05fc9fa820cf1adc6ebf85e45022248883b2d3f5f79f80bb7b04dc94be5df1"

URI_x86_64_v2_uwsgi-router-basicauth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-basicauth-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-basicauth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-basicauth}"
SRC_URI[x86_64_v2_uwsgi-router-basicauth.sha256sum] = "501956321da517d3828830ad0ccab572b1ccfd249a68d147d8b178c7656a7d98"

URI_x86_64_v2_uwsgi-router-cache = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-cache-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-cache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-cache}"
SRC_URI[x86_64_v2_uwsgi-router-cache.sha256sum] = "3eec441218d4e87097e6102378dcd07e6fa5cfef9b11325b044edd1c24b49859"

URI_x86_64_v2_uwsgi-router-expires = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-expires-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-expires;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-expires}"
SRC_URI[x86_64_v2_uwsgi-router-expires.sha256sum] = "4e0ea77eb5121939be59b0740d64366077afd53a6793a842a5a255a050e06fb4"

URI_x86_64_v2_uwsgi-router-fast = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-fast-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-fast;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-fast}"
SRC_URI[x86_64_v2_uwsgi-router-fast.sha256sum] = "579c03087aed7023f904b3e94b8519fa80cc69f7b273f801773e22a6809739b6"

URI_x86_64_v2_uwsgi-router-forkpty = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-forkpty-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-forkpty;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-forkpty}"
SRC_URI[x86_64_v2_uwsgi-router-forkpty.sha256sum] = "a3520e433d48a21fef5fcb3dc5722e5584ae28d9a6d0d90d0eb95eab0e41cdc7"

URI_x86_64_v2_uwsgi-router-hash = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-hash-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-hash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-hash}"
SRC_URI[x86_64_v2_uwsgi-router-hash.sha256sum] = "3a63d6a6fdb136b00d614f944f3ffc6ce6c201dd9883d302cea4621ad338f5a5"

URI_x86_64_v2_uwsgi-router-http = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-http-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-http;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-http}"
SRC_URI[x86_64_v2_uwsgi-router-http.sha256sum] = "e60aff616cbf6adcdb8fb8b604c352d1640df87e7bbb32a741985d07795ef979"

URI_x86_64_v2_uwsgi-router-memcached = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-memcached-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-memcached;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-memcached}"
SRC_URI[x86_64_v2_uwsgi-router-memcached.sha256sum] = "170870dccb9d05456615668e23417f5a568bf07ef807a2c2c4c03d7005471d95"

URI_x86_64_v2_uwsgi-router-metrics = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-metrics-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-metrics;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-metrics}"
SRC_URI[x86_64_v2_uwsgi-router-metrics.sha256sum] = "29a34e69d2973da49166aca50686886e0b528eabf9134c5905d5163a4f3e46ed"

URI_x86_64_v2_uwsgi-router-radius = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-radius-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-radius;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-radius}"
SRC_URI[x86_64_v2_uwsgi-router-radius.sha256sum] = "6ebddec931fcdad84bdcf985a766745e1e8f3c2b8dc4df13ae5f2ca480de22e0"

URI_x86_64_v2_uwsgi-router-raw = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-raw-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-raw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-raw}"
SRC_URI[x86_64_v2_uwsgi-router-raw.sha256sum] = "e07fdf2b8c0dfd544b4e47622b4676e2b60a07c5fdc1cfe6911f2c022aa1ce45"

URI_x86_64_v2_uwsgi-router-redirect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-redirect-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-redirect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-redirect}"
SRC_URI[x86_64_v2_uwsgi-router-redirect.sha256sum] = "64e96aad3b119dab05865ccd659506b79af7c067fa1fcd13320ccf8e90b4fc13"

URI_x86_64_v2_uwsgi-router-redis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-redis-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-redis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-redis}"
SRC_URI[x86_64_v2_uwsgi-router-redis.sha256sum] = "91780df964da01019eb55610537bb2199dcdc0f9c4daa4169a1806beb3f1a6c4"

URI_x86_64_v2_uwsgi-router-rewrite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-rewrite-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-rewrite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-rewrite}"
SRC_URI[x86_64_v2_uwsgi-router-rewrite.sha256sum] = "4b768be55c55325631e84a49498f2e6161cd9d3f75d13ff78b7fcccf1e6904e7"

URI_x86_64_v2_uwsgi-router-spnego = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-spnego-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-spnego;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-spnego}"
SRC_URI[x86_64_v2_uwsgi-router-spnego.sha256sum] = "4cc2e657b0e51b2c0ba9724ee0e04542fe43d099b18f4ce7692dade59cb3bf19"

URI_x86_64_v2_uwsgi-router-ssl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-ssl-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-ssl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-ssl}"
SRC_URI[x86_64_v2_uwsgi-router-ssl.sha256sum] = "f42ceac2aab5fdeff4458799f30127ffe99e436b4fbbfde080c3411345c7cbb1"

URI_x86_64_v2_uwsgi-router-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-static-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-static}"
SRC_URI[x86_64_v2_uwsgi-router-static.sha256sum] = "423b522f939d89158f693de07135090e66f4753c6e57aa1547aef90a964b2446"

URI_x86_64_v2_uwsgi-router-tuntap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-tuntap-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-tuntap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-tuntap}"
SRC_URI[x86_64_v2_uwsgi-router-tuntap.sha256sum] = "001ab6da7b4d450214ede377745e7506d5a14e976785f7d3230bef766cca491e"

URI_x86_64_v2_uwsgi-router-uwsgi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-uwsgi-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-uwsgi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-uwsgi}"
SRC_URI[x86_64_v2_uwsgi-router-uwsgi.sha256sum] = "2e208f8b6aa93d1c6088bdf7ffe5bb535b9cd61bcee6d95c48e6724ba50cccf2"

URI_x86_64_v2_uwsgi-router-xmldir = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-xmldir-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-xmldir;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-xmldir}"
SRC_URI[x86_64_v2_uwsgi-router-xmldir.sha256sum] = "827aa69881721c5d0abb6c84f6bdf58c84e04432734fd34a4c3ab147ca4013e1"

URI_x86_64_v2_uwsgi-stats-pusher-file = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-stats-pusher-file-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-stats-pusher-file;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-stats-pusher-file}"
SRC_URI[x86_64_v2_uwsgi-stats-pusher-file.sha256sum] = "24a2415c0a5df14e5747c369b5d632ed3e86196f60d764fe1182f878eda26e28"

URI_x86_64_v2_uwsgi-stats-pusher-socket = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-stats-pusher-socket-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-stats-pusher-socket;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-stats-pusher-socket}"
SRC_URI[x86_64_v2_uwsgi-stats-pusher-socket.sha256sum] = "4389a761ff2d23a5091bbc0e5250d1fb43765b14b8d373126b996d748bee02f0"

URI_x86_64_v2_uwsgi-stats-pusher-statsd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-stats-pusher-statsd-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-stats-pusher-statsd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-stats-pusher-statsd}"
SRC_URI[x86_64_v2_uwsgi-stats-pusher-statsd.sha256sum] = "0390f759fbd63a668d3deda1f18abe7274eb181c31596f9e1f772439d1d0e530"

URI_x86_64_v2_uwsgi-stats-pusher-zabbix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-stats-pusher-zabbix-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-stats-pusher-zabbix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-stats-pusher-zabbix}"
SRC_URI[x86_64_v2_uwsgi-stats-pusher-zabbix.sha256sum] = "1c678e560ecfd6e4f9b95b1ba645832ddbb03a9668f2ab16f8b1b92995338402"

URI_x86_64_v2_uwsgi-transformation-chunked = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-transformation-chunked-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-transformation-chunked;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-transformation-chunked}"
SRC_URI[x86_64_v2_uwsgi-transformation-chunked.sha256sum] = "451d340152bf97bc2b9119c16398e6e239326456e2efc85806c1bd2eb35c2cf3"

URI_x86_64_v2_uwsgi-transformation-gzip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-transformation-gzip-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-transformation-gzip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-transformation-gzip}"
SRC_URI[x86_64_v2_uwsgi-transformation-gzip.sha256sum] = "6759c1eba0e2777e96bcb47cf4d25642f45f6b2a0afb4b0166eebc20acb5c0fb"

URI_x86_64_v2_uwsgi-transformation-offload = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-transformation-offload-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-transformation-offload;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-transformation-offload}"
SRC_URI[x86_64_v2_uwsgi-transformation-offload.sha256sum] = "1c45156dd15beb1f658642d101217cbd55180206c7a53ee458357d6c2e29bd2c"

URI_x86_64_v2_uwsgi-transformation-template = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-transformation-template-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-transformation-template;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-transformation-template}"
SRC_URI[x86_64_v2_uwsgi-transformation-template.sha256sum] = "805db93d542a3cc1af8bdd8f3c82fcb538765bf65a10a08e0d5caaadb7b1854f"

URI_x86_64_v2_uwsgi-transformation-tofile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-transformation-tofile-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-transformation-tofile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-transformation-tofile}"
SRC_URI[x86_64_v2_uwsgi-transformation-tofile.sha256sum] = "ccf8c80ef86c0c2d0a2978eaea3e9e540d82d2204ad50088e74245573f6592de"

URI_x86_64_v2_uwsgi-transformation-toupper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-transformation-toupper-2.0.30-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-transformation-toupper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-transformation-toupper}"
SRC_URI[x86_64_v2_uwsgi-transformation-toupper.sha256sum] = "ba5ce69cd2c8829d98861104f8fff54d21029e6f9a66210751c7fac2d31fde78"

URI_aarch64_python3-uwsgidecorators = "${EPEL_MIRROR}/aarch64/Packages/p/python3-uwsgidecorators-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_python3-uwsgidecorators;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-uwsgidecorators}"
SRC_URI[aarch64_python3-uwsgidecorators.sha256sum] = "53189b3e75f3eec5fe940028a96bd506f66464900ef1a656a618bf15c7c43e9f"

URI_aarch64_python3.12-uwsgidecorators = "${EPEL_MIRROR}/aarch64/Packages/p/python3.12-uwsgidecorators-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_python3.12-uwsgidecorators;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.12-uwsgidecorators}"
SRC_URI[aarch64_python3.12-uwsgidecorators.sha256sum] = "bf98ff66514548109a98a0b046f12030671f1b1ade8bd34e8a988855a10cd01a"

URI_aarch64_uwsgi = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi}"
SRC_URI[aarch64_uwsgi.sha256sum] = "252fa7a94db2c1029e1fa99a8bbf3e6d51446cabb43dc4e39c1166bc88d4c7ba"

URI_aarch64_uwsgi-alarm-curl = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-alarm-curl-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-alarm-curl;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-alarm-curl}"
SRC_URI[aarch64_uwsgi-alarm-curl.sha256sum] = "79b54516bd8312c502dffc43eaa7813a90d69f8290a3c3e7362a6b0a852f101a"

URI_aarch64_uwsgi-devel = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-devel-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-devel}"
SRC_URI[aarch64_uwsgi-devel.sha256sum] = "3064de4908f2cf412752dc340c2af641d11b4784591af4c1c47526db2744df4c"

URI_aarch64_uwsgi-docs = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-docs-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-docs}"
SRC_URI[aarch64_uwsgi-docs.sha256sum] = "f05dc9f46b490053cb34a5155f7a016241e1c3e5217579c54bb849459e4d73d3"

URI_aarch64_uwsgi-emperor-amqp = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-emperor-amqp-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-emperor-amqp;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-emperor-amqp}"
SRC_URI[aarch64_uwsgi-emperor-amqp.sha256sum] = "711ca64ad1adf815b502b0c332f77a3a65b60221d6f93a55bf6927d252932ff1"

URI_aarch64_uwsgi-emperor-pg = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-emperor-pg-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-emperor-pg;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-emperor-pg}"
SRC_URI[aarch64_uwsgi-emperor-pg.sha256sum] = "833e7bee0b4264a6f7ae3827e24ce9cbb8bac99698e5a792fdf0a6910015dd47"

URI_aarch64_uwsgi-log-encoder-msgpack = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-log-encoder-msgpack-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-log-encoder-msgpack;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-log-encoder-msgpack}"
SRC_URI[aarch64_uwsgi-log-encoder-msgpack.sha256sum] = "a2849c9f8b1c3997abe6e9fed669b9b1a81dbb4b44e6b74dd33935e99fae2fea"

URI_aarch64_uwsgi-logger-crypto = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-logger-crypto-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-logger-crypto;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-logger-crypto}"
SRC_URI[aarch64_uwsgi-logger-crypto.sha256sum] = "0f09470a2e2a99544af5192fa0719551cce3a660c86d7d16926406c890e11cc6"

URI_aarch64_uwsgi-logger-file = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-logger-file-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-logger-file;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-logger-file}"
SRC_URI[aarch64_uwsgi-logger-file.sha256sum] = "7851ccce2d541c91d0dfafdf0da6cd8926c7b48d3bd9b4e46ba8aa804cbbd95b"

URI_aarch64_uwsgi-logger-graylog2 = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-logger-graylog2-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-logger-graylog2;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-logger-graylog2}"
SRC_URI[aarch64_uwsgi-logger-graylog2.sha256sum] = "637683d743479ba483c1efd314f8ae446fdfee36fcf0f0a6d8d5bbc3657b1403"

URI_aarch64_uwsgi-logger-pipe = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-logger-pipe-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-logger-pipe;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-logger-pipe}"
SRC_URI[aarch64_uwsgi-logger-pipe.sha256sum] = "ad5bf45087b15eb82d3eb6027892d801606dba8eab649c49502dfb95a4d6a050"

URI_aarch64_uwsgi-logger-redis = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-logger-redis-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-logger-redis;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-logger-redis}"
SRC_URI[aarch64_uwsgi-logger-redis.sha256sum] = "fc79c653f6aed71a89e4d91eabbda7a4097f8cb49e3d1b310b67eeb01c2f76b7"

URI_aarch64_uwsgi-logger-rsyslog = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-logger-rsyslog-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-logger-rsyslog;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-logger-rsyslog}"
SRC_URI[aarch64_uwsgi-logger-rsyslog.sha256sum] = "388a8686e52edd37fd81400e262ab096ce55f3751704365e7779639e07913dc0"

URI_aarch64_uwsgi-logger-socket = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-logger-socket-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-logger-socket;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-logger-socket}"
SRC_URI[aarch64_uwsgi-logger-socket.sha256sum] = "8ed32df79d7684cdcc7aa337bd6b539d4528e5e7d286b81a8b6c113a2e603761"

URI_aarch64_uwsgi-logger-syslog = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-logger-syslog-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-logger-syslog;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-logger-syslog}"
SRC_URI[aarch64_uwsgi-logger-syslog.sha256sum] = "e68c8cef12dc1605b24e88151059495be785ffc0345290144c606c6ee2d5d268"

URI_aarch64_uwsgi-logger-systemd = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-logger-systemd-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-logger-systemd;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-logger-systemd}"
SRC_URI[aarch64_uwsgi-logger-systemd.sha256sum] = "af4aacc6f6e2942af9ae78cebfd8fe9f6e8ed35c81146fd541f6cd96b78fa3e1"

URI_aarch64_uwsgi-plugin-airbrake = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-airbrake-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-airbrake;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-airbrake}"
SRC_URI[aarch64_uwsgi-plugin-airbrake.sha256sum] = "513baf8aec1fa7e52816aa2fdaf30db05160c00332084635ff3f6fa5d187225d"

URI_aarch64_uwsgi-plugin-cache = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-cache-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-cache;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-cache}"
SRC_URI[aarch64_uwsgi-plugin-cache.sha256sum] = "bb1573077b4765930758b29ce8f0d13097234600f4592f7d909cf97724d0282b"

URI_aarch64_uwsgi-plugin-carbon = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-carbon-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-carbon;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-carbon}"
SRC_URI[aarch64_uwsgi-plugin-carbon.sha256sum] = "d94616a61c05ab6f007126075ba871910a45f5ee832a52a89f25a8bc96377a23"

URI_aarch64_uwsgi-plugin-cheaper-busyness = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-cheaper-busyness-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-cheaper-busyness;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-cheaper-busyness}"
SRC_URI[aarch64_uwsgi-plugin-cheaper-busyness.sha256sum] = "83ba826373bf1f9f4bcab891b2473825713e3de4f94b5e9b105cbbf910057c8e"

URI_aarch64_uwsgi-plugin-common = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-common-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-common}"
SRC_URI[aarch64_uwsgi-plugin-common.sha256sum] = "f8acc2582c54aaf5fab1629b7ab68b466a99a07c4ff6ab9129f28f94db9d54c1"

URI_aarch64_uwsgi-plugin-cplusplus = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-cplusplus-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-cplusplus;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-cplusplus}"
SRC_URI[aarch64_uwsgi-plugin-cplusplus.sha256sum] = "f623188f5890c4722d88210723e13e06543b33d0523a30095ebd056210a03822"

URI_aarch64_uwsgi-plugin-curl-cron = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-curl-cron-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-curl-cron;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-curl-cron}"
SRC_URI[aarch64_uwsgi-plugin-curl-cron.sha256sum] = "b92ffe92678df88544088e8a11880ac1ed4cec52d30f00e2d793ad308fc9768f"

URI_aarch64_uwsgi-plugin-dumbloop = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-dumbloop-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-dumbloop;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-dumbloop}"
SRC_URI[aarch64_uwsgi-plugin-dumbloop.sha256sum] = "a43aeb758cd308b051ec70c1aa6c7e1bb61d06607e9c3e6a835e2fd3479daee7"

URI_aarch64_uwsgi-plugin-dummy = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-dummy-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-dummy;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-dummy}"
SRC_URI[aarch64_uwsgi-plugin-dummy.sha256sum] = "5675c6ce9cdd80dfefbc0f63fce28b91d9f60dd022d93ade61acec42cd6d4cb4"

URI_aarch64_uwsgi-plugin-fiber = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-fiber-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-fiber;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-fiber}"
SRC_URI[aarch64_uwsgi-plugin-fiber.sha256sum] = "27dd71f2be3529a7de82cfee99e0676a2242335913f5b75aa7b5e628c7e0c629"

URI_aarch64_uwsgi-plugin-ldap = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-ldap-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-ldap}"
SRC_URI[aarch64_uwsgi-plugin-ldap.sha256sum] = "e593d892f578e04ae6731488340ec711cb749928ef99f7fd38fbbbfa0c3354d8"

URI_aarch64_uwsgi-plugin-lua = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-lua-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-lua;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-lua}"
SRC_URI[aarch64_uwsgi-plugin-lua.sha256sum] = "7ed443fb5c0ab2a54f0e54bf9cd2b6090a18349f8a739248bf9aa135e6df0202"

URI_aarch64_uwsgi-plugin-nagios = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-nagios-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-nagios;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-nagios}"
SRC_URI[aarch64_uwsgi-plugin-nagios.sha256sum] = "0e76bf7bec2d04b26347629578fea00ed1cb310477c129a99c0733906f316013"

URI_aarch64_uwsgi-plugin-notfound = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-notfound-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-notfound;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-notfound}"
SRC_URI[aarch64_uwsgi-plugin-notfound.sha256sum] = "54bf70d3fe7337cd01f72c33b1554dd7b1d12bf67cfd5af8c0ba50098cc2135d"

URI_aarch64_uwsgi-plugin-pam = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-pam-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-pam;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-pam}"
SRC_URI[aarch64_uwsgi-plugin-pam.sha256sum] = "c5efb31a434f6e9efceb58bfe31d254f21712dec5f978e33525925c84af2a366"

URI_aarch64_uwsgi-plugin-php = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-php-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-php;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-php}"
SRC_URI[aarch64_uwsgi-plugin-php.sha256sum] = "07d0126430a1bb1a92bd5b42b8e69e8c80b380bc8dabeb2e8692e5a28962f9f0"

URI_aarch64_uwsgi-plugin-psgi = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-psgi-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-psgi;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-psgi}"
SRC_URI[aarch64_uwsgi-plugin-psgi.sha256sum] = "6dc4fe4cda43e7d39d3223aeb9cdbc92bd37384a84405b527a219ec55bc0bd2a"

URI_aarch64_uwsgi-plugin-pty = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-pty-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-pty;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-pty}"
SRC_URI[aarch64_uwsgi-plugin-pty.sha256sum] = "5558837f0d77d85c33d8451918f8ff784de200bd4b79e6e2923d8d5e642e0ce8"

URI_aarch64_uwsgi-plugin-python3 = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-python3-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-python3;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-python3}"
SRC_URI[aarch64_uwsgi-plugin-python3.sha256sum] = "531840de4abc83393aafa0ebc05b64848b2721176f66788751362c8be86c635b"

URI_aarch64_uwsgi-plugin-python3-gevent = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-python3-gevent-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-python3-gevent;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-python3-gevent}"
SRC_URI[aarch64_uwsgi-plugin-python3-gevent.sha256sum] = "75cd4d434572c425a11cc78efbdb35e1c058748dabe12658ba7c1eda74eeeacf"

URI_aarch64_uwsgi-plugin-python3-tornado = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-python3-tornado-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-python3-tornado;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-python3-tornado}"
SRC_URI[aarch64_uwsgi-plugin-python3-tornado.sha256sum] = "4ec87324e1c487ab6455ec8310d5af190a9d0dbb359f5fffb306840362d08f53"

URI_aarch64_uwsgi-plugin-python312 = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-python312-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-python312;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-python312}"
SRC_URI[aarch64_uwsgi-plugin-python312.sha256sum] = "55f1574c91f26e262a7d1172aaa9b815771d21ce21f7f3609a55baf13a318d4b"

URI_aarch64_uwsgi-plugin-python312-gevent = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-python312-gevent-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-python312-gevent;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-python312-gevent}"
SRC_URI[aarch64_uwsgi-plugin-python312-gevent.sha256sum] = "0fbbf6a73a5763f8a7acb3ac7cc37557224933a7a9bc296cc7ef4d3d87043736"

URI_aarch64_uwsgi-plugin-rack = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-rack-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-rack;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-rack}"
SRC_URI[aarch64_uwsgi-plugin-rack.sha256sum] = "b950229e40f2b30eb5d2fb883f031adfeded4e96fcf1c18a2cb994d98649a121"

URI_aarch64_uwsgi-plugin-rbthreads = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-rbthreads-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-rbthreads;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-rbthreads}"
SRC_URI[aarch64_uwsgi-plugin-rbthreads.sha256sum] = "36ea735eda57ebe183d10b908a830fa6b53a7e78b5335ee0be8d0283c6da730c"

URI_aarch64_uwsgi-plugin-rpc = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-rpc-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-rpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-rpc}"
SRC_URI[aarch64_uwsgi-plugin-rpc.sha256sum] = "a0c4c1c54dc6f698d109195105c684b9e4f47223bc7eb477e94fed4023f3f285"

URI_aarch64_uwsgi-plugin-rrdtool = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-rrdtool-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-rrdtool;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-rrdtool}"
SRC_URI[aarch64_uwsgi-plugin-rrdtool.sha256sum] = "b8b00d5ff58c171405d1bcf48238ebc88b270da5430604989385ce75dbcd1d0a"

URI_aarch64_uwsgi-plugin-ruby = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-ruby-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-ruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-ruby}"
SRC_URI[aarch64_uwsgi-plugin-ruby.sha256sum] = "afd97c0f7c5e503b12bf23f6f617be6cfa16ae3280d5d2f7455d1e729bf71e45"

URI_aarch64_uwsgi-plugin-spooler = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-spooler-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-spooler;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-spooler}"
SRC_URI[aarch64_uwsgi-plugin-spooler.sha256sum] = "b331c28a19697682c4e815b11c707e621b0950ad6d1abdc4d2a41edf40e97e4a"

URI_aarch64_uwsgi-plugin-sqlite3 = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-sqlite3-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-sqlite3;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-sqlite3}"
SRC_URI[aarch64_uwsgi-plugin-sqlite3.sha256sum] = "5f2ef359d70e0027523e01d39ced515d17b6066bae5510fe1db8b14ebd16da34"

URI_aarch64_uwsgi-plugin-ssi = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-ssi-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-ssi;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-ssi}"
SRC_URI[aarch64_uwsgi-plugin-ssi.sha256sum] = "e1bd72c53806af13e7585a288aa69ddfe7a5d027184edcb271cd39e642b33a26"

URI_aarch64_uwsgi-plugin-ugreen = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-ugreen-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-ugreen;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-ugreen}"
SRC_URI[aarch64_uwsgi-plugin-ugreen.sha256sum] = "1887f557e47c50e31ef5a68b9e8df50c3de25b24f19b30db74149a94aa9f14c0"

URI_aarch64_uwsgi-plugin-webdav = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-webdav-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-webdav;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-webdav}"
SRC_URI[aarch64_uwsgi-plugin-webdav.sha256sum] = "5012a15be8ea4e6304822f637d81137ab757e55ef467bf61dcc728d6836f8830"

URI_aarch64_uwsgi-plugin-xattr = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-xattr-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-xattr;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-xattr}"
SRC_URI[aarch64_uwsgi-plugin-xattr.sha256sum] = "cb6689cbea54b97360952782b4a72bb112482b6a2b449af00f599b846c3055dc"

URI_aarch64_uwsgi-plugin-xslt = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-xslt-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-xslt;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-xslt}"
SRC_URI[aarch64_uwsgi-plugin-xslt.sha256sum] = "388b20de487f2eaf0d0cf1ea00405ca7bcd52923fdebfcd705f444328bf01a80"

URI_aarch64_uwsgi-plugin-zergpool = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-zergpool-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-plugin-zergpool;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-zergpool}"
SRC_URI[aarch64_uwsgi-plugin-zergpool.sha256sum] = "347ba9fb29aa8445611d6c077e13a8fcc62ee1ea8fd66e3caddcc85b42443291"

URI_aarch64_uwsgi-router-basicauth = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-basicauth-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-router-basicauth;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-basicauth}"
SRC_URI[aarch64_uwsgi-router-basicauth.sha256sum] = "5d2abf28cce7077fdbd9630317674983e090650f0e43a3efeeca465588eb5aca"

URI_aarch64_uwsgi-router-cache = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-cache-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-router-cache;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-cache}"
SRC_URI[aarch64_uwsgi-router-cache.sha256sum] = "685cff4a6ce2163590e6d4c9582382a57c2d3c8e2d70b51534bb1e6e9180f261"

URI_aarch64_uwsgi-router-expires = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-expires-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-router-expires;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-expires}"
SRC_URI[aarch64_uwsgi-router-expires.sha256sum] = "a9d59314016bc97fe12ec690c2a825b40462347ddb72cbb085ff521adda3000a"

URI_aarch64_uwsgi-router-fast = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-fast-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-router-fast;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-fast}"
SRC_URI[aarch64_uwsgi-router-fast.sha256sum] = "3ae41b95ec08ad5a5cc8782923fdaca38bf3e3364aa02042afa84679c9e41462"

URI_aarch64_uwsgi-router-forkpty = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-forkpty-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-router-forkpty;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-forkpty}"
SRC_URI[aarch64_uwsgi-router-forkpty.sha256sum] = "73c1d8ba546e509a46c40caa67e09c777380fe2276ce824acc4ab33d82a3dabd"

URI_aarch64_uwsgi-router-hash = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-hash-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-router-hash;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-hash}"
SRC_URI[aarch64_uwsgi-router-hash.sha256sum] = "c92f43569a973b8253fcb6bdc0748ac3a7905063b3c2ffeefdf493ba93bbf9a6"

URI_aarch64_uwsgi-router-http = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-http-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-router-http;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-http}"
SRC_URI[aarch64_uwsgi-router-http.sha256sum] = "6c6b7105b2fe348bf9b61b1a8151ff8e6ba2c3fc40de51816b300f64038648af"

URI_aarch64_uwsgi-router-memcached = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-memcached-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-router-memcached;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-memcached}"
SRC_URI[aarch64_uwsgi-router-memcached.sha256sum] = "61abbb33ee7e31d708a00962b312a6d0b67f8e625e6d8d5c0a90a13adeb4357d"

URI_aarch64_uwsgi-router-metrics = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-metrics-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-router-metrics;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-metrics}"
SRC_URI[aarch64_uwsgi-router-metrics.sha256sum] = "656ad645944184012d646a8a61a347647dd6f29e922786617ed0ccc406f12352"

URI_aarch64_uwsgi-router-radius = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-radius-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-router-radius;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-radius}"
SRC_URI[aarch64_uwsgi-router-radius.sha256sum] = "b7539b10bc88747b60a0f3754885564f2a7b85f684ca0ef5002f04e0a6833cfc"

URI_aarch64_uwsgi-router-raw = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-raw-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-router-raw;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-raw}"
SRC_URI[aarch64_uwsgi-router-raw.sha256sum] = "7aca472f42593c96f6a314b530ea5ffd18e4ca3d0c7616d3cad8e6bc6a374bf6"

URI_aarch64_uwsgi-router-redirect = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-redirect-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-router-redirect;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-redirect}"
SRC_URI[aarch64_uwsgi-router-redirect.sha256sum] = "af5d82905fa76ace007ddb6aa114e939d54a08938a9d2dce94354803a7aa3fc8"

URI_aarch64_uwsgi-router-redis = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-redis-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-router-redis;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-redis}"
SRC_URI[aarch64_uwsgi-router-redis.sha256sum] = "1614d6cc0542942f285fa982484857e8a480ed0174247f7a2784798100c364af"

URI_aarch64_uwsgi-router-rewrite = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-rewrite-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-router-rewrite;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-rewrite}"
SRC_URI[aarch64_uwsgi-router-rewrite.sha256sum] = "b3863698744a7777171ac90fa679e1549b1f419725dbaf61e67e437d9e219a2f"

URI_aarch64_uwsgi-router-spnego = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-spnego-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-router-spnego;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-spnego}"
SRC_URI[aarch64_uwsgi-router-spnego.sha256sum] = "b36cdb9f678e37828e7c1b40fb8deafb27498bc08991d8dfa71fad87c5db5f40"

URI_aarch64_uwsgi-router-ssl = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-ssl-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-router-ssl;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-ssl}"
SRC_URI[aarch64_uwsgi-router-ssl.sha256sum] = "a45fe960a7bb9769b6a7a70a1c2c37ffc5a92720319f056d50aede7c94f83b16"

URI_aarch64_uwsgi-router-static = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-static-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-router-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-static}"
SRC_URI[aarch64_uwsgi-router-static.sha256sum] = "e2f98f9cee1f4eee9924c9ea2d4bd083dafacb84f7c829c8176f405961d02551"

URI_aarch64_uwsgi-router-tuntap = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-tuntap-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-router-tuntap;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-tuntap}"
SRC_URI[aarch64_uwsgi-router-tuntap.sha256sum] = "234f27b084857bef6461333c859d5d1f5f4fdd5141a865cc20515d7986b5316c"

URI_aarch64_uwsgi-router-uwsgi = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-uwsgi-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-router-uwsgi;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-uwsgi}"
SRC_URI[aarch64_uwsgi-router-uwsgi.sha256sum] = "37abe4665c81ed022128f9c84f7f861cf4d42e1214fc8acbd37710dbc058e0a0"

URI_aarch64_uwsgi-router-xmldir = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-xmldir-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-router-xmldir;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-xmldir}"
SRC_URI[aarch64_uwsgi-router-xmldir.sha256sum] = "6ba1a1be613f2036389d4d42620ddc65b62b29cd0991cb3012cf0a027d6f2455"

URI_aarch64_uwsgi-stats-pusher-file = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-stats-pusher-file-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-stats-pusher-file;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-stats-pusher-file}"
SRC_URI[aarch64_uwsgi-stats-pusher-file.sha256sum] = "f59e3a761af2ae3adeecd05528c2b6cc4c2801717f93fe1f9868842ff6cebebf"

URI_aarch64_uwsgi-stats-pusher-socket = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-stats-pusher-socket-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-stats-pusher-socket;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-stats-pusher-socket}"
SRC_URI[aarch64_uwsgi-stats-pusher-socket.sha256sum] = "d9fed6fa6dedca0b726618d2384e257dda1983a5326aeaa7284ff7a5a28ddf16"

URI_aarch64_uwsgi-stats-pusher-statsd = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-stats-pusher-statsd-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-stats-pusher-statsd;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-stats-pusher-statsd}"
SRC_URI[aarch64_uwsgi-stats-pusher-statsd.sha256sum] = "53974601bf8a37a9f495def63eb547e13b84493f2ab8345397a7ecd4bd9ecabd"

URI_aarch64_uwsgi-stats-pusher-zabbix = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-stats-pusher-zabbix-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-stats-pusher-zabbix;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-stats-pusher-zabbix}"
SRC_URI[aarch64_uwsgi-stats-pusher-zabbix.sha256sum] = "a3f241a5ff46b18858fb9a8b48c1218dae8f065ee4be1fa52b3af44fdda4bd8f"

URI_aarch64_uwsgi-transformation-chunked = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-transformation-chunked-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-transformation-chunked;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-transformation-chunked}"
SRC_URI[aarch64_uwsgi-transformation-chunked.sha256sum] = "816ed5bf0af5dca0fbaa3e319d3374d682562e5692d7f48eea2ecce010400d8a"

URI_aarch64_uwsgi-transformation-gzip = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-transformation-gzip-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-transformation-gzip;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-transformation-gzip}"
SRC_URI[aarch64_uwsgi-transformation-gzip.sha256sum] = "b603c22201a82e7a394570e0d058f1d93a21fbbd51b7d2d7c8dbbfbaa89712c9"

URI_aarch64_uwsgi-transformation-offload = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-transformation-offload-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-transformation-offload;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-transformation-offload}"
SRC_URI[aarch64_uwsgi-transformation-offload.sha256sum] = "bccc543b98a704654a0913581b4c0af6ff017bb767716e4a5d874a9b72669a03"

URI_aarch64_uwsgi-transformation-template = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-transformation-template-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-transformation-template;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-transformation-template}"
SRC_URI[aarch64_uwsgi-transformation-template.sha256sum] = "93bd1df956669b14dee1266f4ab9bc0790937c86fc4827c1319b69c80c27698e"

URI_aarch64_uwsgi-transformation-tofile = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-transformation-tofile-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-transformation-tofile;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-transformation-tofile}"
SRC_URI[aarch64_uwsgi-transformation-tofile.sha256sum] = "c6621eac8297dbf8a629aed684aca5cf09d362850e0007180eed2f2e2c8b38fe"

URI_aarch64_uwsgi-transformation-toupper = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-transformation-toupper-2.0.30-1.el10_1.aarch64.rpm;name=aarch64_uwsgi-transformation-toupper;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-transformation-toupper}"
SRC_URI[aarch64_uwsgi-transformation-toupper.sha256sum] = "88e7b9ad43822c3a88b0c56a85ef7ca45a523a4d1231355b33a01db781b45235"

RDEPENDS:python3-uwsgidecorators = " \
 python3 \
 uwsgi \
 uwsgi-plugin-python3 \
 "
RDEPENDS:python3.12-uwsgidecorators = " \
 python3 \
 uwsgi \
 uwsgi-plugin-python312 \
 "
RDEPENDS:uwsgi:x86_64_v2 = " \
 bash \
 glibc \
 jansson \
 libcap \
 libuuid \
 libxml2 \
 libyaml \
 openssl-libs \
 pcre2 \
 systemd \
 zlib-ng-compat \
"
RDEPENDS:uwsgi:aarch64 = " \
 bash \
 glibc \
 jansson \
 libuuid \
 libxml2 \
 libyaml \
 openssl-libs \
 pcre2 \
 systemd \
 zlib-ng-compat \
"
RDEPENDS:uwsgi-alarm-curl = " \
 glibc \
 uwsgi-plugin-common \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:uwsgi-devel = " \
 uwsgi \
 "
RDEPENDS:uwsgi-docs = " \
 uwsgi \
 "
RDEPENDS:uwsgi-emperor-amqp = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-emperor-pg = " \
 glibc \
 libpq \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-log-encoder-msgpack = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-logger-crypto = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-logger-file = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-logger-graylog2 = " \
 glibc \
 uwsgi-plugin-common \
 zlib-ng-compat \
 "
RDEPENDS:uwsgi-logger-pipe = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-logger-redis = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-logger-rsyslog = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-logger-socket = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-logger-syslog = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-logger-systemd = " \
 glibc \
 systemd-libs \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-airbrake = " \
 glibc \
 libxml2 \
 uwsgi-plugin-common \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:uwsgi-plugin-cache = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-carbon = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-cheaper-busyness = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-common = " \
 glibc \
 uwsgi \
 "
RDEPENDS:uwsgi-plugin-cplusplus = " \
 glibc \
 libstdc++ \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-curl-cron = " \
 glibc \
 uwsgi-plugin-common \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:uwsgi-plugin-dumbloop = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-dummy = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-fiber = " \
 glibc \
 uwsgi-plugin-common \
 uwsgi-plugin-rack \
 "
RDEPENDS:uwsgi-plugin-ldap = " \
 glibc \
 openldap \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-lua = " \
 glibc \
 lua-libs \
 uwsgi-plugin-common \
 virtual/lua \
 "
RDEPENDS:uwsgi-plugin-nagios = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-notfound = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-pam = " \
 glibc \
 pam \
 pam-libs \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-php = " \
 glibc \
 php-embedded \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-psgi = " \
 glibc \
 perl-libs \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-pty = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-python3 = " \
 glibc \
 python3 \
 python3-libs \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-python3-gevent = " \
 glibc \
 uwsgi-plugin-python3 \
 "
RDEPENDS:uwsgi-plugin-python3-tornado = " \
 glibc \
 python3-tornado \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-python312 = " \
 glibc \
 python3 \
 python3-libs \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-python312-gevent = " \
 glibc \
 libevent \
 uwsgi-plugin-python312 \
 "
RDEPENDS:uwsgi-plugin-rack = " \
 glibc \
 ruby-libs \
 rubygem-rack \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-rbthreads = " \
 glibc \
 ruby \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-rpc = " \
 glibc \
 rrdtool \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-rrdtool = " \
 glibc \
 rrdtool \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-ruby = " \
 glibc \
 ruby \
 ruby-libs \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-spooler = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-sqlite3 = " \
 glibc \
 sqlite \
 sqlite-libs \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-ssi = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-ugreen = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-webdav = " \
 glibc \
 libxml2 \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-xattr = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-xslt = " \
 glibc \
 libxml2 \
 libxslt \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-zergpool = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-basicauth = " \
 glibc \
 libxcrypt \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-cache = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-expires = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-fast = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-forkpty = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-hash = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-http = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-memcached = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-metrics = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-radius = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-raw = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-redirect = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-redis = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-rewrite = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-spnego = " \
 glibc \
 krb5-libs \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-ssl = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-static = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-tuntap = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-uwsgi = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-xmldir = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-stats-pusher-file = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-stats-pusher-socket = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-stats-pusher-statsd = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-stats-pusher-zabbix = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-transformation-chunked = " \
 glibc \
 uwsgi-plugin-common \
 uwsgi-router-uwsgi \
 "
RDEPENDS:uwsgi-transformation-gzip = " \
 glibc \
 uwsgi-plugin-common \
 uwsgi-router-uwsgi \
 "
RDEPENDS:uwsgi-transformation-offload = " \
 glibc \
 uwsgi-plugin-common \
 uwsgi-router-uwsgi \
 "
RDEPENDS:uwsgi-transformation-template = " \
 glibc \
 uwsgi-plugin-common \
 uwsgi-router-uwsgi \
 "
RDEPENDS:uwsgi-transformation-tofile = " \
 glibc \
 uwsgi-plugin-common \
 uwsgi-router-uwsgi \
 "
RDEPENDS:uwsgi-transformation-toupper = " \
 glibc \
 uwsgi-plugin-common \
 "
