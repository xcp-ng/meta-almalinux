# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "freeipmi"
PV = "1.6.14"
PR = "4.el10"
PACKAGES = " \
 freeipmi \
 freeipmi-bmc-watchdog \
 freeipmi-devel \
 freeipmi-ipmidetectd \
 freeipmi-ipmiseld \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/freeipmi-1.6.14-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7522a0e502ca08fa9201f4bf77b6848eea1b5b2aa285f63d0ac950ebb9b1e40f"

URI_x86_64_v2_freeipmi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeipmi-1.6.14-4.el10.x86_64_v2.rpm;name=x86_64_v2_freeipmi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeipmi}"
SRC_URI[x86_64_v2_freeipmi.sha256sum] = "31f83d820f2a0b23f12687a77c5e2671f8e9de2b1e316542f85fb3db00336827"

URI_x86_64_v2_freeipmi-bmc-watchdog = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeipmi-bmc-watchdog-1.6.14-4.el10.x86_64_v2.rpm;name=x86_64_v2_freeipmi-bmc-watchdog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeipmi-bmc-watchdog}"
SRC_URI[x86_64_v2_freeipmi-bmc-watchdog.sha256sum] = "68a65a8203ac669dcf3d70ad9a0df707a762803a3b48f4ebedcd485600bfa157"

URI_x86_64_v2_freeipmi-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/freeipmi-devel-1.6.14-4.el10.x86_64_v2.rpm;name=x86_64_v2_freeipmi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeipmi-devel}"
SRC_URI[x86_64_v2_freeipmi-devel.sha256sum] = "f9080e5269914240dde404e51b5f24b1789828383b157eeba76475bf85375cba"

URI_x86_64_v2_freeipmi-ipmidetectd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeipmi-ipmidetectd-1.6.14-4.el10.x86_64_v2.rpm;name=x86_64_v2_freeipmi-ipmidetectd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeipmi-ipmidetectd}"
SRC_URI[x86_64_v2_freeipmi-ipmidetectd.sha256sum] = "3661044ab9859b5496971df101aad8ce3882e7689e4b58873680350ffc6fc317"

URI_x86_64_v2_freeipmi-ipmiseld = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeipmi-ipmiseld-1.6.14-4.el10.x86_64_v2.rpm;name=x86_64_v2_freeipmi-ipmiseld;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeipmi-ipmiseld}"
SRC_URI[x86_64_v2_freeipmi-ipmiseld.sha256sum] = "9018af1eeed3e4d50a865df050aa8dd09c4b141745e50e1ac9e0774e0b24ee68"

URI_aarch64_freeipmi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeipmi-1.6.14-4.el10.aarch64.rpm;name=aarch64_freeipmi;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeipmi}"
SRC_URI[aarch64_freeipmi.sha256sum] = "42dc550cab7362778b5452a0a2f9f1c21856c526bd6642f43aa198fe8590ad06"

URI_aarch64_freeipmi-bmc-watchdog = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeipmi-bmc-watchdog-1.6.14-4.el10.aarch64.rpm;name=aarch64_freeipmi-bmc-watchdog;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeipmi-bmc-watchdog}"
SRC_URI[aarch64_freeipmi-bmc-watchdog.sha256sum] = "af2ac7d31d1bd573b92adb4711637abc953fa502b604e06c414a815efb804cd6"

URI_aarch64_freeipmi-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/freeipmi-devel-1.6.14-4.el10.aarch64.rpm;name=aarch64_freeipmi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeipmi-devel}"
SRC_URI[aarch64_freeipmi-devel.sha256sum] = "1dde1e731c0f413153fcab62e3368400f1d053e1469c49ac1d9c9963cc1451ff"

URI_aarch64_freeipmi-ipmidetectd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeipmi-ipmidetectd-1.6.14-4.el10.aarch64.rpm;name=aarch64_freeipmi-ipmidetectd;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeipmi-ipmidetectd}"
SRC_URI[aarch64_freeipmi-ipmidetectd.sha256sum] = "72d21877851109fd0f2e5ceef21a4eb2f37c9694964e89d64ba366a084f9520f"

URI_aarch64_freeipmi-ipmiseld = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeipmi-ipmiseld-1.6.14-4.el10.aarch64.rpm;name=aarch64_freeipmi-ipmiseld;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeipmi-ipmiseld}"
SRC_URI[aarch64_freeipmi-ipmiseld.sha256sum] = "ce9580810d95dea95a636c5ef6a3d9e36177e5ef819f882435fe07b7e29f4a3d"

RDEPENDS:freeipmi = " \
 bash \
 glibc \
 libgcrypt \
 systemd \
 "
RDEPENDS:freeipmi-bmc-watchdog = " \
 bash \
 freeipmi \
 glibc \
 "
RDEPENDS:freeipmi-devel = " \
 freeipmi \
 pkgconf-pkg-config \
 "
RDEPENDS:freeipmi-ipmidetectd = " \
 bash \
 freeipmi \
 glibc \
 "
RDEPENDS:freeipmi-ipmiseld = " \
 bash \
 freeipmi \
 glibc \
 "
