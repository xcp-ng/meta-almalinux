# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-sys"
PV = "0.31.11"
PR = "1.el10_3"
PACKAGES = " \
 rust-wayland-sys+client-devel \
 rust-wayland-sys+cursor-devel \
 rust-wayland-sys+default-devel \
 rust-wayland-sys+dlopen-devel \
 rust-wayland-sys+egl-devel \
 rust-wayland-sys+libc-devel \
 rust-wayland-sys+libwayland_client_1_23-devel \
 rust-wayland-sys+libwayland_server_1_22-devel \
 rust-wayland-sys+libwayland_server_1_23-devel \
 rust-wayland-sys+memoffset-devel \
 rust-wayland-sys+once_cell-devel \
 rust-wayland-sys+server-devel \
 rust-wayland-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-sys-0.31.11-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b03c656cd75d0fc331ea382d52e77545986e63062184255cc14f1fd1eee45b9"

URI_x86_64_v2_rust-wayland-sys+client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+client-devel-0.31.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+client-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+client-devel.sha256sum] = "4b5a40612ecaa9e2f5f76138dea569b113402237a538c59f0c74a7e87cffbca2"

URI_x86_64_v2_rust-wayland-sys+cursor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+cursor-devel-0.31.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+cursor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+cursor-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+cursor-devel.sha256sum] = "51eb80d72649ace287dbec038fabb962f513c1b264f65e81281b903da7f9914c"

URI_x86_64_v2_rust-wayland-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+default-devel-0.31.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+default-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+default-devel.sha256sum] = "3fb0fa4387a26710bb81c0f0543921208bc82177528cfedd71d0652346b16983"

URI_x86_64_v2_rust-wayland-sys+dlopen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+dlopen-devel-0.31.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+dlopen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+dlopen-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+dlopen-devel.sha256sum] = "c55d79e0d7c89d532b75c888cc0887d74c5636dd674f9c26ec6ed9fb2d3bde78"

URI_x86_64_v2_rust-wayland-sys+egl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+egl-devel-0.31.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+egl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+egl-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+egl-devel.sha256sum] = "a600467a6092d013e6b95be6ed315fb422d2d90f2108e5abd59074e0c8263e2a"

URI_x86_64_v2_rust-wayland-sys+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+libc-devel-0.31.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+libc-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+libc-devel.sha256sum] = "fb585041fd1a06138b0a9ad1493bcc7e982fb2a2696b141a2422e23943e19e19"

URI_x86_64_v2_rust-wayland-sys+libwayland_client_1_23-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+libwayland_client_1_23-devel-0.31.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+libwayland_client_1_23-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+libwayland_client_1_23-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+libwayland_client_1_23-devel.sha256sum] = "02f18a2b2c686a65ecc7ba8ffb14f80ca6290a0d838a44ab8192019c0b4a402e"

URI_x86_64_v2_rust-wayland-sys+libwayland_server_1_22-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+libwayland_server_1_22-devel-0.31.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+libwayland_server_1_22-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+libwayland_server_1_22-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+libwayland_server_1_22-devel.sha256sum] = "4dfff23336f6791cb9354db7640fa4389677b6f52fd350016468ab3706b0bf39"

URI_x86_64_v2_rust-wayland-sys+libwayland_server_1_23-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+libwayland_server_1_23-devel-0.31.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+libwayland_server_1_23-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+libwayland_server_1_23-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+libwayland_server_1_23-devel.sha256sum] = "a26f6010f67e13cf55f9db9ba0ccc163643471f29cad75dbb45a5f802faf719a"

URI_x86_64_v2_rust-wayland-sys+memoffset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+memoffset-devel-0.31.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+memoffset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+memoffset-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+memoffset-devel.sha256sum] = "e310ea20dbf66b48d7c1f12e6cbc51c3824bc2ee24d2174e7fe786c36ecb6363"

URI_x86_64_v2_rust-wayland-sys+once_cell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+once_cell-devel-0.31.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+once_cell-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+once_cell-devel.sha256sum] = "64d00427ea6e20fb34d7691b1dba42b0429f8b7b1670190db534517692591a13"

URI_x86_64_v2_rust-wayland-sys+server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+server-devel-0.31.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+server-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+server-devel.sha256sum] = "4cb98ddab91a8cd392d1a918160baea970baeec2cd3e1fa4e1a8914fa1ece76b"

URI_x86_64_v2_rust-wayland-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys-devel-0.31.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys-devel.sha256sum] = "f537f02d29776e8715b74975ea71221c58efcde921f08f4ffb1ad20c1dd05b49"

URI_aarch64_rust-wayland-sys+client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+client-devel-0.31.11-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-sys+client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+client-devel}"
SRC_URI[aarch64_rust-wayland-sys+client-devel.sha256sum] = "c0fdfa0d16cef3997d588b9cabd4ab4c1a0bf8f6eef9dc9396ad47b54efd0d78"

URI_aarch64_rust-wayland-sys+cursor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+cursor-devel-0.31.11-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-sys+cursor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+cursor-devel}"
SRC_URI[aarch64_rust-wayland-sys+cursor-devel.sha256sum] = "1a67489c893b223288be5ef606a26bb5e5afb4cde57b4f51a2b7ed81f336eb02"

URI_aarch64_rust-wayland-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+default-devel-0.31.11-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+default-devel}"
SRC_URI[aarch64_rust-wayland-sys+default-devel.sha256sum] = "3b25e2c30db3e57e009303632a3c5e75f35b12d7650644e4fb06ef5631d4fcc1"

URI_aarch64_rust-wayland-sys+dlopen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+dlopen-devel-0.31.11-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-sys+dlopen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+dlopen-devel}"
SRC_URI[aarch64_rust-wayland-sys+dlopen-devel.sha256sum] = "95d49564c2025b203834ceed1e2f8b61f54f4e395df9d840d1c866827de99723"

URI_aarch64_rust-wayland-sys+egl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+egl-devel-0.31.11-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-sys+egl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+egl-devel}"
SRC_URI[aarch64_rust-wayland-sys+egl-devel.sha256sum] = "89badcaf9b93ed5c4aa8c3fffa29348d568b375bf82c57ee08e00a6a53329e13"

URI_aarch64_rust-wayland-sys+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+libc-devel-0.31.11-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-sys+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+libc-devel}"
SRC_URI[aarch64_rust-wayland-sys+libc-devel.sha256sum] = "b681c514f0b08ae0b6007880a80deb5fad703de2d3be03076d393d1624184d46"

URI_aarch64_rust-wayland-sys+libwayland_client_1_23-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+libwayland_client_1_23-devel-0.31.11-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-sys+libwayland_client_1_23-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+libwayland_client_1_23-devel}"
SRC_URI[aarch64_rust-wayland-sys+libwayland_client_1_23-devel.sha256sum] = "296f7332cd78cea780d6b1d37cdb75bfaf66bc5f7ea031c62c09a0f58fd95929"

URI_aarch64_rust-wayland-sys+libwayland_server_1_22-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+libwayland_server_1_22-devel-0.31.11-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-sys+libwayland_server_1_22-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+libwayland_server_1_22-devel}"
SRC_URI[aarch64_rust-wayland-sys+libwayland_server_1_22-devel.sha256sum] = "d472fca07a7e500060d11a76c175ce0a33c2938489205c6048a69c22aa46c687"

URI_aarch64_rust-wayland-sys+libwayland_server_1_23-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+libwayland_server_1_23-devel-0.31.11-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-sys+libwayland_server_1_23-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+libwayland_server_1_23-devel}"
SRC_URI[aarch64_rust-wayland-sys+libwayland_server_1_23-devel.sha256sum] = "f5bd06e21de7aedcea96cf5e6c90a9f01031e4a4241b915205af520a273de448"

URI_aarch64_rust-wayland-sys+memoffset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+memoffset-devel-0.31.11-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-sys+memoffset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+memoffset-devel}"
SRC_URI[aarch64_rust-wayland-sys+memoffset-devel.sha256sum] = "3c0170731f8e3017fa757a33a4ce54257304cad9c9ab0b453638c2fcd45f56c7"

URI_aarch64_rust-wayland-sys+once_cell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+once_cell-devel-0.31.11-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-sys+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+once_cell-devel}"
SRC_URI[aarch64_rust-wayland-sys+once_cell-devel.sha256sum] = "2fc48abd37cc0b9184cab8ff6e6f36a489bc0ae2e964f44dc84f188e239a4ce7"

URI_aarch64_rust-wayland-sys+server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+server-devel-0.31.11-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-sys+server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+server-devel}"
SRC_URI[aarch64_rust-wayland-sys+server-devel.sha256sum] = "a02e8c0b349ba655eece8d752094098209734bbc78bf86354a440bf8ebb0b752"

URI_aarch64_rust-wayland-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys-devel-0.31.11-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys-devel}"
SRC_URI[aarch64_rust-wayland-sys-devel.sha256sum] = "4f5e7c84ba3d9785d5cea589e25def1f94651ae75af8e0c5fd8612bf55484f4b"

RDEPENDS:rust-wayland-sys+client-devel = " \
 cargo \
 rust-dlib+default-devel \
 rust-log+default-devel \
 rust-wayland-sys-devel \
 wayland-devel \
 "
RDEPENDS:rust-wayland-sys+cursor-devel = " \
 cargo \
 rust-wayland-sys+client-devel \
 rust-wayland-sys-devel \
 wayland-devel \
 "
RDEPENDS:rust-wayland-sys+default-devel = " \
 cargo \
 rust-wayland-sys-devel \
 "
RDEPENDS:rust-wayland-sys+dlopen-devel = " \
 cargo \
 rust-wayland-sys+once_cell-devel \
 rust-wayland-sys-devel \
 "
RDEPENDS:rust-wayland-sys+egl-devel = " \
 cargo \
 rust-wayland-sys+client-devel \
 rust-wayland-sys-devel \
 wayland-devel \
 "
RDEPENDS:rust-wayland-sys+libc-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-wayland-sys-devel \
 "
RDEPENDS:rust-wayland-sys+libwayland_client_1_23-devel = " \
 cargo \
 rust-wayland-sys-devel \
 "
RDEPENDS:rust-wayland-sys+libwayland_server_1_22-devel = " \
 cargo \
 rust-wayland-sys-devel \
 "
RDEPENDS:rust-wayland-sys+libwayland_server_1_23-devel = " \
 cargo \
 rust-wayland-sys+libwayland_server_1_22-devel \
 rust-wayland-sys-devel \
 "
RDEPENDS:rust-wayland-sys+memoffset-devel = " \
 cargo \
 rust-memoffset+default-devel \
 rust-wayland-sys-devel \
 "
RDEPENDS:rust-wayland-sys+once_cell-devel = " \
 cargo \
 rust-once_cell+default-devel \
 rust-wayland-sys-devel \
 "
RDEPENDS:rust-wayland-sys+server-devel = " \
 cargo \
 rust-dlib+default-devel \
 rust-log+default-devel \
 rust-wayland-sys+libc-devel \
 rust-wayland-sys+memoffset-devel \
 rust-wayland-sys-devel \
 wayland-devel \
 "
RDEPENDS:rust-wayland-sys-devel = " \
 cargo \
 rust \
 rust-pkg-config+default-devel \
 wayland-devel \
 "
