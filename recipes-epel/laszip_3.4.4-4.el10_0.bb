# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "laszip"
PV = "3.4.4"
PR = "4.el10_0"
PACKAGES = " \
 laszip \
 laszip-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/laszip-3.4.4-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a9b7f356a618a5d8bbad1efb165475355911e562dc74fdc4fa1fc245504704bb"

URI_x86_64_v2_laszip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/laszip-3.4.4-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_laszip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_laszip}"
SRC_URI[x86_64_v2_laszip.sha256sum] = "eb34cef3fc6b11b65f8be7c8d758557437e865b37d486f99682eb64ac50e8214"

URI_x86_64_v2_laszip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/laszip-devel-3.4.4-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_laszip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_laszip-devel}"
SRC_URI[x86_64_v2_laszip-devel.sha256sum] = "484c621b2b666a6764e2b04bb8720886afea6371fc6b8da4ecd83c121df63667"

URI_aarch64_laszip = "${EPEL_MIRROR}/aarch64/Packages/l/laszip-3.4.4-4.el10_0.aarch64.rpm;name=aarch64_laszip;unpack=0"
SRC_URI:append = " ${URI_aarch64_laszip}"
SRC_URI[aarch64_laszip.sha256sum] = "b942e050939d05f3e465330af4167ee1fff0f8b4a8f0a207dabfd84bffb0e786"

URI_aarch64_laszip-devel = "${EPEL_MIRROR}/aarch64/Packages/l/laszip-devel-3.4.4-4.el10_0.aarch64.rpm;name=aarch64_laszip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_laszip-devel}"
SRC_URI[aarch64_laszip-devel.sha256sum] = "faa00334b6f142e74f85ca413cd1f25fed669175b2b3f68b6f590ed50ae7a938"

RDEPENDS:laszip = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:laszip-devel = " \
 laszip \
 "
