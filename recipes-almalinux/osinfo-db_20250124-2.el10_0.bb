# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "osinfo-db"
PV = "20250124"
PR = "2.el10_0"
PACKAGES = " \
 osinfo-db \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/osinfo-db-20250124-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b7612bff7005ffa21a1bf586e22121a4f8a199b37d8fce394bd439c532ce0ba8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osinfo-db-20250124-2.el10_0.noarch.rpm;name=x86_64_v2_osinfo-db;unpack=0"
SRC_URI[x86_64_v2_osinfo-db.sha256sum] = "0035b076e4022aa791fb83538d84b28736901ae6b5e750b275b2a02518d2802c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osinfo-db-20250124-2.el10_0.noarch.rpm;name=aarch64_osinfo-db;unpack=0"
SRC_URI[aarch64_osinfo-db.sha256sum] = "0035b076e4022aa791fb83538d84b28736901ae6b5e750b275b2a02518d2802c"

RDEPENDS:osinfo-db = " \
 hwdata \
 "
