# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmatroska"
PV = "1.7.1"
PR = "8.el10_0"
PACKAGES = " \
 libmatroska \
 libmatroska-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libmatroska-1.7.1-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7d615bc8cb5040811dc044b6635234d697aeb4970ac5f362a2994a2b141a4d64"

URI_x86_64_v2_libmatroska = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmatroska-1.7.1-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmatroska;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmatroska}"
SRC_URI[x86_64_v2_libmatroska.sha256sum] = "9021e6a1792398f435143e1d6f5a1d270b5e1f7538be814c9eca53b892df04af"

URI_x86_64_v2_libmatroska-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmatroska-devel-1.7.1-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmatroska-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmatroska-devel}"
SRC_URI[x86_64_v2_libmatroska-devel.sha256sum] = "9b9e349f58cb63e9c66fafc4935264ccd8890df7be856baa89e624ede5cc5426"

URI_aarch64_libmatroska = "${EPEL_MIRROR}/aarch64/Packages/l/libmatroska-1.7.1-8.el10_0.aarch64.rpm;name=aarch64_libmatroska;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmatroska}"
SRC_URI[aarch64_libmatroska.sha256sum] = "04ab0009a20856635d5d55ff7cdd19048102ec39d5ec8b744d009331a410b0ae"

URI_aarch64_libmatroska-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libmatroska-devel-1.7.1-8.el10_0.aarch64.rpm;name=aarch64_libmatroska-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmatroska-devel}"
SRC_URI[aarch64_libmatroska-devel.sha256sum] = "cf30653967228a173ebbf1595fe9953ba9e8e50bbb4ac544eef4ed4c78bbcdec"

RDEPENDS:libmatroska = " \
 glibc \
 libebml \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libmatroska-devel = " \
 cmake-filesystem \
 libebml-devel \
 libmatroska \
 pkgconf-pkg-config \
 "
