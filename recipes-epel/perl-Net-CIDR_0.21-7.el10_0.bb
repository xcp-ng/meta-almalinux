# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-CIDR"
PV = "0.21"
PR = "7.el10_0"
PACKAGES = " \
 perl-Net-CIDR \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-CIDR-0.21-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e1bf40d62de9810e72e34becb3ff71e66d1115f4db3c8a394f9993a29db33da"

URI_x86_64_v2_perl-Net-CIDR = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-CIDR-0.21-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-CIDR;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-CIDR}"
SRC_URI[x86_64_v2_perl-Net-CIDR.sha256sum] = "18aa865ee7fa35a60561521bf682c8ee2cf60d5c01c1e56ce72b42b2c00b0122"

URI_aarch64_perl-Net-CIDR = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-CIDR-0.21-7.el10_0.noarch.rpm;name=aarch64_perl-Net-CIDR;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-CIDR}"
SRC_URI[aarch64_perl-Net-CIDR.sha256sum] = "1b10257e35e747ef0eaa87cd826282695ff25a31e730fbbd9163fa5c7030e533"

RDEPENDS:perl-Net-CIDR = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
