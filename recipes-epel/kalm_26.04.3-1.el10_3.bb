# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kalm"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kalm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kalm-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eb4677358d09177304be33d7ad35ee73dfcd66252fe84eba8208807897935cc3"

URI_x86_64_v2_kalm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kalm-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kalm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kalm}"
SRC_URI[x86_64_v2_kalm.sha256sum] = "34b47f81dec2ad78c8e8c4c44fe66a4a95399cf17035de773802125af69e2878"

URI_aarch64_kalm = "${EPEL_MIRROR}/aarch64/Packages/k/kalm-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kalm;unpack=0"
SRC_URI:append = " ${URI_aarch64_kalm}"
SRC_URI[aarch64_kalm.sha256sum] = "2cd5698732d6076e9adb501bd75c94f9be4cf84c14738bba08ac79f948b51cd3"

RDEPENDS:kalm = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kirigami-addons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
