# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openjph"
PV = "0.21.5"
PR = "1.el10_1"
PACKAGES = " \
 libopenjph \
 libopenjph-devel \
 openjph \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/openjph-0.21.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7994344336285845ad623a65b231be3cc34711f517f00b812fbe3ccc8d6f8164"

URI_x86_64_v2_libopenjph = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libopenjph-0.21.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libopenjph;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libopenjph}"
SRC_URI[x86_64_v2_libopenjph.sha256sum] = "da619ea8c5bf3f42d0f3bca7308ce704587ab76844f6bef752167e26b27c5736"

URI_x86_64_v2_libopenjph-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libopenjph-devel-0.21.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libopenjph-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libopenjph-devel}"
SRC_URI[x86_64_v2_libopenjph-devel.sha256sum] = "e14ee7e47e13a057195bdd10e03d39422a952fe92d0d35b82ab5b1832d515b38"

URI_x86_64_v2_openjph = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openjph-0.21.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openjph;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openjph}"
SRC_URI[x86_64_v2_openjph.sha256sum] = "7bf00621764b766c6fa897cad21896c87a57f5ac6273496b95378aad32841ea5"

URI_aarch64_libopenjph = "${EPEL_MIRROR}/aarch64/Packages/l/libopenjph-0.21.5-1.el10_1.aarch64.rpm;name=aarch64_libopenjph;unpack=0"
SRC_URI:append = " ${URI_aarch64_libopenjph}"
SRC_URI[aarch64_libopenjph.sha256sum] = "994c472d83d93ccee147df0723a0039ff553bea0112a6bda539f083cdb0b50c7"

URI_aarch64_libopenjph-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libopenjph-devel-0.21.5-1.el10_1.aarch64.rpm;name=aarch64_libopenjph-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libopenjph-devel}"
SRC_URI[aarch64_libopenjph-devel.sha256sum] = "f4d807d77b0971e5f129a9b8c07e808094672583e19472ba447c72783a38a290"

URI_aarch64_openjph = "${EPEL_MIRROR}/aarch64/Packages/o/openjph-0.21.5-1.el10_1.aarch64.rpm;name=aarch64_openjph;unpack=0"
SRC_URI:append = " ${URI_aarch64_openjph}"
SRC_URI[aarch64_openjph.sha256sum] = "7c9a2bb53117ffbea1940e4da2c3014f3bc1f138e6a62904036d89eba7416209"

RDEPENDS:libopenjph = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libopenjph-devel = " \
 cmake-filesystem \
 libjpeg-turbo-devel \
 libopenjph \
 pkgconf-pkg-config \
 "
RDEPENDS:openjph = " \
 glibc \
 libgcc \
 libopenjph \
 libstdc++ \
 libtiff \
 "
