# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "psmisc"
PV = "23.6"
PR = "8.el10"
PACKAGES = " \
 psmisc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/psmisc-23.6-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e7cd0fd96ac2c599319fe48214d62705de7745be03edce1d4892484c3d95503b"

URI_x86_64_v2_psmisc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/psmisc-23.6-8.el10.x86_64_v2.rpm;name=x86_64_v2_psmisc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_psmisc}"
SRC_URI[x86_64_v2_psmisc.sha256sum] = "c97e8ac9bd12fc011bb6c13edb971d075606bc4dd7684a374b16ecb6ca196359"

URI_aarch64_psmisc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/psmisc-23.6-8.el10.aarch64.rpm;name=aarch64_psmisc;unpack=0"
SRC_URI:append = " ${URI_aarch64_psmisc}"
SRC_URI[aarch64_psmisc.sha256sum] = "aaeaa9d7772394a2043bf5966dd1148314e3a25ca73efbf78bb8d9f2eeb3a880"

RDEPENDS:psmisc = " \
 glibc \
 ncurses-libs \
 "
