# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jurand"
PV = "1.3.2"
PR = "5.el10"
PACKAGES = " \
 jurand \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/jurand-1.3.2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3139f26165320c89d78825aa81f70b3a3b77612ca4a2f00923f5b702b5750bad"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jurand-1.3.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_jurand;unpack=0"
SRC_URI[x86_64_v2_jurand.sha256sum] = "2e52c212b8d99cace434955c595d45375e95bc87cb295af083a6b84db112c3bc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jurand-1.3.2-5.el10.aarch64.rpm;name=aarch64_jurand;unpack=0"
SRC_URI[aarch64_jurand.sha256sum] = "60b75c064e19185bd813db4e767a9d46b843232530ac2406e040ad42de41bdf3"

RDEPENDS:jurand = " \
 glibc \
 libgcc \
 libstdc++ \
 "
