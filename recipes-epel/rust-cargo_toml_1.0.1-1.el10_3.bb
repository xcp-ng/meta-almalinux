# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo_toml"
PV = "1.0.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-cargo_toml+default-devel \
 rust-cargo_toml+features-devel \
 rust-cargo_toml-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-cargo_toml-1.0.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e460a097106b45ed8fc61fa09ac3fdef8f660233c8379c2165bb7f9418386ca1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_toml+default-devel-1.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_toml+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cargo_toml+default-devel.sha256sum] = "60245542e5b09a5890c75118946752b41aabc266014e7ff152ffc0aeaea0c750"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_toml+features-devel-1.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_toml+features-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cargo_toml+features-devel.sha256sum] = "d9847ea109db73744c287ecdef964dd75083fb7f3e01da2fd1b5b3cfcdece619"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_toml-devel-1.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_toml-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cargo_toml-devel.sha256sum] = "5657284f90c4cb7bb3ef266f8e0e1ef5ebdbdb192b30aac2ddba5ce283b4b8a8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_toml+default-devel-1.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-cargo_toml+default-devel;unpack=0"
SRC_URI[aarch64_rust-cargo_toml+default-devel.sha256sum] = "13ba57bdd55a8f10e293aae22946d11738903e79364a7b2f420e1a4e692ea97d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_toml+features-devel-1.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-cargo_toml+features-devel;unpack=0"
SRC_URI[aarch64_rust-cargo_toml+features-devel.sha256sum] = "84e00e6d2cd02080a80b3f438b71b35c578cb786cefe0c4a612153ddbacfc707"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_toml-devel-1.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-cargo_toml-devel;unpack=0"
SRC_URI[aarch64_rust-cargo_toml-devel.sha256sum] = "1a24a909734cbadbcd03469184da569e0b69f263f5c04b8efb47ce83f4f7df76"

RDEPENDS:rust-cargo_toml+default-devel = " \
 cargo \
 rust-cargo_toml-devel \
 "
RDEPENDS:rust-cargo_toml+features-devel = " \
 cargo \
 rust-cargo_toml-devel \
 "
RDEPENDS:rust-cargo_toml-devel = " \
 cargo \
 rust \
 rust-semver+serde-devel \
 rust-semver+std-devel \
 rust-semver-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-toml+default-devel \
 "
