# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hardinfo2"
PV = "2.2.13"
PR = "1.el10_1"
PACKAGES = " \
 hardinfo2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/hardinfo2-2.2.13-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7bdd8743494a465ef690f4f37d000e02dae0d9b1cc312fb86486f44f20b9f235"

URI_x86_64_v2_hardinfo2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hardinfo2-2.2.13-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hardinfo2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hardinfo2}"
SRC_URI[x86_64_v2_hardinfo2.sha256sum] = "51d7e021f07e66b4a320b1b4f50336d5c26f154010eccc87375c13e4ad3b18a9"

URI_aarch64_hardinfo2 = "${EPEL_MIRROR}/aarch64/Packages/h/hardinfo2-2.2.13-1.el10_1.aarch64.rpm;name=aarch64_hardinfo2;unpack=0"
SRC_URI:append = " ${URI_aarch64_hardinfo2}"
SRC_URI[aarch64_hardinfo2.sha256sum] = "261f6e803c2c1356d221f3e17b5387f1e304d16433edc096ff3c62757a977a3d"

RDEPENDS:hardinfo2 = " \
 bash \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 json-glib \
 libX11 \
 libdecor \
 libgcc \
 libsoup3 \
 libstdc++ \
 libwayland-client \
 libxcb \
 pango \
 qt5-qtbase \
 qt5-qtbase-gui \
 vulkan-loader \
 "
