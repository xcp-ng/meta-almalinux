# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Data-Dumper-Names"
PV = "0.03"
PR = "41.el10_0"
PACKAGES = " \
 perl-Data-Dumper-Names \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Data-Dumper-Names-0.03-41.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "024bc06493dde6a14696682dfb8630e33eaeb4ca29957a7c17bd3bbb9d9c099c"

URI_x86_64_v2_perl-Data-Dumper-Names = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Data-Dumper-Names-0.03-41.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Data-Dumper-Names;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Data-Dumper-Names}"
SRC_URI[x86_64_v2_perl-Data-Dumper-Names.sha256sum] = "f851daabd94a99bb663940fa57c209c9bff1120434a8d648943cd77c2bf86259"

URI_aarch64_perl-Data-Dumper-Names = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Data-Dumper-Names-0.03-41.el10_0.noarch.rpm;name=aarch64_perl-Data-Dumper-Names;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Data-Dumper-Names}"
SRC_URI[aarch64_perl-Data-Dumper-Names.sha256sum] = "9c684bd2935a38ef29a45b81648a80220b5190dbe750944f89868e8648c05b39"

RDEPENDS:perl-Data-Dumper-Names = " \
 perl-Data-Dumper \
 perl-Exporter \
 perl-PadWalker \
 perl-Scalar-List-Utils \
 perl-base \
 perl-libs \
 "
