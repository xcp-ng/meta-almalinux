# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-shakespeare"
PV = "2.1.0.1"
PR = "1.el10_0"
PACKAGES = " \
 ghc-shakespeare \
 ghc-shakespeare-devel \
 ghc-shakespeare-doc \
 ghc-shakespeare-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-shakespeare-2.1.0.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b5e68a8a4519e2d9bf31c221a42a5ac83e545282a19606bde626e83f1dabcd16"

URI_x86_64_v2_ghc-shakespeare = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-shakespeare-2.1.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-shakespeare;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-shakespeare}"
SRC_URI[x86_64_v2_ghc-shakespeare.sha256sum] = "31bf8833ba659050d6b7e72df7f8afa7a257cd8152df7fe42e12ea0993fed354"

URI_x86_64_v2_ghc-shakespeare-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-shakespeare-devel-2.1.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-shakespeare-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-shakespeare-devel}"
SRC_URI[x86_64_v2_ghc-shakespeare-devel.sha256sum] = "84ae94bd04dcfae0f553a8be58c15ef5654b472eaf908fd61c11f54de0d486a0"

URI_x86_64_v2_ghc-shakespeare-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-shakespeare-doc-2.1.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-shakespeare-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-shakespeare-doc}"
SRC_URI[x86_64_v2_ghc-shakespeare-doc.sha256sum] = "5df9a4636f99d9ee6b62925bf6a37fe3ee084f6cf692e7eb24604e200cce05a7"

URI_x86_64_v2_ghc-shakespeare-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-shakespeare-prof-2.1.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-shakespeare-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-shakespeare-prof}"
SRC_URI[x86_64_v2_ghc-shakespeare-prof.sha256sum] = "7d71788b2276a80c9175339473e729989b02756aaa5ff8aa3d361559a6e10382"

URI_aarch64_ghc-shakespeare = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-shakespeare-2.1.0.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-shakespeare;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-shakespeare}"
SRC_URI[aarch64_ghc-shakespeare.sha256sum] = "41833b3b0be7c35bee4bd321189de3db9f093d2f2b1aa9846247e96831997ae7"

URI_aarch64_ghc-shakespeare-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-shakespeare-devel-2.1.0.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-shakespeare-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-shakespeare-devel}"
SRC_URI[aarch64_ghc-shakespeare-devel.sha256sum] = "7da906a4c686124db4c6e6e9ba00e9510dc00b1758db31960913dc17aef7556d"

URI_aarch64_ghc-shakespeare-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-shakespeare-doc-2.1.0.1-1.el10_0.noarch.rpm;name=aarch64_ghc-shakespeare-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-shakespeare-doc}"
SRC_URI[aarch64_ghc-shakespeare-doc.sha256sum] = "a9cf3ddb3ddbee46f4e18c00ad7c710a767eff742b7ef185f689c73417f72a8d"

URI_aarch64_ghc-shakespeare-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-shakespeare-prof-2.1.0.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-shakespeare-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-shakespeare-prof}"
SRC_URI[aarch64_ghc-shakespeare-prof.sha256sum] = "ef1fd1ccb94a0e55ffea884c36efb9c4450691e0e828af73f707175ad9eabbea"

RDEPENDS:ghc-shakespeare = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-array \
 ghc-assoc \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-bifunctors \
 ghc-binary \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-bytestring \
 ghc-comonad \
 ghc-containers \
 ghc-contravariant \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-file-embed \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-mtl \
 ghc-os-string \
 ghc-parsec \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-splitmix \
 ghc-stm \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-lift \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-stream \
 ghc-witherable \
 glibc \
 gmp \
 "
RDEPENDS:ghc-shakespeare-devel = " \
 ghc-aeson-devel \
 ghc-base-devel \
 ghc-blaze-html-devel \
 ghc-blaze-markup-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-directory-devel \
 ghc-exceptions-devel \
 ghc-file-embed-devel \
 ghc-parsec-devel \
 ghc-process-devel \
 ghc-scientific-devel \
 ghc-shakespeare \
 ghc-template-haskell-devel \
 ghc-text-devel \
 ghc-th-lift-devel \
 ghc-time-devel \
 ghc-transformers-devel \
 ghc-unordered-containers-devel \
 ghc-vector-devel \
 "
RDEPENDS:ghc-shakespeare-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-shakespeare-prof = " \
 ghc-aeson-prof \
 ghc-base-prof \
 ghc-blaze-html-prof \
 ghc-blaze-markup-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-directory-prof \
 ghc-exceptions-prof \
 ghc-file-embed-prof \
 ghc-parsec-prof \
 ghc-process-prof \
 ghc-scientific-prof \
 ghc-shakespeare-devel \
 ghc-template-haskell-prof \
 ghc-text-prof \
 ghc-th-lift-prof \
 ghc-time-prof \
 ghc-transformers-prof \
 ghc-unordered-containers-prof \
 ghc-vector-prof \
 "
