# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-test-deep"
PV = "1.1.1"
PR = "2.el10_0"
PACKAGES = " \
 golang-github-test-deep-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-test-deep-1.1.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "37c5a53b5638a6606b81118858aa09a4de074955d3378e12dd29c9ec76977cac"

URI_x86_64_v2_golang-github-test-deep-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-test-deep-devel-1.1.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-test-deep-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-test-deep-devel}"
SRC_URI[x86_64_v2_golang-github-test-deep-devel.sha256sum] = "10aea159ed826a3b1f8ca678893a8bb7446550f3f7dde908ef0dd3602091e3c9"

URI_aarch64_golang-github-test-deep-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-test-deep-devel-1.1.1-2.el10_0.noarch.rpm;name=aarch64_golang-github-test-deep-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-test-deep-devel}"
SRC_URI[aarch64_golang-github-test-deep-devel.sha256sum] = "f30b4a5dd0afc231af998ed936f9269e56714e4aaa76e98d7b80fe7ef96c2ec7"

RDEPENDS:golang-github-test-deep-devel = " \
 go-filesystem \
 "
