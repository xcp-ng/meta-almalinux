# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Devel-FindPerl"
PV = "0.016"
PR = "12.el10_3"
PACKAGES = " \
 perl-Devel-FindPerl \
 perl-Devel-FindPerl-tests \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Devel-FindPerl-0.016-12.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6d9247f3ef97f431303a508e1c3ac1ec3dc8d36be1c46599bfef7c41eb979ab7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Devel-FindPerl-0.016-12.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Devel-FindPerl;unpack=0"
SRC_URI[x86_64_v2_perl-Devel-FindPerl.sha256sum] = "34e3c6a9da7858d0516c60df332563f4e4c9840451f1e5fef7ea3c79ae9e5cc3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Devel-FindPerl-tests-0.016-12.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Devel-FindPerl-tests;unpack=0"
SRC_URI[x86_64_v2_perl-Devel-FindPerl-tests.sha256sum] = "52afb52182431f0e73a764fef1dc9b85bca626ea14afc9f0dd3065ecb0892565"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Devel-FindPerl-0.016-12.el10_3.noarch.rpm;name=aarch64_perl-Devel-FindPerl;unpack=0"
SRC_URI[aarch64_perl-Devel-FindPerl.sha256sum] = "b480afa757249395f5e698b815de0a6af8a92ed03b200bfac387dbdd90094a2d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Devel-FindPerl-tests-0.016-12.el10_3.noarch.rpm;name=aarch64_perl-Devel-FindPerl-tests;unpack=0"
SRC_URI[aarch64_perl-Devel-FindPerl-tests.sha256sum] = "87a897badc6f24ddacdeb063bcd69a44e10c03683a11bebde0f34341151e4281"

RDEPENDS:perl-Devel-FindPerl = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Basename \
 perl-IPC-Open3 \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-libs \
 "
RDEPENDS:perl-Devel-FindPerl-tests = " \
 bash \
 perl-Devel-FindPerl \
 perl-IPC-Open3 \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
