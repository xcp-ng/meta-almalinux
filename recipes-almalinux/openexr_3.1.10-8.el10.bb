# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openexr"
PV = "3.1.10"
PR = "8.el10"
PACKAGES = " \
 openexr \
 openexr-devel \
 openexr-libs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/openexr-3.1.10-8.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "be8fa7c1def1b67dc8c1b036a95431c7452caa1fbc289b2cfb8b39b717746cae"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openexr-3.1.10-8.el10.x86_64_v2.rpm;name=x86_64_v2_openexr;unpack=0"
SRC_URI[x86_64_v2_openexr.sha256sum] = "3b2acb29de6ed44360e576eb627a2f00173344d4177978d9059eecf6132ad9c2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openexr-devel-3.1.10-8.el10.x86_64_v2.rpm;name=x86_64_v2_openexr-devel;unpack=0"
SRC_URI[x86_64_v2_openexr-devel.sha256sum] = "ecde25469e45e3fe5bbefbe8df57812563aa43afb1d8beba5612d7e56c034da0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openexr-libs-3.1.10-8.el10.x86_64_v2.rpm;name=x86_64_v2_openexr-libs;unpack=0"
SRC_URI[x86_64_v2_openexr-libs.sha256sum] = "a800fc20cf9d8c6670b0801d84cfd685abf3f8deaf04dfc744e003f2844545d3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openexr-3.1.10-8.el10.aarch64.rpm;name=aarch64_openexr;unpack=0"
SRC_URI[aarch64_openexr.sha256sum] = "6199e301736c25c24bc702c5a2fc3de2a1d7eb1350ececade708f2d81d970275"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openexr-devel-3.1.10-8.el10.aarch64.rpm;name=aarch64_openexr-devel;unpack=0"
SRC_URI[aarch64_openexr-devel.sha256sum] = "f7fa61896d92ccf76a86d38f4c4fe97f10ae8ea2e92da72e9a22929dad46c039"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openexr-libs-3.1.10-8.el10.aarch64.rpm;name=aarch64_openexr-libs;unpack=0"
SRC_URI[aarch64_openexr-libs.sha256sum] = "ae914b65296a47e71aed675fc95e4ff1d7cd4b0aada726a77d5974dec6f2e672"

RDEPENDS:openexr = " \
 glibc \
 imath \
 libgcc \
 libstdc++ \
 openexr-libs \
 "
RDEPENDS:openexr-devel = " \
 cmake-filesystem \
 imath-devel \
 openexr-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:openexr-libs = " \
 glibc \
 imath \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
