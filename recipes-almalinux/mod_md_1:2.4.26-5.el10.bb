# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mod_md"
PE = "1"
PV = "2.4.26"
PR = "5.el10"
PACKAGES = " \
 mod_md \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mod_md-2.4.26-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe0c70669240b54acc331e0e89ef1d5d2dd1533379caab7391ee202a2cd01136"

URI_x86_64_v2_mod_md = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_md-2.4.26-5.el10.x86_64_v2.rpm;name=x86_64_v2_mod_md;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_md}"
SRC_URI[x86_64_v2_mod_md.sha256sum] = "e2041ee2ab3d75b27b35a912f8c3d66757dcc86083f76b9de6b7a27cba0ac05f"

URI_aarch64_mod_md = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_md-2.4.26-5.el10.aarch64.rpm;name=aarch64_mod_md;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_md}"
SRC_URI[aarch64_mod_md.sha256sum] = "be76ea27577ac83ded9297b8a491432dfea74a8500d75be005ad284132662a5c"

RDEPENDS:mod_md = " \
 apr \
 apr-util \
 glibc \
 httpd-core \
 jansson \
 mod_ssl \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 "
