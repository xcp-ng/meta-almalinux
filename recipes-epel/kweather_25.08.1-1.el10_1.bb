# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kweather"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kweather \
 kweather-plasma-applet \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kweather-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7d6363d14ef56477b55a38930783e74073ce50fa50121c0d55b2234322e51393"

URI_x86_64_v2_kweather = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kweather-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kweather;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kweather}"
SRC_URI[x86_64_v2_kweather.sha256sum] = "bf1d40016623183632fb3221d607d3eebd4e5deab6599d20a9cbc4e15fac51a8"

URI_x86_64_v2_kweather-plasma-applet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kweather-plasma-applet-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kweather-plasma-applet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kweather-plasma-applet}"
SRC_URI[x86_64_v2_kweather-plasma-applet.sha256sum] = "5f63eb61a703d0df942a70d5c7bca8d4ff83d8fcef70bd3049a1ac1bec6824bb"

URI_aarch64_kweather = "${EPEL_MIRROR}/aarch64/Packages/k/kweather-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kweather;unpack=0"
SRC_URI:append = " ${URI_aarch64_kweather}"
SRC_URI[aarch64_kweather.sha256sum] = "55bff1998be20fc45007f05b007bb3c162741228ec29df8a8f22484fc7853087"

URI_aarch64_kweather-plasma-applet = "${EPEL_MIRROR}/aarch64/Packages/k/kweather-plasma-applet-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kweather-plasma-applet;unpack=0"
SRC_URI:append = " ${URI_aarch64_kweather-plasma-applet}"
SRC_URI[aarch64_kweather-plasma-applet.sha256sum] = "14dc8665e2715a12063ea488c9a5f87a64932006620db9fb331c8f4dd31e8b94"

RDEPENDS:kweather = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kweathercore \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtcharts \
 qt6-qtdeclarative \
 "
RDEPENDS:kweather-plasma-applet = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kirigami \
 kf6-kirigami-addons \
 kweather \
 kweathercore \
 libplasma \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
