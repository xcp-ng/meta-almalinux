# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "syncthing"
PV = "2.1.3"
PR = "1.el10_2"
PACKAGES = " \
 syncthing \
 syncthing-tools \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/syncthing-2.1.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "409ae271adb0f79453912ff184e4e1350502f522f54014f04df53f505645d542"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syncthing-2.1.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syncthing;unpack=0"
SRC_URI[x86_64_v2_syncthing.sha256sum] = "d655d54c0eb3a6ee53f814fb0fbda4818f2732a13ef3737308dd6669317b71b9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syncthing-tools-2.1.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syncthing-tools;unpack=0"
SRC_URI[x86_64_v2_syncthing-tools.sha256sum] = "a08f9d88fd03f7fa3813c1334420a1c188534ae6cb109e45a587a63472540d39"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/syncthing-2.1.3-1.el10_2.aarch64.rpm;name=aarch64_syncthing;unpack=0"
SRC_URI[aarch64_syncthing.sha256sum] = "2f1d33f985512741c1c8202883fe0079cdf56bcad9746f6be1dbbef884b7b696"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/syncthing-tools-2.1.3-1.el10_2.aarch64.rpm;name=aarch64_syncthing-tools;unpack=0"
SRC_URI[aarch64_syncthing-tools.sha256sum] = "c03833f6de6025aa9511f10613b190f2e3345fae96ef52662f0eb10be064e27b"

RDEPENDS:syncthing = " \
 bash \
 glibc \
 hicolor-icon-theme \
 sqlite-libs \
 "
RDEPENDS:syncthing-tools = " \
 glibc \
 syncthing \
 "
