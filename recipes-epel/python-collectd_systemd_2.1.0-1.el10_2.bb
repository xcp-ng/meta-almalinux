# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-collectd_systemd"
PV = "2.1.0"
PR = "1.el10_2"
PACKAGES = " \
 python-collectd_systemd-selinux \
 python3-collectd_systemd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-collectd_systemd-2.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fba81c695709ec456e8a71fe90649e3692b6ef5c5daabe1481f13fa63b300f79"

URI_x86_64_v2_python-collectd_systemd-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-collectd_systemd-selinux-2.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-collectd_systemd-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-collectd_systemd-selinux}"
SRC_URI[x86_64_v2_python-collectd_systemd-selinux.sha256sum] = "3eaf4c4a9e44f6d0cf1242de489257621c8bf87b82688091f30e954eed205b49"

URI_x86_64_v2_python3-collectd_systemd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-collectd_systemd-2.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-collectd_systemd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-collectd_systemd}"
SRC_URI[x86_64_v2_python3-collectd_systemd.sha256sum] = "681684d0836e35e7a818543fa210b0f1b459e0cf7e99adc2080b16279370414b"

URI_aarch64_python-collectd_systemd-selinux = "${EPEL_MIRROR}/aarch64/Packages/p/python-collectd_systemd-selinux-2.1.0-1.el10_2.noarch.rpm;name=aarch64_python-collectd_systemd-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-collectd_systemd-selinux}"
SRC_URI[aarch64_python-collectd_systemd-selinux.sha256sum] = "dc5526aa588a84f8b7f00a9b436b8ac497cf5ff9abb9d49525e3742464f35e6c"

URI_aarch64_python3-collectd_systemd = "${EPEL_MIRROR}/aarch64/Packages/p/python3-collectd_systemd-2.1.0-1.el10_2.noarch.rpm;name=aarch64_python3-collectd_systemd;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-collectd_systemd}"
SRC_URI[aarch64_python3-collectd_systemd.sha256sum] = "a9e9be8c8e06dd8ab4fb11f6db9d7b080916c9bb9286f5ffe3272f44f3b15eec"

RDEPENDS:python-collectd_systemd-selinux = " \
 bash \
 policycoreutils \
 selinux-policy \
 "
RDEPENDS:python3-collectd_systemd = " \
 python-collectd_systemd-selinux \
 python3 \
 "
