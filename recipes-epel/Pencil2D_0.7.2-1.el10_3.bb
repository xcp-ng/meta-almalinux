# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "Pencil2D"
PV = "0.7.2"
PR = "1.el10_3"
PACKAGES = " \
 Pencil2D \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/Pencil2D-0.7.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf78102e458a9c5b251571fcb9cbc23cde71c6227cd242f9c5ba714f044f1a53"

URI_x86_64_v2_Pencil2D = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/Pencil2D-0.7.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_Pencil2D;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_Pencil2D}"
SRC_URI[x86_64_v2_Pencil2D.sha256sum] = "970548df6fb4f31677d06188390e8415ebad2ab6e60b9a986e5d89fd9d5160fb"

URI_aarch64_Pencil2D = "${EPEL_MIRROR}/aarch64/Packages/p/Pencil2D-0.7.2-1.el10_3.aarch64.rpm;name=aarch64_Pencil2D;unpack=0"
SRC_URI:append = " ${URI_aarch64_Pencil2D}"
SRC_URI[aarch64_Pencil2D.sha256sum] = "119b2b3931b6ab5c5f64f21e50cbabb1760791981c389893476684ac85f4e359"

RDEPENDS:Pencil2D = " \
 ffmpeg-free \
 glibc \
 hicolor-icon-theme \
 libgcc \
 libstdc++ \
 miniz \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
 "
