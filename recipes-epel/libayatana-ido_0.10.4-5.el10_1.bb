# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libayatana-ido"
PV = "0.10.4"
PR = "5.el10_1"
PACKAGES = " \
 libayatana-ido-gtk3 \
 libayatana-ido-gtk3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libayatana-ido-0.10.4-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e2d86068e6da992d8fe0c8148219ed0b904179d2293284a9593aa44520454af"

URI_x86_64_v2_libayatana-ido-gtk3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libayatana-ido-gtk3-0.10.4-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libayatana-ido-gtk3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libayatana-ido-gtk3}"
SRC_URI[x86_64_v2_libayatana-ido-gtk3.sha256sum] = "f0456ecf54591cd12897dada289da0736fe9d1aa25b3dfb0caee62e4c6c945b8"

URI_x86_64_v2_libayatana-ido-gtk3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libayatana-ido-gtk3-devel-0.10.4-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libayatana-ido-gtk3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libayatana-ido-gtk3-devel}"
SRC_URI[x86_64_v2_libayatana-ido-gtk3-devel.sha256sum] = "3469998c543cff0e1cdcb18cac7bae2b3cecebd25a3974bd2f035077da489308"

URI_aarch64_libayatana-ido-gtk3 = "${EPEL_MIRROR}/aarch64/Packages/l/libayatana-ido-gtk3-0.10.4-5.el10_1.aarch64.rpm;name=aarch64_libayatana-ido-gtk3;unpack=0"
SRC_URI:append = " ${URI_aarch64_libayatana-ido-gtk3}"
SRC_URI[aarch64_libayatana-ido-gtk3.sha256sum] = "d66922bb557520fb1750ee91b1371628040d0049d3ccb6ce5d115412d4a7bd39"

URI_aarch64_libayatana-ido-gtk3-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libayatana-ido-gtk3-devel-0.10.4-5.el10_1.aarch64.rpm;name=aarch64_libayatana-ido-gtk3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libayatana-ido-gtk3-devel}"
SRC_URI[aarch64_libayatana-ido-gtk3-devel.sha256sum] = "067aaa8503fb27a00eb24568b58fff3d1b3cb6250f52c60a886374e822ca0c5f"

RDEPENDS:libayatana-ido-gtk3 = " \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 pango \
 "
RDEPENDS:libayatana-ido-gtk3-devel = " \
 glib2-devel \
 gtk3-devel \
 libayatana-ido-gtk3 \
 pkgconf-pkg-config \
 "
