# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "drat-trim"
PV = "0"
PR = "0.25.20240427giteffa1dc.el10_2"
PACKAGES = " \
 drat-trim \
 drat-trim-devel \
 drat-trim-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/drat-trim-0-0.25.20240427giteffa1dc.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "39feecd2f4264d0c1a4366f90277861ebc626113ccf5c22e30597c33c54184fe"

URI_aarch64_drat-trim = "${EPEL_MIRROR}/aarch64/Packages/d/drat-trim-0-0.25.20240427giteffa1dc.el10_2.aarch64.rpm;name=aarch64_drat-trim;unpack=0"
SRC_URI:append = " ${URI_aarch64_drat-trim}"
SRC_URI[aarch64_drat-trim.sha256sum] = "e8fcb812ff1a18d08c9b3aa3c8a6b7c822e325da11311709694a29790eb7e7fb"

URI_aarch64_drat-trim-devel = "${EPEL_MIRROR}/aarch64/Packages/d/drat-trim-devel-0-0.25.20240427giteffa1dc.el10_2.aarch64.rpm;name=aarch64_drat-trim-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_drat-trim-devel}"
SRC_URI[aarch64_drat-trim-devel.sha256sum] = "77d3ac7d3fc64d71e99a276812a8e0842a811e50162b82055ddbf47fc8377f57"

URI_aarch64_drat-trim-tools = "${EPEL_MIRROR}/aarch64/Packages/d/drat-trim-tools-0-0.25.20240427giteffa1dc.el10_2.aarch64.rpm;name=aarch64_drat-trim-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_drat-trim-tools}"
SRC_URI[aarch64_drat-trim-tools.sha256sum] = "e65cd42e5de58e95f8b2e1604436bf8da3ec722698adc779d311e55d4d8bc842"

RDEPENDS:drat-trim = " \
 glibc \
 "
RDEPENDS:drat-trim-devel = " \
 drat-trim \
 "
RDEPENDS:drat-trim-tools = " \
 drat-trim \
 glibc \
 "
