# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lv2-core"
PV = "3.0.0"
PR = "3.el10_0"
PACKAGES = " \
 rust-lv2-core+default-devel \
 rust-lv2-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lv2-core-3.0.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8ac527db2d52f7162c65677a31171247c9d914b5c96ffae1d1ebcce6e997ea7a"

URI_x86_64_v2_rust-lv2-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2-core+default-devel-3.0.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2-core+default-devel}"
SRC_URI[x86_64_v2_rust-lv2-core+default-devel.sha256sum] = "67c056fc519f26a42235e8193249b873ed4195cbbffd1a1b7175bb09fa541b62"

URI_x86_64_v2_rust-lv2-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2-core-devel-3.0.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2-core-devel}"
SRC_URI[x86_64_v2_rust-lv2-core-devel.sha256sum] = "83f54f5731417d690f6b92e5c7a35acab224ba35b04b0788ba4257a1d3804c29"

URI_aarch64_rust-lv2-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2-core+default-devel-3.0.0-3.el10_0.noarch.rpm;name=aarch64_rust-lv2-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2-core+default-devel}"
SRC_URI[aarch64_rust-lv2-core+default-devel.sha256sum] = "f854251c41bf3be5fa989d53af787cee5ada72130078ae4d982ab59c36e0a2ce"

URI_aarch64_rust-lv2-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2-core-devel-3.0.0-3.el10_0.noarch.rpm;name=aarch64_rust-lv2-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2-core-devel}"
SRC_URI[aarch64_rust-lv2-core-devel.sha256sum] = "bdc1ded157ae5e8f62948d1071a11213cf02d86dbf871460ace76138fdf37503"

RDEPENDS:rust-lv2-core+default-devel = " \
 cargo \
 rust-lv2-core-devel \
 "
RDEPENDS:rust-lv2-core-devel = " \
 cargo \
 rust-lv2-core-derive+default-devel \
 rust-lv2-sys+default-devel \
 rust-urid+default-devel \
 "
