# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pdns"
PV = "5.0.7"
PR = "1.el10_3"
PACKAGES = " \
 pdns \
 pdns-backend-ldap \
 pdns-backend-lmdb \
 pdns-backend-lua2 \
 pdns-backend-mysql \
 pdns-backend-pipe \
 pdns-backend-postgresql \
 pdns-backend-remote \
 pdns-backend-sqlite \
 pdns-backend-tinydns \
 pdns-ixfrdist \
 pdns-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pdns-5.0.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3a60069ecc156e764c1e4a94ba77166474c2408350e247cca47d90ce0b0a58ba"

URI_x86_64_v2_pdns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-5.0.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns}"
SRC_URI[x86_64_v2_pdns.sha256sum] = "e3886c529eccfc9e8e1ded9a318d750f4c2a7907ed80f7e52d6babbad47c965a"

URI_x86_64_v2_pdns-backend-ldap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-ldap-5.0.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-ldap}"
SRC_URI[x86_64_v2_pdns-backend-ldap.sha256sum] = "338558991033c8336b7007b2269d420dc6c2a93e496c500996a405781b4b2218"

URI_x86_64_v2_pdns-backend-lmdb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-lmdb-5.0.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-lmdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-lmdb}"
SRC_URI[x86_64_v2_pdns-backend-lmdb.sha256sum] = "f6e7c2f265f1df90b07b5f8024e7e9c206c01d526a44e194a97db35fb3f3dfac"

URI_x86_64_v2_pdns-backend-lua2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-lua2-5.0.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-lua2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-lua2}"
SRC_URI[x86_64_v2_pdns-backend-lua2.sha256sum] = "f67dcbddd82b00151162e938810880e4be2928e2ab2fc091302e7542c26e97fe"

URI_x86_64_v2_pdns-backend-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-mysql-5.0.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-mysql}"
SRC_URI[x86_64_v2_pdns-backend-mysql.sha256sum] = "1807aa7bdb887e7e3225775d5a7e2c6b1611fcf24402113cc4419192b1c2a48a"

URI_x86_64_v2_pdns-backend-pipe = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-pipe-5.0.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-pipe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-pipe}"
SRC_URI[x86_64_v2_pdns-backend-pipe.sha256sum] = "9108f3a2e93c614b1fcbe1886905c40afe4da104d50ad979f1d8f8deebad5808"

URI_x86_64_v2_pdns-backend-postgresql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-postgresql-5.0.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-postgresql}"
SRC_URI[x86_64_v2_pdns-backend-postgresql.sha256sum] = "de066cab48bde9b3b4e19891a06347c42cce5d8700e162c220b2f1a2cd4f1d95"

URI_x86_64_v2_pdns-backend-remote = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-remote-5.0.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-remote;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-remote}"
SRC_URI[x86_64_v2_pdns-backend-remote.sha256sum] = "36385acd3bab98d3eb92423cb64fa47a1443b7ffabe21253555bcbfbf7701b5a"

URI_x86_64_v2_pdns-backend-sqlite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-sqlite-5.0.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-sqlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-sqlite}"
SRC_URI[x86_64_v2_pdns-backend-sqlite.sha256sum] = "4493962ae9bf9fba948edefe965307057e375a1754279c8634db400a2d591c92"

URI_x86_64_v2_pdns-backend-tinydns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-tinydns-5.0.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-tinydns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-tinydns}"
SRC_URI[x86_64_v2_pdns-backend-tinydns.sha256sum] = "04b08e4ae51f4f265d5e5f65c918886b10b2e58c0cb86232f2933635201662ec"

URI_x86_64_v2_pdns-ixfrdist = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-ixfrdist-5.0.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-ixfrdist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-ixfrdist}"
SRC_URI[x86_64_v2_pdns-ixfrdist.sha256sum] = "8e908cfb5d51fd53965c59ed0ad55a2ea7cbb19b2e632a7d01bb3bc80d8fee44"

URI_x86_64_v2_pdns-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-tools-5.0.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-tools}"
SRC_URI[x86_64_v2_pdns-tools.sha256sum] = "428aeea8410fbc6ffced02a79b8dd5e69149fb650c7a4f0a6159877059476e97"

URI_aarch64_pdns = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-5.0.7-1.el10_3.aarch64.rpm;name=aarch64_pdns;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns}"
SRC_URI[aarch64_pdns.sha256sum] = "d230bca7f4165b356d3fc048a61ac30350db8d3a6ec8ea64daf2befd000b68e4"

URI_aarch64_pdns-backend-ldap = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-ldap-5.0.7-1.el10_3.aarch64.rpm;name=aarch64_pdns-backend-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-ldap}"
SRC_URI[aarch64_pdns-backend-ldap.sha256sum] = "9578cca9e694e5f91d8e3e4ac977d6b0443d8f280cf69129626599e4a5f51005"

URI_aarch64_pdns-backend-lmdb = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-lmdb-5.0.7-1.el10_3.aarch64.rpm;name=aarch64_pdns-backend-lmdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-lmdb}"
SRC_URI[aarch64_pdns-backend-lmdb.sha256sum] = "5e13afcb0de73a6be48a18fcc384e8ab790389151f70a10c6f619e4f1cb452f7"

URI_aarch64_pdns-backend-lua2 = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-lua2-5.0.7-1.el10_3.aarch64.rpm;name=aarch64_pdns-backend-lua2;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-lua2}"
SRC_URI[aarch64_pdns-backend-lua2.sha256sum] = "7c23a4ac91829152ea2b00e23f156d1c501c654f78e89b2e21251d849fff8a0f"

URI_aarch64_pdns-backend-mysql = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-mysql-5.0.7-1.el10_3.aarch64.rpm;name=aarch64_pdns-backend-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-mysql}"
SRC_URI[aarch64_pdns-backend-mysql.sha256sum] = "81d96c6b8b404942634e3dafd81eb2655e3ece4f51d5ca4e290d3d91d4f2f8db"

URI_aarch64_pdns-backend-pipe = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-pipe-5.0.7-1.el10_3.aarch64.rpm;name=aarch64_pdns-backend-pipe;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-pipe}"
SRC_URI[aarch64_pdns-backend-pipe.sha256sum] = "7d8dc65f285c17f5f8ca7f238b8226a2201d3ded1aa172667cb4a35e91a1a3cf"

URI_aarch64_pdns-backend-postgresql = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-postgresql-5.0.7-1.el10_3.aarch64.rpm;name=aarch64_pdns-backend-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-postgresql}"
SRC_URI[aarch64_pdns-backend-postgresql.sha256sum] = "f0829ed3c413d216fb94a4a1e8636c3444bb151f90c348829a7aaff3367d1090"

URI_aarch64_pdns-backend-remote = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-remote-5.0.7-1.el10_3.aarch64.rpm;name=aarch64_pdns-backend-remote;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-remote}"
SRC_URI[aarch64_pdns-backend-remote.sha256sum] = "4d6c53e268cb62d09110d8f411cead1c531e384f7aed04345d4b9d357f5c974a"

URI_aarch64_pdns-backend-sqlite = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-sqlite-5.0.7-1.el10_3.aarch64.rpm;name=aarch64_pdns-backend-sqlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-sqlite}"
SRC_URI[aarch64_pdns-backend-sqlite.sha256sum] = "d75ffbeca807659d43916b449ab1c0641b9946ec13b3c9f2ea9ff6927554b0e9"

URI_aarch64_pdns-backend-tinydns = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-tinydns-5.0.7-1.el10_3.aarch64.rpm;name=aarch64_pdns-backend-tinydns;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-tinydns}"
SRC_URI[aarch64_pdns-backend-tinydns.sha256sum] = "cf054a9d423f562f5e7b97ed4a4ccbf390b80fc5a229a4e0253253f839151cd0"

URI_aarch64_pdns-ixfrdist = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-ixfrdist-5.0.7-1.el10_3.aarch64.rpm;name=aarch64_pdns-ixfrdist;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-ixfrdist}"
SRC_URI[aarch64_pdns-ixfrdist.sha256sum] = "560261ee920f4eacd14a9e92fc53d738aa599f4a2b379dc7b7be7f1149034c11"

URI_aarch64_pdns-tools = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-tools-5.0.7-1.el10_3.aarch64.rpm;name=aarch64_pdns-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-tools}"
SRC_URI[aarch64_pdns-tools.sha256sum] = "ff6862272be6cf3760701eb98313134d97453485202d75bf73097858169d57ff"

RDEPENDS:pdns = " \
 bash \
 boost-program-options \
 glibc \
 libgcc \
 libsodium \
 libstdc++ \
 luajit \
 openssl-libs \
 p11-kit \
 shadow-utils \
 sqlite-libs \
 systemd \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:pdns-backend-ldap = " \
 glibc \
 krb5-libs \
 libgcc \
 libstdc++ \
 openldap \
 pdns \
 "
RDEPENDS:pdns-backend-lmdb = " \
 boost-serialization \
 glibc \
 libgcc \
 libstdc++ \
 lmdb-libs \
 pdns \
 systemd-libs \
 "
RDEPENDS:pdns-backend-lua2 = " \
 glibc \
 libgcc \
 libstdc++ \
 luajit \
 pdns \
 "
RDEPENDS:pdns-backend-mysql = " \
 glibc \
 libgcc \
 libstdc++ \
 mariadb-connector-c \
 pdns \
 "
RDEPENDS:pdns-backend-pipe = " \
 glibc \
 libgcc \
 libstdc++ \
 pdns \
 "
RDEPENDS:pdns-backend-postgresql = " \
 glibc \
 libgcc \
 libpq \
 libstdc++ \
 pdns \
 "
RDEPENDS:pdns-backend-remote = " \
 glibc \
 libgcc \
 libstdc++ \
 pdns \
 "
RDEPENDS:pdns-backend-sqlite = " \
 glibc \
 libgcc \
 libstdc++ \
 pdns \
 "
RDEPENDS:pdns-backend-tinydns = " \
 glibc \
 libgcc \
 libstdc++ \
 pdns \
 tinycdb \
 "
RDEPENDS:pdns-ixfrdist = " \
 boost-program-options \
 glibc \
 libgcc \
 libsodium \
 libstdc++ \
 openssl-libs \
 p11-kit \
 yaml-cpp \
 "
RDEPENDS:pdns-tools = " \
 boost-program-options \
 glibc \
 libgcc \
 libsodium \
 libstdc++ \
 openssl-libs \
 p11-kit \
 virtual/libcurl.so.4___64bit_ \
 "
