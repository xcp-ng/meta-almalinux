# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand"
PV = "0.10.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-rand+alloc-devel \
 rust-rand+chacha-devel \
 rust-rand+default-devel \
 rust-rand+log-devel \
 rust-rand+serde-devel \
 rust-rand+std-devel \
 rust-rand+std_rng-devel \
 rust-rand+sys_rng-devel \
 rust-rand+thread_rng-devel \
 rust-rand+unbiased-devel \
 rust-rand-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand-0.10.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "978a69c1cd8bc2eba4af33487357a61186061b3689e4429e08432459fe84c8f5"

URI_x86_64_v2_rust-rand+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+alloc-devel-0.10.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+alloc-devel}"
SRC_URI[x86_64_v2_rust-rand+alloc-devel.sha256sum] = "fbb6f6eb7ed452aae69ff6f9db2f12ea1853d69b67eec04342f785769eb9b0cd"

URI_x86_64_v2_rust-rand+chacha-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+chacha-devel-0.10.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+chacha-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+chacha-devel}"
SRC_URI[x86_64_v2_rust-rand+chacha-devel.sha256sum] = "088658f8c94c482a8bfe2c7e36136c1b28b627122b830a2f7e9fd4581b657ac8"

URI_x86_64_v2_rust-rand+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+default-devel-0.10.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+default-devel}"
SRC_URI[x86_64_v2_rust-rand+default-devel.sha256sum] = "a8c20d20de4ce92c1c158a05491efd9a2a2604abd9ae5e61f7b93d2eee28e8e9"

URI_x86_64_v2_rust-rand+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+log-devel-0.10.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+log-devel}"
SRC_URI[x86_64_v2_rust-rand+log-devel.sha256sum] = "b8518e3cba0909fc4ca09de4552a6d7a0d973300db56ca3e459e4e0422e1afdf"

URI_x86_64_v2_rust-rand+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+serde-devel-0.10.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+serde-devel}"
SRC_URI[x86_64_v2_rust-rand+serde-devel.sha256sum] = "25ad19796835a129929f752e940aa214d147f06218184e11d461b551abd206ab"

URI_x86_64_v2_rust-rand+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+std-devel-0.10.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+std-devel}"
SRC_URI[x86_64_v2_rust-rand+std-devel.sha256sum] = "05907e9192b2e71a5825c75cf181535643209bdfcef7670e5d8acd16b4483b40"

URI_x86_64_v2_rust-rand+std_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+std_rng-devel-0.10.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+std_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+std_rng-devel}"
SRC_URI[x86_64_v2_rust-rand+std_rng-devel.sha256sum] = "6f12b46addec9c2adef7461b931c25faacfb73205755f2136348665a10a21638"

URI_x86_64_v2_rust-rand+sys_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+sys_rng-devel-0.10.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+sys_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+sys_rng-devel}"
SRC_URI[x86_64_v2_rust-rand+sys_rng-devel.sha256sum] = "6cfe839e5bd424f191a8dd52ee4b6a866dc40930546cc3e6e965bd6119b07deb"

URI_x86_64_v2_rust-rand+thread_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+thread_rng-devel-0.10.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+thread_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+thread_rng-devel}"
SRC_URI[x86_64_v2_rust-rand+thread_rng-devel.sha256sum] = "6a47d284cdac164a29c106f185f60ad591c08a7dfb4b5c098dc1400a5b2c82bc"
RPROVIDES:rust-rand+thread_rng-devel:x86_64_v2 = "virtual/crate_rand/thread_rng__ge_0.9.0_with_crate_rand/thread_rng__le_0.11.0"

URI_x86_64_v2_rust-rand+unbiased-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+unbiased-devel-0.10.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+unbiased-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+unbiased-devel}"
SRC_URI[x86_64_v2_rust-rand+unbiased-devel.sha256sum] = "6a305878684af15b424107a530f8efd579562b37916cf3c34c52ee777cd66a1b"

URI_x86_64_v2_rust-rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand-devel-0.10.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand-devel}"
SRC_URI[x86_64_v2_rust-rand-devel.sha256sum] = "d71fb04e4712f8686fa42e1d8cd36667a32190a246fb71f834a85dd90abc389d"
RPROVIDES:rust-rand-devel:x86_64_v2 = "virtual/crate_rand__ge_0.9.0_with_crate_rand__le_0.11.0"

URI_aarch64_rust-rand+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+alloc-devel-0.10.2-1.el10_3.noarch.rpm;name=aarch64_rust-rand+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+alloc-devel}"
SRC_URI[aarch64_rust-rand+alloc-devel.sha256sum] = "330de48493c2a4812896738e5811404f66ac9f95000623da2d045c3e5260aa6a"

URI_aarch64_rust-rand+chacha-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+chacha-devel-0.10.2-1.el10_3.noarch.rpm;name=aarch64_rust-rand+chacha-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+chacha-devel}"
SRC_URI[aarch64_rust-rand+chacha-devel.sha256sum] = "61ce54779d7038c0e983ddffb884657452389b472e50cfd89e28e8bf2861cc78"

URI_aarch64_rust-rand+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+default-devel-0.10.2-1.el10_3.noarch.rpm;name=aarch64_rust-rand+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+default-devel}"
SRC_URI[aarch64_rust-rand+default-devel.sha256sum] = "6d8b045f7cb326b31651c3861a8dac388146400ff24a94945ec7de1be1e2f96a"

URI_aarch64_rust-rand+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+log-devel-0.10.2-1.el10_3.noarch.rpm;name=aarch64_rust-rand+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+log-devel}"
SRC_URI[aarch64_rust-rand+log-devel.sha256sum] = "0d091b37a9a54ee35c93a6b6930701d4b07b38388108d50fcf4c648650ef6b67"

URI_aarch64_rust-rand+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+serde-devel-0.10.2-1.el10_3.noarch.rpm;name=aarch64_rust-rand+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+serde-devel}"
SRC_URI[aarch64_rust-rand+serde-devel.sha256sum] = "f6efa44d13f499cca477113f59a70dbfb325292ad3e5048eda71366dcfbfcc0e"

URI_aarch64_rust-rand+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+std-devel-0.10.2-1.el10_3.noarch.rpm;name=aarch64_rust-rand+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+std-devel}"
SRC_URI[aarch64_rust-rand+std-devel.sha256sum] = "def8bee52a5fa64b7f271151e23d48e1f383513040942ec3e27e721731ec154d"

URI_aarch64_rust-rand+std_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+std_rng-devel-0.10.2-1.el10_3.noarch.rpm;name=aarch64_rust-rand+std_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+std_rng-devel}"
SRC_URI[aarch64_rust-rand+std_rng-devel.sha256sum] = "91e33a8e50ada3dae72fee358f99bfd9a1af0ce0b2e2b381fc456ea96837f2d3"

URI_aarch64_rust-rand+sys_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+sys_rng-devel-0.10.2-1.el10_3.noarch.rpm;name=aarch64_rust-rand+sys_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+sys_rng-devel}"
SRC_URI[aarch64_rust-rand+sys_rng-devel.sha256sum] = "0eb975d9126c54ddac14f5f14575d4db1bb8b42d503b06af373864a3f4cca8f6"

URI_aarch64_rust-rand+thread_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+thread_rng-devel-0.10.2-1.el10_3.noarch.rpm;name=aarch64_rust-rand+thread_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+thread_rng-devel}"
SRC_URI[aarch64_rust-rand+thread_rng-devel.sha256sum] = "ad55562f97786cbebe99ed53b541e3ef955f2fef89dbfb013f1ee8e93a69e58b"
RPROVIDES:rust-rand+thread_rng-devel:aarch64 = "virtual/crate_rand/thread_rng__ge_0.9.0_with_crate_rand/thread_rng__le_0.11.0"

URI_aarch64_rust-rand+unbiased-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+unbiased-devel-0.10.2-1.el10_3.noarch.rpm;name=aarch64_rust-rand+unbiased-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+unbiased-devel}"
SRC_URI[aarch64_rust-rand+unbiased-devel.sha256sum] = "53130a781976e20c890fa918d71542d58080e757fd1a567a3e01740527c4a49e"

URI_aarch64_rust-rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand-devel-0.10.2-1.el10_3.noarch.rpm;name=aarch64_rust-rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand-devel}"
SRC_URI[aarch64_rust-rand-devel.sha256sum] = "517a2411b55f5bf2136d4569ad419b5fb64e41de11f2f60a4ac742d68d86de1b"
RPROVIDES:rust-rand-devel:aarch64 = "virtual/crate_rand__ge_0.9.0_with_crate_rand__le_0.11.0"

RDEPENDS:rust-rand+alloc-devel = " \
 cargo \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+chacha-devel = " \
 cargo \
 rust-chacha20+rng-devel \
 rust-chacha20-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+default-devel = " \
 cargo \
 rust-rand+std-devel \
 rust-rand+std_rng-devel \
 rust-rand+sys_rng-devel \
 rust-rand+thread_rng-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+log-devel = " \
 cargo \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+serde-devel = " \
 cargo \
 rust-rand-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand+std-devel = " \
 cargo \
 rust-getrandom+default-devel \
 rust-getrandom+std-devel \
 rust-rand+alloc-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+std_rng-devel = " \
 cargo \
 rust-chacha20+rng-devel \
 rust-chacha20-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+sys_rng-devel = " \
 cargo \
 rust-getrandom+default-devel \
 rust-getrandom+sys_rng-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+thread_rng-devel = " \
 cargo \
 rust-rand+std-devel \
 rust-rand+std_rng-devel \
 rust-rand+sys_rng-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+unbiased-devel = " \
 cargo \
 rust-rand-devel \
 "
RDEPENDS:rust-rand-devel = " \
 cargo \
 rust \
 rust-rand_core-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_rand/thread_rng__ge_0.9.0_with_crate_rand/thread_rng__le_0.11.0 rpm/virtual/crate_rand__ge_0.9.0_with_crate_rand__le_0.11.0"

PROVIDES:append:aarch64 = " rpm/virtual/crate_rand/thread_rng__ge_0.9.0_with_crate_rand/thread_rng__le_0.11.0 rpm/virtual/crate_rand__ge_0.9.0_with_crate_rand__le_0.11.0"
