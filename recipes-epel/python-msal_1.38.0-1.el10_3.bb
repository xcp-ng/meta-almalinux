# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-msal"
PV = "1.38.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-msal \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-msal-1.38.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0ca03cd97b81bbbdadb53f5287c2aaecb7cfad8916beb4db89522a2db5a773a1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-msal-1.38.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-msal;unpack=0"
SRC_URI[x86_64_v2_python3-msal.sha256sum] = "94e15005c9430423bda4eb4398fde33f65b74af12f96d03ac9b3b71be46c0104"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-msal-1.38.0-1.el10_3.noarch.rpm;name=aarch64_python3-msal;unpack=0"
SRC_URI[aarch64_python3-msal.sha256sum] = "696745517dac72b9113dd9d41c89bf15b77a3df70d2a001f132bc3eebabae30e"

RDEPENDS:python3-msal = " \
 python3 \
 python3-cryptography \
 python3-jwt \
 python3-jwt+crypto \
 python3-requests \
 "
