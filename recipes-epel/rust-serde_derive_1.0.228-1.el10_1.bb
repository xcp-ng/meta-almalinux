# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_derive"
PV = "1.0.228"
PR = "1.el10_1"
PACKAGES = " \
 rust-serde_derive+default-devel \
 rust-serde_derive+deserialize_in_place-devel \
 rust-serde_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_derive-1.0.228-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2160bffb241809cf04f73c0afe630acec1e2e515fc663c75f92e3161a3365e0e"

URI_x86_64_v2_rust-serde_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_derive+default-devel-1.0.228-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_derive+default-devel}"
SRC_URI[x86_64_v2_rust-serde_derive+default-devel.sha256sum] = "5dc12345ce06ba8446cadfea0c7a8ac2c9cb7bfbfa969e8bea68d9c46d90a99b"

URI_x86_64_v2_rust-serde_derive+deserialize_in_place-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_derive+deserialize_in_place-devel-1.0.228-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_derive+deserialize_in_place-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_derive+deserialize_in_place-devel}"
SRC_URI[x86_64_v2_rust-serde_derive+deserialize_in_place-devel.sha256sum] = "97880dceecbe4d0250e263867c39f55fa6883f454d937afaba516974ed836e08"

URI_x86_64_v2_rust-serde_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_derive-devel-1.0.228-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_derive-devel}"
SRC_URI[x86_64_v2_rust-serde_derive-devel.sha256sum] = "a559f8bbab85dc289e4cf9bca3ee6685a77d762854ec769d1544a4159d14d6f8"

URI_aarch64_rust-serde_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_derive+default-devel-1.0.228-1.el10_1.noarch.rpm;name=aarch64_rust-serde_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_derive+default-devel}"
SRC_URI[aarch64_rust-serde_derive+default-devel.sha256sum] = "d0f50e43791dd8b11d146cac5ce22091b517d0c2c996146d174b4bb54a5a5f75"

URI_aarch64_rust-serde_derive+deserialize_in_place-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_derive+deserialize_in_place-devel-1.0.228-1.el10_1.noarch.rpm;name=aarch64_rust-serde_derive+deserialize_in_place-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_derive+deserialize_in_place-devel}"
SRC_URI[aarch64_rust-serde_derive+deserialize_in_place-devel.sha256sum] = "a54119531ef2166d89f044310612ad79b59ff769188c27dfd990f2f9dd1b7456"

URI_aarch64_rust-serde_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_derive-devel-1.0.228-1.el10_1.noarch.rpm;name=aarch64_rust-serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_derive-devel}"
SRC_URI[aarch64_rust-serde_derive-devel.sha256sum] = "2a007dcf8b3d5a93083a99c12a077b219e70f513e23d95fbe70922f618bdaefb"

RDEPENDS:rust-serde_derive+default-devel = " \
 cargo \
 rust-serde_derive-devel \
 "
RDEPENDS:rust-serde_derive+deserialize_in_place-devel = " \
 cargo \
 rust-serde_derive-devel \
 "
RDEPENDS:rust-serde_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+proc-macro-devel \
 rust-proc-macro2-devel \
 rust-quote+proc-macro-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
