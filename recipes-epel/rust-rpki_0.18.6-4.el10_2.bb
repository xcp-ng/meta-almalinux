# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rpki"
PV = "0.18.6"
PR = "4.el10_2"
PACKAGES = " \
 rpki \
 rust-rpki+__windows_ci_all-devel \
 rust-rpki+arbitrary-devel \
 rust-rpki+bcder-devel \
 rust-rpki+ca-devel \
 rust-rpki+compat-devel \
 rust-rpki+crypto-devel \
 rust-rpki+default-devel \
 rust-rpki+futures-util-devel \
 rust-rpki+openssl-devel \
 rust-rpki+quick-xml-devel \
 rust-rpki+repository-devel \
 rust-rpki+ring-devel \
 rust-rpki+rrdp-devel \
 rust-rpki+rtr-devel \
 rust-rpki+serde-devel \
 rust-rpki+serde-support-devel \
 rust-rpki+serde_json-devel \
 rust-rpki+slurm-devel \
 rust-rpki+softkeys-devel \
 rust-rpki+tokio-devel \
 rust-rpki+untrusted-devel \
 rust-rpki+xml-devel \
 rust-rpki-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rpki-0.18.6-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "adc5747401b1d7e8fbad9449bf0aae293d07d66a6a643eb4bef5915f304e7fd9"

URI_x86_64_v2_rpki = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpki-0.18.6-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rpki;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpki}"
SRC_URI[x86_64_v2_rpki.sha256sum] = "381f9322b2880e9c13ca4483bbec37a22f6e23c5a8515b24c13ef3ce3edc7afc"

URI_x86_64_v2_rust-rpki+__windows_ci_all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+__windows_ci_all-devel-0.18.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+__windows_ci_all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+__windows_ci_all-devel}"
SRC_URI[x86_64_v2_rust-rpki+__windows_ci_all-devel.sha256sum] = "81412134d94e9415b7e2df7e98b712cdce878e7d09fbac4a5ac0cd8f1f8f03ff"

URI_x86_64_v2_rust-rpki+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+arbitrary-devel-0.18.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-rpki+arbitrary-devel.sha256sum] = "875088708d6b14322774ba816adf2b7dea87c3edd81bc037e5f369031d6603a8"

URI_x86_64_v2_rust-rpki+bcder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+bcder-devel-0.18.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+bcder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+bcder-devel}"
SRC_URI[x86_64_v2_rust-rpki+bcder-devel.sha256sum] = "56a5186dde2c370e8246934ee357795e4c05d263ed6ba02c4f1905bcc9d0eb20"

URI_x86_64_v2_rust-rpki+ca-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+ca-devel-0.18.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+ca-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+ca-devel}"
SRC_URI[x86_64_v2_rust-rpki+ca-devel.sha256sum] = "4a87fd8e43027a5cf93a1c662d7063aee46428117b86409d69f6d944b8e0e2df"

URI_x86_64_v2_rust-rpki+compat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+compat-devel-0.18.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+compat-devel}"
SRC_URI[x86_64_v2_rust-rpki+compat-devel.sha256sum] = "96053dd24f3c71ecceb95ddee62b06bb9f86f04b7c3235bf12775f026ffd5d4e"

URI_x86_64_v2_rust-rpki+crypto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+crypto-devel-0.18.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+crypto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+crypto-devel}"
SRC_URI[x86_64_v2_rust-rpki+crypto-devel.sha256sum] = "e219de3e4b9e9275948dbee6fc0dc814bf699efd6be5091456d244cb550ee3e5"

URI_x86_64_v2_rust-rpki+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+default-devel-0.18.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+default-devel}"
SRC_URI[x86_64_v2_rust-rpki+default-devel.sha256sum] = "4a75458c18b571acf135f4b77c0f7a4fd55acadfc82e723efad64616ec0709ff"

URI_x86_64_v2_rust-rpki+futures-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+futures-util-devel-0.18.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+futures-util-devel}"
SRC_URI[x86_64_v2_rust-rpki+futures-util-devel.sha256sum] = "82baef13534d1a81128becbfe7c4b139be6740b2b0558493820714b55024248a"

URI_x86_64_v2_rust-rpki+openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+openssl-devel-0.18.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+openssl-devel}"
SRC_URI[x86_64_v2_rust-rpki+openssl-devel.sha256sum] = "7ff7a2883cc9d7832e0392dde14d34eb44870b79677a055686b5ec450443e324"

URI_x86_64_v2_rust-rpki+quick-xml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+quick-xml-devel-0.18.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+quick-xml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+quick-xml-devel}"
SRC_URI[x86_64_v2_rust-rpki+quick-xml-devel.sha256sum] = "1e84ca0b867c6e20d2154adaebae6173ec2aad81de7d79475e3112fc4303b1b4"

URI_x86_64_v2_rust-rpki+repository-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+repository-devel-0.18.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+repository-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+repository-devel}"
SRC_URI[x86_64_v2_rust-rpki+repository-devel.sha256sum] = "7ca4025fff0f815687debd9abef164efc483be5df40461cb64a5fc6d1c9504ed"

URI_x86_64_v2_rust-rpki+ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+ring-devel-0.18.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+ring-devel}"
SRC_URI[x86_64_v2_rust-rpki+ring-devel.sha256sum] = "17772024a66c95ca164f116f91aa6551b6bb04bfcafb2c5dc8e7a9fe0b0fd7f1"

URI_x86_64_v2_rust-rpki+rrdp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+rrdp-devel-0.18.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+rrdp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+rrdp-devel}"
SRC_URI[x86_64_v2_rust-rpki+rrdp-devel.sha256sum] = "d72e6cdcf31b09a7419e6fdaaa8e44607d9ceb00c4c3746b8b9081b8d625f604"

URI_x86_64_v2_rust-rpki+rtr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+rtr-devel-0.18.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+rtr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+rtr-devel}"
SRC_URI[x86_64_v2_rust-rpki+rtr-devel.sha256sum] = "cf6593d9d2f801b05c00b4146b10256db42dfbe431932212e0823a71928d1753"

URI_x86_64_v2_rust-rpki+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+serde-devel-0.18.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+serde-devel}"
SRC_URI[x86_64_v2_rust-rpki+serde-devel.sha256sum] = "dcdd89bc72835021eb79a078d1f7e6afff557d4ecab43d02e3512ad20f7f0878"

URI_x86_64_v2_rust-rpki+serde-support-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+serde-support-devel-0.18.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+serde-support-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+serde-support-devel}"
SRC_URI[x86_64_v2_rust-rpki+serde-support-devel.sha256sum] = "791cf1e928c658dbb4bf913143ae71db0b86435803a44635ea255f23a28d83ce"

URI_x86_64_v2_rust-rpki+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+serde_json-devel-0.18.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+serde_json-devel}"
SRC_URI[x86_64_v2_rust-rpki+serde_json-devel.sha256sum] = "8c27e079ba98ca8eb8309973b4dc838b0baccbb5a42c6cf6a94b3f9db7dd8798"

URI_x86_64_v2_rust-rpki+slurm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+slurm-devel-0.18.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+slurm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+slurm-devel}"
SRC_URI[x86_64_v2_rust-rpki+slurm-devel.sha256sum] = "bd3ae09061822e644b60e4cfcebd6c5b96c88714508df1e9f596f7fe6d10ee53"

URI_x86_64_v2_rust-rpki+softkeys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+softkeys-devel-0.18.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+softkeys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+softkeys-devel}"
SRC_URI[x86_64_v2_rust-rpki+softkeys-devel.sha256sum] = "29073bfff3f76596fc1cbe46865c5cdb135b4517525454a8e44d5cba2fb83c73"

URI_x86_64_v2_rust-rpki+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+tokio-devel-0.18.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+tokio-devel}"
SRC_URI[x86_64_v2_rust-rpki+tokio-devel.sha256sum] = "59b835282aa4bc384096dae4fcaa64b8bdcd69062208b5a789de0b7a1b2a1a1e"

URI_x86_64_v2_rust-rpki+untrusted-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+untrusted-devel-0.18.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+untrusted-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+untrusted-devel}"
SRC_URI[x86_64_v2_rust-rpki+untrusted-devel.sha256sum] = "25a1d61ea660eb019ef1819743743d27cdac9513010f41021327973c56a59ff7"

URI_x86_64_v2_rust-rpki+xml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+xml-devel-0.18.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+xml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+xml-devel}"
SRC_URI[x86_64_v2_rust-rpki+xml-devel.sha256sum] = "c6bab3beb20439a326b47bb1eddde7f0a114ac6912f2af672da25635fce9e8ee"

URI_x86_64_v2_rust-rpki-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki-devel-0.18.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki-devel}"
SRC_URI[x86_64_v2_rust-rpki-devel.sha256sum] = "a71d806a13ad91dcb2ee5bc43dfc837eb908844d80257259926a373d24b389a4"

URI_aarch64_rpki = "${EPEL_MIRROR}/aarch64/Packages/r/rpki-0.18.6-4.el10_2.aarch64.rpm;name=aarch64_rpki;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpki}"
SRC_URI[aarch64_rpki.sha256sum] = "2be64878cbb6b55cf860d6ac82b31b82a7304b61bc68cd15fd1ca5feec055129"

URI_aarch64_rust-rpki+__windows_ci_all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+__windows_ci_all-devel-0.18.6-4.el10_2.noarch.rpm;name=aarch64_rust-rpki+__windows_ci_all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+__windows_ci_all-devel}"
SRC_URI[aarch64_rust-rpki+__windows_ci_all-devel.sha256sum] = "fe2ac4c15cd649ec03a48d881286388a2a7d7b52b2f1a771c7cd43d2856af1d8"

URI_aarch64_rust-rpki+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+arbitrary-devel-0.18.6-4.el10_2.noarch.rpm;name=aarch64_rust-rpki+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+arbitrary-devel}"
SRC_URI[aarch64_rust-rpki+arbitrary-devel.sha256sum] = "79866e26cc1c0c85f8ca6bf32eb59d0f9136741ed1a982c8db1d7aa1f819a064"

URI_aarch64_rust-rpki+bcder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+bcder-devel-0.18.6-4.el10_2.noarch.rpm;name=aarch64_rust-rpki+bcder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+bcder-devel}"
SRC_URI[aarch64_rust-rpki+bcder-devel.sha256sum] = "96d709692802c36f0dd5752c930788fe6fff7268f2a75a59f4f65c7d007146a7"

URI_aarch64_rust-rpki+ca-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+ca-devel-0.18.6-4.el10_2.noarch.rpm;name=aarch64_rust-rpki+ca-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+ca-devel}"
SRC_URI[aarch64_rust-rpki+ca-devel.sha256sum] = "20842b2c6f5f22896d9901f3107b268a642cbc5766c75d31f2fe6c0515e230c7"

URI_aarch64_rust-rpki+compat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+compat-devel-0.18.6-4.el10_2.noarch.rpm;name=aarch64_rust-rpki+compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+compat-devel}"
SRC_URI[aarch64_rust-rpki+compat-devel.sha256sum] = "cab33a67d3dfdb3d809cea8871e79974551f0ce25f90645c7b3aae454f652778"

URI_aarch64_rust-rpki+crypto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+crypto-devel-0.18.6-4.el10_2.noarch.rpm;name=aarch64_rust-rpki+crypto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+crypto-devel}"
SRC_URI[aarch64_rust-rpki+crypto-devel.sha256sum] = "c988c5aadc6495ff52962887dc3478dd77ccf254e3bdcc47b14311abad366c4b"

URI_aarch64_rust-rpki+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+default-devel-0.18.6-4.el10_2.noarch.rpm;name=aarch64_rust-rpki+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+default-devel}"
SRC_URI[aarch64_rust-rpki+default-devel.sha256sum] = "6a01b10adfaf95fb3bec281631570ef8c91a56fef8683380541b2c5ec6539782"

URI_aarch64_rust-rpki+futures-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+futures-util-devel-0.18.6-4.el10_2.noarch.rpm;name=aarch64_rust-rpki+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+futures-util-devel}"
SRC_URI[aarch64_rust-rpki+futures-util-devel.sha256sum] = "c482fee8819342b97103503afe3ce39ffc560b2b98b23205b9937d6c8943225a"

URI_aarch64_rust-rpki+openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+openssl-devel-0.18.6-4.el10_2.noarch.rpm;name=aarch64_rust-rpki+openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+openssl-devel}"
SRC_URI[aarch64_rust-rpki+openssl-devel.sha256sum] = "b15d2455f2c84125daef1cb19f1b0fa2a85b4bd4fefaae32e628c4ad6d6120e6"

URI_aarch64_rust-rpki+quick-xml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+quick-xml-devel-0.18.6-4.el10_2.noarch.rpm;name=aarch64_rust-rpki+quick-xml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+quick-xml-devel}"
SRC_URI[aarch64_rust-rpki+quick-xml-devel.sha256sum] = "d3f59d8c19e9af40d103a322b8c5fef4c9c2711c651b801effd5b1fe51c9a4a0"

URI_aarch64_rust-rpki+repository-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+repository-devel-0.18.6-4.el10_2.noarch.rpm;name=aarch64_rust-rpki+repository-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+repository-devel}"
SRC_URI[aarch64_rust-rpki+repository-devel.sha256sum] = "6b0fafc1491320a29b62ead6a85e90c67019e64ab8febddb8c3f826ad7156f3c"

URI_aarch64_rust-rpki+ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+ring-devel-0.18.6-4.el10_2.noarch.rpm;name=aarch64_rust-rpki+ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+ring-devel}"
SRC_URI[aarch64_rust-rpki+ring-devel.sha256sum] = "1f1e094005936ee1405768c2156438ddf53bd266c4dac3b44a742f3d86433682"

URI_aarch64_rust-rpki+rrdp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+rrdp-devel-0.18.6-4.el10_2.noarch.rpm;name=aarch64_rust-rpki+rrdp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+rrdp-devel}"
SRC_URI[aarch64_rust-rpki+rrdp-devel.sha256sum] = "ece1bdf3f8b3270932dabaf88df8664aef0cc24c4cbd1d60d2142877d397fbb2"

URI_aarch64_rust-rpki+rtr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+rtr-devel-0.18.6-4.el10_2.noarch.rpm;name=aarch64_rust-rpki+rtr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+rtr-devel}"
SRC_URI[aarch64_rust-rpki+rtr-devel.sha256sum] = "d2096714ce45650cf42be35bb5e676c3fd4e6acea91a3a876c4c86c8b35ea17e"

URI_aarch64_rust-rpki+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+serde-devel-0.18.6-4.el10_2.noarch.rpm;name=aarch64_rust-rpki+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+serde-devel}"
SRC_URI[aarch64_rust-rpki+serde-devel.sha256sum] = "48a06b7849bd7c0e1114e6c195e215a68edc750f1d87b270e513f4929f2f4f5a"

URI_aarch64_rust-rpki+serde-support-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+serde-support-devel-0.18.6-4.el10_2.noarch.rpm;name=aarch64_rust-rpki+serde-support-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+serde-support-devel}"
SRC_URI[aarch64_rust-rpki+serde-support-devel.sha256sum] = "a2eba16a8ea08113f6d9e5a59a5d2306e4f237b546fec9ca511ac137a40cafdb"

URI_aarch64_rust-rpki+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+serde_json-devel-0.18.6-4.el10_2.noarch.rpm;name=aarch64_rust-rpki+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+serde_json-devel}"
SRC_URI[aarch64_rust-rpki+serde_json-devel.sha256sum] = "3ca2a26921ae533cd48a3c5f0d1545d25e3999b9e118b7a4f3aba20afdbe472c"

URI_aarch64_rust-rpki+slurm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+slurm-devel-0.18.6-4.el10_2.noarch.rpm;name=aarch64_rust-rpki+slurm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+slurm-devel}"
SRC_URI[aarch64_rust-rpki+slurm-devel.sha256sum] = "4ae95b639d9ed48be1d429ced0bc91138804139c2a2538d0f8b2585b636c133f"

URI_aarch64_rust-rpki+softkeys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+softkeys-devel-0.18.6-4.el10_2.noarch.rpm;name=aarch64_rust-rpki+softkeys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+softkeys-devel}"
SRC_URI[aarch64_rust-rpki+softkeys-devel.sha256sum] = "ca29b40895c11fda3da70baf9958c1d7841f0697fd98ac6815b61a6cc9a97d29"

URI_aarch64_rust-rpki+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+tokio-devel-0.18.6-4.el10_2.noarch.rpm;name=aarch64_rust-rpki+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+tokio-devel}"
SRC_URI[aarch64_rust-rpki+tokio-devel.sha256sum] = "1800947441a083c8f6ba5a90349e92922dddd154e94698219835c6b8f801a1c3"

URI_aarch64_rust-rpki+untrusted-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+untrusted-devel-0.18.6-4.el10_2.noarch.rpm;name=aarch64_rust-rpki+untrusted-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+untrusted-devel}"
SRC_URI[aarch64_rust-rpki+untrusted-devel.sha256sum] = "6a4c648db9d016b975e7028941688a699eac39af4ff348d0112e0dc8674a5dca"

URI_aarch64_rust-rpki+xml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+xml-devel-0.18.6-4.el10_2.noarch.rpm;name=aarch64_rust-rpki+xml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+xml-devel}"
SRC_URI[aarch64_rust-rpki+xml-devel.sha256sum] = "149a716995d0cf8fa7973c9ee06b218562562ab0ea4335222a8ff0b509110212"

URI_aarch64_rust-rpki-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki-devel-0.18.6-4.el10_2.noarch.rpm;name=aarch64_rust-rpki-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki-devel}"
SRC_URI[aarch64_rust-rpki-devel.sha256sum] = "6a91996739ec7c4449d08800e05c410ce2f70f5f76a25189047204320e7607b2"

RDEPENDS:rpki = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-rpki+__windows_ci_all-devel = " \
 cargo \
 rust-rpki+ca-devel \
 rust-rpki+rrdp-devel \
 rust-rpki+rtr-devel \
 rust-rpki+serde-support-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-chrono+arbitrary-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+bcder-devel = " \
 cargo \
 rust-bcder+default-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+ca-devel = " \
 cargo \
 rust-rpki+repository-devel \
 rust-rpki+rrdp-devel \
 rust-rpki+serde-support-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+compat-devel = " \
 cargo \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+crypto-devel = " \
 cargo \
 rust-rpki+bcder-devel \
 rust-rpki+ring-devel \
 rust-rpki+untrusted-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+default-devel = " \
 cargo \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+futures-util-devel = " \
 cargo \
 rust-futures-util+default-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+openssl-devel = " \
 cargo \
 rust-openssl+default-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+quick-xml-devel = " \
 cargo \
 rust-quick-xml0.31+default-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+repository-devel = " \
 cargo \
 rust-rpki+bcder-devel \
 rust-rpki+crypto-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+ring-devel = " \
 cargo \
 rust-ring+default-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+rrdp-devel = " \
 cargo \
 rust-rpki+ring-devel \
 rust-rpki+xml-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+rtr-devel = " \
 cargo \
 rust-rpki+futures-util-devel \
 rust-rpki+tokio-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+serde-devel = " \
 cargo \
 rust-rpki-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rpki+serde-support-devel = " \
 cargo \
 rust-rpki+serde-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+serde_json-devel = " \
 cargo \
 rust-rpki-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-rpki+slurm-devel = " \
 cargo \
 rust-rpki+rtr-devel \
 rust-rpki+serde-support-devel \
 rust-rpki+serde_json-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+softkeys-devel = " \
 cargo \
 rust-rpki+openssl-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+tokio-devel = " \
 cargo \
 rust-rpki-devel \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio+net-devel \
 rust-tokio+rt-devel \
 rust-tokio+sync-devel \
 rust-tokio+time-devel \
 "
RDEPENDS:rust-rpki+untrusted-devel = " \
 cargo \
 rust-rpki-devel \
 rust-untrusted+default-devel \
 "
RDEPENDS:rust-rpki+xml-devel = " \
 cargo \
 rust-rpki+quick-xml-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki-devel = " \
 cargo \
 rust \
 rust-base64+default-devel \
 rust-bytes+default-devel \
 rust-chrono+default-devel \
 rust-chrono+serde-devel \
 rust-log+default-devel \
 rust-uuid+default-devel \
 "
