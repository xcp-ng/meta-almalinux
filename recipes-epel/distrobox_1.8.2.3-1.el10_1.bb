# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "distrobox"
PV = "1.8.2.3"
PR = "1.el10_1"
PACKAGES = " \
 distrobox \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/distrobox-1.8.2.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4ceaad16252f714f534848776e824feade74032b129da26e8025c4c4bef9068"

URI_x86_64_v2_distrobox = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/distrobox-1.8.2.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_distrobox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_distrobox}"
SRC_URI[x86_64_v2_distrobox.sha256sum] = "c128f906113530d9040db544011589d7912644ab0e8f7dd9b960c4cbeb9dd2ea"

URI_aarch64_distrobox = "${EPEL_MIRROR}/aarch64/Packages/d/distrobox-1.8.2.3-1.el10_1.noarch.rpm;name=aarch64_distrobox;unpack=0"
SRC_URI:append = " ${URI_aarch64_distrobox}"
SRC_URI[aarch64_distrobox.sha256sum] = "97682f5a0c40c9d9495e6c07171b0ea9fc914e8c2268ddba4739b6de31d72f0a"

RDEPENDS:distrobox = " \
 bash \
 findutils \
 grep \
 hicolor-icon-theme \
 sed \
 virtual//usr/bin/basename \
 virtual/podman_or_/usr/bin/docker \
 "
