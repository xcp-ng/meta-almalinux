# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-urwid"
PV = "2.5.3"
PR = "4.el10"
PACKAGES = " \
 python3-urwid \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python-urwid-2.5.3-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7282cdbef56472d123c5ceff770b818c268c260de37b3bbd562d9c5f36db7a3"

URI_x86_64_v2_python3-urwid = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-urwid-2.5.3-4.el10.x86_64_v2.rpm;name=x86_64_v2_python3-urwid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-urwid}"
SRC_URI[x86_64_v2_python3-urwid.sha256sum] = "4859cbb0b5a96e5d93e77216941b749d8a2e8886e88c212f0fe605ef8c17ae3f"

URI_aarch64_python3-urwid = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-urwid-2.5.3-4.el10.aarch64.rpm;name=aarch64_python3-urwid;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-urwid}"
SRC_URI[aarch64_python3-urwid.sha256sum] = "5d5d79da18b4405068c09be30ad5bd5e51f6077f779a033c076674c1ee45dfdd"

RDEPENDS:python3-urwid = " \
 glibc \
 python3 \
 python3-typing-extensions \
 python3-wcwidth \
 "
