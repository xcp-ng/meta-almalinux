# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-strict-rfc3339"
PV = "0.7"
PR = "16.el10_0"
PACKAGES = " \
 python3-strict-rfc3339 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-strict-rfc3339-0.7-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e12659b19fdfdd97689e8820de839700937df53316fa4e6271a22504fbc83b54"

URI_x86_64_v2_python3-strict-rfc3339 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-strict-rfc3339-0.7-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-strict-rfc3339;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-strict-rfc3339}"
SRC_URI[x86_64_v2_python3-strict-rfc3339.sha256sum] = "845e466ce6bf603d5fdb5685bf647c4eea0426f7fee1ce63962358ed32172d4f"

URI_aarch64_python3-strict-rfc3339 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-strict-rfc3339-0.7-16.el10_0.noarch.rpm;name=aarch64_python3-strict-rfc3339;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-strict-rfc3339}"
SRC_URI[aarch64_python3-strict-rfc3339.sha256sum] = "bb00b01694d8c6bcb858e5ba632cf5825f07132ae91240208e66c9bb6e4227f6"

RDEPENDS:python3-strict-rfc3339 = " \
 python3 \
 "
