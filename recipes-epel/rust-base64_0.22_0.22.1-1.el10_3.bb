# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-base64_0.22"
PV = "0.22.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-base64_0.22+alloc-devel \
 rust-base64_0.22+default-devel \
 rust-base64_0.22+std-devel \
 rust-base64_0.22-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-base64_0.22-0.22.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b18f338623ce62f42d017e57a043f0082ec26f5a09a57a3cc73dd52590bad5ad"

URI_x86_64_v2_rust-base64_0.22+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64_0.22+alloc-devel-0.22.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64_0.22+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64_0.22+alloc-devel}"
SRC_URI[x86_64_v2_rust-base64_0.22+alloc-devel.sha256sum] = "907c9e58cce29b63fb54a066ffd2d3cbea60fa8295dadcd5e573aa217f4eb009"

URI_x86_64_v2_rust-base64_0.22+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64_0.22+default-devel-0.22.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64_0.22+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64_0.22+default-devel}"
SRC_URI[x86_64_v2_rust-base64_0.22+default-devel.sha256sum] = "760bf3acbeeb815c9be82c070ee89375ea254cf3e96a7ceb9117aed3999d302f"

URI_x86_64_v2_rust-base64_0.22+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64_0.22+std-devel-0.22.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64_0.22+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64_0.22+std-devel}"
SRC_URI[x86_64_v2_rust-base64_0.22+std-devel.sha256sum] = "fb748923e0444315732a56ecb065e8517ca8f0271cebf717de3f816a6b227b08"

URI_x86_64_v2_rust-base64_0.22-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64_0.22-devel-0.22.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64_0.22-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64_0.22-devel}"
SRC_URI[x86_64_v2_rust-base64_0.22-devel.sha256sum] = "08d97c8da8357d444a3248d7f6a60a5d3b6d398f1908e4e088ed772d83aacdd1"

URI_aarch64_rust-base64_0.22+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64_0.22+alloc-devel-0.22.1-1.el10_3.noarch.rpm;name=aarch64_rust-base64_0.22+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64_0.22+alloc-devel}"
SRC_URI[aarch64_rust-base64_0.22+alloc-devel.sha256sum] = "13e576d590e018ab5c9e6850e53d596f83aa66e51cde9a5ba17cfb6e5e93b896"

URI_aarch64_rust-base64_0.22+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64_0.22+default-devel-0.22.1-1.el10_3.noarch.rpm;name=aarch64_rust-base64_0.22+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64_0.22+default-devel}"
SRC_URI[aarch64_rust-base64_0.22+default-devel.sha256sum] = "bbb8b5d673f24fd1f5faa4612638ec63f2221dc51d19c890aa0dab6115c3fc0c"

URI_aarch64_rust-base64_0.22+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64_0.22+std-devel-0.22.1-1.el10_3.noarch.rpm;name=aarch64_rust-base64_0.22+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64_0.22+std-devel}"
SRC_URI[aarch64_rust-base64_0.22+std-devel.sha256sum] = "f08fefae3af2f7a5dd52ebb362753ebd6d664a92659ebebaae7e7070321e2e73"

URI_aarch64_rust-base64_0.22-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64_0.22-devel-0.22.1-1.el10_3.noarch.rpm;name=aarch64_rust-base64_0.22-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64_0.22-devel}"
SRC_URI[aarch64_rust-base64_0.22-devel.sha256sum] = "bccb066e1cb873239682b3d4af346ba18269bcc553cd5c84359c6ab756e21447"

RDEPENDS:rust-base64_0.22+alloc-devel = " \
 cargo \
 rust-base64_0.22-devel \
 "
RDEPENDS:rust-base64_0.22+default-devel = " \
 cargo \
 rust-base64_0.22+std-devel \
 rust-base64_0.22-devel \
 "
RDEPENDS:rust-base64_0.22+std-devel = " \
 cargo \
 rust-base64_0.22+alloc-devel \
 rust-base64_0.22-devel \
 "
RDEPENDS:rust-base64_0.22-devel = " \
 cargo \
 rust \
 "
