# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-prost-types"
PV = "0.14.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-prost-types+arbitrary-devel \
 rust-prost-types+chrono-devel \
 rust-prost-types+default-devel \
 rust-prost-types+std-devel \
 rust-prost-types-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-prost-types-0.14.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3604dd4f0164a4b26ed9ecc09e2d22eb4decf9ff216d6797e10a02aa22495b3"

URI_x86_64_v2_rust-prost-types+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prost-types+arbitrary-devel-0.14.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prost-types+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prost-types+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-prost-types+arbitrary-devel.sha256sum] = "a723ed00f32f22819d1af0e65aa66a3a79f4f0973fa3f422f5160821238e99ca"

URI_x86_64_v2_rust-prost-types+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prost-types+chrono-devel-0.14.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prost-types+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prost-types+chrono-devel}"
SRC_URI[x86_64_v2_rust-prost-types+chrono-devel.sha256sum] = "3447c57e0bfb8053decedde38488393dc53c450788513a1e27a60e27d2668317"

URI_x86_64_v2_rust-prost-types+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prost-types+default-devel-0.14.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prost-types+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prost-types+default-devel}"
SRC_URI[x86_64_v2_rust-prost-types+default-devel.sha256sum] = "33d8598bc4920e098e616c7a68d3db1f3bd6318e2f450cb0ee94fff80fdef104"

URI_x86_64_v2_rust-prost-types+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prost-types+std-devel-0.14.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prost-types+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prost-types+std-devel}"
SRC_URI[x86_64_v2_rust-prost-types+std-devel.sha256sum] = "14cb5d22f6f334eced92446af62604f9dc41e89a4e16597c6df2e6110fc083cf"

URI_x86_64_v2_rust-prost-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prost-types-devel-0.14.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prost-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prost-types-devel}"
SRC_URI[x86_64_v2_rust-prost-types-devel.sha256sum] = "96fec42bb9c771de721e2ed2df418778152de111adb3b7a58a94f2248397474c"

URI_aarch64_rust-prost-types+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prost-types+arbitrary-devel-0.14.3-1.el10_3.noarch.rpm;name=aarch64_rust-prost-types+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prost-types+arbitrary-devel}"
SRC_URI[aarch64_rust-prost-types+arbitrary-devel.sha256sum] = "00fc08bff622281dacc57cfbc34416641d48ffae3c5392e4e68da94021a02972"

URI_aarch64_rust-prost-types+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prost-types+chrono-devel-0.14.3-1.el10_3.noarch.rpm;name=aarch64_rust-prost-types+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prost-types+chrono-devel}"
SRC_URI[aarch64_rust-prost-types+chrono-devel.sha256sum] = "76126af9eb0d9d4e0edd5916fcf4692c0a46fb69748243d3f19b2503c0e67ff7"

URI_aarch64_rust-prost-types+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prost-types+default-devel-0.14.3-1.el10_3.noarch.rpm;name=aarch64_rust-prost-types+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prost-types+default-devel}"
SRC_URI[aarch64_rust-prost-types+default-devel.sha256sum] = "8e3f4334b8a0eed1eb3eecf5592f0e6db0f30002cce94cf24df66ecf4ea0a344"

URI_aarch64_rust-prost-types+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prost-types+std-devel-0.14.3-1.el10_3.noarch.rpm;name=aarch64_rust-prost-types+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prost-types+std-devel}"
SRC_URI[aarch64_rust-prost-types+std-devel.sha256sum] = "d43efb990b9cd86d6c904032a3ddf03cfa2bbc4f1c794585edafd7d9e1f6d4b7"

URI_aarch64_rust-prost-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prost-types-devel-0.14.3-1.el10_3.noarch.rpm;name=aarch64_rust-prost-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prost-types-devel}"
SRC_URI[aarch64_rust-prost-types-devel.sha256sum] = "40926a73db5c3cac334f3b1af443d9953d52c33c3f60cfe68a483b9f52144c6f"

RDEPENDS:rust-prost-types+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-prost-types-devel \
 "
RDEPENDS:rust-prost-types+chrono-devel = " \
 cargo \
 rust-chrono-devel \
 rust-prost-types-devel \
 "
RDEPENDS:rust-prost-types+default-devel = " \
 cargo \
 rust-prost-types+std-devel \
 rust-prost-types-devel \
 "
RDEPENDS:rust-prost-types+std-devel = " \
 cargo \
 rust-prost+std-devel \
 rust-prost-types-devel \
 "
RDEPENDS:rust-prost-types-devel = " \
 cargo \
 rust \
 rust-prost+derive-devel \
 rust-prost-devel \
 "
