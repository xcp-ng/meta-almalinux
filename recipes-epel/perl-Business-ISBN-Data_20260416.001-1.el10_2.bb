# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Business-ISBN-Data"
PV = "20260416.001"
PR = "1.el10_2"
PACKAGES = " \
 perl-Business-ISBN-Data \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Business-ISBN-Data-20260416.001-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb6d3ad76063fe67340caef828001de068abfd76a4103245cdf169438fcb9555"

URI_x86_64_v2_perl-Business-ISBN-Data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Business-ISBN-Data-20260416.001-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Business-ISBN-Data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Business-ISBN-Data}"
SRC_URI[x86_64_v2_perl-Business-ISBN-Data.sha256sum] = "38cd66eaaa93b77803b2f3331fe5b9cb69d334189b967ef697fce1c3f6c79a28"

URI_aarch64_perl-Business-ISBN-Data = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Business-ISBN-Data-20260416.001-1.el10_2.noarch.rpm;name=aarch64_perl-Business-ISBN-Data;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Business-ISBN-Data}"
SRC_URI[aarch64_perl-Business-ISBN-Data.sha256sum] = "7661418d4f17f372495c63582a1fc8b9e65afee1d0834f96b2f90d67ec55f170"

RDEPENDS:perl-Business-ISBN-Data = " \
 perl-Carp \
 perl-File-Basename \
 perl-PathTools \
 perl-libs \
 "
