# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdegraphics-mobipocket"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kdegraphics-mobipocket \
 kdegraphics-mobipocket-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdegraphics-mobipocket-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91feae28f95b6f8abef6cf18657750ac4580ecc6dd7f24f4a4cc1f6425df8df5"

URI_x86_64_v2_kdegraphics-mobipocket = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdegraphics-mobipocket-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdegraphics-mobipocket;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdegraphics-mobipocket}"
SRC_URI[x86_64_v2_kdegraphics-mobipocket.sha256sum] = "8e819d9d69756c6b6a787d7fa4820545ef2f5d9d5e649f3cd5f2fcfbf69e98cd"

URI_x86_64_v2_kdegraphics-mobipocket-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdegraphics-mobipocket-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdegraphics-mobipocket-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdegraphics-mobipocket-devel}"
SRC_URI[x86_64_v2_kdegraphics-mobipocket-devel.sha256sum] = "1d00577b0a8ca5ed877756af55429f0750fbe6bc0c1c696c21a24b5f65ab5efa"

URI_aarch64_kdegraphics-mobipocket = "${EPEL_MIRROR}/aarch64/Packages/k/kdegraphics-mobipocket-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kdegraphics-mobipocket;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdegraphics-mobipocket}"
SRC_URI[aarch64_kdegraphics-mobipocket.sha256sum] = "6a810802195bdf619b7d6b2e8e95aa0a5cbb7adb4b50bbc0ef1dee4d3d26c87c"

URI_aarch64_kdegraphics-mobipocket-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kdegraphics-mobipocket-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kdegraphics-mobipocket-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdegraphics-mobipocket-devel}"
SRC_URI[aarch64_kdegraphics-mobipocket-devel.sha256sum] = "832eb716ebbdef06a0171b42f49bbc49cacbc6f6c7b049c13d07a50abfac3e5e"

RDEPENDS:kdegraphics-mobipocket = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kdegraphics-mobipocket-devel = " \
 cmake-filesystem \
 kdegraphics-mobipocket \
 "
