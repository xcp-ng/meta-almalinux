# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-below-dump"
PV = "0.9.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-below-dump+default-devel \
 rust-below-dump-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-below-dump-0.9.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "51af4f1f4014db42679a1e31a386750f39625776174835657ca8be0447d45f1b"

URI_x86_64_v2_rust-below-dump+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-dump+default-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-dump+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-dump+default-devel}"
SRC_URI[x86_64_v2_rust-below-dump+default-devel.sha256sum] = "64c45419b4ece21afe73856a87d95a33cb0914c15fd43fabfe402ef1c154dbfa"

URI_x86_64_v2_rust-below-dump-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-dump-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-dump-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-dump-devel}"
SRC_URI[x86_64_v2_rust-below-dump-devel.sha256sum] = "02a858f7c1c61500ddec321b2f1906dbcfbd57f8e688af1f1bef587d07dfd765"

URI_aarch64_rust-below-dump+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-dump+default-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-below-dump+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-dump+default-devel}"
SRC_URI[aarch64_rust-below-dump+default-devel.sha256sum] = "e96de9b1e5e78d1a6fa15b7fa4a975c2bc512fd7224fc394ad2d45e0c783efbc"

URI_aarch64_rust-below-dump-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-dump-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-below-dump-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-dump-devel}"
SRC_URI[aarch64_rust-below-dump-devel.sha256sum] = "39a000f6ebecf5ef7677d63453e305ce78f06eb5e0a4c3086dc8d35b06bb6ac0"

RDEPENDS:rust-below-dump+default-devel = " \
 cargo \
 rust-below-dump-devel \
 "
RDEPENDS:rust-below-dump-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-below-common+default-devel \
 rust-below-model+default-devel \
 rust-below-render+default-devel \
 rust-below-store+default-devel \
 rust-below_derive+default-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-clap+env-devel \
 rust-clap+string-devel \
 rust-clap+unicode-devel \
 rust-clap+wrap_help-devel \
 rust-enum-iterator+default-devel \
 rust-once_cell+default-devel \
 rust-regex+default-devel \
 rust-serde_json+default-devel \
 rust-serde_json+float_roundtrip-devel \
 rust-serde_json+unbounded_depth-devel \
 rust-slog+default-devel \
 rust-slog+max_level_trace-devel \
 rust-slog+nested-values-devel \
 rust-tar+default-devel \
 rust-tempfile+default-devel \
 rust-toml+default-devel \
 "
