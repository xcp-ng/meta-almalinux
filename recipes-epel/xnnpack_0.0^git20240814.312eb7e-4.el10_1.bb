# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xnnpack"
PV = "0.0^git20240814.312eb7e"
PR = "4.el10_1"
PACKAGES = " \
 xnnpack \
 xnnpack-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xnnpack-0.0^git20240814.312eb7e-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "176266e16420c204b4954e5b298494d0c669e6f0465f6a2fa3b757520eae4087"

URI_x86_64_v2_xnnpack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xnnpack-0.0^git20240814.312eb7e-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xnnpack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xnnpack}"
SRC_URI[x86_64_v2_xnnpack.sha256sum] = "602181e2ac25d94079bc2d1833b8c3cddd4358300fd6671ab034080ed045e662"

URI_x86_64_v2_xnnpack-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xnnpack-devel-0.0^git20240814.312eb7e-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xnnpack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xnnpack-devel}"
SRC_URI[x86_64_v2_xnnpack-devel.sha256sum] = "08739cd12825d0ca13385e1a557def2b00f2d23a2dececc9ad2fdf1d68b67206"

URI_aarch64_xnnpack = "${EPEL_MIRROR}/aarch64/Packages/x/xnnpack-0.0^git20240814.312eb7e-4.el10_1.aarch64.rpm;name=aarch64_xnnpack;unpack=0"
SRC_URI:append = " ${URI_aarch64_xnnpack}"
SRC_URI[aarch64_xnnpack.sha256sum] = "ac168afb38ffc4cd7a68025e58d13f8f4239550cc9ba231bda61c5de50149a64"

URI_aarch64_xnnpack-devel = "${EPEL_MIRROR}/aarch64/Packages/x/xnnpack-devel-0.0^git20240814.312eb7e-4.el10_1.aarch64.rpm;name=aarch64_xnnpack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xnnpack-devel}"
SRC_URI[aarch64_xnnpack-devel.sha256sum] = "519202be9c79e716d3b92e1a305a87114a6663a4627e1dcacc9245306f317f2d"

RDEPENDS:xnnpack:x86_64_v2 = " \
 cpuinfo \
 glibc \
 pthreadpool \
"
RDEPENDS:xnnpack:aarch64 = " \
 cpuinfo \
 glibc \
 libgcc \
 pthreadpool \
"
RDEPENDS:xnnpack-devel = " \
 xnnpack \
 "
