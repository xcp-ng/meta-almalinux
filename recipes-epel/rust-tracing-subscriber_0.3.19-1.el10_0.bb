# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tracing-subscriber"
PV = "0.3.19"
PR = "1.el10_0"
PACKAGES = " \
 rust-tracing-subscriber+alloc-devel \
 rust-tracing-subscriber+ansi-devel \
 rust-tracing-subscriber+chrono-devel \
 rust-tracing-subscriber+default-devel \
 rust-tracing-subscriber+env-filter-devel \
 rust-tracing-subscriber+fmt-devel \
 rust-tracing-subscriber+json-devel \
 rust-tracing-subscriber+local-time-devel \
 rust-tracing-subscriber+matchers-devel \
 rust-tracing-subscriber+nu-ansi-term-devel \
 rust-tracing-subscriber+once_cell-devel \
 rust-tracing-subscriber+parking_lot-devel \
 rust-tracing-subscriber+regex-devel \
 rust-tracing-subscriber+registry-devel \
 rust-tracing-subscriber+serde-devel \
 rust-tracing-subscriber+serde_json-devel \
 rust-tracing-subscriber+sharded-slab-devel \
 rust-tracing-subscriber+smallvec-devel \
 rust-tracing-subscriber+std-devel \
 rust-tracing-subscriber+thread_local-devel \
 rust-tracing-subscriber+time-devel \
 rust-tracing-subscriber+tracing-devel \
 rust-tracing-subscriber+tracing-log-devel \
 rust-tracing-subscriber+tracing-serde-devel \
 rust-tracing-subscriber-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tracing-subscriber-0.3.19-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e04d7b7c37a5f9c678b873a8e366ef4417ad37386c7cf70d5ae7d73356265c0"

URI_x86_64_v2_rust-tracing-subscriber+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+alloc-devel-0.3.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+alloc-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+alloc-devel.sha256sum] = "d0300f6b8e19ab36648e900f7dae361d0266f35b3b42d7a13d23e1be97e4c7ed"

URI_x86_64_v2_rust-tracing-subscriber+ansi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+ansi-devel-0.3.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+ansi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+ansi-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+ansi-devel.sha256sum] = "530638c68781c9d7ef261f2c27621af69e1810c6f1c2ae4c4b2b3767cb9a3c8f"

URI_x86_64_v2_rust-tracing-subscriber+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+chrono-devel-0.3.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+chrono-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+chrono-devel.sha256sum] = "6abbb39c94405b38ade196cdd564f0cec5948d3f698033d51657fc800f82660f"

URI_x86_64_v2_rust-tracing-subscriber+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+default-devel-0.3.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+default-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+default-devel.sha256sum] = "5dbc6c54b318f2a90736d46aafc4a1849822a31c2b189e5adb4133cf8e64ec74"

URI_x86_64_v2_rust-tracing-subscriber+env-filter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+env-filter-devel-0.3.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+env-filter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+env-filter-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+env-filter-devel.sha256sum] = "92ae6b7e05acc06d2a9432c1187c8707162b9c9ca2f9304c60010c22c09693b1"

URI_x86_64_v2_rust-tracing-subscriber+fmt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+fmt-devel-0.3.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+fmt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+fmt-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+fmt-devel.sha256sum] = "05bfbfdff03e2c18c7b24c2ffe495d3ad703fd19b8aab3a769f72d2428c72b3c"

URI_x86_64_v2_rust-tracing-subscriber+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+json-devel-0.3.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+json-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+json-devel.sha256sum] = "3ecbb9461da28efe3b203da5438f1970d3071ad10c66082d12dccd926ef28828"

URI_x86_64_v2_rust-tracing-subscriber+local-time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+local-time-devel-0.3.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+local-time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+local-time-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+local-time-devel.sha256sum] = "326b44d579ef29fda5ab993a91389c8d78134101e10d26526c6590828f70614c"

URI_x86_64_v2_rust-tracing-subscriber+matchers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+matchers-devel-0.3.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+matchers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+matchers-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+matchers-devel.sha256sum] = "cdf82662a3334e3dad9dd432471403923298463d169849ead82ce8333dd0ebbd"

URI_x86_64_v2_rust-tracing-subscriber+nu-ansi-term-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+nu-ansi-term-devel-0.3.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+nu-ansi-term-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+nu-ansi-term-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+nu-ansi-term-devel.sha256sum] = "42cf7a1a2791372931af737678347eb5054218d208ae8521045460002eca6be2"

URI_x86_64_v2_rust-tracing-subscriber+once_cell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+once_cell-devel-0.3.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+once_cell-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+once_cell-devel.sha256sum] = "c8994250dd869d0342347bafc38b7afa7e869a5f334476d9e7760406469b89cb"

URI_x86_64_v2_rust-tracing-subscriber+parking_lot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+parking_lot-devel-0.3.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+parking_lot-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+parking_lot-devel.sha256sum] = "22650d8dfa49ae8e6cf05a06717131d46f1a4ecd171369ced91f4433c79cbd93"

URI_x86_64_v2_rust-tracing-subscriber+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+regex-devel-0.3.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+regex-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+regex-devel.sha256sum] = "b9670f48b595753af8ec04918a66e07d3a5a2f6925bb357db79b2ccfa1bb2cb3"

URI_x86_64_v2_rust-tracing-subscriber+registry-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+registry-devel-0.3.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+registry-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+registry-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+registry-devel.sha256sum] = "c9bcbc6af12e05ddbec530a900417197f4c3a2a4e53308f04b23019616190b6a"

URI_x86_64_v2_rust-tracing-subscriber+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+serde-devel-0.3.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+serde-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+serde-devel.sha256sum] = "50b9d8efb45b2ac8c5206282932e3da8f4b9f3e69ae4eb2ad7d31f694e35d4dc"

URI_x86_64_v2_rust-tracing-subscriber+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+serde_json-devel-0.3.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+serde_json-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+serde_json-devel.sha256sum] = "ed6a89bd98581148d4ba78b0975ea0baf438902e6d387a90e7a36939d16128ae"

URI_x86_64_v2_rust-tracing-subscriber+sharded-slab-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+sharded-slab-devel-0.3.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+sharded-slab-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+sharded-slab-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+sharded-slab-devel.sha256sum] = "5e78fb9b3dc3fc1a1dff2cf9eb668fe9ab7f1f7c77734a87c4d97da722e33833"

URI_x86_64_v2_rust-tracing-subscriber+smallvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+smallvec-devel-0.3.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+smallvec-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+smallvec-devel.sha256sum] = "b9c8fe220a87d8bf638a3181b779209059dd582b1c0049625f181bcaed345ae5"

URI_x86_64_v2_rust-tracing-subscriber+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+std-devel-0.3.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+std-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+std-devel.sha256sum] = "9e091b3d1d9ac6353c41ecce64b897bf82842526f5009e5bc452f2e3a1a02143"

URI_x86_64_v2_rust-tracing-subscriber+thread_local-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+thread_local-devel-0.3.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+thread_local-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+thread_local-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+thread_local-devel.sha256sum] = "4527e2276b71156fb081ab218cd6286edc1724f45ab7ca24a08c354485695f52"

URI_x86_64_v2_rust-tracing-subscriber+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+time-devel-0.3.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+time-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+time-devel.sha256sum] = "2433bf681352dc180e9268f5b16edcd7e28b8808384b1eef5e7afe8f5f9f1101"

URI_x86_64_v2_rust-tracing-subscriber+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+tracing-devel-0.3.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+tracing-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+tracing-devel.sha256sum] = "01005efda5c22e6b02b2405c31bceb8c6da05423c2201160d5d76fe7cd8e4cff"

URI_x86_64_v2_rust-tracing-subscriber+tracing-log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+tracing-log-devel-0.3.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+tracing-log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+tracing-log-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+tracing-log-devel.sha256sum] = "cd79b906334c19353c9e1ec3f18156a09dd253cdec56493f7856f163d4d04627"

URI_x86_64_v2_rust-tracing-subscriber+tracing-serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+tracing-serde-devel-0.3.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+tracing-serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+tracing-serde-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+tracing-serde-devel.sha256sum] = "d0e32608fc9c16d22c1aaa015b895090d32e54e1d057737d7b1094927a00a682"

URI_x86_64_v2_rust-tracing-subscriber-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber-devel-0.3.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber-devel.sha256sum] = "c68a6ce1acde774669ade848aa8c78f5a4ed34679b8115b9d1ec462aa9c12902"

URI_aarch64_rust-tracing-subscriber+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+alloc-devel-0.3.19-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-subscriber+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+alloc-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+alloc-devel.sha256sum] = "ab226e85d9fe70e7918f51cc6af0ea566f73eee17a62fd62a0f374521e262c03"

URI_aarch64_rust-tracing-subscriber+ansi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+ansi-devel-0.3.19-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-subscriber+ansi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+ansi-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+ansi-devel.sha256sum] = "ad5650fd355b2e6526749faaf9cee0936c1ad526d19747a1f5f206f681cbaa57"

URI_aarch64_rust-tracing-subscriber+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+chrono-devel-0.3.19-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-subscriber+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+chrono-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+chrono-devel.sha256sum] = "1402920acb9ee0c8a40b38b6645c042f7977f69d7fc11e8b84ce86c4bee64e7f"

URI_aarch64_rust-tracing-subscriber+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+default-devel-0.3.19-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-subscriber+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+default-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+default-devel.sha256sum] = "600add5a47e86c82654705a78574e3177108ed0e05db55856183761e629e9b4e"

URI_aarch64_rust-tracing-subscriber+env-filter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+env-filter-devel-0.3.19-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-subscriber+env-filter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+env-filter-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+env-filter-devel.sha256sum] = "4aa635a8f91382e1b9fa35441845a4f5e6a63c7b82b77d80ec16e2b14a8b3980"

URI_aarch64_rust-tracing-subscriber+fmt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+fmt-devel-0.3.19-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-subscriber+fmt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+fmt-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+fmt-devel.sha256sum] = "7323d581e588a9295027308741b23f9cfa037d999c1fef52d924c364b9cd09db"

URI_aarch64_rust-tracing-subscriber+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+json-devel-0.3.19-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-subscriber+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+json-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+json-devel.sha256sum] = "8b449f9313db840e0e60c167145d98af6fcb1ed0140a944781bf13bec5c0bf51"

URI_aarch64_rust-tracing-subscriber+local-time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+local-time-devel-0.3.19-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-subscriber+local-time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+local-time-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+local-time-devel.sha256sum] = "3de3aec1e59bb5ee5fe5b53c69c5825b7b22a9a3d564af4ba1c535ae985ea73d"

URI_aarch64_rust-tracing-subscriber+matchers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+matchers-devel-0.3.19-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-subscriber+matchers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+matchers-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+matchers-devel.sha256sum] = "896ae0940d1c8b741084b651d74da7bc1bcff7347476080cab1160d0de4ded28"

URI_aarch64_rust-tracing-subscriber+nu-ansi-term-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+nu-ansi-term-devel-0.3.19-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-subscriber+nu-ansi-term-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+nu-ansi-term-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+nu-ansi-term-devel.sha256sum] = "46094093b84ed57f358b622da4fe695e0fe2274136aad8a7ae62cdf3ac8417f0"

URI_aarch64_rust-tracing-subscriber+once_cell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+once_cell-devel-0.3.19-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-subscriber+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+once_cell-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+once_cell-devel.sha256sum] = "fd6f9d0cf032199904f75ae243a0e9a41bdbf8396eae34c7ca934cfdfffb1011"

URI_aarch64_rust-tracing-subscriber+parking_lot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+parking_lot-devel-0.3.19-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-subscriber+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+parking_lot-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+parking_lot-devel.sha256sum] = "96b73aa96b0895ab00580834090ef25180039cd5313624bd51d907a2766b453c"

URI_aarch64_rust-tracing-subscriber+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+regex-devel-0.3.19-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-subscriber+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+regex-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+regex-devel.sha256sum] = "9b96df1b8d6e298fe6a030772a27f66a7fb68f7fc49bf0783240c74e9d1087a3"

URI_aarch64_rust-tracing-subscriber+registry-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+registry-devel-0.3.19-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-subscriber+registry-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+registry-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+registry-devel.sha256sum] = "bc10042783326b763409508a8854a5050a015459e3569071ead609cc3fe2cf34"

URI_aarch64_rust-tracing-subscriber+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+serde-devel-0.3.19-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-subscriber+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+serde-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+serde-devel.sha256sum] = "f090cba2904e7df361c5496904651eee3439af4f389b14aa4fef6c5c353bfd98"

URI_aarch64_rust-tracing-subscriber+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+serde_json-devel-0.3.19-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-subscriber+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+serde_json-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+serde_json-devel.sha256sum] = "2fcf6bafd7f669c8f5408ba9b09b51389ab501470a2b8798e517e92225927b8a"

URI_aarch64_rust-tracing-subscriber+sharded-slab-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+sharded-slab-devel-0.3.19-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-subscriber+sharded-slab-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+sharded-slab-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+sharded-slab-devel.sha256sum] = "a8077c437ae7bc02e99e7f5b1a903055932fc1ffbfabfb30c3ad376ca7d175f9"

URI_aarch64_rust-tracing-subscriber+smallvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+smallvec-devel-0.3.19-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-subscriber+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+smallvec-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+smallvec-devel.sha256sum] = "7ddcbff3839a2052f40f5ac1d99a6c9587ceceac9f3a54d4148d7e971212a5cf"

URI_aarch64_rust-tracing-subscriber+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+std-devel-0.3.19-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-subscriber+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+std-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+std-devel.sha256sum] = "c68f6406c6b7acfb5957a843e8f6ade49fe82a2b8155b268a52f42b6654aa526"

URI_aarch64_rust-tracing-subscriber+thread_local-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+thread_local-devel-0.3.19-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-subscriber+thread_local-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+thread_local-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+thread_local-devel.sha256sum] = "5f4e637a518378cd5eb3f685d14fff60dec2f3bc7158acf5f943e8c4a5e54939"

URI_aarch64_rust-tracing-subscriber+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+time-devel-0.3.19-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-subscriber+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+time-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+time-devel.sha256sum] = "88baf00c5c975075cc1ccc425aae760338099721c813c817ec6bbff15b5c1b0e"

URI_aarch64_rust-tracing-subscriber+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+tracing-devel-0.3.19-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-subscriber+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+tracing-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+tracing-devel.sha256sum] = "6ae3b7e48d60565827f1420d553305899ad5c38f864d8392910413bed5def4e0"

URI_aarch64_rust-tracing-subscriber+tracing-log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+tracing-log-devel-0.3.19-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-subscriber+tracing-log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+tracing-log-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+tracing-log-devel.sha256sum] = "46ae6ac30a1ff1092fee25ab9cfff366b4358090e07dcf1b9fcdd66a4e035669"

URI_aarch64_rust-tracing-subscriber+tracing-serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+tracing-serde-devel-0.3.19-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-subscriber+tracing-serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+tracing-serde-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+tracing-serde-devel.sha256sum] = "53c263c8e62e803cbb5fb9a71b51889adc0dddc5eb17e97ba7d62f4be73d6c90"

URI_aarch64_rust-tracing-subscriber-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber-devel-0.3.19-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-subscriber-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber-devel}"
SRC_URI[aarch64_rust-tracing-subscriber-devel.sha256sum] = "58dd5e1bcb4aece4fa3c1da5cbe938d56faaf0e0a7776b9b2ce2aa2ded80964a"

RDEPENDS:rust-tracing-subscriber+alloc-devel = " \
 cargo \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+ansi-devel = " \
 cargo \
 rust-tracing-subscriber+fmt-devel \
 rust-tracing-subscriber+nu-ansi-term-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+chrono-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono+std-devel \
 rust-chrono-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+default-devel = " \
 cargo \
 rust-tracing-subscriber+ansi-devel \
 rust-tracing-subscriber+fmt-devel \
 rust-tracing-subscriber+smallvec-devel \
 rust-tracing-subscriber+std-devel \
 rust-tracing-subscriber+tracing-log-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+env-filter-devel = " \
 cargo \
 rust-tracing-subscriber+matchers-devel \
 rust-tracing-subscriber+once_cell-devel \
 rust-tracing-subscriber+regex-devel \
 rust-tracing-subscriber+std-devel \
 rust-tracing-subscriber+thread_local-devel \
 rust-tracing-subscriber+tracing-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+fmt-devel = " \
 cargo \
 rust-tracing-subscriber+registry-devel \
 rust-tracing-subscriber+std-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+json-devel = " \
 cargo \
 rust-tracing-subscriber+serde-devel \
 rust-tracing-subscriber+serde_json-devel \
 rust-tracing-subscriber+tracing-serde-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+local-time-devel = " \
 cargo \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+local-offset-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+matchers-devel = " \
 cargo \
 rust-matchers+default-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+nu-ansi-term-devel = " \
 cargo \
 rust-nu-ansi-term+default-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+once_cell-devel = " \
 cargo \
 rust-once_cell+default-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+parking_lot-devel = " \
 cargo \
 rust-parking_lot+default-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+regex-devel = " \
 cargo \
 rust-regex+std-devel \
 rust-regex+unicode-case-devel \
 rust-regex+unicode-perl-devel \
 rust-regex-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+registry-devel = " \
 cargo \
 rust-tracing-subscriber+sharded-slab-devel \
 rust-tracing-subscriber+std-devel \
 rust-tracing-subscriber+thread_local-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+serde_json-devel = " \
 cargo \
 rust-serde_json+default-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+sharded-slab-devel = " \
 cargo \
 rust-sharded-slab+default-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+smallvec-devel = " \
 cargo \
 rust-smallvec+default-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+std-devel = " \
 cargo \
 rust-tracing-core+std-devel \
 rust-tracing-subscriber+alloc-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+thread_local-devel = " \
 cargo \
 rust-thread_local+default-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+time-devel = " \
 cargo \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+tracing-devel = " \
 cargo \
 rust-tracing-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+tracing-log-devel = " \
 cargo \
 rust-tracing-log+log-tracer-devel \
 rust-tracing-log+std-devel \
 rust-tracing-log-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+tracing-serde-devel = " \
 cargo \
 rust-tracing-serde+default-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber-devel = " \
 cargo \
 rust \
 rust-tracing-core-devel \
 "
