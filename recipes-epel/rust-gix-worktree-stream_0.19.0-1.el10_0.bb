# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-worktree-stream"
PV = "0.19.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-worktree-stream+default-devel \
 rust-gix-worktree-stream-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-worktree-stream-0.19.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca6993018a87e0e54af1aa687e418fbff2a2e9fadfdb9ead692ceb6fecee799a"

URI_x86_64_v2_rust-gix-worktree-stream+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree-stream+default-devel-0.19.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree-stream+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree-stream+default-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree-stream+default-devel.sha256sum] = "219fdf4c0cc629268a7f8143152e3121025a6887ba809baf7d486fd52dc01c88"

URI_x86_64_v2_rust-gix-worktree-stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree-stream-devel-0.19.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree-stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree-stream-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree-stream-devel.sha256sum] = "c68c349f74d68455431d8019eb46a015c3ddb6429aabd2bb9508337c55fc29f5"

URI_aarch64_rust-gix-worktree-stream+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree-stream+default-devel-0.19.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-worktree-stream+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree-stream+default-devel}"
SRC_URI[aarch64_rust-gix-worktree-stream+default-devel.sha256sum] = "8feda9893aae4fd8148b0659880ac0fa0908d4bb66a12aa9ff9e2c01c0dffece"

URI_aarch64_rust-gix-worktree-stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree-stream-devel-0.19.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-worktree-stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree-stream-devel}"
SRC_URI[aarch64_rust-gix-worktree-stream-devel.sha256sum] = "2ff8f2530792744c8559aed44443d319bd70fa34e0fd1af6580e61e0c1aee4ee"

RDEPENDS:rust-gix-worktree-stream+default-devel = " \
 cargo \
 rust-gix-worktree-stream-devel \
 "
RDEPENDS:rust-gix-worktree-stream-devel = " \
 cargo \
 rust \
 rust-gix-attributes+default-devel \
 rust-gix-features+default-devel \
 rust-gix-features+io-pipe-devel \
 rust-gix-features+progress-devel \
 rust-gix-filter+default-devel \
 rust-gix-fs+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-object+default-devel \
 rust-gix-path+default-devel \
 rust-gix-traverse+default-devel \
 rust-parking_lot+default-devel \
 rust-thiserror+default-devel \
 "
