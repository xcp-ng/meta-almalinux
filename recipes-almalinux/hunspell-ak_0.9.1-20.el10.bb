# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-ak"
PV = "0.9.1"
PR = "20.el10"
PACKAGES = " \
 hunspell-ak \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-ak-0.9.1-20.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b4657bd37ae54283440d89e44db78f44c358d887a42468fdf0982ed908e29afb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-ak-0.9.1-20.el10.noarch.rpm;name=x86_64_v2_hunspell-ak;unpack=0"
SRC_URI[x86_64_v2_hunspell-ak.sha256sum] = "d570412e0d29230cbc3e7bc6a434c0a7f7613595ae464a6123da8d1587da6752"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-ak-0.9.1-20.el10.noarch.rpm;name=aarch64_hunspell-ak;unpack=0"
SRC_URI[aarch64_hunspell-ak.sha256sum] = "d570412e0d29230cbc3e7bc6a434c0a7f7613595ae464a6123da8d1587da6752"

RDEPENDS:hunspell-ak = " \
 hunspell-filesystem \
 "
