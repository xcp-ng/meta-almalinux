# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vlc-plugin-pause-click"
PV = "2.2.0"
PR = "1.el10_0"
PACKAGES = " \
 vlc-plugin-pause-click \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/v/vlc-plugin-pause-click-2.2.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c3fd340016db08a43b4c509fcd94152a0bfdf02bd91f41c16322c9838d70d867"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-pause-click-2.2.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-pause-click;unpack=0"
SRC_URI[x86_64_v2_vlc-plugin-pause-click.sha256sum] = "841a2422bca7c3544ea46cb7f9274498e9d8609aea1dfec35dcb472ee9bfbcfa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-pause-click-2.2.0-1.el10_0.aarch64.rpm;name=aarch64_vlc-plugin-pause-click;unpack=0"
SRC_URI[aarch64_vlc-plugin-pause-click.sha256sum] = "1f047b4eb3eaf2c5dd8edbed4273ca1844f8c7ad33a81e2f1586be6c6d2b29e5"

RDEPENDS:vlc-plugin-pause-click = " \
 glibc \
 vlc-libs \
 vlc-plugins-video-out \
 "
