# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "blosc"
PV = "1.21.6"
PR = "4.el10_0"
PACKAGES = " \
 blosc \
 blosc-bench \
 blosc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/blosc-1.21.6-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0a2ea7eeb7e9544630740b0a9ce324b2a78a22592023b2adccf8ced8ab75247"

URI_x86_64_v2_blosc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blosc-1.21.6-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_blosc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blosc}"
SRC_URI[x86_64_v2_blosc.sha256sum] = "097b48cec2bf5d6a746bb2b080eb6d55c6ee9e355f397944aa7334b112b49678"

URI_x86_64_v2_blosc-bench = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blosc-bench-1.21.6-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_blosc-bench;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blosc-bench}"
SRC_URI[x86_64_v2_blosc-bench.sha256sum] = "f83f65d4d6945e2076f3e689180d4978e6a46d3926251648794d0036380c108d"

URI_x86_64_v2_blosc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blosc-devel-1.21.6-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_blosc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blosc-devel}"
SRC_URI[x86_64_v2_blosc-devel.sha256sum] = "2c9579bb74bb4b0a9dcb8561ca1691ef49ff3e2229abec6313e15c25ac2c360d"

URI_aarch64_blosc = "${EPEL_MIRROR}/aarch64/Packages/b/blosc-1.21.6-4.el10_0.aarch64.rpm;name=aarch64_blosc;unpack=0"
SRC_URI:append = " ${URI_aarch64_blosc}"
SRC_URI[aarch64_blosc.sha256sum] = "fb34e63e8e8b59f294470815967045435dc91a32753f596c640e2451e2daac6f"

URI_aarch64_blosc-bench = "${EPEL_MIRROR}/aarch64/Packages/b/blosc-bench-1.21.6-4.el10_0.aarch64.rpm;name=aarch64_blosc-bench;unpack=0"
SRC_URI:append = " ${URI_aarch64_blosc-bench}"
SRC_URI[aarch64_blosc-bench.sha256sum] = "c7bb4789139b1199755c9bc6d6520fbb34f5d0a3744285615233a82e53ffcf65"

URI_aarch64_blosc-devel = "${EPEL_MIRROR}/aarch64/Packages/b/blosc-devel-1.21.6-4.el10_0.aarch64.rpm;name=aarch64_blosc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_blosc-devel}"
SRC_URI[aarch64_blosc-devel.sha256sum] = "37d59048a97eb347a8d3a2fbfb9606817b13f4c6173ae87dfb3dc4262eb33498"

RDEPENDS:blosc = " \
 glibc \
 libzstd \
 lz4-libs \
 snappy \
 zlib-ng-compat \
 "
RDEPENDS:blosc-bench = " \
 blosc \
 glibc \
 python3 \
 python3-matplotlib \
 "
RDEPENDS:blosc-devel = " \
 blosc \
 pkgconf-pkg-config \
 "
