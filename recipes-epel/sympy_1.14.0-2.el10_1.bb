# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sympy"
PV = "1.14.0"
PR = "2.el10_1"
PACKAGES = " \
 python3-sympy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sympy-1.14.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ae2d70826aabde47d010ae5003d99feafa4714b7d174aaf9a6a7f9402a9f0451"

URI_x86_64_v2_python3-sympy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sympy-1.14.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-sympy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sympy}"
SRC_URI[x86_64_v2_python3-sympy.sha256sum] = "cd8514da7e7b53f2f033685b29bf01f3b1c166bbaf84b17dde094b8966a76e92"

URI_aarch64_python3-sympy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sympy-1.14.0-2.el10_1.aarch64.rpm;name=aarch64_python3-sympy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sympy}"
SRC_URI[aarch64_python3-sympy.sha256sum] = "6980ae044b4435a388d8d95d8f3429cec913d7b2b6ef4e7d99a09f84cdb983c5"

RDEPENDS:python3-sympy = " \
 python3 \
 "
