# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libusb1"
PV = "1.0.27"
PR = "4.el10"
PACKAGES = " \
 libusb1 \
 libusb1-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libusb1-1.0.27-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce29cb4fff260fa2a3b0f9fb46d527de0514dce77d32b85b1d93acef209bfa02"

URI_x86_64_v2_libusb1 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libusb1-1.0.27-4.el10.x86_64_v2.rpm;name=x86_64_v2_libusb1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libusb1}"
SRC_URI[x86_64_v2_libusb1.sha256sum] = "97bb80c57a2d1159525c666d311df0982519f12d0708e410f1620ce1099bd406"

URI_x86_64_v2_libusb1-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libusb1-devel-1.0.27-4.el10.x86_64_v2.rpm;name=x86_64_v2_libusb1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libusb1-devel}"
SRC_URI[x86_64_v2_libusb1-devel.sha256sum] = "065fd82517f0aab56eb67873d3f4ec1ee4bce6b60f298bb8a0b0da9483b46c7d"

URI_aarch64_libusb1 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libusb1-1.0.27-4.el10.aarch64.rpm;name=aarch64_libusb1;unpack=0"
SRC_URI:append = " ${URI_aarch64_libusb1}"
SRC_URI[aarch64_libusb1.sha256sum] = "52342486ce09297446deba6f2a4a2c59755ff4ecf3d75a93e49d7d0fa29411ae"

URI_aarch64_libusb1-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libusb1-devel-1.0.27-4.el10.aarch64.rpm;name=aarch64_libusb1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libusb1-devel}"
SRC_URI[aarch64_libusb1-devel.sha256sum] = "9f3551551a3df8a449c6e688c5549bb38e276a659acb4174ee45a7397cfb424d"

RDEPENDS:libusb1 = " \
 glibc \
 systemd-libs \
 "
RDEPENDS:libusb1-devel = " \
 libusb1 \
 pkgconf-pkg-config \
 "
