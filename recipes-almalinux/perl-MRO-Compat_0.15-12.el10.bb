# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-MRO-Compat"
PV = "0.15"
PR = "12.el10"
PACKAGES = " \
 perl-MRO-Compat \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-MRO-Compat-0.15-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5dcda64f958ed36d7d9efe60510a05bf027b81be8efeb796c0879592a6bd4d63"

URI_x86_64_v2_perl-MRO-Compat = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-MRO-Compat-0.15-12.el10.noarch.rpm;name=x86_64_v2_perl-MRO-Compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-MRO-Compat}"
SRC_URI[x86_64_v2_perl-MRO-Compat.sha256sum] = "9075cd518291789985bede42efb324c2bd850796236e995e427123a874ce71c1"

URI_aarch64_perl-MRO-Compat = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-MRO-Compat-0.15-12.el10.noarch.rpm;name=aarch64_perl-MRO-Compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-MRO-Compat}"
SRC_URI[aarch64_perl-MRO-Compat.sha256sum] = "9075cd518291789985bede42efb324c2bd850796236e995e427123a874ce71c1"

RDEPENDS:perl-MRO-Compat = " \
 perl-libs \
 "
