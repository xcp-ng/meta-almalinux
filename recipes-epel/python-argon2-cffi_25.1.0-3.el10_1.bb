# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-argon2-cffi"
PV = "25.1.0"
PR = "3.el10_1"
PACKAGES = " \
 python3-argon2-cffi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-argon2-cffi-25.1.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "88192fb27e1f885144adabdb780070e79f74b44f0c8c6e3df32179aaf1386a10"

URI_x86_64_v2_python3-argon2-cffi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-argon2-cffi-25.1.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-argon2-cffi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-argon2-cffi}"
SRC_URI[x86_64_v2_python3-argon2-cffi.sha256sum] = "58c5e4e9bf3a33f38d7ea0c3ea27a643a2e63929225918324217046febbfe98b"

URI_aarch64_python3-argon2-cffi = "${EPEL_MIRROR}/aarch64/Packages/p/python3-argon2-cffi-25.1.0-3.el10_1.noarch.rpm;name=aarch64_python3-argon2-cffi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-argon2-cffi}"
SRC_URI[aarch64_python3-argon2-cffi.sha256sum] = "9a3f2cb940036408f0bd1a61d62599e7c4060021d259473aaf44d4b5e3c85379"

RDEPENDS:python3-argon2-cffi = " \
 python3 \
 python3-argon2-cffi-bindings \
 "
