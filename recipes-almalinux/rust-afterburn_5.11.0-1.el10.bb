# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-afterburn"
PV = "5.11.0"
PR = "1.el10"
PACKAGES = " \
 afterburn \
 afterburn-dracut \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rust-afterburn-5.11.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e480e8105c801821a8b00c7361db3fc673dbbfffab3f3c50b8a9a71aec29240c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/afterburn-5.11.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_afterburn;unpack=0"
SRC_URI[x86_64_v2_afterburn.sha256sum] = "e0386ad4a377d8776ce746d0066e0987962a6a94a280290dc25f02ca501cbb36"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/afterburn-dracut-5.11.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_afterburn-dracut;unpack=0"
SRC_URI[x86_64_v2_afterburn-dracut.sha256sum] = "5cbef4f41d549403bf8cf11b51a7d9d4dfe5976cd89585420dba09545caf7a5c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/afterburn-5.11.0-1.el10.aarch64.rpm;name=aarch64_afterburn;unpack=0"
SRC_URI[aarch64_afterburn.sha256sum] = "ade49166cf8d9115568c8e114eaeb2ec8675e980def33cf45b32232cab69601b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/afterburn-dracut-5.11.0-1.el10.aarch64.rpm;name=aarch64_afterburn-dracut;unpack=0"
SRC_URI[aarch64_afterburn-dracut.sha256sum] = "481ad23dfa35aa0979f5d8bde9a33c52950c2da12d84cd07070af1f1e2886e58"

RDEPENDS:afterburn = " \
 bash \
 glibc \
 libgcc \
 openssl-libs \
 systemd \
 "
RDEPENDS:afterburn-dracut = " \
 afterburn \
 bash \
 dracut \
 dracut-network \
 "
