# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-plist"
PV = "1.8.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-plist+default-devel \
 rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel \
 rust-plist+serde-devel \
 rust-plist-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-plist-1.8.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "57cc257cc634a8ad9983d0f72c3640eb47bf761e5801d63d8d24b4c2af6d175a"

URI_x86_64_v2_rust-plist+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-plist+default-devel-1.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-plist+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-plist+default-devel}"
SRC_URI[x86_64_v2_rust-plist+default-devel.sha256sum] = "c31df666aa765e08e6cc302dd7777ced7823994824f4e475e3f66b2d0f369c22"

URI_x86_64_v2_rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel-1.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel}"
SRC_URI[x86_64_v2_rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel.sha256sum] = "a99752f5c1906eb1c068e517d25e70b9a6cf3fef15a93979e59b34da8970f54c"

URI_x86_64_v2_rust-plist+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-plist+serde-devel-1.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-plist+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-plist+serde-devel}"
SRC_URI[x86_64_v2_rust-plist+serde-devel.sha256sum] = "b665d0c986767a324c5e12dafaa77f3e225a8d0f9114edbbf4dc8771ba36abff"

URI_x86_64_v2_rust-plist-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-plist-devel-1.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-plist-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-plist-devel}"
SRC_URI[x86_64_v2_rust-plist-devel.sha256sum] = "ad95971f91444d5307809cc91a803d8a763e3c2588f99e0c49026898ca8d9a63"

URI_aarch64_rust-plist+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-plist+default-devel-1.8.0-1.el10_2.noarch.rpm;name=aarch64_rust-plist+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-plist+default-devel}"
SRC_URI[aarch64_rust-plist+default-devel.sha256sum] = "74ad45ac2b26d3253bf4e7281449e753d72df4e45f9dc346c5594754b10fe476"

URI_aarch64_rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel-1.8.0-1.el10_2.noarch.rpm;name=aarch64_rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel}"
SRC_URI[aarch64_rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel.sha256sum] = "da8e5c43664ed7c6405306c313b7b2866520bdc3ee5fceefe8cd35bdc52ad860"

URI_aarch64_rust-plist+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-plist+serde-devel-1.8.0-1.el10_2.noarch.rpm;name=aarch64_rust-plist+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-plist+serde-devel}"
SRC_URI[aarch64_rust-plist+serde-devel.sha256sum] = "a1afc67eceea53053082bb777ef47d41fe6f48f1794aa3dd6cbb76fba87850f3"

URI_aarch64_rust-plist-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-plist-devel-1.8.0-1.el10_2.noarch.rpm;name=aarch64_rust-plist-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-plist-devel}"
SRC_URI[aarch64_rust-plist-devel.sha256sum] = "788140833b1ff413eb1ce290efdd3041176e74776ba6a3a58e03bacada666242"

RDEPENDS:rust-plist+default-devel = " \
 cargo \
 rust-plist+serde-devel \
 rust-plist-devel \
 "
RDEPENDS:rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel = " \
 cargo \
 rust-plist-devel \
 "
RDEPENDS:rust-plist+serde-devel = " \
 cargo \
 rust-plist-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-plist-devel = " \
 cargo \
 rust \
 rust-base64+default-devel \
 rust-indexmap+default-devel \
 rust-quick-xml+default-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+parsing-devel \
 "
