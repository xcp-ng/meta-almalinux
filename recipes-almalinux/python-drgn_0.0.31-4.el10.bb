# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-drgn"
PV = "0.0.31"
PR = "4.el10"
PACKAGES = " \
 drgn \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-drgn-0.0.31-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5aa1f1eeb8ec3169d8829ee8676c73f2c39df2b4bcc5cebb76aae8e1c70cce98"

URI_x86_64_v2_drgn = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/drgn-0.0.31-4.el10.x86_64_v2.rpm;name=x86_64_v2_drgn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_drgn}"
SRC_URI[x86_64_v2_drgn.sha256sum] = "a2b046eadd6d21661e62a42f38f6a7d31be6f069c1797c372c6cd6f4d6508edc"

URI_aarch64_drgn = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/drgn-0.0.31-4.el10.aarch64.rpm;name=aarch64_drgn;unpack=0"
SRC_URI:append = " ${URI_aarch64_drgn}"
SRC_URI[aarch64_drgn.sha256sum] = "c7fee1179e8f42082424cffd83891df63ebdb270c8a09f7081d1c74f35bce2d2"

RDEPENDS:drgn = " \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libgcc \
 libgomp \
 libkdumpfile \
 python3 \
 "
