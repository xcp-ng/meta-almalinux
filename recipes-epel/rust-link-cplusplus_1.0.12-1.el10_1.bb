# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-link-cplusplus"
PV = "1.0.12"
PR = "1.el10_1"
PACKAGES = " \
 rust-link-cplusplus+default-devel \
 rust-link-cplusplus+libc++-devel \
 rust-link-cplusplus+libcxx-devel \
 rust-link-cplusplus+libstdc++-devel \
 rust-link-cplusplus+libstdcxx-devel \
 rust-link-cplusplus+nothing-devel \
 rust-link-cplusplus-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-link-cplusplus-1.0.12-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5bfb952137f95d538bcfb6ccad62aed2fab465d4867563a253799decf5dc8e12"

URI_x86_64_v2_rust-link-cplusplus+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-link-cplusplus+default-devel-1.0.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-link-cplusplus+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-link-cplusplus+default-devel}"
SRC_URI[x86_64_v2_rust-link-cplusplus+default-devel.sha256sum] = "f5e998564a021fe52be4502533206667a13466c7fd91435c6e1584813034a772"

URI_x86_64_v2_rust-link-cplusplus+libc++-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-link-cplusplus+libc++-devel-1.0.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-link-cplusplus+libc++-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-link-cplusplus+libc++-devel}"
SRC_URI[x86_64_v2_rust-link-cplusplus+libc++-devel.sha256sum] = "ae03a10fe088d0548f533a15756fef81372c449b4709886381ffe938a31e1201"

URI_x86_64_v2_rust-link-cplusplus+libcxx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-link-cplusplus+libcxx-devel-1.0.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-link-cplusplus+libcxx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-link-cplusplus+libcxx-devel}"
SRC_URI[x86_64_v2_rust-link-cplusplus+libcxx-devel.sha256sum] = "5e243ed5d72f4ec1ace630a299460ac13f9a3a889bd8d3732236f03f34bc10b5"

URI_x86_64_v2_rust-link-cplusplus+libstdc++-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-link-cplusplus+libstdc++-devel-1.0.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-link-cplusplus+libstdc++-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-link-cplusplus+libstdc++-devel}"
SRC_URI[x86_64_v2_rust-link-cplusplus+libstdc++-devel.sha256sum] = "66150938e5fcf0015878b12ec11b31a37a9e4494a63c3b8e7d1f87947e6bd9a9"

URI_x86_64_v2_rust-link-cplusplus+libstdcxx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-link-cplusplus+libstdcxx-devel-1.0.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-link-cplusplus+libstdcxx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-link-cplusplus+libstdcxx-devel}"
SRC_URI[x86_64_v2_rust-link-cplusplus+libstdcxx-devel.sha256sum] = "6be0bb22897c9a7dc2016267cf696a61c99ab8427b7291cb5e62fbc8fbb4b3f3"

URI_x86_64_v2_rust-link-cplusplus+nothing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-link-cplusplus+nothing-devel-1.0.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-link-cplusplus+nothing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-link-cplusplus+nothing-devel}"
SRC_URI[x86_64_v2_rust-link-cplusplus+nothing-devel.sha256sum] = "3ad4bcfe8e8c1635687091e431487925ed510caf7a28f14da7b86a884a300e9a"

URI_x86_64_v2_rust-link-cplusplus-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-link-cplusplus-devel-1.0.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-link-cplusplus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-link-cplusplus-devel}"
SRC_URI[x86_64_v2_rust-link-cplusplus-devel.sha256sum] = "aee2cde4229783dae22c916483df61277eb68cb7edaab93fddd11d52f8a2e458"

URI_aarch64_rust-link-cplusplus+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-link-cplusplus+default-devel-1.0.12-1.el10_1.noarch.rpm;name=aarch64_rust-link-cplusplus+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-link-cplusplus+default-devel}"
SRC_URI[aarch64_rust-link-cplusplus+default-devel.sha256sum] = "10f52f8bd521538e499779db07db7b2e83ef133724aa6e5a96dbd1f75b91b02d"

URI_aarch64_rust-link-cplusplus+libc++-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-link-cplusplus+libc++-devel-1.0.12-1.el10_1.noarch.rpm;name=aarch64_rust-link-cplusplus+libc++-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-link-cplusplus+libc++-devel}"
SRC_URI[aarch64_rust-link-cplusplus+libc++-devel.sha256sum] = "7616d058eb4399e863a4fa871d246cb13a577178ef2c929c990e9d59a7f5d33f"

URI_aarch64_rust-link-cplusplus+libcxx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-link-cplusplus+libcxx-devel-1.0.12-1.el10_1.noarch.rpm;name=aarch64_rust-link-cplusplus+libcxx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-link-cplusplus+libcxx-devel}"
SRC_URI[aarch64_rust-link-cplusplus+libcxx-devel.sha256sum] = "3becde7aebca34a92e01fa2f124cb718cb95970d1ec19ee6551aac09ce53ac5d"

URI_aarch64_rust-link-cplusplus+libstdc++-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-link-cplusplus+libstdc++-devel-1.0.12-1.el10_1.noarch.rpm;name=aarch64_rust-link-cplusplus+libstdc++-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-link-cplusplus+libstdc++-devel}"
SRC_URI[aarch64_rust-link-cplusplus+libstdc++-devel.sha256sum] = "b41af0a06eb54e235f118b4d4d8ffea2651b634c27d22bcab84e203be2ef29f1"

URI_aarch64_rust-link-cplusplus+libstdcxx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-link-cplusplus+libstdcxx-devel-1.0.12-1.el10_1.noarch.rpm;name=aarch64_rust-link-cplusplus+libstdcxx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-link-cplusplus+libstdcxx-devel}"
SRC_URI[aarch64_rust-link-cplusplus+libstdcxx-devel.sha256sum] = "c95308381c9ce5f417cf73870424c02f602173eef4f5d83a64f38aec35f97943"

URI_aarch64_rust-link-cplusplus+nothing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-link-cplusplus+nothing-devel-1.0.12-1.el10_1.noarch.rpm;name=aarch64_rust-link-cplusplus+nothing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-link-cplusplus+nothing-devel}"
SRC_URI[aarch64_rust-link-cplusplus+nothing-devel.sha256sum] = "2e255f502c1e72e462d3111c0afa727cc8e73740cd7f9adb422d32aa684a5e35"

URI_aarch64_rust-link-cplusplus-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-link-cplusplus-devel-1.0.12-1.el10_1.noarch.rpm;name=aarch64_rust-link-cplusplus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-link-cplusplus-devel}"
SRC_URI[aarch64_rust-link-cplusplus-devel.sha256sum] = "5040b8ee710715f5bb1099b277bb9ecd24d3ee4fa3edf6619a5ca475fb27be90"

RDEPENDS:rust-link-cplusplus+default-devel = " \
 cargo \
 rust-link-cplusplus-devel \
 "
RDEPENDS:rust-link-cplusplus+libc++-devel = " \
 cargo \
 rust-link-cplusplus-devel \
 "
RDEPENDS:rust-link-cplusplus+libcxx-devel = " \
 cargo \
 rust-link-cplusplus+libc++-devel \
 rust-link-cplusplus-devel \
 "
RDEPENDS:rust-link-cplusplus+libstdc++-devel = " \
 cargo \
 rust-link-cplusplus-devel \
 "
RDEPENDS:rust-link-cplusplus+libstdcxx-devel = " \
 cargo \
 rust-link-cplusplus+libstdc++-devel \
 rust-link-cplusplus-devel \
 "
RDEPENDS:rust-link-cplusplus+nothing-devel = " \
 cargo \
 rust-link-cplusplus-devel \
 "
RDEPENDS:rust-link-cplusplus-devel = " \
 cargo \
 rust \
 rust-cc+default-devel \
 "
