# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-Only"
PV = "0.1"
PR = "31.el10_0"
PACKAGES = " \
 ghc-Only \
 ghc-Only-devel \
 ghc-Only-doc \
 ghc-Only-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-Only-0.1-31.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3b4e68c6a1f7c8ace00ad8b40c413338b478733553135b651d90cea954e6001"

URI_x86_64_v2_ghc-Only = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-Only-0.1-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-Only;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-Only}"
SRC_URI[x86_64_v2_ghc-Only.sha256sum] = "f27b124cde0ac6a7c9b881eaa25958f1af9d49b76c02355897f626c64450bf94"

URI_x86_64_v2_ghc-Only-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-Only-devel-0.1-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-Only-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-Only-devel}"
SRC_URI[x86_64_v2_ghc-Only-devel.sha256sum] = "a7431b67b9910538027fa11d1a466f06a5a6a46f86fddc883bc95c2191799f8a"

URI_x86_64_v2_ghc-Only-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-Only-doc-0.1-31.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-Only-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-Only-doc}"
SRC_URI[x86_64_v2_ghc-Only-doc.sha256sum] = "397461e1a82d604598dbe46a164b191eb257f4b4a51e563a4a1291c874e05891"

URI_x86_64_v2_ghc-Only-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-Only-prof-0.1-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-Only-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-Only-prof}"
SRC_URI[x86_64_v2_ghc-Only-prof.sha256sum] = "ae4cbfe1afe2961fbfc578ce8763538977b623d7a896104c9014f94ee54b5a07"

URI_aarch64_ghc-Only = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-Only-0.1-31.el10_0.aarch64.rpm;name=aarch64_ghc-Only;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-Only}"
SRC_URI[aarch64_ghc-Only.sha256sum] = "194f9d046d81e0211f3d9245ce00f9f9033fe958b5554a06dfb86593e51056a9"

URI_aarch64_ghc-Only-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-Only-devel-0.1-31.el10_0.aarch64.rpm;name=aarch64_ghc-Only-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-Only-devel}"
SRC_URI[aarch64_ghc-Only-devel.sha256sum] = "bd4fdb96056845a39d6196ff5bc2cd3be66eb989afd4d1bf77089013a2d92bf5"

URI_aarch64_ghc-Only-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-Only-doc-0.1-31.el10_0.noarch.rpm;name=aarch64_ghc-Only-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-Only-doc}"
SRC_URI[aarch64_ghc-Only-doc.sha256sum] = "798aa3f53a2c257c82ddef73cf792768ac33ba01edbc7ff0f9fd3818164dde7b"

URI_aarch64_ghc-Only-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-Only-prof-0.1-31.el10_0.aarch64.rpm;name=aarch64_ghc-Only-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-Only-prof}"
SRC_URI[aarch64_ghc-Only-prof.sha256sum] = "d725666fed33a58e3d4ee6ed04b82e91a16569414c82ca3f70e32a4a4d45ae78"

RDEPENDS:ghc-Only = " \
 ghc-array \
 ghc-base \
 ghc-deepseq \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-Only-devel = " \
 ghc-Only \
 ghc-base-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 "
RDEPENDS:ghc-Only-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-Only-prof = " \
 ghc-Only-devel \
 ghc-base-prof \
 ghc-deepseq-prof \
 "
