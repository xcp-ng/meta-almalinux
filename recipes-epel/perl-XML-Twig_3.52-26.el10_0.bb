# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-XML-Twig"
PV = "3.52"
PR = "26.el10_0"
PACKAGES = " \
 perl-XML-Twig \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-XML-Twig-3.52-26.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4b109e32f4096c6146e79ab5b5dd3d2094c0a9318ba872af80c10113210499d0"

URI_x86_64_v2_perl-XML-Twig = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-XML-Twig-3.52-26.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-XML-Twig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XML-Twig}"
SRC_URI[x86_64_v2_perl-XML-Twig.sha256sum] = "f4ba6ea7c7d53799adbffdd0ef0ef790248595b4d3a0f969526182e6df306916"

URI_aarch64_perl-XML-Twig = "${EPEL_MIRROR}/aarch64/Packages/p/perl-XML-Twig-3.52-26.el10_0.noarch.rpm;name=aarch64_perl-XML-Twig;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XML-Twig}"
SRC_URI[aarch64_perl-XML-Twig.sha256sum] = "05f34ce95f159166ebd42e6f302b01ae31af6ece8fa7c2bcc571e95b7cf54f7b"

RDEPENDS:perl-XML-Twig = " \
 perl-Carp \
 perl-Encode \
 perl-File-Basename \
 perl-File-Temp \
 perl-FindBin \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-HTML-Tree \
 perl-IO-stringy \
 perl-PathTools \
 perl-Pod-Usage \
 perl-Scalar-List-Utils \
 perl-Text-Tabs+Wrap \
 perl-XML-Parser \
 perl-XML-Twig \
 perl-base \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
