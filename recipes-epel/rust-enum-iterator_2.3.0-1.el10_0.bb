# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-enum-iterator"
PV = "2.3.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-enum-iterator+default-devel \
 rust-enum-iterator-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-enum-iterator-2.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "160fe38523e0bda60f23631480b2cf82791312c95e38002be9df9198773dd422"

URI_x86_64_v2_rust-enum-iterator+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enum-iterator+default-devel-2.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enum-iterator+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enum-iterator+default-devel}"
SRC_URI[x86_64_v2_rust-enum-iterator+default-devel.sha256sum] = "0cd178722e0dccea6cae89a99ceb67e1f5399203cb41b3475839ad0d4896b83c"

URI_x86_64_v2_rust-enum-iterator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enum-iterator-devel-2.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enum-iterator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enum-iterator-devel}"
SRC_URI[x86_64_v2_rust-enum-iterator-devel.sha256sum] = "0f7a6b5b041745f7bc8c31ec7bb574c4df5c1b8bb25138267fc3849f2d71d588"

URI_aarch64_rust-enum-iterator+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enum-iterator+default-devel-2.3.0-1.el10_0.noarch.rpm;name=aarch64_rust-enum-iterator+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enum-iterator+default-devel}"
SRC_URI[aarch64_rust-enum-iterator+default-devel.sha256sum] = "5bb4a8cb39918f89c92e67273de83208e3187e83763c68f07652a1ad3c6aeb3b"

URI_aarch64_rust-enum-iterator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enum-iterator-devel-2.3.0-1.el10_0.noarch.rpm;name=aarch64_rust-enum-iterator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enum-iterator-devel}"
SRC_URI[aarch64_rust-enum-iterator-devel.sha256sum] = "b008137a96356207fe42eeaba5fc17494f918310f88cdbb7e6dc4c8742f3b8e1"

RDEPENDS:rust-enum-iterator+default-devel = " \
 cargo \
 rust-enum-iterator-devel \
 "
RDEPENDS:rust-enum-iterator-devel = " \
 cargo \
 rust-enum-iterator-derive+default-devel \
 "
