# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-probe"
PV = "0.5.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-probe+default-devel \
 rust-probe-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-probe-0.5.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6955debf5bae4347de3108e12ac00b92dfdde901fcf45c06938256ae6d657e8d"

URI_x86_64_v2_rust-probe+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-probe+default-devel-0.5.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-probe+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-probe+default-devel}"
SRC_URI[x86_64_v2_rust-probe+default-devel.sha256sum] = "f51869765fd7882fae775c7a453fbc4e7a1f0e8d4288f8094801e21320b68f1c"

URI_x86_64_v2_rust-probe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-probe-devel-0.5.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-probe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-probe-devel}"
SRC_URI[x86_64_v2_rust-probe-devel.sha256sum] = "9a76ef520a3ea7aba6f442691bce7ac737073c57e34485c3509f04dfdbe9cd6d"

URI_aarch64_rust-probe+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-probe+default-devel-0.5.2-1.el10_1.noarch.rpm;name=aarch64_rust-probe+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-probe+default-devel}"
SRC_URI[aarch64_rust-probe+default-devel.sha256sum] = "1f4997630e5cb97ca3d4aa98c09632fcfdb6ce5ec39fe81022712e239bad7442"

URI_aarch64_rust-probe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-probe-devel-0.5.2-1.el10_1.noarch.rpm;name=aarch64_rust-probe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-probe-devel}"
SRC_URI[aarch64_rust-probe-devel.sha256sum] = "95962e3bf26ac54aef6731a862903d632cc0b269976440cae2b0a75ea322f994"

RDEPENDS:rust-probe+default-devel = " \
 cargo \
 rust-probe-devel \
 "
RDEPENDS:rust-probe-devel = " \
 cargo \
 rust \
 "
