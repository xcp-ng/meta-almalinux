# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "graphviz"
PV = "9.0.0"
PR = "15.el10"
PACKAGES = " \
 graphviz \
 graphviz-devel \
 graphviz-doc \
 graphviz-gd \
 graphviz-python3 \
 graphviz-ruby \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/graphviz-9.0.0-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "76e417c1500659ac2bda1ce65c4ba3e59a4d1019d91ff0187281a0762fa7d107"

URI_x86_64_v2_graphviz = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/graphviz-9.0.0-15.el10.x86_64_v2.rpm;name=x86_64_v2_graphviz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_graphviz}"
SRC_URI[x86_64_v2_graphviz.sha256sum] = "cd98550c7bd992fe0e3c2f3e09ec327e087eb92f66456767f1d8e6749999f23b"

URI_x86_64_v2_graphviz-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/graphviz-devel-9.0.0-15.el10.x86_64_v2.rpm;name=x86_64_v2_graphviz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_graphviz-devel}"
SRC_URI[x86_64_v2_graphviz-devel.sha256sum] = "e2fd2ed454977de528d1a2c6e9d1936568cfa48a3d2ba7aa9011056d22a08d68"

URI_x86_64_v2_graphviz-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/graphviz-doc-9.0.0-15.el10.x86_64_v2.rpm;name=x86_64_v2_graphviz-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_graphviz-doc}"
SRC_URI[x86_64_v2_graphviz-doc.sha256sum] = "db2c28cdfad71c196327d645187093b540eacfb2908ff22a224dfe79a9ca819b"

URI_x86_64_v2_graphviz-gd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/graphviz-gd-9.0.0-15.el10.x86_64_v2.rpm;name=x86_64_v2_graphviz-gd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_graphviz-gd}"
SRC_URI[x86_64_v2_graphviz-gd.sha256sum] = "db3a0ca3530958617efdaf9865b45eca2064626a938b3acc3668f53c35bd728c"

URI_x86_64_v2_graphviz-python3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/graphviz-python3-9.0.0-15.el10.x86_64_v2.rpm;name=x86_64_v2_graphviz-python3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_graphviz-python3}"
SRC_URI[x86_64_v2_graphviz-python3.sha256sum] = "036808b78dd4f0dd73df7b74dbfd3e635de4d12a391300bd7dd59f7ae421392e"

URI_x86_64_v2_graphviz-ruby = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/graphviz-ruby-9.0.0-15.el10.x86_64_v2.rpm;name=x86_64_v2_graphviz-ruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_graphviz-ruby}"
SRC_URI[x86_64_v2_graphviz-ruby.sha256sum] = "2a0a1817b9d7a665673a1285a13223244969241f4622ef28fe23b9d9ba2ebd71"

URI_aarch64_graphviz = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/graphviz-9.0.0-15.el10.aarch64.rpm;name=aarch64_graphviz;unpack=0"
SRC_URI:append = " ${URI_aarch64_graphviz}"
SRC_URI[aarch64_graphviz.sha256sum] = "f3e08c2d9e7562a4985bc5349c3f7343d9b5506d2961f9af3c7ced1464f838eb"

URI_aarch64_graphviz-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/graphviz-devel-9.0.0-15.el10.aarch64.rpm;name=aarch64_graphviz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_graphviz-devel}"
SRC_URI[aarch64_graphviz-devel.sha256sum] = "553ea846a032cc75c71cb5fc627f274185f3cdc77a0fe26751114273a33a21f8"

URI_aarch64_graphviz-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/graphviz-doc-9.0.0-15.el10.aarch64.rpm;name=aarch64_graphviz-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_graphviz-doc}"
SRC_URI[aarch64_graphviz-doc.sha256sum] = "6164de11cbc064073875a40fde42847429010b25059b902a0fde54184c4cacfd"

URI_aarch64_graphviz-gd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/graphviz-gd-9.0.0-15.el10.aarch64.rpm;name=aarch64_graphviz-gd;unpack=0"
SRC_URI:append = " ${URI_aarch64_graphviz-gd}"
SRC_URI[aarch64_graphviz-gd.sha256sum] = "51738a39463a0c0c67516403ba26b748801f352ed83651c9b92ac4de67caa110"

URI_aarch64_graphviz-python3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/graphviz-python3-9.0.0-15.el10.aarch64.rpm;name=aarch64_graphviz-python3;unpack=0"
SRC_URI:append = " ${URI_aarch64_graphviz-python3}"
SRC_URI[aarch64_graphviz-python3.sha256sum] = "aa758b7276849a491a28132b0d0e377931ac43bea66165342234f5a3f37b4769"

URI_aarch64_graphviz-ruby = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/graphviz-ruby-9.0.0-15.el10.aarch64.rpm;name=aarch64_graphviz-ruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_graphviz-ruby}"
SRC_URI[aarch64_graphviz-ruby.sha256sum] = "4061203c7a99a2eda1ac6b5469455b90d58750dadabfde9e84f2f82be565236f"

RDEPENDS:graphviz = " \
 bash \
 cairo \
 expat \
 fontconfig \
 freetype \
 gd \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 harfbuzz \
 libX11 \
 libXrender \
 libgcc \
 libgs \
 librsvg2 \
 libstdc++ \
 libtool-ltdl \
 libwebp \
 pango \
 poppler-glib \
 urw-base35-fonts \
 zlib-ng-compat \
 "
RDEPENDS:graphviz-devel = " \
 graphviz \
 graphviz-gd \
 pkgconf-pkg-config \
 "
RDEPENDS:graphviz-doc = " \
 "
RDEPENDS:graphviz-gd = " \
 cairo \
 expat \
 gd \
 glib2 \
 glibc \
 graphviz \
 harfbuzz \
 libtool-ltdl \
 pango \
 zlib-ng-compat \
 "
RDEPENDS:graphviz-python3 = " \
 expat \
 glibc \
 graphviz \
 libgcc \
 libstdc++ \
 libtool-ltdl \
 python3 \
 zlib-ng-compat \
 "
RDEPENDS:graphviz-ruby = " \
 expat \
 glibc \
 graphviz \
 libgcc \
 libstdc++ \
 libtool-ltdl \
 ruby \
 ruby-libs \
 zlib-ng-compat \
 "
