# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jigdo"
PV = "0.8.2"
PR = "9.el10_2"
PACKAGES = " \
 jigdo \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/j/jigdo-0.8.2-9.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6ce73e57c4ea55aa93891a8b8420dce222f4ef3288856fb48a47b3986e0c8a33"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jigdo-0.8.2-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_jigdo;unpack=0"
SRC_URI[x86_64_v2_jigdo.sha256sum] = "be4bd1b18f112644621a3b7ca056f1637438e8f04898b55d1f7956993e8bc398"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/jigdo-0.8.2-9.el10_2.aarch64.rpm;name=aarch64_jigdo;unpack=0"
SRC_URI[aarch64_jigdo.sha256sum] = "9e3e3483ed2c46f428bf78fb8a9d69560b68e3a1a480751b4e5332a4801dfa57"

RDEPENDS:jigdo = " \
 bash \
 bzip2-libs \
 glibc \
 libdb \
 libgcc \
 libstdc++ \
 wget \
 zlib-ng-compat \
 "
