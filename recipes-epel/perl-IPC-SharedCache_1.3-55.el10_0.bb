# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-IPC-SharedCache"
PV = "1.3"
PR = "55.el10_0"
PACKAGES = " \
 perl-IPC-SharedCache \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-IPC-SharedCache-1.3-55.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "42e33d446daaf2d77a661f23a3cef18e2bedfb540cab56453d95e0b6ee62e334"

URI_x86_64_v2_perl-IPC-SharedCache = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-IPC-SharedCache-1.3-55.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-IPC-SharedCache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-IPC-SharedCache}"
SRC_URI[x86_64_v2_perl-IPC-SharedCache.sha256sum] = "9b9c53e4ffce39e6c0bb3c0693ef08f95d5f566ecafe24cf12fd646d91639d26"

URI_aarch64_perl-IPC-SharedCache = "${EPEL_MIRROR}/aarch64/Packages/p/perl-IPC-SharedCache-1.3-55.el10_0.noarch.rpm;name=aarch64_perl-IPC-SharedCache;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-IPC-SharedCache}"
SRC_URI[aarch64_perl-IPC-SharedCache.sha256sum] = "3edcaeb44776bbbc786d3f54ce144d5c0f5291001af742ffbc256a92f7a5b0ce"

RDEPENDS:perl-IPC-SharedCache = " \
 perl-Carp \
 perl-IPC-ShareLite \
 perl-Storable \
 perl-libs \
 perl-vars \
 "
