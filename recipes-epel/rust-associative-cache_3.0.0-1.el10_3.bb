# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-associative-cache"
PV = "3.0.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-associative-cache+default-devel \
 rust-associative-cache+rand-devel \
 rust-associative-cache-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-associative-cache-3.0.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b1018aab0ca99f6b7ce6f8bf48e8a9e195df789a71d0c870289fc4e15a377f7"

URI_x86_64_v2_rust-associative-cache+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-associative-cache+default-devel-3.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-associative-cache+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-associative-cache+default-devel}"
SRC_URI[x86_64_v2_rust-associative-cache+default-devel.sha256sum] = "c22250396a85c7b0d4b729e048b0fbc7bfdce80a23e574389b35fd34932217a1"

URI_x86_64_v2_rust-associative-cache+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-associative-cache+rand-devel-3.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-associative-cache+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-associative-cache+rand-devel}"
SRC_URI[x86_64_v2_rust-associative-cache+rand-devel.sha256sum] = "e2d5bd109db22ad10bdbe245204e7eb45dda9c27cdf56741839961be74b1fd8b"

URI_x86_64_v2_rust-associative-cache-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-associative-cache-devel-3.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-associative-cache-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-associative-cache-devel}"
SRC_URI[x86_64_v2_rust-associative-cache-devel.sha256sum] = "54ba06740f1e140c5d59fc37bd53bcda76239d8ec5102605c75d557a0bcb87e3"

URI_aarch64_rust-associative-cache+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-associative-cache+default-devel-3.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-associative-cache+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-associative-cache+default-devel}"
SRC_URI[aarch64_rust-associative-cache+default-devel.sha256sum] = "b16a37d269c549222216041bf32bbb410744df01098d3e787d970f659ea40856"

URI_aarch64_rust-associative-cache+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-associative-cache+rand-devel-3.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-associative-cache+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-associative-cache+rand-devel}"
SRC_URI[aarch64_rust-associative-cache+rand-devel.sha256sum] = "fd92874f42f3edc946c54ed8da7170b2c8de3fa42db36fe4cb3df919d3551824"

URI_aarch64_rust-associative-cache-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-associative-cache-devel-3.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-associative-cache-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-associative-cache-devel}"
SRC_URI[aarch64_rust-associative-cache-devel.sha256sum] = "64ef323254f81dc39b3ea0448f8f8b213decabc530fa9623daee3b418c22811e"

RDEPENDS:rust-associative-cache+default-devel = " \
 cargo \
 rust-associative-cache-devel \
 "
RDEPENDS:rust-associative-cache+rand-devel = " \
 cargo \
 rust-associative-cache-devel \
 rust-rand+default-devel \
 "
RDEPENDS:rust-associative-cache-devel = " \
 cargo \
 rust \
 "
