# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-urwid"
PV = "2.5.3"
PR = "4.el10_2.5"
PACKAGES = " \
 python3-urwid \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python-urwid-2.5.3-4.el10_2.5.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "be4b4daceb13422511a35d921585c00da94841afaffb7497ffe7bd0986ec8c31"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-urwid-2.5.3-4.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_python3-urwid;unpack=0"
SRC_URI[x86_64_v2_python3-urwid.sha256sum] = "cd7aa3f5354d6be0bf639ad42be7f9147d8e0b8bb0a33e5872e628c5b48d8824"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-urwid-2.5.3-4.el10_2.5.aarch64.rpm;name=aarch64_python3-urwid;unpack=0"
SRC_URI[aarch64_python3-urwid.sha256sum] = "995356245402b6d969db4af190b6f7ec60a101c6f1cfc08a3c1affdbe9df7466"

RDEPENDS:python3-urwid = " \
 glibc \
 python3 \
 python3-typing-extensions \
 python3-wcwidth \
 "
