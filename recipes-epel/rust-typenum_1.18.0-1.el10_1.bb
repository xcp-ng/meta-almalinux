# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-typenum"
PV = "1.18.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-typenum+const-generics-devel \
 rust-typenum+default-devel \
 rust-typenum+force_unix_path_separator-devel \
 rust-typenum+i128-devel \
 rust-typenum+no_std-devel \
 rust-typenum+strict-devel \
 rust-typenum-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-typenum-1.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a413ced40579039775e691842d0515f6884e5db3916444bd9e0367c06288163e"

URI_x86_64_v2_rust-typenum+const-generics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typenum+const-generics-devel-1.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typenum+const-generics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typenum+const-generics-devel}"
SRC_URI[x86_64_v2_rust-typenum+const-generics-devel.sha256sum] = "7fd02ff6e2269905167ac497798676f90f96f35cd72c7f3cdd581617dcadd197"

URI_x86_64_v2_rust-typenum+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typenum+default-devel-1.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typenum+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typenum+default-devel}"
SRC_URI[x86_64_v2_rust-typenum+default-devel.sha256sum] = "d44f78a102752b61166399c154f7044c384795dbd27e80213ae5406c2e0c74a4"

URI_x86_64_v2_rust-typenum+force_unix_path_separator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typenum+force_unix_path_separator-devel-1.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typenum+force_unix_path_separator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typenum+force_unix_path_separator-devel}"
SRC_URI[x86_64_v2_rust-typenum+force_unix_path_separator-devel.sha256sum] = "3ca29071b2ae5e125889079b03a93241f53042297358fdc234f954161d7ce15f"

URI_x86_64_v2_rust-typenum+i128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typenum+i128-devel-1.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typenum+i128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typenum+i128-devel}"
SRC_URI[x86_64_v2_rust-typenum+i128-devel.sha256sum] = "42f6b02f74a26f1a67423c00873a0be715e215e0c969629e3dd09ae657e26ba7"

URI_x86_64_v2_rust-typenum+no_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typenum+no_std-devel-1.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typenum+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typenum+no_std-devel}"
SRC_URI[x86_64_v2_rust-typenum+no_std-devel.sha256sum] = "e2278c20e2b878d7ee72744d85441c082acce0cb29af2bc7020a0c6ac973cd26"

URI_x86_64_v2_rust-typenum+strict-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typenum+strict-devel-1.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typenum+strict-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typenum+strict-devel}"
SRC_URI[x86_64_v2_rust-typenum+strict-devel.sha256sum] = "8ae1b038c7954e9a001af7baebd16b3bf304dcd010875c2043054ad92ff1667a"

URI_x86_64_v2_rust-typenum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typenum-devel-1.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typenum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typenum-devel}"
SRC_URI[x86_64_v2_rust-typenum-devel.sha256sum] = "57ad3609d1cf17159a4c8498b7c59cff7e2b8765bb9273285b066c800d0c62eb"

URI_aarch64_rust-typenum+const-generics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typenum+const-generics-devel-1.18.0-1.el10_1.noarch.rpm;name=aarch64_rust-typenum+const-generics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typenum+const-generics-devel}"
SRC_URI[aarch64_rust-typenum+const-generics-devel.sha256sum] = "01f2081abfbb023b27ab4a1c194e5125871f185b16a9a64e2f5b220175cdc668"

URI_aarch64_rust-typenum+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typenum+default-devel-1.18.0-1.el10_1.noarch.rpm;name=aarch64_rust-typenum+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typenum+default-devel}"
SRC_URI[aarch64_rust-typenum+default-devel.sha256sum] = "2666932fb1f09838836c1376498a332cb4620ee071992c3ac68cebc322ad345d"

URI_aarch64_rust-typenum+force_unix_path_separator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typenum+force_unix_path_separator-devel-1.18.0-1.el10_1.noarch.rpm;name=aarch64_rust-typenum+force_unix_path_separator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typenum+force_unix_path_separator-devel}"
SRC_URI[aarch64_rust-typenum+force_unix_path_separator-devel.sha256sum] = "c56df3bfdaccddac890d83f575fb5d06bef6d0058cda2ab52eccf91b07313251"

URI_aarch64_rust-typenum+i128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typenum+i128-devel-1.18.0-1.el10_1.noarch.rpm;name=aarch64_rust-typenum+i128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typenum+i128-devel}"
SRC_URI[aarch64_rust-typenum+i128-devel.sha256sum] = "72f308f3d06f4f1bef1843ed64ce1a607833299ab663dc2a608a70df696f089a"

URI_aarch64_rust-typenum+no_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typenum+no_std-devel-1.18.0-1.el10_1.noarch.rpm;name=aarch64_rust-typenum+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typenum+no_std-devel}"
SRC_URI[aarch64_rust-typenum+no_std-devel.sha256sum] = "c62555d7ef6b2104ca1573c17d83fe809fd124493b22969930c1edcc4b2231c1"

URI_aarch64_rust-typenum+strict-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typenum+strict-devel-1.18.0-1.el10_1.noarch.rpm;name=aarch64_rust-typenum+strict-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typenum+strict-devel}"
SRC_URI[aarch64_rust-typenum+strict-devel.sha256sum] = "765a898e543dfee41df069643b4cd10daa404772650596d69cc97245c31ceeea"

URI_aarch64_rust-typenum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typenum-devel-1.18.0-1.el10_1.noarch.rpm;name=aarch64_rust-typenum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typenum-devel}"
SRC_URI[aarch64_rust-typenum-devel.sha256sum] = "996414a615dc00e6f8db7b38341f50b8c11cd25d8b57933056fcb25763a65814"

RDEPENDS:rust-typenum+const-generics-devel = " \
 cargo \
 rust-typenum-devel \
 "
RDEPENDS:rust-typenum+default-devel = " \
 cargo \
 rust-typenum-devel \
 "
RDEPENDS:rust-typenum+force_unix_path_separator-devel = " \
 cargo \
 rust-typenum-devel \
 "
RDEPENDS:rust-typenum+i128-devel = " \
 cargo \
 rust-typenum-devel \
 "
RDEPENDS:rust-typenum+no_std-devel = " \
 cargo \
 rust-typenum-devel \
 "
RDEPENDS:rust-typenum+strict-devel = " \
 cargo \
 rust-typenum-devel \
 "
RDEPENDS:rust-typenum-devel = " \
 cargo \
 rust \
 "
