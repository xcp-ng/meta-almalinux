# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-toml_writer"
PV = "1.0.6"
PR = "1.el10_2"
PACKAGES = " \
 rust-toml_writer+alloc-devel \
 rust-toml_writer+default-devel \
 rust-toml_writer+std-devel \
 rust-toml_writer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-toml_writer-1.0.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b9fd3720fa3be9d7c67b5874dd9351eb66e2f9140ca20ed380e54209dad64ae5"

URI_x86_64_v2_rust-toml_writer+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_writer+alloc-devel-1.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_writer+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_writer+alloc-devel}"
SRC_URI[x86_64_v2_rust-toml_writer+alloc-devel.sha256sum] = "65d972801794c0f6e8fcb68a0aef8b242c48b3fc0e44fa8af7a61ce09fd0c2db"

URI_x86_64_v2_rust-toml_writer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_writer+default-devel-1.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_writer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_writer+default-devel}"
SRC_URI[x86_64_v2_rust-toml_writer+default-devel.sha256sum] = "5c86a0dd35ae40f21697a150c7e6aa472c3faf719432bf7ee9168a2f91583545"

URI_x86_64_v2_rust-toml_writer+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_writer+std-devel-1.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_writer+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_writer+std-devel}"
SRC_URI[x86_64_v2_rust-toml_writer+std-devel.sha256sum] = "169ea0adfb2556cc589c954e6a858b7d9159a6cb66554fe52f34945aff6e95d8"

URI_x86_64_v2_rust-toml_writer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_writer-devel-1.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_writer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_writer-devel}"
SRC_URI[x86_64_v2_rust-toml_writer-devel.sha256sum] = "a501e9e42874ca727926aa3d7dfc6cad7cccca29b19f076e7887db0ea9b8d482"

URI_aarch64_rust-toml_writer+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_writer+alloc-devel-1.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-toml_writer+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_writer+alloc-devel}"
SRC_URI[aarch64_rust-toml_writer+alloc-devel.sha256sum] = "c1f53929cbc6c0c5c99e0833a1a9614b35b320db90ca0bdd3aa2351b03541c39"

URI_aarch64_rust-toml_writer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_writer+default-devel-1.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-toml_writer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_writer+default-devel}"
SRC_URI[aarch64_rust-toml_writer+default-devel.sha256sum] = "032f0c7ae40f9a233de547a369a32a7c8477de5349ccdebc3e4543f7f2626ddb"

URI_aarch64_rust-toml_writer+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_writer+std-devel-1.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-toml_writer+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_writer+std-devel}"
SRC_URI[aarch64_rust-toml_writer+std-devel.sha256sum] = "d38009a95154ab9ffd63bc0c4e84a5f3d9d2aca579491798a1e2d40c8003f72b"

URI_aarch64_rust-toml_writer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_writer-devel-1.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-toml_writer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_writer-devel}"
SRC_URI[aarch64_rust-toml_writer-devel.sha256sum] = "82e391e562a53acc24fc66632592d46308d9a9c08ef6ca7693d0cda06ac008ff"

RDEPENDS:rust-toml_writer+alloc-devel = " \
 cargo \
 rust-toml_writer-devel \
 "
RDEPENDS:rust-toml_writer+default-devel = " \
 cargo \
 rust-toml_writer+std-devel \
 rust-toml_writer-devel \
 "
RDEPENDS:rust-toml_writer+std-devel = " \
 cargo \
 rust-toml_writer+alloc-devel \
 rust-toml_writer-devel \
 "
RDEPENDS:rust-toml_writer-devel = " \
 cargo \
 rust \
 "
