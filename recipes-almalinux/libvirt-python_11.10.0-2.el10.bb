# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libvirt-python"
PV = "11.10.0"
PR = "2.el10"
PACKAGES = " \
 python3-libvirt \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libvirt-python-11.10.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e608f25a60e1e972c1bdccf3442e47ab9881aba5c486157bb48bf3fa7370174"

URI_x86_64_v2_python3-libvirt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libvirt-11.10.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libvirt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libvirt}"
SRC_URI[x86_64_v2_python3-libvirt.sha256sum] = "3a1f881e7d26984cab5965f4fd583eb2a8ea3b41a35c9aebdef8b7b0af39f329"

URI_aarch64_python3-libvirt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libvirt-11.10.0-2.el10.aarch64.rpm;name=aarch64_python3-libvirt;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libvirt}"
SRC_URI[aarch64_python3-libvirt.sha256sum] = "09d1a0996504ad4211ed6e7eaa5ae823b204e687daf7e291f2b78f75122f2fe5"

RDEPENDS:python3-libvirt = " \
 glibc \
 libvirt-libs \
 python3 \
 "
