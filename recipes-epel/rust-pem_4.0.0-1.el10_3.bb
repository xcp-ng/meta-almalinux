# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pem"
PV = "4.0.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-pem+default-devel \
 rust-pem+serde-devel \
 rust-pem+std-devel \
 rust-pem-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-pem-4.0.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2f31ddf41c9fc85b562bfcff30e7fd067d909902c1d2a1904b72210fbea024e0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pem+default-devel-4.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pem+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pem+default-devel.sha256sum] = "734bdf8c313c6f472d32550b26273a851c6ce53e784e9f2d0e7c26c2a6c7f41f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pem+serde-devel-4.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pem+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pem+serde-devel.sha256sum] = "2888d6353fd5e8e15511607b84d7162165b26766d0fcc88e3bfca896ef329728"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pem+std-devel-4.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pem+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pem+std-devel.sha256sum] = "5b695ed34c9d18f2b1175bb7f89dbc796f2be0d655997135ed3362b87c6c3b33"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pem-devel-4.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pem-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pem-devel.sha256sum] = "8214fca2e6c7de82c1974e7394c22e3995451c0bbadef6812dc5fabb1cfaf706"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pem+default-devel-4.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-pem+default-devel;unpack=0"
SRC_URI[aarch64_rust-pem+default-devel.sha256sum] = "0e4dea485f424045c06a8bad53e88b30978d411600a6297065898a66be8eb579"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pem+serde-devel-4.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-pem+serde-devel;unpack=0"
SRC_URI[aarch64_rust-pem+serde-devel.sha256sum] = "32198a94572caf2cd21b25aa362fda82235962b8f5a665a77ae1e7365dd86004"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pem+std-devel-4.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-pem+std-devel;unpack=0"
SRC_URI[aarch64_rust-pem+std-devel.sha256sum] = "c1f26b20432accffa7a59a15c269256e67434a1215c08ccb574256dae14db7fe"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pem-devel-4.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-pem-devel;unpack=0"
SRC_URI[aarch64_rust-pem-devel.sha256sum] = "f9dffecccfcf400a5a7fadd58298a0afac45ff673c267d282ae5bb56e78fff5f"

RDEPENDS:rust-pem+default-devel = " \
 cargo \
 rust-pem+std-devel \
 rust-pem-devel \
 "
RDEPENDS:rust-pem+serde-devel = " \
 cargo \
 rust-pem-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-pem+std-devel = " \
 cargo \
 rust-base64+std-devel \
 rust-pem-devel \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-pem-devel = " \
 cargo \
 rust \
 rust-base64+alloc-devel \
 rust-base64-devel \
 "
