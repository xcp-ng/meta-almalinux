# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-firewall"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 plasma-firewall \
 plasma-firewall-firewalld \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-firewall-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f091b0997efd5d00aad6ea29bd566bca4bcaf1b8d8cce657b0b8559257487562"

URI_x86_64_v2_plasma-firewall = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-firewall-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-firewall;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-firewall}"
SRC_URI[x86_64_v2_plasma-firewall.sha256sum] = "e72998f61d4e48cf02d2a5bb94f59a73febefbae2d3b43b8c7b0d7a317ba9057"

URI_x86_64_v2_plasma-firewall-firewalld = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-firewall-firewalld-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-firewall-firewalld;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-firewall-firewalld}"
SRC_URI[x86_64_v2_plasma-firewall-firewalld.sha256sum] = "1b6db6977b63a7c606093d4aa7d83696de66363e82152d7bde03943644b232dc"

URI_aarch64_plasma-firewall = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-firewall-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-firewall;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-firewall}"
SRC_URI[aarch64_plasma-firewall.sha256sum] = "2c98ded59aa7a658913061c540d9ced9b7d26a61bcce361b95f46c51654256ab"

URI_aarch64_plasma-firewall-firewalld = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-firewall-firewalld-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-firewall-firewalld;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-firewall-firewalld}"
SRC_URI[aarch64_plasma-firewall-firewalld.sha256sum] = "8bf350de1930bd72734bf5ddcf988392845312df437a5e961040cdf5c3ec2b47"

RDEPENDS:plasma-firewall = " \
 glibc \
 kf6-kcmutils \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 plasma-firewall-firewalld \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:plasma-firewall-firewalld = " \
 firewalld \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 plasma-firewall \
 qt6-qtbase \
 "
