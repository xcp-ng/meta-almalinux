# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-debian"
PV = "0.1.51"
PR = "10.el10_2"
PACKAGES = " \
 python3-debian \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-debian-0.1.51-10.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "051f97086ba8342e9719749618744cff94e2c2ace7a9de8b3d8456bf6401f27a"

URI_x86_64_v2_python3-debian = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-debian-0.1.51-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-debian;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-debian}"
SRC_URI[x86_64_v2_python3-debian.sha256sum] = "4f4faa1a2431c085b32592e47b186f9b1059764a45f411959c91e57b7c3bb1f5"

URI_aarch64_python3-debian = "${EPEL_MIRROR}/aarch64/Packages/p/python3-debian-0.1.51-10.el10_2.noarch.rpm;name=aarch64_python3-debian;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-debian}"
SRC_URI[aarch64_python3-debian.sha256sum] = "d73c47b36c41f26b7baf174724b14706a0f92bb1205d2b55c30550bebe941db2"

RDEPENDS:python3-debian = " \
 python3 \
 python3-chardet \
 python3-charset-normalizer \
 python3-six \
 xz \
 "
