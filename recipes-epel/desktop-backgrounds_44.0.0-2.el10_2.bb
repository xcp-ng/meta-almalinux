# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "desktop-backgrounds"
PV = "44.0.0"
PR = "2.el10_2"
PACKAGES = " \
 desktop-backgrounds-basic \
 desktop-backgrounds-budgie \
 desktop-backgrounds-compat \
 desktop-backgrounds-gnome \
 desktop-backgrounds-kde \
 desktop-backgrounds-waves \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/desktop-backgrounds-44.0.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28b66212462525b6b59243eeceaa9a6a563d4b3d37e50d276e13827857ab4cfe"

URI_x86_64_v2_desktop-backgrounds-basic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/desktop-backgrounds-basic-44.0.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_desktop-backgrounds-basic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_desktop-backgrounds-basic}"
SRC_URI[x86_64_v2_desktop-backgrounds-basic.sha256sum] = "ffeb1ad1b406bc55caee6b02826b6e627d36c25611e8dbc08232c9346821e005"

URI_x86_64_v2_desktop-backgrounds-budgie = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/desktop-backgrounds-budgie-44.0.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_desktop-backgrounds-budgie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_desktop-backgrounds-budgie}"
SRC_URI[x86_64_v2_desktop-backgrounds-budgie.sha256sum] = "0a8a7ab34e39760a7d31a931aeca5760007cc4675ed61e674e3e58a340cc8906"

URI_x86_64_v2_desktop-backgrounds-compat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/desktop-backgrounds-compat-44.0.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_desktop-backgrounds-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_desktop-backgrounds-compat}"
SRC_URI[x86_64_v2_desktop-backgrounds-compat.sha256sum] = "e5a2ce0b7da78b85b92ef96e3278e57b8dff93baa4a9be54e734f9445460f10a"
RPROVIDES:desktop-backgrounds-compat:x86_64_v2 = "virtual/desktop-backgrounds-compat"

URI_x86_64_v2_desktop-backgrounds-gnome = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/desktop-backgrounds-gnome-44.0.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_desktop-backgrounds-gnome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_desktop-backgrounds-gnome}"
SRC_URI[x86_64_v2_desktop-backgrounds-gnome.sha256sum] = "8c9961f2ae6e85ddcf28aead1a51cb748b4e23ea5c4be828f1f107e20f99f1df"

URI_x86_64_v2_desktop-backgrounds-kde = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/desktop-backgrounds-kde-44.0.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_desktop-backgrounds-kde;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_desktop-backgrounds-kde}"
SRC_URI[x86_64_v2_desktop-backgrounds-kde.sha256sum] = "fe0d00ddf08be06b8a5018230743fd5b18fec423677cfae97f7788aaa45cde6f"
RPROVIDES:desktop-backgrounds-kde:x86_64_v2 = "virtual/system-backgrounds-kde"

URI_x86_64_v2_desktop-backgrounds-waves = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/desktop-backgrounds-waves-44.0.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_desktop-backgrounds-waves;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_desktop-backgrounds-waves}"
SRC_URI[x86_64_v2_desktop-backgrounds-waves.sha256sum] = "fb440073b68629fa9f7c6d941632c46bfea0291559af73eeb19f79671ce3072f"

URI_aarch64_desktop-backgrounds-basic = "${EPEL_MIRROR}/aarch64/Packages/d/desktop-backgrounds-basic-44.0.0-2.el10_2.noarch.rpm;name=aarch64_desktop-backgrounds-basic;unpack=0"
SRC_URI:append = " ${URI_aarch64_desktop-backgrounds-basic}"
SRC_URI[aarch64_desktop-backgrounds-basic.sha256sum] = "ba2e813df2d0a75a0cc0c074bc7a535c067e4d363835c912f677a0e7abc6f820"

URI_aarch64_desktop-backgrounds-budgie = "${EPEL_MIRROR}/aarch64/Packages/d/desktop-backgrounds-budgie-44.0.0-2.el10_2.noarch.rpm;name=aarch64_desktop-backgrounds-budgie;unpack=0"
SRC_URI:append = " ${URI_aarch64_desktop-backgrounds-budgie}"
SRC_URI[aarch64_desktop-backgrounds-budgie.sha256sum] = "3e86735cdaf3c8783a7ce5efcefcf32bdc3f55369d84c958a6605c5c8ba7619a"

URI_aarch64_desktop-backgrounds-compat = "${EPEL_MIRROR}/aarch64/Packages/d/desktop-backgrounds-compat-44.0.0-2.el10_2.noarch.rpm;name=aarch64_desktop-backgrounds-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_desktop-backgrounds-compat}"
SRC_URI[aarch64_desktop-backgrounds-compat.sha256sum] = "af4ef9211befcc56ed5a4ff31d906fcc3ca8450f4d39f1c5b696043dbec428b7"
RPROVIDES:desktop-backgrounds-compat:aarch64 = "virtual/desktop-backgrounds-compat"

URI_aarch64_desktop-backgrounds-gnome = "${EPEL_MIRROR}/aarch64/Packages/d/desktop-backgrounds-gnome-44.0.0-2.el10_2.noarch.rpm;name=aarch64_desktop-backgrounds-gnome;unpack=0"
SRC_URI:append = " ${URI_aarch64_desktop-backgrounds-gnome}"
SRC_URI[aarch64_desktop-backgrounds-gnome.sha256sum] = "475306ed1e73d2f30b7b1a99c06a5611724e4d08be4376c875d111c81c74643a"

URI_aarch64_desktop-backgrounds-kde = "${EPEL_MIRROR}/aarch64/Packages/d/desktop-backgrounds-kde-44.0.0-2.el10_2.noarch.rpm;name=aarch64_desktop-backgrounds-kde;unpack=0"
SRC_URI:append = " ${URI_aarch64_desktop-backgrounds-kde}"
SRC_URI[aarch64_desktop-backgrounds-kde.sha256sum] = "f0f9843cf504da71c02a1d09c6f23869603c2e5fd4209e00b6d6d42984d7b94f"
RPROVIDES:desktop-backgrounds-kde:aarch64 = "virtual/system-backgrounds-kde"

URI_aarch64_desktop-backgrounds-waves = "${EPEL_MIRROR}/aarch64/Packages/d/desktop-backgrounds-waves-44.0.0-2.el10_2.noarch.rpm;name=aarch64_desktop-backgrounds-waves;unpack=0"
SRC_URI:append = " ${URI_aarch64_desktop-backgrounds-waves}"
SRC_URI[aarch64_desktop-backgrounds-waves.sha256sum] = "c350beaf5f988de0ff7775ed5323045c4b4850dda7c38608118558e6879984c8"

RDEPENDS:desktop-backgrounds-basic = " \
 "
RDEPENDS:desktop-backgrounds-budgie = " \
 f44-backgrounds-budgie \
 gsettings-desktop-schemas \
 "
RDEPENDS:desktop-backgrounds-compat = " \
 f44-backgrounds-base \
 "
RDEPENDS:desktop-backgrounds-gnome = " \
 f44-backgrounds-gnome \
 gsettings-desktop-schemas \
 "
RDEPENDS:desktop-backgrounds-kde = " \
 f44-backgrounds-kde \
 "
RDEPENDS:desktop-backgrounds-waves = " \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/desktop-backgrounds-compat rpm/virtual/system-backgrounds-kde"

PROVIDES:append:aarch64 = " rpm/virtual/desktop-backgrounds-compat rpm/virtual/system-backgrounds-kde"
