# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Pod-Parser"
PV = "1.67"
PR = "5.el10"
PACKAGES = " \
 perl-Pod-Parser \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Pod-Parser-1.67-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ceea01daae99ee9c949cf970e4017ea6e083bcce2a5e27452917030d2ef91474"

URI_x86_64_v2_perl-Pod-Parser = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Pod-Parser-1.67-5.el10.noarch.rpm;name=x86_64_v2_perl-Pod-Parser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Pod-Parser}"
SRC_URI[x86_64_v2_perl-Pod-Parser.sha256sum] = "9816f28f61fd837590a99f9cd9898edfd0b8f12065149f37cddcf0b69373cef9"

URI_aarch64_perl-Pod-Parser = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Pod-Parser-1.67-5.el10.noarch.rpm;name=aarch64_perl-Pod-Parser;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Pod-Parser}"
SRC_URI[aarch64_perl-Pod-Parser.sha256sum] = "9816f28f61fd837590a99f9cd9898edfd0b8f12065149f37cddcf0b69373cef9"

RDEPENDS:perl-Pod-Parser = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Find \
 perl-Getopt-Long \
 perl-PathTools \
 perl-Pod-Parser \
 perl-Pod-Usage \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
