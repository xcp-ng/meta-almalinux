# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-parsec-numbers"
PV = "0.1.0"
PR = "35.el10_0"
PACKAGES = " \
 ghc-parsec-numbers \
 ghc-parsec-numbers-devel \
 ghc-parsec-numbers-doc \
 ghc-parsec-numbers-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-parsec-numbers-0.1.0-35.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "afd06cac8a977aa2885e696a95fd85f6a0a8d4a7931dcf583590ab8f0582e137"

URI_x86_64_v2_ghc-parsec-numbers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-parsec-numbers-0.1.0-35.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-parsec-numbers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-parsec-numbers}"
SRC_URI[x86_64_v2_ghc-parsec-numbers.sha256sum] = "562b22c65ae5cec13452e9254608c3d3dd32455b7b3b2386d85d66cad1756110"

URI_x86_64_v2_ghc-parsec-numbers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-parsec-numbers-devel-0.1.0-35.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-parsec-numbers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-parsec-numbers-devel}"
SRC_URI[x86_64_v2_ghc-parsec-numbers-devel.sha256sum] = "d30c661600c86b3f2637f75dcf49d5837901ca25ba8bd253e0651854e8aefd43"

URI_x86_64_v2_ghc-parsec-numbers-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-parsec-numbers-doc-0.1.0-35.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-parsec-numbers-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-parsec-numbers-doc}"
SRC_URI[x86_64_v2_ghc-parsec-numbers-doc.sha256sum] = "5f32fc634549ac8315d8fc2179c396a6381f02024709b40aca9e94c4adf85d84"

URI_x86_64_v2_ghc-parsec-numbers-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-parsec-numbers-prof-0.1.0-35.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-parsec-numbers-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-parsec-numbers-prof}"
SRC_URI[x86_64_v2_ghc-parsec-numbers-prof.sha256sum] = "5b9a27b482467cf8595f644f9eb225d3f78727c190ebbee25b5c96d03e33a4a0"

URI_aarch64_ghc-parsec-numbers = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-parsec-numbers-0.1.0-35.el10_0.aarch64.rpm;name=aarch64_ghc-parsec-numbers;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-parsec-numbers}"
SRC_URI[aarch64_ghc-parsec-numbers.sha256sum] = "a39953fab109c0147b18d299024034732c4f61a8083f94debd400c19b2f1f3ce"

URI_aarch64_ghc-parsec-numbers-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-parsec-numbers-devel-0.1.0-35.el10_0.aarch64.rpm;name=aarch64_ghc-parsec-numbers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-parsec-numbers-devel}"
SRC_URI[aarch64_ghc-parsec-numbers-devel.sha256sum] = "013d82718692fad202776e1b3d55896d06131b36f79db0174969248a4d54bdb5"

URI_aarch64_ghc-parsec-numbers-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-parsec-numbers-doc-0.1.0-35.el10_0.noarch.rpm;name=aarch64_ghc-parsec-numbers-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-parsec-numbers-doc}"
SRC_URI[aarch64_ghc-parsec-numbers-doc.sha256sum] = "6ac5dd4fbe5d3d924f4c64adcd26fca1b77d421599389d90c38e3b93b372f959"

URI_aarch64_ghc-parsec-numbers-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-parsec-numbers-prof-0.1.0-35.el10_0.aarch64.rpm;name=aarch64_ghc-parsec-numbers-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-parsec-numbers-prof}"
SRC_URI[aarch64_ghc-parsec-numbers-prof.sha256sum] = "c09ac219192c6e67f26970494dd9d14dc167937e0a1c3fb9f108a8d2cbffcb43"

RDEPENDS:ghc-parsec-numbers = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-parsec \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-parsec-numbers-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-parsec-devel \
 ghc-parsec-numbers \
 "
RDEPENDS:ghc-parsec-numbers-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-parsec-numbers-prof = " \
 ghc-base-prof \
 ghc-parsec-numbers-devel \
 ghc-parsec-prof \
 "
