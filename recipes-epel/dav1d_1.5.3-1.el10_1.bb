# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dav1d"
PV = "1.5.3"
PR = "1.el10_1"
PACKAGES = " \
 dav1d \
 libdav1d \
 libdav1d-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dav1d-1.5.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f105683e059d163c202574ebb0ac3a7a7dc805d779ef21bcd55e6a7bbee2a660"

URI_x86_64_v2_dav1d = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dav1d-1.5.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dav1d;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dav1d}"
SRC_URI[x86_64_v2_dav1d.sha256sum] = "e35df1054f8f079682f1aa1088054ff6086c0a5a2fe564885c4346e3fd240228"

URI_x86_64_v2_libdav1d = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdav1d-1.5.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdav1d;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdav1d}"
SRC_URI[x86_64_v2_libdav1d.sha256sum] = "f74e8465210b756117c11d535331b82f6303b467dae3bc2ac5165be8be7ce55f"

URI_x86_64_v2_libdav1d-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdav1d-devel-1.5.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdav1d-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdav1d-devel}"
SRC_URI[x86_64_v2_libdav1d-devel.sha256sum] = "5d6f0895b6a67c40a41a4f13efd01fe69c3b6fc7b9245d52d0d38abb048d054d"

URI_aarch64_dav1d = "${EPEL_MIRROR}/aarch64/Packages/d/dav1d-1.5.3-1.el10_1.aarch64.rpm;name=aarch64_dav1d;unpack=0"
SRC_URI:append = " ${URI_aarch64_dav1d}"
SRC_URI[aarch64_dav1d.sha256sum] = "c54b01c1f52c2ccdce580844ebff5578c133b6d64479b5160c87828c3e765b65"

URI_aarch64_libdav1d = "${EPEL_MIRROR}/aarch64/Packages/l/libdav1d-1.5.3-1.el10_1.aarch64.rpm;name=aarch64_libdav1d;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdav1d}"
SRC_URI[aarch64_libdav1d.sha256sum] = "99116336a873f8b8ae3a1905eb098abeefc283dcdff8915369f31979ad22841e"

URI_aarch64_libdav1d-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libdav1d-devel-1.5.3-1.el10_1.aarch64.rpm;name=aarch64_libdav1d-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdav1d-devel}"
SRC_URI[aarch64_libdav1d-devel.sha256sum] = "cd169f2981cf4b840f7dd2c4003c29c0e229126b1ef712aa3caf39ececaff487"

RDEPENDS:dav1d = " \
 glibc \
 libdav1d \
 "
RDEPENDS:libdav1d = " \
 glibc \
 "
RDEPENDS:libdav1d-devel = " \
 libdav1d \
 pkgconf-pkg-config \
 "
