# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tomlplusplus"
PV = "3.4.0"
PR = "5.el10_0"
PACKAGES = " \
 tomlplusplus \
 tomlplusplus-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tomlplusplus-3.4.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2dfa8f8c82535cbbc56c7704f59d664b814ff37d0acd87e277b7303501656070"

URI_x86_64_v2_tomlplusplus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tomlplusplus-3.4.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tomlplusplus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomlplusplus}"
SRC_URI[x86_64_v2_tomlplusplus.sha256sum] = "2a47bcd093eebf2538bcdbb72cbfb2baa88b7f9490917f17405686da464ff976"

URI_x86_64_v2_tomlplusplus-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tomlplusplus-devel-3.4.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tomlplusplus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomlplusplus-devel}"
SRC_URI[x86_64_v2_tomlplusplus-devel.sha256sum] = "a9b2de3cd1cc44add2dc80487d934ea6d5cdc4cb66512327aff94aa11838c788"

URI_aarch64_tomlplusplus = "${EPEL_MIRROR}/aarch64/Packages/t/tomlplusplus-3.4.0-5.el10_0.aarch64.rpm;name=aarch64_tomlplusplus;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomlplusplus}"
SRC_URI[aarch64_tomlplusplus.sha256sum] = "1ccd544098fc82ba294a7ff28a491745818d2240a8b516991b9174fcc6352b31"

URI_aarch64_tomlplusplus-devel = "${EPEL_MIRROR}/aarch64/Packages/t/tomlplusplus-devel-3.4.0-5.el10_0.aarch64.rpm;name=aarch64_tomlplusplus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomlplusplus-devel}"
SRC_URI[aarch64_tomlplusplus-devel.sha256sum] = "43d9a031be0ca43453a930c86596c8e58c91864edc3ef1e51c324df4ee16b325"

RDEPENDS:tomlplusplus = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:tomlplusplus-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 tomlplusplus \
 "
