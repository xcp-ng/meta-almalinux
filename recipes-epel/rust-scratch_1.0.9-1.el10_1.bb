# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-scratch"
PV = "1.0.9"
PR = "1.el10_1"
PACKAGES = " \
 rust-scratch+default-devel \
 rust-scratch-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-scratch-1.0.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be1eb41d8cf5fc41023b4477191fcddabe65c81bcee78ff2803bf25301eb7040"

URI_x86_64_v2_rust-scratch+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scratch+default-devel-1.0.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scratch+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scratch+default-devel}"
SRC_URI[x86_64_v2_rust-scratch+default-devel.sha256sum] = "083345e7f83695c3fc8e50b94acd18195c453f4df69fbe4dc844ce4a47a8ebaa"

URI_x86_64_v2_rust-scratch-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scratch-devel-1.0.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scratch-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scratch-devel}"
SRC_URI[x86_64_v2_rust-scratch-devel.sha256sum] = "2fdeda41a278979b219cfa2c2fad06e729afc19747b93e7892898432a98bc168"

URI_aarch64_rust-scratch+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scratch+default-devel-1.0.9-1.el10_1.noarch.rpm;name=aarch64_rust-scratch+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scratch+default-devel}"
SRC_URI[aarch64_rust-scratch+default-devel.sha256sum] = "c9e9477f48883609186aa8d10a6e243c394cd108f228b13441aa2da662b55270"

URI_aarch64_rust-scratch-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scratch-devel-1.0.9-1.el10_1.noarch.rpm;name=aarch64_rust-scratch-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scratch-devel}"
SRC_URI[aarch64_rust-scratch-devel.sha256sum] = "d601334a2f92edc6fda269f031b70ccd986700569c8b8c85433fe97687f79a88"

RDEPENDS:rust-scratch+default-devel = " \
 cargo \
 rust-scratch-devel \
 "
RDEPENDS:rust-scratch-devel = " \
 cargo \
 rust \
 "
