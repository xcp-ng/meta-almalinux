# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-conda-package-handling"
PV = "2.4.0"
PR = "6.el10_3"
PACKAGES = " \
 python3-conda-package-handling \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-conda-package-handling-2.4.0-6.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "427370bda8c31e60f90a0437f7a71621516e98e7acfe0dcb769ccc46ca24dc49"

URI_x86_64_v2_python3-conda-package-handling = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-conda-package-handling-2.4.0-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-conda-package-handling;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-conda-package-handling}"
SRC_URI[x86_64_v2_python3-conda-package-handling.sha256sum] = "179cdda542b63d11e4f183574f464e7634166868aaef3b9fd3c4fdf2fb2dc9af"

URI_aarch64_python3-conda-package-handling = "${EPEL_MIRROR}/aarch64/Packages/p/python3-conda-package-handling-2.4.0-6.el10_3.noarch.rpm;name=aarch64_python3-conda-package-handling;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-conda-package-handling}"
SRC_URI[aarch64_python3-conda-package-handling.sha256sum] = "7b5f5f05cf9c095a035bba9ef0e279a8d8c04dc9fcfd2396d4fe27bbd6d715c2"

RDEPENDS:python3-conda-package-handling = " \
 python3 \
 python3-conda-package-streaming \
 "
