# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wyz"
PV = "0.5.1"
PR = "5.el10_0"
PACKAGES = " \
 rust-wyz+alloc-devel \
 rust-wyz+default-devel \
 rust-wyz+std-devel \
 rust-wyz-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wyz-0.5.1-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2679fc999e96c56f942438c8b169563afc8311d0ed537820c587717a345f02a0"

URI_x86_64_v2_rust-wyz+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wyz+alloc-devel-0.5.1-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wyz+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wyz+alloc-devel}"
SRC_URI[x86_64_v2_rust-wyz+alloc-devel.sha256sum] = "92ccc3e36b4d1b3cd8fb7be7452c8e197eb60a569a0fddcef1ae801d56a6d70a"

URI_x86_64_v2_rust-wyz+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wyz+default-devel-0.5.1-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wyz+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wyz+default-devel}"
SRC_URI[x86_64_v2_rust-wyz+default-devel.sha256sum] = "9f9b71820798d0785a1319c91887e234bec9d99481cd0dcd66298021eaf6d98f"

URI_x86_64_v2_rust-wyz+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wyz+std-devel-0.5.1-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wyz+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wyz+std-devel}"
SRC_URI[x86_64_v2_rust-wyz+std-devel.sha256sum] = "bbc46a868fac777581852ce14fa34504e35662f8e1f170dc54e6910cc2dadc66"

URI_x86_64_v2_rust-wyz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wyz-devel-0.5.1-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wyz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wyz-devel}"
SRC_URI[x86_64_v2_rust-wyz-devel.sha256sum] = "22b1c4b908112a8e09aeba1b0eedae0e8bfe3d211e8ec6798caf76534799394f"

URI_aarch64_rust-wyz+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wyz+alloc-devel-0.5.1-5.el10_0.noarch.rpm;name=aarch64_rust-wyz+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wyz+alloc-devel}"
SRC_URI[aarch64_rust-wyz+alloc-devel.sha256sum] = "c8b74185e857c22d442095c97d192eedef0e3d07a1e90cc7905c145e83cee03a"

URI_aarch64_rust-wyz+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wyz+default-devel-0.5.1-5.el10_0.noarch.rpm;name=aarch64_rust-wyz+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wyz+default-devel}"
SRC_URI[aarch64_rust-wyz+default-devel.sha256sum] = "5710fc241463fe263620018d75ea6bfb96db38aad79b89c554dd8c8ce6920d03"

URI_aarch64_rust-wyz+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wyz+std-devel-0.5.1-5.el10_0.noarch.rpm;name=aarch64_rust-wyz+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wyz+std-devel}"
SRC_URI[aarch64_rust-wyz+std-devel.sha256sum] = "8cfe618df24042d858675c45e2b504fbd320b6c48af39164e75fae4f85ed4994"

URI_aarch64_rust-wyz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wyz-devel-0.5.1-5.el10_0.noarch.rpm;name=aarch64_rust-wyz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wyz-devel}"
SRC_URI[aarch64_rust-wyz-devel.sha256sum] = "3f41a3e201c0c25c2ae22f47f37ff0d6791552c1507c6c2bd58e3458ca3d58cc"

RDEPENDS:rust-wyz+alloc-devel = " \
 cargo \
 rust-wyz-devel \
 "
RDEPENDS:rust-wyz+default-devel = " \
 cargo \
 rust-wyz+std-devel \
 rust-wyz-devel \
 "
RDEPENDS:rust-wyz+std-devel = " \
 cargo \
 rust-wyz+alloc-devel \
 rust-wyz-devel \
 "
RDEPENDS:rust-wyz-devel = " \
 cargo \
 rust-tap+default-devel \
 "
