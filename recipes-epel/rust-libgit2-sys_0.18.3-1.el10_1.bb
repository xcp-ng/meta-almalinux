# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libgit2-sys"
PV = "0.18.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-libgit2-sys+default-devel \
 rust-libgit2-sys+https-devel \
 rust-libgit2-sys+libssh2-sys-devel \
 rust-libgit2-sys+openssl-sys-devel \
 rust-libgit2-sys+ssh-devel \
 rust-libgit2-sys+vendored-devel \
 rust-libgit2-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libgit2-sys-0.18.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "31470c5d3ea697aa17dd0a3c472fc97670f4d0ca893c0317aff634da799c2d74"

URI_x86_64_v2_rust-libgit2-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys+default-devel-0.18.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys+default-devel.sha256sum] = "ce7ce93c177f4142046102af2c84fd0cdfe44eb440d0d6a928fc38a97cd6e038"

URI_x86_64_v2_rust-libgit2-sys+https-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys+https-devel-0.18.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys+https-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys+https-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys+https-devel.sha256sum] = "e5dfef155f6366bbcafe0762cc4e2098f59d2ee2997327dc22cc9c644000204e"

URI_x86_64_v2_rust-libgit2-sys+libssh2-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys+libssh2-sys-devel-0.18.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys+libssh2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys+libssh2-sys-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys+libssh2-sys-devel.sha256sum] = "b61dded19d56651115b670e09502072d920d68b93fc9257538d90b0e4fc0b64a"

URI_x86_64_v2_rust-libgit2-sys+openssl-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys+openssl-sys-devel-0.18.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys+openssl-sys-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys+openssl-sys-devel.sha256sum] = "7a7f838d544d1c48dde43bca37e9364acd72775a94bac2d29e21c78fc4277af4"

URI_x86_64_v2_rust-libgit2-sys+ssh-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys+ssh-devel-0.18.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys+ssh-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys+ssh-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys+ssh-devel.sha256sum] = "60c8e6ecbaf047b5eb60ad0091b22202cae81fea953edc9395729a5322ce39fe"

URI_x86_64_v2_rust-libgit2-sys+vendored-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys+vendored-devel-0.18.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys+vendored-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys+vendored-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys+vendored-devel.sha256sum] = "2eb7c43b40eadb1018c7783870723c9e82da64c642d70fc50e7cb44e92d5584f"

URI_x86_64_v2_rust-libgit2-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys-devel-0.18.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys-devel.sha256sum] = "9113eccc6f5b4027c6284aa00db509e2fb09dcae470da67803b4c950bcab577e"

URI_aarch64_rust-libgit2-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys+default-devel-0.18.3-1.el10_1.noarch.rpm;name=aarch64_rust-libgit2-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys+default-devel}"
SRC_URI[aarch64_rust-libgit2-sys+default-devel.sha256sum] = "88092c791a2b53670b574e2b2ccd265f2d7ff82778d45e94976da3348f427447"

URI_aarch64_rust-libgit2-sys+https-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys+https-devel-0.18.3-1.el10_1.noarch.rpm;name=aarch64_rust-libgit2-sys+https-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys+https-devel}"
SRC_URI[aarch64_rust-libgit2-sys+https-devel.sha256sum] = "40540d46f4cebbb8603ccadc6af27199544f976b62373c7bdd81e3d5292398eb"

URI_aarch64_rust-libgit2-sys+libssh2-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys+libssh2-sys-devel-0.18.3-1.el10_1.noarch.rpm;name=aarch64_rust-libgit2-sys+libssh2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys+libssh2-sys-devel}"
SRC_URI[aarch64_rust-libgit2-sys+libssh2-sys-devel.sha256sum] = "41936ed5018a4642ddfb72c0e60c11c4f162d71aa27b0ad1a7df1f99c3c9af95"

URI_aarch64_rust-libgit2-sys+openssl-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys+openssl-sys-devel-0.18.3-1.el10_1.noarch.rpm;name=aarch64_rust-libgit2-sys+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys+openssl-sys-devel}"
SRC_URI[aarch64_rust-libgit2-sys+openssl-sys-devel.sha256sum] = "480b44c459d63c14186c892b17125bd362d9c5da9042bbbbe908832f5bf8964a"

URI_aarch64_rust-libgit2-sys+ssh-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys+ssh-devel-0.18.3-1.el10_1.noarch.rpm;name=aarch64_rust-libgit2-sys+ssh-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys+ssh-devel}"
SRC_URI[aarch64_rust-libgit2-sys+ssh-devel.sha256sum] = "890f907475238937517359c598542104e1b47d3ca602af6c9118ac66e44ca1ea"

URI_aarch64_rust-libgit2-sys+vendored-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys+vendored-devel-0.18.3-1.el10_1.noarch.rpm;name=aarch64_rust-libgit2-sys+vendored-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys+vendored-devel}"
SRC_URI[aarch64_rust-libgit2-sys+vendored-devel.sha256sum] = "7b39e2b19977615f4386a3a2aca16f335fe664be4d28c190c4e19cd4a8e6c395"

URI_aarch64_rust-libgit2-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys-devel-0.18.3-1.el10_1.noarch.rpm;name=aarch64_rust-libgit2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys-devel}"
SRC_URI[aarch64_rust-libgit2-sys-devel.sha256sum] = "938754b5ae18a3391ce33cc5cf5cbf122a7a78ba5b424657c100d892f4bafb75"

RDEPENDS:rust-libgit2-sys+default-devel = " \
 cargo \
 rust-libgit2-sys-devel \
 "
RDEPENDS:rust-libgit2-sys+https-devel = " \
 cargo \
 rust-libgit2-sys+openssl-sys-devel \
 rust-libgit2-sys-devel \
 "
RDEPENDS:rust-libgit2-sys+libssh2-sys-devel = " \
 cargo \
 rust-libgit2-sys-devel \
 rust-libssh2-sys+default-devel \
 "
RDEPENDS:rust-libgit2-sys+openssl-sys-devel = " \
 cargo \
 rust-libgit2-sys-devel \
 rust-openssl-sys+default-devel \
 "
RDEPENDS:rust-libgit2-sys+ssh-devel = " \
 cargo \
 rust-libgit2-sys+libssh2-sys-devel \
 rust-libgit2-sys-devel \
 "
RDEPENDS:rust-libgit2-sys+vendored-devel = " \
 cargo \
 rust-libgit2-sys-devel \
 "
RDEPENDS:rust-libgit2-sys-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-cc+parallel-devel \
 rust-libc+default-devel \
 rust-libz-sys+libc-devel \
 rust-libz-sys-devel \
 rust-pkg-config+default-devel \
 "
