# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "IP2Location"
PV = "8.6.1"
PR = "6.el10_0"
PACKAGES = " \
 IP2Location \
 IP2Location-data-sample \
 IP2Location-devel \
 IP2Location-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/IP2Location-8.6.1-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6d27b02460d4cd9bc3c62e859838ec77db695582f74135cc9da8cfe3ae45e554"

URI_x86_64_v2_IP2Location = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/IP2Location-8.6.1-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_IP2Location;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_IP2Location}"
SRC_URI[x86_64_v2_IP2Location.sha256sum] = "0e225a6d040022f1f87c211a3137cfa1404e4cc3375955967abcf340280e670c"

URI_x86_64_v2_IP2Location-data-sample = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/IP2Location-data-sample-8.6.1-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_IP2Location-data-sample;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_IP2Location-data-sample}"
SRC_URI[x86_64_v2_IP2Location-data-sample.sha256sum] = "3e18f74539b52e8963c7681fb526d905daa43f7486a32d5de43089246aafed21"

URI_x86_64_v2_IP2Location-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/IP2Location-devel-8.6.1-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_IP2Location-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_IP2Location-devel}"
SRC_URI[x86_64_v2_IP2Location-devel.sha256sum] = "f9cb56cd44f57a840c27f775568b40ca5dae4d4a3d156d6890e102ab2b49a78b"

URI_x86_64_v2_IP2Location-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/IP2Location-libs-8.6.1-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_IP2Location-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_IP2Location-libs}"
SRC_URI[x86_64_v2_IP2Location-libs.sha256sum] = "9101dcdd17923aa8ce83b5728c81b155994a271fdfe0552ab29fd4307e8b1e81"

URI_aarch64_IP2Location = "${EPEL_MIRROR}/aarch64/Packages/i/IP2Location-8.6.1-6.el10_0.aarch64.rpm;name=aarch64_IP2Location;unpack=0"
SRC_URI:append = " ${URI_aarch64_IP2Location}"
SRC_URI[aarch64_IP2Location.sha256sum] = "a440140a905a47bf63ef6205809d75f61a4de85a1ef9d7383c4b1575bfcd5c8f"

URI_aarch64_IP2Location-data-sample = "${EPEL_MIRROR}/aarch64/Packages/i/IP2Location-data-sample-8.6.1-6.el10_0.aarch64.rpm;name=aarch64_IP2Location-data-sample;unpack=0"
SRC_URI:append = " ${URI_aarch64_IP2Location-data-sample}"
SRC_URI[aarch64_IP2Location-data-sample.sha256sum] = "ec86589131bd3c560aedc615582f36ab30cebe172a7c3bb487943035d7110d73"

URI_aarch64_IP2Location-devel = "${EPEL_MIRROR}/aarch64/Packages/i/IP2Location-devel-8.6.1-6.el10_0.aarch64.rpm;name=aarch64_IP2Location-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_IP2Location-devel}"
SRC_URI[aarch64_IP2Location-devel.sha256sum] = "6f2523bf233a5b01c9f42f73f7ab5f98fc583cfa4897addabbfda3b41132eb7e"

URI_aarch64_IP2Location-libs = "${EPEL_MIRROR}/aarch64/Packages/i/IP2Location-libs-8.6.1-6.el10_0.aarch64.rpm;name=aarch64_IP2Location-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_IP2Location-libs}"
SRC_URI[aarch64_IP2Location-libs.sha256sum] = "3f0f5bd153d7b921ad4e0cf22f79454e6454c828be173c3d55a2800b511f768f"

RDEPENDS:IP2Location = " \
 IP2Location-libs \
 glibc \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:IP2Location-data-sample = " \
 IP2Location \
 "
RDEPENDS:IP2Location-devel = " \
 IP2Location \
 IP2Location-libs \
 "
RDEPENDS:IP2Location-libs = " \
 glibc \
 "
