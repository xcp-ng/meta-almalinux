# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-config-value"
PV = "0.18.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-config-value+default-devel \
 rust-gix-config-value+document-features-devel \
 rust-gix-config-value+serde-devel \
 rust-gix-config-value-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-config-value-0.18.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4893ae6d4cdd7426e14127378084e1e01eaa2b747e59ece69a600784aa652404"

URI_x86_64_v2_rust-gix-config-value+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config-value+default-devel-0.18.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config-value+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config-value+default-devel}"
SRC_URI[x86_64_v2_rust-gix-config-value+default-devel.sha256sum] = "3b17235697885ff18902556a23714c34485b6472ba635a3fcfbec9515913fc91"

URI_x86_64_v2_rust-gix-config-value+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config-value+document-features-devel-0.18.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config-value+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config-value+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-config-value+document-features-devel.sha256sum] = "08cc72bb41a8f90e786fa9bd25b91fab75fbf5c66686a2dd2356136ec46c148b"

URI_x86_64_v2_rust-gix-config-value+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config-value+serde-devel-0.18.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config-value+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config-value+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-config-value+serde-devel.sha256sum] = "ea74ac7633efe0a457eef2accead43c2eb10090792cfeb3e1671f41b789f42f5"

URI_x86_64_v2_rust-gix-config-value-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config-value-devel-0.18.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config-value-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config-value-devel}"
SRC_URI[x86_64_v2_rust-gix-config-value-devel.sha256sum] = "81fb15e9a8fd1e8b0653fba6adfb3da4177b9e62bf138951268062c1f56140dd"

URI_aarch64_rust-gix-config-value+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config-value+default-devel-0.18.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-config-value+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config-value+default-devel}"
SRC_URI[aarch64_rust-gix-config-value+default-devel.sha256sum] = "bede09a98c459d504cb58e86112fe64cbcb6044c050cb18aa8e62dd46401ea5e"

URI_aarch64_rust-gix-config-value+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config-value+document-features-devel-0.18.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-config-value+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config-value+document-features-devel}"
SRC_URI[aarch64_rust-gix-config-value+document-features-devel.sha256sum] = "0fef8cbb6c9820e076292efb3e3587a5b5fb822e7b4bc11996b03f0cf4dabdbf"

URI_aarch64_rust-gix-config-value+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config-value+serde-devel-0.18.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-config-value+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config-value+serde-devel}"
SRC_URI[aarch64_rust-gix-config-value+serde-devel.sha256sum] = "445fafa3bc650fcfbd26f2fc7a6c71499aefd24002f3d1182e5bd265110d3f3c"

URI_aarch64_rust-gix-config-value-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config-value-devel-0.18.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-config-value-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config-value-devel}"
SRC_URI[aarch64_rust-gix-config-value-devel.sha256sum] = "69ad5924d11465b8b6467c3834691c11b856bf41ca56fd944307dbdefd424360"

RDEPENDS:rust-gix-config-value+default-devel = " \
 cargo \
 rust-gix-config-value-devel \
 "
RDEPENDS:rust-gix-config-value+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-config-value-devel \
 "
RDEPENDS:rust-gix-config-value+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-config-value-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-config-value-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-path+default-devel \
 rust-libc+default-devel \
 rust-thiserror+default-devel \
 "
