# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libquicktime"
PV = "1.2.4"
PR = "62.20240202git2213b76.el10_1"
PACKAGES = " \
 libquicktime \
 libquicktime-devel \
 libquicktime-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libquicktime-1.2.4-62.20240202git2213b76.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6538bd3a2bf1a48209fae168f08bd11abdee1f1634ce2b51d6cb419e755a64cc"

URI_x86_64_v2_libquicktime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libquicktime-1.2.4-62.20240202git2213b76.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libquicktime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libquicktime}"
SRC_URI[x86_64_v2_libquicktime.sha256sum] = "fea2c231f787f9b5291e2aa4360178b6bb8091f94c65b8147b8f1896c956e27a"

URI_x86_64_v2_libquicktime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libquicktime-devel-1.2.4-62.20240202git2213b76.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libquicktime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libquicktime-devel}"
SRC_URI[x86_64_v2_libquicktime-devel.sha256sum] = "ca6b6c1213083dd1af35210aa689799d41b0b6d249038ac3a8553909cf5df78c"

URI_x86_64_v2_libquicktime-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libquicktime-utils-1.2.4-62.20240202git2213b76.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libquicktime-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libquicktime-utils}"
SRC_URI[x86_64_v2_libquicktime-utils.sha256sum] = "e477e4bf9c222d4699ae4a668b0338cdd44f5e8fa590b7a79e11d0144aae8f87"

URI_aarch64_libquicktime = "${EPEL_MIRROR}/aarch64/Packages/l/libquicktime-1.2.4-62.20240202git2213b76.el10_1.aarch64.rpm;name=aarch64_libquicktime;unpack=0"
SRC_URI:append = " ${URI_aarch64_libquicktime}"
SRC_URI[aarch64_libquicktime.sha256sum] = "a29201ac4aa5144641b276176f0287346e29614e6c9fcad3cb5a5fdf46b21670"

URI_aarch64_libquicktime-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libquicktime-devel-1.2.4-62.20240202git2213b76.el10_1.aarch64.rpm;name=aarch64_libquicktime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libquicktime-devel}"
SRC_URI[aarch64_libquicktime-devel.sha256sum] = "ace2683c133a07fb2eb609cf136a16e5d94516ee40ee92769d16f73a7f4ab15c"

URI_aarch64_libquicktime-utils = "${EPEL_MIRROR}/aarch64/Packages/l/libquicktime-utils-1.2.4-62.20240202git2213b76.el10_1.aarch64.rpm;name=aarch64_libquicktime-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libquicktime-utils}"
SRC_URI[aarch64_libquicktime-utils.sha256sum] = "b5a2a518414173bd3a36ae575f50be2fb9548da7fa8f7d8e7302c31e7bfdfe79"

RDEPENDS:libquicktime = " \
 glibc \
 lame-libs \
 libjpeg-turbo \
 libpng \
 libvorbis \
 zlib-ng-compat \
 "
RDEPENDS:libquicktime-devel = " \
 libquicktime \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:libquicktime-utils = " \
 alsa-lib \
 glib2 \
 glibc \
 gtk2 \
 libX11 \
 libXaw \
 libXext \
 libXt \
 libXv \
 libglvnd-glx \
 libquicktime \
 "
