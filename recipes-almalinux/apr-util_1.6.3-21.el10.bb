# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apr-util"
PV = "1.6.3"
PR = "21.el10"
PACKAGES = " \
 apr-util \
 apr-util-devel \
 apr-util-ldap \
 apr-util-lmdb \
 apr-util-mysql \
 apr-util-odbc \
 apr-util-openssl \
 apr-util-pgsql \
 apr-util-sqlite \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/apr-util-1.6.3-21.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b81533273ab61aae0af1493b5d1fde427221a88c24a2a5d4f25e850380ef19ee"

URI_x86_64_v2_apr-util = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-1.6.3-21.el10.x86_64_v2.rpm;name=x86_64_v2_apr-util;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apr-util}"
SRC_URI[x86_64_v2_apr-util.sha256sum] = "018bc0c29c7bff3647297940f6aee6a0695e02c4f6105baebd8762df857de647"

URI_x86_64_v2_apr-util-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-devel-1.6.3-21.el10.x86_64_v2.rpm;name=x86_64_v2_apr-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apr-util-devel}"
SRC_URI[x86_64_v2_apr-util-devel.sha256sum] = "c7812c538a752e111c8d37d889f832c2d2087782b2b02631150e48da8ae894ff"

URI_x86_64_v2_apr-util-ldap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-ldap-1.6.3-21.el10.x86_64_v2.rpm;name=x86_64_v2_apr-util-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apr-util-ldap}"
SRC_URI[x86_64_v2_apr-util-ldap.sha256sum] = "b9cbeab6b3e9a620212c758b3437a51868df982d33d0ac7a0848cbb918fa5e1b"

URI_x86_64_v2_apr-util-lmdb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-lmdb-1.6.3-21.el10.x86_64_v2.rpm;name=x86_64_v2_apr-util-lmdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apr-util-lmdb}"
SRC_URI[x86_64_v2_apr-util-lmdb.sha256sum] = "bf7697ebdf278e9ae9b3e925ef0babf2d9f4fb1d26efc705abf934dbc2adde43"

URI_x86_64_v2_apr-util-mysql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-mysql-1.6.3-21.el10.x86_64_v2.rpm;name=x86_64_v2_apr-util-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apr-util-mysql}"
SRC_URI[x86_64_v2_apr-util-mysql.sha256sum] = "aa2a68c1c3d90de901531c7ada717dff952cb9b74cf5bdd9b7aae0750341cdde"

URI_x86_64_v2_apr-util-odbc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-odbc-1.6.3-21.el10.x86_64_v2.rpm;name=x86_64_v2_apr-util-odbc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apr-util-odbc}"
SRC_URI[x86_64_v2_apr-util-odbc.sha256sum] = "e41299c49da1f12f9e5a6081f7223477554322fa0bd707d5e774782dc95c6e05"

URI_x86_64_v2_apr-util-openssl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-openssl-1.6.3-21.el10.x86_64_v2.rpm;name=x86_64_v2_apr-util-openssl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apr-util-openssl}"
SRC_URI[x86_64_v2_apr-util-openssl.sha256sum] = "92e0564ebd71b84a80357656453442fa9b9d12de8a970e8c6ab4128a99ba4027"

URI_x86_64_v2_apr-util-pgsql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-pgsql-1.6.3-21.el10.x86_64_v2.rpm;name=x86_64_v2_apr-util-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apr-util-pgsql}"
SRC_URI[x86_64_v2_apr-util-pgsql.sha256sum] = "6780005e0cd91449891e3594d6c42c43e4c749c942c68460d87a4875881012dd"

URI_x86_64_v2_apr-util-sqlite = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-sqlite-1.6.3-21.el10.x86_64_v2.rpm;name=x86_64_v2_apr-util-sqlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apr-util-sqlite}"
SRC_URI[x86_64_v2_apr-util-sqlite.sha256sum] = "33b1d1367b97fa6e1b03c1fe8bf0ee8d708f58e806b5aa2b14e30383063b1ff3"

URI_aarch64_apr-util = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-1.6.3-21.el10.aarch64.rpm;name=aarch64_apr-util;unpack=0"
SRC_URI:append = " ${URI_aarch64_apr-util}"
SRC_URI[aarch64_apr-util.sha256sum] = "b87fca5fd3cc0b1890aa0230d01d93d042fe463f0d5141f17c81f6c2d6c5ff0d"

URI_aarch64_apr-util-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-devel-1.6.3-21.el10.aarch64.rpm;name=aarch64_apr-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_apr-util-devel}"
SRC_URI[aarch64_apr-util-devel.sha256sum] = "f424c7992284b3a5286a73fbe5c1c058bed732e79593ea1696baa3c01cb234a7"

URI_aarch64_apr-util-ldap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-ldap-1.6.3-21.el10.aarch64.rpm;name=aarch64_apr-util-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_apr-util-ldap}"
SRC_URI[aarch64_apr-util-ldap.sha256sum] = "ee5093e29760d618ae17af9c552e36c1e93ad76a13cc0cccd03fffb95ec39b6b"

URI_aarch64_apr-util-lmdb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-lmdb-1.6.3-21.el10.aarch64.rpm;name=aarch64_apr-util-lmdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_apr-util-lmdb}"
SRC_URI[aarch64_apr-util-lmdb.sha256sum] = "7130757a2b418a0515ed2a83f4042d8b56aee632a40c126476b765723b012460"

URI_aarch64_apr-util-mysql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-mysql-1.6.3-21.el10.aarch64.rpm;name=aarch64_apr-util-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_apr-util-mysql}"
SRC_URI[aarch64_apr-util-mysql.sha256sum] = "9da4f893ec86ac4e71e8f7388dd6bd421d367c119efa00689633669a479c6f83"

URI_aarch64_apr-util-odbc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-odbc-1.6.3-21.el10.aarch64.rpm;name=aarch64_apr-util-odbc;unpack=0"
SRC_URI:append = " ${URI_aarch64_apr-util-odbc}"
SRC_URI[aarch64_apr-util-odbc.sha256sum] = "3eaa60fbe1a9a2803dcc8619584bbbb3340237cd86c30b85e2a9e715f2a8479f"

URI_aarch64_apr-util-openssl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-openssl-1.6.3-21.el10.aarch64.rpm;name=aarch64_apr-util-openssl;unpack=0"
SRC_URI:append = " ${URI_aarch64_apr-util-openssl}"
SRC_URI[aarch64_apr-util-openssl.sha256sum] = "fc5426f5195895546973d9eacc9431ff9f707928e7cfa7e479b9dbf9728d2e7b"

URI_aarch64_apr-util-pgsql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-pgsql-1.6.3-21.el10.aarch64.rpm;name=aarch64_apr-util-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_apr-util-pgsql}"
SRC_URI[aarch64_apr-util-pgsql.sha256sum] = "9805d195433523b561f7f29d7fc176d7361df206c1ef8f4ca727e81823546e70"

URI_aarch64_apr-util-sqlite = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-sqlite-1.6.3-21.el10.aarch64.rpm;name=aarch64_apr-util-sqlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_apr-util-sqlite}"
SRC_URI[aarch64_apr-util-sqlite.sha256sum] = "934d42af08bf39bf7f0a83d984ba0503d89e33ae63aff75f134328a28284c87b"

RDEPENDS:apr-util = " \
 apr \
 expat \
 glibc \
 libuuid \
 libxcrypt \
 "
RDEPENDS:apr-util-devel = " \
 apr-devel \
 apr-util \
 bash \
 expat-devel \
 openldap-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:apr-util-ldap = " \
 apr-util \
 glibc \
 openldap \
 "
RDEPENDS:apr-util-lmdb = " \
 apr-util \
 glibc \
 lmdb-libs \
 "
RDEPENDS:apr-util-mysql = " \
 apr-util \
 glibc \
 mariadb-connector-c \
 "
RDEPENDS:apr-util-odbc = " \
 apr-util \
 glibc \
 unixODBC \
 "
RDEPENDS:apr-util-openssl = " \
 apr-util \
 glibc \
 openssl-libs \
 "
RDEPENDS:apr-util-pgsql = " \
 apr-util \
 glibc \
 libpq \
 "
RDEPENDS:apr-util-sqlite = " \
 apr-util \
 glibc \
 sqlite-libs \
 "
