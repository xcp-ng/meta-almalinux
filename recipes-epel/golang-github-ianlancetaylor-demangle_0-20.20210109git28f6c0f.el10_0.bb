# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-ianlancetaylor-demangle"
PV = "0"
PR = "20.20210109git28f6c0f.el10_0"
PACKAGES = " \
 golang-github-ianlancetaylor-demangle-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-ianlancetaylor-demangle-0-20.20210109git28f6c0f.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d01b49b446046f8ab1830c4c3dce6b448467c2abfe04ddf1662f1737981768d8"

URI_aarch64_golang-github-ianlancetaylor-demangle-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-ianlancetaylor-demangle-devel-0-20.20210109git28f6c0f.el10_0.noarch.rpm;name=aarch64_golang-github-ianlancetaylor-demangle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-ianlancetaylor-demangle-devel}"
SRC_URI[aarch64_golang-github-ianlancetaylor-demangle-devel.sha256sum] = "1a557de70a6cd17b966201518f0b72a26a7c7fe2191d8728d327a37dc47e8d65"

RDEPENDS:golang-github-ianlancetaylor-demangle-devel = " \
 go-filesystem \
 "
