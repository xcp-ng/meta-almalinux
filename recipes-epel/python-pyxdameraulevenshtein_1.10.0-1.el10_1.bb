# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyxdameraulevenshtein"
PV = "1.10.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-pyxdameraulevenshtein \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyxdameraulevenshtein-1.10.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25d6cd7a6820ff1de4099fa725eb3b4b42a237d8a2bb27373f6680f0883b6bc1"

URI_x86_64_v2_python3-pyxdameraulevenshtein = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyxdameraulevenshtein-1.10.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyxdameraulevenshtein;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyxdameraulevenshtein}"
SRC_URI[x86_64_v2_python3-pyxdameraulevenshtein.sha256sum] = "c5c3e2d22e8ea80cb74e9ce466a71affd3e6c5896fa43cca710c0907214227c9"

URI_aarch64_python3-pyxdameraulevenshtein = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyxdameraulevenshtein-1.10.0-1.el10_1.aarch64.rpm;name=aarch64_python3-pyxdameraulevenshtein;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyxdameraulevenshtein}"
SRC_URI[aarch64_python3-pyxdameraulevenshtein.sha256sum] = "7d1a5ebda006072178e55e41caf2ad4ede643316258015114a6fb7e4274951f4"

RDEPENDS:python3-pyxdameraulevenshtein = " \
 glibc \
 python3 \
 "
