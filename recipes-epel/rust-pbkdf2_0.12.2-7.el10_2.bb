# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pbkdf2"
PV = "0.12.2"
PR = "7.el10_2"
PACKAGES = " \
 rust-pbkdf2+default-devel \
 rust-pbkdf2+hmac-devel \
 rust-pbkdf2+parallel-devel \
 rust-pbkdf2+password-hash-devel \
 rust-pbkdf2+rayon-devel \
 rust-pbkdf2+sha1-devel \
 rust-pbkdf2+sha2-devel \
 rust-pbkdf2+simple-devel \
 rust-pbkdf2+std-devel \
 rust-pbkdf2-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-pbkdf2-0.12.2-7.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2c7844a541547872e75c00b9da80a9a62eaf62699e73e8e4bcb6000566f4ddfc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2+default-devel-0.12.2-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pbkdf2+default-devel.sha256sum] = "96064c9465c4ef04c3483728a872ca612937dda10f6f0910a176ec1a11f0f96b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2+hmac-devel-0.12.2-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2+hmac-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pbkdf2+hmac-devel.sha256sum] = "b88295b243e324fc1a47cd8b1e298c4a93728e7155e53791c8c421989a3b2bcc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2+parallel-devel-0.12.2-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2+parallel-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pbkdf2+parallel-devel.sha256sum] = "58fd39c9301aebb39f0d1420328e11cccd71cf152f049084d9edd4a83701cb5c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2+password-hash-devel-0.12.2-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2+password-hash-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pbkdf2+password-hash-devel.sha256sum] = "8b8729cfb6a57df71e354030f5ea269ae781bd1d9912ba93c28dbb5081e64818"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2+rayon-devel-0.12.2-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2+rayon-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pbkdf2+rayon-devel.sha256sum] = "0bf9320b7ee08d18a6e979946fa63b0431d6fa48e19961103af1e35131dfb5bd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2+sha1-devel-0.12.2-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2+sha1-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pbkdf2+sha1-devel.sha256sum] = "ca543ed87410c7d4ecc2070be0d3f51c15e629537a3fa6f95db8b40072af1435"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2+sha2-devel-0.12.2-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2+sha2-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pbkdf2+sha2-devel.sha256sum] = "0fbb61efa1a17513ea894d9c6807c3fce576ec636a0f77f8d7d30aa54308c1dc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2+simple-devel-0.12.2-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2+simple-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pbkdf2+simple-devel.sha256sum] = "89d4b9388467e28ebd9c3753dd3e5697a6f4ac572949100be7b7d364c631428c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2+std-devel-0.12.2-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pbkdf2+std-devel.sha256sum] = "88c2a956ed09ba7623f6d578f0d0395e613dfa91a3ceb2658282fc28def5e958"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2-devel-0.12.2-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pbkdf2-devel.sha256sum] = "24e59d79360ac18b53d1d75734450eae32b026474454ffd23ab38b9528a1863e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2+default-devel-0.12.2-7.el10_2.noarch.rpm;name=aarch64_rust-pbkdf2+default-devel;unpack=0"
SRC_URI[aarch64_rust-pbkdf2+default-devel.sha256sum] = "5252b47245f771263bf0bd9e65eb7cdbbc37b1aa542f5df3bfad980bbb80c00c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2+hmac-devel-0.12.2-7.el10_2.noarch.rpm;name=aarch64_rust-pbkdf2+hmac-devel;unpack=0"
SRC_URI[aarch64_rust-pbkdf2+hmac-devel.sha256sum] = "a988c45a1f0a1af6ee74511f981ba681ec3950ff16fced274dc44071d78bd047"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2+parallel-devel-0.12.2-7.el10_2.noarch.rpm;name=aarch64_rust-pbkdf2+parallel-devel;unpack=0"
SRC_URI[aarch64_rust-pbkdf2+parallel-devel.sha256sum] = "882964b6cf5ad52c7040e7f7233c38528e9d58b2f1139f7a7fd3afbbada21fe9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2+password-hash-devel-0.12.2-7.el10_2.noarch.rpm;name=aarch64_rust-pbkdf2+password-hash-devel;unpack=0"
SRC_URI[aarch64_rust-pbkdf2+password-hash-devel.sha256sum] = "2ff089a3f0cf93dffde804b1f522e382caceeec8f7efea6d23dc824db74b9316"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2+rayon-devel-0.12.2-7.el10_2.noarch.rpm;name=aarch64_rust-pbkdf2+rayon-devel;unpack=0"
SRC_URI[aarch64_rust-pbkdf2+rayon-devel.sha256sum] = "58596da497c3d84958efd8330c88d39dc682bd3023b1fdb3560ef59440142712"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2+sha1-devel-0.12.2-7.el10_2.noarch.rpm;name=aarch64_rust-pbkdf2+sha1-devel;unpack=0"
SRC_URI[aarch64_rust-pbkdf2+sha1-devel.sha256sum] = "d5a665c4eddd3ba0da29404e6a7541f4f9e0a5c5c5ee97061275aadc250c159b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2+sha2-devel-0.12.2-7.el10_2.noarch.rpm;name=aarch64_rust-pbkdf2+sha2-devel;unpack=0"
SRC_URI[aarch64_rust-pbkdf2+sha2-devel.sha256sum] = "75f0fa7c3429d2602b2651e83005743f8ba104c6bf7b62ac32d0bc24f316928d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2+simple-devel-0.12.2-7.el10_2.noarch.rpm;name=aarch64_rust-pbkdf2+simple-devel;unpack=0"
SRC_URI[aarch64_rust-pbkdf2+simple-devel.sha256sum] = "d29ebeefd56a9c2ce07a64bc4e505bdd710ea12c37d0bcbba70a508a5d6ea69f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2+std-devel-0.12.2-7.el10_2.noarch.rpm;name=aarch64_rust-pbkdf2+std-devel;unpack=0"
SRC_URI[aarch64_rust-pbkdf2+std-devel.sha256sum] = "9f545f5fcc4a82e9ce2b388965c6ac5ee6e8bda389d86b3e9da7280aa605646a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2-devel-0.12.2-7.el10_2.noarch.rpm;name=aarch64_rust-pbkdf2-devel;unpack=0"
SRC_URI[aarch64_rust-pbkdf2-devel.sha256sum] = "2c683abec78f930a195b8cd17b1c2f29e28376fc5f8a1b26c18ffa26f8a33ab3"

RDEPENDS:rust-pbkdf2+default-devel = " \
 cargo \
 rust-pbkdf2+hmac-devel \
 rust-pbkdf2-devel \
 "
RDEPENDS:rust-pbkdf2+hmac-devel = " \
 cargo \
 rust-hmac-devel \
 rust-pbkdf2-devel \
 "
RDEPENDS:rust-pbkdf2+parallel-devel = " \
 cargo \
 rust-pbkdf2+rayon-devel \
 rust-pbkdf2+std-devel \
 rust-pbkdf2-devel \
 "
RDEPENDS:rust-pbkdf2+password-hash-devel = " \
 cargo \
 rust-password-hash+rand_core-devel \
 rust-password-hash-devel \
 rust-pbkdf2-devel \
 "
RDEPENDS:rust-pbkdf2+rayon-devel = " \
 cargo \
 rust-pbkdf2-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-pbkdf2+sha1-devel = " \
 cargo \
 rust-pbkdf2-devel \
 rust-sha1-devel \
 "
RDEPENDS:rust-pbkdf2+sha2-devel = " \
 cargo \
 rust-pbkdf2-devel \
 rust-sha2-devel \
 "
RDEPENDS:rust-pbkdf2+simple-devel = " \
 cargo \
 rust-pbkdf2+hmac-devel \
 rust-pbkdf2+password-hash-devel \
 rust-pbkdf2+sha2-devel \
 rust-pbkdf2-devel \
 "
RDEPENDS:rust-pbkdf2+std-devel = " \
 cargo \
 rust-password-hash+rand_core-devel \
 rust-password-hash+std-devel \
 rust-password-hash-devel \
 rust-pbkdf2-devel \
 "
RDEPENDS:rust-pbkdf2-devel = " \
 cargo \
 rust \
 rust-digest+default-devel \
 rust-digest+mac-devel \
 "
