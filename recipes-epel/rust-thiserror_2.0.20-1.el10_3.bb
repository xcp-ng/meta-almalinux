# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-thiserror"
PV = "2.0.20"
PR = "1.el10_3"
PACKAGES = " \
 rust-thiserror+default-devel \
 rust-thiserror+std-devel \
 rust-thiserror-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-thiserror-2.0.20-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9829712a16ce9f245274630b22ce805d248176d029eab05b7051a45a6ce5470b"

URI_x86_64_v2_rust-thiserror+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thiserror+default-devel-2.0.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thiserror+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thiserror+default-devel}"
SRC_URI[x86_64_v2_rust-thiserror+default-devel.sha256sum] = "2726fedb377d2c09e118e74f3224c005eb4fd6e1992a237f951f55d7f04dc52a"
RPROVIDES:rust-thiserror+default-devel:x86_64_v2 = "virtual/crate_thiserror/default__ge_1.0.0_with_crate_thiserror/default__lt_3.0.0~"

URI_x86_64_v2_rust-thiserror+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thiserror+std-devel-2.0.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thiserror+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thiserror+std-devel}"
SRC_URI[x86_64_v2_rust-thiserror+std-devel.sha256sum] = "6c7661c59ef754f3cb51b801d3f91c13dc9298f412f91259057534d89d0d2966"

URI_x86_64_v2_rust-thiserror-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thiserror-devel-2.0.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thiserror-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thiserror-devel}"
SRC_URI[x86_64_v2_rust-thiserror-devel.sha256sum] = "75216ebed2c0a68f68f2411a3a3f6fb8192449b26242a4812c58f701d331ec31"
RPROVIDES:rust-thiserror-devel:x86_64_v2 = "virtual/crate_thiserror__ge_1.0.0_with_crate_thiserror__lt_3.0.0~"

URI_aarch64_rust-thiserror+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thiserror+default-devel-2.0.20-1.el10_3.noarch.rpm;name=aarch64_rust-thiserror+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thiserror+default-devel}"
SRC_URI[aarch64_rust-thiserror+default-devel.sha256sum] = "51a3bf25db307093ea52505adf05f20106d80c767fe4cb1052e5b707d7c907bf"
RPROVIDES:rust-thiserror+default-devel:aarch64 = "virtual/crate_thiserror/default__ge_1.0.0_with_crate_thiserror/default__lt_3.0.0~"

URI_aarch64_rust-thiserror+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thiserror+std-devel-2.0.20-1.el10_3.noarch.rpm;name=aarch64_rust-thiserror+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thiserror+std-devel}"
SRC_URI[aarch64_rust-thiserror+std-devel.sha256sum] = "5ca886343ae26762c980aa4f0ffa87e238213871308dc6fbb362af09b22c224e"

URI_aarch64_rust-thiserror-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thiserror-devel-2.0.20-1.el10_3.noarch.rpm;name=aarch64_rust-thiserror-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thiserror-devel}"
SRC_URI[aarch64_rust-thiserror-devel.sha256sum] = "30c5dfa139c76eca03843afc6bc872d9d3c15d417e1469d3c33785d790e8d982"
RPROVIDES:rust-thiserror-devel:aarch64 = "virtual/crate_thiserror__ge_1.0.0_with_crate_thiserror__lt_3.0.0~"

RDEPENDS:rust-thiserror+default-devel = " \
 cargo \
 rust-thiserror+std-devel \
 rust-thiserror-devel \
 "
RDEPENDS:rust-thiserror+std-devel = " \
 cargo \
 rust-thiserror-devel \
 "
RDEPENDS:rust-thiserror-devel = " \
 cargo \
 rust \
 rust-thiserror-impl+default-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_thiserror/default__ge_1.0.0_with_crate_thiserror/default__lt_3.0.0~ rpm/virtual/crate_thiserror__ge_1.0.0_with_crate_thiserror__lt_3.0.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_thiserror/default__ge_1.0.0_with_crate_thiserror/default__lt_3.0.0~ rpm/virtual/crate_thiserror__ge_1.0.0_with_crate_thiserror__lt_3.0.0~"
