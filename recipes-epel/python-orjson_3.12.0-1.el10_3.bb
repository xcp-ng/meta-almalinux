# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-orjson"
PV = "3.12.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-orjson \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-orjson-3.12.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e98f538c96c3a1166e22af62c7f072480bf2586daf151f200ebe13c027396f2f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-orjson-3.12.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-orjson;unpack=0"
SRC_URI[x86_64_v2_python3-orjson.sha256sum] = "3d454a69abe4b72f6d899c0798605473404f356d368333dd27798d3017983b85"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-orjson-3.12.0-1.el10_3.aarch64.rpm;name=aarch64_python3-orjson;unpack=0"
SRC_URI[aarch64_python3-orjson.sha256sum] = "e21d0b914f4c03a5db8285c7f62aae394b9e04cf78155f0123d12bc01d7aa776"

RDEPENDS:python3-orjson = " \
 glibc \
 libgcc \
 python3 \
 "
