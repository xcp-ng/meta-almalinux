# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-insta"
PV = "1.43.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-insta+_cargo_insta_internal-devel \
 rust-insta+clap-devel \
 rust-insta+colors-devel \
 rust-insta+console-devel \
 rust-insta+csv-devel \
 rust-insta+default-devel \
 rust-insta+filters-devel \
 rust-insta+glob-devel \
 rust-insta+globset-devel \
 rust-insta+json-devel \
 rust-insta+pest-devel \
 rust-insta+pest_derive-devel \
 rust-insta+redactions-devel \
 rust-insta+regex-devel \
 rust-insta+ron-devel \
 rust-insta+serde-devel \
 rust-insta+toml-devel \
 rust-insta+walkdir-devel \
 rust-insta+yaml-devel \
 rust-insta-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-insta-1.43.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "33c6830f99e32a6f349cd143f9ae23c22840a2f5d0bbda72a6dc48ac5300f512"

URI_x86_64_v2_rust-insta+_cargo_insta_internal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+_cargo_insta_internal-devel-1.43.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+_cargo_insta_internal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+_cargo_insta_internal-devel}"
SRC_URI[x86_64_v2_rust-insta+_cargo_insta_internal-devel.sha256sum] = "b7ffac12911324a0df438620f1224749e3427e383264f20e8a5972770b7d2822"

URI_x86_64_v2_rust-insta+clap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+clap-devel-1.43.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+clap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+clap-devel}"
SRC_URI[x86_64_v2_rust-insta+clap-devel.sha256sum] = "8361d8c549095bde9cf78d270f549ecd5176dddcad0405f0c2a22a619d6f586b"

URI_x86_64_v2_rust-insta+colors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+colors-devel-1.43.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+colors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+colors-devel}"
SRC_URI[x86_64_v2_rust-insta+colors-devel.sha256sum] = "55927a2e2708973ca02404f33969ed786895887b6376e6700a205d565e13be30"

URI_x86_64_v2_rust-insta+console-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+console-devel-1.43.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+console-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+console-devel}"
SRC_URI[x86_64_v2_rust-insta+console-devel.sha256sum] = "687d6baa354e1058883bff1e6f2183e679379225e6ea7be4fecc1aa59b601467"

URI_x86_64_v2_rust-insta+csv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+csv-devel-1.43.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+csv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+csv-devel}"
SRC_URI[x86_64_v2_rust-insta+csv-devel.sha256sum] = "8166164c5c367ffbaa9a98a29af29313f116d6198bf1a295cc86a41a8f9cb650"

URI_x86_64_v2_rust-insta+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+default-devel-1.43.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+default-devel}"
SRC_URI[x86_64_v2_rust-insta+default-devel.sha256sum] = "9e1cb7c9b31b9b4e6c917c0a86ba3dc12d0d7ab26e66eb89e6f7abac7fc6a5e9"

URI_x86_64_v2_rust-insta+filters-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+filters-devel-1.43.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+filters-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+filters-devel}"
SRC_URI[x86_64_v2_rust-insta+filters-devel.sha256sum] = "337d2e19f62b960eaea302047e13d5524491db01a3ddd5517cc851d39767d1f8"

URI_x86_64_v2_rust-insta+glob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+glob-devel-1.43.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+glob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+glob-devel}"
SRC_URI[x86_64_v2_rust-insta+glob-devel.sha256sum] = "bafeb98e386f58f6789e28393d671cc414d2100633f36dc1f42f2b215d2cf1d5"

URI_x86_64_v2_rust-insta+globset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+globset-devel-1.43.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+globset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+globset-devel}"
SRC_URI[x86_64_v2_rust-insta+globset-devel.sha256sum] = "2b3a284258ed60ea2d15b0ecb68b71aecfa720d1b2ca9168e9da0fecefa50916"

URI_x86_64_v2_rust-insta+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+json-devel-1.43.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+json-devel}"
SRC_URI[x86_64_v2_rust-insta+json-devel.sha256sum] = "336adac22357da74a59adc0f9200f7765c0bb3c1291c0e05ca568dca10d2cdee"

URI_x86_64_v2_rust-insta+pest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+pest-devel-1.43.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+pest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+pest-devel}"
SRC_URI[x86_64_v2_rust-insta+pest-devel.sha256sum] = "cc5a982f9023a911d824f293c1b0bdf9db3c38f0df1880da7d820554b6618323"

URI_x86_64_v2_rust-insta+pest_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+pest_derive-devel-1.43.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+pest_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+pest_derive-devel}"
SRC_URI[x86_64_v2_rust-insta+pest_derive-devel.sha256sum] = "2f8d7dd06e2554ad2171df417f54a4feba388bafa3a007e2c9e89a5fc22ef6f8"

URI_x86_64_v2_rust-insta+redactions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+redactions-devel-1.43.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+redactions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+redactions-devel}"
SRC_URI[x86_64_v2_rust-insta+redactions-devel.sha256sum] = "0df3c21cc2b6ed9aefd04b619e238003c8ce66d2483b11397c9f32607c64382b"

URI_x86_64_v2_rust-insta+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+regex-devel-1.43.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+regex-devel}"
SRC_URI[x86_64_v2_rust-insta+regex-devel.sha256sum] = "80795a09211d48e110dcbe08f776d6466e3ca0738b848a93809dee08f50fad3b"

URI_x86_64_v2_rust-insta+ron-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+ron-devel-1.43.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+ron-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+ron-devel}"
SRC_URI[x86_64_v2_rust-insta+ron-devel.sha256sum] = "b60277b60b25dfb1a556fefad52887295fe1b4dc1b1198cfc0b357ef6cdbc26c"

URI_x86_64_v2_rust-insta+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+serde-devel-1.43.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+serde-devel}"
SRC_URI[x86_64_v2_rust-insta+serde-devel.sha256sum] = "20e0457d1078f492be0407beeb78cbfbc0d4f867e22043b13de11766a5758931"

URI_x86_64_v2_rust-insta+toml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+toml-devel-1.43.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+toml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+toml-devel}"
SRC_URI[x86_64_v2_rust-insta+toml-devel.sha256sum] = "13f5b751a62edbc9641cff5da04dba884b90eb35f37ce0c22e1b993c06e35e76"

URI_x86_64_v2_rust-insta+walkdir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+walkdir-devel-1.43.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+walkdir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+walkdir-devel}"
SRC_URI[x86_64_v2_rust-insta+walkdir-devel.sha256sum] = "0bcfcc3ef6815d9739d29608ec4df5c95b7e0c27c1e02d5ab359ec2867012082"

URI_x86_64_v2_rust-insta+yaml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+yaml-devel-1.43.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+yaml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+yaml-devel}"
SRC_URI[x86_64_v2_rust-insta+yaml-devel.sha256sum] = "8e20a541185c80470c7c9d4810b50ae09c71aacf91b428221dbe85d163e0382a"

URI_x86_64_v2_rust-insta-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta-devel-1.43.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta-devel}"
SRC_URI[x86_64_v2_rust-insta-devel.sha256sum] = "76a751ad41e840126fbc611d4df2bbd32313ab5a97887312eb997ace00934dfb"

URI_aarch64_rust-insta+_cargo_insta_internal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+_cargo_insta_internal-devel-1.43.1-1.el10_0.noarch.rpm;name=aarch64_rust-insta+_cargo_insta_internal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+_cargo_insta_internal-devel}"
SRC_URI[aarch64_rust-insta+_cargo_insta_internal-devel.sha256sum] = "9b825afeab64bb0a433256595811db2b63e95ad86e717117bb3e6273276ba55a"

URI_aarch64_rust-insta+clap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+clap-devel-1.43.1-1.el10_0.noarch.rpm;name=aarch64_rust-insta+clap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+clap-devel}"
SRC_URI[aarch64_rust-insta+clap-devel.sha256sum] = "618910fdd78f4d0f36ef9e21624e56db8d67cc80c3008765c48d6832815fc68b"

URI_aarch64_rust-insta+colors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+colors-devel-1.43.1-1.el10_0.noarch.rpm;name=aarch64_rust-insta+colors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+colors-devel}"
SRC_URI[aarch64_rust-insta+colors-devel.sha256sum] = "25d5732da92e8a20276a0346b2c3c26eea7813c81973295dcf44d6bc89f791d0"

URI_aarch64_rust-insta+console-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+console-devel-1.43.1-1.el10_0.noarch.rpm;name=aarch64_rust-insta+console-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+console-devel}"
SRC_URI[aarch64_rust-insta+console-devel.sha256sum] = "50af6ba8d17a675bc6423f4d160b70aea2482ae5d5b50701e2e5862b58488015"

URI_aarch64_rust-insta+csv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+csv-devel-1.43.1-1.el10_0.noarch.rpm;name=aarch64_rust-insta+csv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+csv-devel}"
SRC_URI[aarch64_rust-insta+csv-devel.sha256sum] = "efd4cab71d5f902996ee678db4f9466e1e1bd0fe43a7b3ca5a7bec0cdc52d511"

URI_aarch64_rust-insta+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+default-devel-1.43.1-1.el10_0.noarch.rpm;name=aarch64_rust-insta+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+default-devel}"
SRC_URI[aarch64_rust-insta+default-devel.sha256sum] = "7d89f7b5b5c9860edaac2c76999378b1a2643e728ca38a1566fa289498793d8a"

URI_aarch64_rust-insta+filters-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+filters-devel-1.43.1-1.el10_0.noarch.rpm;name=aarch64_rust-insta+filters-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+filters-devel}"
SRC_URI[aarch64_rust-insta+filters-devel.sha256sum] = "c65f6cbce688a2c7338d96ca5b00090a06557297755d3f424c62c92e923f102a"

URI_aarch64_rust-insta+glob-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+glob-devel-1.43.1-1.el10_0.noarch.rpm;name=aarch64_rust-insta+glob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+glob-devel}"
SRC_URI[aarch64_rust-insta+glob-devel.sha256sum] = "68610730fe6ee8bb788e3b000c16fbe5b3d086801d915b3e70cff59cafc909d3"

URI_aarch64_rust-insta+globset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+globset-devel-1.43.1-1.el10_0.noarch.rpm;name=aarch64_rust-insta+globset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+globset-devel}"
SRC_URI[aarch64_rust-insta+globset-devel.sha256sum] = "512ff559f5fbf3d149549182c215d7ada3e2251233ca9935d438cced21d9ebf1"

URI_aarch64_rust-insta+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+json-devel-1.43.1-1.el10_0.noarch.rpm;name=aarch64_rust-insta+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+json-devel}"
SRC_URI[aarch64_rust-insta+json-devel.sha256sum] = "de238f030aa8b2c83d42ac6ee2c0cd8aa93c6a163ab353bc0d3243ad24a1c48a"

URI_aarch64_rust-insta+pest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+pest-devel-1.43.1-1.el10_0.noarch.rpm;name=aarch64_rust-insta+pest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+pest-devel}"
SRC_URI[aarch64_rust-insta+pest-devel.sha256sum] = "2e4bd8b45d395651ef775420aa784070e5ca8e48d7d4c5f18a12ad72ac7f150d"

URI_aarch64_rust-insta+pest_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+pest_derive-devel-1.43.1-1.el10_0.noarch.rpm;name=aarch64_rust-insta+pest_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+pest_derive-devel}"
SRC_URI[aarch64_rust-insta+pest_derive-devel.sha256sum] = "75c4521fe7738739024261eff510c08dd1a5ec86885f8e9e63ce845c92310b61"

URI_aarch64_rust-insta+redactions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+redactions-devel-1.43.1-1.el10_0.noarch.rpm;name=aarch64_rust-insta+redactions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+redactions-devel}"
SRC_URI[aarch64_rust-insta+redactions-devel.sha256sum] = "09459e7e9b6a87af4f581fc559054b2385b367259b3c8a8c548433a96e3d86f9"

URI_aarch64_rust-insta+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+regex-devel-1.43.1-1.el10_0.noarch.rpm;name=aarch64_rust-insta+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+regex-devel}"
SRC_URI[aarch64_rust-insta+regex-devel.sha256sum] = "11f87de412a9793ee0cfaff7dfd2e73869a1fd0030d39eff7349f8902c7002ba"

URI_aarch64_rust-insta+ron-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+ron-devel-1.43.1-1.el10_0.noarch.rpm;name=aarch64_rust-insta+ron-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+ron-devel}"
SRC_URI[aarch64_rust-insta+ron-devel.sha256sum] = "ae7aa5ef91607d96723c40300bc675fa47f5398a554d0055680fdde59bc1149a"

URI_aarch64_rust-insta+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+serde-devel-1.43.1-1.el10_0.noarch.rpm;name=aarch64_rust-insta+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+serde-devel}"
SRC_URI[aarch64_rust-insta+serde-devel.sha256sum] = "7c007d8b4080c9d9eedfdcf4b40846b544532b29ceaf7f19dd60305dd1e4bc14"

URI_aarch64_rust-insta+toml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+toml-devel-1.43.1-1.el10_0.noarch.rpm;name=aarch64_rust-insta+toml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+toml-devel}"
SRC_URI[aarch64_rust-insta+toml-devel.sha256sum] = "00b4eb59794312eb54051acf7909914582592788bcd47008effe0f03b6b21334"

URI_aarch64_rust-insta+walkdir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+walkdir-devel-1.43.1-1.el10_0.noarch.rpm;name=aarch64_rust-insta+walkdir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+walkdir-devel}"
SRC_URI[aarch64_rust-insta+walkdir-devel.sha256sum] = "5ec53e04116c2a7974462b76df1a79ef8d7b656974247981c0de95ea78ef9ca5"

URI_aarch64_rust-insta+yaml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+yaml-devel-1.43.1-1.el10_0.noarch.rpm;name=aarch64_rust-insta+yaml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+yaml-devel}"
SRC_URI[aarch64_rust-insta+yaml-devel.sha256sum] = "430432b6c4f82f16f68fbd9da841438a549930fca5e314de662116c3dee075f0"

URI_aarch64_rust-insta-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta-devel-1.43.1-1.el10_0.noarch.rpm;name=aarch64_rust-insta-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta-devel}"
SRC_URI[aarch64_rust-insta-devel.sha256sum] = "dba98865daaa50afd9bf0da770e5d196ad4d4d0d929f621de0b8f132bd31983c"

RDEPENDS:rust-insta+_cargo_insta_internal-devel = " \
 cargo \
 rust-insta+clap-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+clap-devel = " \
 cargo \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-clap+env-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+colors-devel = " \
 cargo \
 rust-insta+console-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+console-devel = " \
 cargo \
 rust-console-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+csv-devel = " \
 cargo \
 rust-csv+default-devel \
 rust-insta+serde-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+default-devel = " \
 cargo \
 rust-insta+colors-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+filters-devel = " \
 cargo \
 rust-insta+regex-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+glob-devel = " \
 cargo \
 rust-insta+globset-devel \
 rust-insta+walkdir-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+globset-devel = " \
 cargo \
 rust-globset+default-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+json-devel = " \
 cargo \
 rust-insta+serde-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+pest-devel = " \
 cargo \
 rust-insta-devel \
 rust-pest+default-devel \
 "
RDEPENDS:rust-insta+pest_derive-devel = " \
 cargo \
 rust-insta-devel \
 rust-pest_derive+default-devel \
 "
RDEPENDS:rust-insta+redactions-devel = " \
 cargo \
 rust-insta+pest-devel \
 rust-insta+pest_derive-devel \
 rust-insta+serde-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+regex-devel = " \
 cargo \
 rust-insta-devel \
 rust-regex+std-devel \
 rust-regex+unicode-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-insta+ron-devel = " \
 cargo \
 rust-insta+serde-devel \
 rust-insta-devel \
 rust-ron0.7+default-devel \
 "
RDEPENDS:rust-insta+serde-devel = " \
 cargo \
 rust-insta-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-insta+toml-devel = " \
 cargo \
 rust-insta+serde-devel \
 rust-insta-devel \
 rust-toml0.5+default-devel \
 "
RDEPENDS:rust-insta+walkdir-devel = " \
 cargo \
 rust-insta-devel \
 rust-walkdir+default-devel \
 "
RDEPENDS:rust-insta+yaml-devel = " \
 cargo \
 rust-insta+serde-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta-devel = " \
 cargo \
 rust \
 rust-once_cell+default-devel \
 rust-similar+default-devel \
 rust-similar+inline-devel \
 "
