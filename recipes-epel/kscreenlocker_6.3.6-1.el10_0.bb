# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kscreenlocker"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 kscreenlocker \
 kscreenlocker-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kscreenlocker-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b368292f96fc8260fe7fd640bc4be48e5459b827274125705b9dce69f6396e42"

URI_x86_64_v2_kscreenlocker = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kscreenlocker-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kscreenlocker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kscreenlocker}"
SRC_URI[x86_64_v2_kscreenlocker.sha256sum] = "a2a1d035e8bf24528492c10d32ebf85e14bc1edc0936c573fcd4324c8c4fad7f"

URI_x86_64_v2_kscreenlocker-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kscreenlocker-devel-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kscreenlocker-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kscreenlocker-devel}"
SRC_URI[x86_64_v2_kscreenlocker-devel.sha256sum] = "d19c1984386a85a50acf717270f58ee8e89bf4336b628c0ef1593a651ee29e17"

URI_aarch64_kscreenlocker = "${EPEL_MIRROR}/aarch64/Packages/k/kscreenlocker-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_kscreenlocker;unpack=0"
SRC_URI:append = " ${URI_aarch64_kscreenlocker}"
SRC_URI[aarch64_kscreenlocker.sha256sum] = "57ef19b349c618d6e99fbe2145808a35f9b3486a167685d1e05ed32afd30a4d8"

URI_aarch64_kscreenlocker-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kscreenlocker-devel-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_kscreenlocker-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kscreenlocker-devel}"
SRC_URI[aarch64_kscreenlocker-devel.sha256sum] = "432d59032b96c3bee15941ce0521428ba6fce8135404446bdcb2c6b210aa8909"

RDEPENDS:kscreenlocker = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kidletime \
 kf6-kio-core-libs \
 kf6-knotifications \
 kf6-kpackage \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 layer-shell-qt \
 libX11 \
 libXi \
 libkscreen \
 libplasma \
 libstdc++ \
 libwayland-client \
 libwayland-server \
 libxcb \
 pam-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 xcb-util-keysyms \
 "
RDEPENDS:kscreenlocker-devel = " \
 cmake-filesystem \
 kscreenlocker \
 "
