# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wavbreaker"
PV = "0.16"
PR = "5.el10_0"
PACKAGES = " \
 wavbreaker \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/wavbreaker-0.16-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2cf33abdb39088b11cac9aee6e0eac04afc97501dc3ccde00d8272f4be5e2794"

URI_x86_64_v2_wavbreaker = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wavbreaker-0.16-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wavbreaker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wavbreaker}"
SRC_URI[x86_64_v2_wavbreaker.sha256sum] = "d9d4a28c278c628d0d0cf97126749b0c977fd30d312bc5797a8b7268d79f30bf"

URI_aarch64_wavbreaker = "${EPEL_MIRROR}/aarch64/Packages/w/wavbreaker-0.16-5.el10_0.aarch64.rpm;name=aarch64_wavbreaker;unpack=0"
SRC_URI:append = " ${URI_aarch64_wavbreaker}"
SRC_URI[aarch64_wavbreaker.sha256sum] = "6e691ad4ca712cea2a06493effcc7af4e1b7cd03dee6d332aac5dab9c3c767f0"

RDEPENDS:wavbreaker = " \
 cairo \
 glib2 \
 glibc \
 gtk3 \
 libao \
 libvorbis \
 mpg123-libs \
 "
