# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fluent-langneg"
PV = "0.13.0"
PR = "12.el10_2"
PACKAGES = " \
 rust-fluent-langneg+cldr-devel \
 rust-fluent-langneg+default-devel \
 rust-fluent-langneg-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fluent-langneg-0.13.0-12.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fbc006b30afb1ae7cf6962f366ded7f16ac6039459bb240dd0d0c82c3e20de71"

URI_x86_64_v2_rust-fluent-langneg+cldr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fluent-langneg+cldr-devel-0.13.0-12.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fluent-langneg+cldr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fluent-langneg+cldr-devel}"
SRC_URI[x86_64_v2_rust-fluent-langneg+cldr-devel.sha256sum] = "fd44bd7f56b15abd937ced53c7ca09d6d2a9f0593de00d63343b5db5085a75f3"

URI_x86_64_v2_rust-fluent-langneg+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fluent-langneg+default-devel-0.13.0-12.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fluent-langneg+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fluent-langneg+default-devel}"
SRC_URI[x86_64_v2_rust-fluent-langneg+default-devel.sha256sum] = "4d3fab12299bdf899d9c3988ff6395702d5519f60ff2c53a4fe333069c9e6d81"

URI_x86_64_v2_rust-fluent-langneg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fluent-langneg-devel-0.13.0-12.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fluent-langneg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fluent-langneg-devel}"
SRC_URI[x86_64_v2_rust-fluent-langneg-devel.sha256sum] = "abec4d0137190537f7365518c6010d64b0407771c72adbe0b0e6860f667a2a31"

URI_aarch64_rust-fluent-langneg+cldr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fluent-langneg+cldr-devel-0.13.0-12.el10_2.noarch.rpm;name=aarch64_rust-fluent-langneg+cldr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fluent-langneg+cldr-devel}"
SRC_URI[aarch64_rust-fluent-langneg+cldr-devel.sha256sum] = "96dfa178e88b173680fecb6fc5bb96b44b1ad40a27d38e1315877709de8eea02"

URI_aarch64_rust-fluent-langneg+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fluent-langneg+default-devel-0.13.0-12.el10_2.noarch.rpm;name=aarch64_rust-fluent-langneg+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fluent-langneg+default-devel}"
SRC_URI[aarch64_rust-fluent-langneg+default-devel.sha256sum] = "4bfdc14b91663f827c4855716a1a982d5effe94dbe303f1496fdb8bbc384df45"

URI_aarch64_rust-fluent-langneg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fluent-langneg-devel-0.13.0-12.el10_2.noarch.rpm;name=aarch64_rust-fluent-langneg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fluent-langneg-devel}"
SRC_URI[aarch64_rust-fluent-langneg-devel.sha256sum] = "3657205e1abe38f29eadd734ad2da320fedbc240787d25bf0b2742b31e3485bc"

RDEPENDS:rust-fluent-langneg+cldr-devel = " \
 cargo \
 rust-fluent-langneg-devel \
 rust-unic-langid+likelysubtags-devel \
 "
RDEPENDS:rust-fluent-langneg+default-devel = " \
 cargo \
 rust-fluent-langneg-devel \
 "
RDEPENDS:rust-fluent-langneg-devel = " \
 cargo \
 rust-unic-langid+default-devel \
 "
