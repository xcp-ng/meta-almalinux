# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "git-review"
PV = "2.3.1"
PR = "9.el10_0"
PACKAGES = " \
 git-review \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/git-review-2.3.1-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c89eddc3967a16db1999284d4e33c9ba873d2f1c429330aa30db856c9641db7"

URI_x86_64_v2_git-review = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/git-review-2.3.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_git-review;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-review}"
SRC_URI[x86_64_v2_git-review.sha256sum] = "d050f5764bc397ecf9e8f7aa05354391370a1804000a8102693f746467a5fbb1"

URI_aarch64_git-review = "${EPEL_MIRROR}/aarch64/Packages/g/git-review-2.3.1-9.el10_0.noarch.rpm;name=aarch64_git-review;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-review}"
SRC_URI[aarch64_git-review.sha256sum] = "c58bf210e768fd3ecd1c90243fc9d13a9bdc608e240b73fa6b2f0404324865fb"

RDEPENDS:git-review = " \
 git-core \
 python3 \
 python3-requests \
 python3-setuptools \
 "
