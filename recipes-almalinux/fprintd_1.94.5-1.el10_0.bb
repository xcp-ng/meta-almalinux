# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fprintd"
PV = "1.94.5"
PR = "1.el10_0"
PACKAGES:x86_64_v2 = " \
 fprintd \
 fprintd-pam \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/fprintd-1.94.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "128c159d5693d9a1b0e79fe7bd7960f694a6733a6dfc6ee48c912963882d8832"

URI_x86_64_v2_fprintd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fprintd-1.94.5-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_fprintd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fprintd}"
SRC_URI[x86_64_v2_fprintd.sha256sum] = "8f3ea4e323c965f90ea50a9130e3baa2ec9224cc2928f7e96c7741fc897b1afc"

URI_x86_64_v2_fprintd-pam = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fprintd-pam-1.94.5-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_fprintd-pam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fprintd-pam}"
SRC_URI[x86_64_v2_fprintd-pam.sha256sum] = "926d815747e29feaa854ff821d2868359b84f4de8a3bcb5b773982dfea2a396a"

RDEPENDS:fprintd = " \
 glib2 \
 glibc \
 libfprint \
 libgcc \
 polkit-libs \
 "
RDEPENDS:fprintd-pam = " \
 authselect \
 bash \
 fprintd \
 glibc \
 libgcc \
 pam-libs \
 systemd-libs \
 "
