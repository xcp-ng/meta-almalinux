# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua-binaryheap"
PV = "0.4"
PR = "14.el10_1"
PACKAGES = " \
 lua-binaryheap \
 lua5.1-binaryheap \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lua-binaryheap-0.4-14.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ccc1161ad15a77b6438cf87410fb02bedc9ce12dad2ccbdd4f287d48eae14d2d"

URI_x86_64_v2_lua-binaryheap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua-binaryheap-0.4-14.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lua-binaryheap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-binaryheap}"
SRC_URI[x86_64_v2_lua-binaryheap.sha256sum] = "3673592c3bd3ba2d8bed21d36f38a9f262fbffe12f653926af18b3064b8e1b6e"

URI_x86_64_v2_lua5.1-binaryheap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua5.1-binaryheap-0.4-14.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lua5.1-binaryheap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua5.1-binaryheap}"
SRC_URI[x86_64_v2_lua5.1-binaryheap.sha256sum] = "bf2b7d087ab2c1552385d6d9aa3eadcf6524396d5437f08ca0bbdcd15d657792"

URI_aarch64_lua-binaryheap = "${EPEL_MIRROR}/aarch64/Packages/l/lua-binaryheap-0.4-14.el10_1.noarch.rpm;name=aarch64_lua-binaryheap;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-binaryheap}"
SRC_URI[aarch64_lua-binaryheap.sha256sum] = "34e5bd69fd38b25e5f9e60bfd36323c9f967a4cde5edb32bc4aaa9c4dd5e03e6"

URI_aarch64_lua5.1-binaryheap = "${EPEL_MIRROR}/aarch64/Packages/l/lua5.1-binaryheap-0.4-14.el10_1.noarch.rpm;name=aarch64_lua5.1-binaryheap;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua5.1-binaryheap}"
SRC_URI[aarch64_lua5.1-binaryheap.sha256sum] = "6be37a00a01fcfd73ca9b5af6e1d9f1a7b9c30a090d1fac81a38c979de73d31b"

RDEPENDS:lua-binaryheap = " \
 "
RDEPENDS:lua5.1-binaryheap = " \
 "
