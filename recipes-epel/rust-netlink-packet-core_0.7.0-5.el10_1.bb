# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-netlink-packet-core"
PV = "0.7.0"
PR = "5.el10_1"
PACKAGES = " \
 rust-netlink-packet-core+default-devel \
 rust-netlink-packet-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-netlink-packet-core-0.7.0-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0db19fd9020c3decb16cd5edf194a1f895b7c8e6e99e26ff647162a387b672e7"

URI_x86_64_v2_rust-netlink-packet-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netlink-packet-core+default-devel-0.7.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netlink-packet-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netlink-packet-core+default-devel}"
SRC_URI[x86_64_v2_rust-netlink-packet-core+default-devel.sha256sum] = "1e89c8b20837eb5858eea10ae73ce6977df4186be0804232171474a415c159fa"

URI_x86_64_v2_rust-netlink-packet-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netlink-packet-core-devel-0.7.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netlink-packet-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netlink-packet-core-devel}"
SRC_URI[x86_64_v2_rust-netlink-packet-core-devel.sha256sum] = "bf0d80cc8b44d71901e759ccb56dda1ea52bc704e2e5572c7fe25e6b1a7d146b"

URI_aarch64_rust-netlink-packet-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netlink-packet-core+default-devel-0.7.0-5.el10_1.noarch.rpm;name=aarch64_rust-netlink-packet-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netlink-packet-core+default-devel}"
SRC_URI[aarch64_rust-netlink-packet-core+default-devel.sha256sum] = "a48408b9b7bcfc583fbfd7d2d14fc14afbc8949599d3e7727b817ebeb306d6e2"

URI_aarch64_rust-netlink-packet-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netlink-packet-core-devel-0.7.0-5.el10_1.noarch.rpm;name=aarch64_rust-netlink-packet-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netlink-packet-core-devel}"
SRC_URI[aarch64_rust-netlink-packet-core-devel.sha256sum] = "f401b8177bf251e8e9274a993dfc6b11e6c66c68841e530f6d46e6d4f4c98611"

RDEPENDS:rust-netlink-packet-core+default-devel = " \
 cargo \
 rust-netlink-packet-core-devel \
 "
RDEPENDS:rust-netlink-packet-core-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-byteorder+default-devel \
 rust-netlink-packet-utils+default-devel \
 "
