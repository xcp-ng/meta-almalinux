# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tmt"
PV = "1.55.0"
PR = "1.el10_1"
PACKAGES = " \
 tmt \
 tmt+all \
 tmt+export-polarion \
 tmt+link-jira \
 tmt+provision-beaker \
 tmt+provision-bootc \
 tmt+provision-container \
 tmt+provision-virtual \
 tmt+report-junit \
 tmt+report-polarion \
 tmt+test-convert \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tmt-1.55.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e9477b9a1f43b247ad994a78feb6eaa597110a8d43cca919a06ff8e946de26d"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - tmt: sshpass

URI_x86_64_v2_tmt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt-1.55.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_tmt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt}"
SRC_URI[x86_64_v2_tmt.sha256sum] = "1776518add8eae08f62727e27edc56639338c69f7ee95c5f277eb37f0eeb2474"

URI_x86_64_v2_tmt+all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+all-1.55.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+all}"
SRC_URI[x86_64_v2_tmt+all.sha256sum] = "82d800af46978bf099cb1f6f4ed0fe60a7e8c6d78e6907b25ecf2c89fffb49da"

URI_x86_64_v2_tmt+export-polarion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+export-polarion-1.55.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+export-polarion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+export-polarion}"
SRC_URI[x86_64_v2_tmt+export-polarion.sha256sum] = "882a0b58112dcd5754ede31861271fd81dede9059a1b99fac0f051dfbde411b7"

URI_x86_64_v2_tmt+link-jira = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+link-jira-1.55.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+link-jira;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+link-jira}"
SRC_URI[x86_64_v2_tmt+link-jira.sha256sum] = "7074d33c554cbda9da89e607e13c17c6cd8aead6b6b1c94781da4a7d66403243"

URI_x86_64_v2_tmt+provision-beaker = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+provision-beaker-1.55.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+provision-beaker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+provision-beaker}"
SRC_URI[x86_64_v2_tmt+provision-beaker.sha256sum] = "ce1a8984943f371c530eef592825a06343c368b80801a39c96c33f3d6aec5988"

URI_x86_64_v2_tmt+provision-bootc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+provision-bootc-1.55.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+provision-bootc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+provision-bootc}"
SRC_URI[x86_64_v2_tmt+provision-bootc.sha256sum] = "0ba97dc7f3edbca0c4dd131b210db052b5a982ca17d46c929d59e912df8b1ee7"

URI_x86_64_v2_tmt+provision-container = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+provision-container-1.55.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+provision-container;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+provision-container}"
SRC_URI[x86_64_v2_tmt+provision-container.sha256sum] = "0d3e477a84f9e405f2f793c44fbebb0c2fa0a4a6ed6f2a8162c231615ab5caf3"

URI_x86_64_v2_tmt+provision-virtual = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+provision-virtual-1.55.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+provision-virtual;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+provision-virtual}"
SRC_URI[x86_64_v2_tmt+provision-virtual.sha256sum] = "94a58f1fa99f3e10849749bc959d3673bd2d9fa0381852334c07829931612aa5"

URI_x86_64_v2_tmt+report-junit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+report-junit-1.55.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+report-junit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+report-junit}"
SRC_URI[x86_64_v2_tmt+report-junit.sha256sum] = "987af390a2c68b0712e8d108c8a3f7371bb44e078ebe1667c546c337e2d7a1da"

URI_x86_64_v2_tmt+report-polarion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+report-polarion-1.55.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+report-polarion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+report-polarion}"
SRC_URI[x86_64_v2_tmt+report-polarion.sha256sum] = "50bb196b6fb3d2500240a051fce2ef64f7d504f3d4ec0849b010a7ec3edbdc96"

URI_x86_64_v2_tmt+test-convert = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+test-convert-1.55.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+test-convert;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+test-convert}"
SRC_URI[x86_64_v2_tmt+test-convert.sha256sum] = "584e58387eefa4725a5898fd08db97f3bdc0b81ffc0682bc3a15b9273145d0a8"

URI_aarch64_tmt = "${EPEL_MIRROR}/aarch64/Packages/t/tmt-1.55.0-1.el10_1.noarch.rpm;name=aarch64_tmt;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt}"
SRC_URI[aarch64_tmt.sha256sum] = "132f6179c29a2cc6d4448e2cbd9d2d5341e4cb4dfb1ef084cefd095616600aab"

URI_aarch64_tmt+all = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+all-1.55.0-1.el10_1.noarch.rpm;name=aarch64_tmt+all;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+all}"
SRC_URI[aarch64_tmt+all.sha256sum] = "2fb2ba6793e474108f6a0888c73ea5134ffa5d67879426f7cf999cad7e0aa215"

URI_aarch64_tmt+export-polarion = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+export-polarion-1.55.0-1.el10_1.noarch.rpm;name=aarch64_tmt+export-polarion;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+export-polarion}"
SRC_URI[aarch64_tmt+export-polarion.sha256sum] = "1029fc03e3bfd656128eb10a6d04819b4269116adf2035724e4c5ac8f08331cf"

URI_aarch64_tmt+link-jira = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+link-jira-1.55.0-1.el10_1.noarch.rpm;name=aarch64_tmt+link-jira;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+link-jira}"
SRC_URI[aarch64_tmt+link-jira.sha256sum] = "e1537678e1530cd21996a61bf26ff6c62c18677cc80da8926a3ed3b1f63140c9"

URI_aarch64_tmt+provision-beaker = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+provision-beaker-1.55.0-1.el10_1.noarch.rpm;name=aarch64_tmt+provision-beaker;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+provision-beaker}"
SRC_URI[aarch64_tmt+provision-beaker.sha256sum] = "214fe268103a944a75bdbc468ea840b08014b09829597c41332e14338aa82ef8"

URI_aarch64_tmt+provision-bootc = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+provision-bootc-1.55.0-1.el10_1.noarch.rpm;name=aarch64_tmt+provision-bootc;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+provision-bootc}"
SRC_URI[aarch64_tmt+provision-bootc.sha256sum] = "280c5085b9bd8d2300b7672df2980d06036438a41e2f604741eaac628803c794"

URI_aarch64_tmt+provision-container = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+provision-container-1.55.0-1.el10_1.noarch.rpm;name=aarch64_tmt+provision-container;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+provision-container}"
SRC_URI[aarch64_tmt+provision-container.sha256sum] = "6b260d2c71c8622a5b5f372cfd737a73dcd2b0fe08c08b556c35444ea0f5e24f"

URI_aarch64_tmt+provision-virtual = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+provision-virtual-1.55.0-1.el10_1.noarch.rpm;name=aarch64_tmt+provision-virtual;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+provision-virtual}"
SRC_URI[aarch64_tmt+provision-virtual.sha256sum] = "bc03a9d48e32b2073c6d9cd0baa56cefd5ce69cc4d830ca3069042de30487d7f"

URI_aarch64_tmt+report-junit = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+report-junit-1.55.0-1.el10_1.noarch.rpm;name=aarch64_tmt+report-junit;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+report-junit}"
SRC_URI[aarch64_tmt+report-junit.sha256sum] = "8c826e14b41a042cf860e8aed91150b2d7722ed378a80e25a4120c68cb2bc5d0"

URI_aarch64_tmt+report-polarion = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+report-polarion-1.55.0-1.el10_1.noarch.rpm;name=aarch64_tmt+report-polarion;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+report-polarion}"
SRC_URI[aarch64_tmt+report-polarion.sha256sum] = "715f6c5c24571de46cdf1f2571bb803ba3451284ccbbb17d5dedf6622f8db575"

URI_aarch64_tmt+test-convert = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+test-convert-1.55.0-1.el10_1.noarch.rpm;name=aarch64_tmt+test-convert;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+test-convert}"
SRC_URI[aarch64_tmt+test-convert.sha256sum] = "5552c39c63897270fd9cd05e4730667cf45739042dc703d448cc2498dda84a79"

RDEPENDS:tmt:x86_64_v2 = " \
 bash \
 fmf \
 git-core \
 python3 \
 python3-click \
 python3-docutils \
 python3-jinja2 \
 python3-packaging \
 python3-pint \
 python3-pydantic \
 python3-pygments \
 python3-requests \
 python3-ruamel-yaml \
 python3-typing-extensions \
 python3-urllib3 \
 rsync \
"
RDEPENDS:tmt:aarch64 = " \
 bash \
 fmf \
 git-core \
 python3 \
 python3-click \
 python3-docutils \
 python3-jinja2 \
 python3-packaging \
 python3-pint \
 python3-pydantic \
 python3-pygments \
 python3-requests \
 python3-ruamel-yaml \
 python3-typing-extensions \
 python3-urllib3 \
 rsync \
 sshpass \
"
RDEPENDS:tmt+all = " \
 python3 \
 python3-bugzilla \
 python3-html2text \
 python3-jira \
 python3-lxml \
 python3-markdown \
 python3-mracklib \
 python3-nitrate \
 python3-pylero \
 python3-testcloud \
 tmt+export-polarion \
 tmt+provision-beaker \
 tmt+provision-container \
 tmt+provision-virtual \
 tmt+report-junit \
 tmt+report-polarion \
 tmt+test-convert \
 "
RDEPENDS:tmt+export-polarion = " \
 python3 \
 python3-pylero \
 tmt \
 "
RDEPENDS:tmt+link-jira = " \
 python3 \
 python3-jira \
 tmt \
 "
RDEPENDS:tmt+provision-beaker = " \
 python3 \
 python3-mrack-beaker \
 python3-mracklib \
 tmt \
 "
RDEPENDS:tmt+provision-bootc = " \
 podman \
 python3 \
 tmt \
 tmt+provision-virtual \
 "
RDEPENDS:tmt+provision-container = " \
 ansible-collection-containers-podman \
 podman \
 python3 \
 tmt \
 "
RDEPENDS:tmt+provision-virtual = " \
 libvirt-daemon-config-network \
 openssh-clients \
 python3 \
 python3-testcloud \
 tmt \
 "
RDEPENDS:tmt+report-junit = " \
 python3 \
 python3-lxml \
 tmt \
 "
RDEPENDS:tmt+report-polarion = " \
 python3 \
 python3-lxml \
 python3-pylero \
 tmt \
 "
RDEPENDS:tmt+test-convert = " \
 make \
 python3 \
 python3-bugzilla \
 python3-html2text \
 python3-markdown \
 python3-nitrate \
 tmt \
 "
