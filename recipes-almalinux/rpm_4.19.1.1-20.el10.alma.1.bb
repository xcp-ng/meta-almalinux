# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rpm"
PV = "4.19.1.1"
PR = "20.el10.alma.1"
PACKAGES = " \
 python3-rpm \
 rpm \
 rpm-apidocs \
 rpm-build \
 rpm-build-libs \
 rpm-cron \
 rpm-devel \
 rpm-libs \
 rpm-plugin-audit \
 rpm-plugin-dbus-announce \
 rpm-plugin-fapolicyd \
 rpm-plugin-ima \
 rpm-plugin-selinux \
 rpm-plugin-syslog \
 rpm-plugin-systemd-inhibit \
 rpm-sign \
 rpm-sign-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/rpm-4.19.1.1-20.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be36d7180d71c31d4a165239ead4e23ee3c8ee3828d493e359791ae99c0583ba"

URI_x86_64_v2_python3-rpm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-rpm-4.19.1.1-20.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-rpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rpm}"
SRC_URI[x86_64_v2_python3-rpm.sha256sum] = "e2d0542ab2ae021f8e7baadf67800bb63f46a2c0f96d6b1ba9e6ed30b09219e0"

URI_x86_64_v2_rpm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rpm-4.19.1.1-20.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm}"
SRC_URI[x86_64_v2_rpm.sha256sum] = "7b5cb59f1f901ec174f170ec9658677bb1d21f4a1bd7686dda6eb73e6b74344c"

URI_x86_64_v2_rpm-apidocs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-apidocs-4.19.1.1-20.el10.alma.1.noarch.rpm;name=x86_64_v2_rpm-apidocs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-apidocs}"
SRC_URI[x86_64_v2_rpm-apidocs.sha256sum] = "49eb5ec3fa0e510d1a994d35e882a35d8642a0a1cd5af4d797c4373cc9cd70f8"

URI_x86_64_v2_rpm-build = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-build-4.19.1.1-20.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-build;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-build}"
SRC_URI[x86_64_v2_rpm-build.sha256sum] = "77a31ec5bf442a193ff36be6aa6525a0ebb41941907c388b00642a869283b690"

URI_x86_64_v2_rpm-build-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rpm-build-libs-4.19.1.1-20.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-build-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-build-libs}"
SRC_URI[x86_64_v2_rpm-build-libs.sha256sum] = "6d50b1db4151b5a36f21bec61a7728b5cc51fc59a5dfc567be9b0f1710906e23"

URI_x86_64_v2_rpm-cron = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-cron-4.19.1.1-20.el10.alma.1.noarch.rpm;name=x86_64_v2_rpm-cron;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-cron}"
SRC_URI[x86_64_v2_rpm-cron.sha256sum] = "1748cdee3f85d54bb4e4a8f98a66b998f2f1cc9f71bf5f29f9bd6f9e1aaef278"

URI_x86_64_v2_rpm-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-devel-4.19.1.1-20.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-devel}"
SRC_URI[x86_64_v2_rpm-devel.sha256sum] = "50a0d497504865ff8ca68c001ae284a52fd1d7b85533b448d3d3f191cbacdfe6"

URI_x86_64_v2_rpm-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rpm-libs-4.19.1.1-20.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-libs}"
SRC_URI[x86_64_v2_rpm-libs.sha256sum] = "0dc4343af3097e7a5aa8c05fe73771c8db83f8ef18c47ebfd306cf323f9cd6a6"

URI_x86_64_v2_rpm-plugin-audit = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rpm-plugin-audit-4.19.1.1-20.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-plugin-audit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-plugin-audit}"
SRC_URI[x86_64_v2_rpm-plugin-audit.sha256sum] = "0361d07cc4f9c60f4d4130ec018c4a3d04fe05bb04afcbe9727046788d66e722"

URI_x86_64_v2_rpm-plugin-dbus-announce = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-plugin-dbus-announce-4.19.1.1-20.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-plugin-dbus-announce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-plugin-dbus-announce}"
SRC_URI[x86_64_v2_rpm-plugin-dbus-announce.sha256sum] = "ede2d3cedfa40181fdc86b24e90ad51b9ab83c95f150622ba8534b4f2c711ebb"

URI_x86_64_v2_rpm-plugin-fapolicyd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-plugin-fapolicyd-4.19.1.1-20.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-plugin-fapolicyd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-plugin-fapolicyd}"
SRC_URI[x86_64_v2_rpm-plugin-fapolicyd.sha256sum] = "5bb0b489d5a948eba72c7d7840f5ff66fc5cfde6eb49508373a372a77d8ce643"

URI_x86_64_v2_rpm-plugin-ima = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-plugin-ima-4.19.1.1-20.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-plugin-ima;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-plugin-ima}"
SRC_URI[x86_64_v2_rpm-plugin-ima.sha256sum] = "a83958b6a579bfc483eac3b577d9dc0237e5cda1def1b99a241c93d3b280b90f"

URI_x86_64_v2_rpm-plugin-selinux = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rpm-plugin-selinux-4.19.1.1-20.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-plugin-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-plugin-selinux}"
SRC_URI[x86_64_v2_rpm-plugin-selinux.sha256sum] = "0e4200845bd6e8151ab9c533667fe5ce57488ad0fbee7a2fa916b3bdea00c1e6"

URI_x86_64_v2_rpm-plugin-syslog = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-plugin-syslog-4.19.1.1-20.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-plugin-syslog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-plugin-syslog}"
SRC_URI[x86_64_v2_rpm-plugin-syslog.sha256sum] = "bbcc015bbb6d431b56d2dd4979ff2722c727f1ffe2cbde74f617672e1a737ade"

URI_x86_64_v2_rpm-plugin-systemd-inhibit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-plugin-systemd-inhibit-4.19.1.1-20.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-plugin-systemd-inhibit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-plugin-systemd-inhibit}"
SRC_URI[x86_64_v2_rpm-plugin-systemd-inhibit.sha256sum] = "4cd19085aea678f4ffe855f4220f2cee959968c6a15d5bf2bed664a703edc8f6"

URI_x86_64_v2_rpm-sign = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rpm-sign-4.19.1.1-20.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-sign;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-sign}"
SRC_URI[x86_64_v2_rpm-sign.sha256sum] = "8266e29e6e119fb3eaa212aa1283677d0ed3c5441be9723e5ffafe8f6a21f6d4"

URI_x86_64_v2_rpm-sign-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rpm-sign-libs-4.19.1.1-20.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-sign-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-sign-libs}"
SRC_URI[x86_64_v2_rpm-sign-libs.sha256sum] = "f9bcf618792df926a673cdc6a9e7985d8a5657828706bad4fce9996d48c6c492"

URI_aarch64_python3-rpm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-rpm-4.19.1.1-20.el10.alma.1.aarch64.rpm;name=aarch64_python3-rpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rpm}"
SRC_URI[aarch64_python3-rpm.sha256sum] = "879b33e688990e20b5a9bad9889b976b6b3840c22d0609cf07e6f419f832e15f"

URI_aarch64_rpm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rpm-4.19.1.1-20.el10.alma.1.aarch64.rpm;name=aarch64_rpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm}"
SRC_URI[aarch64_rpm.sha256sum] = "219ba6f44bd7ac249af741a0baec3d2703ca5e9583652c30573c1c83cfe8b967"

URI_aarch64_rpm-apidocs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-apidocs-4.19.1.1-20.el10.alma.1.noarch.rpm;name=aarch64_rpm-apidocs;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-apidocs}"
SRC_URI[aarch64_rpm-apidocs.sha256sum] = "49eb5ec3fa0e510d1a994d35e882a35d8642a0a1cd5af4d797c4373cc9cd70f8"

URI_aarch64_rpm-build = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-build-4.19.1.1-20.el10.alma.1.aarch64.rpm;name=aarch64_rpm-build;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-build}"
SRC_URI[aarch64_rpm-build.sha256sum] = "31873daeac4f0d7ec3556b2e6cbeef02e65200002b46e717c7ba53c6e42420fc"

URI_aarch64_rpm-build-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rpm-build-libs-4.19.1.1-20.el10.alma.1.aarch64.rpm;name=aarch64_rpm-build-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-build-libs}"
SRC_URI[aarch64_rpm-build-libs.sha256sum] = "1f6693a87a1cb9f4e3394eef751d4d71a877dbb3b57587796929ffe2b0ae9160"

URI_aarch64_rpm-cron = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-cron-4.19.1.1-20.el10.alma.1.noarch.rpm;name=aarch64_rpm-cron;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-cron}"
SRC_URI[aarch64_rpm-cron.sha256sum] = "1748cdee3f85d54bb4e4a8f98a66b998f2f1cc9f71bf5f29f9bd6f9e1aaef278"

URI_aarch64_rpm-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-devel-4.19.1.1-20.el10.alma.1.aarch64.rpm;name=aarch64_rpm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-devel}"
SRC_URI[aarch64_rpm-devel.sha256sum] = "9b27d32f0978d5e8a4adc6def9bd73b06111b031653c93550257e28432127a25"

URI_aarch64_rpm-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rpm-libs-4.19.1.1-20.el10.alma.1.aarch64.rpm;name=aarch64_rpm-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-libs}"
SRC_URI[aarch64_rpm-libs.sha256sum] = "05055857ef3e9c3400a8d138a6261a437f6c4b09ad4ebfa5d6b92e0dac2fafbc"

URI_aarch64_rpm-plugin-audit = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rpm-plugin-audit-4.19.1.1-20.el10.alma.1.aarch64.rpm;name=aarch64_rpm-plugin-audit;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-plugin-audit}"
SRC_URI[aarch64_rpm-plugin-audit.sha256sum] = "a266b8bdcd3e9bf433fdcee5d47c325e02455af9839a2c311b20aa20aeadc314"

URI_aarch64_rpm-plugin-dbus-announce = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-plugin-dbus-announce-4.19.1.1-20.el10.alma.1.aarch64.rpm;name=aarch64_rpm-plugin-dbus-announce;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-plugin-dbus-announce}"
SRC_URI[aarch64_rpm-plugin-dbus-announce.sha256sum] = "520cb4ece2cfb460fc65b0d930988e4c304fee4db4dabcec5444e989575a8e7d"

URI_aarch64_rpm-plugin-fapolicyd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-plugin-fapolicyd-4.19.1.1-20.el10.alma.1.aarch64.rpm;name=aarch64_rpm-plugin-fapolicyd;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-plugin-fapolicyd}"
SRC_URI[aarch64_rpm-plugin-fapolicyd.sha256sum] = "cdda2d6b92b9fa9fac4e3812508a98c45fc576fb6c7c1e1f1e315915be3a487c"

URI_aarch64_rpm-plugin-ima = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-plugin-ima-4.19.1.1-20.el10.alma.1.aarch64.rpm;name=aarch64_rpm-plugin-ima;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-plugin-ima}"
SRC_URI[aarch64_rpm-plugin-ima.sha256sum] = "5f41b2833611ac92c80b72f1f74c3123241ccd843f8d1acee878a5a473cdce27"

URI_aarch64_rpm-plugin-selinux = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rpm-plugin-selinux-4.19.1.1-20.el10.alma.1.aarch64.rpm;name=aarch64_rpm-plugin-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-plugin-selinux}"
SRC_URI[aarch64_rpm-plugin-selinux.sha256sum] = "7762fee1fdceb446a91334a3b7de38d9baa962431b6b94b89e447a1dc9783f6a"

URI_aarch64_rpm-plugin-syslog = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-plugin-syslog-4.19.1.1-20.el10.alma.1.aarch64.rpm;name=aarch64_rpm-plugin-syslog;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-plugin-syslog}"
SRC_URI[aarch64_rpm-plugin-syslog.sha256sum] = "62ac798f83f29ebc69f50ea4af01060be909a1dc090f02607584b16d1cae4ca5"

URI_aarch64_rpm-plugin-systemd-inhibit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-plugin-systemd-inhibit-4.19.1.1-20.el10.alma.1.aarch64.rpm;name=aarch64_rpm-plugin-systemd-inhibit;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-plugin-systemd-inhibit}"
SRC_URI[aarch64_rpm-plugin-systemd-inhibit.sha256sum] = "2660540026aea45ef57904e659d0cf38b1038d66547cdd132ae044e0f3d466e9"

URI_aarch64_rpm-sign = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rpm-sign-4.19.1.1-20.el10.alma.1.aarch64.rpm;name=aarch64_rpm-sign;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-sign}"
SRC_URI[aarch64_rpm-sign.sha256sum] = "a6d0f2a5d117ae5a250b45fafaed7401f3106333ec9d7826cec53c0c2a2b1b5b"

URI_aarch64_rpm-sign-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rpm-sign-libs-4.19.1.1-20.el10.alma.1.aarch64.rpm;name=aarch64_rpm-sign-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-sign-libs}"
SRC_URI[aarch64_rpm-sign-libs.sha256sum] = "6fac2bc319ef72f840351ada4e8c97818a8d73dea26f6c5131b56f33238b1424"

RDEPENDS:python3-rpm = " \
 glibc \
 python3 \
 rpm-build-libs \
 rpm-libs \
 rpm-sign-libs \
 "
RDEPENDS:rpm = " \
 bash \
 curl \
 findutils \
 glibc \
 libarchive \
 popt \
 rpm-libs \
 sed \
 virtual/coreutils \
 "
RDEPENDS:rpm-apidocs = " \
 "
RDEPENDS:rpm-build = " \
 bash \
 binutils \
 bzip2 \
 cpio \
 debugedit \
 diffutils \
 elfutils \
 elfutils-libelf \
 file \
 findutils \
 gawk \
 glibc \
 grep \
 gzip \
 patch \
 pkgconf-pkg-config \
 popt \
 readline \
 redhat-rpm-config \
 rpm \
 rpm-build-libs \
 rpm-libs \
 sed \
 tar \
 unzip \
 virtual//usr/bin/gdb-add-index \
 xz \
 zstd \
 "
RDEPENDS:rpm-build-libs = " \
 elfutils-libelf \
 elfutils-libs \
 file-libs \
 glibc \
 libcap \
 libgcc \
 libgomp \
 lua-libs \
 popt \
 rpm-libs \
 "
RDEPENDS:rpm-cron = " \
 bash \
 crontabs \
 logrotate \
 rpm \
 "
RDEPENDS:rpm-devel = " \
 cmake-filesystem \
 glibc \
 pkgconf-pkg-config \
 popt \
 popt-devel \
 rpm \
 rpm-build-libs \
 rpm-libs \
 rpm-sign-libs \
 "
RDEPENDS:rpm-libs = " \
 bzip2-libs \
 glibc \
 libacl \
 libcap \
 libzstd \
 lua-libs \
 popt \
 rpm \
 rpm-sequoia \
 sqlite-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:rpm-plugin-audit = " \
 audit-libs \
 glibc \
 rpm-libs \
 "
RDEPENDS:rpm-plugin-dbus-announce = " \
 dbus-libs \
 glibc \
 rpm-libs \
 "
RDEPENDS:rpm-plugin-fapolicyd = " \
 glibc \
 rpm-libs \
 "
RDEPENDS:rpm-plugin-ima = " \
 glibc \
 rpm-libs \
 "
RDEPENDS:rpm-plugin-selinux = " \
 glibc \
 libselinux \
 rpm-libs \
 selinux-policy \
 "
RDEPENDS:rpm-plugin-syslog = " \
 glibc \
 rpm-libs \
 "
RDEPENDS:rpm-plugin-systemd-inhibit = " \
 dbus-libs \
 glibc \
 rpm-libs \
 "
RDEPENDS:rpm-sign = " \
 glibc \
 popt \
 rpm-libs \
 rpm-sign-libs \
 "
RDEPENDS:rpm-sign-libs = " \
 glibc \
 ima-evm-utils \
 popt \
 rpm-libs \
 "
