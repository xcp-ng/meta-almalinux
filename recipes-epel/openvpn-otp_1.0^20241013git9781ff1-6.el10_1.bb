# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openvpn-otp"
PV = "1.0^20241013git9781ff1"
PR = "6.el10_1"
PACKAGES = " \
 openvpn-otp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/openvpn-otp-1.0^20241013git9781ff1-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f5d9ed70552efe75f17213be896db271843973f66e29162268fa3d34bb356a35"

URI_x86_64_v2_openvpn-otp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openvpn-otp-1.0^20241013git9781ff1-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openvpn-otp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openvpn-otp}"
SRC_URI[x86_64_v2_openvpn-otp.sha256sum] = "75692dccba1872e86c10ccc60cb93e18b4950078efdd31f9d560d8f526243e93"

URI_aarch64_openvpn-otp = "${EPEL_MIRROR}/aarch64/Packages/o/openvpn-otp-1.0^20241013git9781ff1-6.el10_1.aarch64.rpm;name=aarch64_openvpn-otp;unpack=0"
SRC_URI:append = " ${URI_aarch64_openvpn-otp}"
SRC_URI[aarch64_openvpn-otp.sha256sum] = "619c1c7fd8acfd31c453e73be00ddcf255b6c4ab2fd770f189c20648b4eba9bc"

RDEPENDS:openvpn-otp = " \
 glibc \
 openvpn \
 "
