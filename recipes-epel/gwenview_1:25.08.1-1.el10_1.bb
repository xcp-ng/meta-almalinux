# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gwenview"
PE = "1"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 gwenview \
 gwenview-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gwenview-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c3472419dccee4d9de5c343a5108649a489c1464245081c65b3203acc641fc8"

URI_x86_64_v2_gwenview = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gwenview-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gwenview;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gwenview}"
SRC_URI[x86_64_v2_gwenview.sha256sum] = "91073b340a31481fa7ea0289141995b155ac7b36803620109cb099a670238708"

URI_x86_64_v2_gwenview-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gwenview-libs-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gwenview-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gwenview-libs}"
SRC_URI[x86_64_v2_gwenview-libs.sha256sum] = "ac5fb2703b203e7088c4bc2f66447abe2a29b24de81fecee456cd1136dfe59a6"

URI_aarch64_gwenview = "${EPEL_MIRROR}/aarch64/Packages/g/gwenview-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_gwenview;unpack=0"
SRC_URI:append = " ${URI_aarch64_gwenview}"
SRC_URI[aarch64_gwenview.sha256sum] = "a1e50db9eb24a0e8ff74a0207fe5878c758b9125c7a167ba698c18ec8b72e652"

URI_aarch64_gwenview-libs = "${EPEL_MIRROR}/aarch64/Packages/g/gwenview-libs-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_gwenview-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gwenview-libs}"
SRC_URI[aarch64_gwenview-libs.sha256sum] = "a2f26258be0188c330825b1577f4a1db000a57a86b7d634745191e78376f816e"

RDEPENDS:gwenview = " \
 exiv2-libs \
 glibc \
 gwenview-libs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-purpose \
 kf6-solid \
 kimageannotator-qt6 \
 libgcc \
 libstdc++ \
 libtiff \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:gwenview-libs = " \
 cfitsio \
 exiv2-libs \
 glibc \
 gwenview \
 kf6-baloo-libs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kfilemetadata \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kimageannotator-qt6 \
 lcms2 \
 libX11 \
 libgcc \
 libjpeg-turbo \
 libkdcraw \
 libpng \
 libstdc++ \
 libwayland-client \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
 qt6-qtwayland \
 "
