# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-python-pkginfo"
PV = "0.6.6"
PR = "1.el10_1"
PACKAGES = " \
 rust-python-pkginfo+bzip2-devel \
 rust-python-pkginfo+default-devel \
 rust-python-pkginfo+deprecated-formats-devel \
 rust-python-pkginfo+serde-devel \
 rust-python-pkginfo+xz-devel \
 rust-python-pkginfo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-python-pkginfo-0.6.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c2b08a5735d509ed5bd8e5fcf8e4dd79575c5ae2730e140d4bd72dfeac30b5f"

URI_x86_64_v2_rust-python-pkginfo+bzip2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-python-pkginfo+bzip2-devel-0.6.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-python-pkginfo+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-python-pkginfo+bzip2-devel}"
SRC_URI[x86_64_v2_rust-python-pkginfo+bzip2-devel.sha256sum] = "d9040605cf7dc1e16387cc03b5f262aa9829f720578aa8e21783e284794481bc"

URI_x86_64_v2_rust-python-pkginfo+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-python-pkginfo+default-devel-0.6.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-python-pkginfo+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-python-pkginfo+default-devel}"
SRC_URI[x86_64_v2_rust-python-pkginfo+default-devel.sha256sum] = "9205765683083e9a1f994016df6fb11a1048d49bf5d74cac71fec8fca8a3fa7e"

URI_x86_64_v2_rust-python-pkginfo+deprecated-formats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-python-pkginfo+deprecated-formats-devel-0.6.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-python-pkginfo+deprecated-formats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-python-pkginfo+deprecated-formats-devel}"
SRC_URI[x86_64_v2_rust-python-pkginfo+deprecated-formats-devel.sha256sum] = "42076930ee62497d1c39d7777dbcae28b37d15f4de8f9bb28e6f912d27e99d70"

URI_x86_64_v2_rust-python-pkginfo+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-python-pkginfo+serde-devel-0.6.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-python-pkginfo+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-python-pkginfo+serde-devel}"
SRC_URI[x86_64_v2_rust-python-pkginfo+serde-devel.sha256sum] = "965010b20aafd0ef29608c611429896338da9725f650deaa3fc7d7a409baf124"

URI_x86_64_v2_rust-python-pkginfo+xz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-python-pkginfo+xz-devel-0.6.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-python-pkginfo+xz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-python-pkginfo+xz-devel}"
SRC_URI[x86_64_v2_rust-python-pkginfo+xz-devel.sha256sum] = "20920b0e84c08754d53745d800b4b71891b24897f2280ca61d38507fcf8117c4"

URI_x86_64_v2_rust-python-pkginfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-python-pkginfo-devel-0.6.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-python-pkginfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-python-pkginfo-devel}"
SRC_URI[x86_64_v2_rust-python-pkginfo-devel.sha256sum] = "4d0f40768aece5801563fce24adcc447e3f91809c15099b3128e1f954533d454"

URI_aarch64_rust-python-pkginfo+bzip2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-python-pkginfo+bzip2-devel-0.6.6-1.el10_1.noarch.rpm;name=aarch64_rust-python-pkginfo+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-python-pkginfo+bzip2-devel}"
SRC_URI[aarch64_rust-python-pkginfo+bzip2-devel.sha256sum] = "c99090da226faa10fe119c1fc7bc0266a8c0648d02a1bb624f6473eeb3392df1"

URI_aarch64_rust-python-pkginfo+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-python-pkginfo+default-devel-0.6.6-1.el10_1.noarch.rpm;name=aarch64_rust-python-pkginfo+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-python-pkginfo+default-devel}"
SRC_URI[aarch64_rust-python-pkginfo+default-devel.sha256sum] = "63abe7b9edbf8b2f42149f4d6e09466bd777c5932eb3be459fa6a1b02a3b45da"

URI_aarch64_rust-python-pkginfo+deprecated-formats-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-python-pkginfo+deprecated-formats-devel-0.6.6-1.el10_1.noarch.rpm;name=aarch64_rust-python-pkginfo+deprecated-formats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-python-pkginfo+deprecated-formats-devel}"
SRC_URI[aarch64_rust-python-pkginfo+deprecated-formats-devel.sha256sum] = "0b9b3d80abf2cafd1c28657f229bfff94a6f9072b08ce539311719f17f4e27e6"

URI_aarch64_rust-python-pkginfo+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-python-pkginfo+serde-devel-0.6.6-1.el10_1.noarch.rpm;name=aarch64_rust-python-pkginfo+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-python-pkginfo+serde-devel}"
SRC_URI[aarch64_rust-python-pkginfo+serde-devel.sha256sum] = "6fb905513007580ef9f3a466f0cbaff30cd80c12e16edf60345265d256d08d2c"

URI_aarch64_rust-python-pkginfo+xz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-python-pkginfo+xz-devel-0.6.6-1.el10_1.noarch.rpm;name=aarch64_rust-python-pkginfo+xz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-python-pkginfo+xz-devel}"
SRC_URI[aarch64_rust-python-pkginfo+xz-devel.sha256sum] = "35885d21fefb87cd72bbfff52aee9ca64504176ffc8cf7d2fb94894ca456d549"

URI_aarch64_rust-python-pkginfo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-python-pkginfo-devel-0.6.6-1.el10_1.noarch.rpm;name=aarch64_rust-python-pkginfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-python-pkginfo-devel}"
SRC_URI[aarch64_rust-python-pkginfo-devel.sha256sum] = "ec3091d59b034b1816d3744c66c00fdf17f62f420ad72c1eed941eae03f5d537"

RDEPENDS:rust-python-pkginfo+bzip2-devel = " \
 cargo \
 rust-bzip2+default-devel \
 rust-python-pkginfo-devel \
 "
RDEPENDS:rust-python-pkginfo+default-devel = " \
 cargo \
 rust-python-pkginfo-devel \
 "
RDEPENDS:rust-python-pkginfo+deprecated-formats-devel = " \
 cargo \
 rust-python-pkginfo+bzip2-devel \
 rust-python-pkginfo+xz-devel \
 rust-python-pkginfo-devel \
 virtual/crate_zip/bzip2__ge_0.6.0_with_crate_zip/bzip2__lt_7.0.0~ \
 "
RDEPENDS:rust-python-pkginfo+serde-devel = " \
 cargo \
 rust-python-pkginfo-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-python-pkginfo+xz-devel = " \
 cargo \
 rust-python-pkginfo-devel \
 rust-xz2+default-devel \
 "
RDEPENDS:rust-python-pkginfo-devel = " \
 cargo \
 rust-flate2+default-devel \
 rust-fs-err+default-devel \
 rust-mailparse+default-devel \
 rust-rfc2047-decoder+default-devel \
 rust-tar+default-devel \
 rust-thiserror+default-devel \
 virtual/crate_zip/deflate__ge_0.6.0_with_crate_zip/deflate__lt_7.0.0~ \
 virtual/crate_zip__ge_0.6.0_with_crate_zip__lt_7.0.0~ \
 "
