# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cockpit-session-recording"
PV = "17"
PR = "1.el10"
PACKAGES = " \
 cockpit-session-recording \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cockpit-session-recording-17-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f147217cadee657611b41cba901dcce61a32a2869f2d516eafe8bc542fa8b290"

URI_x86_64_v2_cockpit-session-recording = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cockpit-session-recording-17-1.el10.noarch.rpm;name=x86_64_v2_cockpit-session-recording;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-session-recording}"
SRC_URI[x86_64_v2_cockpit-session-recording.sha256sum] = "c78166f52fc4e7a3144ad83235d4fed9dd8da1ff680e4e853029079ba6149088"

URI_aarch64_cockpit-session-recording = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cockpit-session-recording-17-1.el10.noarch.rpm;name=aarch64_cockpit-session-recording;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-session-recording}"
SRC_URI[aarch64_cockpit-session-recording.sha256sum] = "c78166f52fc4e7a3144ad83235d4fed9dd8da1ff680e4e853029079ba6149088"

RDEPENDS:cockpit-session-recording = " \
 cockpit-system \
 sssd-proxy \
 tlog \
 "
