# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdump-utils"
PV = "1.0.51"
PR = "11.el10_0"
PACKAGES = " \
 kdump-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/kdump-utils-1.0.51-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "140947d49e1babc847308449a578727a7d937db3efc2844c1ef09b00c7fe4c0d"

URI_x86_64_v2_kdump-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kdump-utils-1.0.51-11.el10_0.x86_64_v2.rpm;name=x86_64_v2_kdump-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdump-utils}"
SRC_URI[x86_64_v2_kdump-utils.sha256sum] = "bd97289824e00a10d4a19016d1d8bfc16b03680d9487117521d0ceac908e92f2"

URI_aarch64_kdump-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kdump-utils-1.0.51-11.el10_0.aarch64.rpm;name=aarch64_kdump-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdump-utils}"
SRC_URI[aarch64_kdump-utils.sha256sum] = "3c029f99d85eaa6cc86be080223242e714d25cba1879ed22ae770ca902b93448"

RDEPENDS:kdump-utils = " \
 bash \
 dracut \
 dracut-network \
 dracut-squash \
 ethtool \
 kexec-tools \
 makedumpfile \
 sed \
 systemd-udev \
 util-linux \
 virtual/coreutils \
 "
