# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkcddb"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 libkcddb \
 libkcddb-devel \
 libkcddb-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libkcddb-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "27702682202a37d48838dc3c6a11c32829a05e5b6b42969df3f7dd68812e7f5c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkcddb-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkcddb;unpack=0"
SRC_URI[x86_64_v2_libkcddb.sha256sum] = "377ddb675d98460b327322c16d45766c2221acecdfd709316ad9f1e29c66b669"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkcddb-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkcddb-devel;unpack=0"
SRC_URI[x86_64_v2_libkcddb-devel.sha256sum] = "a4c7f431b391f57e8d0b87526d9a01ee47aafca9d507d50069d209374b0fb52f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkcddb-doc-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_libkcddb-doc;unpack=0"
SRC_URI[x86_64_v2_libkcddb-doc.sha256sum] = "a4d48eb7a55923b6e0b34459958c3a12c99e8db55e1cbf164e92b071cb0e463b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libkcddb-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_libkcddb;unpack=0"
SRC_URI[aarch64_libkcddb.sha256sum] = "7c38145aca653375e57cb1219dbc7da45dcd2ea1bf0d8344ca4cd32b56c2c654"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libkcddb-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_libkcddb-devel;unpack=0"
SRC_URI[aarch64_libkcddb-devel.sha256sum] = "dc61241b37f10421d4e2728e7887617833f75daad4288397531db138ae1ea70b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libkcddb-doc-26.08.1-1.el10_3.noarch.rpm;name=aarch64_libkcddb-doc;unpack=0"
SRC_URI[aarch64_libkcddb-doc.sha256sum] = "ecb4015143918d2c5e4fa64751ff5eba8aa62112f9bf07eaf5c7572d3bfa8ac7"

RDEPENDS:libkcddb = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-solid \
 libgcc \
 libkcddb-doc \
 libmusicbrainz5 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkcddb-devel = " \
 cmake-filesystem \
 libkcddb \
 "
RDEPENDS:libkcddb-doc = " \
 libkcddb \
 "
