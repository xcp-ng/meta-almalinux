# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wireshark"
PE = "1"
PV = "4.4.2"
PR = "10.el10_2"
PACKAGES = " \
 wireshark \
 wireshark-cli \
 wireshark-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/wireshark-4.4.2-10.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7dea1b569957397bcc1b4da93604d620564be49e1cd6ff7bc32628c5b3f2852"

URI_x86_64_v2_wireshark = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/wireshark-4.4.2-10.el10_2.x86_64_v2.rpm;name=x86_64_v2_wireshark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wireshark}"
SRC_URI[x86_64_v2_wireshark.sha256sum] = "3470c9c7a886fd80ed05140da9cf0736f9b60fd74ea7c256f00df410fcd92278"

URI_x86_64_v2_wireshark-cli = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/wireshark-cli-4.4.2-10.el10_2.x86_64_v2.rpm;name=x86_64_v2_wireshark-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wireshark-cli}"
SRC_URI[x86_64_v2_wireshark-cli.sha256sum] = "8137707b1a7f6dc5bc7b3e1dbcb7d8f3b9dc390e2451ac36a200a1eb4fd2f3c6"

URI_x86_64_v2_wireshark-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/wireshark-devel-4.4.2-10.el10_2.x86_64_v2.rpm;name=x86_64_v2_wireshark-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wireshark-devel}"
SRC_URI[x86_64_v2_wireshark-devel.sha256sum] = "54d9eeb82b9fbb4a316c1de71748c8f253d91e3873bdb40aa681412facec4e91"

URI_aarch64_wireshark = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/wireshark-4.4.2-10.el10_2.aarch64.rpm;name=aarch64_wireshark;unpack=0"
SRC_URI:append = " ${URI_aarch64_wireshark}"
SRC_URI[aarch64_wireshark.sha256sum] = "e5bdd064ddcc685084cbb657e866a333c13e38eb54e3dfd1475a4a2ed7a58f43"

URI_aarch64_wireshark-cli = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/wireshark-cli-4.4.2-10.el10_2.aarch64.rpm;name=aarch64_wireshark-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_wireshark-cli}"
SRC_URI[aarch64_wireshark-cli.sha256sum] = "c4439b2082ba7acc5f24dccd0bac75acf12d00beaf8ab74e73c6108268ed7673"

URI_aarch64_wireshark-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/wireshark-devel-4.4.2-10.el10_2.aarch64.rpm;name=aarch64_wireshark-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_wireshark-devel}"
SRC_URI[aarch64_wireshark-devel.sha256sum] = "19d7f8329d1f2b1ca846a9779933725e4f482161b5974a8a193149086b4ec1db"

RDEPENDS:wireshark = " \
 glib2 \
 glibc \
 hicolor-icon-theme \
 libgcc \
 libgcrypt \
 libnl3 \
 libpcap \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 speexdsp \
 wireshark-cli \
 xdg-utils \
 "
RDEPENDS:wireshark-cli = " \
 bash \
 c-ares \
 glib2 \
 glibc \
 gnutls \
 krb5-libs \
 libcap \
 libgcc \
 libgcrypt \
 libnghttp2 \
 libnl3 \
 libpcap \
 libsmi \
 libssh \
 libxml2 \
 libzstd \
 lua-libs \
 pcre2 \
 shadow-utils \
 speexdsp \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:wireshark-devel = " \
 glib2-devel \
 glibc-devel \
 pkgconf-pkg-config \
 wireshark \
 wireshark-cli \
 "
