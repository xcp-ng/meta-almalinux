# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kunitconversion"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kunitconversion \
 kf6-kunitconversion-devel \
 kf6-kunitconversion-doc \
 kf6-kunitconversion-html \
 python3-kf6-kunitconversion \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kunitconversion-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e9a5ce36e117b1594f2488dd42b18f67ad8b58706100a70169f0fde96d985ab"

URI_x86_64_v2_kf6-kunitconversion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kunitconversion-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kunitconversion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kunitconversion}"
SRC_URI[x86_64_v2_kf6-kunitconversion.sha256sum] = "aebec64f7b3dd7fc59e041aeb804f3b1f3873977879337c76b7d1b62204681c7"

URI_x86_64_v2_kf6-kunitconversion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kunitconversion-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kunitconversion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kunitconversion-devel}"
SRC_URI[x86_64_v2_kf6-kunitconversion-devel.sha256sum] = "3e5bdfef68e8edbf4f5fb8c506f01b6896f1bc9a12de03d44fc17e81a94f5d44"

URI_x86_64_v2_kf6-kunitconversion-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kunitconversion-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kunitconversion-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kunitconversion-doc}"
SRC_URI[x86_64_v2_kf6-kunitconversion-doc.sha256sum] = "33b317ba748cd84c4e8ba3d856bcb2b6a0499fc4a9a8199a8a023c3e9696cc6f"

URI_x86_64_v2_kf6-kunitconversion-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kunitconversion-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kunitconversion-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kunitconversion-html}"
SRC_URI[x86_64_v2_kf6-kunitconversion-html.sha256sum] = "6ba1bc6da2bdc0cddbf87147d80f9c691d83a98fa22416c24201cc7a600db2f6"

URI_x86_64_v2_python3-kf6-kunitconversion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-kunitconversion-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-kunitconversion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kf6-kunitconversion}"
SRC_URI[x86_64_v2_python3-kf6-kunitconversion.sha256sum] = "00950e15446001b719016d2759441905d92a26bf865dc79b61fafc7d02e27228"

URI_aarch64_kf6-kunitconversion = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kunitconversion-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kunitconversion;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kunitconversion}"
SRC_URI[aarch64_kf6-kunitconversion.sha256sum] = "3b8184eafaa13758faf96cbf44de53e74c34010bba40e565b150d108d769b480"

URI_aarch64_kf6-kunitconversion-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kunitconversion-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kunitconversion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kunitconversion-devel}"
SRC_URI[aarch64_kf6-kunitconversion-devel.sha256sum] = "7375c5114bc24127584681c4fc31b7570a71be31dd0445bc5da22b85bb1479e9"

URI_aarch64_kf6-kunitconversion-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kunitconversion-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kunitconversion-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kunitconversion-doc}"
SRC_URI[aarch64_kf6-kunitconversion-doc.sha256sum] = "9b076badee9315699b200b80a039828da9f0bc3d9c071cdcae840c240efa301f"

URI_aarch64_kf6-kunitconversion-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kunitconversion-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kunitconversion-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kunitconversion-html}"
SRC_URI[aarch64_kf6-kunitconversion-html.sha256sum] = "023f10049e901579a6e229268535c668deee521c39a791d41a0933283f4d7876"

URI_aarch64_python3-kf6-kunitconversion = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-kunitconversion-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_python3-kf6-kunitconversion;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kf6-kunitconversion}"
SRC_URI[aarch64_python3-kf6-kunitconversion.sha256sum] = "ca3c664ea27d26e5044de2de41a3faafaea6b70527990cf0fe65a73a13b6215c"

RDEPENDS:kf6-kunitconversion = " \
 glibc \
 kf6-filesystem \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kunitconversion-devel = " \
 cmake-filesystem \
 kf6-kunitconversion \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kunitconversion-doc = " \
 "
RDEPENDS:kf6-kunitconversion-html = " \
 "
RDEPENDS:python3-kf6-kunitconversion = " \
 glibc \
 kf6-kunitconversion \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 "
