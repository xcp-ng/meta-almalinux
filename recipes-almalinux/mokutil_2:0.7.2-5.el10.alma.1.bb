# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mokutil"
PE = "2"
PV = "0.7.2"
PR = "5.el10.alma.1"
PACKAGES = " \
 mokutil \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/mokutil-0.7.2-5.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dcd6d8fe54844f2a66722300d3f50354ba5efeba94c1dc0262ac0f9caad53151"

URI_x86_64_v2_mokutil = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mokutil-0.7.2-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_mokutil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mokutil}"
SRC_URI[x86_64_v2_mokutil.sha256sum] = "ad57fe8b23799f39be44c329b641ea73e844d1e9c7948eb8ec6478849b3d4964"

URI_aarch64_mokutil = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mokutil-0.7.2-5.el10.alma.1.aarch64.rpm;name=aarch64_mokutil;unpack=0"
SRC_URI:append = " ${URI_aarch64_mokutil}"
SRC_URI[aarch64_mokutil.sha256sum] = "50fde00f71ef79acdaeef636c72f3b9fb99cc861fecaf9d67ccdef4765e81809"

RDEPENDS:mokutil = " \
 efivar-libs \
 glibc \
 keyutils-libs \
 libxcrypt \
 openssl-libs \
 "
