# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Moose"
PV = "2.2207"
PR = "1.el10_0"
PACKAGES = " \
 perl-Moose \
 perl-Test-Moose \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Moose-2.2207-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b6bfe1479807a2ba9962d5b8c0f355fc7a48559460dd4dac61ea10c7d061fb02"

URI_x86_64_v2_perl-Moose = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Moose-2.2207-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Moose;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Moose}"
SRC_URI[x86_64_v2_perl-Moose.sha256sum] = "12e01f1602f017ad44c1d69e60e3f3dc0a60f43400b48b6cac6e671f675932ec"
RPROVIDES:perl-Moose:append:x86_64_v2 = " virtual/perl_Any-Moose__ge_0.40"

URI_x86_64_v2_perl-Test-Moose = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-Moose-2.2207-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Test-Moose;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-Moose}"
SRC_URI[x86_64_v2_perl-Test-Moose.sha256sum] = "f1aced6a2e7e2b384162c6987aa968a31e0b9fdabc065c16eac90b5ed338e729"

URI_aarch64_perl-Moose = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Moose-2.2207-1.el10_0.aarch64.rpm;name=aarch64_perl-Moose;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Moose}"
SRC_URI[aarch64_perl-Moose.sha256sum] = "65c3f737547e65dfe78083fc9c6564a2f7ce679df1528f41c83ce6ee7c47a42c"
RPROVIDES:perl-Moose:append:aarch64 = " virtual/perl_Any-Moose__ge_0.40"

URI_aarch64_perl-Test-Moose = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-Moose-2.2207-1.el10_0.aarch64.rpm;name=aarch64_perl-Test-Moose;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-Moose}"
SRC_URI[aarch64_perl-Test-Moose.sha256sum] = "821318dd01644401d5592ddf000ad023552e94513834b21ff5c98b10306bf637"

RDEPENDS:perl-Moose = " \
 glibc \
 perl-B \
 perl-Carp \
 perl-Class-Load \
 perl-Class-Load-XS \
 perl-Data-Dumper \
 perl-Data-OptList \
 perl-Devel-GlobalDestruction \
 perl-Devel-OverloadInfo \
 perl-Devel-PartialDump \
 perl-Devel-StackTrace \
 perl-Dist-CheckConflicts \
 perl-Eval-Closure \
 perl-Filter-Simple \
 perl-Getopt-Long \
 perl-MRO-Compat \
 perl-Module-Runtime \
 perl-Module-Runtime-Conflicts \
 perl-Moose \
 perl-Package-DeprecationManager \
 perl-Package-Stash \
 perl-Package-Stash-XS \
 perl-Params-Util \
 perl-Scalar-List-Utils \
 perl-Sub-Exporter \
 perl-Try-Tiny \
 perl-constant \
 perl-if \
 perl-interpreter \
 perl-libs \
 perl-overload \
 perl-parent \
 "
RDEPENDS:perl-Test-Moose = " \
 perl-Moose \
 perl-Scalar-List-Utils \
 perl-Sub-Exporter \
 perl-Test-Simple \
 perl-libs \
 "
