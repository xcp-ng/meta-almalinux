# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libre"
PV = "4.7.0"
PR = "1.el10_1"
PACKAGES = " \
 libre \
 libre-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libre-4.7.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7e73186a8874139c0e08e89f3be6314b2fe7fdcd58a94ad0b77aa032e112b9e3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libre-4.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libre;unpack=0"
SRC_URI[x86_64_v2_libre.sha256sum] = "d052e03fe1df6c2a529f9b02829e60e1d6ec4aee671ada048efa74c3da0762d9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libre-devel-4.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libre-devel;unpack=0"
SRC_URI[x86_64_v2_libre-devel.sha256sum] = "c5b00fbfa01946d15df13e0ed9efdc57f5bb4792289fc22bab6edf877b955a05"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libre-4.7.0-1.el10_1.aarch64.rpm;name=aarch64_libre;unpack=0"
SRC_URI[aarch64_libre.sha256sum] = "ec24b952a9dd1c8eb6265a001536d7652985161ba7f98709baad9cee6c109719"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libre-devel-4.7.0-1.el10_1.aarch64.rpm;name=aarch64_libre-devel;unpack=0"
SRC_URI[aarch64_libre-devel.sha256sum] = "2f41482fea8aff7a5370360ce409bfc4f976e590d87ba379737655442b19ec61"

RDEPENDS:libre = " \
 glibc \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:libre-devel = " \
 cmake-filesystem \
 libre \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
