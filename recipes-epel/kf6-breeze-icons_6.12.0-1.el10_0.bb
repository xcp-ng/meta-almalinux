# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-breeze-icons"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 breeze-icon-theme \
 breeze-icon-theme-rcc \
 kf6-breeze-icons \
 kf6-breeze-icons-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-breeze-icons-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3a6a93ecc16d7f8b396bd8185da412f3597a35208ca0d4aad13d7dc0f0c08c99"

URI_x86_64_v2_breeze-icon-theme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-icon-theme-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-icon-theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_breeze-icon-theme}"
SRC_URI[x86_64_v2_breeze-icon-theme.sha256sum] = "7e0d1d93071155579ff5eeeb5a787d34d24844553ada47adb423f5acfb84118d"

URI_x86_64_v2_breeze-icon-theme-rcc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-icon-theme-rcc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-icon-theme-rcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_breeze-icon-theme-rcc}"
SRC_URI[x86_64_v2_breeze-icon-theme-rcc.sha256sum] = "77f7f52dc8349ff0b4f1a3043c0aecfb64b63fb94b0e95e527afa29312e0f078"

URI_x86_64_v2_kf6-breeze-icons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-breeze-icons-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-breeze-icons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-breeze-icons}"
SRC_URI[x86_64_v2_kf6-breeze-icons.sha256sum] = "065fb8bb4bf9dfa72dbc1cbc24890b3bc1547e973196116b7877d56744fbf035"

URI_x86_64_v2_kf6-breeze-icons-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-breeze-icons-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-breeze-icons-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-breeze-icons-devel}"
SRC_URI[x86_64_v2_kf6-breeze-icons-devel.sha256sum] = "ae6b3429dde7d205910f829dcc47427c9331251b17ac50541c11bd14a9cede21"

URI_aarch64_breeze-icon-theme = "${EPEL_MIRROR}/aarch64/Packages/b/breeze-icon-theme-6.12.0-1.el10_0.noarch.rpm;name=aarch64_breeze-icon-theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_breeze-icon-theme}"
SRC_URI[aarch64_breeze-icon-theme.sha256sum] = "8d6431b5a49fdf2726455c4a17c28c51bd7a3bbdc76d74de9b517106b53e580e"

URI_aarch64_breeze-icon-theme-rcc = "${EPEL_MIRROR}/aarch64/Packages/b/breeze-icon-theme-rcc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_breeze-icon-theme-rcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_breeze-icon-theme-rcc}"
SRC_URI[aarch64_breeze-icon-theme-rcc.sha256sum] = "f51051bb8276c96bb23781c27c5746ab9bba8bc116e54ad015166a60a5ccf603"

URI_aarch64_kf6-breeze-icons = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-breeze-icons-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-breeze-icons;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-breeze-icons}"
SRC_URI[aarch64_kf6-breeze-icons.sha256sum] = "7cd5ff2c735fcdcd27d6a35adb2dbdfc711027c66ae4405e2b0a6c95c3d418fe"

URI_aarch64_kf6-breeze-icons-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-breeze-icons-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-breeze-icons-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-breeze-icons-devel}"
SRC_URI[aarch64_kf6-breeze-icons-devel.sha256sum] = "da7264499173d828bc756c10193a38debd09b22fd054c0a5f33e638e1c5d2e87"

RDEPENDS:breeze-icon-theme = " \
 almalinux-logos \
 bash \
 hicolor-icon-theme \
 "
RDEPENDS:breeze-icon-theme-rcc = " \
 "
RDEPENDS:kf6-breeze-icons = " \
 breeze-icon-theme \
 glibc \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-breeze-icons-devel = " \
 cmake-filesystem \
 kf6-breeze-icons \
 "
