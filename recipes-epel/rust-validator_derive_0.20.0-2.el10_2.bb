# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-validator_derive"
PV = "0.20.0"
PR = "2.el10_2"
PACKAGES = " \
 rust-validator_derive+default-devel \
 rust-validator_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-validator_derive-0.20.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "89b3eb1279e8b7831990cd6ae87651f8ce9a6bfe7adecd6b1b08b92bb2aa8165"

URI_x86_64_v2_rust-validator_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-validator_derive+default-devel-0.20.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-validator_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-validator_derive+default-devel}"
SRC_URI[x86_64_v2_rust-validator_derive+default-devel.sha256sum] = "b3edacc4482cb4a0e3a12a7bc8de6400ccd25318b945d56782287211f290923f"

URI_x86_64_v2_rust-validator_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-validator_derive-devel-0.20.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-validator_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-validator_derive-devel}"
SRC_URI[x86_64_v2_rust-validator_derive-devel.sha256sum] = "a19e684f950a864812ea32556bb37e47e357ce7cafaf761a61ee1f0f31f022c5"

URI_aarch64_rust-validator_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-validator_derive+default-devel-0.20.0-2.el10_2.noarch.rpm;name=aarch64_rust-validator_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-validator_derive+default-devel}"
SRC_URI[aarch64_rust-validator_derive+default-devel.sha256sum] = "d40833c16833607553123f52a19a3849f863ab571cdb3c96b580493684da233a"

URI_aarch64_rust-validator_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-validator_derive-devel-0.20.0-2.el10_2.noarch.rpm;name=aarch64_rust-validator_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-validator_derive-devel}"
SRC_URI[aarch64_rust-validator_derive-devel.sha256sum] = "a352fe28a160f3ea658181307f876e21e58d2e6bb4225cdabb86007789019395"

RDEPENDS:rust-validator_derive+default-devel = " \
 cargo \
 rust-validator_derive-devel \
 "
RDEPENDS:rust-validator_derive-devel = " \
 cargo \
 rust \
 rust-darling+default-devel \
 rust-darling+suggestions-devel \
 rust-once_cell+default-devel \
 rust-proc-macro-error2+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
