# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bcvk"
PV = "0.10.0"
PR = "1.el10_2"
PACKAGES = " \
 bcvk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bcvk-0.10.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df7cc6b6687522a7b55a477d44304db4d3294d274112147cf698aec3ce671a19"

URI_x86_64_v2_bcvk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bcvk-0.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bcvk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bcvk}"
SRC_URI[x86_64_v2_bcvk.sha256sum] = "adba14678c107e4083a06b33cfa51c2c210851c9566659d63be574a343b2c49f"

URI_aarch64_bcvk = "${EPEL_MIRROR}/aarch64/Packages/b/bcvk-0.10.0-1.el10_2.aarch64.rpm;name=aarch64_bcvk;unpack=0"
SRC_URI:append = " ${URI_aarch64_bcvk}"
SRC_URI[aarch64_bcvk.sha256sum] = "bdefedd84edb7374082d89152f998d18486d23492ce9a7b9228dc658b94fbb69"

RDEPENDS:bcvk = " \
 glibc \
 libgcc \
 "
