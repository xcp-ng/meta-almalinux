# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unic-langid-macros-impl"
PV = "0.9.6"
PR = "2.el10_2"
PACKAGES = " \
 rust-unic-langid-macros-impl+default-devel \
 rust-unic-langid-macros-impl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unic-langid-macros-impl-0.9.6-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "99097b0febffd9e91faeddf4ba552bb185c1db9c34f370311afa285a769d600f"

URI_x86_64_v2_rust-unic-langid-macros-impl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-langid-macros-impl+default-devel-0.9.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-langid-macros-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-langid-macros-impl+default-devel}"
SRC_URI[x86_64_v2_rust-unic-langid-macros-impl+default-devel.sha256sum] = "da1edcda7fad79f151acb3794578ebbcbe885eafbc726aaaa426426968468093"

URI_x86_64_v2_rust-unic-langid-macros-impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-langid-macros-impl-devel-0.9.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-langid-macros-impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-langid-macros-impl-devel}"
SRC_URI[x86_64_v2_rust-unic-langid-macros-impl-devel.sha256sum] = "78d2534651ca61b58feccc8bc25a77d3109947bbe648182d5877a7f4d3bfd76b"

URI_aarch64_rust-unic-langid-macros-impl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-langid-macros-impl+default-devel-0.9.6-2.el10_2.noarch.rpm;name=aarch64_rust-unic-langid-macros-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-langid-macros-impl+default-devel}"
SRC_URI[aarch64_rust-unic-langid-macros-impl+default-devel.sha256sum] = "e9ee5bc994e4e4a0dda7ec0e43bd7b620fc5c6740e20cb295ad0a770e31923fc"

URI_aarch64_rust-unic-langid-macros-impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-langid-macros-impl-devel-0.9.6-2.el10_2.noarch.rpm;name=aarch64_rust-unic-langid-macros-impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-langid-macros-impl-devel}"
SRC_URI[aarch64_rust-unic-langid-macros-impl-devel.sha256sum] = "3d2571caa5999f9432639f22c89a64a360e9c9e723de2bbe37f400798a3a5ec6"

RDEPENDS:rust-unic-langid-macros-impl+default-devel = " \
 cargo \
 rust-unic-langid-macros-impl-devel \
 "
RDEPENDS:rust-unic-langid-macros-impl-devel = " \
 cargo \
 rust-proc-macro-hack+default-devel \
 rust-quote+default-devel \
 rust-syn+parsing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 rust-unic-langid-impl+default-devel \
 "
