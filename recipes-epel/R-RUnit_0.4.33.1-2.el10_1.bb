# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "R-RUnit"
PV = "0.4.33.1"
PR = "2.el10_1"
PACKAGES = " \
 R-RUnit \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/R-RUnit-0.4.33.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87871e086d831c75a437deb1af513a8efeb60c3529cb478c3f7f3757f7f1c5f2"

URI_x86_64_v2_R-RUnit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-RUnit-0.4.33.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_R-RUnit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-RUnit}"
SRC_URI[x86_64_v2_R-RUnit.sha256sum] = "8aa417fa986e5e5302729e6bc791338c31c0725d73a0fc8e5b71e25cd40ab8b5"

URI_aarch64_R-RUnit = "${EPEL_MIRROR}/aarch64/Packages/r/R-RUnit-0.4.33.1-2.el10_1.noarch.rpm;name=aarch64_R-RUnit;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-RUnit}"
SRC_URI[aarch64_R-RUnit.sha256sum] = "7afb15e753c5625c0b0189d7d2e7080fe117e64767973bed437546717372b4a6"

RDEPENDS:R-RUnit = " \
 R-core \
 "
