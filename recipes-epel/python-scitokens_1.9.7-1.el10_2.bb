# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-scitokens"
PV = "1.9.7"
PR = "1.el10_2"
PACKAGES = " \
 python3-scitokens \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-scitokens-1.9.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2721dac4794d469b11f5e29e1451002656de5550a23c5b5095703caf139d887b"

URI_x86_64_v2_python3-scitokens = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-scitokens-1.9.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-scitokens;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-scitokens}"
SRC_URI[x86_64_v2_python3-scitokens.sha256sum] = "fa0627a09f3e6b85cdfb1ad777de1ae504ec2e5c7382e86227d32256c38538c8"

URI_aarch64_python3-scitokens = "${EPEL_MIRROR}/aarch64/Packages/p/python3-scitokens-1.9.7-1.el10_2.noarch.rpm;name=aarch64_python3-scitokens;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-scitokens}"
SRC_URI[aarch64_python3-scitokens.sha256sum] = "8e82bc391ef4a16add3d5b337391b6ec0c0883590701969021af33a1800bca59"

RDEPENDS:python3-scitokens = " \
 python3 \
 python3-cryptography \
 python3-jwt \
 python3-requests \
 "
