# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vaultwarden-web"
PV = "2026.6.4"
PR = "1.el10_2"
PACKAGES = " \
 vaultwarden-web \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/v/vaultwarden-web-2026.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "936ef70f9a7be452283cf87602668849447e397392525e418ca5e226caa1504b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vaultwarden-web-2026.6.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_vaultwarden-web;unpack=0"
SRC_URI[x86_64_v2_vaultwarden-web.sha256sum] = "5b225eb3bcad73f1eff9b99e1e92912126249253487b4f319ffc64ba764fe4d7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vaultwarden-web-2026.6.4-1.el10_2.noarch.rpm;name=aarch64_vaultwarden-web;unpack=0"
SRC_URI[aarch64_vaultwarden-web.sha256sum] = "6384f4dccb0a3cd4970b8b03972a9e61c0ebe4ee5bc6c2cc333b151ef92608c1"

RDEPENDS:vaultwarden-web = " \
 "
