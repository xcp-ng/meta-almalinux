# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libinput"
PV = "1.30.1"
PR = "2.el10_2"
PACKAGES = " \
 libinput \
 libinput-devel \
 libinput-utils \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libinput-1.30.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9779662202d967f07d78bf9c904644356dd240ebc9bb9979648ea9abfa6220ed"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libinput-1.30.1-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_libinput;unpack=0"
SRC_URI[x86_64_v2_libinput.sha256sum] = "15063957f45eef42384618e7af39ade2cb381ee09c1f48ded3dc044eb00aa982"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libinput-devel-1.30.1-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_libinput-devel;unpack=0"
SRC_URI[x86_64_v2_libinput-devel.sha256sum] = "c56edbbd259226f4f986fdabcc5afb27736cd0c06d96e38111e9e464002268d8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libinput-utils-1.30.1-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_libinput-utils;unpack=0"
SRC_URI[x86_64_v2_libinput-utils.sha256sum] = "6ebdb727e613467b8b481e73b9e77d08164e7aec1d51e2ac54625957ce98704f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libinput-1.30.1-2.el10_2.aarch64.rpm;name=aarch64_libinput;unpack=0"
SRC_URI[aarch64_libinput.sha256sum] = "61595cde17ebb36c96d1ed8563484c31b39f5523a6e9ed733fa43f1afbfdb528"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libinput-devel-1.30.1-2.el10_2.aarch64.rpm;name=aarch64_libinput-devel;unpack=0"
SRC_URI[aarch64_libinput-devel.sha256sum] = "4339dbeb0b4931cf1aef7ccfcacb8254d51e4be19081337c8ae1114a7581f66a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libinput-utils-1.30.1-2.el10_2.aarch64.rpm;name=aarch64_libinput-utils;unpack=0"
SRC_URI[aarch64_libinput-utils.sha256sum] = "c9561da04dff3ba38fb4aba7d8f56d94e44f6d9c2d66501f83ea16032e5f15e3"

RDEPENDS:libinput = " \
 bash \
 glibc \
 libevdev \
 libgcc \
 libwacom \
 mtdev \
 systemd-libs \
 "
RDEPENDS:libinput-devel = " \
 libinput \
 pkgconf-pkg-config \
 systemd-devel \
 "
RDEPENDS:libinput-utils = " \
 glibc \
 libevdev \
 libgcc \
 libinput \
 python3 \
 python3-libevdev \
 python3-pyudev \
 systemd-libs \
 "
