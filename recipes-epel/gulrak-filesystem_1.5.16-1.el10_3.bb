# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gulrak-filesystem"
PV = "1.5.16"
PR = "1.el10_3"
PACKAGES = " \
 gulrak-filesystem-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gulrak-filesystem-1.5.16-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b03d9d299d6e52e3027b1889876f3a7afd935d4e630f41e4d2a202009be65959"

URI_x86_64_v2_gulrak-filesystem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gulrak-filesystem-devel-1.5.16-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gulrak-filesystem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gulrak-filesystem-devel}"
SRC_URI[x86_64_v2_gulrak-filesystem-devel.sha256sum] = "b329f989de92fb20af3dd4d7cc35d54078321df0881ab8a30b32f3f16b47cfef"

URI_aarch64_gulrak-filesystem-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gulrak-filesystem-devel-1.5.16-1.el10_3.aarch64.rpm;name=aarch64_gulrak-filesystem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gulrak-filesystem-devel}"
SRC_URI[aarch64_gulrak-filesystem-devel.sha256sum] = "48d50ad46349584622b1a3ee71d007fb93918db4aeed8c7a0a5d30e6dc88b0bf"

RDEPENDS:gulrak-filesystem-devel = " \
 cmake-filesystem \
 "
