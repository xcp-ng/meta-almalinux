# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-inflate"
PV = "0.4.5"
PR = "19.el10_0"
PACKAGES = " \
 rust-inflate+default-devel \
 rust-inflate+unstable-devel \
 rust-inflate-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-inflate-0.4.5-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12efd80bac9bc00d685f075e59a5c7c6a03f89b4e0de44820eafbfe52a27b0a3"

URI_x86_64_v2_rust-inflate+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inflate+default-devel-0.4.5-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inflate+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inflate+default-devel}"
SRC_URI[x86_64_v2_rust-inflate+default-devel.sha256sum] = "2b57e56e17a8dd0d5f29914020c6e0a9554e4f871d3356c6d85ffd55900e3ee0"

URI_x86_64_v2_rust-inflate+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inflate+unstable-devel-0.4.5-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inflate+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inflate+unstable-devel}"
SRC_URI[x86_64_v2_rust-inflate+unstable-devel.sha256sum] = "38b9b281c3c698f4ec77e9b6e585160c5b78f388f621003fe5d21606c39d423b"

URI_x86_64_v2_rust-inflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inflate-devel-0.4.5-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inflate-devel}"
SRC_URI[x86_64_v2_rust-inflate-devel.sha256sum] = "17ac5b841da8c2d30aa0b2261d2d5faaae84161af196abf0fba3b3518636838c"

URI_aarch64_rust-inflate+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inflate+default-devel-0.4.5-19.el10_0.noarch.rpm;name=aarch64_rust-inflate+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inflate+default-devel}"
SRC_URI[aarch64_rust-inflate+default-devel.sha256sum] = "3504a2024fbe2ace29dc6f06078503dd447231894f5991d93150e41deb9cfdc6"

URI_aarch64_rust-inflate+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inflate+unstable-devel-0.4.5-19.el10_0.noarch.rpm;name=aarch64_rust-inflate+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inflate+unstable-devel}"
SRC_URI[aarch64_rust-inflate+unstable-devel.sha256sum] = "bef453d618ee17e07122a938337c6a2581b10af99a4fc8bf95c17091f5f15d7d"

URI_aarch64_rust-inflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inflate-devel-0.4.5-19.el10_0.noarch.rpm;name=aarch64_rust-inflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inflate-devel}"
SRC_URI[aarch64_rust-inflate-devel.sha256sum] = "db0061215f3a9d56a068e6895a14c4209e9e457a415d22e62225a14ecaea6e04"

RDEPENDS:rust-inflate+default-devel = " \
 cargo \
 rust-inflate-devel \
 "
RDEPENDS:rust-inflate+unstable-devel = " \
 cargo \
 rust-inflate-devel \
 "
RDEPENDS:rust-inflate-devel = " \
 cargo \
 rust-adler32+default-devel \
 "
