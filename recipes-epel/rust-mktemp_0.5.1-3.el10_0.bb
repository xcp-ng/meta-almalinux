# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mktemp"
PV = "0.5.1"
PR = "3.el10_0"
PACKAGES = " \
 rust-mktemp+default-devel \
 rust-mktemp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mktemp-0.5.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a11679aaab03a887929a4017a47307b0ace2e1254983317bbefbff9780184954"

URI_x86_64_v2_rust-mktemp+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mktemp+default-devel-0.5.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mktemp+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mktemp+default-devel}"
SRC_URI[x86_64_v2_rust-mktemp+default-devel.sha256sum] = "b0625ea009c06ecea3ff460bfb1208f80302b45fe3556c08d600d65ab3ebeb6b"

URI_x86_64_v2_rust-mktemp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mktemp-devel-0.5.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mktemp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mktemp-devel}"
SRC_URI[x86_64_v2_rust-mktemp-devel.sha256sum] = "d3288e5f3d292c328f3ce1e3efd3afaa3b966274ff716850e1826ee3217057ff"

URI_aarch64_rust-mktemp+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mktemp+default-devel-0.5.1-3.el10_0.noarch.rpm;name=aarch64_rust-mktemp+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mktemp+default-devel}"
SRC_URI[aarch64_rust-mktemp+default-devel.sha256sum] = "0eb891b689abd3df246ecd9c2ef9848bddfc4cde5d8ce029ae15c3c3c2ba0467"

URI_aarch64_rust-mktemp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mktemp-devel-0.5.1-3.el10_0.noarch.rpm;name=aarch64_rust-mktemp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mktemp-devel}"
SRC_URI[aarch64_rust-mktemp-devel.sha256sum] = "a7a5de71e15c421fc4e3b64aa2a14608dac321fb1de14b5c2641f114376252ea"

RDEPENDS:rust-mktemp+default-devel = " \
 cargo \
 rust-mktemp-devel \
 "
RDEPENDS:rust-mktemp-devel = " \
 cargo \
 rust-uuid+default-devel \
 rust-uuid+v4-devel \
 "
