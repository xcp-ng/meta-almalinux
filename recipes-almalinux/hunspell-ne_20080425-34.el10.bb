# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-ne"
PV = "20080425"
PR = "34.el10"
PACKAGES = " \
 hunspell-ne \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-ne-20080425-34.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b048ccccdc343fd1c9cfbdf14f21411ec2630e55065025f0d51ffbe03aaa88b"

URI_x86_64_v2_hunspell-ne = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-ne-20080425-34.el10.noarch.rpm;name=x86_64_v2_hunspell-ne;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-ne}"
SRC_URI[x86_64_v2_hunspell-ne.sha256sum] = "9dd505ebf121d5029c18e50230e5c73b26d5bd76c4f42f7bb09c7da58fc42e54"

URI_aarch64_hunspell-ne = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-ne-20080425-34.el10.noarch.rpm;name=aarch64_hunspell-ne;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-ne}"
SRC_URI[aarch64_hunspell-ne.sha256sum] = "9dd505ebf121d5029c18e50230e5c73b26d5bd76c4f42f7bb09c7da58fc42e54"

RDEPENDS:hunspell-ne = " \
 hunspell-filesystem \
 "
