# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-manilaclient"
PV = "6.0.0"
PR = "1.el10_2"
PACKAGES = " \
 python-manilaclient-doc \
 python3-manilaclient \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-manilaclient-6.0.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "dd3d3fb91ac6db4b812745f92daf30301880ae7250f78f362fc7200f87bc07b4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-manilaclient-doc-6.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-manilaclient-doc;unpack=0"
SRC_URI[x86_64_v2_python-manilaclient-doc.sha256sum] = "03564a2644b74e190023035d4a68144f3cefadc04c81a3c925a5395aa58ba638"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-manilaclient-6.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-manilaclient;unpack=0"
SRC_URI[x86_64_v2_python3-manilaclient.sha256sum] = "6611b0df181ce334cbaf9a6e0a87de040a87318915d8a63a85b9a8b9262ae55d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-manilaclient-doc-6.0.0-1.el10_2.noarch.rpm;name=aarch64_python-manilaclient-doc;unpack=0"
SRC_URI[aarch64_python-manilaclient-doc.sha256sum] = "5d0f2b77e86da8c53d315f7fe7dcf13b62e8e2702415dab480bcde6d84cf47ca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-manilaclient-6.0.0-1.el10_2.noarch.rpm;name=aarch64_python3-manilaclient;unpack=0"
SRC_URI[aarch64_python3-manilaclient.sha256sum] = "2fe7013209f371201e37661ffd39c1e5e205a83b394360a4acb0bad3d5a10a03"

RDEPENDS:python-manilaclient-doc = " \
 "
RDEPENDS:python3-manilaclient = " \
 python3 \
 python3-debtcollector \
 python3-keystoneauth1 \
 python3-osc-lib \
 python3-oslo-config \
 python3-oslo-log \
 python3-oslo-serialization \
 python3-oslo-utils \
 python3-pbr \
 python3-prettytable \
 python3-requests \
 "
