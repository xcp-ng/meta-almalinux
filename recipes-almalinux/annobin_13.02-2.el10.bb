# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "annobin"
PV = "13.02"
PR = "2.el10"
PACKAGES = " \
 annobin-annocheck \
 annobin-docs \
 annobin-libannocheck \
 annobin-plugin-clang \
 annobin-plugin-gcc \
 annobin-plugin-llvm \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/annobin-13.02-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1a7a7f8540b4beed875dc15f0342f318899347d75a5f93d41de656e5046a6394"

URI_x86_64_v2_annobin-annocheck = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/annobin-annocheck-13.02-2.el10.x86_64_v2.rpm;name=x86_64_v2_annobin-annocheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_annobin-annocheck}"
SRC_URI[x86_64_v2_annobin-annocheck.sha256sum] = "80705368d0296513c7fb82f4e85d096bd94d5d4e9a0137d241c55e0680bde261"

URI_x86_64_v2_annobin-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/annobin-docs-13.02-2.el10.noarch.rpm;name=x86_64_v2_annobin-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_annobin-docs}"
SRC_URI[x86_64_v2_annobin-docs.sha256sum] = "ee70939ca73e3d2b917591b6646ae2817efdd20a9b102963002717f95ff4e3a6"

URI_x86_64_v2_annobin-libannocheck = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/annobin-libannocheck-13.02-2.el10.x86_64_v2.rpm;name=x86_64_v2_annobin-libannocheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_annobin-libannocheck}"
SRC_URI[x86_64_v2_annobin-libannocheck.sha256sum] = "e5094711d8be078db63ddacbef67633e8de2a91025b64717e17eee7687bd3683"

URI_x86_64_v2_annobin-plugin-clang = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/annobin-plugin-clang-13.02-2.el10.x86_64_v2.rpm;name=x86_64_v2_annobin-plugin-clang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_annobin-plugin-clang}"
SRC_URI[x86_64_v2_annobin-plugin-clang.sha256sum] = "994ae998bf2a1c6d6adb8c6fb4de3ecc7a5ad9f5888c53e9df64c4e2978ec0b0"

URI_x86_64_v2_annobin-plugin-gcc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/annobin-plugin-gcc-13.02-2.el10.x86_64_v2.rpm;name=x86_64_v2_annobin-plugin-gcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_annobin-plugin-gcc}"
SRC_URI[x86_64_v2_annobin-plugin-gcc.sha256sum] = "e00131e63266104d214c37f68b25d07cc85e23b5371e147a1ef150a16bd0a24c"

URI_x86_64_v2_annobin-plugin-llvm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/annobin-plugin-llvm-13.02-2.el10.x86_64_v2.rpm;name=x86_64_v2_annobin-plugin-llvm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_annobin-plugin-llvm}"
SRC_URI[x86_64_v2_annobin-plugin-llvm.sha256sum] = "6eb4ac8543aa2cbed33e0510b95e4dd1684130c5fae90abd48dac6b454d0aeae"

URI_aarch64_annobin-annocheck = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/annobin-annocheck-13.02-2.el10.aarch64.rpm;name=aarch64_annobin-annocheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_annobin-annocheck}"
SRC_URI[aarch64_annobin-annocheck.sha256sum] = "3cf53404d170cae89b4e38941ea1effd8714b43792fdb5e025e2f1388fdaf571"

URI_aarch64_annobin-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/annobin-docs-13.02-2.el10.noarch.rpm;name=aarch64_annobin-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_annobin-docs}"
SRC_URI[aarch64_annobin-docs.sha256sum] = "ee70939ca73e3d2b917591b6646ae2817efdd20a9b102963002717f95ff4e3a6"

URI_aarch64_annobin-libannocheck = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/annobin-libannocheck-13.02-2.el10.aarch64.rpm;name=aarch64_annobin-libannocheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_annobin-libannocheck}"
SRC_URI[aarch64_annobin-libannocheck.sha256sum] = "a1e8e03038b8e7e700add6e57f56be421c48f269ea3b8394e224091fd8c22d41"

URI_aarch64_annobin-plugin-clang = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/annobin-plugin-clang-13.02-2.el10.aarch64.rpm;name=aarch64_annobin-plugin-clang;unpack=0"
SRC_URI:append = " ${URI_aarch64_annobin-plugin-clang}"
SRC_URI[aarch64_annobin-plugin-clang.sha256sum] = "cd81301921a50895bb6ec6948d44d1882a24111b19b1b4f899da3c44f3b8af12"

URI_aarch64_annobin-plugin-gcc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/annobin-plugin-gcc-13.02-2.el10.aarch64.rpm;name=aarch64_annobin-plugin-gcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_annobin-plugin-gcc}"
SRC_URI[aarch64_annobin-plugin-gcc.sha256sum] = "495eebf57087011fc3e868836dcd95f85161e7dfa88f720b263c69b7d5a0fd03"

URI_aarch64_annobin-plugin-llvm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/annobin-plugin-llvm-13.02-2.el10.aarch64.rpm;name=aarch64_annobin-plugin-llvm;unpack=0"
SRC_URI:append = " ${URI_aarch64_annobin-plugin-llvm}"
SRC_URI[aarch64_annobin-plugin-llvm.sha256sum] = "87f03b9fa9f76d647e97ad09210570333df0e9739eeb8cdf463bdc19eb71c57a"

RDEPENDS:annobin-annocheck = " \
 annobin-docs \
 cpio \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 rpm \
 rpm-libs \
 "
RDEPENDS:annobin-docs = " \
 "
RDEPENDS:annobin-libannocheck = " \
 annobin-docs \
 glibc \
 pkgconf-pkg-config \
 "
RDEPENDS:annobin-plugin-clang = " \
 annobin-docs \
 glibc \
 libgcc \
 libstdc++ \
 llvm-libs \
 "
RDEPENDS:annobin-plugin-gcc = " \
 annobin-docs \
 gcc \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:annobin-plugin-llvm = " \
 annobin-docs \
 glibc \
 libgcc \
 libstdc++ \
 llvm-libs \
 "
