# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "conmon"
PE = "3"
PV = "2.2.1"
PR = "2.el10"
PACKAGES = " \
 conmon \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/conmon-2.2.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "85c72df7fe4907657ffef0a1d48a6acf035e5632dd76b94ffe69081340ced822"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/conmon-2.2.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_conmon;unpack=0"
SRC_URI[x86_64_v2_conmon.sha256sum] = "de5913b8f11ca1f74fabf7a601933f8997742c0056a64fbedfefcfda9d6d523b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/conmon-2.2.1-2.el10.aarch64.rpm;name=aarch64_conmon;unpack=0"
SRC_URI[aarch64_conmon.sha256sum] = "16de86c7bfad000e825fc1db20b47f6beaee84a0d4330dba0c275bd99ff06d55"

RDEPENDS:conmon = " \
 glib2 \
 glibc \
 libgcc \
 libseccomp \
 systemd-libs \
 "
