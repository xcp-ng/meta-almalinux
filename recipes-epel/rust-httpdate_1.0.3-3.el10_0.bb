# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-httpdate"
PV = "1.0.3"
PR = "3.el10_0"
PACKAGES = " \
 rust-httpdate+default-devel \
 rust-httpdate-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-httpdate-1.0.3-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0ff13b939552df7589ebef2926d48c7e1aec33bdf6070405cb2327ac8934b41"

URI_x86_64_v2_rust-httpdate+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-httpdate+default-devel-1.0.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-httpdate+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-httpdate+default-devel}"
SRC_URI[x86_64_v2_rust-httpdate+default-devel.sha256sum] = "9de9a5c86aad714547c114b34a04a1badd6d8e2bc8e724f3c2a80e202438a637"

URI_x86_64_v2_rust-httpdate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-httpdate-devel-1.0.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-httpdate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-httpdate-devel}"
SRC_URI[x86_64_v2_rust-httpdate-devel.sha256sum] = "398592c21453f02f4ab75503f81ed25c9bafa1ba077a994f11f4e01e19abbaeb"

URI_aarch64_rust-httpdate+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-httpdate+default-devel-1.0.3-3.el10_0.noarch.rpm;name=aarch64_rust-httpdate+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-httpdate+default-devel}"
SRC_URI[aarch64_rust-httpdate+default-devel.sha256sum] = "034529f168fa0ef862b7ae8846823a30f68fc203f78a88fab6b06bad967e6799"

URI_aarch64_rust-httpdate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-httpdate-devel-1.0.3-3.el10_0.noarch.rpm;name=aarch64_rust-httpdate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-httpdate-devel}"
SRC_URI[aarch64_rust-httpdate-devel.sha256sum] = "6c914875702d7c0d3cd2d115e56ef53c7fac9ac666c55d49ae195512486ce56b"

RDEPENDS:rust-httpdate+default-devel = " \
 cargo \
 rust-httpdate-devel \
 "
RDEPENDS:rust-httpdate-devel = " \
 cargo \
 rust \
 "
