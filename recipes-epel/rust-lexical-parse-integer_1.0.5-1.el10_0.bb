# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lexical-parse-integer"
PV = "1.0.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-lexical-parse-integer+compact-devel \
 rust-lexical-parse-integer+default-devel \
 rust-lexical-parse-integer+format-devel \
 rust-lexical-parse-integer+lint-devel \
 rust-lexical-parse-integer+power-of-two-devel \
 rust-lexical-parse-integer+radix-devel \
 rust-lexical-parse-integer+std-devel \
 rust-lexical-parse-integer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lexical-parse-integer-1.0.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b36cde84994f8ef0d39b9e5dc921037aa4ced0d488b941b3d24486d29e42e0c"

URI_x86_64_v2_rust-lexical-parse-integer+compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-integer+compact-devel-1.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-integer+compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-integer+compact-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-integer+compact-devel.sha256sum] = "b6ac1db849ef53aee4e80255d04831bf34c146c3e8f617e8bad8c96070b2642a"

URI_x86_64_v2_rust-lexical-parse-integer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-integer+default-devel-1.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-integer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-integer+default-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-integer+default-devel.sha256sum] = "68d30a588e69742a971e46e455d4e79ff916f6cc957b9bccbfea0054d4465fdb"

URI_x86_64_v2_rust-lexical-parse-integer+format-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-integer+format-devel-1.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-integer+format-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-integer+format-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-integer+format-devel.sha256sum] = "1b3c75ee8650af355f74f13a1c45fe7faf97f6d1dac7510d94af470c9fe5d6ee"

URI_x86_64_v2_rust-lexical-parse-integer+lint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-integer+lint-devel-1.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-integer+lint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-integer+lint-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-integer+lint-devel.sha256sum] = "2f4b07e09974f5f22f2f667ff6b43edf43bd28a2a26687cb7876d3a1150675d9"

URI_x86_64_v2_rust-lexical-parse-integer+power-of-two-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-integer+power-of-two-devel-1.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-integer+power-of-two-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-integer+power-of-two-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-integer+power-of-two-devel.sha256sum] = "b30455bd36f1c40eb2ec39914dac07a239bf23d24a3be781c19b8745e0b26907"

URI_x86_64_v2_rust-lexical-parse-integer+radix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-integer+radix-devel-1.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-integer+radix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-integer+radix-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-integer+radix-devel.sha256sum] = "53a294710dc3476600edb068ac9c8322c68cddb8006a1789d628f3e28a712c8d"

URI_x86_64_v2_rust-lexical-parse-integer+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-integer+std-devel-1.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-integer+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-integer+std-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-integer+std-devel.sha256sum] = "6de85d0022a492bfc84cd311e99ac8fdfb7e84b306bf05b18e197b229f07c5fe"

URI_x86_64_v2_rust-lexical-parse-integer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-integer-devel-1.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-integer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-integer-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-integer-devel.sha256sum] = "6412f73b2b23bae007a6a07381e52830fcad784de407b52768242220ab7a8e9b"

URI_aarch64_rust-lexical-parse-integer+compact-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-integer+compact-devel-1.0.5-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-parse-integer+compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-integer+compact-devel}"
SRC_URI[aarch64_rust-lexical-parse-integer+compact-devel.sha256sum] = "63dd206554c553d3c9e742a8bc41ea64a0b146955e78ef0b1456bf1a7d3d0dbb"

URI_aarch64_rust-lexical-parse-integer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-integer+default-devel-1.0.5-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-parse-integer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-integer+default-devel}"
SRC_URI[aarch64_rust-lexical-parse-integer+default-devel.sha256sum] = "50946122a371994ce210bddb4907669c42359f5f1a3531bf604b9009bbf46340"

URI_aarch64_rust-lexical-parse-integer+format-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-integer+format-devel-1.0.5-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-parse-integer+format-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-integer+format-devel}"
SRC_URI[aarch64_rust-lexical-parse-integer+format-devel.sha256sum] = "9738a51dcccf0d241cfa8475eacc6dee3dfc60f9ef3923611280f258887ee604"

URI_aarch64_rust-lexical-parse-integer+lint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-integer+lint-devel-1.0.5-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-parse-integer+lint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-integer+lint-devel}"
SRC_URI[aarch64_rust-lexical-parse-integer+lint-devel.sha256sum] = "b3b96059298d807ddcb3fc27cf8122334867e5da7b5ab81ceabecb4b1044f042"

URI_aarch64_rust-lexical-parse-integer+power-of-two-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-integer+power-of-two-devel-1.0.5-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-parse-integer+power-of-two-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-integer+power-of-two-devel}"
SRC_URI[aarch64_rust-lexical-parse-integer+power-of-two-devel.sha256sum] = "91be918cb9dfaf00214ef3ce667cc7fd266f0c3f140cdcbfe5d0bd90ebff9417"

URI_aarch64_rust-lexical-parse-integer+radix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-integer+radix-devel-1.0.5-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-parse-integer+radix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-integer+radix-devel}"
SRC_URI[aarch64_rust-lexical-parse-integer+radix-devel.sha256sum] = "9ebabffeda0053ab2750a573ca102b87c92f5dc2c8b5ab4abcff4b13cf7aba6d"

URI_aarch64_rust-lexical-parse-integer+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-integer+std-devel-1.0.5-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-parse-integer+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-integer+std-devel}"
SRC_URI[aarch64_rust-lexical-parse-integer+std-devel.sha256sum] = "5f5b08ed8f827fe97379bb44a86690986980e5b3b8009b834490b3f522af9732"

URI_aarch64_rust-lexical-parse-integer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-integer-devel-1.0.5-1.el10_0.noarch.rpm;name=aarch64_rust-lexical-parse-integer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-integer-devel}"
SRC_URI[aarch64_rust-lexical-parse-integer-devel.sha256sum] = "6bfff90fa6d5127e1f2acb86fd8da026d93949dfe12f688875975c71649c99c4"

RDEPENDS:rust-lexical-parse-integer+compact-devel = " \
 cargo \
 rust-lexical-parse-integer-devel \
 rust-lexical-util+compact-devel \
 "
RDEPENDS:rust-lexical-parse-integer+default-devel = " \
 cargo \
 rust-lexical-parse-integer+std-devel \
 rust-lexical-parse-integer-devel \
 "
RDEPENDS:rust-lexical-parse-integer+format-devel = " \
 cargo \
 rust-lexical-parse-integer-devel \
 rust-lexical-util+format-devel \
 "
RDEPENDS:rust-lexical-parse-integer+lint-devel = " \
 cargo \
 rust-lexical-parse-integer-devel \
 rust-lexical-util+lint-devel \
 "
RDEPENDS:rust-lexical-parse-integer+power-of-two-devel = " \
 cargo \
 rust-lexical-parse-integer-devel \
 rust-lexical-util+power-of-two-devel \
 "
RDEPENDS:rust-lexical-parse-integer+radix-devel = " \
 cargo \
 rust-lexical-parse-integer+power-of-two-devel \
 rust-lexical-parse-integer-devel \
 rust-lexical-util+radix-devel \
 "
RDEPENDS:rust-lexical-parse-integer+std-devel = " \
 cargo \
 rust-lexical-parse-integer-devel \
 rust-lexical-util+std-devel \
 "
RDEPENDS:rust-lexical-parse-integer-devel = " \
 cargo \
 rust \
 rust-lexical-util+parse-integers-devel \
 rust-lexical-util-devel \
 rust-static_assertions+default-devel \
 "
