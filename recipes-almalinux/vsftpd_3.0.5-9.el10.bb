# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vsftpd"
PV = "3.0.5"
PR = "9.el10"
PACKAGES = " \
 vsftpd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/vsftpd-3.0.5-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f4fb01ba935ed1fd3c039f4bbea6d2d7e03f751e1bf2faf510337043ebaf8b2c"

URI_x86_64_v2_vsftpd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vsftpd-3.0.5-9.el10.x86_64_v2.rpm;name=x86_64_v2_vsftpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vsftpd}"
SRC_URI[x86_64_v2_vsftpd.sha256sum] = "77ed2e7c9d657e1ae23fb090badfeb0e78db32a5e67eda992dedb8542a94147e"

URI_aarch64_vsftpd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vsftpd-3.0.5-9.el10.aarch64.rpm;name=aarch64_vsftpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_vsftpd}"
SRC_URI[aarch64_vsftpd.sha256sum] = "ab53e954e8392d772d7b21d0dcc97f0614f70426028b85bca2037a73f3c71edf"

RDEPENDS:vsftpd = " \
 bash \
 glibc \
 libcap \
 logrotate \
 openssl-libs \
 pam-libs \
 "
