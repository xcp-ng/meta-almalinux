# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-markup5ever"
PV = "0.35.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-markup5ever+default-devel \
 rust-markup5ever-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-markup5ever-0.35.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff7439f04fb2e3c3c917ee7b7fbeac5e2c7b7320b2f4d98dc8faa3fc52ad08f1"

URI_x86_64_v2_rust-markup5ever+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-markup5ever+default-devel-0.35.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-markup5ever+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-markup5ever+default-devel}"
SRC_URI[x86_64_v2_rust-markup5ever+default-devel.sha256sum] = "ef5873bc5bf42d03f9f66ebd451baadcd03152477398329062c3ab970059b3fb"

URI_x86_64_v2_rust-markup5ever-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-markup5ever-devel-0.35.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-markup5ever-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-markup5ever-devel}"
SRC_URI[x86_64_v2_rust-markup5ever-devel.sha256sum] = "2748cde1c588de30285ad9bcebf1faa6fc159c46c4c2eacb89cfb283325f4eda"

URI_aarch64_rust-markup5ever+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-markup5ever+default-devel-0.35.0-1.el10_2.noarch.rpm;name=aarch64_rust-markup5ever+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-markup5ever+default-devel}"
SRC_URI[aarch64_rust-markup5ever+default-devel.sha256sum] = "0561c2d2ad04f662bf4d487951173018393076ae08731e9a8e3256de34666f92"

URI_aarch64_rust-markup5ever-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-markup5ever-devel-0.35.0-1.el10_2.noarch.rpm;name=aarch64_rust-markup5ever-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-markup5ever-devel}"
SRC_URI[aarch64_rust-markup5ever-devel.sha256sum] = "ef31c38111a354da4c957b53a274f6bd68536bde12eaa4cb1de9b5ae375b199a"

RDEPENDS:rust-markup5ever+default-devel = " \
 cargo \
 rust-markup5ever-devel \
 "
RDEPENDS:rust-markup5ever-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-tendril+default-devel \
 rust-web_atoms+default-devel \
 "
