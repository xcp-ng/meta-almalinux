# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hashbrown"
PV = "0.17.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-hashbrown+allocator-api2-devel \
 rust-hashbrown+default-devel \
 rust-hashbrown+default-hasher-devel \
 rust-hashbrown+equivalent-devel \
 rust-hashbrown+inline-more-devel \
 rust-hashbrown+raw-entry-devel \
 rust-hashbrown+rayon-devel \
 rust-hashbrown+serde-devel \
 rust-hashbrown-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hashbrown-0.17.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c364785aa18f6f278329c08e8a71a7fcef92c1f8d4d8139ead17c3209ec46e7f"

URI_x86_64_v2_rust-hashbrown+allocator-api2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+allocator-api2-devel-0.17.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+allocator-api2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown+allocator-api2-devel}"
SRC_URI[x86_64_v2_rust-hashbrown+allocator-api2-devel.sha256sum] = "8464ea3dbc15246b8bfcee41a588aed555e9eda0d603ec1d785364470e6e616f"

URI_x86_64_v2_rust-hashbrown+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+default-devel-0.17.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown+default-devel}"
SRC_URI[x86_64_v2_rust-hashbrown+default-devel.sha256sum] = "7770fd40f0eedd7cf159e779440d7c7ae7a56f96df135d4e917d89b52bfc8215"

URI_x86_64_v2_rust-hashbrown+default-hasher-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+default-hasher-devel-0.17.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+default-hasher-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown+default-hasher-devel}"
SRC_URI[x86_64_v2_rust-hashbrown+default-hasher-devel.sha256sum] = "0ddb2d710ed867785bd7adf8e8b81c56f9486e7d8652756573695337db733dcc"
RPROVIDES:rust-hashbrown+default-hasher-devel:x86_64_v2 = "virtual/crate_hashbrown/default-hasher__ge_0.15.0_with_crate_hashbrown/default-hasher__lt_0.18.0~"

URI_x86_64_v2_rust-hashbrown+equivalent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+equivalent-devel-0.17.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+equivalent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown+equivalent-devel}"
SRC_URI[x86_64_v2_rust-hashbrown+equivalent-devel.sha256sum] = "c619ec6fc95e9ee74f6b08d033cccc52eaddcc95b97ecb4fd99dcd1b797a0a4f"

URI_x86_64_v2_rust-hashbrown+inline-more-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+inline-more-devel-0.17.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+inline-more-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown+inline-more-devel}"
SRC_URI[x86_64_v2_rust-hashbrown+inline-more-devel.sha256sum] = "5808eeefd9e97cfeec0a9ab289d87bb373865c7cd354b4a2922cf2fdffe97ad0"
RPROVIDES:rust-hashbrown+inline-more-devel:x86_64_v2 = "virtual/crate_hashbrown/inline-more__ge_0.15.0_with_crate_hashbrown/inline-more__lt_0.18.0~"

URI_x86_64_v2_rust-hashbrown+raw-entry-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+raw-entry-devel-0.17.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+raw-entry-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown+raw-entry-devel}"
SRC_URI[x86_64_v2_rust-hashbrown+raw-entry-devel.sha256sum] = "b3db368bd66c10955254bf53dfd527cc0cbd4f7f86211ea40414eb24789dee12"

URI_x86_64_v2_rust-hashbrown+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+rayon-devel-0.17.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown+rayon-devel}"
SRC_URI[x86_64_v2_rust-hashbrown+rayon-devel.sha256sum] = "2d732347ed24c31c5c49bb509a1d19a35e41926f8889d97c9ab6cdb13d0825f9"

URI_x86_64_v2_rust-hashbrown+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+serde-devel-0.17.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown+serde-devel}"
SRC_URI[x86_64_v2_rust-hashbrown+serde-devel.sha256sum] = "08f5ff3c0685819f0ef00e02152b4e2b43ac3f9b670f5e6c3ffb74cf3e4b480f"

URI_x86_64_v2_rust-hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown-devel-0.17.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown-devel}"
SRC_URI[x86_64_v2_rust-hashbrown-devel.sha256sum] = "46048319acacb66e7edfc4dfd54e1bf6ea8b380aa048e1ec731d8a3e6d1b7b72"
RPROVIDES:rust-hashbrown-devel:x86_64_v2 = "virtual/crate_hashbrown__ge_0.15.0_with_crate_hashbrown__lt_0.18.0~"

URI_aarch64_rust-hashbrown+allocator-api2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+allocator-api2-devel-0.17.0-1.el10_3.noarch.rpm;name=aarch64_rust-hashbrown+allocator-api2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown+allocator-api2-devel}"
SRC_URI[aarch64_rust-hashbrown+allocator-api2-devel.sha256sum] = "94a95a38df2a5e27482bbc7bf62d36bf10e9a13fd21143e68b2d5eb2c6531143"

URI_aarch64_rust-hashbrown+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+default-devel-0.17.0-1.el10_3.noarch.rpm;name=aarch64_rust-hashbrown+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown+default-devel}"
SRC_URI[aarch64_rust-hashbrown+default-devel.sha256sum] = "652bf69ba653b6be471cee9e896503ff03c22c8a6735f65cee89b4635f378ec9"

URI_aarch64_rust-hashbrown+default-hasher-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+default-hasher-devel-0.17.0-1.el10_3.noarch.rpm;name=aarch64_rust-hashbrown+default-hasher-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown+default-hasher-devel}"
SRC_URI[aarch64_rust-hashbrown+default-hasher-devel.sha256sum] = "7d795a821a1756aa19b4629fff677c4f7cae82dcdcbff629572384066e53ebdb"
RPROVIDES:rust-hashbrown+default-hasher-devel:aarch64 = "virtual/crate_hashbrown/default-hasher__ge_0.15.0_with_crate_hashbrown/default-hasher__lt_0.18.0~"

URI_aarch64_rust-hashbrown+equivalent-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+equivalent-devel-0.17.0-1.el10_3.noarch.rpm;name=aarch64_rust-hashbrown+equivalent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown+equivalent-devel}"
SRC_URI[aarch64_rust-hashbrown+equivalent-devel.sha256sum] = "c60d88e58396e9fc65401d0e8be959e27527a704a7e25632875fa8d9458ac7e3"

URI_aarch64_rust-hashbrown+inline-more-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+inline-more-devel-0.17.0-1.el10_3.noarch.rpm;name=aarch64_rust-hashbrown+inline-more-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown+inline-more-devel}"
SRC_URI[aarch64_rust-hashbrown+inline-more-devel.sha256sum] = "d6d4eca649acf482d02921c0134becc56799cbd0d0377bbd3d4f5151b35c9cbf"
RPROVIDES:rust-hashbrown+inline-more-devel:aarch64 = "virtual/crate_hashbrown/inline-more__ge_0.15.0_with_crate_hashbrown/inline-more__lt_0.18.0~"

URI_aarch64_rust-hashbrown+raw-entry-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+raw-entry-devel-0.17.0-1.el10_3.noarch.rpm;name=aarch64_rust-hashbrown+raw-entry-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown+raw-entry-devel}"
SRC_URI[aarch64_rust-hashbrown+raw-entry-devel.sha256sum] = "571c9874fd311369004f760ebbf6b9c7cbe17712c39991834426d5683823e6aa"

URI_aarch64_rust-hashbrown+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+rayon-devel-0.17.0-1.el10_3.noarch.rpm;name=aarch64_rust-hashbrown+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown+rayon-devel}"
SRC_URI[aarch64_rust-hashbrown+rayon-devel.sha256sum] = "ae55ee8b4063aa8274dc5d68d49c4a200e7137826bafbb066e44c9d54e5aa879"

URI_aarch64_rust-hashbrown+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+serde-devel-0.17.0-1.el10_3.noarch.rpm;name=aarch64_rust-hashbrown+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown+serde-devel}"
SRC_URI[aarch64_rust-hashbrown+serde-devel.sha256sum] = "afa376415784c6c07be0a799383af00a9bd78c8792b99bf62cf4357feb4ba189"

URI_aarch64_rust-hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown-devel-0.17.0-1.el10_3.noarch.rpm;name=aarch64_rust-hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown-devel}"
SRC_URI[aarch64_rust-hashbrown-devel.sha256sum] = "5544ca6253ea332c9bda6f50a76dc0a2c0b5e21d502f9bcd013a151b45e0bff9"
RPROVIDES:rust-hashbrown-devel:aarch64 = "virtual/crate_hashbrown__ge_0.15.0_with_crate_hashbrown__lt_0.18.0~"

RDEPENDS:rust-hashbrown+allocator-api2-devel = " \
 cargo \
 rust-allocator-api2+alloc-devel \
 rust-allocator-api2-devel \
 rust-hashbrown-devel \
 "
RDEPENDS:rust-hashbrown+default-devel = " \
 cargo \
 rust-hashbrown+allocator-api2-devel \
 rust-hashbrown+default-hasher-devel \
 rust-hashbrown+equivalent-devel \
 rust-hashbrown+inline-more-devel \
 rust-hashbrown+raw-entry-devel \
 rust-hashbrown-devel \
 "
RDEPENDS:rust-hashbrown+default-hasher-devel = " \
 cargo \
 rust-foldhash-devel \
 rust-hashbrown-devel \
 "
RDEPENDS:rust-hashbrown+equivalent-devel = " \
 cargo \
 rust-equivalent-devel \
 rust-hashbrown-devel \
 "
RDEPENDS:rust-hashbrown+inline-more-devel = " \
 cargo \
 rust-hashbrown-devel \
 "
RDEPENDS:rust-hashbrown+raw-entry-devel = " \
 cargo \
 rust-hashbrown-devel \
 "
RDEPENDS:rust-hashbrown+rayon-devel = " \
 cargo \
 rust-hashbrown-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-hashbrown+serde-devel = " \
 cargo \
 rust-hashbrown-devel \
 rust-serde-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-hashbrown-devel = " \
 cargo \
 rust \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_hashbrown/default-hasher__ge_0.15.0_with_crate_hashbrown/default-hasher__lt_0.18.0~ rpm/virtual/crate_hashbrown/inline-more__ge_0.15.0_with_crate_hashbrown/inline-more__lt_0.18.0~ rpm/virtual/crate_hashbrown__ge_0.15.0_with_crate_hashbrown__lt_0.18.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_hashbrown/default-hasher__ge_0.15.0_with_crate_hashbrown/default-hasher__lt_0.18.0~ rpm/virtual/crate_hashbrown/inline-more__ge_0.15.0_with_crate_hashbrown/inline-more__lt_0.18.0~ rpm/virtual/crate_hashbrown__ge_0.15.0_with_crate_hashbrown__lt_0.18.0~"
