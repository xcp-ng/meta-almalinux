# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtserialport"
PV = "6.8.1"
PR = "2.el10"
PACKAGES = " \
 qt6-qtserialport \
 qt6-qtserialport-devel \
 qt6-qtserialport-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtserialport-6.8.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "16766148c0d29059525fab776b054e848a8bc0945c39bbf8ed58a2de05d90e05"

URI_x86_64_v2_qt6-qtserialport = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtserialport-6.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtserialport;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtserialport}"
SRC_URI[x86_64_v2_qt6-qtserialport.sha256sum] = "bc7c0c940acb28293e22327127d0f8e4096ae496f119af771258904ebdc945a2"

URI_x86_64_v2_qt6-qtserialport-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtserialport-devel-6.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtserialport-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtserialport-devel}"
SRC_URI[x86_64_v2_qt6-qtserialport-devel.sha256sum] = "b688b9d236cedb90d9cf844cea5b3cc2dc9d81999f0b098ade81b45099ac64ba"

URI_x86_64_v2_qt6-qtserialport-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtserialport-examples-6.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtserialport-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtserialport-examples}"
SRC_URI[x86_64_v2_qt6-qtserialport-examples.sha256sum] = "813e1a90e04247eb53b62e582dfaed6cf932843be0ada8d5692478b54fb3fc88"

URI_aarch64_qt6-qtserialport = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtserialport-6.8.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtserialport;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtserialport}"
SRC_URI[aarch64_qt6-qtserialport.sha256sum] = "18e8656b3260b17143d40613f53bfbfa0d50cf59d0e0f31f3fcb1c7f124bb9fa"

URI_aarch64_qt6-qtserialport-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtserialport-devel-6.8.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtserialport-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtserialport-devel}"
SRC_URI[aarch64_qt6-qtserialport-devel.sha256sum] = "38e318fb15110c40290bb8b27062368616cdba6503098d939ae613f8632acfc2"

URI_aarch64_qt6-qtserialport-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtserialport-examples-6.8.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtserialport-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtserialport-examples}"
SRC_URI[aarch64_qt6-qtserialport-examples.sha256sum] = "83858460089db7dd09eb95a10457738b4803e28fbed58423b540c68cd93504ae"

RDEPENDS:qt6-qtserialport = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 systemd-libs \
 "
RDEPENDS:qt6-qtserialport-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtserialport \
 "
RDEPENDS:qt6-qtserialport-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtserialport \
 "
