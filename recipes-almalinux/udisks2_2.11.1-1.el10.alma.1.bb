# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "udisks2"
PV = "2.11.1"
PR = "1.el10.alma.1"
PACKAGES = " \
 libudisks2 \
 libudisks2-devel \
 udisks2 \
 udisks2-btrfs \
 udisks2-iscsi \
 udisks2-lsm \
 udisks2-lvm2 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/udisks2-2.11.1-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0d525649894b777851cc6981181686199ed0a98add05cce5a2309a2508da9047"

URI_x86_64_v2_libudisks2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libudisks2-2.11.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libudisks2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libudisks2}"
SRC_URI[x86_64_v2_libudisks2.sha256sum] = "4d18820e96f115ea01d20c1706c4dead114534bb06bdaa73d1834f355dfb399e"

URI_x86_64_v2_libudisks2-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libudisks2-devel-2.11.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libudisks2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libudisks2-devel}"
SRC_URI[x86_64_v2_libudisks2-devel.sha256sum] = "eb34301894bac95059902c16a32d77724f487d156d559a70ac0d6d98a57374d6"

URI_x86_64_v2_udisks2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/udisks2-2.11.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_udisks2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_udisks2}"
SRC_URI[x86_64_v2_udisks2.sha256sum] = "a664b1afc0d1d7accc5668b7784dc80e9f19614886c885f03d821cf4f7caef86"

URI_x86_64_v2_udisks2-btrfs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/udisks2-btrfs-2.11.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_udisks2-btrfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_udisks2-btrfs}"
SRC_URI[x86_64_v2_udisks2-btrfs.sha256sum] = "145ccb030296f458ad7f0399d85e35cd469045a88f175ac240bd90749e73f210"

URI_x86_64_v2_udisks2-iscsi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/udisks2-iscsi-2.11.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_udisks2-iscsi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_udisks2-iscsi}"
SRC_URI[x86_64_v2_udisks2-iscsi.sha256sum] = "6556ee31434d7e01d5a8819cd5e7e4d4148b9c07ac3cae4100eb78b4952427f1"

URI_x86_64_v2_udisks2-lsm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/udisks2-lsm-2.11.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_udisks2-lsm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_udisks2-lsm}"
SRC_URI[x86_64_v2_udisks2-lsm.sha256sum] = "189ffc506a52d6e5d874a662b947b952d012a6174a1a62c9a87a9a955a77f1e5"

URI_x86_64_v2_udisks2-lvm2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/udisks2-lvm2-2.11.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_udisks2-lvm2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_udisks2-lvm2}"
SRC_URI[x86_64_v2_udisks2-lvm2.sha256sum] = "6fe836d9814b23c8dc3ac7364eabf5b7870c827a88696ccbc9fe7270ef9ab252"

URI_aarch64_libudisks2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libudisks2-2.11.1-1.el10.alma.1.aarch64.rpm;name=aarch64_libudisks2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libudisks2}"
SRC_URI[aarch64_libudisks2.sha256sum] = "15163d57528490a4059ae4c33a28663eea17e8bfedc4e46cb12837f9a654974b"

URI_aarch64_libudisks2-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libudisks2-devel-2.11.1-1.el10.alma.1.aarch64.rpm;name=aarch64_libudisks2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libudisks2-devel}"
SRC_URI[aarch64_libudisks2-devel.sha256sum] = "7e701f472c3114f4a4cd8b1c5d6229f6a173912733afeb016e66597761d2272b"

URI_aarch64_udisks2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/udisks2-2.11.1-1.el10.alma.1.aarch64.rpm;name=aarch64_udisks2;unpack=0"
SRC_URI:append = " ${URI_aarch64_udisks2}"
SRC_URI[aarch64_udisks2.sha256sum] = "d690e2801458165c9eb0f1e5ac516bb1dbf95f61b9fbea243b4484a78f8637e0"

URI_aarch64_udisks2-btrfs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/udisks2-btrfs-2.11.1-1.el10.alma.1.aarch64.rpm;name=aarch64_udisks2-btrfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_udisks2-btrfs}"
SRC_URI[aarch64_udisks2-btrfs.sha256sum] = "53526e812443ebc0b029a81504cf8c661e741ef5c6c9659fc2cb954b5bba9911"

URI_aarch64_udisks2-iscsi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/udisks2-iscsi-2.11.1-1.el10.alma.1.aarch64.rpm;name=aarch64_udisks2-iscsi;unpack=0"
SRC_URI:append = " ${URI_aarch64_udisks2-iscsi}"
SRC_URI[aarch64_udisks2-iscsi.sha256sum] = "876244935e2523c0a3194b83ff17bc5712fc659b3bcc0ae865d168fd8205e9eb"

URI_aarch64_udisks2-lsm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/udisks2-lsm-2.11.1-1.el10.alma.1.aarch64.rpm;name=aarch64_udisks2-lsm;unpack=0"
SRC_URI:append = " ${URI_aarch64_udisks2-lsm}"
SRC_URI[aarch64_udisks2-lsm.sha256sum] = "28d31cd7f94a01a3c842a302ce4130d9c3b3e3a64f5010231ce9c5f78822d9a3"

URI_aarch64_udisks2-lvm2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/udisks2-lvm2-2.11.1-1.el10.alma.1.aarch64.rpm;name=aarch64_udisks2-lvm2;unpack=0"
SRC_URI:append = " ${URI_aarch64_udisks2-lvm2}"
SRC_URI[aarch64_udisks2-lvm2.sha256sum] = "4f6024d6d8ed7ad6e1ccff150c3d0ac9e70475d95a98dabdeff9771a97ae4feb"

RDEPENDS:libudisks2 = " \
 glib2 \
 glibc \
 "
RDEPENDS:libudisks2-devel = " \
 glib2-devel \
 libudisks2 \
 libudisks2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:udisks2 = " \
 bash \
 dbus \
 glib2 \
 glibc \
 libacl \
 libblkid \
 libblockdev \
 libblockdev-crypto \
 libblockdev-fs \
 libblockdev-loop \
 libblockdev-mdraid \
 libblockdev-nvme \
 libblockdev-part \
 libblockdev-smart \
 libblockdev-swap \
 libblockdev-utils \
 libgcc \
 libgudev \
 libmount \
 libudisks2 \
 libuuid \
 polkit \
 polkit-libs \
 systemd-libs \
 systemd-udev \
 util-linux \
 "
RDEPENDS:udisks2-btrfs = " \
 glib2 \
 glibc \
 libacl \
 libblkid \
 libblockdev \
 libblockdev-btrfs \
 libblockdev-utils \
 libgcc \
 libgudev \
 libmount \
 libudisks2 \
 libuuid \
 polkit-libs \
 systemd-libs \
 "
RDEPENDS:udisks2-iscsi = " \
 glib2 \
 glibc \
 iscsi-initiator-utils \
 libacl \
 libblkid \
 libblockdev \
 libblockdev-utils \
 libgcc \
 libgudev \
 libmount \
 libudisks2 \
 libuuid \
 polkit-libs \
 systemd-libs \
 "
RDEPENDS:udisks2-lsm = " \
 glib2 \
 glibc \
 libacl \
 libblkid \
 libblockdev \
 libblockdev-utils \
 libconfig \
 libgcc \
 libgudev \
 libmount \
 libstoragemgmt \
 libudisks2 \
 libuuid \
 polkit-libs \
 systemd-libs \
 "
RDEPENDS:udisks2-lvm2 = " \
 glib2 \
 glibc \
 libacl \
 libblkid \
 libblockdev \
 libblockdev-lvm \
 libblockdev-utils \
 libgcc \
 libgudev \
 libmount \
 libudisks2 \
 libuuid \
 lvm2 \
 polkit-libs \
 systemd-libs \
 "
