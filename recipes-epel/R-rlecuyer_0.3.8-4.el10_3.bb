# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "R-rlecuyer"
PV = "0.3.8"
PR = "4.el10_3"
PACKAGES = " \
 R-rlecuyer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/R-rlecuyer-0.3.8-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb5417f8e1ef18e8c71072b376d8fc7efd7e560c167d213c8d6750c6f3d6f936"

URI_x86_64_v2_R-rlecuyer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-rlecuyer-0.3.8-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-rlecuyer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-rlecuyer}"
SRC_URI[x86_64_v2_R-rlecuyer.sha256sum] = "2c4f41d3993d637a04a00da9c4d749744e0de751bde6f2c470bc8d8019d00d28"

URI_aarch64_R-rlecuyer = "${EPEL_MIRROR}/aarch64/Packages/r/R-rlecuyer-0.3.8-4.el10_3.aarch64.rpm;name=aarch64_R-rlecuyer;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-rlecuyer}"
SRC_URI[aarch64_R-rlecuyer.sha256sum] = "3f3533862c1675a5d3516d20a5c9fd4112b79c2b445a31185bda169872a1f3ea"

RDEPENDS:R-rlecuyer = " \
 R-core \
 glibc \
 "
