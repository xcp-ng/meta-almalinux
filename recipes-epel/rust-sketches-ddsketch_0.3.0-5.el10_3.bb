# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sketches-ddsketch"
PV = "0.3.0"
PR = "5.el10_3"
PACKAGES = " \
 rust-sketches-ddsketch+default-devel \
 rust-sketches-ddsketch+serde-devel \
 rust-sketches-ddsketch+use_serde-devel \
 rust-sketches-ddsketch-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sketches-ddsketch-0.3.0-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e8f884fef4f28d7ca0885e42c7b94f4159352b8f7308c21335addb1d7ac034f"

URI_x86_64_v2_rust-sketches-ddsketch+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sketches-ddsketch+default-devel-0.3.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sketches-ddsketch+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sketches-ddsketch+default-devel}"
SRC_URI[x86_64_v2_rust-sketches-ddsketch+default-devel.sha256sum] = "b3591e580e91cd1719e953b5d85234f75b6e6ce75f3c1b66568d8ab3f9d61176"

URI_x86_64_v2_rust-sketches-ddsketch+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sketches-ddsketch+serde-devel-0.3.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sketches-ddsketch+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sketches-ddsketch+serde-devel}"
SRC_URI[x86_64_v2_rust-sketches-ddsketch+serde-devel.sha256sum] = "15757baa129e55014cce8630bbf810915d2c7e73ac2ceecc1db1bd02f1007f7a"

URI_x86_64_v2_rust-sketches-ddsketch+use_serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sketches-ddsketch+use_serde-devel-0.3.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sketches-ddsketch+use_serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sketches-ddsketch+use_serde-devel}"
SRC_URI[x86_64_v2_rust-sketches-ddsketch+use_serde-devel.sha256sum] = "b520ef9869023c271965b51d116dabb0ed6a5599888c2998231f27cbe45bd1a7"

URI_x86_64_v2_rust-sketches-ddsketch-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sketches-ddsketch-devel-0.3.0-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sketches-ddsketch-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sketches-ddsketch-devel}"
SRC_URI[x86_64_v2_rust-sketches-ddsketch-devel.sha256sum] = "60e798dda0a9b503a22462d9d8af18e66f616a1b1d48063fb59279802e8f15bb"

URI_aarch64_rust-sketches-ddsketch+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sketches-ddsketch+default-devel-0.3.0-5.el10_3.noarch.rpm;name=aarch64_rust-sketches-ddsketch+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sketches-ddsketch+default-devel}"
SRC_URI[aarch64_rust-sketches-ddsketch+default-devel.sha256sum] = "e16bf7a3256d4eb474dae96d967592586164c3c77116e77c2db03e55ba477ec9"

URI_aarch64_rust-sketches-ddsketch+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sketches-ddsketch+serde-devel-0.3.0-5.el10_3.noarch.rpm;name=aarch64_rust-sketches-ddsketch+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sketches-ddsketch+serde-devel}"
SRC_URI[aarch64_rust-sketches-ddsketch+serde-devel.sha256sum] = "3c6665888f466254e97221d98d8f5a08f9ca15dc5ccd12a7c9cb3e5e662b3ba9"

URI_aarch64_rust-sketches-ddsketch+use_serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sketches-ddsketch+use_serde-devel-0.3.0-5.el10_3.noarch.rpm;name=aarch64_rust-sketches-ddsketch+use_serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sketches-ddsketch+use_serde-devel}"
SRC_URI[aarch64_rust-sketches-ddsketch+use_serde-devel.sha256sum] = "c9b9a324e366947a53129b73d80cfad411d0f1ba324a21aca55f27acf2cf34e9"

URI_aarch64_rust-sketches-ddsketch-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sketches-ddsketch-devel-0.3.0-5.el10_3.noarch.rpm;name=aarch64_rust-sketches-ddsketch-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sketches-ddsketch-devel}"
SRC_URI[aarch64_rust-sketches-ddsketch-devel.sha256sum] = "3e3cac0bb58395dd8fc2183c47d7e444f74b45ff6399f3838d938a617f453f60"

RDEPENDS:rust-sketches-ddsketch+default-devel = " \
 cargo \
 rust-sketches-ddsketch-devel \
 "
RDEPENDS:rust-sketches-ddsketch+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+serde_derive-devel \
 rust-sketches-ddsketch-devel \
 "
RDEPENDS:rust-sketches-ddsketch+use_serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+serde_derive-devel \
 rust-sketches-ddsketch+serde-devel \
 rust-sketches-ddsketch-devel \
 "
RDEPENDS:rust-sketches-ddsketch-devel = " \
 cargo \
 "
