# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plantuml"
PE = "1"
PV = "1.2025.2"
PR = "1.el10_0"
PACKAGES = " \
 plantuml \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plantuml-1.2025.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e94ae64b70c05f1b3ba702d22a3a7316f4f0a5d593536f4e1e9c03b9c4d1d2aa"

URI_x86_64_v2_plantuml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plantuml-1.2025.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_plantuml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plantuml}"
SRC_URI[x86_64_v2_plantuml.sha256sum] = "1c83dda8a216b3686790bde8beb88afff90656c6493f06c4f2584ac6c55cada2"

URI_aarch64_plantuml = "${EPEL_MIRROR}/aarch64/Packages/p/plantuml-1.2025.2-1.el10_0.noarch.rpm;name=aarch64_plantuml;unpack=0"
SRC_URI:append = " ${URI_aarch64_plantuml}"
SRC_URI[aarch64_plantuml.sha256sum] = "89c5a81e8ceff864e326481fc266c9c6e83126ad5d142fb4b30849137dd2b242"

RDEPENDS:plantuml = " \
 bash \
 java-21-openjdk \
 javapackages-filesystem \
 javapackages-tools \
 "
