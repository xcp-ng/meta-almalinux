# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "conmon"
PE = "3"
PV = "2.1.12"
PR = "4.el10"
PACKAGES = " \
 conmon \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/conmon-2.1.12-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2fee73959c5b7cc29a603a72d8c5bfdb04b4b0445c7ed2283709ba549e77c7aa"

URI_x86_64_v2_conmon = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/conmon-2.1.12-4.el10.x86_64_v2.rpm;name=x86_64_v2_conmon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_conmon}"
SRC_URI[x86_64_v2_conmon.sha256sum] = "177cf1848b3ce1c18a4e18d8db537a15496693fa08d2856c6f77136ee8dc92ae"

URI_aarch64_conmon = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/conmon-2.1.12-4.el10.aarch64.rpm;name=aarch64_conmon;unpack=0"
SRC_URI:append = " ${URI_aarch64_conmon}"
SRC_URI[aarch64_conmon.sha256sum] = "afcb97782f62f452ffb96df0902f442ad0480500f5cffe7c458810d1a54c659d"

RDEPENDS:conmon = " \
 glib2 \
 glibc \
 libgcc \
 libseccomp \
 systemd-libs \
 "
