# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-mixin"
PV = "0.3.2"
PR = "1.el10_3"
PACKAGES = " \
 python3-colcon-mixin \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-colcon-mixin-0.3.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f8258fad2c6737ed2cf62c526ff4e012c0b78b887c5a76a5357ae5384b9b7372"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-mixin-0.3.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-mixin;unpack=0"
SRC_URI[x86_64_v2_python3-colcon-mixin.sha256sum] = "699bc04587548bd26895500fa942ede958203e3418d5a48923132807f0ad45bc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-mixin-0.3.2-1.el10_3.noarch.rpm;name=aarch64_python3-colcon-mixin;unpack=0"
SRC_URI[aarch64_python3-colcon-mixin.sha256sum] = "bd71fd3c8ed9787f4cf20827fdfbe4aec0f89b56d180c8e2f57b29a029bf222b"

RDEPENDS:python3-colcon-mixin = " \
 python3 \
 python3-colcon-core \
 python3-pyyaml \
 "
