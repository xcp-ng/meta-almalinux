# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qttranslations"
PV = "5.15.18"
PR = "1.el10_2"
PACKAGES = " \
 qt5-qttranslations \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/q/qt5-qttranslations-5.15.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8d4aacf73943f163503ac5130bb1ec43d248e0cd994177d504b13a3d6ed9aebb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttranslations-5.15.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qttranslations;unpack=0"
SRC_URI[x86_64_v2_qt5-qttranslations.sha256sum] = "511b6f2bd0cd45cafb76cf6dcfbb9fbdfdede11dd02132113c40098a1011041e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttranslations-5.15.18-1.el10_2.noarch.rpm;name=aarch64_qt5-qttranslations;unpack=0"
SRC_URI[aarch64_qt5-qttranslations.sha256sum] = "bde29e8fdcdee792e878a9cc9a299b0f9070be588d1514cac3a71b97360e393f"

RDEPENDS:qt5-qttranslations = " \
 "
