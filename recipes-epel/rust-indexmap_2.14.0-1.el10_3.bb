# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-indexmap"
PV = "2.14.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-indexmap+arbitrary-devel \
 rust-indexmap+default-devel \
 rust-indexmap+quickcheck-devel \
 rust-indexmap+rayon-devel \
 rust-indexmap+serde-devel \
 rust-indexmap+std-devel \
 rust-indexmap+test_debug-devel \
 rust-indexmap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-indexmap-2.14.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0fb7ae4639a1bc1a0ea48a5fd70fe837bbde1252853722cafd43ff883a8abe32"

URI_x86_64_v2_rust-indexmap+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+arbitrary-devel-2.14.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-indexmap+arbitrary-devel.sha256sum] = "ada0d3c2e43e6a806140a42bf2fa92944a59a74590826af79d620d33042c57c9"

URI_x86_64_v2_rust-indexmap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+default-devel-2.14.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap+default-devel}"
SRC_URI[x86_64_v2_rust-indexmap+default-devel.sha256sum] = "9d1f1a94c29b19d4063f0a40aeb25e3d644abf3413e7728b52e98de524a4bebe"
RPROVIDES:rust-indexmap+default-devel:x86_64_v2 = "virtual/crate_indexmap/default__ge_1.6.0_with_crate_indexmap/default__lt_3.0.0~"

URI_x86_64_v2_rust-indexmap+quickcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+quickcheck-devel-2.14.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap+quickcheck-devel}"
SRC_URI[x86_64_v2_rust-indexmap+quickcheck-devel.sha256sum] = "1cdc37789d5276f57a423babf36dc823266dcfbc1076a4b9870ae3ee6cd766a0"

URI_x86_64_v2_rust-indexmap+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+rayon-devel-2.14.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap+rayon-devel}"
SRC_URI[x86_64_v2_rust-indexmap+rayon-devel.sha256sum] = "abcfd9a3dbe0e0d6ef40955f81ed9c7ad88d78e92a3f771121e7be4d0f36b3f7"

URI_x86_64_v2_rust-indexmap+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+serde-devel-2.14.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap+serde-devel}"
SRC_URI[x86_64_v2_rust-indexmap+serde-devel.sha256sum] = "e7437efeb9fc7429fea53c20c4ac24164a8b8d9b718ff0262b453cb83e124c01"

URI_x86_64_v2_rust-indexmap+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+std-devel-2.14.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap+std-devel}"
SRC_URI[x86_64_v2_rust-indexmap+std-devel.sha256sum] = "ddeb265198ae6f1af4c06adfe215c961e1dbdac997243f25fbc31e7bf91ed507"

URI_x86_64_v2_rust-indexmap+test_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+test_debug-devel-2.14.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+test_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap+test_debug-devel}"
SRC_URI[x86_64_v2_rust-indexmap+test_debug-devel.sha256sum] = "b5d7ac97023b91af482bb16c5f47da54c249f2cf58788dc7b2beb8c41596f8a8"

URI_x86_64_v2_rust-indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap-devel-2.14.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap-devel}"
SRC_URI[x86_64_v2_rust-indexmap-devel.sha256sum] = "a0838829a65934d96ba388201ec016094c134fc6184dcefb169cf6a27fa6f1a9"

URI_aarch64_rust-indexmap+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+arbitrary-devel-2.14.0-1.el10_3.noarch.rpm;name=aarch64_rust-indexmap+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap+arbitrary-devel}"
SRC_URI[aarch64_rust-indexmap+arbitrary-devel.sha256sum] = "5164c00ef574233e1d8a1f3b9e447d1c24c05a56e44f2d3cb1ff2310ae079f23"

URI_aarch64_rust-indexmap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+default-devel-2.14.0-1.el10_3.noarch.rpm;name=aarch64_rust-indexmap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap+default-devel}"
SRC_URI[aarch64_rust-indexmap+default-devel.sha256sum] = "34c195493d2448c28b2a53482e623147916d2900c9959e4494472c0ea00ee8db"
RPROVIDES:rust-indexmap+default-devel:aarch64 = "virtual/crate_indexmap/default__ge_1.6.0_with_crate_indexmap/default__lt_3.0.0~"

URI_aarch64_rust-indexmap+quickcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+quickcheck-devel-2.14.0-1.el10_3.noarch.rpm;name=aarch64_rust-indexmap+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap+quickcheck-devel}"
SRC_URI[aarch64_rust-indexmap+quickcheck-devel.sha256sum] = "499b51b0a529b1174b29c6911938d3c439ebd99e2a7957e1cf535db24a924abe"

URI_aarch64_rust-indexmap+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+rayon-devel-2.14.0-1.el10_3.noarch.rpm;name=aarch64_rust-indexmap+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap+rayon-devel}"
SRC_URI[aarch64_rust-indexmap+rayon-devel.sha256sum] = "649af21bfbab9978db9168b7817439af1b87589f86377c4a6172a356cc1e5c08"

URI_aarch64_rust-indexmap+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+serde-devel-2.14.0-1.el10_3.noarch.rpm;name=aarch64_rust-indexmap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap+serde-devel}"
SRC_URI[aarch64_rust-indexmap+serde-devel.sha256sum] = "4d6586acb0f2e99a08ce53ec4885cbcf70c7c6db8f6ec124c5f5d9951c8f0f76"

URI_aarch64_rust-indexmap+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+std-devel-2.14.0-1.el10_3.noarch.rpm;name=aarch64_rust-indexmap+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap+std-devel}"
SRC_URI[aarch64_rust-indexmap+std-devel.sha256sum] = "14ded4106371471b6b5049649669047f5be6c8a94e416790ad802ef88e2d431c"

URI_aarch64_rust-indexmap+test_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+test_debug-devel-2.14.0-1.el10_3.noarch.rpm;name=aarch64_rust-indexmap+test_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap+test_debug-devel}"
SRC_URI[aarch64_rust-indexmap+test_debug-devel.sha256sum] = "2fddb0d27f2e327a451be79755ba2290fbecafd150a7371ada02d3dc783787c0"

URI_aarch64_rust-indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap-devel-2.14.0-1.el10_3.noarch.rpm;name=aarch64_rust-indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap-devel}"
SRC_URI[aarch64_rust-indexmap-devel.sha256sum] = "dccf1cb4fc662827f7534d039dce2fd9ff785c1eec11d7c601e0a52e580f78ba"

RDEPENDS:rust-indexmap+arbitrary-devel = " \
 cargo \
 rust-arbitrary-devel \
 rust-indexmap-devel \
 "
RDEPENDS:rust-indexmap+default-devel = " \
 cargo \
 rust-indexmap+std-devel \
 rust-indexmap-devel \
 "
RDEPENDS:rust-indexmap+quickcheck-devel = " \
 cargo \
 rust-indexmap-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-indexmap+rayon-devel = " \
 cargo \
 rust-indexmap-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-indexmap+serde-devel = " \
 cargo \
 rust-indexmap-devel \
 rust-serde-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-indexmap+std-devel = " \
 cargo \
 rust-indexmap-devel \
 "
RDEPENDS:rust-indexmap+test_debug-devel = " \
 cargo \
 rust-indexmap-devel \
 "
RDEPENDS:rust-indexmap-devel = " \
 cargo \
 rust \
 rust-equivalent-devel \
 rust-hashbrown-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_indexmap/default__ge_1.6.0_with_crate_indexmap/default__lt_3.0.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_indexmap/default__ge_1.6.0_with_crate_indexmap/default__lt_3.0.0~"
