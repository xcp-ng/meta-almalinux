# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-gopkg-jcmturner-rpc-1"
PV = "1.1.0"
PR = "13.el10_0"
PACKAGES = " \
 golang-gopkg-jcmturner-rpc-1-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/golang-gopkg-jcmturner-rpc-1-1.1.0-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "aca6dccc9bdb3890be841448e5b1e242021147a90afa9ceaf93cce918e26037b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-gopkg-jcmturner-rpc-1-devel-1.1.0-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-gopkg-jcmturner-rpc-1-devel;unpack=0"
SRC_URI[x86_64_v2_golang-gopkg-jcmturner-rpc-1-devel.sha256sum] = "dc021ffe0b43c9d81dcf7741cfafd52bee6573c44533e5a87738dd5d073b5069"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-gopkg-jcmturner-rpc-1-devel-1.1.0-13.el10_0.noarch.rpm;name=aarch64_golang-gopkg-jcmturner-rpc-1-devel;unpack=0"
SRC_URI[aarch64_golang-gopkg-jcmturner-rpc-1-devel.sha256sum] = "66cdbdb48b62347e855e15b1589b270437002c09ecd2ca6271879214893249df"

RDEPENDS:golang-gopkg-jcmturner-rpc-1-devel = " \
 go-filesystem \
 "
