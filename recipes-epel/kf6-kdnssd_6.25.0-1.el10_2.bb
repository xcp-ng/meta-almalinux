# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kdnssd"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kdnssd \
 kf6-kdnssd-devel \
 kf6-kdnssd-doc \
 kf6-kdnssd-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kdnssd-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "510caf1d08671b2ff259ba89be73996cdc6ac9c97071a57a6d00b97dda981d4e"

URI_x86_64_v2_kf6-kdnssd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdnssd-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdnssd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdnssd}"
SRC_URI[x86_64_v2_kf6-kdnssd.sha256sum] = "03c074e8f1c239c1d19b7de9f99cf54c7b9e45b94ea2279664d3920fc5604268"

URI_x86_64_v2_kf6-kdnssd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdnssd-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdnssd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdnssd-devel}"
SRC_URI[x86_64_v2_kf6-kdnssd-devel.sha256sum] = "6b91935c0334c3d021f9e615b8a7e518b70bdd55e8f937050525b42e7aabd071"

URI_x86_64_v2_kf6-kdnssd-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdnssd-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdnssd-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdnssd-doc}"
SRC_URI[x86_64_v2_kf6-kdnssd-doc.sha256sum] = "0f1b7c42bb62682830ee3f7efccabc4df1c57499c75f670eb8f31ac45cc6f700"

URI_x86_64_v2_kf6-kdnssd-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdnssd-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdnssd-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdnssd-html}"
SRC_URI[x86_64_v2_kf6-kdnssd-html.sha256sum] = "7dc5266f974827cd7f97387099bbe6d0166d86c879f00f383e87f2cf3036fcf2"

URI_aarch64_kf6-kdnssd = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdnssd-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kdnssd;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdnssd}"
SRC_URI[aarch64_kf6-kdnssd.sha256sum] = "19ba47909c9c36bf23ad9bf32b7fd55ea2e26bbc78293521a4281fc04b382dd8"

URI_aarch64_kf6-kdnssd-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdnssd-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kdnssd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdnssd-devel}"
SRC_URI[aarch64_kf6-kdnssd-devel.sha256sum] = "23569aebc40f73b6f16c973e997bd083fdb588a613ebbaf7f806d533586f233f"

URI_aarch64_kf6-kdnssd-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdnssd-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kdnssd-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdnssd-doc}"
SRC_URI[aarch64_kf6-kdnssd-doc.sha256sum] = "939e5b4738156b044882c0ee17bf79655a119523e29245893a8f96e0a473f532"

URI_aarch64_kf6-kdnssd-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdnssd-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kdnssd-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdnssd-html}"
SRC_URI[aarch64_kf6-kdnssd-html.sha256sum] = "ddafb46b19a366c452fa236270f2767d2073a0a0d1115d11bd2f28798a5c2d6e"

RDEPENDS:kf6-kdnssd = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 nss-mdns \
 qt6-qtbase \
 "
RDEPENDS:kf6-kdnssd-devel = " \
 cmake-filesystem \
 kf6-kdnssd \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kdnssd-doc = " \
 "
RDEPENDS:kf6-kdnssd-html = " \
 "
