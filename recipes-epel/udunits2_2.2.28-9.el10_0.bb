# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "udunits2"
PV = "2.2.28"
PR = "9.el10_0"
PACKAGES = " \
 udunits2 \
 udunits2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/udunits2-2.2.28-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "31965111a1d5d105dd6dc22e5431f0565cf614d4e5d8b3e3a497d96ee34505d9"

URI_x86_64_v2_udunits2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/udunits2-2.2.28-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_udunits2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_udunits2}"
SRC_URI[x86_64_v2_udunits2.sha256sum] = "d65b8c3e616f893409f98479339c54253565c78422a94917234a6df5ec9cc130"

URI_x86_64_v2_udunits2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/udunits2-devel-2.2.28-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_udunits2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_udunits2-devel}"
SRC_URI[x86_64_v2_udunits2-devel.sha256sum] = "e48fed709e3f3f3e9a65f83167b1ef6838525003e35198d7de6be5dcb0eb3b4a"

URI_aarch64_udunits2 = "${EPEL_MIRROR}/aarch64/Packages/u/udunits2-2.2.28-9.el10_0.aarch64.rpm;name=aarch64_udunits2;unpack=0"
SRC_URI:append = " ${URI_aarch64_udunits2}"
SRC_URI[aarch64_udunits2.sha256sum] = "d0f08c8f846f0d919a16cc60d1f57d027de4f9a412c7ac82826292360b36b0b3"

URI_aarch64_udunits2-devel = "${EPEL_MIRROR}/aarch64/Packages/u/udunits2-devel-2.2.28-9.el10_0.aarch64.rpm;name=aarch64_udunits2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_udunits2-devel}"
SRC_URI[aarch64_udunits2-devel.sha256sum] = "e953b1084c7f26cdde15e3a3d4345feba883b41d99d2117e4cbddbeee07f7459"

RDEPENDS:udunits2 = " \
 expat \
 glibc \
 "
RDEPENDS:udunits2-devel = " \
 udunits2 \
 "
