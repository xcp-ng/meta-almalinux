# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keditbookmarks"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 keditbookmarks \
 keditbookmarks-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/keditbookmarks-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1a7d2c269821db9d424b3b0a2ea62ec3528082aa2db28842c32714f686127a33"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/keditbookmarks-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_keditbookmarks;unpack=0"
SRC_URI[x86_64_v2_keditbookmarks.sha256sum] = "8d8e18ea5d1449de8c74de0d16ea839ef5ae095471448c2a5597f8a9424874ce"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/keditbookmarks-libs-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_keditbookmarks-libs;unpack=0"
SRC_URI[x86_64_v2_keditbookmarks-libs.sha256sum] = "7c5803a26b9267de4df5817555a7bfd14a023aebc5a6be87f4b17b529d921eab"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/keditbookmarks-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_keditbookmarks;unpack=0"
SRC_URI[aarch64_keditbookmarks.sha256sum] = "3f187d43655c5e4474932d53aad1adfbc6486b68ac49f5983eeca5af44089f0c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/keditbookmarks-libs-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_keditbookmarks-libs;unpack=0"
SRC_URI[aarch64_keditbookmarks-libs.sha256sum] = "a57a9db01d01a9b835c83634ea49c992f0ac862091437e2b3c14652facaa7660"

RDEPENDS:keditbookmarks = " \
 glibc \
 keditbookmarks-libs \
 kf6-kbookmarks \
 kf6-kcodecs \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:keditbookmarks-libs = " \
 glibc \
 keditbookmarks \
 kf6-kbookmarks \
 kf6-kconfigwidgets \
 kf6-ki18n \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
