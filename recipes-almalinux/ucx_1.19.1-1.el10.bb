# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ucx"
PV = "1.19.1"
PR = "1.el10"
PACKAGES = " \
 ucx \
 ucx-cma \
 ucx-devel \
 ucx-ib \
 ucx-rdmacm \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ucx-1.19.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "95172df95ef71c9fb5d2a76244c0ecb0bada6d5e873cce50af2340ee4052096d"

URI_x86_64_v2_ucx = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ucx-1.19.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_ucx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ucx}"
SRC_URI[x86_64_v2_ucx.sha256sum] = "af83cbf001ed071dc7633b671f7562610b2901d35df89b3dc5ff2ab860818b72"

URI_x86_64_v2_ucx-cma = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ucx-cma-1.19.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_ucx-cma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ucx-cma}"
SRC_URI[x86_64_v2_ucx-cma.sha256sum] = "5a1020aba2f4c20b9a7c3ba85cafa5ba0f47f9c94a7950d7a5334a7ed469e751"

URI_x86_64_v2_ucx-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ucx-devel-1.19.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_ucx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ucx-devel}"
SRC_URI[x86_64_v2_ucx-devel.sha256sum] = "4573d6915bbba6652ad11765006c56f64a934247fde7615c68b213c47df3788f"

URI_x86_64_v2_ucx-ib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ucx-ib-1.19.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_ucx-ib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ucx-ib}"
SRC_URI[x86_64_v2_ucx-ib.sha256sum] = "badaea99eb361575ca7dab5e239378de7997a726e40906f03aa898eb7edc3378"

URI_x86_64_v2_ucx-rdmacm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ucx-rdmacm-1.19.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_ucx-rdmacm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ucx-rdmacm}"
SRC_URI[x86_64_v2_ucx-rdmacm.sha256sum] = "5ef3ecd55c06895401687bb667d4a20b56594b7c24a319121eb06b061659a1e9"

URI_aarch64_ucx = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ucx-1.19.1-1.el10.aarch64.rpm;name=aarch64_ucx;unpack=0"
SRC_URI:append = " ${URI_aarch64_ucx}"
SRC_URI[aarch64_ucx.sha256sum] = "7ab31cba626314142f05edadc6aac4334baab551bed978ecbe430ab7dda34a9d"

URI_aarch64_ucx-cma = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ucx-cma-1.19.1-1.el10.aarch64.rpm;name=aarch64_ucx-cma;unpack=0"
SRC_URI:append = " ${URI_aarch64_ucx-cma}"
SRC_URI[aarch64_ucx-cma.sha256sum] = "8029f25052198155759ef1eae31f1fcdc6225a275fc1451aefc3f3b63a2f7d5c"

URI_aarch64_ucx-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ucx-devel-1.19.1-1.el10.aarch64.rpm;name=aarch64_ucx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ucx-devel}"
SRC_URI[aarch64_ucx-devel.sha256sum] = "972b2b010c7f7e4cf292d1d0246ac21176a1058727b3d94358d130fc1cce5f2a"

URI_aarch64_ucx-ib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ucx-ib-1.19.1-1.el10.aarch64.rpm;name=aarch64_ucx-ib;unpack=0"
SRC_URI:append = " ${URI_aarch64_ucx-ib}"
SRC_URI[aarch64_ucx-ib.sha256sum] = "e10efb9bf66d576ac29249d31e21c928e73c183d613b9b4c0b1085221980d187"

URI_aarch64_ucx-rdmacm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ucx-rdmacm-1.19.1-1.el10.aarch64.rpm;name=aarch64_ucx-rdmacm;unpack=0"
SRC_URI:append = " ${URI_aarch64_ucx-rdmacm}"
SRC_URI[aarch64_ucx-rdmacm.sha256sum] = "d462eb5141210885bee95749c7deb1362d4be7389b606b60ab364ad466868a76"

RDEPENDS:ucx = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 "
RDEPENDS:ucx-cma = " \
 glibc \
 ucx \
 "
RDEPENDS:ucx-devel = " \
 pkgconf-pkg-config \
 rdma-core-devel \
 ucx \
 ucx-devel \
 "
RDEPENDS:ucx-ib = " \
 glibc \
 libibverbs \
 ucx \
 "
RDEPENDS:ucx-rdmacm = " \
 glibc \
 libibverbs \
 librdmacm \
 ucx \
 ucx-ib \
 "
