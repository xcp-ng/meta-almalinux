# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-RDF-Query"
PV = "2.919"
PR = "2.el10_0"
PACKAGES = " \
 perl-RDF-Query \
 perl-RDF-Query-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-RDF-Query-2.919-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "56ff9388a8f0a53b63fb68094f96760dd46072fac9682ff2611cabb1cebf1b17"

URI_x86_64_v2_perl-RDF-Query = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-RDF-Query-2.919-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-RDF-Query;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-RDF-Query}"
SRC_URI[x86_64_v2_perl-RDF-Query.sha256sum] = "c1a1bca7874e7a7b17522d79108edba22124bd2f3ee8a1a43e287aa367fc27a6"

URI_x86_64_v2_perl-RDF-Query-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-RDF-Query-tests-2.919-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-RDF-Query-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-RDF-Query-tests}"
SRC_URI[x86_64_v2_perl-RDF-Query-tests.sha256sum] = "46e851fea01b902ef1017827203f57979caf2cf2cea02d9bd559b9b81133fd3d"

URI_aarch64_perl-RDF-Query = "${EPEL_MIRROR}/aarch64/Packages/p/perl-RDF-Query-2.919-2.el10_0.noarch.rpm;name=aarch64_perl-RDF-Query;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-RDF-Query}"
SRC_URI[aarch64_perl-RDF-Query.sha256sum] = "f22054c9d4412ec99a7803dc2fdcf79592adf3dd6a61db21e09797cf2e942bb3"

URI_aarch64_perl-RDF-Query-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-RDF-Query-tests-2.919-2.el10_0.noarch.rpm;name=aarch64_perl-RDF-Query-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-RDF-Query-tests}"
SRC_URI[aarch64_perl-RDF-Query-tests.sha256sum] = "175e11258197405acb77c02e1ce00ac0fda83c87ae24ca44dfeb64cd0313f6c5"

RDEPENDS:perl-RDF-Query = " \
 perl-Benchmark \
 perl-CGI \
 perl-Carp \
 perl-Data-Dumper \
 perl-Data-UUID \
 perl-DateTime \
 perl-DateTime-Format-W3CDTF \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-Encode \
 perl-Error \
 perl-Exporter \
 perl-I18N-LangTags \
 perl-JSON \
 perl-LWP-MediaTypes \
 perl-Log-Log4perl \
 perl-MIME-Base64 \
 perl-Math-BigInt \
 perl-Module-Pluggable \
 perl-POSIX \
 perl-Parse-RecDescent \
 perl-PathTools \
 perl-RDF-Query \
 perl-RDF-Trine \
 perl-Scalar-List-Utils \
 perl-Set-Scalar \
 perl-Storable \
 perl-Term-ReadLine \
 perl-TermReadKey \
 perl-Time-HiRes \
 perl-URI \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-libwww-perl \
 perl-overload \
 perl-sort \
 "
RDEPENDS:perl-RDF-Query-tests = " \
 bash \
 perl-PathTools \
 perl-RDF-Query \
 perl-RDF-Trine \
 perl-Scalar-List-Utils \
 perl-Test-Exception \
 perl-Test-Harness \
 perl-Test-JSON \
 perl-Test-Simple \
 perl-URI \
 perl-interpreter \
 perl-lib \
 perl-libs \
 "
