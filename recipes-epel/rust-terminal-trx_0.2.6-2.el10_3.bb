# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-terminal-trx"
PV = "0.2.6"
PR = "2.el10_3"
PACKAGES = " \
 rust-terminal-trx+default-devel \
 rust-terminal-trx-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-terminal-trx-0.2.6-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15a800b826a94e74be6491abe3054f0f876ebdf6ef82051ddd227f9d3fd343d9"

URI_x86_64_v2_rust-terminal-trx+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-terminal-trx+default-devel-0.2.6-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-terminal-trx+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-terminal-trx+default-devel}"
SRC_URI[x86_64_v2_rust-terminal-trx+default-devel.sha256sum] = "70c85ed00761a92e1a2365529ac1489f0651fd20a833e7e7822d720729a8f443"

URI_x86_64_v2_rust-terminal-trx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-terminal-trx-devel-0.2.6-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-terminal-trx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-terminal-trx-devel}"
SRC_URI[x86_64_v2_rust-terminal-trx-devel.sha256sum] = "6f7f2aab74603307bb05f47a014fc4c63553b663078d24c301ff348097b52ae5"

URI_aarch64_rust-terminal-trx+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-terminal-trx+default-devel-0.2.6-2.el10_3.noarch.rpm;name=aarch64_rust-terminal-trx+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-terminal-trx+default-devel}"
SRC_URI[aarch64_rust-terminal-trx+default-devel.sha256sum] = "e6ff995675e91cf91b68b691f5affd1363c336df10be80007bc69dc682796f9e"

URI_aarch64_rust-terminal-trx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-terminal-trx-devel-0.2.6-2.el10_3.noarch.rpm;name=aarch64_rust-terminal-trx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-terminal-trx-devel}"
SRC_URI[aarch64_rust-terminal-trx-devel.sha256sum] = "3cc14b48487be06fef5827c4bc64df2efad4470fec04b8988ff7144e759ad3f8"

RDEPENDS:rust-terminal-trx+default-devel = " \
 cargo \
 rust-terminal-trx-devel \
 "
RDEPENDS:rust-terminal-trx-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 "
