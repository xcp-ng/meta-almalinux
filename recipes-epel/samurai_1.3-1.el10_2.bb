# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "samurai"
PV = "1.3"
PR = "1.el10_2"
PACKAGES = " \
 samurai \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/samurai-1.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8157a255468a9bc7808f05bee06ee026c403e1b58b99983a850e10fe690ee7cd"

URI_x86_64_v2_samurai = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/samurai-1.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_samurai;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samurai}"
SRC_URI[x86_64_v2_samurai.sha256sum] = "27ebb311e1c05d219006c24168d7c80c699c1d705cbf7415bc7509ad8e218afc"

URI_aarch64_samurai = "${EPEL_MIRROR}/aarch64/Packages/s/samurai-1.3-1.el10_2.aarch64.rpm;name=aarch64_samurai;unpack=0"
SRC_URI:append = " ${URI_aarch64_samurai}"
SRC_URI[aarch64_samurai.sha256sum] = "181d80253479a55520f9a9db9f39758baa884c1be1085fa13da5a756cf296aeb"

RDEPENDS:samurai = " \
 glibc \
 "
