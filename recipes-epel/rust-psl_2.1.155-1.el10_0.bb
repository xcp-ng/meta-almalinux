# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-psl"
PV = "2.1.155"
PR = "1.el10_0"
PACKAGES = " \
 rust-psl+default-devel \
 rust-psl+helpers-devel \
 rust-psl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-psl-2.1.155-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9ad1f24101f622fb2dc790faac59e7531b85e62bdc16110144dbd03ff2e2e3e"

URI_x86_64_v2_rust-psl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-psl+default-devel-2.1.155-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-psl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-psl+default-devel}"
SRC_URI[x86_64_v2_rust-psl+default-devel.sha256sum] = "f8c09477f50a759d16e65f0482e74557409cadabb89dad97a88a9a73d7c827c4"

URI_x86_64_v2_rust-psl+helpers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-psl+helpers-devel-2.1.155-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-psl+helpers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-psl+helpers-devel}"
SRC_URI[x86_64_v2_rust-psl+helpers-devel.sha256sum] = "7d9dba14a09c95c388e80d4924382fb0a4debc4a64620f4aa12e46853072168c"

URI_x86_64_v2_rust-psl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-psl-devel-2.1.155-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-psl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-psl-devel}"
SRC_URI[x86_64_v2_rust-psl-devel.sha256sum] = "b72520945c680a29195e8053d543af5ee72877019da180d90c08ed8695403e89"

URI_aarch64_rust-psl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-psl+default-devel-2.1.155-1.el10_0.noarch.rpm;name=aarch64_rust-psl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-psl+default-devel}"
SRC_URI[aarch64_rust-psl+default-devel.sha256sum] = "f3a9b7b1fc81d395af0d83de56ee2910a3e98b7c3b36e0cf302172cb72ef3e71"

URI_aarch64_rust-psl+helpers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-psl+helpers-devel-2.1.155-1.el10_0.noarch.rpm;name=aarch64_rust-psl+helpers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-psl+helpers-devel}"
SRC_URI[aarch64_rust-psl+helpers-devel.sha256sum] = "85d831c4e8f4066a28bc986d96e2540f112052224a9ff543543304df2078bd22"

URI_aarch64_rust-psl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-psl-devel-2.1.155-1.el10_0.noarch.rpm;name=aarch64_rust-psl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-psl-devel}"
SRC_URI[aarch64_rust-psl-devel.sha256sum] = "69b7d5b7c494bc137dd2fee823121b1c725657b9769078131dae54df576a9b5b"

RDEPENDS:rust-psl+default-devel = " \
 cargo \
 rust-psl+helpers-devel \
 rust-psl-devel \
 "
RDEPENDS:rust-psl+helpers-devel = " \
 cargo \
 rust-psl-devel \
 "
RDEPENDS:rust-psl-devel = " \
 cargo \
 rust-psl-types+default-devel \
 "
