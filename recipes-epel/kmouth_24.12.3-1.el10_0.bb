# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmouth"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kmouth \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmouth-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "afd6f5cd20f5dc24267e75d551db10d1c899153b6c7ae2bc77c65de3537ea4af"

URI_x86_64_v2_kmouth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmouth-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmouth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmouth}"
SRC_URI[x86_64_v2_kmouth.sha256sum] = "f38bd78e93e36b4f1aabcd8c229529a544962bdbb3cfb1caac0f0517f16ee60a"

URI_aarch64_kmouth = "${EPEL_MIRROR}/aarch64/Packages/k/kmouth-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kmouth;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmouth}"
SRC_URI[aarch64_kmouth.sha256sum] = "20998252a99ad3a669bf5ecdd1249d1cdc5fcdd1d26bea1a57d3535e85876ffa"

RDEPENDS:kmouth = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtspeech \
 "
