# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "knock"
PV = "0.8"
PR = "11.el10_1"
PACKAGES = " \
 knock \
 knock-server \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/knock-0.8-11.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "02d1ba67036e013a2168dbe2d428a0f5bae5cf0cb426cbc6612ad8c798cd6730"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knock-0.8-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knock;unpack=0"
SRC_URI[x86_64_v2_knock.sha256sum] = "9ca7fc4b21e48f38efa1c6407c2a6d4310511566f15e7d5ef5b8310b6323e8c3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knock-server-0.8-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knock-server;unpack=0"
SRC_URI[x86_64_v2_knock-server.sha256sum] = "49eac535d8973bc5afc8c9ce34454ccad3f9e5276e0be425c1b5a0df28a13503"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/knock-0.8-11.el10_1.aarch64.rpm;name=aarch64_knock;unpack=0"
SRC_URI[aarch64_knock.sha256sum] = "4da573ae76d38c08916f241c97de499632d74d1f73654b89f8563e07f0799cb1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/knock-server-0.8-11.el10_1.aarch64.rpm;name=aarch64_knock-server;unpack=0"
SRC_URI[aarch64_knock-server.sha256sum] = "c97538f60f95448d4d27a2054bdb828ffd6d1dd1684d67dcdec195d975ee2765"

RDEPENDS:knock = " \
 glibc \
 systemd \
 "
RDEPENDS:knock-server = " \
 bash \
 glibc \
 libpcap \
 "
