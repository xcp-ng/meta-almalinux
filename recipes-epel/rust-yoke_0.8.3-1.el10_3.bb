# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-yoke"
PV = "0.8.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-yoke+alloc-devel \
 rust-yoke+default-devel \
 rust-yoke+derive-devel \
 rust-yoke+serde-devel \
 rust-yoke+zerofrom-devel \
 rust-yoke-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-yoke-0.8.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e3d60346ad80a5236d02baa041aef4caeb4d2b6ce7636333e140b7b21f467a44"

URI_x86_64_v2_rust-yoke+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yoke+alloc-devel-0.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yoke+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yoke+alloc-devel}"
SRC_URI[x86_64_v2_rust-yoke+alloc-devel.sha256sum] = "e9f4f79388792df20ee3aa04dfcbb55a0fd1838c94eae781948b699457398192"

URI_x86_64_v2_rust-yoke+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yoke+default-devel-0.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yoke+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yoke+default-devel}"
SRC_URI[x86_64_v2_rust-yoke+default-devel.sha256sum] = "d16663989f09903e19fbbecee2a0eb71af91fd4f3d62f58dde158c52a81473f8"

URI_x86_64_v2_rust-yoke+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yoke+derive-devel-0.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yoke+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yoke+derive-devel}"
SRC_URI[x86_64_v2_rust-yoke+derive-devel.sha256sum] = "b33ce872176107c688c729a395df9ccf49615b4e5310b3f3aaaac65d58c9cd3d"

URI_x86_64_v2_rust-yoke+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yoke+serde-devel-0.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yoke+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yoke+serde-devel}"
SRC_URI[x86_64_v2_rust-yoke+serde-devel.sha256sum] = "ed774f1437a6116968433b0d281d170d5ce49f0aae05c6efe8109d3a5118517f"

URI_x86_64_v2_rust-yoke+zerofrom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yoke+zerofrom-devel-0.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yoke+zerofrom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yoke+zerofrom-devel}"
SRC_URI[x86_64_v2_rust-yoke+zerofrom-devel.sha256sum] = "6d7028c56bee7b0e3aca5651051fb495517c0003c51629385bd50fc35a291d1f"

URI_x86_64_v2_rust-yoke-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yoke-devel-0.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yoke-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yoke-devel}"
SRC_URI[x86_64_v2_rust-yoke-devel.sha256sum] = "14fb1ca4f35689f50039686cde4f3c721b6aba7387a016a5e22fee5bd8fb0315"

URI_aarch64_rust-yoke+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yoke+alloc-devel-0.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-yoke+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yoke+alloc-devel}"
SRC_URI[aarch64_rust-yoke+alloc-devel.sha256sum] = "1bbb1c040a2af29d427be103e159b6bc0a45c09ff85e956802218492bbbd0442"

URI_aarch64_rust-yoke+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yoke+default-devel-0.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-yoke+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yoke+default-devel}"
SRC_URI[aarch64_rust-yoke+default-devel.sha256sum] = "eba86113fd37fe9981a8a5403cf119a3aa92441872956588cf539e80bdc6ef69"

URI_aarch64_rust-yoke+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yoke+derive-devel-0.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-yoke+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yoke+derive-devel}"
SRC_URI[aarch64_rust-yoke+derive-devel.sha256sum] = "f4e1f5cf3cadf0e4fe68724ca9493e303f0775fd31aa6a83a38cf22925a48465"

URI_aarch64_rust-yoke+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yoke+serde-devel-0.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-yoke+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yoke+serde-devel}"
SRC_URI[aarch64_rust-yoke+serde-devel.sha256sum] = "69d1f5bdea3b8f0e30e06b199e893a83af3e92cde8153192bdff339a2edf5437"

URI_aarch64_rust-yoke+zerofrom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yoke+zerofrom-devel-0.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-yoke+zerofrom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yoke+zerofrom-devel}"
SRC_URI[aarch64_rust-yoke+zerofrom-devel.sha256sum] = "f5eeaf01df42c233b8527c76c7d1945047b30711efbfce70def272ea928c6194"

URI_aarch64_rust-yoke-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yoke-devel-0.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-yoke-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yoke-devel}"
SRC_URI[aarch64_rust-yoke-devel.sha256sum] = "5ccf3e235acbc5722a16c6b57a8f62743f7f90b15a70175f1e2f000f5d7fa669"

RDEPENDS:rust-yoke+alloc-devel = " \
 cargo \
 rust-stable_deref_trait+alloc-devel \
 rust-yoke-devel \
 rust-zerofrom+alloc-devel \
 rust-zerofrom-devel \
 "
RDEPENDS:rust-yoke+default-devel = " \
 cargo \
 rust-yoke+alloc-devel \
 rust-yoke+zerofrom-devel \
 rust-yoke-devel \
 "
RDEPENDS:rust-yoke+derive-devel = " \
 cargo \
 rust-yoke-derive-devel \
 rust-yoke-devel \
 rust-zerofrom+derive-devel \
 rust-zerofrom-devel \
 "
RDEPENDS:rust-yoke+serde-devel = " \
 cargo \
 rust-yoke-devel \
 "
RDEPENDS:rust-yoke+zerofrom-devel = " \
 cargo \
 rust-yoke-devel \
 rust-zerofrom-devel \
 "
RDEPENDS:rust-yoke-devel = " \
 cargo \
 rust \
 rust-stable_deref_trait-devel \
 "
