# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-tf-random"
PV = "0.5"
PR = "47.el10_0"
PACKAGES = " \
 ghc-tf-random \
 ghc-tf-random-devel \
 ghc-tf-random-doc \
 ghc-tf-random-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-tf-random-0.5-47.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "974192da9f1875977585a05796cb7642452ef8ab054ebd062b17429443bbc18a"

URI_x86_64_v2_ghc-tf-random = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tf-random-0.5-47.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tf-random;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tf-random}"
SRC_URI[x86_64_v2_ghc-tf-random.sha256sum] = "34a71a2bc4bffaa17c6761d1d3427913013b297242e09bc8ed133b965fbb5082"

URI_x86_64_v2_ghc-tf-random-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tf-random-devel-0.5-47.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tf-random-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tf-random-devel}"
SRC_URI[x86_64_v2_ghc-tf-random-devel.sha256sum] = "4cbe536746f972b9e680d4357192939c38562387ea943fddd0d0fddffd22d364"

URI_x86_64_v2_ghc-tf-random-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tf-random-doc-0.5-47.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-tf-random-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tf-random-doc}"
SRC_URI[x86_64_v2_ghc-tf-random-doc.sha256sum] = "e50295b3b80fcf3edb24f7575de1847782917fed80d630076a01726540e330a7"

URI_x86_64_v2_ghc-tf-random-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tf-random-prof-0.5-47.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tf-random-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tf-random-prof}"
SRC_URI[x86_64_v2_ghc-tf-random-prof.sha256sum] = "1b289e7a948aea2f30d9e7e54a2f8ae8d0cab05997a333427291e9d82cfc42c6"

URI_aarch64_ghc-tf-random = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tf-random-0.5-47.el10_0.aarch64.rpm;name=aarch64_ghc-tf-random;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tf-random}"
SRC_URI[aarch64_ghc-tf-random.sha256sum] = "5242c2ab73124e5455c98663e695a99cbc5f3b5a93ec26a8613c4a83ae14666a"

URI_aarch64_ghc-tf-random-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tf-random-devel-0.5-47.el10_0.aarch64.rpm;name=aarch64_ghc-tf-random-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tf-random-devel}"
SRC_URI[aarch64_ghc-tf-random-devel.sha256sum] = "2bd61581312b6ee71a6971753336264893634ec0ea03c238566efab5be844558"

URI_aarch64_ghc-tf-random-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tf-random-doc-0.5-47.el10_0.noarch.rpm;name=aarch64_ghc-tf-random-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tf-random-doc}"
SRC_URI[aarch64_ghc-tf-random-doc.sha256sum] = "27b9175845337506caacfb57c7034494aa6a551158da5a5762c7ccbdb5e46e99"

URI_aarch64_ghc-tf-random-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tf-random-prof-0.5-47.el10_0.aarch64.rpm;name=aarch64_ghc-tf-random-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tf-random-prof}"
SRC_URI[aarch64_ghc-tf-random-prof.sha256sum] = "020d0bf62dc49e4a7a9f0b96af8f8fa58437d7a7daf1cca5ca9f0a7f1a93ded5"

RDEPENDS:ghc-tf-random = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-primitive \
 ghc-random \
 ghc-splitmix \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-tf-random-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-primitive-devel \
 ghc-random-devel \
 ghc-tf-random \
 ghc-time-devel \
 "
RDEPENDS:ghc-tf-random-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-tf-random-prof = " \
 ghc-base-prof \
 ghc-primitive-prof \
 ghc-random-prof \
 ghc-tf-random-devel \
 ghc-time-prof \
 "
