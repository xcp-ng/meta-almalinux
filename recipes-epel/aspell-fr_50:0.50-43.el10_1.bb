# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aspell-fr"
PE = "50"
PV = "0.50"
PR = "43.el10_1"
PACKAGES = " \
 aspell-fr \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aspell-fr-0.50-43.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "18615879fb3f615abcd8a95b1a963fb5dcf1f3fea6a1c9546bcc0aa5820354f6"

URI_x86_64_v2_aspell-fr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aspell-fr-0.50-43.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aspell-fr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspell-fr}"
SRC_URI[x86_64_v2_aspell-fr.sha256sum] = "184290e5c87f2f5423434b074ef55206d807e87ef0516a9c4079c66af480b939"

URI_aarch64_aspell-fr = "${EPEL_MIRROR}/aarch64/Packages/a/aspell-fr-0.50-43.el10_1.aarch64.rpm;name=aarch64_aspell-fr;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspell-fr}"
SRC_URI[aarch64_aspell-fr.sha256sum] = "b945a4f8fa6c9c00fc49294e890988d962803ced5769ac7ea8cc25ba3f0ec58e"

RDEPENDS:aspell-fr = " \
 aspell \
 "
