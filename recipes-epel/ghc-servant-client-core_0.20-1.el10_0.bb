# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-servant-client-core"
PV = "0.20"
PR = "1.el10_0"
PACKAGES = " \
 ghc-servant-client-core \
 ghc-servant-client-core-devel \
 ghc-servant-client-core-doc \
 ghc-servant-client-core-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-servant-client-core-0.20-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a7b81ff5a63fb7d49496c200e05da115a2231574ebc43bd54012256ca116dd3"

URI_x86_64_v2_ghc-servant-client-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-servant-client-core-0.20-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-servant-client-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-servant-client-core}"
SRC_URI[x86_64_v2_ghc-servant-client-core.sha256sum] = "cf940bea4b037635bfe22b99a72d802cf88d36b692e269aafbf37c65da5a321c"

URI_x86_64_v2_ghc-servant-client-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-servant-client-core-devel-0.20-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-servant-client-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-servant-client-core-devel}"
SRC_URI[x86_64_v2_ghc-servant-client-core-devel.sha256sum] = "302874ab562e6d5baebab1f2f4f22c066af5f16a53872908de8f63c54cd0a258"

URI_x86_64_v2_ghc-servant-client-core-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-servant-client-core-doc-0.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-servant-client-core-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-servant-client-core-doc}"
SRC_URI[x86_64_v2_ghc-servant-client-core-doc.sha256sum] = "f18c2b1dbf4875fc920b47402c00f2518a0c4a6a633ef4e945b91468497a4120"

URI_x86_64_v2_ghc-servant-client-core-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-servant-client-core-prof-0.20-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-servant-client-core-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-servant-client-core-prof}"
SRC_URI[x86_64_v2_ghc-servant-client-core-prof.sha256sum] = "83f43d77e1a4479f46a839bd944c56ed94825796f5f83c35b6e33f4d2fda2471"

URI_aarch64_ghc-servant-client-core = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-servant-client-core-0.20-1.el10_0.aarch64.rpm;name=aarch64_ghc-servant-client-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-servant-client-core}"
SRC_URI[aarch64_ghc-servant-client-core.sha256sum] = "0c5d91b0042b3c1c76d9b125b981c968336b2095745191576477d88236aecce3"

URI_aarch64_ghc-servant-client-core-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-servant-client-core-devel-0.20-1.el10_0.aarch64.rpm;name=aarch64_ghc-servant-client-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-servant-client-core-devel}"
SRC_URI[aarch64_ghc-servant-client-core-devel.sha256sum] = "4f409d0655c74825a8ef63b88be2715fa66c22f4c279cd467b7571106e4ef99d"

URI_aarch64_ghc-servant-client-core-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-servant-client-core-doc-0.20-1.el10_0.noarch.rpm;name=aarch64_ghc-servant-client-core-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-servant-client-core-doc}"
SRC_URI[aarch64_ghc-servant-client-core-doc.sha256sum] = "0be3cd7bddf50ec17725cecab8187509005a62b1a889e62149483c9e3afff38a"

URI_aarch64_ghc-servant-client-core-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-servant-client-core-prof-0.20-1.el10_0.aarch64.rpm;name=aarch64_ghc-servant-client-core-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-servant-client-core-prof}"
SRC_URI[aarch64_ghc-servant-client-core-prof.sha256sum] = "ad7eb1b4367885998731cf35989686bc8796a073708e2abfe037710a8243b54c"

RDEPENDS:ghc-servant-client-core = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-array \
 ghc-assoc \
 ghc-attoparsec \
 ghc-attoparsec-iso8601 \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-bifunctors \
 ghc-binary \
 ghc-boring \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-comonad \
 ghc-constraints \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-dec \
 ghc-deepseq \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-free \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-http-api-data \
 ghc-http-media \
 ghc-http-types \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-conversion \
 ghc-integer-logarithms \
 ghc-mmorph \
 ghc-mtl \
 ghc-network-uri \
 ghc-os-string \
 ghc-parsec \
 ghc-pretty \
 ghc-primitive \
 ghc-profunctors \
 ghc-random \
 ghc-safe \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-servant \
 ghc-singleton-bool \
 ghc-some \
 ghc-sop-core \
 ghc-splitmix \
 ghc-stm \
 ghc-strict \
 ghc-string-conversions \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-compat \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-base \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unordered-containers \
 ghc-utf8-string \
 ghc-uuid-types \
 ghc-vault \
 ghc-vector \
 ghc-vector-stream \
 ghc-witherable \
 glibc \
 gmp \
 "
RDEPENDS:ghc-servant-client-core-devel = " \
 ghc-aeson-devel \
 ghc-base-compat-devel \
 ghc-base-devel \
 ghc-base64-bytestring-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-constraints-devel \
 ghc-containers-devel \
 ghc-deepseq-devel \
 ghc-exceptions-devel \
 ghc-free-devel \
 ghc-http-media-devel \
 ghc-http-types-devel \
 ghc-network-uri-devel \
 ghc-safe-devel \
 ghc-servant-client-core \
 ghc-servant-devel \
 ghc-sop-core-devel \
 ghc-template-haskell-devel \
 ghc-text-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-servant-client-core-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-servant-client-core-prof = " \
 ghc-aeson-prof \
 ghc-base-compat-prof \
 ghc-base-prof \
 ghc-base64-bytestring-prof \
 ghc-bytestring-prof \
 ghc-constraints-prof \
 ghc-containers-prof \
 ghc-deepseq-prof \
 ghc-exceptions-prof \
 ghc-free-prof \
 ghc-http-media-prof \
 ghc-http-types-prof \
 ghc-network-uri-prof \
 ghc-safe-prof \
 ghc-servant-client-core-devel \
 ghc-servant-prof \
 ghc-sop-core-prof \
 ghc-template-haskell-prof \
 ghc-text-prof \
 ghc-transformers-prof \
 "
