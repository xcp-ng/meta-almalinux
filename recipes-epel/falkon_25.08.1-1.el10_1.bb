# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "falkon"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 falkon \
 falkon-kde \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/falkon-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c53bab1f52dcd576bd58a77241aa566579c900eca3ed03b1f2e60cc09f1c0d31"

URI_x86_64_v2_falkon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/falkon-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_falkon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_falkon}"
SRC_URI[x86_64_v2_falkon.sha256sum] = "f27c65073f4f8592bf6b01b1c2bc1be01fbf1f1068c463a05a95605397d24fcc"

URI_x86_64_v2_falkon-kde = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/falkon-kde-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_falkon-kde;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_falkon-kde}"
SRC_URI[x86_64_v2_falkon-kde.sha256sum] = "c5965986d1ef2d7f18a366be3d90aa1b0dba4f520a78b144966bedc777d1565c"

URI_aarch64_falkon = "${EPEL_MIRROR}/aarch64/Packages/f/falkon-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_falkon;unpack=0"
SRC_URI:append = " ${URI_aarch64_falkon}"
SRC_URI[aarch64_falkon.sha256sum] = "8e15bc61ad2ad26612600d6446d0d5651445a8aafe5cdc90313ac4204850b640"

URI_aarch64_falkon-kde = "${EPEL_MIRROR}/aarch64/Packages/f/falkon-kde-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_falkon-kde;unpack=0"
SRC_URI:append = " ${URI_aarch64_falkon-kde}"
SRC_URI[aarch64_falkon-kde.sha256sum] = "d10f8f7ca7286cbc7cfa5e9c9351582c0f8c7ade261192e376a9fd0db0d386c6"

RDEPENDS:falkon = " \
 glibc \
 hicolor-icon-theme \
 kf6-karchive \
 libgcc \
 libstdc++ \
 libxcb \
 openssl-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebchannel \
 qt6-qtwebengine \
 "
RDEPENDS:falkon-kde = " \
 falkon \
 glibc \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kio-core-libs \
 kf6-kjobwidgets \
 kf6-kwallet-libs \
 kf6-purpose \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
