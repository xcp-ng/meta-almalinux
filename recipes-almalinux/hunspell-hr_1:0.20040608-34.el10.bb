# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-hr"
PE = "1"
PV = "0.20040608"
PR = "34.el10"
PACKAGES = " \
 hunspell-hr \
 hyphen-hr \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-hr-0.20040608-34.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dbb2217e29277ba3d871744a4ead9cf1181154ebc056b976147561ff43547c99"

URI_x86_64_v2_hunspell-hr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-hr-0.20040608-34.el10.noarch.rpm;name=x86_64_v2_hunspell-hr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-hr}"
SRC_URI[x86_64_v2_hunspell-hr.sha256sum] = "0063aae175201e1b831a9e93a555df44a787bd62cd6f18eb1e38c2cf2d84714c"

URI_x86_64_v2_hyphen-hr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-hr-0.20040608-34.el10.noarch.rpm;name=x86_64_v2_hyphen-hr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyphen-hr}"
SRC_URI[x86_64_v2_hyphen-hr.sha256sum] = "33f20c44052846ed9edb324a3f32bd0560c6b5a73d2b1b913999ee2c843a31b1"

URI_aarch64_hunspell-hr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-hr-0.20040608-34.el10.noarch.rpm;name=aarch64_hunspell-hr;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-hr}"
SRC_URI[aarch64_hunspell-hr.sha256sum] = "0063aae175201e1b831a9e93a555df44a787bd62cd6f18eb1e38c2cf2d84714c"

URI_aarch64_hyphen-hr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-hr-0.20040608-34.el10.noarch.rpm;name=aarch64_hyphen-hr;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyphen-hr}"
SRC_URI[aarch64_hyphen-hr.sha256sum] = "33f20c44052846ed9edb324a3f32bd0560c6b5a73d2b1b913999ee2c843a31b1"

RDEPENDS:hunspell-hr = " \
 hunspell-filesystem \
 "
RDEPENDS:hyphen-hr = " \
 hyphen \
 "
