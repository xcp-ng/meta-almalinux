# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kscreenlocker"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 kscreenlocker \
 kscreenlocker-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kscreenlocker-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c2883d15a592d56073309f33b3996746e5c8a5022d120d9a2833d9b4fdd927e"

URI_x86_64_v2_kscreenlocker = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kscreenlocker-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kscreenlocker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kscreenlocker}"
SRC_URI[x86_64_v2_kscreenlocker.sha256sum] = "468526f406acf0bdffd39f0e71c10d07cffef367e30bc5c52e80da17415c8d0f"

URI_x86_64_v2_kscreenlocker-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kscreenlocker-devel-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kscreenlocker-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kscreenlocker-devel}"
SRC_URI[x86_64_v2_kscreenlocker-devel.sha256sum] = "27ca3267cac8febbe2fc92f876cdf18fa38baac25be158f3b3cf4a15fa3db362"

URI_aarch64_kscreenlocker = "${EPEL_MIRROR}/aarch64/Packages/k/kscreenlocker-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_kscreenlocker;unpack=0"
SRC_URI:append = " ${URI_aarch64_kscreenlocker}"
SRC_URI[aarch64_kscreenlocker.sha256sum] = "575129f1ebe6e4f50f7064ff8b9f1903206c0ad4b43aed3cfea07970c8348d62"

URI_aarch64_kscreenlocker-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kscreenlocker-devel-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_kscreenlocker-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kscreenlocker-devel}"
SRC_URI[aarch64_kscreenlocker-devel.sha256sum] = "a840bb3fb647d573642abbdadb834eb80bea5773f200ce782e753b8daeabec59"

RDEPENDS:kscreenlocker = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kidletime \
 kf6-kio-core-libs \
 kf6-knotifications \
 kf6-kpackage \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 layer-shell-qt \
 libX11 \
 libXi \
 libkscreen \
 libplasma \
 libstdc++ \
 libwayland-client \
 libwayland-server \
 libxcb \
 pam-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 xcb-util-keysyms \
 "
RDEPENDS:kscreenlocker-devel = " \
 cmake-filesystem \
 kscreenlocker \
 "
