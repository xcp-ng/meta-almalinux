# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mio"
PV = "1.1.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-mio+default-devel \
 rust-mio+log-devel \
 rust-mio+net-devel \
 rust-mio+os-ext-devel \
 rust-mio+os-poll-devel \
 rust-mio-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mio-1.1.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e069a28528e5ac4f0e15daeffb8aacbe5e0e3cd4b4f1d82a746a6b341d2830f"

URI_x86_64_v2_rust-mio+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio+default-devel-1.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio+default-devel}"
SRC_URI[x86_64_v2_rust-mio+default-devel.sha256sum] = "81362f032bb39638c837112e3348c37366f41f0dda10be2272cdca3bd036dcd9"

URI_x86_64_v2_rust-mio+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio+log-devel-1.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio+log-devel}"
SRC_URI[x86_64_v2_rust-mio+log-devel.sha256sum] = "2e9fd5337c2a13b827f229d0c36575ca8849b8fc11c5bd00af02f51ba6ffa232"

URI_x86_64_v2_rust-mio+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio+net-devel-1.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio+net-devel}"
SRC_URI[x86_64_v2_rust-mio+net-devel.sha256sum] = "c88ffc3833f4ace0db4d7d595173f421a988957405fdaf54b02e5a44d808b3e4"

URI_x86_64_v2_rust-mio+os-ext-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio+os-ext-devel-1.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio+os-ext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio+os-ext-devel}"
SRC_URI[x86_64_v2_rust-mio+os-ext-devel.sha256sum] = "e6ed2f18acab829635b646728d8fc20f424c68db51374244d8a9436c41343cb0"

URI_x86_64_v2_rust-mio+os-poll-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio+os-poll-devel-1.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio+os-poll-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio+os-poll-devel}"
SRC_URI[x86_64_v2_rust-mio+os-poll-devel.sha256sum] = "ac8dd099aa8f2a7a95fc37d5ef18ec661406495d350c3e7e516ed5a90fec8168"

URI_x86_64_v2_rust-mio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio-devel-1.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio-devel}"
SRC_URI[x86_64_v2_rust-mio-devel.sha256sum] = "07a37f8573a76c2f3943c9dda2cd991524fda51845799a937c81d8394d1277ef"

URI_aarch64_rust-mio+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio+default-devel-1.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-mio+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio+default-devel}"
SRC_URI[aarch64_rust-mio+default-devel.sha256sum] = "acd6cdf1ce769117fd2bab37e25f838fd8be1f140cc86e9f123708e5a33f4749"

URI_aarch64_rust-mio+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio+log-devel-1.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-mio+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio+log-devel}"
SRC_URI[aarch64_rust-mio+log-devel.sha256sum] = "19742c2a5167f3e5e9f42d4fbf7046ccc2a415e22d5b1d92bed0a4a134b23920"

URI_aarch64_rust-mio+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio+net-devel-1.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-mio+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio+net-devel}"
SRC_URI[aarch64_rust-mio+net-devel.sha256sum] = "519ab966a2e46e678e5ed7ad667c6042b8346725e9153dffc0c2b33ac83385aa"

URI_aarch64_rust-mio+os-ext-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio+os-ext-devel-1.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-mio+os-ext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio+os-ext-devel}"
SRC_URI[aarch64_rust-mio+os-ext-devel.sha256sum] = "bf9e3356b5c50260f42391ddd8fc44296ee9153d66bce91ee52282a2de5c8602"

URI_aarch64_rust-mio+os-poll-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio+os-poll-devel-1.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-mio+os-poll-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio+os-poll-devel}"
SRC_URI[aarch64_rust-mio+os-poll-devel.sha256sum] = "5375631f77d90c281ab98df8da8a40862db03c83e22e852f074d25f6e59578ae"

URI_aarch64_rust-mio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio-devel-1.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-mio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio-devel}"
SRC_URI[aarch64_rust-mio-devel.sha256sum] = "37ca273d663fe9a67b6acc8d3bc45647a50f45dc23af423f4417f0b73e108f89"

RDEPENDS:rust-mio+default-devel = " \
 cargo \
 rust-mio+log-devel \
 rust-mio-devel \
 "
RDEPENDS:rust-mio+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-mio-devel \
 "
RDEPENDS:rust-mio+net-devel = " \
 cargo \
 rust-mio-devel \
 "
RDEPENDS:rust-mio+os-ext-devel = " \
 cargo \
 rust-mio+os-poll-devel \
 rust-mio-devel \
 "
RDEPENDS:rust-mio+os-poll-devel = " \
 cargo \
 rust-mio-devel \
 "
RDEPENDS:rust-mio-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
