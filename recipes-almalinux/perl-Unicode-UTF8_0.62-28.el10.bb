# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Unicode-UTF8"
PV = "0.62"
PR = "28.el10"
PACKAGES = " \
 perl-Unicode-UTF8 \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Unicode-UTF8-0.62-28.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d630625279792a647c3a1bb0a9a0298b69e7e2280fc76c98efad6aaab1546133"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Unicode-UTF8-0.62-28.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Unicode-UTF8;unpack=0"
SRC_URI[x86_64_v2_perl-Unicode-UTF8.sha256sum] = "98449c5ab55f98bd9c803875203608faa463482c7c54d5bbeec9f8c3be50c268"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Unicode-UTF8-0.62-28.el10.aarch64.rpm;name=aarch64_perl-Unicode-UTF8;unpack=0"
SRC_URI[aarch64_perl-Unicode-UTF8.sha256sum] = "bb54a9895e9dcf6e2ca30383e0921b198c31a76c02732016ead129a5353c7933"

RDEPENDS:perl-Unicode-UTF8 = " \
 glibc \
 perl-Exporter \
 perl-libs \
 "
