# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "flatpak"
PV = "1.16.0"
PR = "9.el10_2.1"
PACKAGES = " \
 flatpak \
 flatpak-devel \
 flatpak-libs \
 flatpak-selinux \
 flatpak-session-helper \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/flatpak-1.16.0-9.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2b2bb3a14e6b4c79d650121fcf367ccd0a413342bad0d448f31d5ec958af99e3"

URI_x86_64_v2_flatpak = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/flatpak-1.16.0-9.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_flatpak;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flatpak}"
SRC_URI[x86_64_v2_flatpak.sha256sum] = "0c31d436b97831e787da899c9c572316bd531e098303548d91cdbbbd273944ac"

URI_x86_64_v2_flatpak-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/flatpak-devel-1.16.0-9.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_flatpak-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flatpak-devel}"
SRC_URI[x86_64_v2_flatpak-devel.sha256sum] = "9b6ed3c8d68f25b41a1a01043bb09d3cc6e443e0dbe492e063fc8abcea7e663f"

URI_x86_64_v2_flatpak-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/flatpak-libs-1.16.0-9.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_flatpak-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flatpak-libs}"
SRC_URI[x86_64_v2_flatpak-libs.sha256sum] = "60d1d9f8bf0c9d8929a491dd9e93aa782ca90dce9d5cdcc1bc273b286662d0ea"

URI_x86_64_v2_flatpak-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/flatpak-selinux-1.16.0-9.el10_2.1.noarch.rpm;name=x86_64_v2_flatpak-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flatpak-selinux}"
SRC_URI[x86_64_v2_flatpak-selinux.sha256sum] = "22949ff4b832a5fbaf79d354cfc73af59a6746d662dcf4d0c294b24dcd69a9c7"

URI_x86_64_v2_flatpak-session-helper = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/flatpak-session-helper-1.16.0-9.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_flatpak-session-helper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flatpak-session-helper}"
SRC_URI[x86_64_v2_flatpak-session-helper.sha256sum] = "743d833aa29eba1625c8faf53e87297cce5ce176418548d7024bbcbb5212ed21"

URI_aarch64_flatpak = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/flatpak-1.16.0-9.el10_2.1.aarch64.rpm;name=aarch64_flatpak;unpack=0"
SRC_URI:append = " ${URI_aarch64_flatpak}"
SRC_URI[aarch64_flatpak.sha256sum] = "cfcb3c7fe3f1c47adcfcaeb3a71530ea886543cc6928a17a1de9ad74f0f69f59"

URI_aarch64_flatpak-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/flatpak-devel-1.16.0-9.el10_2.1.aarch64.rpm;name=aarch64_flatpak-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_flatpak-devel}"
SRC_URI[aarch64_flatpak-devel.sha256sum] = "b902ff54f1af13ed9d0a7c2263dc8242e09c13a3ca8c831b01682b5c4f833ad4"

URI_aarch64_flatpak-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/flatpak-libs-1.16.0-9.el10_2.1.aarch64.rpm;name=aarch64_flatpak-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_flatpak-libs}"
SRC_URI[aarch64_flatpak-libs.sha256sum] = "ab47ee54e8bbb0727e9b8f9e36b1e7edcdb250c0c5ab9448682ae233947ab8e7"

URI_aarch64_flatpak-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/flatpak-selinux-1.16.0-9.el10_2.1.noarch.rpm;name=aarch64_flatpak-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_flatpak-selinux}"
SRC_URI[aarch64_flatpak-selinux.sha256sum] = "22949ff4b832a5fbaf79d354cfc73af59a6746d662dcf4d0c294b24dcd69a9c7"

URI_aarch64_flatpak-session-helper = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/flatpak-session-helper-1.16.0-9.el10_2.1.aarch64.rpm;name=aarch64_flatpak-session-helper;unpack=0"
SRC_URI:append = " ${URI_aarch64_flatpak-session-helper}"
SRC_URI[aarch64_flatpak-session-helper.sha256sum] = "beab4085aa5c4e9527b41ac5af5b3b42dcd64a1ffdfba7b8d8906bf41455c9c3"

RDEPENDS:flatpak:x86_64_v2 = " \
 appstream \
 bash \
 bubblewrap \
 dconf \
 flatpak-selinux \
 flatpak-session-helper \
 fuse3 \
 fuse3-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 json-glib \
 libXau \
 libarchive \
 libgcc \
 librsvg2 \
 libseccomp \
 libwayland-client \
 libxml2 \
 libzstd \
 ostree-libs \
 polkit-libs \
 python3 \
 shadow-utils \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_x86-64__ge_7.29.0 \
 xdg-dbus-proxy \
"
RDEPENDS:flatpak:aarch64 = " \
 appstream \
 bash \
 bubblewrap \
 dconf \
 flatpak-selinux \
 flatpak-session-helper \
 fuse3 \
 fuse3-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 json-glib \
 libXau \
 libarchive \
 libgcc \
 librsvg2 \
 libseccomp \
 libwayland-client \
 libxml2 \
 libzstd \
 ostree-libs \
 polkit-libs \
 python3 \
 shadow-utils \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_aarch-64__ge_7.29.0 \
 xdg-dbus-proxy \
"
RDEPENDS:flatpak-devel = " \
 dconf-devel \
 flatpak \
 flatpak-libs \
 glib2-devel \
 gpgme-devel \
 json-glib-devel \
 libXau-devel \
 libarchive-devel \
 libcurl-devel \
 libseccomp-devel \
 libxml2-devel \
 libzstd-devel \
 ostree-devel \
 pkgconf-pkg-config \
 polkit-devel \
 systemd-devel \
 wayland-devel \
 "
RDEPENDS:flatpak-libs = " \
 bubblewrap \
 dconf \
 glib2 \
 glibc \
 json-glib \
 libXau \
 libarchive \
 libgcc \
 libseccomp \
 libwayland-client \
 libxml2 \
 libzstd \
 ostree-libs \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:flatpak-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 "
RDEPENDS:flatpak-session-helper = " \
 glib2 \
 glibc \
 libgcc \
 systemd \
 "
