# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gdbm"
PE = "1"
PV = "1.26"
PR = "15.el10"
PACKAGES = " \
 gdbm \
 gdbm-devel \
 gdbm-libs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/gdbm-1.26-15.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1513779a1a0fdc9098463f44d18127fd72d336894848638606625db97a456b49"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/gdbm-1.26-15.el10.x86_64_v2.rpm;name=x86_64_v2_gdbm;unpack=0"
SRC_URI[x86_64_v2_gdbm.sha256sum] = "e5a112201973038131b345d6ceb8c5cacdf67c112e58e4d31211692af5e871bd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gdbm-devel-1.26-15.el10.x86_64_v2.rpm;name=x86_64_v2_gdbm-devel;unpack=0"
SRC_URI[x86_64_v2_gdbm-devel.sha256sum] = "be96b15a4b88724ea032d1edaaefb4db1a137340b14645b2bda622881e984f66"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/gdbm-libs-1.26-15.el10.x86_64_v2.rpm;name=x86_64_v2_gdbm-libs;unpack=0"
SRC_URI[x86_64_v2_gdbm-libs.sha256sum] = "7589f918f9849b1bbc5d37a3bfed479e92e80fb662f5f8b9e1194e4abb4b96b0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/gdbm-1.26-15.el10.aarch64.rpm;name=aarch64_gdbm;unpack=0"
SRC_URI[aarch64_gdbm.sha256sum] = "51b85590e5bd58add50f6e416fdacbe7572ec82ba30a8341ba82fc8267fccdb9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gdbm-devel-1.26-15.el10.aarch64.rpm;name=aarch64_gdbm-devel;unpack=0"
SRC_URI[aarch64_gdbm-devel.sha256sum] = "05a0a00062b7879ef2080700c1a650ed8bfaf8582156864173e97dff7d0f609e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/gdbm-libs-1.26-15.el10.aarch64.rpm;name=aarch64_gdbm-libs;unpack=0"
SRC_URI[aarch64_gdbm-libs.sha256sum] = "adae880407252ae1a8e9d0341bd7b048e54176c1baff7651161122d5561a6415"

RDEPENDS:gdbm = " \
 gdbm-libs \
 glibc \
 readline \
 "
RDEPENDS:gdbm-devel = " \
 gdbm \
 gdbm-libs \
 info \
 "
RDEPENDS:gdbm-libs = " \
 glibc \
 "
