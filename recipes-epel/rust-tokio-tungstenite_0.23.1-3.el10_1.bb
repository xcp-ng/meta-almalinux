# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio-tungstenite"
PV = "0.23.1"
PR = "3.el10_1"
PACKAGES = " \
 rust-tokio-tungstenite+__rustls-tls-devel \
 rust-tokio-tungstenite+connect-devel \
 rust-tokio-tungstenite+default-devel \
 rust-tokio-tungstenite+handshake-devel \
 rust-tokio-tungstenite+native-tls-crate-devel \
 rust-tokio-tungstenite+native-tls-devel \
 rust-tokio-tungstenite+rustls-devel \
 rust-tokio-tungstenite+rustls-native-certs-devel \
 rust-tokio-tungstenite+rustls-pki-types-devel \
 rust-tokio-tungstenite+rustls-tls-native-roots-devel \
 rust-tokio-tungstenite+rustls-tls-webpki-roots-devel \
 rust-tokio-tungstenite+stream-devel \
 rust-tokio-tungstenite+tokio-native-tls-devel \
 rust-tokio-tungstenite+tokio-rustls-devel \
 rust-tokio-tungstenite+url-devel \
 rust-tokio-tungstenite+webpki-roots-devel \
 rust-tokio-tungstenite-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-tungstenite-0.23.1-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf2d68b1bbf05139e5d2f9dc7ab32701d82cb007c86d3eddb027ad58a145c737"

URI_x86_64_v2_rust-tokio-tungstenite+__rustls-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+__rustls-tls-devel-0.23.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+__rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+__rustls-tls-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+__rustls-tls-devel.sha256sum] = "7f1c8c3f15d22e355aebbaf43bd013555cc80eda0ed6dd2d6fc49e85be771964"

URI_x86_64_v2_rust-tokio-tungstenite+connect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+connect-devel-0.23.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+connect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+connect-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+connect-devel.sha256sum] = "62b2be5398cc130b7430eaf9bcf1173de8085bf666609d3d3898db7c5e019847"

URI_x86_64_v2_rust-tokio-tungstenite+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+default-devel-0.23.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+default-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+default-devel.sha256sum] = "19b304f6c6bd24ea6f6f70c548f9f223822124569fca211b8c0b8afea865d182"

URI_x86_64_v2_rust-tokio-tungstenite+handshake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+handshake-devel-0.23.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+handshake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+handshake-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+handshake-devel.sha256sum] = "bd8689ae241c28854697bb14d2546dc453e005faa51ae1c5a23994f0da6a8be0"

URI_x86_64_v2_rust-tokio-tungstenite+native-tls-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+native-tls-crate-devel-0.23.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+native-tls-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+native-tls-crate-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+native-tls-crate-devel.sha256sum] = "679bee23df4e229dbf12b118ef661c048a40be2d2bea49bd6cd0cc4ca343e5c4"

URI_x86_64_v2_rust-tokio-tungstenite+native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+native-tls-devel-0.23.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+native-tls-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+native-tls-devel.sha256sum] = "493cd0e65c65000108feddb7ab9f1743b790b880e06396437039fe4706cfed48"

URI_x86_64_v2_rust-tokio-tungstenite+rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+rustls-devel-0.23.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+rustls-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+rustls-devel.sha256sum] = "0bd9663c832d4651acb922403506ef5e8aee1f718a9d0c7a4a7595634ebcc239"

URI_x86_64_v2_rust-tokio-tungstenite+rustls-native-certs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+rustls-native-certs-devel-0.23.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+rustls-native-certs-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+rustls-native-certs-devel.sha256sum] = "23527cda6f4cc1f64275335cfa667a317737e7832df3f569b94a0fd1a357b7e7"

URI_x86_64_v2_rust-tokio-tungstenite+rustls-pki-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+rustls-pki-types-devel-0.23.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+rustls-pki-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+rustls-pki-types-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+rustls-pki-types-devel.sha256sum] = "70925c0a5068083eb8154bea2d948702d7ebfe6443c990c2782e2126cf659665"

URI_x86_64_v2_rust-tokio-tungstenite+rustls-tls-native-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+rustls-tls-native-roots-devel-0.23.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+rustls-tls-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+rustls-tls-native-roots-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+rustls-tls-native-roots-devel.sha256sum] = "dc1ca0b6d1bb932db3ad2e868270e9bdd4be68b8c0121956e213f5482db97f70"

URI_x86_64_v2_rust-tokio-tungstenite+rustls-tls-webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+rustls-tls-webpki-roots-devel-0.23.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+rustls-tls-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+rustls-tls-webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+rustls-tls-webpki-roots-devel.sha256sum] = "7744bd70ba7890b5f48657ce4f29e95642ce61c4f65c3847b046817d9b9b2250"

URI_x86_64_v2_rust-tokio-tungstenite+stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+stream-devel-0.23.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+stream-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+stream-devel.sha256sum] = "2d397dd5a688490beb3ee6df219a60155051af469b52f11a624a6e0fdb684c8b"

URI_x86_64_v2_rust-tokio-tungstenite+tokio-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+tokio-native-tls-devel-0.23.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+tokio-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+tokio-native-tls-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+tokio-native-tls-devel.sha256sum] = "e583c535a15f6a921e33f4554a037643e9d505b476e8cafa91c263a3674e89c1"

URI_x86_64_v2_rust-tokio-tungstenite+tokio-rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+tokio-rustls-devel-0.23.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+tokio-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+tokio-rustls-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+tokio-rustls-devel.sha256sum] = "eb01b6c9c241e4ad824e4c76184532a42739add37d0ae0ce689513a873e04bd1"

URI_x86_64_v2_rust-tokio-tungstenite+url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+url-devel-0.23.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+url-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+url-devel.sha256sum] = "5ed0e6902657fe9db83df497c0e379dd9877a1a3f0b7a82f055730b858d7649f"

URI_x86_64_v2_rust-tokio-tungstenite+webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+webpki-roots-devel-0.23.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+webpki-roots-devel.sha256sum] = "a2e646a4f48b0e61e420e43995cd386755717c4fbfd45c0c4dce8d46adaef893"

URI_x86_64_v2_rust-tokio-tungstenite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite-devel-0.23.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite-devel.sha256sum] = "9565f1b087ff795a56e95135eda4b945dc946df60ea9f399b1119da12cca1efa"

URI_aarch64_rust-tokio-tungstenite+__rustls-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+__rustls-tls-devel-0.23.1-3.el10_1.noarch.rpm;name=aarch64_rust-tokio-tungstenite+__rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+__rustls-tls-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+__rustls-tls-devel.sha256sum] = "8da0adbeaf2eee841637fd7a2fd7bf859c52c759b48c7ec22b35408f51c0ff6e"

URI_aarch64_rust-tokio-tungstenite+connect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+connect-devel-0.23.1-3.el10_1.noarch.rpm;name=aarch64_rust-tokio-tungstenite+connect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+connect-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+connect-devel.sha256sum] = "227967485bba0cd6cfea39b074ff7ad6ed08398aed4cf6e88a477af419574a36"

URI_aarch64_rust-tokio-tungstenite+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+default-devel-0.23.1-3.el10_1.noarch.rpm;name=aarch64_rust-tokio-tungstenite+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+default-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+default-devel.sha256sum] = "d02e5681971c7efde3ee98d017a94863d86decf77cbdaf3060635f7db65ea2f2"

URI_aarch64_rust-tokio-tungstenite+handshake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+handshake-devel-0.23.1-3.el10_1.noarch.rpm;name=aarch64_rust-tokio-tungstenite+handshake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+handshake-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+handshake-devel.sha256sum] = "45d8fcb887c3a816d8c7e32cceb994f14055e2edd0817c45fa0cdc739012cde7"

URI_aarch64_rust-tokio-tungstenite+native-tls-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+native-tls-crate-devel-0.23.1-3.el10_1.noarch.rpm;name=aarch64_rust-tokio-tungstenite+native-tls-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+native-tls-crate-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+native-tls-crate-devel.sha256sum] = "eb6418df9929dacf1cf53f0b09656c83fd92d8dc91d355246e5ab2c5d1de3cbe"

URI_aarch64_rust-tokio-tungstenite+native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+native-tls-devel-0.23.1-3.el10_1.noarch.rpm;name=aarch64_rust-tokio-tungstenite+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+native-tls-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+native-tls-devel.sha256sum] = "24db545fc454915bbf85c2b80717550344c792322163a6b7cf84c4d2fb41f9fc"

URI_aarch64_rust-tokio-tungstenite+rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+rustls-devel-0.23.1-3.el10_1.noarch.rpm;name=aarch64_rust-tokio-tungstenite+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+rustls-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+rustls-devel.sha256sum] = "d5392b580e1353be7cea5a5ff4989abf1fd19cc727f3b67a48c3f3a3def38ea0"

URI_aarch64_rust-tokio-tungstenite+rustls-native-certs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+rustls-native-certs-devel-0.23.1-3.el10_1.noarch.rpm;name=aarch64_rust-tokio-tungstenite+rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+rustls-native-certs-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+rustls-native-certs-devel.sha256sum] = "55008dcbb8cdc8ad4ce8824cdcdd89f094888e5e9c4e40b34ebc3c45206799c6"

URI_aarch64_rust-tokio-tungstenite+rustls-pki-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+rustls-pki-types-devel-0.23.1-3.el10_1.noarch.rpm;name=aarch64_rust-tokio-tungstenite+rustls-pki-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+rustls-pki-types-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+rustls-pki-types-devel.sha256sum] = "e0b0ffcdb7f22a9ec0199eca6b838f6107fb3a34ffa6749e26393b9f8ae34fe8"

URI_aarch64_rust-tokio-tungstenite+rustls-tls-native-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+rustls-tls-native-roots-devel-0.23.1-3.el10_1.noarch.rpm;name=aarch64_rust-tokio-tungstenite+rustls-tls-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+rustls-tls-native-roots-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+rustls-tls-native-roots-devel.sha256sum] = "457341c9999fb1464ffb49b8cfc939f21e6dacb9f78750d1948ec180a0095f58"

URI_aarch64_rust-tokio-tungstenite+rustls-tls-webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+rustls-tls-webpki-roots-devel-0.23.1-3.el10_1.noarch.rpm;name=aarch64_rust-tokio-tungstenite+rustls-tls-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+rustls-tls-webpki-roots-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+rustls-tls-webpki-roots-devel.sha256sum] = "e0fc8ddd00d6e7200d9df476ae2f691567ba42d42d29a14b146fdd945503219c"

URI_aarch64_rust-tokio-tungstenite+stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+stream-devel-0.23.1-3.el10_1.noarch.rpm;name=aarch64_rust-tokio-tungstenite+stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+stream-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+stream-devel.sha256sum] = "4db8364125bb29e2ac622aa9d606bfd9c05a742751718241b83db94c873c5fa6"

URI_aarch64_rust-tokio-tungstenite+tokio-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+tokio-native-tls-devel-0.23.1-3.el10_1.noarch.rpm;name=aarch64_rust-tokio-tungstenite+tokio-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+tokio-native-tls-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+tokio-native-tls-devel.sha256sum] = "ae605a504751902b9d157493a57589c1a4b37647d7699ef38ac21710af3e4d7f"

URI_aarch64_rust-tokio-tungstenite+tokio-rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+tokio-rustls-devel-0.23.1-3.el10_1.noarch.rpm;name=aarch64_rust-tokio-tungstenite+tokio-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+tokio-rustls-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+tokio-rustls-devel.sha256sum] = "397066cb22ed2676dad78aefd489ef903edc6866ef3412a824173fdbb0ce0a60"

URI_aarch64_rust-tokio-tungstenite+url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+url-devel-0.23.1-3.el10_1.noarch.rpm;name=aarch64_rust-tokio-tungstenite+url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+url-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+url-devel.sha256sum] = "d34587ab178f5f0903b5e1141417717804e702e9df1bbe9635b1714390175501"

URI_aarch64_rust-tokio-tungstenite+webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+webpki-roots-devel-0.23.1-3.el10_1.noarch.rpm;name=aarch64_rust-tokio-tungstenite+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+webpki-roots-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+webpki-roots-devel.sha256sum] = "009a7e8db9019498dfa50bd7398b961b05853912e3541681a12cdcb7303196cf"

URI_aarch64_rust-tokio-tungstenite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite-devel-0.23.1-3.el10_1.noarch.rpm;name=aarch64_rust-tokio-tungstenite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite-devel.sha256sum] = "d6f51ec87e848311422363f60fefe2d86f585a545256b8f9e92fac55e63f00d1"

RDEPENDS:rust-tokio-tungstenite+__rustls-tls-devel = " \
 cargo \
 rust-tokio-tungstenite+handshake-devel \
 rust-tokio-tungstenite+rustls-devel \
 rust-tokio-tungstenite+rustls-pki-types-devel \
 rust-tokio-tungstenite+stream-devel \
 rust-tokio-tungstenite+tokio-rustls-devel \
 rust-tokio-tungstenite-devel \
 rust-tungstenite+__rustls-tls-devel \
 "
RDEPENDS:rust-tokio-tungstenite+connect-devel = " \
 cargo \
 rust-tokio+net-devel \
 rust-tokio-tungstenite+handshake-devel \
 rust-tokio-tungstenite+stream-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+default-devel = " \
 cargo \
 rust-tokio-tungstenite+connect-devel \
 rust-tokio-tungstenite+handshake-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+handshake-devel = " \
 cargo \
 rust-tokio-tungstenite-devel \
 rust-tungstenite+handshake-devel \
 "
RDEPENDS:rust-tokio-tungstenite+native-tls-crate-devel = " \
 cargo \
 rust-native-tls+default-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+native-tls-devel = " \
 cargo \
 rust-tokio-tungstenite+handshake-devel \
 rust-tokio-tungstenite+native-tls-crate-devel \
 rust-tokio-tungstenite+stream-devel \
 rust-tokio-tungstenite+tokio-native-tls-devel \
 rust-tokio-tungstenite-devel \
 rust-tungstenite+native-tls-devel \
 "
RDEPENDS:rust-tokio-tungstenite+rustls-devel = " \
 cargo \
 rust-rustls-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+rustls-native-certs-devel = " \
 cargo \
 rust-rustls-native-certs0.7+default-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+rustls-pki-types-devel = " \
 cargo \
 rust-rustls-pki-types+default-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+rustls-tls-native-roots-devel = " \
 cargo \
 rust-tokio-tungstenite+__rustls-tls-devel \
 rust-tokio-tungstenite+rustls-native-certs-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+rustls-tls-webpki-roots-devel = " \
 cargo \
 rust-tokio-tungstenite+__rustls-tls-devel \
 rust-tokio-tungstenite+webpki-roots-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+stream-devel = " \
 cargo \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+tokio-native-tls-devel = " \
 cargo \
 rust-tokio-native-tls+default-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+tokio-rustls-devel = " \
 cargo \
 rust-tokio-rustls-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+url-devel = " \
 cargo \
 rust-tokio-tungstenite-devel \
 rust-tungstenite+url-devel \
 "
RDEPENDS:rust-tokio-tungstenite+webpki-roots-devel = " \
 cargo \
 rust-tokio-tungstenite-devel \
 rust-webpki-roots0.26+default-devel \
 "
RDEPENDS:rust-tokio-tungstenite-devel = " \
 cargo \
 rust \
 rust-futures-util+sink-devel \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 rust-log+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio-devel \
 rust-tungstenite-devel \
 "
