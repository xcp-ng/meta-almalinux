# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "htslib"
PV = "1.23.1"
PR = "1.el10_1"
PACKAGES = " \
 htslib \
 htslib-devel \
 htslib-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/htslib-1.23.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be512e121d8cabc7dfc024b473501c7a876cafb121b01aad4215ddbc43033d6a"

URI_x86_64_v2_htslib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/htslib-1.23.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_htslib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_htslib}"
SRC_URI[x86_64_v2_htslib.sha256sum] = "98bd7c63ae5d949b8ea7a3a855d1c3bbc636a9b44bbf7f11b704b9bbe5628fe7"

URI_x86_64_v2_htslib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/htslib-devel-1.23.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_htslib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_htslib-devel}"
SRC_URI[x86_64_v2_htslib-devel.sha256sum] = "d7ba7015d02e062e769f2c320e792f23e415a026281362f5ba54ddaf244b4f6b"

URI_x86_64_v2_htslib-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/htslib-tools-1.23.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_htslib-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_htslib-tools}"
SRC_URI[x86_64_v2_htslib-tools.sha256sum] = "6369664738ac085b78ede738a241d2badb8b434134300f184bfce5c9d67b727d"

URI_aarch64_htslib = "${EPEL_MIRROR}/aarch64/Packages/h/htslib-1.23.1-1.el10_1.aarch64.rpm;name=aarch64_htslib;unpack=0"
SRC_URI:append = " ${URI_aarch64_htslib}"
SRC_URI[aarch64_htslib.sha256sum] = "ce8dcd6d855be134fa4fd797b3cdde38cd262b8de5ba077c44ca1ae485a8452b"

URI_aarch64_htslib-devel = "${EPEL_MIRROR}/aarch64/Packages/h/htslib-devel-1.23.1-1.el10_1.aarch64.rpm;name=aarch64_htslib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_htslib-devel}"
SRC_URI[aarch64_htslib-devel.sha256sum] = "0d6b033628c31424afaa50dfdc3a2f444de6ee328088129e3ebdc6d4b3c2abbc"

URI_aarch64_htslib-tools = "${EPEL_MIRROR}/aarch64/Packages/h/htslib-tools-1.23.1-1.el10_1.aarch64.rpm;name=aarch64_htslib-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_htslib-tools}"
SRC_URI[aarch64_htslib-tools.sha256sum] = "ae2376b9b8dea57eb6317c33979667655fb661da04ab5a90458095c0998d88d1"

RDEPENDS:htslib = " \
 bzip2-libs \
 glibc \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:htslib-devel = " \
 htslib \
 pkgconf-pkg-config \
 "
RDEPENDS:htslib-tools = " \
 bzip2-libs \
 glibc \
 htslib \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 zlib-ng-compat \
 "
