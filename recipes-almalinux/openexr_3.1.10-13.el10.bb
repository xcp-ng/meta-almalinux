# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openexr"
PV = "3.1.10"
PR = "13.el10"
PACKAGES = " \
 openexr \
 openexr-devel \
 openexr-libs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/openexr-3.1.10-13.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e10238c6798f70e24cfab93f6f6277b1d52af170f597ca272031832b52edbb77"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openexr-3.1.10-13.el10.x86_64_v2.rpm;name=x86_64_v2_openexr;unpack=0"
SRC_URI[x86_64_v2_openexr.sha256sum] = "f144d78ec8e5ef3555a572838437b3bf09264206ab47f45f728968adab03c3e2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openexr-devel-3.1.10-13.el10.x86_64_v2.rpm;name=x86_64_v2_openexr-devel;unpack=0"
SRC_URI[x86_64_v2_openexr-devel.sha256sum] = "0c67c235d90b9508af250fef7bfd4d98dd7e2e0e522fa0312f82983c915b7630"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openexr-libs-3.1.10-13.el10.x86_64_v2.rpm;name=x86_64_v2_openexr-libs;unpack=0"
SRC_URI[x86_64_v2_openexr-libs.sha256sum] = "761153955817d65f82e88b2d8ef314f054f6924569afedaa3168e05ee6feecaa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openexr-3.1.10-13.el10.aarch64.rpm;name=aarch64_openexr;unpack=0"
SRC_URI[aarch64_openexr.sha256sum] = "184cfb6f504116290f7b54eefbf7cbde2ee9f3b7f4292060dc7875569ce37600"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openexr-devel-3.1.10-13.el10.aarch64.rpm;name=aarch64_openexr-devel;unpack=0"
SRC_URI[aarch64_openexr-devel.sha256sum] = "c1b6ecd9f38e8241c648a7f9f8496757cfd81db58a1d9d0843c07b7efda59a23"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openexr-libs-3.1.10-13.el10.aarch64.rpm;name=aarch64_openexr-libs;unpack=0"
SRC_URI[aarch64_openexr-libs.sha256sum] = "10af0c0157ffd206bfb29b51e0c10962f731fa2d4408724edcdc25bd8092a6f3"

RDEPENDS:openexr = " \
 glibc \
 imath \
 libgcc \
 libstdc++ \
 openexr-libs \
 "
RDEPENDS:openexr-devel = " \
 cmake-filesystem \
 imath-devel \
 openexr-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:openexr-libs = " \
 glibc \
 imath \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
