# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-timestamped-socket"
PV = "0.2.7"
PR = "2.el10_1"
PACKAGES = " \
 rust-timestamped-socket+default-devel \
 rust-timestamped-socket+serde-devel \
 rust-timestamped-socket-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-timestamped-socket-0.2.7-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fdbc3320479d5b990fb402d0e6ee4dccf5ded4869bd6862b83e85cb8c2993a86"

URI_x86_64_v2_rust-timestamped-socket+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-timestamped-socket+default-devel-0.2.7-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-timestamped-socket+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-timestamped-socket+default-devel}"
SRC_URI[x86_64_v2_rust-timestamped-socket+default-devel.sha256sum] = "04e403ccf594272fe6b47aa75bc2398c4d856c55f9b1257e59bd4eb630019d76"

URI_x86_64_v2_rust-timestamped-socket+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-timestamped-socket+serde-devel-0.2.7-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-timestamped-socket+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-timestamped-socket+serde-devel}"
SRC_URI[x86_64_v2_rust-timestamped-socket+serde-devel.sha256sum] = "35d7fd1d940bb5c1200c692a9dbe27c1c4231d8e04e2e5759afc25279e59ac0a"

URI_x86_64_v2_rust-timestamped-socket-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-timestamped-socket-devel-0.2.7-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-timestamped-socket-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-timestamped-socket-devel}"
SRC_URI[x86_64_v2_rust-timestamped-socket-devel.sha256sum] = "db0e74d1243c47f898168f5cd1c9375f5a81200bff0c1bb6b42bae95d2142a01"

URI_aarch64_rust-timestamped-socket+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-timestamped-socket+default-devel-0.2.7-2.el10_1.noarch.rpm;name=aarch64_rust-timestamped-socket+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-timestamped-socket+default-devel}"
SRC_URI[aarch64_rust-timestamped-socket+default-devel.sha256sum] = "198408075c7ba482756343e8ffb085b8284923f65bc1117ad235830995874391"

URI_aarch64_rust-timestamped-socket+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-timestamped-socket+serde-devel-0.2.7-2.el10_1.noarch.rpm;name=aarch64_rust-timestamped-socket+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-timestamped-socket+serde-devel}"
SRC_URI[aarch64_rust-timestamped-socket+serde-devel.sha256sum] = "b32acf796004089088807e2fb3e3aa2102d220863383c05f015330a4185b51c7"

URI_aarch64_rust-timestamped-socket-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-timestamped-socket-devel-0.2.7-2.el10_1.noarch.rpm;name=aarch64_rust-timestamped-socket-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-timestamped-socket-devel}"
SRC_URI[aarch64_rust-timestamped-socket-devel.sha256sum] = "4c9d494b7cd762f2cbd73347c3648e13674db476ccb0e16f7c02041b46ad7b5b"

RDEPENDS:rust-timestamped-socket+default-devel = " \
 cargo \
 rust-timestamped-socket+serde-devel \
 rust-timestamped-socket-devel \
 "
RDEPENDS:rust-timestamped-socket+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-timestamped-socket-devel \
 "
RDEPENDS:rust-timestamped-socket-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 rust-tokio+default-devel \
 rust-tokio+net-devel \
 rust-tokio+time-devel \
 rust-tracing+log-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
