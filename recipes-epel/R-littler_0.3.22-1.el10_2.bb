# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "R-littler"
PV = "0.3.22"
PR = "1.el10_2"
PACKAGES = " \
 R-littler \
 R-littler-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/R-littler-0.3.22-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "46ac266dafc3c8f7b1c0f94e0afa13bf6d3bcc088628725e5d64243fd44052d5"

URI_x86_64_v2_R-littler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-littler-0.3.22-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-littler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-littler}"
SRC_URI[x86_64_v2_R-littler.sha256sum] = "b5319d0b7ff0661e96e83f1dff06d88f617f2efde55c9b60f69a31add5687e01"

URI_x86_64_v2_R-littler-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-littler-examples-0.3.22-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-littler-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-littler-examples}"
SRC_URI[x86_64_v2_R-littler-examples.sha256sum] = "c5b0daa37a875086658eb71d0c40879062c07024c27a240f14b1da12bf79ae3f"

URI_aarch64_R-littler = "${EPEL_MIRROR}/aarch64/Packages/r/R-littler-0.3.22-1.el10_2.aarch64.rpm;name=aarch64_R-littler;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-littler}"
SRC_URI[aarch64_R-littler.sha256sum] = "b6527b57893e38abcd69bb88929e6834835d5aec4965df6a8d721b02e467b568"

URI_aarch64_R-littler-examples = "${EPEL_MIRROR}/aarch64/Packages/r/R-littler-examples-0.3.22-1.el10_2.aarch64.rpm;name=aarch64_R-littler-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-littler-examples}"
SRC_URI[aarch64_R-littler-examples.sha256sum] = "eeef41808d6b0f9fc7b76cad83b9b7f2e4571d821203ee25742eb88c85b22613"

RDEPENDS:R-littler = " \
 R-core \
 glibc \
 "
RDEPENDS:R-littler-examples = " \
 R-littler \
 "
