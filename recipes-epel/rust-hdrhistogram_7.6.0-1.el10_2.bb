# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hdrhistogram"
PV = "7.6.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-hdrhistogram+bench_private-devel \
 rust-hdrhistogram+default-devel \
 rust-hdrhistogram+serialization-devel \
 rust-hdrhistogram+sync-devel \
 rust-hdrhistogram-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hdrhistogram-7.6.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c56efc489a7e1b879e1ae37b9226b2dbbe64e0641fcaf4334454b1c78c59d74"

URI_x86_64_v2_rust-hdrhistogram+bench_private-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hdrhistogram+bench_private-devel-7.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hdrhistogram+bench_private-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hdrhistogram+bench_private-devel}"
SRC_URI[x86_64_v2_rust-hdrhistogram+bench_private-devel.sha256sum] = "037e3b74581703ba1686d00c18a6aee170ee1a4bf52ec669cb0626c6d48c94e9"

URI_x86_64_v2_rust-hdrhistogram+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hdrhistogram+default-devel-7.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hdrhistogram+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hdrhistogram+default-devel}"
SRC_URI[x86_64_v2_rust-hdrhistogram+default-devel.sha256sum] = "e14f4e0c07ae3e6fbd14d0cbcf5a8f6e4f2c7ff2f9b31d416fd77f394d2c6aa8"

URI_x86_64_v2_rust-hdrhistogram+serialization-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hdrhistogram+serialization-devel-7.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hdrhistogram+serialization-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hdrhistogram+serialization-devel}"
SRC_URI[x86_64_v2_rust-hdrhistogram+serialization-devel.sha256sum] = "567f75ce558b66ee1af4a1a1335a2a4c037a24b160dc0f6151aa66e7efdf15a7"

URI_x86_64_v2_rust-hdrhistogram+sync-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hdrhistogram+sync-devel-7.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hdrhistogram+sync-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hdrhistogram+sync-devel}"
SRC_URI[x86_64_v2_rust-hdrhistogram+sync-devel.sha256sum] = "ecce932e2e6d4d1e89757dcd29d6f80e7259c9a74ed8a859cc7197500f2221e2"

URI_x86_64_v2_rust-hdrhistogram-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hdrhistogram-devel-7.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hdrhistogram-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hdrhistogram-devel}"
SRC_URI[x86_64_v2_rust-hdrhistogram-devel.sha256sum] = "21ea2d9b2e5b29040eb376bfd0c072a78252169091b6ede128df92a18c955745"

URI_aarch64_rust-hdrhistogram+bench_private-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hdrhistogram+bench_private-devel-7.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-hdrhistogram+bench_private-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hdrhistogram+bench_private-devel}"
SRC_URI[aarch64_rust-hdrhistogram+bench_private-devel.sha256sum] = "e5b18f766c51a49dedcb24819d4084d0b23d3d2373acf161716fc5e335521c85"

URI_aarch64_rust-hdrhistogram+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hdrhistogram+default-devel-7.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-hdrhistogram+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hdrhistogram+default-devel}"
SRC_URI[aarch64_rust-hdrhistogram+default-devel.sha256sum] = "8a04484b2bd78feef0fdabe12e7cdd711074c025f787227f05a054182cc50628"

URI_aarch64_rust-hdrhistogram+serialization-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hdrhistogram+serialization-devel-7.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-hdrhistogram+serialization-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hdrhistogram+serialization-devel}"
SRC_URI[aarch64_rust-hdrhistogram+serialization-devel.sha256sum] = "dffd3736bfb439e40be6461798d9366ef90e5f2046015845eb10d962d4b3113c"

URI_aarch64_rust-hdrhistogram+sync-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hdrhistogram+sync-devel-7.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-hdrhistogram+sync-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hdrhistogram+sync-devel}"
SRC_URI[aarch64_rust-hdrhistogram+sync-devel.sha256sum] = "7211ae25f8487eeca1aeac4f1909f0f428f7e3cd21e941b12a134ba589809715"

URI_aarch64_rust-hdrhistogram-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hdrhistogram-devel-7.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-hdrhistogram-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hdrhistogram-devel}"
SRC_URI[aarch64_rust-hdrhistogram-devel.sha256sum] = "b622e0b5a50ecdf2a32a76dbf9c45c49ec23bb8e484b44b8cb946a46258045d5"

RDEPENDS:rust-hdrhistogram+bench_private-devel = " \
 cargo \
 rust-hdrhistogram-devel \
 "
RDEPENDS:rust-hdrhistogram+default-devel = " \
 cargo \
 rust-hdrhistogram+serialization-devel \
 rust-hdrhistogram+sync-devel \
 rust-hdrhistogram-devel \
 "
RDEPENDS:rust-hdrhistogram+serialization-devel = " \
 cargo \
 rust-base64+default-devel \
 rust-flate2+default-devel \
 rust-hdrhistogram-devel \
 rust-nom+default-devel \
 "
RDEPENDS:rust-hdrhistogram+sync-devel = " \
 cargo \
 rust-crossbeam-channel+default-devel \
 rust-hdrhistogram-devel \
 "
RDEPENDS:rust-hdrhistogram-devel = " \
 cargo \
 rust \
 rust-byteorder+default-devel \
 rust-num-traits+default-devel \
 "
