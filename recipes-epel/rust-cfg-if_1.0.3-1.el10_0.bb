# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cfg-if"
PV = "1.0.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-cfg-if+default-devel \
 rust-cfg-if-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cfg-if-1.0.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fdaaca101072c7ea147d7b7696f31c8dad0cc025df40f73484ce46a30e5f0e05"

URI_x86_64_v2_rust-cfg-if+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg-if+default-devel-1.0.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg-if+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfg-if+default-devel}"
SRC_URI[x86_64_v2_rust-cfg-if+default-devel.sha256sum] = "618367a050e0c855cb79b1cb9f96e6fb44b3f34733a9b1b3d53cb70a1c8fe772"

URI_x86_64_v2_rust-cfg-if-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg-if-devel-1.0.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg-if-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfg-if-devel}"
SRC_URI[x86_64_v2_rust-cfg-if-devel.sha256sum] = "7e41adfbe8a4d6d8276f888852d9e7ddd8b5bf4be8cca01ad613b0879f20e589"

URI_aarch64_rust-cfg-if+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg-if+default-devel-1.0.3-1.el10_0.noarch.rpm;name=aarch64_rust-cfg-if+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfg-if+default-devel}"
SRC_URI[aarch64_rust-cfg-if+default-devel.sha256sum] = "9c580afb4b28e6433b58006a45535e44293eb9dbe4a55beac1b2638c09fb5013"

URI_aarch64_rust-cfg-if-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg-if-devel-1.0.3-1.el10_0.noarch.rpm;name=aarch64_rust-cfg-if-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfg-if-devel}"
SRC_URI[aarch64_rust-cfg-if-devel.sha256sum] = "29016e7d882b5589b24b5923ef96bd6febf351353c966a2f733957c0722c1b32"

RDEPENDS:rust-cfg-if+default-devel = " \
 cargo \
 rust-cfg-if-devel \
 "
RDEPENDS:rust-cfg-if-devel = " \
 cargo \
 "
