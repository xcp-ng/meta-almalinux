# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "passt"
PV = "0^20260728.gf8df3f1"
PR = "1.el10"
PACKAGES = " \
 passt \
 passt-selinux \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/passt-0^20260728.gf8df3f1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a2d4ab713f9b96a126249b2ff03de73d276a53052470d05284a7c420ad5b3f6a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/passt-0^20260728.gf8df3f1-1.el10.x86_64_v2.rpm;name=x86_64_v2_passt;unpack=0"
SRC_URI[x86_64_v2_passt.sha256sum] = "0f3037313b2ffa7b472388dc825e9d80e14b35fe5911a8622d4285c60648c8e7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/passt-selinux-0^20260728.gf8df3f1-1.el10.noarch.rpm;name=x86_64_v2_passt-selinux;unpack=0"
SRC_URI[x86_64_v2_passt-selinux.sha256sum] = "efb313fecd879312a379d05d4090d667ed55c0e70564adb8a113aa5430cbf56f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/passt-0^20260728.gf8df3f1-1.el10.aarch64.rpm;name=aarch64_passt;unpack=0"
SRC_URI[aarch64_passt.sha256sum] = "37eff3658d254565f4baf5b85d5ff4f6ad537230f5066694d7dad489b73719f7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/passt-selinux-0^20260728.gf8df3f1-1.el10.noarch.rpm;name=aarch64_passt-selinux;unpack=0"
SRC_URI[aarch64_passt-selinux.sha256sum] = "efb313fecd879312a379d05d4090d667ed55c0e70564adb8a113aa5430cbf56f"

RDEPENDS:passt = " \
 glibc \
 passt-selinux \
 "
RDEPENDS:passt-selinux = " \
 bash \
 container-selinux \
 libselinux-utils \
 policycoreutils \
 selinux-policy-targeted \
 "
