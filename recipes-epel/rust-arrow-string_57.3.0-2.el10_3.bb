# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-arrow-string"
PV = "57.3.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-arrow-string+default-devel \
 rust-arrow-string-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-arrow-string-57.3.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3368056f1a48e393ab9dce3423b40d4de657b6d72dc3aa1d3175e1a42ef34e33"

URI_x86_64_v2_rust-arrow-string+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-string+default-devel-57.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-string+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-string+default-devel}"
SRC_URI[x86_64_v2_rust-arrow-string+default-devel.sha256sum] = "9afe11c2d85ea753787c1c8b9a85e74996ad222dcb6e760ab213f40eff3cb9a7"

URI_x86_64_v2_rust-arrow-string-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-string-devel-57.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-string-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-string-devel}"
SRC_URI[x86_64_v2_rust-arrow-string-devel.sha256sum] = "2064d34cd8e999f39a755bfd026658fd1dd06877fa9c4888ac1904f2f672f4e1"

URI_aarch64_rust-arrow-string+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-string+default-devel-57.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-arrow-string+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-string+default-devel}"
SRC_URI[aarch64_rust-arrow-string+default-devel.sha256sum] = "27a82cd81d365d59df6542c8d749b45d48cc324bd5752c430b39ab2ba3b8c977"

URI_aarch64_rust-arrow-string-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-string-devel-57.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-arrow-string-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-string-devel}"
SRC_URI[aarch64_rust-arrow-string-devel.sha256sum] = "89119174bca2db4a6de95b3c1c086cc9c62251b11c580b1f29812615bc25bbdb"

RDEPENDS:rust-arrow-string+default-devel = " \
 cargo \
 rust-arrow-string-devel \
 "
RDEPENDS:rust-arrow-string-devel = " \
 cargo \
 rust \
 rust-arrow-array+default-devel \
 rust-arrow-buffer+default-devel \
 rust-arrow-data+default-devel \
 rust-arrow-schema+default-devel \
 rust-arrow-select+default-devel \
 rust-memchr+default-devel \
 rust-num-traits+std-devel \
 rust-num-traits-devel \
 rust-regex+perf-devel \
 rust-regex+std-devel \
 rust-regex+unicode-devel \
 rust-regex-devel \
 rust-regex-syntax+unicode-devel \
 rust-regex-syntax-devel \
 "
