# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-execnet"
PV = "2.1.2"
PR = "1.el10_1"
PACKAGES = " \
 python3-execnet \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-execnet-2.1.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "84ce238c7cdde406c9bb5ce54f67b3b01ebaf8a0fafabbc3d17535606b4fb174"

URI_x86_64_v2_python3-execnet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-execnet-2.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-execnet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-execnet}"
SRC_URI[x86_64_v2_python3-execnet.sha256sum] = "f65c4d88a9c648ade71f00ccc21dc40879efba8a196ef2435b5d1d6c1662e7eb"

URI_aarch64_python3-execnet = "${EPEL_MIRROR}/aarch64/Packages/p/python3-execnet-2.1.2-1.el10_1.noarch.rpm;name=aarch64_python3-execnet;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-execnet}"
SRC_URI[aarch64_python3-execnet.sha256sum] = "600450ecb8381e472ea2a2b05615e3b83dac24d81666ae739197e8e373ac044d"

RDEPENDS:python3-execnet = " \
 python3 \
 "
