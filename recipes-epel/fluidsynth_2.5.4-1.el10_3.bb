# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fluidsynth"
PV = "2.5.4"
PR = "1.el10_3"
PACKAGES = " \
 fluidsynth \
 fluidsynth-devel \
 fluidsynth-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fluidsynth-2.5.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e567b403631fa24248a085f10cedf4d3b1eb3f0c018589d050ef2cc3cebebc06"

URI_x86_64_v2_fluidsynth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fluidsynth-2.5.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fluidsynth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fluidsynth}"
SRC_URI[x86_64_v2_fluidsynth.sha256sum] = "a6c346a5b9624a22a8e46c2a8267550d4d4a70eedddb0200c7136722b3b263b1"

URI_x86_64_v2_fluidsynth-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fluidsynth-devel-2.5.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fluidsynth-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fluidsynth-devel}"
SRC_URI[x86_64_v2_fluidsynth-devel.sha256sum] = "93995bad1ded4e5f98f138d0dfc00dbbc0d5577575896e77e62e65aec1297e56"

URI_x86_64_v2_fluidsynth-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fluidsynth-libs-2.5.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fluidsynth-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fluidsynth-libs}"
SRC_URI[x86_64_v2_fluidsynth-libs.sha256sum] = "81b39aa95ec8ca486d1a52661b79eb361cd70662ed387334161305721bf90c6b"

URI_aarch64_fluidsynth = "${EPEL_MIRROR}/aarch64/Packages/f/fluidsynth-2.5.4-1.el10_3.aarch64.rpm;name=aarch64_fluidsynth;unpack=0"
SRC_URI:append = " ${URI_aarch64_fluidsynth}"
SRC_URI[aarch64_fluidsynth.sha256sum] = "4450f6763b68caaf8a130dbdeec8e56935a79298592d0518e31e18bba422d4da"

URI_aarch64_fluidsynth-devel = "${EPEL_MIRROR}/aarch64/Packages/f/fluidsynth-devel-2.5.4-1.el10_3.aarch64.rpm;name=aarch64_fluidsynth-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_fluidsynth-devel}"
SRC_URI[aarch64_fluidsynth-devel.sha256sum] = "61e4144cb82d761d371df7694e4862622a401a5ac65e70bf5cf396bcc429d9b5"

URI_aarch64_fluidsynth-libs = "${EPEL_MIRROR}/aarch64/Packages/f/fluidsynth-libs-2.5.4-1.el10_3.aarch64.rpm;name=aarch64_fluidsynth-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_fluidsynth-libs}"
SRC_URI[aarch64_fluidsynth-libs.sha256sum] = "4aa5d4b6fc7ad390000d58e31b8d2bf4cd3864894b72b0cd6d6c17aa1dbf4a2a"

RDEPENDS:fluidsynth = " \
 fluidsynth-libs \
 glib2 \
 glibc \
 pipewire-libs \
 systemd-libs \
 "
RDEPENDS:fluidsynth-devel = " \
 alsa-lib-devel \
 cmake-filesystem \
 dbus-devel \
 fluidsynth \
 fluidsynth-libs \
 glib2-devel \
 libsndfile-devel \
 pipewire-devel \
 pipewire-jack-audio-connection-kit-devel \
 pkgconf-pkg-config \
 pulseaudio-libs-devel \
 readline-devel \
 systemd-devel \
 "
RDEPENDS:fluidsynth-libs = " \
 alsa-lib \
 dbus-libs \
 glib2 \
 glibc \
 libgcc \
 libgomp \
 libsndfile \
 libstdc++ \
 pipewire-jack-audio-connection-kit-libs \
 pipewire-libs \
 pulseaudio-libs \
 readline \
 "
