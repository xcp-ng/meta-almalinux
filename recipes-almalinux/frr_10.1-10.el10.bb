# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "frr"
PV = "10.1"
PR = "10.el10"
PACKAGES = " \
 frr \
 frr-selinux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/frr-10.1-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "416b1271727439410cd9b4fb06dbd1552e92e87b1b16ff27ad2859565174410a"

URI_x86_64_v2_frr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/frr-10.1-10.el10.x86_64_v2.rpm;name=x86_64_v2_frr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_frr}"
SRC_URI[x86_64_v2_frr.sha256sum] = "816d51fb91e4e1c82c96976d61b0fc6137dc07b26685aa6e8dc1df3d399be9da"

URI_x86_64_v2_frr-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/frr-selinux-10.1-10.el10.noarch.rpm;name=x86_64_v2_frr-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_frr-selinux}"
SRC_URI[x86_64_v2_frr-selinux.sha256sum] = "6b07ae536f8e29c726097c13972afd8cd3925c6cf2b915544272fbfcad41b24a"

URI_aarch64_frr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/frr-10.1-10.el10.aarch64.rpm;name=aarch64_frr;unpack=0"
SRC_URI:append = " ${URI_aarch64_frr}"
SRC_URI[aarch64_frr.sha256sum] = "0cc1b73dd4a80988058a4566fcefaf6f2b4159efaca2d08abfd12d577e0b681e"

URI_aarch64_frr-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/frr-selinux-10.1-10.el10.noarch.rpm;name=aarch64_frr-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_frr-selinux}"
SRC_URI[aarch64_frr-selinux.sha256sum] = "6b07ae536f8e29c726097c13972afd8cd3925c6cf2b915544272fbfcad41b24a"

RDEPENDS:frr:x86_64_v2 = " \
 bash \
 c-ares \
 frr-selinux \
 glibc \
 hostname \
 json-c \
 libcap \
 libgcc \
 libxcrypt \
 libyang \
 ncurses \
 net-snmp \
 net-snmp-agent-libs \
 net-snmp-libs \
 openssl-libs \
 protobuf-c \
 python3 \
 readline \
 rpm-libs \
 shadow-utils \
 systemd \
"
RDEPENDS:frr:aarch64 = " \
 bash \
 c-ares \
 frr-selinux \
 glibc \
 hostname \
 json-c \
 libatomic \
 libcap \
 libgcc \
 libxcrypt \
 libyang \
 ncurses \
 net-snmp \
 net-snmp-agent-libs \
 net-snmp-libs \
 openssl-libs \
 protobuf-c \
 python3 \
 readline \
 rpm-libs \
 shadow-utils \
 systemd \
"
RDEPENDS:frr-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
