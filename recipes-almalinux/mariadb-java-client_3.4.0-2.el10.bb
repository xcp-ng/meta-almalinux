# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mariadb-java-client"
PV = "3.4.0"
PR = "2.el10"
PACKAGES = " \
 mariadb-java-client \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mariadb-java-client-3.4.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "de4d007789b82276010d8c7edafb4504f618569772eed4e9d6db04670632bdac"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-java-client-3.4.0-2.el10.noarch.rpm;name=x86_64_v2_mariadb-java-client;unpack=0"
SRC_URI[x86_64_v2_mariadb-java-client.sha256sum] = "826efd7594ff2af87fe50f858b29a4f7066c2c69a059202c5d3846abebf5763b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-java-client-3.4.0-2.el10.noarch.rpm;name=aarch64_mariadb-java-client;unpack=0"
SRC_URI[aarch64_mariadb-java-client.sha256sum] = "826efd7594ff2af87fe50f858b29a4f7066c2c69a059202c5d3846abebf5763b"

RDEPENDS:mariadb-java-client = " \
 javapackages-filesystem \
 jna \
 jna-contrib \
 slf4j \
 "
