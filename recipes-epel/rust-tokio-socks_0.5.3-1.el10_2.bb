# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio-socks"
PV = "0.5.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-tokio-socks+default-devel \
 rust-tokio-socks+futures-io-devel \
 rust-tokio-socks+tokio-devel \
 rust-tokio-socks+tor-devel \
 rust-tokio-socks-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-socks-0.5.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "318939be9aca57c04112ebe308a3843ab47f3637cf9d6ba1052872e9851861b4"

URI_x86_64_v2_rust-tokio-socks+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-socks+default-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-socks+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-socks+default-devel}"
SRC_URI[x86_64_v2_rust-tokio-socks+default-devel.sha256sum] = "f391e868e8e7687a61bb8d5fe11ce729720eca80283ced1b7c89e4c98d0ba3da"

URI_x86_64_v2_rust-tokio-socks+futures-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-socks+futures-io-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-socks+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-socks+futures-io-devel}"
SRC_URI[x86_64_v2_rust-tokio-socks+futures-io-devel.sha256sum] = "474f1703d3612ec44ba2786e597dd4cd6aa8c2a05086d67d1893bb545f4a9a11"

URI_x86_64_v2_rust-tokio-socks+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-socks+tokio-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-socks+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-socks+tokio-devel}"
SRC_URI[x86_64_v2_rust-tokio-socks+tokio-devel.sha256sum] = "360baa89d5c816f328d159bcd1ce54b67c9b3cd9565d0aaa5589ff142f105327"

URI_x86_64_v2_rust-tokio-socks+tor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-socks+tor-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-socks+tor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-socks+tor-devel}"
SRC_URI[x86_64_v2_rust-tokio-socks+tor-devel.sha256sum] = "62cb9e51790fa4416cec87755c2af427950a6a235da46438f01f419b2062e733"

URI_x86_64_v2_rust-tokio-socks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-socks-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-socks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-socks-devel}"
SRC_URI[x86_64_v2_rust-tokio-socks-devel.sha256sum] = "fd9d6d44d490462d54eacd296f170feb32b82e9cf9419fff187616853db77c66"

URI_aarch64_rust-tokio-socks+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-socks+default-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-socks+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-socks+default-devel}"
SRC_URI[aarch64_rust-tokio-socks+default-devel.sha256sum] = "521d7c38be521e7d97e589bdc705b6407199435902c146edbdbf86c492b75a34"

URI_aarch64_rust-tokio-socks+futures-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-socks+futures-io-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-socks+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-socks+futures-io-devel}"
SRC_URI[aarch64_rust-tokio-socks+futures-io-devel.sha256sum] = "27e2705c605fa4166649b87aa43ef80b5b06646344df2731d591b69c767e1a6c"

URI_aarch64_rust-tokio-socks+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-socks+tokio-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-socks+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-socks+tokio-devel}"
SRC_URI[aarch64_rust-tokio-socks+tokio-devel.sha256sum] = "8f658edbdae0138732c144322f3377248688203f785d5c58e352dc4e0146ac92"

URI_aarch64_rust-tokio-socks+tor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-socks+tor-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-socks+tor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-socks+tor-devel}"
SRC_URI[aarch64_rust-tokio-socks+tor-devel.sha256sum] = "9c21c19ebf1c154a748e5f50d105902c68811a31797f50f010de78678495174c"

URI_aarch64_rust-tokio-socks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-socks-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-socks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-socks-devel}"
SRC_URI[aarch64_rust-tokio-socks-devel.sha256sum] = "986686681de50f1cd85600a63cb5e7b801c6f584761644f6b88d3456585140e7"

RDEPENDS:rust-tokio-socks+default-devel = " \
 cargo \
 rust-tokio-socks+tokio-devel \
 rust-tokio-socks-devel \
 "
RDEPENDS:rust-tokio-socks+futures-io-devel = " \
 cargo \
 rust-futures-io+default-devel \
 rust-tokio-socks-devel \
 "
RDEPENDS:rust-tokio-socks+tokio-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio+net-devel \
 rust-tokio-socks-devel \
 "
RDEPENDS:rust-tokio-socks+tor-devel = " \
 cargo \
 rust-tokio-socks-devel \
 "
RDEPENDS:rust-tokio-socks-devel = " \
 bash \
 cargo \
 rust-either+default-devel \
 rust-futures-util-devel \
 rust-thiserror1+default-devel \
 "
