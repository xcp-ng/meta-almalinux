# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kernel"
PV = "6.12.0"
PR = "55.43.1.el10_0"
PACKAGES:x86_64_v2 = " \
 kernel \
 kernel-abi-stablelists \
 kernel-core \
 kernel-cross-headers \
 kernel-debug \
 kernel-debug-core \
 kernel-debug-devel \
 kernel-debug-devel-matched \
 kernel-debug-modules \
 kernel-debug-modules-core \
 kernel-debug-modules-extra \
 kernel-debug-uki-virt \
 kernel-devel \
 kernel-devel-matched \
 kernel-doc \
 kernel-headers \
 kernel-modules \
 kernel-modules-core \
 kernel-modules-extra \
 kernel-tools \
 kernel-tools-libs \
 kernel-tools-libs-devel \
 kernel-uki-virt \
 kernel-uki-virt-addons \
 libperf \
 perf \
 python3-perf \
 rtla \
 rv \
"
PACKAGES:aarch64 = " \
 kernel \
 kernel-64k \
 kernel-64k-core \
 kernel-64k-debug \
 kernel-64k-debug-core \
 kernel-64k-debug-devel \
 kernel-64k-debug-devel-matched \
 kernel-64k-debug-modules \
 kernel-64k-debug-modules-core \
 kernel-64k-debug-modules-extra \
 kernel-64k-devel \
 kernel-64k-devel-matched \
 kernel-64k-modules \
 kernel-64k-modules-core \
 kernel-64k-modules-extra \
 kernel-abi-stablelists \
 kernel-core \
 kernel-cross-headers \
 kernel-debug \
 kernel-debug-core \
 kernel-debug-devel \
 kernel-debug-devel-matched \
 kernel-debug-modules \
 kernel-debug-modules-core \
 kernel-debug-modules-extra \
 kernel-devel \
 kernel-devel-matched \
 kernel-doc \
 kernel-headers \
 kernel-modules \
 kernel-modules-core \
 kernel-modules-extra \
 kernel-tools \
 kernel-tools-libs \
 kernel-tools-libs-devel \
 kernel-uki-virt \
 kernel-uki-virt-addons \
 libperf \
 perf \
 python3-perf \
 rtla \
 rv \
"

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/kernel-6.12.0-55.43.1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28960e05e71f8976591f354048ea885db970ce8bb1d9cedc0e2de20bd32675c3"

URI_x86_64_v2_kernel = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_kernel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel}"
SRC_URI[x86_64_v2_kernel.sha256sum] = "7ed1eaa79137cd867af1fb9b8208eb48d850802cc0eb2885b17a2bd50363c1df"
RPROVIDES:kernel:x86_64_v2 = "virtual/kernel"

URI_x86_64_v2_kernel-abi-stablelists = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-abi-stablelists-6.12.0-55.43.1.el10_0.noarch.rpm;name=x86_64_v2_kernel-abi-stablelists;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-abi-stablelists}"
SRC_URI[x86_64_v2_kernel-abi-stablelists.sha256sum] = "aadc2e9b1e386f1ea6664405610136dd4772241a6002cfe18a718f14592c63cd"

URI_x86_64_v2_kernel-core = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-core-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_kernel-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-core}"
SRC_URI[x86_64_v2_kernel-core.sha256sum] = "42073ee7cd348bbbf08be0d51db5cbdd71cf6e8905559959e2a9fdcefc58c19d"
RPROVIDES:kernel-core:x86_64_v2 = "virtual/kernel virtual/kernel-uname-r_eq_6.12.0-55.43.1.el10_0.x86_64_v2"

URI_x86_64_v2_kernel-cross-headers = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/kernel-cross-headers-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_kernel-cross-headers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-cross-headers}"
SRC_URI[x86_64_v2_kernel-cross-headers.sha256sum] = "49a1143ce75b0872be86d42ca5e92db0a9ad1a29d2af60ecb5e1f8523af752b4"

URI_x86_64_v2_kernel-debug = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_kernel-debug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-debug}"
SRC_URI[x86_64_v2_kernel-debug.sha256sum] = "04c926a435ff8a3f36373d7094ef8d71f4675d9554bdf60869082a68a2edf4f4"

URI_x86_64_v2_kernel-debug-core = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-core-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-debug-core}"
SRC_URI[x86_64_v2_kernel-debug-core.sha256sum] = "b4443608bd3d80dae8450e25e2406a91f96355b46d2f33f8828f5ee1c1902bef"
RPROVIDES:kernel-debug-core:x86_64_v2 = "virtual/kernel virtual/kernel-uname-r_eq_6.12.0-55.43.1.el10_0.x86_64_v2++debug"

URI_x86_64_v2_kernel-debug-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-debug-devel-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-debug-devel}"
SRC_URI[x86_64_v2_kernel-debug-devel.sha256sum] = "53011502c6c41ce171d7fafb50741d84ab4f4f50fed003e42a5b2c4a5df9d2f2"
RPROVIDES:kernel-debug-devel:x86_64_v2 = "virtual/kernel-devel-uname-r"

URI_x86_64_v2_kernel-debug-devel-matched = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-debug-devel-matched-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-devel-matched;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-debug-devel-matched}"
SRC_URI[x86_64_v2_kernel-debug-devel-matched.sha256sum] = "12a587eb8883367a0e88889e73ce6814ba38ce710729720637f4d73dd99e3878"

URI_x86_64_v2_kernel-debug-modules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-modules-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-debug-modules}"
SRC_URI[x86_64_v2_kernel-debug-modules.sha256sum] = "b2c38ac327146781d6402a604912f39dfff1d41a97cf43d66c2921ed8f75d522"
RPROVIDES:kernel-debug-modules:x86_64_v2 = "virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

URI_x86_64_v2_kernel-debug-modules-core = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-modules-core-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-modules-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-debug-modules-core}"
SRC_URI[x86_64_v2_kernel-debug-modules-core.sha256sum] = "d87394de1e629956bff3ef4978e2e4d031fffe6a2015372e7b20a9ce75df52ab"

URI_x86_64_v2_kernel-debug-modules-extra = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-modules-extra-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-modules-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-debug-modules-extra}"
SRC_URI[x86_64_v2_kernel-debug-modules-extra.sha256sum] = "421167e24c4bc8192429f95b93283cebfd8269918f687a6771af59b9eda5c486"
RPROVIDES:kernel-debug-modules-extra:x86_64_v2 = "virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

URI_x86_64_v2_kernel-debug-uki-virt = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-uki-virt-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-uki-virt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-debug-uki-virt}"
SRC_URI[x86_64_v2_kernel-debug-uki-virt.sha256sum] = "fdf322c68c8c644809d44ee15e4678f970b3c26747547109e824d7ad40ba8539"
RPROVIDES:kernel-debug-uki-virt:x86_64_v2 = "virtual/kernel-uname-r_eq_6.12.0-55.43.1.el10_0.x86_64_v2++debug"

URI_x86_64_v2_kernel-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-devel-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_kernel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-devel}"
SRC_URI[x86_64_v2_kernel-devel.sha256sum] = "96975b5b7f4b941432fde39217733dab0c82f2943990350c461d7ca183096e52"
RPROVIDES:kernel-devel:x86_64_v2 = "virtual/kernel-devel-uname-r"

URI_x86_64_v2_kernel-devel-matched = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-devel-matched-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_kernel-devel-matched;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-devel-matched}"
SRC_URI[x86_64_v2_kernel-devel-matched.sha256sum] = "60e3323ddaf0497d627913cf3990941e1428af76a5db013b22c680957ae9f64a"

URI_x86_64_v2_kernel-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-doc-6.12.0-55.43.1.el10_0.noarch.rpm;name=x86_64_v2_kernel-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-doc}"
SRC_URI[x86_64_v2_kernel-doc.sha256sum] = "fb59a2bf75905db148bf655a7be80a53cfcd4725fa0b6b5f67ded19b31dd8005"

URI_x86_64_v2_kernel-headers = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-headers-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_kernel-headers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-headers}"
SRC_URI[x86_64_v2_kernel-headers.sha256sum] = "0f7c276f094fb9e5a528c5a580abf5a14cfde1505fc57e0e2dd6bc2a5e15229a"

URI_x86_64_v2_kernel-modules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-modules-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_kernel-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-modules}"
SRC_URI[x86_64_v2_kernel-modules.sha256sum] = "67542082b18eac2c4bbd04e4c3d2eeab1e592af23c117c6c19dd68cc62b4e666"
RPROVIDES:kernel-modules:x86_64_v2 = "virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

URI_x86_64_v2_kernel-modules-core = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-modules-core-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_kernel-modules-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-modules-core}"
SRC_URI[x86_64_v2_kernel-modules-core.sha256sum] = "3ffbc9703c8a9597c91bd5873eec338a5de72c9b6ff7c2d0dd16571f64ff7be4"

URI_x86_64_v2_kernel-modules-extra = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-modules-extra-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_kernel-modules-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-modules-extra}"
SRC_URI[x86_64_v2_kernel-modules-extra.sha256sum] = "173ac03df52d513ecae7f721e5f2556366ffebb7c6297dc175ce712d748ec052"
RPROVIDES:kernel-modules-extra:x86_64_v2 = "virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

URI_x86_64_v2_kernel-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-tools-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_kernel-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-tools}"
SRC_URI[x86_64_v2_kernel-tools.sha256sum] = "b5aa3f973edeb6d7563f27b9fab100099b83d4d614a6c03a2ba2939ed69e7aae"

URI_x86_64_v2_kernel-tools-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-tools-libs-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_kernel-tools-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-tools-libs}"
SRC_URI[x86_64_v2_kernel-tools-libs.sha256sum] = "30778591714b1bd95a543763325c20947f72c3d22f6a0ce9ff805582fbfc8629"

URI_x86_64_v2_kernel-tools-libs-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/kernel-tools-libs-devel-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_kernel-tools-libs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-tools-libs-devel}"
SRC_URI[x86_64_v2_kernel-tools-libs-devel.sha256sum] = "406d103173edb520939d5f363bcf555dd4dd7d2d6fd3bb1f337121cdc84e6692"

URI_x86_64_v2_kernel-uki-virt = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-uki-virt-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_kernel-uki-virt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-uki-virt}"
SRC_URI[x86_64_v2_kernel-uki-virt.sha256sum] = "edc78109721b71642d1a76c1b744cedb5ae6e3d6578f250d1cf19d401a0d795b"
RPROVIDES:kernel-uki-virt:x86_64_v2 = "virtual/kernel-uname-r_eq_6.12.0-55.43.1.el10_0.x86_64_v2"

URI_x86_64_v2_kernel-uki-virt-addons = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-uki-virt-addons-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_kernel-uki-virt-addons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-uki-virt-addons}"
SRC_URI[x86_64_v2_kernel-uki-virt-addons.sha256sum] = "d213f614d4b89cc3dcd626a665e5409e807890fc317d7201de04e3294d43cdbb"

URI_x86_64_v2_libperf = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libperf-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_libperf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libperf}"
SRC_URI[x86_64_v2_libperf.sha256sum] = "0b41b2783f6a4b8bde6293215a529320eaf61580ddd322337d25b88c213ff52b"

URI_x86_64_v2_perf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perf-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_perf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perf}"
SRC_URI[x86_64_v2_perf.sha256sum] = "5d46c8cd5ce855e8847e9e2ed3e2f2aa79eb7295bed820302ae99da81e5fc432"

URI_x86_64_v2_python3-perf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-perf-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_python3-perf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-perf}"
SRC_URI[x86_64_v2_python3-perf.sha256sum] = "5a01c0f2691ff7c6856a0202d921aaada4ac5535d50fed939e732662b075718f"

URI_x86_64_v2_rtla = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rtla-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_rtla;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rtla}"
SRC_URI[x86_64_v2_rtla.sha256sum] = "1f54c4837f05e5314840c8415a5a01b153644d28bfc59747e27e209d0e043ec9"

URI_x86_64_v2_rv = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rv-6.12.0-55.43.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_rv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rv}"
SRC_URI[x86_64_v2_rv.sha256sum] = "b4342b9164493f31cc6750f9f949ee065bdbdce8241d85f1155eaec8fc3687e4"

URI_aarch64_kernel = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel}"
SRC_URI[aarch64_kernel.sha256sum] = "716be35063d726ddca7cfc9597eab33f6d3af63d436f21d7548ad7ca81ab3f40"
RPROVIDES:kernel:aarch64 = "virtual/kernel"

URI_aarch64_kernel-64k = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-64k;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k}"
SRC_URI[aarch64_kernel-64k.sha256sum] = "4a28ea3ccc230e48766b598ac7356d24b4650ddfbaa696ae8f8a958f4b50b638"

URI_aarch64_kernel-64k-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-core-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-64k-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-core}"
SRC_URI[aarch64_kernel-64k-core.sha256sum] = "03c7653dfa8ad116e5fb011c995766fc791e26f056f951bf60f4fadb7006ce1a"
RPROVIDES:kernel-64k-core:aarch64 = "virtual/kernel"

URI_aarch64_kernel-64k-debug = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-debug-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-64k-debug;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-debug}"
SRC_URI[aarch64_kernel-64k-debug.sha256sum] = "2410d2289ccc2515c2ccfecf8c2bdd38baeee76a253ef5dedb272b2b377ff764"

URI_aarch64_kernel-64k-debug-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-debug-core-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-64k-debug-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-debug-core}"
SRC_URI[aarch64_kernel-64k-debug-core.sha256sum] = "ad3d58a4ddbb59c1b4709de05bcadfba1f4b19e2fc554edf4fb9acb307fac208"
RPROVIDES:kernel-64k-debug-core:aarch64 = "virtual/kernel"

URI_aarch64_kernel-64k-debug-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-64k-debug-devel-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-64k-debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-debug-devel}"
SRC_URI[aarch64_kernel-64k-debug-devel.sha256sum] = "678f809858b962ef52fb86caf36fb74a60ce50786d5f354d1331faf091301400"
RPROVIDES:kernel-64k-debug-devel:aarch64 = "virtual/kernel-devel-uname-r"

URI_aarch64_kernel-64k-debug-devel-matched = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-64k-debug-devel-matched-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-64k-debug-devel-matched;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-debug-devel-matched}"
SRC_URI[aarch64_kernel-64k-debug-devel-matched.sha256sum] = "47b5c7033913a2a4fdd836ee3ef5393002c7fdbde983081435c9bb8e0c49c78d"

URI_aarch64_kernel-64k-debug-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-debug-modules-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-64k-debug-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-debug-modules}"
SRC_URI[aarch64_kernel-64k-debug-modules.sha256sum] = "cf4b4aa27b60b40a9c27ed3730b8143925b95e9558938c10bb024f4484fc5099"
RPROVIDES:kernel-64k-debug-modules:aarch64 = "virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

URI_aarch64_kernel-64k-debug-modules-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-debug-modules-core-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-64k-debug-modules-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-debug-modules-core}"
SRC_URI[aarch64_kernel-64k-debug-modules-core.sha256sum] = "8e1eb1758febfd32a8f51b72d6045d6f2bc53bba58eba63c7c453c72f9def966"

URI_aarch64_kernel-64k-debug-modules-extra = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-debug-modules-extra-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-64k-debug-modules-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-debug-modules-extra}"
SRC_URI[aarch64_kernel-64k-debug-modules-extra.sha256sum] = "9df7973f6606e22af13d0a0b6be25f83753bff0cec9f1fd92d9bee60db92d053"
RPROVIDES:kernel-64k-debug-modules-extra:aarch64 = "virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

URI_aarch64_kernel-64k-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-64k-devel-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-64k-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-devel}"
SRC_URI[aarch64_kernel-64k-devel.sha256sum] = "2eb2406b6a67e6cc35234bbde1e18ab159afd3a99892c1e817c932bc134e0a8d"
RPROVIDES:kernel-64k-devel:aarch64 = "virtual/kernel-devel-uname-r"

URI_aarch64_kernel-64k-devel-matched = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-64k-devel-matched-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-64k-devel-matched;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-devel-matched}"
SRC_URI[aarch64_kernel-64k-devel-matched.sha256sum] = "804d8cef80bb026739140be5c1baf3bc2a8db22b8edfb4eed4862d2a114722a2"

URI_aarch64_kernel-64k-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-modules-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-64k-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-modules}"
SRC_URI[aarch64_kernel-64k-modules.sha256sum] = "32ebe08098a27ca843772025992131740693c9c9970a2264fb8e57f621f24225"
RPROVIDES:kernel-64k-modules:aarch64 = "virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

URI_aarch64_kernel-64k-modules-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-modules-core-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-64k-modules-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-modules-core}"
SRC_URI[aarch64_kernel-64k-modules-core.sha256sum] = "06208483a40dc8576251b59f98b2d53843dc2a3cf2b368b637a78c7d2dba0c45"

URI_aarch64_kernel-64k-modules-extra = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-modules-extra-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-64k-modules-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-modules-extra}"
SRC_URI[aarch64_kernel-64k-modules-extra.sha256sum] = "28c759bef6e46ad8adae67e30a115a0df49537b4d9023adc9fabe762947d348d"
RPROVIDES:kernel-64k-modules-extra:aarch64 = "virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

URI_aarch64_kernel-abi-stablelists = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-abi-stablelists-6.12.0-55.43.1.el10_0.noarch.rpm;name=aarch64_kernel-abi-stablelists;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-abi-stablelists}"
SRC_URI[aarch64_kernel-abi-stablelists.sha256sum] = "aadc2e9b1e386f1ea6664405610136dd4772241a6002cfe18a718f14592c63cd"

URI_aarch64_kernel-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-core-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-core}"
SRC_URI[aarch64_kernel-core.sha256sum] = "0511b8c250bb9491acf63d2c057bc5a4d61e33992b571c60a9d2b56e431ad229"
RPROVIDES:kernel-core:aarch64 = "virtual/kernel virtual/kernel-uname-r_eq_6.12.0-55.43.1.el10_0.aarch64"

URI_aarch64_kernel-cross-headers = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/kernel-cross-headers-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-cross-headers;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-cross-headers}"
SRC_URI[aarch64_kernel-cross-headers.sha256sum] = "462c6d274acca6c32edd800d7a257746df5ba19f86f8e28f2f6ca1c2d5382744"

URI_aarch64_kernel-debug = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-debug-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-debug;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-debug}"
SRC_URI[aarch64_kernel-debug.sha256sum] = "d21f468019166434dd8e74f1e005891e38c625e548b0d24c61625d0e1a009a4f"

URI_aarch64_kernel-debug-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-debug-core-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-debug-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-debug-core}"
SRC_URI[aarch64_kernel-debug-core.sha256sum] = "e893661d129110b76518cb86748cb8ef3897a2245f5664a3e849ce9882d419ed"
RPROVIDES:kernel-debug-core:aarch64 = "virtual/kernel"

URI_aarch64_kernel-debug-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-debug-devel-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-debug-devel}"
SRC_URI[aarch64_kernel-debug-devel.sha256sum] = "a9988b950e846cad8c1a180ddd2f544a6e4f717337bf7612ac968ff2abadc835"
RPROVIDES:kernel-debug-devel:aarch64 = "virtual/kernel-devel-uname-r"

URI_aarch64_kernel-debug-devel-matched = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-debug-devel-matched-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-debug-devel-matched;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-debug-devel-matched}"
SRC_URI[aarch64_kernel-debug-devel-matched.sha256sum] = "faaeba87a215cb3701829c596258cf01e50d9b5581f1f34bf770e516984fdd69"

URI_aarch64_kernel-debug-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-debug-modules-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-debug-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-debug-modules}"
SRC_URI[aarch64_kernel-debug-modules.sha256sum] = "a68ce538da160f81b057abbb0e07545b3c63b41d6916ed6317a50f7ea8a996da"
RPROVIDES:kernel-debug-modules:aarch64 = "virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

URI_aarch64_kernel-debug-modules-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-debug-modules-core-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-debug-modules-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-debug-modules-core}"
SRC_URI[aarch64_kernel-debug-modules-core.sha256sum] = "742b346e78f491ec0f4e5fb9b34af4ca4ca6e5803997958a51f5995092fe3966"

URI_aarch64_kernel-debug-modules-extra = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-debug-modules-extra-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-debug-modules-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-debug-modules-extra}"
SRC_URI[aarch64_kernel-debug-modules-extra.sha256sum] = "742f11d9acc35a94f66316136b3e7cf18a72972610f9ec66f7cb65eff1e5a7df"
RPROVIDES:kernel-debug-modules-extra:aarch64 = "virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

URI_aarch64_kernel-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-devel-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-devel}"
SRC_URI[aarch64_kernel-devel.sha256sum] = "d1f75a802a57769e0e488f3ad0e5550504ec6a92efa7b3eadb509a46e238a85c"
RPROVIDES:kernel-devel:aarch64 = "virtual/kernel-devel-uname-r"

URI_aarch64_kernel-devel-matched = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-devel-matched-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-devel-matched;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-devel-matched}"
SRC_URI[aarch64_kernel-devel-matched.sha256sum] = "e84385020c50c2d9e1a4c3e637f816a22ea6a63f8cc1496a9048a7d20a07ee1d"

URI_aarch64_kernel-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-doc-6.12.0-55.43.1.el10_0.noarch.rpm;name=aarch64_kernel-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-doc}"
SRC_URI[aarch64_kernel-doc.sha256sum] = "fb59a2bf75905db148bf655a7be80a53cfcd4725fa0b6b5f67ded19b31dd8005"

URI_aarch64_kernel-headers = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-headers-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-headers;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-headers}"
SRC_URI[aarch64_kernel-headers.sha256sum] = "2e25c83fdd6c4d009cf5a8d7bc2f8cfd1b012407fa06ed41103d697066dab65c"

URI_aarch64_kernel-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-modules-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-modules}"
SRC_URI[aarch64_kernel-modules.sha256sum] = "05a008d09deb835f0bc023bdab323e2d1d4c17f1fd21dfb5dfdb8298e5471cc7"
RPROVIDES:kernel-modules:aarch64 = "virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

URI_aarch64_kernel-modules-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-modules-core-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-modules-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-modules-core}"
SRC_URI[aarch64_kernel-modules-core.sha256sum] = "26730bad7489ceb4fe626ff2be827588d66903ac52bb496e358eb05f581f5072"

URI_aarch64_kernel-modules-extra = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-modules-extra-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-modules-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-modules-extra}"
SRC_URI[aarch64_kernel-modules-extra.sha256sum] = "2660a9dc8afc0b3d3df9b1da574a8d0bf479fa65940025ed25f0c0691520e3c2"
RPROVIDES:kernel-modules-extra:aarch64 = "virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

URI_aarch64_kernel-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-tools-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-tools}"
SRC_URI[aarch64_kernel-tools.sha256sum] = "751fe20e9b195356f09c94e10a02799ddb8b8b345ba71f58fb20a68dcb9b335e"

URI_aarch64_kernel-tools-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-tools-libs-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-tools-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-tools-libs}"
SRC_URI[aarch64_kernel-tools-libs.sha256sum] = "7bf0044ef5f4afae10db1273779b2a7fd8d639d1a3de8cfc02ea7e598431d080"

URI_aarch64_kernel-tools-libs-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/kernel-tools-libs-devel-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-tools-libs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-tools-libs-devel}"
SRC_URI[aarch64_kernel-tools-libs-devel.sha256sum] = "25dd8b1eac84d3fd5cdf34bb0dfd0965198221d7c5eebb4de303f15cbd0c41b8"

URI_aarch64_kernel-uki-virt = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-uki-virt-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-uki-virt;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-uki-virt}"
SRC_URI[aarch64_kernel-uki-virt.sha256sum] = "47067baaa6892486fa7b9e44c03416cab3deca52ab6a912c94ebe82fa1f9ac47"
RPROVIDES:kernel-uki-virt:aarch64 = "virtual/kernel-uname-r_eq_6.12.0-55.43.1.el10_0.aarch64"

URI_aarch64_kernel-uki-virt-addons = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-uki-virt-addons-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_kernel-uki-virt-addons;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-uki-virt-addons}"
SRC_URI[aarch64_kernel-uki-virt-addons.sha256sum] = "4928b7e10440226498a1296b2632d982d12508fd21b405ec38684777cce72a09"

URI_aarch64_libperf = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libperf-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_libperf;unpack=0"
SRC_URI:append = " ${URI_aarch64_libperf}"
SRC_URI[aarch64_libperf.sha256sum] = "1c09461498d384572e2430ff1c31577bc0ec48696b53ca62a17b8c5cef7a5ca9"

URI_aarch64_perf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perf-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_perf;unpack=0"
SRC_URI:append = " ${URI_aarch64_perf}"
SRC_URI[aarch64_perf.sha256sum] = "dc6ab29d6a654fc28e71d64b0e8257bf4c0a56696eb5d669f8080faae27eb4a7"

URI_aarch64_python3-perf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-perf-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_python3-perf;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-perf}"
SRC_URI[aarch64_python3-perf.sha256sum] = "eed0a9ae0d1dcdc24182baec57bc3780a030e6e9cbd11cf277864252fa9b0b8d"

URI_aarch64_rtla = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rtla-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_rtla;unpack=0"
SRC_URI:append = " ${URI_aarch64_rtla}"
SRC_URI[aarch64_rtla.sha256sum] = "d9b35c22ce7d3fe8a439735163bb3049da09027ddb19632eee1ed2fefd262fe1"

URI_aarch64_rv = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rv-6.12.0-55.43.1.el10_0.aarch64.rpm;name=aarch64_rv;unpack=0"
SRC_URI:append = " ${URI_aarch64_rv}"
SRC_URI[aarch64_rv.sha256sum] = "643b4ebd31ff0b2fdf402c4dda7794c9b10c9ad1c0e160621ac5c2764d712eaf"

RDEPENDS:kernel = " \
 kernel-core \
 kernel-modules \
 kernel-modules-core \
 "
RDEPENDS:kernel-abi-stablelists = " \
 "
RDEPENDS:kernel-core = " \
 bash \
 dracut \
 kernel-modules-core \
 linux-firmware \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-cross-headers = " \
 "
RDEPENDS:kernel-debug = " \
 kernel-debug-core \
 kernel-debug-modules \
 kernel-debug-modules-core \
 "
RDEPENDS:kernel-debug-core = " \
 bash \
 dracut \
 kernel-debug-modules-core \
 linux-firmware \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-debug-devel = " \
 bash \
 bison \
 elfutils-libelf-devel \
 findutils \
 flex \
 gcc \
 make \
 openssl-devel \
 perl-interpreter \
 "
RDEPENDS:kernel-debug-devel-matched = " \
 kernel-debug-core \
 kernel-debug-devel \
 "
RDEPENDS:kernel-debug-modules:x86_64_v2 = " \
 bash \
 kernel-debug-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-55.43.1.el10_0.x86_64_v2++debug \
"
RDEPENDS:kernel-debug-modules:aarch64 = " \
 bash \
 kernel-debug-core \
 kernel-debug-modules-core \
"
RDEPENDS:kernel-debug-modules-core:x86_64_v2 = " \
 bash \
 virtual/kernel-uname-r_eq_6.12.0-55.43.1.el10_0.x86_64_v2++debug \
"
RDEPENDS:kernel-debug-modules-core:aarch64 = " \
 bash \
 kernel-debug-core \
"
RDEPENDS:kernel-debug-modules-extra:x86_64_v2 = " \
 bash \
 kernel-debug-modules \
 kernel-debug-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-55.43.1.el10_0.x86_64_v2++debug \
"
RDEPENDS:kernel-debug-modules-extra:aarch64 = " \
 bash \
 kernel-debug-core \
 kernel-debug-modules \
 kernel-debug-modules-core \
"
RDEPENDS:kernel-debug-uki-virt = " \
 bash \
 kernel-debug-modules-core \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-devel = " \
 bash \
 bison \
 elfutils-libelf-devel \
 findutils \
 flex \
 gcc \
 make \
 openssl-devel \
 perl-interpreter \
 "
RDEPENDS:kernel-devel-matched = " \
 kernel-core \
 kernel-devel \
 "
RDEPENDS:kernel-doc = " \
 "
RDEPENDS:kernel-headers = " \
 "
RDEPENDS:kernel-modules:x86_64_v2 = " \
 bash \
 kernel-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-55.43.1.el10_0.x86_64_v2 \
"
RDEPENDS:kernel-modules:aarch64 = " \
 bash \
 kernel-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-55.43.1.el10_0.aarch64 \
"
RDEPENDS:kernel-modules-core:x86_64_v2 = " \
 bash \
 virtual/kernel-uname-r_eq_6.12.0-55.43.1.el10_0.x86_64_v2 \
"
RDEPENDS:kernel-modules-core:aarch64 = " \
 bash \
 virtual/kernel-uname-r_eq_6.12.0-55.43.1.el10_0.aarch64 \
"
RDEPENDS:kernel-modules-extra:x86_64_v2 = " \
 bash \
 kernel-modules \
 kernel-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-55.43.1.el10_0.x86_64_v2 \
"
RDEPENDS:kernel-modules-extra:aarch64 = " \
 bash \
 kernel-modules \
 kernel-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-55.43.1.el10_0.aarch64 \
"
RDEPENDS:kernel-tools:x86_64_v2 = " \
 glibc \
 kernel-tools-libs \
 libcap \
 libnl3 \
 ncurses-libs \
 pciutils-libs \
 python3 \
 python3-jsonschema \
 python3-pyyaml \
"
RDEPENDS:kernel-tools:aarch64 = " \
 glibc \
 kernel-tools-libs \
 ncurses-libs \
 python3 \
 python3-jsonschema \
 python3-pyyaml \
"
RDEPENDS:kernel-tools-libs = " \
 bash \
 glibc \
 "
RDEPENDS:kernel-tools-libs-devel = " \
 kernel-tools \
 kernel-tools-libs \
 "
RDEPENDS:kernel-uki-virt = " \
 bash \
 kernel-modules-core \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-uki-virt-addons = " \
 kernel-uki-virt \
 systemd \
 "
RDEPENDS:libperf = " \
 glibc \
 "
RDEPENDS:perf:x86_64_v2 = " \
 bash \
 bzip2 \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libbabeltrace \
 libbpf \
 libstdc++ \
 libtraceevent \
 libzstd \
 llvm-libs \
 numactl-libs \
 openssl-libs \
 perf \
 perl-Exporter \
 perl-POSIX \
 perl-interpreter \
 perl-lib \
 perl-libs \
 python3-libs \
 slang \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:perf:aarch64 = " \
 bash \
 bzip2 \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libbabeltrace \
 libbpf \
 libstdc++ \
 libtraceevent \
 libzstd \
 llvm-libs \
 numactl-libs \
 opencsd \
 openssl-libs \
 perf \
 perl-Exporter \
 perl-POSIX \
 perl-interpreter \
 perl-lib \
 perl-libs \
 python3-libs \
 slang \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:python3-perf:x86_64_v2 = " \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libbabeltrace \
 libbpf \
 libstdc++ \
 libtraceevent \
 libzstd \
 llvm-libs \
 numactl-libs \
 openssl-libs \
 perl-libs \
 python3 \
 python3-libs \
 slang \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:python3-perf:aarch64 = " \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libbabeltrace \
 libbpf \
 libstdc++ \
 libtraceevent \
 libzstd \
 llvm-libs \
 numactl-libs \
 opencsd \
 openssl-libs \
 perl-libs \
 python3 \
 python3-libs \
 slang \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:rtla = " \
 glibc \
 kernel-tools-libs \
 libtraceevent \
 libtracefs \
 "
RDEPENDS:rv = " \
 glibc \
 libtraceevent \
 libtracefs \
 "
RDEPENDS:kernel-64k = " \
 kernel-64k-core \
 kernel-64k-modules \
 kernel-64k-modules-core \
 "
RDEPENDS:kernel-64k-core = " \
 bash \
 dracut \
 kernel-64k-modules-core \
 linux-firmware \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-64k-debug = " \
 kernel-64k-debug-core \
 kernel-64k-debug-modules \
 kernel-64k-debug-modules-core \
 "
RDEPENDS:kernel-64k-debug-core = " \
 bash \
 dracut \
 kernel-64k-debug-modules-core \
 linux-firmware \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-64k-debug-devel = " \
 bash \
 bison \
 elfutils-libelf-devel \
 findutils \
 flex \
 gcc \
 make \
 openssl-devel \
 perl-interpreter \
 "
RDEPENDS:kernel-64k-debug-devel-matched = " \
 kernel-64k-debug-core \
 kernel-64k-debug-devel \
 "
RDEPENDS:kernel-64k-debug-modules = " \
 bash \
 kernel-64k-debug-core \
 kernel-64k-debug-modules-core \
 "
RDEPENDS:kernel-64k-debug-modules-core = " \
 bash \
 kernel-64k-debug-core \
 "
RDEPENDS:kernel-64k-debug-modules-extra = " \
 bash \
 kernel-64k-debug-core \
 kernel-64k-debug-modules \
 kernel-64k-debug-modules-core \
 "
RDEPENDS:kernel-64k-devel = " \
 bash \
 bison \
 elfutils-libelf-devel \
 findutils \
 flex \
 gcc \
 make \
 openssl-devel \
 perl-interpreter \
 "
RDEPENDS:kernel-64k-devel-matched = " \
 kernel-64k-core \
 kernel-64k-devel \
 "
RDEPENDS:kernel-64k-modules = " \
 bash \
 kernel-64k-core \
 kernel-64k-modules-core \
 "
RDEPENDS:kernel-64k-modules-core = " \
 bash \
 kernel-64k-core \
 "
RDEPENDS:kernel-64k-modules-extra = " \
 bash \
 kernel-64k-core \
 kernel-64k-modules \
 kernel-64k-modules-core \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_ rpm/virtual/kernel rpm/virtual/kernel-devel-uname-r rpm/virtual/kernel-uname-r_eq_6.12.0-55.43.1.el10_0.x86_64_v2 rpm/virtual/kernel-uname-r_eq_6.12.0-55.43.1.el10_0.x86_64_v2++debug rpm/virtual/kmod_cuse.ko_ rpm/virtual/kmod_l2tp_ppp.ko_"

PROVIDES:append:aarch64 = " rpm/virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_ rpm/virtual/kernel rpm/virtual/kernel-devel-uname-r rpm/virtual/kernel-uname-r_eq_6.12.0-55.43.1.el10_0.aarch64 rpm/virtual/kmod_cuse.ko_ rpm/virtual/kmod_l2tp_ppp.ko_"
