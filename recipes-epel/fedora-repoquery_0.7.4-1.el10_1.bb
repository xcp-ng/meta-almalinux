# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fedora-repoquery"
PV = "0.7.4"
PR = "1.el10_1"
PACKAGES = " \
 fedora-repoquery \
 fedora-repoquery-short \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fedora-repoquery-0.7.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3962b6a507cc4106cfc2ee4c9c103efeba009e9efb198fbc21868884a1a25dd1"

URI_x86_64_v2_fedora-repoquery = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedora-repoquery-0.7.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fedora-repoquery;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fedora-repoquery}"
SRC_URI[x86_64_v2_fedora-repoquery.sha256sum] = "44508ca0f836ddbd1222996836e3ca67cd4bab27fb0b13edd57528010de3205f"

URI_x86_64_v2_fedora-repoquery-short = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedora-repoquery-short-0.7.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_fedora-repoquery-short;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fedora-repoquery-short}"
SRC_URI[x86_64_v2_fedora-repoquery-short.sha256sum] = "28416218776332d6997bf615b573c8a0ee26c6ff2cf6926898151cdff629417d"

URI_aarch64_fedora-repoquery = "${EPEL_MIRROR}/aarch64/Packages/f/fedora-repoquery-0.7.4-1.el10_1.aarch64.rpm;name=aarch64_fedora-repoquery;unpack=0"
SRC_URI:append = " ${URI_aarch64_fedora-repoquery}"
SRC_URI[aarch64_fedora-repoquery.sha256sum] = "3571652c276ee80ef23f5116c7449725242e24bc9d6edcd97c5ae8c3ffc06227"

URI_aarch64_fedora-repoquery-short = "${EPEL_MIRROR}/aarch64/Packages/f/fedora-repoquery-short-0.7.4-1.el10_1.noarch.rpm;name=aarch64_fedora-repoquery-short;unpack=0"
SRC_URI:append = " ${URI_aarch64_fedora-repoquery-short}"
SRC_URI[aarch64_fedora-repoquery-short.sha256sum] = "c06f4adee6189e6cf344ae044ac545330dda866385db50cf15a94172dfe92ca2"

RDEPENDS:fedora-repoquery = " \
 glibc \
 gmp \
 libffi \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:fedora-repoquery-short = " \
 fedora-repoquery \
 "
