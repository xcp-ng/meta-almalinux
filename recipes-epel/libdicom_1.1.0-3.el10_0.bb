# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdicom"
PV = "1.1.0"
PR = "3.el10_0"
PACKAGES = " \
 libdicom \
 libdicom-devel \
 libdicom-doc \
 libdicom-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libdicom-1.1.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0202eee6afb0015ed5096907c891d8adbf77cee84a754369fc831fa779e0488b"

URI_x86_64_v2_libdicom = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdicom-1.1.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdicom;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdicom}"
SRC_URI[x86_64_v2_libdicom.sha256sum] = "ff388b119408c0bf427361095ca3e6bc1d138e9517f2f2c26f3dc99590a8418b"

URI_x86_64_v2_libdicom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdicom-devel-1.1.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdicom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdicom-devel}"
SRC_URI[x86_64_v2_libdicom-devel.sha256sum] = "afcfd5cb5dd2a29d21e9f559e97fbdac1b7d5ad5c663b86308bf76f26ceb9ad3"

URI_x86_64_v2_libdicom-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdicom-doc-1.1.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_libdicom-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdicom-doc}"
SRC_URI[x86_64_v2_libdicom-doc.sha256sum] = "37def23cb379111f4d3dab618e73392c1c11bd89149525ab0fd35e92deeb92c0"

URI_x86_64_v2_libdicom-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdicom-tools-1.1.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdicom-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdicom-tools}"
SRC_URI[x86_64_v2_libdicom-tools.sha256sum] = "1a200e46fa2f84a0485e3ebcfaf3238fc4bf349a23216903fc43361732a2b70f"

URI_aarch64_libdicom = "${EPEL_MIRROR}/aarch64/Packages/l/libdicom-1.1.0-3.el10_0.aarch64.rpm;name=aarch64_libdicom;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdicom}"
SRC_URI[aarch64_libdicom.sha256sum] = "97174be0b5b84f93783e4b2c43e48fbd1e2a00c5427c23ca9829a76043431ca2"

URI_aarch64_libdicom-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libdicom-devel-1.1.0-3.el10_0.aarch64.rpm;name=aarch64_libdicom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdicom-devel}"
SRC_URI[aarch64_libdicom-devel.sha256sum] = "ea415f96499fcd996cf51782f53a30fdea89c1478a4392d4ae93ce1c9e8ae53b"

URI_aarch64_libdicom-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libdicom-doc-1.1.0-3.el10_0.noarch.rpm;name=aarch64_libdicom-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdicom-doc}"
SRC_URI[aarch64_libdicom-doc.sha256sum] = "95862950c1ecb3200185148edb446d0a3f6bfbba59772bd40ed22b83103ea394"

URI_aarch64_libdicom-tools = "${EPEL_MIRROR}/aarch64/Packages/l/libdicom-tools-1.1.0-3.el10_0.aarch64.rpm;name=aarch64_libdicom-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdicom-tools}"
SRC_URI[aarch64_libdicom-tools.sha256sum] = "1709b3213a4f3ad74c7ce5512a6db394bf1e266ada8f506217a849e777c79615"

RDEPENDS:libdicom = " \
 glibc \
 "
RDEPENDS:libdicom-devel = " \
 libdicom \
 pkgconf-pkg-config \
 "
RDEPENDS:libdicom-doc = " \
 "
RDEPENDS:libdicom-tools = " \
 glibc \
 libdicom \
 "
