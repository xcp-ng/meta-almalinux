# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "packit"
PV = "1.16.3"
PR = "1.el10_2"
PACKAGES = " \
 packit \
 python3-packit \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/packit-1.16.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "df0846faba7335f8ea71728baa334d1a04cbced8da9a737fb39de58f57598333"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/packit-1.16.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_packit;unpack=0"
SRC_URI[x86_64_v2_packit.sha256sum] = "7d1d3660eed3479a6929f543124ca32e9544018f4f3ab8478674f34e742cd59c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-packit-1.16.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-packit;unpack=0"
SRC_URI[x86_64_v2_python3-packit.sha256sum] = "bed661a5c55bf6f2c4c3cebac7bc06f56e3332def3adb90976655b027ff63987"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/packit-1.16.3-1.el10_2.noarch.rpm;name=aarch64_packit;unpack=0"
SRC_URI[aarch64_packit.sha256sum] = "08d359561ef209ed70a4977d685844d1d2f36bed78f8e5db86552915fb3f96a3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-packit-1.16.3-1.el10_2.noarch.rpm;name=aarch64_python3-packit;unpack=0"
SRC_URI[aarch64_python3-packit.sha256sum] = "5153cd13b7d7b9fc1a59e2fa3bdc4d3055d245da4f2fcc35860882064a6f4fe7"

RDEPENDS:packit = " \
 python3 \
 python3-packit \
 "
RDEPENDS:python3-packit = " \
 bash \
 bodhi-client \
 fedpkg \
 git-core \
 krb5-workstation \
 osc \
 python3 \
 python3-GitPython \
 python3-backoff \
 python3-bugzilla \
 python3-cachetools \
 python3-cccolutils \
 python3-click \
 python3-copr \
 python3-fedora-distro-aliases \
 python3-gnupg \
 python3-koji \
 python3-lazy-object-proxy \
 python3-marshmallow \
 python3-munch \
 python3-ogr \
 python3-opensuse-distro-aliases \
 python3-packaging \
 python3-pyyaml \
 python3-requests \
 python3-requests-kerberos \
 python3-rpkg \
 python3-specfile \
 python3-tabulate \
 rpm-build \
 rpmdevtools \
 rsync \
 "
