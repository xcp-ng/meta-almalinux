# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo"
PV = "0.96.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-cargo+default-devel \
 rust-cargo+http-transport-curl-devel \
 rust-cargo+http-transport-reqwest-devel \
 rust-cargo+openssl-devel \
 rust-cargo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-0.96.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25ed410f374c1b4b1a482c4497d777f1a438ab3e7871e9e6c0449f4f67cb790d"

URI_x86_64_v2_rust-cargo+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo+default-devel-0.96.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo+default-devel}"
SRC_URI[x86_64_v2_rust-cargo+default-devel.sha256sum] = "5b53d297ddfd04b463265a9363c4fbcffda4e31a8bab6fd98d29e08e834f9623"

URI_x86_64_v2_rust-cargo+http-transport-curl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo+http-transport-curl-devel-0.96.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo+http-transport-curl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo+http-transport-curl-devel}"
SRC_URI[x86_64_v2_rust-cargo+http-transport-curl-devel.sha256sum] = "b6358c820c6eeb4c1bbf43c5e5bf3725f8d9f403c4b5802383253c2166bb93e3"

URI_x86_64_v2_rust-cargo+http-transport-reqwest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo+http-transport-reqwest-devel-0.96.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo+http-transport-reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo+http-transport-reqwest-devel}"
SRC_URI[x86_64_v2_rust-cargo+http-transport-reqwest-devel.sha256sum] = "daa86b17033978d7d1c09560d7ed6e5fc545ad6aa2309e3b14692de994657537"

URI_x86_64_v2_rust-cargo+openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo+openssl-devel-0.96.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo+openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo+openssl-devel}"
SRC_URI[x86_64_v2_rust-cargo+openssl-devel.sha256sum] = "274ac47d650906cbce3fea340faede625aaf1b3f2a9d59268ccef976b6e0f78a"

URI_x86_64_v2_rust-cargo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-devel-0.96.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-devel}"
SRC_URI[x86_64_v2_rust-cargo-devel.sha256sum] = "e0da73dbcced5cd51d4955dc844534327c9011db04fa0b6ea99f92461661b272"

URI_aarch64_rust-cargo+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo+default-devel-0.96.0-1.el10_3.noarch.rpm;name=aarch64_rust-cargo+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo+default-devel}"
SRC_URI[aarch64_rust-cargo+default-devel.sha256sum] = "766504ddcb221351383bcdb9fc04b885fefca96496a27f47956d16422de0ee6d"

URI_aarch64_rust-cargo+http-transport-curl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo+http-transport-curl-devel-0.96.0-1.el10_3.noarch.rpm;name=aarch64_rust-cargo+http-transport-curl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo+http-transport-curl-devel}"
SRC_URI[aarch64_rust-cargo+http-transport-curl-devel.sha256sum] = "3cf3425035662fcc2893dc428671dbdbc2fac4488ad6128250c3dd5e5220371a"

URI_aarch64_rust-cargo+http-transport-reqwest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo+http-transport-reqwest-devel-0.96.0-1.el10_3.noarch.rpm;name=aarch64_rust-cargo+http-transport-reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo+http-transport-reqwest-devel}"
SRC_URI[aarch64_rust-cargo+http-transport-reqwest-devel.sha256sum] = "91c6bdef1a3eea492c34dae83e93e604817d50efc2970d57a7645e91093faf25"

URI_aarch64_rust-cargo+openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo+openssl-devel-0.96.0-1.el10_3.noarch.rpm;name=aarch64_rust-cargo+openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo+openssl-devel}"
SRC_URI[aarch64_rust-cargo+openssl-devel.sha256sum] = "e949cab4aa07b3555600d90920e48e14af42fa2fa9eb24bd0f467b242aec915b"

URI_aarch64_rust-cargo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-devel-0.96.0-1.el10_3.noarch.rpm;name=aarch64_rust-cargo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-devel}"
SRC_URI[aarch64_rust-cargo-devel.sha256sum] = "4d0472133f4596816790d76c0b7f8123ad98b6857b69199f06bc02b9cdb27e04"

RDEPENDS:rust-cargo+default-devel = " \
 cargo \
 rust-cargo+http-transport-curl-devel \
 rust-cargo-devel \
 "
RDEPENDS:rust-cargo+http-transport-curl-devel = " \
 cargo \
 rust-cargo-devel \
 rust-gix+blocking-http-transport-curl-devel \
 "
RDEPENDS:rust-cargo+http-transport-reqwest-devel = " \
 cargo \
 rust-cargo-devel \
 rust-gix+blocking-http-transport-reqwest-devel \
 "
RDEPENDS:rust-cargo+openssl-devel = " \
 cargo \
 rust-cargo-devel \
 rust-openssl+default-devel \
 "
RDEPENDS:rust-cargo-devel = " \
 cargo \
 rust \
 rust-annotate-snippets+default-devel \
 rust-annotate-snippets+simd-devel \
 rust-anstream0.6+default-devel \
 rust-anstyle+default-devel \
 rust-anyhow+default-devel \
 rust-base64_0.22+default-devel \
 rust-blake3+default-devel \
 rust-cargo-credential+default-devel \
 rust-cargo-credential-libsecret+default-devel \
 rust-cargo-platform+default-devel \
 rust-cargo-util+default-devel \
 rust-cargo-util-schemas+default-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-clap_complete+default-devel \
 rust-clap_complete+unstable-dynamic-devel \
 rust-color-print+default-devel \
 rust-crates-io+default-devel \
 rust-curl+default-devel \
 rust-curl+http2-devel \
 rust-curl-sys+default-devel \
 rust-filetime+default-devel \
 rust-flate2+zlib-rs-devel \
 rust-flate2-devel \
 rust-git2-curl+default-devel \
 rust-git2_0.20+default-devel \
 rust-gix+dirwalk-devel \
 rust-gix+parallel-devel \
 rust-gix+progress-tree-devel \
 rust-gix+sha1-devel \
 rust-gix+status-devel \
 rust-gix-devel \
 rust-glob+default-devel \
 rust-heck+default-devel \
 rust-hex+default-devel \
 rust-hmac0.12+default-devel \
 rust-home+default-devel \
 rust-http-auth-devel \
 rust-ignore+default-devel \
 rust-im-rc+default-devel \
 rust-indexmap+default-devel \
 rust-itertools0.14+default-devel \
 rust-jiff+serde-devel \
 rust-jiff+std-devel \
 rust-jiff-devel \
 rust-jobserver+default-devel \
 rust-libc+default-devel \
 rust-libgit2-sys+default-devel \
 rust-memchr+default-devel \
 rust-opener+default-devel \
 rust-os_info-devel \
 rust-pasetors+default-devel \
 rust-pasetors+paserk-devel \
 rust-pasetors+serde-devel \
 rust-pasetors+std-devel \
 rust-pasetors+v3-devel \
 rust-pathdiff+default-devel \
 rust-rand0.9+default-devel \
 rust-regex+default-devel \
 rust-rusqlite+default-devel \
 rust-rusqlite+fallible_uint-devel \
 rust-rustc-hash+default-devel \
 rust-rustc-stable-hash+default-devel \
 rust-rustfix+default-devel \
 rust-same-file+default-devel \
 rust-semver+default-devel \
 rust-semver+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde-untagged+default-devel \
 rust-serde_ignored+default-devel \
 rust-serde_json+default-devel \
 rust-serde_json+raw_value-devel \
 rust-sha1_0.10+default-devel \
 rust-shell-escape+default-devel \
 rust-supports-hyperlinks+default-devel \
 rust-supports-unicode+default-devel \
 rust-tar-devel \
 rust-tempfile+default-devel \
 rust-thiserror+default-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+parsing-devel \
 rust-time+serde-devel \
 rust-toml0.9+display-devel \
 rust-toml0.9+parse-devel \
 rust-toml0.9+preserve_order-devel \
 rust-toml0.9+serde-devel \
 rust-toml0.9+std-devel \
 rust-toml0.9-devel \
 rust-toml_edit0.24+default-devel \
 rust-toml_edit0.24+serde-devel \
 rust-tracing+attributes-devel \
 rust-tracing+std-devel \
 rust-tracing-chrome+default-devel \
 rust-tracing-devel \
 rust-tracing-subscriber+default-devel \
 rust-tracing-subscriber+env-filter-devel \
 rust-unicase+default-devel \
 rust-unicode-ident+default-devel \
 rust-unicode-width+default-devel \
 rust-url+default-devel \
 rust-walkdir+default-devel \
 rust-winnow0.7+default-devel \
 "
