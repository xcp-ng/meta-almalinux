# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-dev-utils"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kde-dev-utils \
 kde-dev-utils-common \
 kpartloader \
 kuiviewer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kde-dev-utils-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c945323a0dfceaf1818f1eeb88e1cbc633ec9c09f7086d78a9fc1f47059a9274"

URI_x86_64_v2_kde-dev-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-dev-utils-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-dev-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-dev-utils}"
SRC_URI[x86_64_v2_kde-dev-utils.sha256sum] = "e294bcde985617d386df4d49e544974a9e3a6a05d18267bb1371b7208def0d14"

URI_x86_64_v2_kde-dev-utils-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-dev-utils-common-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kde-dev-utils-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-dev-utils-common}"
SRC_URI[x86_64_v2_kde-dev-utils-common.sha256sum] = "0f96960af4c7f25fc4a9f6c2d957faf18a1273e5f418fa732ae0542b86fd4096"

URI_x86_64_v2_kpartloader = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpartloader-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpartloader;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpartloader}"
SRC_URI[x86_64_v2_kpartloader.sha256sum] = "148ae65e03a8d0979d8b62b66c470a3db6b3988dcdf892e5c2b1d397932a80c6"

URI_x86_64_v2_kuiviewer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kuiviewer-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kuiviewer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kuiviewer}"
SRC_URI[x86_64_v2_kuiviewer.sha256sum] = "83c24c67780671b018bfa9d2c2238d3bd836a7dcc1d20f2088f3250b4a5e473d"

URI_aarch64_kde-dev-utils = "${EPEL_MIRROR}/aarch64/Packages/k/kde-dev-utils-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kde-dev-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-dev-utils}"
SRC_URI[aarch64_kde-dev-utils.sha256sum] = "99f3c8e32064a12767fe173fcd74ad9d6a8f83db77b91494be707b4353a00056"

URI_aarch64_kde-dev-utils-common = "${EPEL_MIRROR}/aarch64/Packages/k/kde-dev-utils-common-24.12.3-1.el10_0.noarch.rpm;name=aarch64_kde-dev-utils-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-dev-utils-common}"
SRC_URI[aarch64_kde-dev-utils-common.sha256sum] = "052373e7622145eb88f5c6d539490b5285f4673430e5381d41df43ae5f2615cc"

URI_aarch64_kpartloader = "${EPEL_MIRROR}/aarch64/Packages/k/kpartloader-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kpartloader;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpartloader}"
SRC_URI[aarch64_kpartloader.sha256sum] = "3c90f4e0a2495255632778b420d504e8093c7b40b80a6e8f73c14c9b43e25f8b"

URI_aarch64_kuiviewer = "${EPEL_MIRROR}/aarch64/Packages/k/kuiviewer-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kuiviewer;unpack=0"
SRC_URI:append = " ${URI_aarch64_kuiviewer}"
SRC_URI[aarch64_kuiviewer.sha256sum] = "c7e54e658168f7453ce467daaf7a484b2abb309a0da1b8f6c1bd10f02a8dfbfd"

RDEPENDS:kde-dev-utils = " \
 kpartloader \
 kuiviewer \
 "
RDEPENDS:kde-dev-utils-common = " \
 "
RDEPENDS:kpartloader = " \
 glibc \
 kde-dev-utils-common \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kuiviewer = " \
 glibc \
 kde-dev-utils-common \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-libs-designer \
 "
