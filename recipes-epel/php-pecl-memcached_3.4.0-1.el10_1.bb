# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-memcached"
PV = "3.4.0"
PR = "1.el10_1"
PACKAGES = " \
 php-pecl-memcached \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-memcached-3.4.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "33fcca2e65fc7e9bfbd968e9d35419c238998caffcbbb5aeac76cc8a9315d4e1"

URI_x86_64_v2_php-pecl-memcached = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-memcached-3.4.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-memcached;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-memcached}"
SRC_URI[x86_64_v2_php-pecl-memcached.sha256sum] = "48d0288697688fae94e03f6e1f5168a8ae6ef3e1a80f434dff18eb8f9b4cfb72"

URI_aarch64_php-pecl-memcached = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-memcached-3.4.0-1.el10_1.aarch64.rpm;name=aarch64_php-pecl-memcached;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-memcached}"
SRC_URI[aarch64_php-pecl-memcached.sha256sum] = "afd8ca172e75e8eb7d6e636c5d8175d49abe0bb8bab661acde06b61b8b587bca"

RDEPENDS:php-pecl-memcached = " \
 cyrus-sasl-lib \
 fastlz \
 glibc \
 libevent \
 libmemcached-awesome \
 libzstd \
 php-common \
 php-pecl-igbinary \
 php-pecl-msgpack \
 zlib-ng-compat \
 "
