# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtopcua"
PV = "6.10.1"
PR = "1.el10_2"
PACKAGES = " \
 qt6-qtopcua \
 qt6-qtopcua-devel \
 qt6-qtopcua-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt6-qtopcua-6.10.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d34068d4321b2a79d7238cdbe0af74363047b51b2d7e5fc81b75665f42140df7"

URI_x86_64_v2_qt6-qtopcua = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtopcua-6.10.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtopcua;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtopcua}"
SRC_URI[x86_64_v2_qt6-qtopcua.sha256sum] = "e69291807e3561560db6c32a43c68a5b3dd07f5d13c575afe90d4668956c4d9e"

URI_x86_64_v2_qt6-qtopcua-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtopcua-devel-6.10.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtopcua-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtopcua-devel}"
SRC_URI[x86_64_v2_qt6-qtopcua-devel.sha256sum] = "55e641e2ae415fd49747eaa12a430704e5eb219181254a2a232bc9c8fb1d5680"

URI_x86_64_v2_qt6-qtopcua-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtopcua-examples-6.10.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtopcua-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtopcua-examples}"
SRC_URI[x86_64_v2_qt6-qtopcua-examples.sha256sum] = "bc2c264e83e5ac23b39abee397f549711b5ff35b2568e5b1fd1b959f6855400f"

URI_aarch64_qt6-qtopcua = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtopcua-6.10.1-1.el10_2.aarch64.rpm;name=aarch64_qt6-qtopcua;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtopcua}"
SRC_URI[aarch64_qt6-qtopcua.sha256sum] = "68deae7560ff495bfec9ee2e99198e2d7f27643c837bdf02d73827ad49894cf8"

URI_aarch64_qt6-qtopcua-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtopcua-devel-6.10.1-1.el10_2.aarch64.rpm;name=aarch64_qt6-qtopcua-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtopcua-devel}"
SRC_URI[aarch64_qt6-qtopcua-devel.sha256sum] = "7d0ba87908625ab5ab3b9416baa3206721b6d6468bc537a56f14f5a03a49b0b2"

URI_aarch64_qt6-qtopcua-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtopcua-examples-6.10.1-1.el10_2.aarch64.rpm;name=aarch64_qt6-qtopcua-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtopcua-examples}"
SRC_URI[aarch64_qt6-qtopcua-examples.sha256sum] = "79319d32c3cad76cc78d7cc6b8ecd500af4ae457e94a81f54eb5a070b2a9ee0e"

RDEPENDS:qt6-qtopcua = " \
 glibc \
 libstdc++ \
 openssl-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:qt6-qtopcua-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtopcua \
 qt6-qtopcua-devel \
 "
RDEPENDS:qt6-qtopcua-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtopcua \
 qt6-qtopcua-devel \
 "
