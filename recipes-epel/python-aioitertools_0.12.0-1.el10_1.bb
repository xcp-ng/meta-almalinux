# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-aioitertools"
PV = "0.12.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-aioitertools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-aioitertools-0.12.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "66abcc6a2aa1aac20e86db3143474212710cb17676bf115f17fccd27f429ba98"

URI_x86_64_v2_python3-aioitertools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-aioitertools-0.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-aioitertools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-aioitertools}"
SRC_URI[x86_64_v2_python3-aioitertools.sha256sum] = "f5d0332cf997eb5a8c322c3c800ac809988c4c7cba4f126215702985304ab83a"

URI_aarch64_python3-aioitertools = "${EPEL_MIRROR}/aarch64/Packages/p/python3-aioitertools-0.12.0-1.el10_1.noarch.rpm;name=aarch64_python3-aioitertools;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-aioitertools}"
SRC_URI[aarch64_python3-aioitertools.sha256sum] = "170592463b8fd7d8c5b34bcc00e68b581484c051f37748ff5a4cf3ad3761300c"

RDEPENDS:python3-aioitertools = " \
 python3 \
 "
