# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-mitogen"
PV = "0.3.10"
PR = "1.el10_0"
PACKAGES = " \
 python3-mitogen \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-mitogen-0.3.10-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd09ec9b0ae4967b3fe9941fb6fb01af43754390c8b03064696448f0b87b1857"

URI_x86_64_v2_python3-mitogen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mitogen-0.3.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mitogen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mitogen}"
SRC_URI[x86_64_v2_python3-mitogen.sha256sum] = "ef091beda4a70377243d0df93e41fe2a6f9bfc039a12eab128ac760d5d895019"

URI_aarch64_python3-mitogen = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mitogen-0.3.10-1.el10_0.noarch.rpm;name=aarch64_python3-mitogen;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mitogen}"
SRC_URI[aarch64_python3-mitogen.sha256sum] = "877134105e96952a32896d5a72042f546625d2245025802c1016b8e391866d52"

RDEPENDS:python3-mitogen = " \
 python3 \
 "
