# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "krfb"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 krfb \
 krfb-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/krfb-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "775bd9af5b3d4f238b6e3b796f994d393f3beb337ff4ad113ab1d6215a5bb636"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krfb-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krfb;unpack=0"
SRC_URI[x86_64_v2_krfb.sha256sum] = "59493e0f12c40c57942ac7eca320dd0717dd9aabdbb820704a1df8a24c16fec4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krfb-libs-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krfb-libs;unpack=0"
SRC_URI[x86_64_v2_krfb-libs.sha256sum] = "66345e754364fb46b3116c75d5641aecc12c81e80a9cdcbc70c60e01cb781c1f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/krfb-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_krfb;unpack=0"
SRC_URI[aarch64_krfb.sha256sum] = "e427baead592a9a9efb7f6fe81a0250989325ae4cb53724b021a3380c57a42e6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/krfb-libs-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_krfb-libs;unpack=0"
SRC_URI[aarch64_krfb-libs.sha256sum] = "ba1371c2759453ffd14c57710bb642a2397d85e198e9ae03099601e6f88bc7ab"

RDEPENDS:krfb = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdnssd \
 kf6-ki18n \
 kf6-knotifications \
 kf6-kstatusnotifieritem \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 krfb-libs \
 libXtst \
 libstdc++ \
 libvncserver \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:krfb-libs = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kpipewire \
 krfb \
 kwayland \
 libX11 \
 libXtst \
 libstdc++ \
 libwayland-client \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 xcb-util-image \
 "
