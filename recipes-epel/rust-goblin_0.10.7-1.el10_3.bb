# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-goblin"
PV = "0.10.7"
PR = "1.el10_3"
PACKAGES = " \
 rust-goblin+alloc-devel \
 rust-goblin+archive-devel \
 rust-goblin+default-devel \
 rust-goblin+elf32-devel \
 rust-goblin+elf64-devel \
 rust-goblin+endian_fd-devel \
 rust-goblin+log-devel \
 rust-goblin+mach32-devel \
 rust-goblin+mach64-devel \
 rust-goblin+pe32-devel \
 rust-goblin+pe64-devel \
 rust-goblin+std-devel \
 rust-goblin+te-devel \
 rust-goblin-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-goblin-0.10.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6868f9d3f904d5681a3e84a9a914e6d9aa0f2f4aaf81a919d55c10cbf5b8e2e2"

URI_x86_64_v2_rust-goblin+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+alloc-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+alloc-devel}"
SRC_URI[x86_64_v2_rust-goblin+alloc-devel.sha256sum] = "143919f2793d192f32c9d7c8a129b7fb282a1d93c456a0943eaf319ecf266979"

URI_x86_64_v2_rust-goblin+archive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+archive-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+archive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+archive-devel}"
SRC_URI[x86_64_v2_rust-goblin+archive-devel.sha256sum] = "59f10531b9f2195033ce01fc56d675e56e063cb188e5bd8868814cb2aeb4a724"

URI_x86_64_v2_rust-goblin+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+default-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+default-devel}"
SRC_URI[x86_64_v2_rust-goblin+default-devel.sha256sum] = "674ed4775fc0880b1ffbb62408be964583ce6ccf0ed1ac5338ae6eeb1f3c343d"
RPROVIDES:rust-goblin+default-devel:x86_64_v2 = "virtual/crate_goblin/default__ge_0.9.0_with_crate_goblin/default__lt_0.11.0~"

URI_x86_64_v2_rust-goblin+elf32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+elf32-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+elf32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+elf32-devel}"
SRC_URI[x86_64_v2_rust-goblin+elf32-devel.sha256sum] = "a491254512578dd7a6a9f47451c250eb7d4f22a614d5c2bcfbd27388d7e6ae5d"

URI_x86_64_v2_rust-goblin+elf64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+elf64-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+elf64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+elf64-devel}"
SRC_URI[x86_64_v2_rust-goblin+elf64-devel.sha256sum] = "b0ba69d40e1d9e5f49e032f7be15fa73f96ad0ca9681730df137e4495d96b775"

URI_x86_64_v2_rust-goblin+endian_fd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+endian_fd-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+endian_fd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+endian_fd-devel}"
SRC_URI[x86_64_v2_rust-goblin+endian_fd-devel.sha256sum] = "c37ccdb8f29fdbca80273274d77d910ce29299ad0d7f591c701d5051c508fa8e"

URI_x86_64_v2_rust-goblin+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+log-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+log-devel}"
SRC_URI[x86_64_v2_rust-goblin+log-devel.sha256sum] = "c99a453d90c8362a2442105d0fe5af1452a16560b14732c7d7a2678e94ec2db4"

URI_x86_64_v2_rust-goblin+mach32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+mach32-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+mach32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+mach32-devel}"
SRC_URI[x86_64_v2_rust-goblin+mach32-devel.sha256sum] = "6a1bce7d3bad454408625d594b9e1a7bd31d186680c2df322ca8a37bf93d58ab"

URI_x86_64_v2_rust-goblin+mach64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+mach64-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+mach64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+mach64-devel}"
SRC_URI[x86_64_v2_rust-goblin+mach64-devel.sha256sum] = "b046bcb9a4a8fbc9f94039682155c7bd31638337826aa79fc92ef4579ad56229"

URI_x86_64_v2_rust-goblin+pe32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+pe32-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+pe32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+pe32-devel}"
SRC_URI[x86_64_v2_rust-goblin+pe32-devel.sha256sum] = "a68ebff3535a855994a2067f2e5a642d606cee137ad23673a84de0b353730854"

URI_x86_64_v2_rust-goblin+pe64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+pe64-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+pe64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+pe64-devel}"
SRC_URI[x86_64_v2_rust-goblin+pe64-devel.sha256sum] = "b51f46f990d5e9a5d60b74148a596f7c6bac87d3e4fba4974ba4d21c896a125d"

URI_x86_64_v2_rust-goblin+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+std-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+std-devel}"
SRC_URI[x86_64_v2_rust-goblin+std-devel.sha256sum] = "af8b2c2de72ffb8dcd707305ee453eedbfa10bf0911bec29da97c870c2b56635"

URI_x86_64_v2_rust-goblin+te-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin+te-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin+te-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin+te-devel}"
SRC_URI[x86_64_v2_rust-goblin+te-devel.sha256sum] = "265d743c3a10fce751434d271fccd6f9bc0d1895938f6abadb339c5f2d083f24"

URI_x86_64_v2_rust-goblin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin-devel}"
SRC_URI[x86_64_v2_rust-goblin-devel.sha256sum] = "50c171f3940a8d2816ed804e7d2064dd37e511944caddcce487c0ad798b091ef"

URI_aarch64_rust-goblin+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+alloc-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-goblin+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+alloc-devel}"
SRC_URI[aarch64_rust-goblin+alloc-devel.sha256sum] = "22a8dac7454941abc143523fbaf42fee8720fdf514491146fa88e4de8c965490"

URI_aarch64_rust-goblin+archive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+archive-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-goblin+archive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+archive-devel}"
SRC_URI[aarch64_rust-goblin+archive-devel.sha256sum] = "4de611c8210715e0726b1f5462fbfea902b963873bc964accc54d23cb9239f88"

URI_aarch64_rust-goblin+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+default-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-goblin+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+default-devel}"
SRC_URI[aarch64_rust-goblin+default-devel.sha256sum] = "cb09c148033852fd7c87a67e590578eb191d9fe476412509c32c930d5e1fb871"
RPROVIDES:rust-goblin+default-devel:aarch64 = "virtual/crate_goblin/default__ge_0.9.0_with_crate_goblin/default__lt_0.11.0~"

URI_aarch64_rust-goblin+elf32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+elf32-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-goblin+elf32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+elf32-devel}"
SRC_URI[aarch64_rust-goblin+elf32-devel.sha256sum] = "a88400ea448dcccd5c7b66eb0459fb510149f1b1a5287e387224d5d622a3b9d6"

URI_aarch64_rust-goblin+elf64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+elf64-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-goblin+elf64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+elf64-devel}"
SRC_URI[aarch64_rust-goblin+elf64-devel.sha256sum] = "63b7f51eec634498332d47327850903d9d605de9cd98ca08c19b469e5009241a"

URI_aarch64_rust-goblin+endian_fd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+endian_fd-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-goblin+endian_fd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+endian_fd-devel}"
SRC_URI[aarch64_rust-goblin+endian_fd-devel.sha256sum] = "caf498c002cb7f3bec468a2df5c0ebf083fd73f49325ad3e2234f912a4f2efec"

URI_aarch64_rust-goblin+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+log-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-goblin+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+log-devel}"
SRC_URI[aarch64_rust-goblin+log-devel.sha256sum] = "308fe7b1324532aede296b4058c957fb0b6b347447e0ed47221a0ef7a6803ea2"

URI_aarch64_rust-goblin+mach32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+mach32-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-goblin+mach32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+mach32-devel}"
SRC_URI[aarch64_rust-goblin+mach32-devel.sha256sum] = "d418adf47fcb17b97422f22e962c9c94acf73462a4ff92b8a3a8ccc79cb08d8c"

URI_aarch64_rust-goblin+mach64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+mach64-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-goblin+mach64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+mach64-devel}"
SRC_URI[aarch64_rust-goblin+mach64-devel.sha256sum] = "c2c925f096052bb5293d82cf27f860dd07cffc25fa8ab37014d6b2cb6d751fe5"

URI_aarch64_rust-goblin+pe32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+pe32-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-goblin+pe32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+pe32-devel}"
SRC_URI[aarch64_rust-goblin+pe32-devel.sha256sum] = "297df8601fe486cd7fa62238a115b72864b451869412c97ddad192a41b2b4bd4"

URI_aarch64_rust-goblin+pe64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+pe64-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-goblin+pe64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+pe64-devel}"
SRC_URI[aarch64_rust-goblin+pe64-devel.sha256sum] = "edbcaf847cd5ebb4548dbbb962f3f6ad144575213734e1dfbe26df7aa0a267bf"

URI_aarch64_rust-goblin+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+std-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-goblin+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+std-devel}"
SRC_URI[aarch64_rust-goblin+std-devel.sha256sum] = "b0a0886654c76701600503f4d2d3a776d146bf9bc47b1e892a04aa6f47b7d6d4"

URI_aarch64_rust-goblin+te-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin+te-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-goblin+te-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin+te-devel}"
SRC_URI[aarch64_rust-goblin+te-devel.sha256sum] = "f7f19939639a0f4f8bbeb1d45c616907170eedb3ab466d7d2b403e374e82c4a1"

URI_aarch64_rust-goblin-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-goblin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin-devel}"
SRC_URI[aarch64_rust-goblin-devel.sha256sum] = "661d14c335ed29bcbf0b06cd48bfdbcb8c908a25d291c8e672aea96071c8acf6"

RDEPENDS:rust-goblin+alloc-devel = " \
 cargo \
 rust-goblin+log-devel \
 rust-goblin-devel \
 rust-scroll+derive-devel \
 "
RDEPENDS:rust-goblin+archive-devel = " \
 cargo \
 rust-goblin+alloc-devel \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+default-devel = " \
 cargo \
 rust-goblin+archive-devel \
 rust-goblin+elf32-devel \
 rust-goblin+elf64-devel \
 rust-goblin+endian_fd-devel \
 rust-goblin+mach32-devel \
 rust-goblin+mach64-devel \
 rust-goblin+pe32-devel \
 rust-goblin+pe64-devel \
 rust-goblin+std-devel \
 rust-goblin+te-devel \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+elf32-devel = " \
 cargo \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+elf64-devel = " \
 cargo \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+endian_fd-devel = " \
 cargo \
 rust-goblin+alloc-devel \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+log-devel = " \
 cargo \
 rust-goblin-devel \
 rust-log-devel \
 "
RDEPENDS:rust-goblin+mach32-devel = " \
 cargo \
 rust-goblin+alloc-devel \
 rust-goblin+archive-devel \
 rust-goblin+endian_fd-devel \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+mach64-devel = " \
 cargo \
 rust-goblin+alloc-devel \
 rust-goblin+archive-devel \
 rust-goblin+endian_fd-devel \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+pe32-devel = " \
 cargo \
 rust-goblin+alloc-devel \
 rust-goblin+endian_fd-devel \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+pe64-devel = " \
 cargo \
 rust-goblin+alloc-devel \
 rust-goblin+endian_fd-devel \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin+std-devel = " \
 cargo \
 rust-goblin+alloc-devel \
 rust-goblin-devel \
 rust-scroll+std-devel \
 "
RDEPENDS:rust-goblin+te-devel = " \
 cargo \
 rust-goblin+alloc-devel \
 rust-goblin+endian_fd-devel \
 rust-goblin-devel \
 "
RDEPENDS:rust-goblin-devel = " \
 cargo \
 rust \
 rust-plain+default-devel \
 rust-scroll-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_goblin/default__ge_0.9.0_with_crate_goblin/default__lt_0.11.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_goblin/default__ge_0.9.0_with_crate_goblin/default__lt_0.11.0~"
