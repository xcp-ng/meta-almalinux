# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mujs"
PV = "1.3.3"
PR = "7.el10_0"
PACKAGES = " \
 mujs \
 mujs-devel \
 mujs-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mujs-1.3.3-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7281710495b06790e0daf47eb5b957cf588d93a352016d3478bf8674b033e2c"

URI_x86_64_v2_mujs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mujs-1.3.3-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mujs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mujs}"
SRC_URI[x86_64_v2_mujs.sha256sum] = "2c18575d19060902aecf42fc85f5c86034fa118195f3016ff2e506ccb60970e1"

URI_x86_64_v2_mujs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mujs-devel-1.3.3-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mujs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mujs-devel}"
SRC_URI[x86_64_v2_mujs-devel.sha256sum] = "64790d414fc76984be25bfe551e12d0dd016fb700bb3e7f0f1461440353a4906"

URI_x86_64_v2_mujs-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mujs-static-1.3.3-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mujs-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mujs-static}"
SRC_URI[x86_64_v2_mujs-static.sha256sum] = "02c8b302443f6333f056ece0da6b54df308bd02bd718b19ed28daa325643b51c"

URI_aarch64_mujs = "${EPEL_MIRROR}/aarch64/Packages/m/mujs-1.3.3-7.el10_0.aarch64.rpm;name=aarch64_mujs;unpack=0"
SRC_URI:append = " ${URI_aarch64_mujs}"
SRC_URI[aarch64_mujs.sha256sum] = "7f1685aafcc06de839c932e462533bae0e1746a8141280703e6df8bfdbd54ae6"

URI_aarch64_mujs-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mujs-devel-1.3.3-7.el10_0.aarch64.rpm;name=aarch64_mujs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mujs-devel}"
SRC_URI[aarch64_mujs-devel.sha256sum] = "b3c3c86d2e260d137d3be2521a176117c8fb9d7017ee677491b977873e9a5716"

URI_aarch64_mujs-static = "${EPEL_MIRROR}/aarch64/Packages/m/mujs-static-1.3.3-7.el10_0.aarch64.rpm;name=aarch64_mujs-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_mujs-static}"
SRC_URI[aarch64_mujs-static.sha256sum] = "1ba11a8968896d208ea95235f0b31665e54f83ea45c647e6df1a2240c1aeeb0f"

RDEPENDS:mujs = " \
 glibc \
 readline \
 "
RDEPENDS:mujs-devel = " \
 mujs \
 pkgconf-pkg-config \
 "
RDEPENDS:mujs-static = " \
 mujs-devel \
 "
