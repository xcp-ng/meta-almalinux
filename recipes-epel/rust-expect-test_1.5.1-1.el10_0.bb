# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-expect-test"
PV = "1.5.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-expect-test+default-devel \
 rust-expect-test-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-expect-test-1.5.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1dda5f629e87908a7c992f3b0cf88e1f2151c24857c1011632824f062271d6f8"

URI_x86_64_v2_rust-expect-test+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-expect-test+default-devel-1.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-expect-test+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-expect-test+default-devel}"
SRC_URI[x86_64_v2_rust-expect-test+default-devel.sha256sum] = "4ac4b08db6f421c00cafbbd88b0839db0b5b5746a2af1b02bd3f47d8141dfbb8"

URI_x86_64_v2_rust-expect-test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-expect-test-devel-1.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-expect-test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-expect-test-devel}"
SRC_URI[x86_64_v2_rust-expect-test-devel.sha256sum] = "483e92251c1813a663b2ab96d765bf6521ee5dce226274704f3f858c22b6694b"

URI_aarch64_rust-expect-test+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-expect-test+default-devel-1.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-expect-test+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-expect-test+default-devel}"
SRC_URI[aarch64_rust-expect-test+default-devel.sha256sum] = "2ab03cdc3ee46d7e2821c091c22921ab7666d13554c6fba679a312793219aa52"

URI_aarch64_rust-expect-test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-expect-test-devel-1.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-expect-test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-expect-test-devel}"
SRC_URI[aarch64_rust-expect-test-devel.sha256sum] = "3446e04bfc59497d1cdff038d770d5f134b34f8c3eaca75ecc9c1c2cbab1ccea"

RDEPENDS:rust-expect-test+default-devel = " \
 cargo \
 rust-expect-test-devel \
 "
RDEPENDS:rust-expect-test-devel = " \
 cargo \
 rust \
 rust-dissimilar+default-devel \
 rust-once_cell+default-devel \
 "
