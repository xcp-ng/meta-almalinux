# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-yoke"
PV = "0.7.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-yoke+alloc-devel \
 rust-yoke+default-devel \
 rust-yoke+derive-devel \
 rust-yoke+serde-devel \
 rust-yoke+zerofrom-devel \
 rust-yoke-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-yoke-0.7.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c28ef3c129a0bd59ccbf8e49906829969451edcc585c1a569d8b6b9ac7e639e9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yoke+alloc-devel-0.7.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yoke+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-yoke+alloc-devel.sha256sum] = "1b002dccf3702ef567ac7da6c7f3dfc7a5cd4376a1068a733d4acaeff8e3497c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yoke+default-devel-0.7.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yoke+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-yoke+default-devel.sha256sum] = "fb13bacd473f0a2a40f6b31aa2aee3952716e13bcf5419df03d4eab4dbc9bf5e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yoke+derive-devel-0.7.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yoke+derive-devel;unpack=0"
SRC_URI[x86_64_v2_rust-yoke+derive-devel.sha256sum] = "9f8b8de99f26479507d04d283abe8f2b3f70de4cb8b31492f3e4477eefa7fcb9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yoke+serde-devel-0.7.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yoke+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-yoke+serde-devel.sha256sum] = "a79ffa5ffc5ba3125f51b2f718278872d845b7b29dd313f9fd6002e7d91f6062"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yoke+zerofrom-devel-0.7.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yoke+zerofrom-devel;unpack=0"
SRC_URI[x86_64_v2_rust-yoke+zerofrom-devel.sha256sum] = "f18d1b864e52272dad8ea12afae1ced332a8dd9258eef4539b39724917b846ae"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yoke-devel-0.7.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yoke-devel;unpack=0"
SRC_URI[x86_64_v2_rust-yoke-devel.sha256sum] = "c0edf4262d4bb3cafae5ce7314d0acffbb84ad32c4e9fc81bd97ab00645b4cc5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-yoke+alloc-devel-0.7.5-1.el10_0.noarch.rpm;name=aarch64_rust-yoke+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-yoke+alloc-devel.sha256sum] = "5eb1c6b04d81906c9f8f43d8c74b4c87c530e90c43852024db283927e7e413ef"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-yoke+default-devel-0.7.5-1.el10_0.noarch.rpm;name=aarch64_rust-yoke+default-devel;unpack=0"
SRC_URI[aarch64_rust-yoke+default-devel.sha256sum] = "ae7180dc68d0b0dea597bddb8f7b35935a253988aef18840bfbc412bb96cd930"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-yoke+derive-devel-0.7.5-1.el10_0.noarch.rpm;name=aarch64_rust-yoke+derive-devel;unpack=0"
SRC_URI[aarch64_rust-yoke+derive-devel.sha256sum] = "779e1ead11ef9f7cc11af3d03fed633fb28b0d1e295e5ea6ac9c2cc74f28c68f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-yoke+serde-devel-0.7.5-1.el10_0.noarch.rpm;name=aarch64_rust-yoke+serde-devel;unpack=0"
SRC_URI[aarch64_rust-yoke+serde-devel.sha256sum] = "284f0789eb3b88b4c8121e4bc899935c81c937243c1a4876a9029b2722b44f6a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-yoke+zerofrom-devel-0.7.5-1.el10_0.noarch.rpm;name=aarch64_rust-yoke+zerofrom-devel;unpack=0"
SRC_URI[aarch64_rust-yoke+zerofrom-devel.sha256sum] = "a23bc87b09b0ca0d89868f4f86b3d3010c33085d9c383a81af19bc41136a53e8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-yoke-devel-0.7.5-1.el10_0.noarch.rpm;name=aarch64_rust-yoke-devel;unpack=0"
SRC_URI[aarch64_rust-yoke-devel.sha256sum] = "21bd0acc6e260a877b85cb44dc3e0b0f37486601b0615a82cc7dbf72e116ee78"

RDEPENDS:rust-yoke+alloc-devel = " \
 cargo \
 rust-serde+alloc-devel \
 rust-serde-devel \
 rust-stable_deref_trait+alloc-devel \
 rust-yoke-devel \
 rust-zerofrom+alloc-devel \
 rust-zerofrom-devel \
 "
RDEPENDS:rust-yoke+default-devel = " \
 cargo \
 rust-yoke+alloc-devel \
 rust-yoke+zerofrom-devel \
 rust-yoke-devel \
 "
RDEPENDS:rust-yoke+derive-devel = " \
 cargo \
 rust-yoke-derive-devel \
 rust-yoke-devel \
 rust-zerofrom+derive-devel \
 rust-zerofrom-devel \
 "
RDEPENDS:rust-yoke+serde-devel = " \
 cargo \
 rust-serde-devel \
 rust-yoke-devel \
 "
RDEPENDS:rust-yoke+zerofrom-devel = " \
 cargo \
 rust-yoke-devel \
 rust-zerofrom-devel \
 "
RDEPENDS:rust-yoke-devel = " \
 cargo \
 rust \
 rust-stable_deref_trait-devel \
 "
