# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdenetwork-filesharing"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kdenetwork-filesharing \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdenetwork-filesharing-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9b9d5434778a4f74391f46924ef31d8d4594686db06cd9097c718128bdf5d850"

URI_x86_64_v2_kdenetwork-filesharing = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdenetwork-filesharing-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdenetwork-filesharing;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdenetwork-filesharing}"
SRC_URI[x86_64_v2_kdenetwork-filesharing.sha256sum] = "cca78733205d9c01ca02005d65e1c6e7990efa281047143d6fcf293b600d23e7"

URI_aarch64_kdenetwork-filesharing = "${EPEL_MIRROR}/aarch64/Packages/k/kdenetwork-filesharing-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kdenetwork-filesharing;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdenetwork-filesharing}"
SRC_URI[aarch64_kdenetwork-filesharing.sha256sum] = "5ab327c46afac0bd44d9d59af1e62aceb5b5df6f888965ffc2f7e732c264f7cc"

RDEPENDS:kdenetwork-filesharing = " \
 PackageKit-Qt6 \
 glibc \
 kf6-kauth \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
