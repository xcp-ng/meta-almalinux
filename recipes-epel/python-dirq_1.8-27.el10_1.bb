# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-dirq"
PV = "1.8"
PR = "27.el10_1"
PACKAGES = " \
 python3-dirq \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-dirq-1.8-27.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e260885826b06916f7fac5795a206fef6b32b8f4119f906a9378659c4887013"

URI_x86_64_v2_python3-dirq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-dirq-1.8-27.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-dirq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dirq}"
SRC_URI[x86_64_v2_python3-dirq.sha256sum] = "7414204dd429cdfff85a4fcc4afd241bdc6f94594f0bcdc932876b49a82a8bd4"

URI_aarch64_python3-dirq = "${EPEL_MIRROR}/aarch64/Packages/p/python3-dirq-1.8-27.el10_1.noarch.rpm;name=aarch64_python3-dirq;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dirq}"
SRC_URI[aarch64_python3-dirq.sha256sum] = "1d3d5de091e112d71cbc7071084e82082eb3cdc301950012d65ddf1f842f8a36"

RDEPENDS:python3-dirq = " \
 python3 \
 "
