# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "f43-backgrounds"
PV = "43.0.4"
PR = "2.el10_2"
PACKAGES = " \
 f43-backgrounds \
 f43-backgrounds-base \
 f43-backgrounds-budgie \
 f43-backgrounds-gnome \
 f43-backgrounds-kde \
 f43-backgrounds-mate \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/f43-backgrounds-43.0.4-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "39deea37b99e06e8d7d8e56a45d071c68406c9a326d3892e8da43817eb3ead8e"

URI_x86_64_v2_f43-backgrounds = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f43-backgrounds-43.0.4-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_f43-backgrounds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f43-backgrounds}"
SRC_URI[x86_64_v2_f43-backgrounds.sha256sum] = "28ebe9498049b4ea46b2a091f6e6b3fbbf1debf280d3da8bdbace5d9d4da330c"

URI_x86_64_v2_f43-backgrounds-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f43-backgrounds-base-43.0.4-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_f43-backgrounds-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f43-backgrounds-base}"
SRC_URI[x86_64_v2_f43-backgrounds-base.sha256sum] = "62843cf221d7c0ff1e94669d0b50dd657f5df940dafc865b182ff209e9d68aa5"

URI_x86_64_v2_f43-backgrounds-budgie = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f43-backgrounds-budgie-43.0.4-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_f43-backgrounds-budgie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f43-backgrounds-budgie}"
SRC_URI[x86_64_v2_f43-backgrounds-budgie.sha256sum] = "9ab4dfd4730af6f3e8e8de4113fc5e2518ca07dabc7ac23d879c52137492cf62"

URI_x86_64_v2_f43-backgrounds-gnome = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f43-backgrounds-gnome-43.0.4-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_f43-backgrounds-gnome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f43-backgrounds-gnome}"
SRC_URI[x86_64_v2_f43-backgrounds-gnome.sha256sum] = "8444bba9621af632c4eb4a5fa08515db75608bd15d0a90a0457f86bd98fa59d2"

URI_x86_64_v2_f43-backgrounds-kde = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f43-backgrounds-kde-43.0.4-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_f43-backgrounds-kde;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f43-backgrounds-kde}"
SRC_URI[x86_64_v2_f43-backgrounds-kde.sha256sum] = "16d3b8d39970a5de416adfef830db5e3015aad58af460c427ad069de49464e24"

URI_x86_64_v2_f43-backgrounds-mate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f43-backgrounds-mate-43.0.4-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_f43-backgrounds-mate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f43-backgrounds-mate}"
SRC_URI[x86_64_v2_f43-backgrounds-mate.sha256sum] = "53371e55b9848c9839082f2e45d1281b0a8375519b5f68c293aaf0af75ae7403"

URI_aarch64_f43-backgrounds = "${EPEL_MIRROR}/aarch64/Packages/f/f43-backgrounds-43.0.4-2.el10_2.noarch.rpm;name=aarch64_f43-backgrounds;unpack=0"
SRC_URI:append = " ${URI_aarch64_f43-backgrounds}"
SRC_URI[aarch64_f43-backgrounds.sha256sum] = "8cc5abc3ed811ffc0a7285714de131408282ab237cff3dccc226927076f3eba2"

URI_aarch64_f43-backgrounds-base = "${EPEL_MIRROR}/aarch64/Packages/f/f43-backgrounds-base-43.0.4-2.el10_2.noarch.rpm;name=aarch64_f43-backgrounds-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_f43-backgrounds-base}"
SRC_URI[aarch64_f43-backgrounds-base.sha256sum] = "c02458fc4e55100d759e68a1159cbb010a9c7599f479fcd0d08842599320a6d3"

URI_aarch64_f43-backgrounds-budgie = "${EPEL_MIRROR}/aarch64/Packages/f/f43-backgrounds-budgie-43.0.4-2.el10_2.noarch.rpm;name=aarch64_f43-backgrounds-budgie;unpack=0"
SRC_URI:append = " ${URI_aarch64_f43-backgrounds-budgie}"
SRC_URI[aarch64_f43-backgrounds-budgie.sha256sum] = "591fe554611e70c68648f0d6a9e4cc13274cd71e7fcee5352c75d8375481decd"

URI_aarch64_f43-backgrounds-gnome = "${EPEL_MIRROR}/aarch64/Packages/f/f43-backgrounds-gnome-43.0.4-2.el10_2.noarch.rpm;name=aarch64_f43-backgrounds-gnome;unpack=0"
SRC_URI:append = " ${URI_aarch64_f43-backgrounds-gnome}"
SRC_URI[aarch64_f43-backgrounds-gnome.sha256sum] = "583cfc66213432ce0a2546295030cbbb13629925baa56113ec97df90bd4ce2f5"

URI_aarch64_f43-backgrounds-kde = "${EPEL_MIRROR}/aarch64/Packages/f/f43-backgrounds-kde-43.0.4-2.el10_2.noarch.rpm;name=aarch64_f43-backgrounds-kde;unpack=0"
SRC_URI:append = " ${URI_aarch64_f43-backgrounds-kde}"
SRC_URI[aarch64_f43-backgrounds-kde.sha256sum] = "797667943a9528d7bf9d1a799a044bee8923062584f498982c9109b1477117b8"

URI_aarch64_f43-backgrounds-mate = "${EPEL_MIRROR}/aarch64/Packages/f/f43-backgrounds-mate-43.0.4-2.el10_2.noarch.rpm;name=aarch64_f43-backgrounds-mate;unpack=0"
SRC_URI:append = " ${URI_aarch64_f43-backgrounds-mate}"
SRC_URI[aarch64_f43-backgrounds-mate.sha256sum] = "6f92a24a275e130f3c1cb7ae58bbefde200dd4c7d4726c1d988784221f09cedf"

RDEPENDS:f43-backgrounds = " \
 f43-backgrounds-budgie \
 f43-backgrounds-gnome \
 f43-backgrounds-kde \
 f43-backgrounds-mate \
 "
RDEPENDS:f43-backgrounds-base = " \
 jxl-pixbuf-loader \
 kf6-kimageformats \
 "
RDEPENDS:f43-backgrounds-budgie = " \
 f43-backgrounds-base \
 "
RDEPENDS:f43-backgrounds-gnome = " \
 f43-backgrounds-base \
 "
RDEPENDS:f43-backgrounds-kde = " \
 f43-backgrounds-base \
 kde-filesystem \
 "
RDEPENDS:f43-backgrounds-mate = " \
 f43-backgrounds-base \
 "
