# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-login-manager"
PV = "6.7.3"
PR = "4.el10_3"
PACKAGES = " \
 kcm-plasmalogin \
 plasma-login-manager \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-login-manager-6.7.3-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27727ec2b87a3eb151539d06991d547ca17866197af8092597549b03a560dbbf"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - plasma-login-manager: kde-settings-plasma

URI_x86_64_v2_kcm-plasmalogin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcm-plasmalogin-6.7.3-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcm-plasmalogin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcm-plasmalogin}"
SRC_URI[x86_64_v2_kcm-plasmalogin.sha256sum] = "9cfce072271f6fd6859295460d66376517f6c387ed59c51733f3f282d4b91afa"

URI_x86_64_v2_plasma-login-manager = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-login-manager-6.7.3-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-login-manager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-login-manager}"
SRC_URI[x86_64_v2_plasma-login-manager.sha256sum] = "9a37e40c3823d271432c98774bf1d47cce69aed955b64957eefa1fe62de42339"

URI_aarch64_kcm-plasmalogin = "${EPEL_MIRROR}/aarch64/Packages/k/kcm-plasmalogin-6.7.3-4.el10_3.aarch64.rpm;name=aarch64_kcm-plasmalogin;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcm-plasmalogin}"
SRC_URI[aarch64_kcm-plasmalogin.sha256sum] = "c9b7692b169dcf711f17448ddf4f5eb15037c3eefa4e480747d0dd209db88b83"

URI_aarch64_plasma-login-manager = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-login-manager-6.7.3-4.el10_3.aarch64.rpm;name=aarch64_plasma-login-manager;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-login-manager}"
SRC_URI[aarch64_plasma-login-manager.sha256sum] = "11b8728ca8d44ff259bf17b031b2d1cd6ebe66fee8be95dfa13114797176d8cf"

RDEPENDS:kcm-plasmalogin = " \
 dbus-common \
 glibc \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kpackage \
 kf6-kservice \
 libstdc++ \
 plasma-login-manager \
 plasma-systemsettings \
 polkit \
 qt6-filesystem \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:plasma-login-manager:x86_64_v2 = " \
 bash \
 glibc \
 kcm-plasmalogin \
 kf6-filesystem \
 kf6-kauth \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kimageformats \
 kf6-kpackage \
 kf6-kwindowsystem \
 kwin \
 layer-shell-qt \
 libXau \
 libkscreen \
 libkworkspace6 \
 libplasma \
 libstdc++ \
 pam-libs \
 plasma-workspace-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 shadow-utils \
 systemd \
 systemd-libs \
"
RDEPENDS:plasma-login-manager:aarch64 = " \
 bash \
 glibc \
 kcm-plasmalogin \
 kde-settings-plasma \
 kf6-filesystem \
 kf6-kauth \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kimageformats \
 kf6-kpackage \
 kf6-kwindowsystem \
 kwin \
 layer-shell-qt \
 libXau \
 libkscreen \
 libkworkspace6 \
 libplasma \
 libstdc++ \
 pam-libs \
 plasma-workspace-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 shadow-utils \
 systemd \
 systemd-libs \
"
