# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xkeyboard-config"
PV = "2.41"
PR = "3.el10"
PACKAGES = " \
 xkeyboard-config \
 xkeyboard-config-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xkeyboard-config-2.41-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4886065816e6140615bb3e3766193ac3bb7e7a8c23f3b64397186988cde485bd"

URI_x86_64_v2_xkeyboard-config = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xkeyboard-config-2.41-3.el10.noarch.rpm;name=x86_64_v2_xkeyboard-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xkeyboard-config}"
SRC_URI[x86_64_v2_xkeyboard-config.sha256sum] = "314888f0735303e7173cbe8750947cd02b6c817f689001cde60f22887b665dff"

URI_x86_64_v2_xkeyboard-config-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xkeyboard-config-devel-2.41-3.el10.noarch.rpm;name=x86_64_v2_xkeyboard-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xkeyboard-config-devel}"
SRC_URI[x86_64_v2_xkeyboard-config-devel.sha256sum] = "889fa9600ca07832a1489f190d4d88b0c1dceaaf49afb4eb89aff1fc379123db"

URI_aarch64_xkeyboard-config = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xkeyboard-config-2.41-3.el10.noarch.rpm;name=aarch64_xkeyboard-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_xkeyboard-config}"
SRC_URI[aarch64_xkeyboard-config.sha256sum] = "314888f0735303e7173cbe8750947cd02b6c817f689001cde60f22887b665dff"

URI_aarch64_xkeyboard-config-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xkeyboard-config-devel-2.41-3.el10.noarch.rpm;name=aarch64_xkeyboard-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xkeyboard-config-devel}"
SRC_URI[aarch64_xkeyboard-config-devel.sha256sum] = "889fa9600ca07832a1489f190d4d88b0c1dceaaf49afb4eb89aff1fc379123db"

RDEPENDS:xkeyboard-config = " \
 "
RDEPENDS:xkeyboard-config-devel = " \
 pkgconf-pkg-config \
 xkeyboard-config \
 "
