# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-prodash"
PV = "29.0.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-prodash+async-io-devel \
 rust-prodash+bytesize-devel \
 rust-prodash+ctrlc-devel \
 rust-prodash+dashmap-devel \
 rust-prodash+default-devel \
 rust-prodash+futures-core-devel \
 rust-prodash+futures-lite-devel \
 rust-prodash+human_format-devel \
 rust-prodash+is-terminal-devel \
 rust-prodash+jiff-devel \
 rust-prodash+local-time-devel \
 rust-prodash+log-devel \
 rust-prodash+parking_lot-devel \
 rust-prodash+progress-log-devel \
 rust-prodash+progress-tree-devel \
 rust-prodash+progress-tree-hp-hashmap-devel \
 rust-prodash+progress-tree-log-devel \
 rust-prodash+render-line-autoconfigure-devel \
 rust-prodash+signal-hook-devel \
 rust-prodash+unicode-segmentation-devel \
 rust-prodash+unicode-width-devel \
 rust-prodash+unit-bytes-devel \
 rust-prodash+unit-human-devel \
 rust-prodash-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-prodash-29.0.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c54221c878c291e7e7ff7cda5555174f95ad7fdb6f98c26961721d5b7569e3c6"

URI_x86_64_v2_rust-prodash+async-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+async-io-devel-29.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+async-io-devel}"
SRC_URI[x86_64_v2_rust-prodash+async-io-devel.sha256sum] = "d92c6ce7f703cec767c599e8a4bc7998b21a2910ad39a5dd71dabd677e856890"

URI_x86_64_v2_rust-prodash+bytesize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+bytesize-devel-29.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+bytesize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+bytesize-devel}"
SRC_URI[x86_64_v2_rust-prodash+bytesize-devel.sha256sum] = "05dbe61c597a9fba2676da2b54e577f012fb9309ab467445e71283d60d853eb6"

URI_x86_64_v2_rust-prodash+ctrlc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+ctrlc-devel-29.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+ctrlc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+ctrlc-devel}"
SRC_URI[x86_64_v2_rust-prodash+ctrlc-devel.sha256sum] = "8674560185dafe7ae32b20667de7c96f531a66fa440491072edf5a505002c907"

URI_x86_64_v2_rust-prodash+dashmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+dashmap-devel-29.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+dashmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+dashmap-devel}"
SRC_URI[x86_64_v2_rust-prodash+dashmap-devel.sha256sum] = "36a7e2adbebe1a953bbf49ccc54123bfbf73d6955d7d9f0582a6f04f1be8a1ab"

URI_x86_64_v2_rust-prodash+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+default-devel-29.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+default-devel}"
SRC_URI[x86_64_v2_rust-prodash+default-devel.sha256sum] = "f338a5e29cc404ecd9b23a85e74108a070da37d4b025b6245aef5275298c8192"

URI_x86_64_v2_rust-prodash+futures-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+futures-core-devel-29.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+futures-core-devel}"
SRC_URI[x86_64_v2_rust-prodash+futures-core-devel.sha256sum] = "6050fe3f8348867a662833e2932310fae0ab24dcb4a1bba7156c3a0f93199eb0"

URI_x86_64_v2_rust-prodash+futures-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+futures-lite-devel-29.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+futures-lite-devel}"
SRC_URI[x86_64_v2_rust-prodash+futures-lite-devel.sha256sum] = "fd8709d722ac971335c0c4aa60b36e1c581837d8738021610105cdfb5a3148c5"

URI_x86_64_v2_rust-prodash+human_format-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+human_format-devel-29.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+human_format-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+human_format-devel}"
SRC_URI[x86_64_v2_rust-prodash+human_format-devel.sha256sum] = "bfb5b3de18dde95a535a754d32d7a64ea25a2b1a67ac95ffc410503528094166"

URI_x86_64_v2_rust-prodash+is-terminal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+is-terminal-devel-29.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+is-terminal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+is-terminal-devel}"
SRC_URI[x86_64_v2_rust-prodash+is-terminal-devel.sha256sum] = "64ef03299ebc5df5a571bd1d89b585b3ee710863405cfcd1b17de377b659a074"

URI_x86_64_v2_rust-prodash+jiff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+jiff-devel-29.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+jiff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+jiff-devel}"
SRC_URI[x86_64_v2_rust-prodash+jiff-devel.sha256sum] = "c50df573d522a2102930517b9cf8cd1f46a6331db073bef3376947f697e31408"

URI_x86_64_v2_rust-prodash+local-time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+local-time-devel-29.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+local-time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+local-time-devel}"
SRC_URI[x86_64_v2_rust-prodash+local-time-devel.sha256sum] = "b878b227e9ddc7ae96ac5853bb86a634a4a5dfe3bafe76aae98eac83c0cca643"

URI_x86_64_v2_rust-prodash+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+log-devel-29.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+log-devel}"
SRC_URI[x86_64_v2_rust-prodash+log-devel.sha256sum] = "1bed5256f64aa3e2d3b9aa4648fa4346d8c51cd78e698c953c46434fcbdc9eb3"

URI_x86_64_v2_rust-prodash+parking_lot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+parking_lot-devel-29.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+parking_lot-devel}"
SRC_URI[x86_64_v2_rust-prodash+parking_lot-devel.sha256sum] = "4cba4e5ddee8fce7e338120f55aa9237ca9a15efb714a7b780c827ef855b5060"

URI_x86_64_v2_rust-prodash+progress-log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+progress-log-devel-29.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+progress-log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+progress-log-devel}"
SRC_URI[x86_64_v2_rust-prodash+progress-log-devel.sha256sum] = "b03731d433b57c825aa1cc614193f7448a6d0f19199a282e521034551ca2c327"

URI_x86_64_v2_rust-prodash+progress-tree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+progress-tree-devel-29.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+progress-tree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+progress-tree-devel}"
SRC_URI[x86_64_v2_rust-prodash+progress-tree-devel.sha256sum] = "01bc1b63dc158c2741ab7a5840185ebf4786503940257bd3829e533d4c9c704a"

URI_x86_64_v2_rust-prodash+progress-tree-hp-hashmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+progress-tree-hp-hashmap-devel-29.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+progress-tree-hp-hashmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+progress-tree-hp-hashmap-devel}"
SRC_URI[x86_64_v2_rust-prodash+progress-tree-hp-hashmap-devel.sha256sum] = "43b5021eb92b18304ef7c2df73d52d805ce87130a4bf685a87b47f9a02192b64"

URI_x86_64_v2_rust-prodash+progress-tree-log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+progress-tree-log-devel-29.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+progress-tree-log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+progress-tree-log-devel}"
SRC_URI[x86_64_v2_rust-prodash+progress-tree-log-devel.sha256sum] = "2dbb129893f3c7ad1f6598236383dc01defe11f0bed84584589e3879aec7f48c"

URI_x86_64_v2_rust-prodash+render-line-autoconfigure-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+render-line-autoconfigure-devel-29.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+render-line-autoconfigure-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+render-line-autoconfigure-devel}"
SRC_URI[x86_64_v2_rust-prodash+render-line-autoconfigure-devel.sha256sum] = "12e3ca857407ee468f87f7a58d8612e59231354de094ce9c2574af72114cf1e7"

URI_x86_64_v2_rust-prodash+signal-hook-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+signal-hook-devel-29.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+signal-hook-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+signal-hook-devel}"
SRC_URI[x86_64_v2_rust-prodash+signal-hook-devel.sha256sum] = "deb0f8365c0038657ab140d4d54f9beee4dcf3a9022127969929d20424101017"

URI_x86_64_v2_rust-prodash+unicode-segmentation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+unicode-segmentation-devel-29.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+unicode-segmentation-devel}"
SRC_URI[x86_64_v2_rust-prodash+unicode-segmentation-devel.sha256sum] = "8c1ee01b01987600ae68981cd1d702f367cdaeab889f2fc99c6cebb76b7bef60"

URI_x86_64_v2_rust-prodash+unicode-width-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+unicode-width-devel-29.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+unicode-width-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+unicode-width-devel}"
SRC_URI[x86_64_v2_rust-prodash+unicode-width-devel.sha256sum] = "5dee6b607107a23b636abddf99564931901946f658c2d40416add95afa1fc133"

URI_x86_64_v2_rust-prodash+unit-bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+unit-bytes-devel-29.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+unit-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+unit-bytes-devel}"
SRC_URI[x86_64_v2_rust-prodash+unit-bytes-devel.sha256sum] = "505618cde2622cec7d612b77f3ba7d6da7df9a6417932d2d761e0915130f3788"

URI_x86_64_v2_rust-prodash+unit-human-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+unit-human-devel-29.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+unit-human-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+unit-human-devel}"
SRC_URI[x86_64_v2_rust-prodash+unit-human-devel.sha256sum] = "612688e0d6861fd8c7e6879a3a53652a0e251266b62abd16598d4cbfa183bbe6"

URI_x86_64_v2_rust-prodash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash-devel-29.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash-devel}"
SRC_URI[x86_64_v2_rust-prodash-devel.sha256sum] = "8764d1d91170b75a8e9373345fa4390ef34709bca47b87597fd9882fcbe08709"

URI_aarch64_rust-prodash+async-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+async-io-devel-29.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-prodash+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+async-io-devel}"
SRC_URI[aarch64_rust-prodash+async-io-devel.sha256sum] = "3818a951ee645caf0da10a0ba81aab2891b2fc91f98cdfd659a5e0e19e1df78d"

URI_aarch64_rust-prodash+bytesize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+bytesize-devel-29.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-prodash+bytesize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+bytesize-devel}"
SRC_URI[aarch64_rust-prodash+bytesize-devel.sha256sum] = "963edb8d3f3f5a41034a040771e00fd4cc6ab015a1b99ef739b48b07773ad59f"

URI_aarch64_rust-prodash+ctrlc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+ctrlc-devel-29.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-prodash+ctrlc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+ctrlc-devel}"
SRC_URI[aarch64_rust-prodash+ctrlc-devel.sha256sum] = "535f6cee58dfbe0e95c3b12940c6c6767fe7891408c79c5b5390bc94a7bc7003"

URI_aarch64_rust-prodash+dashmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+dashmap-devel-29.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-prodash+dashmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+dashmap-devel}"
SRC_URI[aarch64_rust-prodash+dashmap-devel.sha256sum] = "10c47778a57ec726c315c594a89793d7449e0b6d8877d29cc579040113825a0b"

URI_aarch64_rust-prodash+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+default-devel-29.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-prodash+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+default-devel}"
SRC_URI[aarch64_rust-prodash+default-devel.sha256sum] = "0e4fbb12eb6290d238d0ab2288d450c4b22cdc396b288f835986cfb28490428c"

URI_aarch64_rust-prodash+futures-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+futures-core-devel-29.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-prodash+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+futures-core-devel}"
SRC_URI[aarch64_rust-prodash+futures-core-devel.sha256sum] = "de64bd3911613efc02a4b703ed69dafe76ccb62b3b5566062f80fe6e6e16a600"

URI_aarch64_rust-prodash+futures-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+futures-lite-devel-29.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-prodash+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+futures-lite-devel}"
SRC_URI[aarch64_rust-prodash+futures-lite-devel.sha256sum] = "bca95d3284eb7128b88b84dd73e77388815f50c7ff865ea384b1f4131abc73b9"

URI_aarch64_rust-prodash+human_format-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+human_format-devel-29.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-prodash+human_format-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+human_format-devel}"
SRC_URI[aarch64_rust-prodash+human_format-devel.sha256sum] = "68bc60139e78fcc9f44efc964642fc2d6964c4da65e89b30d7d4c943ceb4e2c0"

URI_aarch64_rust-prodash+is-terminal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+is-terminal-devel-29.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-prodash+is-terminal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+is-terminal-devel}"
SRC_URI[aarch64_rust-prodash+is-terminal-devel.sha256sum] = "36c85b495a65fa39bcdf83ade10b56549324e97f61e5e5886fc9f9e7011c4d5a"

URI_aarch64_rust-prodash+jiff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+jiff-devel-29.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-prodash+jiff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+jiff-devel}"
SRC_URI[aarch64_rust-prodash+jiff-devel.sha256sum] = "feca93110436dd56b2c2b5d635726301421647ae093a5f0b3b88ca8720a6db68"

URI_aarch64_rust-prodash+local-time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+local-time-devel-29.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-prodash+local-time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+local-time-devel}"
SRC_URI[aarch64_rust-prodash+local-time-devel.sha256sum] = "912959a30e961799a34fb76a66d2d2cc6bd4bf4fb44cf4c021e7890a138060bc"

URI_aarch64_rust-prodash+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+log-devel-29.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-prodash+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+log-devel}"
SRC_URI[aarch64_rust-prodash+log-devel.sha256sum] = "7f12941539bbe4b2e33def97d9cf846b2c28a7dced86d990d55c698e23a0c9a0"

URI_aarch64_rust-prodash+parking_lot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+parking_lot-devel-29.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-prodash+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+parking_lot-devel}"
SRC_URI[aarch64_rust-prodash+parking_lot-devel.sha256sum] = "7c5297b12cfd769b1fa6cba883f310127f88740098a9aef9d7b96403b4dc4b5a"

URI_aarch64_rust-prodash+progress-log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+progress-log-devel-29.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-prodash+progress-log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+progress-log-devel}"
SRC_URI[aarch64_rust-prodash+progress-log-devel.sha256sum] = "4f1943c98f18059b701a0965cb8058bd66211a64623b95c9a51cf4e29f53cf06"

URI_aarch64_rust-prodash+progress-tree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+progress-tree-devel-29.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-prodash+progress-tree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+progress-tree-devel}"
SRC_URI[aarch64_rust-prodash+progress-tree-devel.sha256sum] = "ab6937ff81c289314298d234bf6db14b01c61daf30fe8aecd0d51a99a134f55f"

URI_aarch64_rust-prodash+progress-tree-hp-hashmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+progress-tree-hp-hashmap-devel-29.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-prodash+progress-tree-hp-hashmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+progress-tree-hp-hashmap-devel}"
SRC_URI[aarch64_rust-prodash+progress-tree-hp-hashmap-devel.sha256sum] = "d9d10fc11916a2e1958cd04563ded51ae46e60c7d1cbe278a6ab47c0045535b6"

URI_aarch64_rust-prodash+progress-tree-log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+progress-tree-log-devel-29.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-prodash+progress-tree-log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+progress-tree-log-devel}"
SRC_URI[aarch64_rust-prodash+progress-tree-log-devel.sha256sum] = "594365826ad713dd8ab704e4896cadbb2d1e49d46f88d899e812a1004116c106"

URI_aarch64_rust-prodash+render-line-autoconfigure-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+render-line-autoconfigure-devel-29.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-prodash+render-line-autoconfigure-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+render-line-autoconfigure-devel}"
SRC_URI[aarch64_rust-prodash+render-line-autoconfigure-devel.sha256sum] = "2d758175b779da4127ba9f52adceea0ef8dfebd38c6fa9433022f380cade6df5"

URI_aarch64_rust-prodash+signal-hook-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+signal-hook-devel-29.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-prodash+signal-hook-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+signal-hook-devel}"
SRC_URI[aarch64_rust-prodash+signal-hook-devel.sha256sum] = "a57b9c6a0f2e5d4ea3372742ae4e63d78f55c2783aaab05262456f8dde41428b"

URI_aarch64_rust-prodash+unicode-segmentation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+unicode-segmentation-devel-29.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-prodash+unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+unicode-segmentation-devel}"
SRC_URI[aarch64_rust-prodash+unicode-segmentation-devel.sha256sum] = "02809deb7ba6f90acb0d8f226e0fa99d09089bb8b25b0dc008ecea76eabd9952"

URI_aarch64_rust-prodash+unicode-width-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+unicode-width-devel-29.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-prodash+unicode-width-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+unicode-width-devel}"
SRC_URI[aarch64_rust-prodash+unicode-width-devel.sha256sum] = "69a669d0064eb6147ba35dd5040dd93ee5a52816e22877dc6b1594f24c51f89e"

URI_aarch64_rust-prodash+unit-bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+unit-bytes-devel-29.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-prodash+unit-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+unit-bytes-devel}"
SRC_URI[aarch64_rust-prodash+unit-bytes-devel.sha256sum] = "877bcc2e21a1cedb7257ff5091ba840dc2bb57f12a0d1a09b55e7a9184075778"

URI_aarch64_rust-prodash+unit-human-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+unit-human-devel-29.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-prodash+unit-human-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+unit-human-devel}"
SRC_URI[aarch64_rust-prodash+unit-human-devel.sha256sum] = "304145dfdd66d6896108ba66d1e513244dcaff31aa19f2d15ed45933fd560d66"

URI_aarch64_rust-prodash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash-devel-29.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-prodash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash-devel}"
SRC_URI[aarch64_rust-prodash-devel.sha256sum] = "eec91f43dccf0b2c5b66e5c30521bd518732bccb3743f88b4f6c44ce66ea6521"

RDEPENDS:rust-prodash+async-io-devel = " \
 cargo \
 rust-async-io+default-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+bytesize-devel = " \
 cargo \
 rust-bytesize+default-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+ctrlc-devel = " \
 cargo \
 rust-ctrlc+termination-devel \
 rust-ctrlc-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+dashmap-devel = " \
 cargo \
 rust-dashmap-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+default-devel = " \
 cargo \
 rust-prodash+progress-tree-devel \
 rust-prodash+progress-tree-log-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+futures-core-devel = " \
 cargo \
 rust-futures-core-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+futures-lite-devel = " \
 cargo \
 rust-futures-lite+default-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+human_format-devel = " \
 cargo \
 rust-human_format+default-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+is-terminal-devel = " \
 cargo \
 rust-is-terminal+default-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+jiff-devel = " \
 cargo \
 rust-jiff+default-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+local-time-devel = " \
 cargo \
 rust-prodash+jiff-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+parking_lot-devel = " \
 cargo \
 rust-parking_lot-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+progress-log-devel = " \
 cargo \
 rust-prodash+log-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+progress-tree-devel = " \
 cargo \
 rust-prodash+parking_lot-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+progress-tree-hp-hashmap-devel = " \
 cargo \
 rust-prodash+dashmap-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+progress-tree-log-devel = " \
 cargo \
 rust-prodash+log-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+render-line-autoconfigure-devel = " \
 cargo \
 rust-prodash+is-terminal-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+signal-hook-devel = " \
 cargo \
 rust-prodash-devel \
 rust-signal-hook-devel \
 "
RDEPENDS:rust-prodash+unicode-segmentation-devel = " \
 cargo \
 rust-prodash-devel \
 rust-unicode-segmentation+default-devel \
 "
RDEPENDS:rust-prodash+unicode-width-devel = " \
 cargo \
 rust-prodash-devel \
 rust-unicode-width0.1+default-devel \
 "
RDEPENDS:rust-prodash+unit-bytes-devel = " \
 cargo \
 rust-prodash+bytesize-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+unit-human-devel = " \
 cargo \
 rust-prodash+human_format-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash-devel = " \
 cargo \
 rust \
 "
