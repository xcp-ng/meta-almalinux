# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-mercantile"
PV = "1.2.1"
PR = "21.el10_2"
PACKAGES = " \
 python3-mercantile \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-mercantile-1.2.1-21.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d5a91898532e867a8efe5fbd04df76c0586ae8fcf241eb568d4df789262c5491"

URI_x86_64_v2_python3-mercantile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mercantile-1.2.1-21.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mercantile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mercantile}"
SRC_URI[x86_64_v2_python3-mercantile.sha256sum] = "f75e0f0ceb60058fe98bfe6732dde5f207d9bdecf49e628877766215374461f4"

URI_aarch64_python3-mercantile = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mercantile-1.2.1-21.el10_2.noarch.rpm;name=aarch64_python3-mercantile;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mercantile}"
SRC_URI[aarch64_python3-mercantile.sha256sum] = "a5909f87350ee2eefa10d0b6c0c62298b29826d86926609197da4d8b8b232c47"

RDEPENDS:python3-mercantile = " \
 python3 \
 python3-click \
 "
