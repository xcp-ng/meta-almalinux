# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-colored"
PV = "3.1.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-colored+default-devel \
 rust-colored+no-color-devel \
 rust-colored-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-colored-3.1.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fc326c93cacd62c834a6a6924d529dd1f621b7b7ec99f21a84b915c3cc9a80ec"

URI_x86_64_v2_rust-colored+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-colored+default-devel-3.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-colored+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-colored+default-devel}"
SRC_URI[x86_64_v2_rust-colored+default-devel.sha256sum] = "d7aadf396ebe7f7fa9098a4171ee4366960a205acd2d0af970643ed20f502a4f"
RPROVIDES:rust-colored+default-devel:x86_64_v2 = "virtual/crate_colored/default__ge_2.0.0_with_crate_colored/default__lt_4.0.0~"

URI_x86_64_v2_rust-colored+no-color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-colored+no-color-devel-3.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-colored+no-color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-colored+no-color-devel}"
SRC_URI[x86_64_v2_rust-colored+no-color-devel.sha256sum] = "580366d358ea009c91cd2777392352281a8fb99696e5a17b1edd91fc7e71c7ae"

URI_x86_64_v2_rust-colored-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-colored-devel-3.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-colored-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-colored-devel}"
SRC_URI[x86_64_v2_rust-colored-devel.sha256sum] = "5b97ecd74d645c417b26534138a53527ca40f97ccf0a55bd84f2041172805452"

URI_aarch64_rust-colored+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-colored+default-devel-3.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-colored+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-colored+default-devel}"
SRC_URI[aarch64_rust-colored+default-devel.sha256sum] = "5720be56921cb41ca9ec7487856ce5903d17fc98ebdc07f6b6671b09aeed9794"
RPROVIDES:rust-colored+default-devel:aarch64 = "virtual/crate_colored/default__ge_2.0.0_with_crate_colored/default__lt_4.0.0~"

URI_aarch64_rust-colored+no-color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-colored+no-color-devel-3.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-colored+no-color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-colored+no-color-devel}"
SRC_URI[aarch64_rust-colored+no-color-devel.sha256sum] = "dbe88e8dff8eadfe2cc271502f0973d6e097285e6d262a9999ac872debc59351"

URI_aarch64_rust-colored-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-colored-devel-3.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-colored-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-colored-devel}"
SRC_URI[aarch64_rust-colored-devel.sha256sum] = "88811ddb5124b0665093c2a62d645456592a1f13d59a84e6459cbac707c27e40"

RDEPENDS:rust-colored+default-devel = " \
 cargo \
 rust-colored-devel \
 "
RDEPENDS:rust-colored+no-color-devel = " \
 cargo \
 rust-colored-devel \
 "
RDEPENDS:rust-colored-devel = " \
 cargo \
 rust \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_colored/default__ge_2.0.0_with_crate_colored/default__lt_4.0.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_colored/default__ge_2.0.0_with_crate_colored/default__lt_4.0.0~"
