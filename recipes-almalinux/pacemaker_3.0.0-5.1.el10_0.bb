# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pacemaker"
PV = "3.0.0"
PR = "5.1.el10_0"
PACKAGES = " \
 pacemaker-cluster-libs \
 pacemaker-libs \
 pacemaker-schemas \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pacemaker-3.0.0-5.1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0630ff3db0a3b71824479f62ff563112a5b50078cebdd94d802d54f53e6cde0a"

URI_x86_64_v2_pacemaker-cluster-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pacemaker-cluster-libs-3.0.0-5.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pacemaker-cluster-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pacemaker-cluster-libs}"
SRC_URI[x86_64_v2_pacemaker-cluster-libs.sha256sum] = "878179ee6c76f756d7dc711020c10cc5e3909b44f21197e93aa10ccb2d79714c"

URI_x86_64_v2_pacemaker-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pacemaker-libs-3.0.0-5.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pacemaker-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pacemaker-libs}"
SRC_URI[x86_64_v2_pacemaker-libs.sha256sum] = "68a2bb135c2196c912475bc59b843530884d6b1c31e4b9a76f452f4692938a2a"

URI_x86_64_v2_pacemaker-schemas = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pacemaker-schemas-3.0.0-5.1.el10_0.noarch.rpm;name=x86_64_v2_pacemaker-schemas;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pacemaker-schemas}"
SRC_URI[x86_64_v2_pacemaker-schemas.sha256sum] = "39b2716c64ca2c1968dc066a6ccd0a4da89244e3f0f0e92c8a185c86ac880617"

URI_aarch64_pacemaker-cluster-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pacemaker-cluster-libs-3.0.0-5.1.el10_0.aarch64.rpm;name=aarch64_pacemaker-cluster-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pacemaker-cluster-libs}"
SRC_URI[aarch64_pacemaker-cluster-libs.sha256sum] = "000f7056d51779855e44fcc3e6d642b5f6f0aa8cbe156b264f5dd0e8b4e692ef"

URI_aarch64_pacemaker-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pacemaker-libs-3.0.0-5.1.el10_0.aarch64.rpm;name=aarch64_pacemaker-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pacemaker-libs}"
SRC_URI[aarch64_pacemaker-libs.sha256sum] = "5b31290378027a5ffe1a55ab292313d5d246a83fbf7423ebe889d2f52f56b225"

URI_aarch64_pacemaker-schemas = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pacemaker-schemas-3.0.0-5.1.el10_0.noarch.rpm;name=aarch64_pacemaker-schemas;unpack=0"
SRC_URI:append = " ${URI_aarch64_pacemaker-schemas}"
SRC_URI[aarch64_pacemaker-schemas.sha256sum] = "39b2716c64ca2c1968dc066a6ccd0a4da89244e3f0f0e92c8a185c86ac880617"

RDEPENDS:pacemaker-cluster-libs = " \
 bzip2-libs \
 corosynclib \
 dbus-libs \
 glib2 \
 glibc \
 gnutls \
 libqb \
 libuuid \
 libxml2 \
 libxslt \
 pacemaker-libs \
 "
RDEPENDS:pacemaker-libs = " \
 bash \
 bzip2-libs \
 dbus-libs \
 glib2 \
 glibc \
 gnutls \
 libqb \
 libuuid \
 libxml2 \
 libxslt \
 pacemaker-schemas \
 shadow-utils \
 "
RDEPENDS:pacemaker-schemas = " \
 pkgconf-pkg-config \
 "
