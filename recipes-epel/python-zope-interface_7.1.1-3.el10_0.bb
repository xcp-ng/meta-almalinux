# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-zope-interface"
PV = "7.1.1"
PR = "3.el10_0"
PACKAGES = " \
 python3-zope-interface \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-zope-interface-7.1.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f86e786b033281dc5a47b92a90bbadf935cb7b2d40abf7e82fdec1e4a9d7977"

URI_x86_64_v2_python3-zope-interface = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-zope-interface-7.1.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-zope-interface;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-zope-interface}"
SRC_URI[x86_64_v2_python3-zope-interface.sha256sum] = "0bc402d982cf5f9a7a79b7a2b6933892668264aa225122ec0525d9f034c191f2"

URI_aarch64_python3-zope-interface = "${EPEL_MIRROR}/aarch64/Packages/p/python3-zope-interface-7.1.1-3.el10_0.aarch64.rpm;name=aarch64_python3-zope-interface;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-zope-interface}"
SRC_URI[aarch64_python3-zope-interface.sha256sum] = "9346f8a8bef3f834492ba11ef9dfedc634982182a8db9efc061e2977fea5aac1"

RDEPENDS:python3-zope-interface = " \
 glibc \
 python3 \
 python3-setuptools \
 "
