# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-knotifyconfig"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-knotifyconfig \
 kf6-knotifyconfig-devel \
 kf6-knotifyconfig-doc \
 kf6-knotifyconfig-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-knotifyconfig-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2596b1a0e22a1caeeeafe5d6d89af4a36cffd7e1324f478e8648b78e97318f85"

URI_x86_64_v2_kf6-knotifyconfig = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifyconfig-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-knotifyconfig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knotifyconfig}"
SRC_URI[x86_64_v2_kf6-knotifyconfig.sha256sum] = "5532b03c7ab1fdf57f0e89062e49d40e1b7c8f4b832956f00ced96e48cea3e5f"

URI_x86_64_v2_kf6-knotifyconfig-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifyconfig-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-knotifyconfig-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knotifyconfig-devel}"
SRC_URI[x86_64_v2_kf6-knotifyconfig-devel.sha256sum] = "16235cf177c2d9a7c0d27f247738850ddb55fd7ef4001276b28a6b869fd95b22"

URI_x86_64_v2_kf6-knotifyconfig-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifyconfig-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-knotifyconfig-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knotifyconfig-doc}"
SRC_URI[x86_64_v2_kf6-knotifyconfig-doc.sha256sum] = "4c3d3422537b849f67e7520894ebfad95b6726dc9157845d006542e77c2395e4"

URI_x86_64_v2_kf6-knotifyconfig-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifyconfig-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-knotifyconfig-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knotifyconfig-html}"
SRC_URI[x86_64_v2_kf6-knotifyconfig-html.sha256sum] = "87c01c70cc5a49adf3875b87a19e5b8323e8e86784be319b0221b800c7f8d8b4"

URI_aarch64_kf6-knotifyconfig = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifyconfig-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-knotifyconfig;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knotifyconfig}"
SRC_URI[aarch64_kf6-knotifyconfig.sha256sum] = "161c2360e2bb974a672ceff677d29d23102346cadc189b046952554b083606e7"

URI_aarch64_kf6-knotifyconfig-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifyconfig-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-knotifyconfig-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knotifyconfig-devel}"
SRC_URI[aarch64_kf6-knotifyconfig-devel.sha256sum] = "9a3abb17416c0c1ef636ab850aa105efe00da0407be0cb23052c0c19105d9f0d"

URI_aarch64_kf6-knotifyconfig-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifyconfig-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-knotifyconfig-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knotifyconfig-doc}"
SRC_URI[aarch64_kf6-knotifyconfig-doc.sha256sum] = "b5a7d57dfe3c11f7948ad4c63086f0eee628f869c08c0fb74697ceb067329868"

URI_aarch64_kf6-knotifyconfig-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifyconfig-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-knotifyconfig-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knotifyconfig-html}"
SRC_URI[aarch64_kf6-knotifyconfig-html.sha256sum] = "8a256f328059499637d51a2657fb2bbef233091c1198af859a4e7eb261a14749"

RDEPENDS:kf6-knotifyconfig = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 libcanberra \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-knotifyconfig-devel = " \
 cmake-filesystem \
 kf6-knotifyconfig \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-knotifyconfig-doc = " \
 "
RDEPENDS:kf6-knotifyconfig-html = " \
 "
