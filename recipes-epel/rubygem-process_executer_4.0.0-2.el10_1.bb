# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-process_executer"
PV = "4.0.0"
PR = "2.el10_1"
PACKAGES = " \
 rubygem-process_executer \
 rubygem-process_executer-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-process_executer-4.0.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f758b41b8056972d4b6be72dd4716c839c52d5a72cd29f2a8a61acdba172afc"

URI_x86_64_v2_rubygem-process_executer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-process_executer-4.0.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-process_executer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-process_executer}"
SRC_URI[x86_64_v2_rubygem-process_executer.sha256sum] = "e7b1881032b9222b427910508fe215320442218bb60de8d67b4b97fc9abe9dd0"

URI_x86_64_v2_rubygem-process_executer-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-process_executer-doc-4.0.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-process_executer-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-process_executer-doc}"
SRC_URI[x86_64_v2_rubygem-process_executer-doc.sha256sum] = "3bfd66f9ec11e185e0ee5268c8f5005fd3d3dcf9050c175558bef87e4f61a581"

URI_aarch64_rubygem-process_executer = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-process_executer-4.0.0-2.el10_1.noarch.rpm;name=aarch64_rubygem-process_executer;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-process_executer}"
SRC_URI[aarch64_rubygem-process_executer.sha256sum] = "046c589406c9bba76e44cfd776e2a2e99d9c66f831e769009321a6c65b1f4147"

URI_aarch64_rubygem-process_executer-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-process_executer-doc-4.0.0-2.el10_1.noarch.rpm;name=aarch64_rubygem-process_executer-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-process_executer-doc}"
SRC_URI[aarch64_rubygem-process_executer-doc.sha256sum] = "239d9fbe64a66f5bfc3d3fa96b534762d5b66d767fc1308a3bedae76848138ad"

RDEPENDS:rubygem-process_executer = " \
 rubygem-track_open_instances \
 rubygems \
 "
RDEPENDS:rubygem-process_executer-doc = " \
 rubygem-process_executer \
 "
