# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtmqtt"
PV = "6.9.1"
PR = "1.el10_1"
PACKAGES = " \
 qt6-qtmqtt \
 qt6-qtmqtt-devel \
 qt6-qtmqtt-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt6-qtmqtt-6.9.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6c90da300c44c18a0c348f4b509e7b31f13a4f035e22e0e059832e1d79bfbaf"

URI_x86_64_v2_qt6-qtmqtt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtmqtt-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtmqtt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtmqtt}"
SRC_URI[x86_64_v2_qt6-qtmqtt.sha256sum] = "82673f52cad20a3ce89beb333bb58afabf0afbf520309900911463584420b387"

URI_x86_64_v2_qt6-qtmqtt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtmqtt-devel-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtmqtt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtmqtt-devel}"
SRC_URI[x86_64_v2_qt6-qtmqtt-devel.sha256sum] = "3fbd9df371e00fe021c4f2916f1b7652e161d476c7747e9d25787cd7174bc144"

URI_x86_64_v2_qt6-qtmqtt-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtmqtt-examples-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtmqtt-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtmqtt-examples}"
SRC_URI[x86_64_v2_qt6-qtmqtt-examples.sha256sum] = "b96b8a75b8425060c07973f4c0ad7ac75959aaab540e45cf446ca4bdca4ae35d"

URI_aarch64_qt6-qtmqtt = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtmqtt-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_qt6-qtmqtt;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtmqtt}"
SRC_URI[aarch64_qt6-qtmqtt.sha256sum] = "15815a76b6706a10eb15d1deb73dd599a27995cba3f6ae121c5b0188ef5831d3"

URI_aarch64_qt6-qtmqtt-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtmqtt-devel-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_qt6-qtmqtt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtmqtt-devel}"
SRC_URI[aarch64_qt6-qtmqtt-devel.sha256sum] = "497913445d457e8f700a10f359bdffd3f269123393d8b150cb7f6a989a374d28"

URI_aarch64_qt6-qtmqtt-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtmqtt-examples-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_qt6-qtmqtt-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtmqtt-examples}"
SRC_URI[aarch64_qt6-qtmqtt-examples.sha256sum] = "6454a949f9e7f566516f9ce4bb58640c075473f82f597c3690788929b03bc64a"

RDEPENDS:qt6-qtmqtt = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:qt6-qtmqtt-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtmqtt \
 "
RDEPENDS:qt6-qtmqtt-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmqtt \
 "
