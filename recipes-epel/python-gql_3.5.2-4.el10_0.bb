# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-gql"
PV = "3.5.2"
PR = "4.el10_0"
PACKAGES = " \
 python3-gql \
 python3-gql+aiohttp \
 python3-gql+botocore \
 python3-gql+httpx \
 python3-gql+requests \
 python3-gql+websockets \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-gql-3.5.2-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a79eab183b7cf07ba361d55b90c194679bbb8884c19f61538675e326fdea3ef"

URI_x86_64_v2_python3-gql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gql-3.5.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-gql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gql}"
SRC_URI[x86_64_v2_python3-gql.sha256sum] = "f82bd19f9a4372bca39640c257fa6ec2e5cf082dc4f82b1e401bc24e57757dd8"

URI_x86_64_v2_python3-gql+aiohttp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gql+aiohttp-3.5.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-gql+aiohttp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gql+aiohttp}"
SRC_URI[x86_64_v2_python3-gql+aiohttp.sha256sum] = "2f3f993efbe8e8f6b1e9f4aa30a07251577486df7229e1f1e6bcaec07c67fbe9"

URI_x86_64_v2_python3-gql+botocore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gql+botocore-3.5.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-gql+botocore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gql+botocore}"
SRC_URI[x86_64_v2_python3-gql+botocore.sha256sum] = "49213e9c01e298143f0d8244db998b4450722f0bee7310dc90950b5e79a27454"

URI_x86_64_v2_python3-gql+httpx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gql+httpx-3.5.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-gql+httpx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gql+httpx}"
SRC_URI[x86_64_v2_python3-gql+httpx.sha256sum] = "6027c88cdd3f2b809fe2f4187f53e290238796aadda94a4ff1be090a1470b0bc"

URI_x86_64_v2_python3-gql+requests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gql+requests-3.5.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-gql+requests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gql+requests}"
SRC_URI[x86_64_v2_python3-gql+requests.sha256sum] = "5626b3e50249f13353dfdd8c02032fc3f32d87727437eb78af7e7fe884ea5ce9"

URI_x86_64_v2_python3-gql+websockets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gql+websockets-3.5.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-gql+websockets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gql+websockets}"
SRC_URI[x86_64_v2_python3-gql+websockets.sha256sum] = "ee12e1be74953be7466f64875671a07e7e8ce7c0e1e920e04fb277ada1f17409"

URI_aarch64_python3-gql = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gql-3.5.2-4.el10_0.noarch.rpm;name=aarch64_python3-gql;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gql}"
SRC_URI[aarch64_python3-gql.sha256sum] = "227898e8d572054f03d4688187d194829ce8477c2b3caafccfc39660f21c8182"

URI_aarch64_python3-gql+aiohttp = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gql+aiohttp-3.5.2-4.el10_0.noarch.rpm;name=aarch64_python3-gql+aiohttp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gql+aiohttp}"
SRC_URI[aarch64_python3-gql+aiohttp.sha256sum] = "76e26e0f29510f8ed45200e8043f4190e3fa7168e299e3890f7c4b32145ee3d9"

URI_aarch64_python3-gql+botocore = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gql+botocore-3.5.2-4.el10_0.noarch.rpm;name=aarch64_python3-gql+botocore;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gql+botocore}"
SRC_URI[aarch64_python3-gql+botocore.sha256sum] = "22a54412d97b1c791a1809f1110a4e14826f0e8b2112a81eddafdb9ecf5b1664"

URI_aarch64_python3-gql+httpx = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gql+httpx-3.5.2-4.el10_0.noarch.rpm;name=aarch64_python3-gql+httpx;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gql+httpx}"
SRC_URI[aarch64_python3-gql+httpx.sha256sum] = "64ec40de6dae71f32bdf492a6be986944d1bbccc54660559fc11881e755c8aea"

URI_aarch64_python3-gql+requests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gql+requests-3.5.2-4.el10_0.noarch.rpm;name=aarch64_python3-gql+requests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gql+requests}"
SRC_URI[aarch64_python3-gql+requests.sha256sum] = "1a4abbe1b2f3e63939bee289d21e649997884c29f8aa766e56a081e74e9b5036"

URI_aarch64_python3-gql+websockets = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gql+websockets-3.5.2-4.el10_0.noarch.rpm;name=aarch64_python3-gql+websockets;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gql+websockets}"
SRC_URI[aarch64_python3-gql+websockets.sha256sum] = "eb5274c7aebbb22b2cdf79282d97f04be9a721be1b8b93633241629c786c3a36"

RDEPENDS:python3-gql = " \
 python3 \
 python3-anyio \
 python3-backoff \
 python3-graphql-core \
 python3-yarl \
 "
RDEPENDS:python3-gql+aiohttp = " \
 python3 \
 python3-aiohttp \
 python3-gql \
 "
RDEPENDS:python3-gql+botocore = " \
 python3 \
 python3-botocore \
 python3-gql \
 "
RDEPENDS:python3-gql+httpx = " \
 python3 \
 python3-gql \
 python3-httpx \
 "
RDEPENDS:python3-gql+requests = " \
 python3 \
 python3-gql \
 python3-requests \
 python3-requests-toolbelt \
 "
RDEPENDS:python3-gql+websockets = " \
 python3 \
 python3-gql \
 python3-websockets \
 "
