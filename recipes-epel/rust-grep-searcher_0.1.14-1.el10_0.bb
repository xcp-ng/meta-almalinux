# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-grep-searcher"
PV = "0.1.14"
PR = "1.el10_0"
PACKAGES = " \
 rust-grep-searcher+default-devel \
 rust-grep-searcher-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-grep-searcher-0.1.14-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9673d86f3f9d0dc3b66796ad619b55cd9f6a749edd42545cf95d68a97969d4a9"

URI_x86_64_v2_rust-grep-searcher+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-searcher+default-devel-0.1.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-searcher+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-searcher+default-devel}"
SRC_URI[x86_64_v2_rust-grep-searcher+default-devel.sha256sum] = "0758074e1f162314514d68ca2c5a4249cef963fa8881b2d80ce547ef543d8d3b"

URI_x86_64_v2_rust-grep-searcher-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-searcher-devel-0.1.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-searcher-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-searcher-devel}"
SRC_URI[x86_64_v2_rust-grep-searcher-devel.sha256sum] = "09768e06d1cda66e3e9dd0b41332c7af8940b3669b00e61e30d0bdb6c5fb7a48"

URI_aarch64_rust-grep-searcher+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-searcher+default-devel-0.1.14-1.el10_0.noarch.rpm;name=aarch64_rust-grep-searcher+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-searcher+default-devel}"
SRC_URI[aarch64_rust-grep-searcher+default-devel.sha256sum] = "d94889677c30ec37951f07fe59352f6f69d02a59e088fd078b7510b451f36574"

URI_aarch64_rust-grep-searcher-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-searcher-devel-0.1.14-1.el10_0.noarch.rpm;name=aarch64_rust-grep-searcher-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-searcher-devel}"
SRC_URI[aarch64_rust-grep-searcher-devel.sha256sum] = "8b6559915b262f6b921ab44fcf7ccae8c3c3e89772785657bb63c15baa8bd962"

RDEPENDS:rust-grep-searcher+default-devel = " \
 cargo \
 rust-grep-searcher-devel \
 "
RDEPENDS:rust-grep-searcher-devel = " \
 cargo \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-encoding_rs+default-devel \
 rust-encoding_rs_io+default-devel \
 rust-grep-matcher+default-devel \
 rust-log+default-devel \
 rust-memchr+default-devel \
 rust-memmap2+default-devel \
 "
