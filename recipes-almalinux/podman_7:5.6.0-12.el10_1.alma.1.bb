# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "podman"
PE = "7"
PV = "5.6.0"
PR = "12.el10_1.alma.1"
PACKAGES = " \
 podman \
 podman-docker \
 podman-remote \
 podman-tests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/podman-5.6.0-12.el10_1.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5b290ef4616a65c96aa8c7f4f612b99466173763372a5b6987278328898c7c9e"

URI_x86_64_v2_podman = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/podman-5.6.0-12.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_podman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_podman}"
SRC_URI[x86_64_v2_podman.sha256sum] = "457cd64589fae05744c760c6106a2deee16545573047de9d4e740a88574ef297"
RPROVIDES:podman:x86_64_v2 = "virtual/podman_or_/usr/bin/docker"

URI_x86_64_v2_podman-docker = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/podman-docker-5.6.0-12.el10_1.alma.1.noarch.rpm;name=x86_64_v2_podman-docker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_podman-docker}"
SRC_URI[x86_64_v2_podman-docker.sha256sum] = "80f70b57e8c0d83fc499d457c70ac52864961794ccf398aa96dac4e858438a80"
RPROVIDES:podman-docker:x86_64_v2 = "virtual/podman_or_/usr/bin/docker"

URI_x86_64_v2_podman-remote = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/podman-remote-5.6.0-12.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_podman-remote;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_podman-remote}"
SRC_URI[x86_64_v2_podman-remote.sha256sum] = "acdb7f6751c3bd0b070494316f6b3e0d6e61eb157ccab875a2bfc711f933d865"

URI_x86_64_v2_podman-tests = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/podman-tests-5.6.0-12.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_podman-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_podman-tests}"
SRC_URI[x86_64_v2_podman-tests.sha256sum] = "d742866fac7753a6f86ccd704610d49571ea7dd15e09b28beaabdd812cc8bec3"

URI_aarch64_podman = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/podman-5.6.0-12.el10_1.alma.1.aarch64.rpm;name=aarch64_podman;unpack=0"
SRC_URI:append = " ${URI_aarch64_podman}"
SRC_URI[aarch64_podman.sha256sum] = "eb81c842939953015a3d5b1e6fe13691a4260904610f151574cc2c6e46c6b68c"
RPROVIDES:podman:aarch64 = "virtual/podman_or_/usr/bin/docker"

URI_aarch64_podman-docker = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/podman-docker-5.6.0-12.el10_1.alma.1.noarch.rpm;name=aarch64_podman-docker;unpack=0"
SRC_URI:append = " ${URI_aarch64_podman-docker}"
SRC_URI[aarch64_podman-docker.sha256sum] = "80f70b57e8c0d83fc499d457c70ac52864961794ccf398aa96dac4e858438a80"
RPROVIDES:podman-docker:aarch64 = "virtual/podman_or_/usr/bin/docker"

URI_aarch64_podman-remote = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/podman-remote-5.6.0-12.el10_1.alma.1.aarch64.rpm;name=aarch64_podman-remote;unpack=0"
SRC_URI:append = " ${URI_aarch64_podman-remote}"
SRC_URI[aarch64_podman-remote.sha256sum] = "97052bb5191b7a151b7e8b01413c14fc76ca2d9cd1a21705b9d75529d3d7c6bd"

URI_aarch64_podman-tests = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/podman-tests-5.6.0-12.el10_1.alma.1.aarch64.rpm;name=aarch64_podman-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_podman-tests}"
SRC_URI[aarch64_podman-tests.sha256sum] = "37dba6482c3d74948b76acd7f8d94e20ae27d5db11fe360b4799d27b369d4083"

RDEPENDS:podman = " \
 catatonit \
 conmon \
 containers-common-extra \
 glibc \
 gpgme \
 libgcc \
 libseccomp \
 shadow-utils-subid \
 sqlite-libs \
 "
RDEPENDS:podman-docker = " \
 bash \
 podman \
 "
RDEPENDS:podman-remote = " \
 glibc \
 gpgme \
 libgcc \
 shadow-utils-subid \
 sqlite-libs \
 "
RDEPENDS:podman-tests = " \
 attr \
 bash \
 buildah \
 glibc \
 gnupg2 \
 gpgme \
 httpd-tools \
 jq \
 libgcc \
 libseccomp \
 nmap-ncat \
 openssl \
 podman \
 shadow-utils-subid \
 skopeo \
 slirp4netns \
 socat \
 sqlite-libs \
 xfsprogs \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/podman_or_/usr/bin/docker"

PROVIDES:append:aarch64 = " rpm/virtual/podman_or_/usr/bin/docker"
