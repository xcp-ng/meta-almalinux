# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-distutils-extra"
PV = "2.39"
PR = "39.el10_1"
PACKAGES = " \
 python3-distutils-extra \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-distutils-extra-2.39-39.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1fdd974f9b4862c04ce6df5ba12d1c7303ec657b03e062ab5cae5c8241b717ef"

URI_x86_64_v2_python3-distutils-extra = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-distutils-extra-2.39-39.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-distutils-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-distutils-extra}"
SRC_URI[x86_64_v2_python3-distutils-extra.sha256sum] = "d5dbc5f343c1ce0a63629be78046f8185938dde4aab40be2e52e219d402914a9"

URI_aarch64_python3-distutils-extra = "${EPEL_MIRROR}/aarch64/Packages/p/python3-distutils-extra-2.39-39.el10_1.noarch.rpm;name=aarch64_python3-distutils-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-distutils-extra}"
SRC_URI[aarch64_python3-distutils-extra.sha256sum] = "bc3502629ea87760ed58d04717fc5cc07fe69ae9ee75daeccb7bf8d3d55bb4f7"

RDEPENDS:python3-distutils-extra = " \
 intltool \
 python3 \
 python3-setuptools \
 "
