# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "postgresql-jdbc"
PV = "42.7.2"
PR = "1.el10_2.2"
PACKAGES = " \
 postgresql-jdbc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/postgresql-jdbc-42.7.2-1.el10_2.2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d71fbe67260d209cecf7ede41809c5db1b27ed751a331789967b4975c3865d5b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-jdbc-42.7.2-1.el10_2.2.noarch.rpm;name=x86_64_v2_postgresql-jdbc;unpack=0"
SRC_URI[x86_64_v2_postgresql-jdbc.sha256sum] = "12ad5a0377cc543161f693dbedf80444ce6430610d3c37c638d24895a91baf32"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-jdbc-42.7.2-1.el10_2.2.noarch.rpm;name=aarch64_postgresql-jdbc;unpack=0"
SRC_URI[aarch64_postgresql-jdbc.sha256sum] = "12ad5a0377cc543161f693dbedf80444ce6430610d3c37c638d24895a91baf32"

RDEPENDS:postgresql-jdbc = " \
 javapackages-filesystem \
 ongres-scram-client \
 "
