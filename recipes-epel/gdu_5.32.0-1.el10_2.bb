# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gdu"
PV = "5.32.0"
PR = "1.el10_2"
PACKAGES = " \
 gdu \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/gdu-5.32.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "29f98a2fef7922c09da4c0d36cf5adadfffccbe3783ebdf868b4b149fe55e33b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gdu-5.32.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gdu;unpack=0"
SRC_URI[x86_64_v2_gdu.sha256sum] = "464b25b54cc56f777f8effec75a296bd635f15c13b948f685e7fe891524ce66f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gdu-5.32.0-1.el10_2.aarch64.rpm;name=aarch64_gdu;unpack=0"
SRC_URI[aarch64_gdu.sha256sum] = "dc92dc5f87fcc1f9a910fba23886a71322c34fda171bbded32f404d286aa75af"

RDEPENDS:gdu = " \
 glibc \
 "
