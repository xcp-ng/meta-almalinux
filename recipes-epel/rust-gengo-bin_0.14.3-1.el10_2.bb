# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gengo-bin"
PV = "0.14.3"
PR = "1.el10_2"
PACKAGES = " \
 gengo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gengo-bin-0.14.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9346895767e6bdd0ace31ee76018b5cc0335cf72d5d63676c1db51c144800634"

URI_x86_64_v2_gengo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gengo-0.14.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gengo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gengo}"
SRC_URI[x86_64_v2_gengo.sha256sum] = "d3376c39a63c8244081049d513055d735bbb37d8c7b21b1191ce735fe1a051f6"

URI_aarch64_gengo = "${EPEL_MIRROR}/aarch64/Packages/g/gengo-0.14.3-1.el10_2.aarch64.rpm;name=aarch64_gengo;unpack=0"
SRC_URI:append = " ${URI_aarch64_gengo}"
SRC_URI[aarch64_gengo.sha256sum] = "e691807358165cec9f34a0ab447ecabd55680e59ad1b07a3748f39819cf9bd28"

RDEPENDS:gengo = " \
 glibc \
 libgcc \
 "
