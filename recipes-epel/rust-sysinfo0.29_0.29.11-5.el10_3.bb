# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sysinfo0.29"
PV = "0.29.11"
PR = "5.el10_3"
PACKAGES = " \
 rust-sysinfo0.29+c-interface-devel \
 rust-sysinfo0.29+debug-devel \
 rust-sysinfo0.29+default-devel \
 rust-sysinfo0.29+multithread-devel \
 rust-sysinfo0.29+rayon-devel \
 rust-sysinfo0.29+serde-devel \
 rust-sysinfo0.29-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sysinfo0.29-0.29.11-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fdfd25f5b34a2bbfe9065a395d913ce68d17a2f244f6980d93ee6f444dfd6e4f"

URI_x86_64_v2_rust-sysinfo0.29+c-interface-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.29+c-interface-devel-0.29.11-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.29+c-interface-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.29+c-interface-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.29+c-interface-devel.sha256sum] = "905f396bf139ea2314729f6e541fdba57828634ac442c430e89d21d9380b572c"

URI_x86_64_v2_rust-sysinfo0.29+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.29+debug-devel-0.29.11-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.29+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.29+debug-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.29+debug-devel.sha256sum] = "f94a7369f93088e9fb77f7801acf4c65471962cc788774e3f90c37532c388c67"

URI_x86_64_v2_rust-sysinfo0.29+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.29+default-devel-0.29.11-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.29+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.29+default-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.29+default-devel.sha256sum] = "fd0bd6445f9c1860624edbbae431613a103a7f5c5e93cb1bceff3afdd89b4673"

URI_x86_64_v2_rust-sysinfo0.29+multithread-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.29+multithread-devel-0.29.11-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.29+multithread-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.29+multithread-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.29+multithread-devel.sha256sum] = "a93f9d81576a422224d4dc3bec6d890895f37f1b5dce3a55e70d444f5e96fc9f"

URI_x86_64_v2_rust-sysinfo0.29+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.29+rayon-devel-0.29.11-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.29+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.29+rayon-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.29+rayon-devel.sha256sum] = "f52533aedf77cd12f82a911ae6b1de7b6a00a7c88e8a97c22d78acd3430f9140"

URI_x86_64_v2_rust-sysinfo0.29+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.29+serde-devel-0.29.11-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.29+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.29+serde-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.29+serde-devel.sha256sum] = "51566e578a4e7f61c634f1f0b218dd4a105c963e0a1c90c0bd149f93874cd841"

URI_x86_64_v2_rust-sysinfo0.29-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.29-devel-0.29.11-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.29-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.29-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.29-devel.sha256sum] = "f05e0252046d27e045357c54d573e1e8b41ea964992a131c1660c9e77725ba3c"

URI_aarch64_rust-sysinfo0.29+c-interface-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.29+c-interface-devel-0.29.11-5.el10_3.noarch.rpm;name=aarch64_rust-sysinfo0.29+c-interface-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.29+c-interface-devel}"
SRC_URI[aarch64_rust-sysinfo0.29+c-interface-devel.sha256sum] = "1202d8a6f0848064a727ee510bec8b9ca39e226607ba02a1ee620f1ac39ead73"

URI_aarch64_rust-sysinfo0.29+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.29+debug-devel-0.29.11-5.el10_3.noarch.rpm;name=aarch64_rust-sysinfo0.29+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.29+debug-devel}"
SRC_URI[aarch64_rust-sysinfo0.29+debug-devel.sha256sum] = "92f6cf7ba56dd05b1e843f24ea1bd0c929cf87df171a68ea67a15d14103ba2e9"

URI_aarch64_rust-sysinfo0.29+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.29+default-devel-0.29.11-5.el10_3.noarch.rpm;name=aarch64_rust-sysinfo0.29+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.29+default-devel}"
SRC_URI[aarch64_rust-sysinfo0.29+default-devel.sha256sum] = "b93302332fb396129ef35abce782c5a45cf43a1b3aae5da989ef10e24a0ed172"

URI_aarch64_rust-sysinfo0.29+multithread-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.29+multithread-devel-0.29.11-5.el10_3.noarch.rpm;name=aarch64_rust-sysinfo0.29+multithread-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.29+multithread-devel}"
SRC_URI[aarch64_rust-sysinfo0.29+multithread-devel.sha256sum] = "49e9805874a7d14c349e19a1aded2c61286a9ba713d38a9435ffb70f70449bb8"

URI_aarch64_rust-sysinfo0.29+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.29+rayon-devel-0.29.11-5.el10_3.noarch.rpm;name=aarch64_rust-sysinfo0.29+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.29+rayon-devel}"
SRC_URI[aarch64_rust-sysinfo0.29+rayon-devel.sha256sum] = "9cecafefb1651e72c69f57d5078fd66dfcd31fafa1374b5e4913cc70f1773f24"

URI_aarch64_rust-sysinfo0.29+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.29+serde-devel-0.29.11-5.el10_3.noarch.rpm;name=aarch64_rust-sysinfo0.29+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.29+serde-devel}"
SRC_URI[aarch64_rust-sysinfo0.29+serde-devel.sha256sum] = "9decae950a27558571b1267b21be85ce6db2204cedcd40a5186993b469d3f7c5"

URI_aarch64_rust-sysinfo0.29-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.29-devel-0.29.11-5.el10_3.noarch.rpm;name=aarch64_rust-sysinfo0.29-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.29-devel}"
SRC_URI[aarch64_rust-sysinfo0.29-devel.sha256sum] = "46b7b1ac3ab1962ae041303cff486e390e2b52e1c2bd5b1d3f3797114f4187a2"

RDEPENDS:rust-sysinfo0.29+c-interface-devel = " \
 cargo \
 rust-sysinfo0.29-devel \
 "
RDEPENDS:rust-sysinfo0.29+debug-devel = " \
 cargo \
 rust-libc+extra_traits-devel \
 rust-sysinfo0.29-devel \
 "
RDEPENDS:rust-sysinfo0.29+default-devel = " \
 cargo \
 rust-sysinfo0.29+multithread-devel \
 rust-sysinfo0.29-devel \
 "
RDEPENDS:rust-sysinfo0.29+multithread-devel = " \
 cargo \
 rust-sysinfo0.29+rayon-devel \
 rust-sysinfo0.29-devel \
 "
RDEPENDS:rust-sysinfo0.29+rayon-devel = " \
 cargo \
 rust-rayon+default-devel \
 rust-sysinfo0.29-devel \
 "
RDEPENDS:rust-sysinfo0.29+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-sysinfo0.29-devel \
 "
RDEPENDS:rust-sysinfo0.29-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 rust-once_cell+default-devel \
 "
