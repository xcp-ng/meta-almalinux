# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tinc"
PV = "1.0.36"
PR = "13.el10_1"
PACKAGES = " \
 tinc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tinc-1.0.36-13.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ddfc98b318f71277c900d2c828d97ef159ade89ba49bc1c2c2554e468b2cb3b2"

URI_x86_64_v2_tinc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tinc-1.0.36-13.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tinc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tinc}"
SRC_URI[x86_64_v2_tinc.sha256sum] = "707c450f55c27a727a6804550a33f5d30535a55487c077c572f7111b407b793b"

URI_aarch64_tinc = "${EPEL_MIRROR}/aarch64/Packages/t/tinc-1.0.36-13.el10_1.aarch64.rpm;name=aarch64_tinc;unpack=0"
SRC_URI:append = " ${URI_aarch64_tinc}"
SRC_URI[aarch64_tinc.sha256sum] = "e2d128c78d66060cf142805bc0fa3e878ad1d5c558ad49fbd634a2dadf627d3c"

RDEPENDS:tinc = " \
 bash \
 glibc \
 lzo \
 openssl-libs \
 systemd \
 zlib-ng-compat \
 "
