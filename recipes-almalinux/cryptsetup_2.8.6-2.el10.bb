# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cryptsetup"
PV = "2.8.6"
PR = "2.el10"
PACKAGES = " \
 cryptsetup \
 cryptsetup-devel \
 cryptsetup-libs \
 integritysetup \
 veritysetup \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/cryptsetup-2.8.6-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "419e820fb70dca9d412ad8889d83561183e953cb3f9782173098354d94c4fd7e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cryptsetup-2.8.6-2.el10.x86_64_v2.rpm;name=x86_64_v2_cryptsetup;unpack=0"
SRC_URI[x86_64_v2_cryptsetup.sha256sum] = "c0797e0bc9735f8fca28ba00877d02f97c9d08f648b53b3621f97fd8ca1faf5c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/cryptsetup-devel-2.8.6-2.el10.x86_64_v2.rpm;name=x86_64_v2_cryptsetup-devel;unpack=0"
SRC_URI[x86_64_v2_cryptsetup-devel.sha256sum] = "4c04df8dcf4ef119bba3847ef560dc9ab04838933abc44e9c81b4d5334a5374e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cryptsetup-libs-2.8.6-2.el10.x86_64_v2.rpm;name=x86_64_v2_cryptsetup-libs;unpack=0"
SRC_URI[x86_64_v2_cryptsetup-libs.sha256sum] = "207105fd1f0fde62ebc20bfd046c696864f9da2f9e9c7adb29403db8414454ac"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/integritysetup-2.8.6-2.el10.x86_64_v2.rpm;name=x86_64_v2_integritysetup;unpack=0"
SRC_URI[x86_64_v2_integritysetup.sha256sum] = "89aae2b053f85a846821d22875766a61d68fb856d6bc4754eb5e71cf34f8613e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/veritysetup-2.8.6-2.el10.x86_64_v2.rpm;name=x86_64_v2_veritysetup;unpack=0"
SRC_URI[x86_64_v2_veritysetup.sha256sum] = "5721bdf4a924713bf10511f9f4f54e1a2e58db9c24138b524b17ae99929df27f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cryptsetup-2.8.6-2.el10.aarch64.rpm;name=aarch64_cryptsetup;unpack=0"
SRC_URI[aarch64_cryptsetup.sha256sum] = "08780daf2a947047acf4d4a1f9fe77bcdd35d3e79b4dc65df583f905ffa2e666"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/cryptsetup-devel-2.8.6-2.el10.aarch64.rpm;name=aarch64_cryptsetup-devel;unpack=0"
SRC_URI[aarch64_cryptsetup-devel.sha256sum] = "7dcf68e3a6133a0360da50904bb7e11cafa67c70a4a09489498f99a3490521f6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cryptsetup-libs-2.8.6-2.el10.aarch64.rpm;name=aarch64_cryptsetup-libs;unpack=0"
SRC_URI[aarch64_cryptsetup-libs.sha256sum] = "4bc5a6a8d549f6823292a0fddba9c300d82d2e9e2e4279c1fdcf3857efe8ecba"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/integritysetup-2.8.6-2.el10.aarch64.rpm;name=aarch64_integritysetup;unpack=0"
SRC_URI[aarch64_integritysetup.sha256sum] = "cd4ab8cb8ab8ead6724e8a1c7a29e669b6b0c2a50505584bb2e8f167b4813827"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/veritysetup-2.8.6-2.el10.aarch64.rpm;name=aarch64_veritysetup;unpack=0"
SRC_URI[aarch64_veritysetup.sha256sum] = "62d02872767bc6382de3cd220d17e9c1643809da355b16e5fbf5a1bce745d880"

RDEPENDS:cryptsetup = " \
 cryptsetup-libs \
 glibc \
 libblkid \
 libpwquality \
 libuuid \
 popt \
 "
RDEPENDS:cryptsetup-devel = " \
 cryptsetup-libs \
 device-mapper-devel \
 json-c-devel \
 libblkid-devel \
 libuuid-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:cryptsetup-libs = " \
 device-mapper-libs \
 glibc \
 json-c \
 libblkid \
 libuuid \
 openssl-libs \
 "
RDEPENDS:integritysetup = " \
 cryptsetup-libs \
 glibc \
 libblkid \
 libuuid \
 popt \
 "
RDEPENDS:veritysetup = " \
 cryptsetup-libs \
 glibc \
 popt \
 "
