# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pcl"
PV = "1.15.1"
PR = "2.el10_2"
PACKAGES = " \
 pcl \
 pcl-devel \
 pcl-doc \
 pcl-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pcl-1.15.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b5e8b5f858c01841f552334deb4336760fece60acfb19fbc820acfcaf59b051a"

URI_x86_64_v2_pcl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pcl-1.15.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pcl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcl}"
SRC_URI[x86_64_v2_pcl.sha256sum] = "9d9c1457f2f2f4253c629feb3a41ebe7abd038afd5f5368fe745eb38b531edaf"

URI_x86_64_v2_pcl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pcl-devel-1.15.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pcl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcl-devel}"
SRC_URI[x86_64_v2_pcl-devel.sha256sum] = "4a56e36aa759f7ab5783563cd0c47a59438a8ffb66781f07136d9317b3d1e51e"

URI_x86_64_v2_pcl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pcl-doc-1.15.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_pcl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcl-doc}"
SRC_URI[x86_64_v2_pcl-doc.sha256sum] = "a8fa7de29a71ee697b6d9c78ec4af7e2fb13fc924bc2fd34448c48cdb65a97db"

URI_x86_64_v2_pcl-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pcl-tools-1.15.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pcl-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcl-tools}"
SRC_URI[x86_64_v2_pcl-tools.sha256sum] = "413d336532ab0cf61bb3400427584fa2ad30458fce189efeb42829050eb3fe8f"

URI_aarch64_pcl = "${EPEL_MIRROR}/aarch64/Packages/p/pcl-1.15.1-2.el10_2.aarch64.rpm;name=aarch64_pcl;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcl}"
SRC_URI[aarch64_pcl.sha256sum] = "f4fd089727c0cc7f877b5879aa080252602e7f1690c0e57d4b09fa96c5ef6c63"

URI_aarch64_pcl-devel = "${EPEL_MIRROR}/aarch64/Packages/p/pcl-devel-1.15.1-2.el10_2.aarch64.rpm;name=aarch64_pcl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcl-devel}"
SRC_URI[aarch64_pcl-devel.sha256sum] = "e7be2ff0f76655cb7a53213c81edd1dcc2be51419d3657476dd03319e3ddcccb"

URI_aarch64_pcl-doc = "${EPEL_MIRROR}/aarch64/Packages/p/pcl-doc-1.15.1-2.el10_2.noarch.rpm;name=aarch64_pcl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcl-doc}"
SRC_URI[aarch64_pcl-doc.sha256sum] = "c755d506168f13a360468d8449f0c3f54c9a911e44f865bdb7419058cf71c0fd"

URI_aarch64_pcl-tools = "${EPEL_MIRROR}/aarch64/Packages/p/pcl-tools-1.15.1-2.el10_2.aarch64.rpm;name=aarch64_pcl-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcl-tools}"
SRC_URI[aarch64_pcl-tools.sha256sum] = "14cd0a7bb4a525293fd969be1cb49c861dd1cd279a58e9488d03f1a6ca5541be"

RDEPENDS:pcl:x86_64_v2 = " \
 boost-iostreams \
 glibc \
 libgcc \
 libgomp \
 libpcap \
 libqhull_r \
 libstdc++ \
 libusb1 \
 lz4-libs \
 openni \
"
RDEPENDS:pcl:aarch64 = " \
 boost-iostreams \
 glibc \
 libgcc \
 libgomp \
 libpcap \
 libqhull_r \
 libstdc++ \
 libusb1 \
 lz4-libs \
"
RDEPENDS:pcl-devel:x86_64_v2 = " \
 cmake-filesystem \
 eigen3-devel \
 flann-devel \
 libusb1-devel \
 openni-devel \
 pcl \
 pcl-devel \
 pkgconf-pkg-config \
 qhull-devel \
"
RDEPENDS:pcl-devel:aarch64 = " \
 cmake-filesystem \
 eigen3-devel \
 flann-devel \
 libusb1-devel \
 pcl \
 pcl-devel \
 pkgconf-pkg-config \
 qhull-devel \
"
RDEPENDS:pcl-doc = " \
 "
RDEPENDS:pcl-tools:x86_64_v2 = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 openni \
 pcl \
"
RDEPENDS:pcl-tools:aarch64 = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 pcl \
"
