# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-content_inspector"
PV = "0.2.4"
PR = "19.el10_0"
PACKAGES = " \
 rust-content_inspector+default-devel \
 rust-content_inspector-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-content_inspector-0.2.4-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d1ede212e90e680e833de80e0c3ab0c77f42c6b1d6cb8939f8f83c67ce4d5017"

URI_x86_64_v2_rust-content_inspector+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-content_inspector+default-devel-0.2.4-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-content_inspector+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-content_inspector+default-devel}"
SRC_URI[x86_64_v2_rust-content_inspector+default-devel.sha256sum] = "5fe8026a2b4fc6490c35f9bf32d744c0fe0179a257015410daadcb4081ed8044"

URI_x86_64_v2_rust-content_inspector-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-content_inspector-devel-0.2.4-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-content_inspector-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-content_inspector-devel}"
SRC_URI[x86_64_v2_rust-content_inspector-devel.sha256sum] = "ddd0c3f02729cfe705ec9bc212fdeb5135ada8d53bbc2665539127a3efb7dce2"

URI_aarch64_rust-content_inspector+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-content_inspector+default-devel-0.2.4-19.el10_0.noarch.rpm;name=aarch64_rust-content_inspector+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-content_inspector+default-devel}"
SRC_URI[aarch64_rust-content_inspector+default-devel.sha256sum] = "74b771ebdf64ce1b6496f6a0a154602ebde2e884db2e35cfdf7ac53c5ebf6b35"

URI_aarch64_rust-content_inspector-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-content_inspector-devel-0.2.4-19.el10_0.noarch.rpm;name=aarch64_rust-content_inspector-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-content_inspector-devel}"
SRC_URI[aarch64_rust-content_inspector-devel.sha256sum] = "783ddc18d1efdf62e4edc9f002cc9640062e4562dd1ac5c9efcb51bba338eeff"

RDEPENDS:rust-content_inspector+default-devel = " \
 cargo \
 rust-content_inspector-devel \
 "
RDEPENDS:rust-content_inspector-devel = " \
 cargo \
 rust-memchr+default-devel \
 "
