# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-data-default"
PV = "0.7.1.1"
PR = "38.el10_0"
PACKAGES = " \
 ghc-data-default \
 ghc-data-default-devel \
 ghc-data-default-doc \
 ghc-data-default-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-data-default-0.7.1.1-38.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25ea26a3f6ad93528cddebdab45267a3c0cc2d20cad4bc461b4b2f9bc099793b"

URI_x86_64_v2_ghc-data-default = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-default-0.7.1.1-38.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-data-default;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-default}"
SRC_URI[x86_64_v2_ghc-data-default.sha256sum] = "2673b59978bdcf9ff9b5466a699912687823aeea81243a5e9c957306e5113ad8"

URI_x86_64_v2_ghc-data-default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-default-devel-0.7.1.1-38.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-data-default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-default-devel}"
SRC_URI[x86_64_v2_ghc-data-default-devel.sha256sum] = "dd47a6f5b37ce01fce2e5a22c41575911f0a5fa02a8a8943c6ce0352b52d102c"

URI_x86_64_v2_ghc-data-default-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-default-doc-0.7.1.1-38.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-data-default-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-default-doc}"
SRC_URI[x86_64_v2_ghc-data-default-doc.sha256sum] = "f656b8de6237a7efe6219ca1bf4e893e3ba84c7f75e0cfc84f06edacea1454c8"

URI_x86_64_v2_ghc-data-default-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-default-prof-0.7.1.1-38.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-data-default-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-default-prof}"
SRC_URI[x86_64_v2_ghc-data-default-prof.sha256sum] = "7af1c940ac9e3c69ced14845843bc0e38df78b6601dc9976763064a556850140"

URI_aarch64_ghc-data-default = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-default-0.7.1.1-38.el10_0.aarch64.rpm;name=aarch64_ghc-data-default;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-default}"
SRC_URI[aarch64_ghc-data-default.sha256sum] = "a8eb4c8fe72de31ce25101b40035b49f677f9303c11485a034e2202fbe6094a8"

URI_aarch64_ghc-data-default-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-default-devel-0.7.1.1-38.el10_0.aarch64.rpm;name=aarch64_ghc-data-default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-default-devel}"
SRC_URI[aarch64_ghc-data-default-devel.sha256sum] = "982c5efe01d3415896bce1a089b364d1d03bfcc546c7ad6c01b55e321603d84c"

URI_aarch64_ghc-data-default-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-default-doc-0.7.1.1-38.el10_0.noarch.rpm;name=aarch64_ghc-data-default-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-default-doc}"
SRC_URI[aarch64_ghc-data-default-doc.sha256sum] = "5376b3e69832c37e0731417124db96b1005718afcbe32433c1d70e8113bcf8a5"

URI_aarch64_ghc-data-default-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-default-prof-0.7.1.1-38.el10_0.aarch64.rpm;name=aarch64_ghc-data-default-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-default-prof}"
SRC_URI[aarch64_ghc-data-default-prof.sha256sum] = "92e3cbc6a83a6271cc36db48c88df7a3d1dc26a7e529f2ef9d44e8a2dc1ba49c"

RDEPENDS:ghc-data-default = " \
 ghc-array \
 ghc-base \
 ghc-containers \
 ghc-data-default-class \
 ghc-data-default-instances-containers \
 ghc-data-default-instances-dlist \
 ghc-data-default-instances-old-locale \
 ghc-deepseq \
 ghc-dlist \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-old-locale \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-data-default-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-data-default \
 ghc-data-default-class-devel \
 ghc-data-default-instances-containers-devel \
 ghc-data-default-instances-dlist-devel \
 ghc-data-default-instances-old-locale-devel \
 "
RDEPENDS:ghc-data-default-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-data-default-prof = " \
 ghc-base-prof \
 ghc-data-default-class-prof \
 ghc-data-default-devel \
 ghc-data-default-instances-containers-prof \
 ghc-data-default-instances-dlist-prof \
 ghc-data-default-instances-old-locale-prof \
 "
