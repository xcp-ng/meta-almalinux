# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustdct"
PV = "0.7.1"
PR = "3.el10_0"
PACKAGES = " \
 rust-rustdct+default-devel \
 rust-rustdct-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustdct-0.7.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f74be7c6e210247aefa2dec83cec2bf0fca0e63c7993be02425789dba97f1357"

URI_x86_64_v2_rust-rustdct+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustdct+default-devel-0.7.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustdct+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustdct+default-devel}"
SRC_URI[x86_64_v2_rust-rustdct+default-devel.sha256sum] = "e193d2c3574ba83c5e709b88ca371d81036b9a41a7597359ff63176fc7109b6c"

URI_x86_64_v2_rust-rustdct-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustdct-devel-0.7.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustdct-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustdct-devel}"
SRC_URI[x86_64_v2_rust-rustdct-devel.sha256sum] = "c2275ab444918940f6830e7eecf85326c7dd709021aa41ce341c0f87f28a2749"

URI_aarch64_rust-rustdct+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustdct+default-devel-0.7.1-3.el10_0.noarch.rpm;name=aarch64_rust-rustdct+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustdct+default-devel}"
SRC_URI[aarch64_rust-rustdct+default-devel.sha256sum] = "08ec943f293ace5dbcaf40075e286cf33c3003785a57ef6a63848852db866e61"

URI_aarch64_rust-rustdct-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustdct-devel-0.7.1-3.el10_0.noarch.rpm;name=aarch64_rust-rustdct-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustdct-devel}"
SRC_URI[aarch64_rust-rustdct-devel.sha256sum] = "b76d139177cb5719f4326ff24f1cd8e6e4f6bacc528f3da3e041bea148676681"

RDEPENDS:rust-rustdct+default-devel = " \
 cargo \
 rust-rustdct-devel \
 "
RDEPENDS:rust-rustdct-devel = " \
 cargo \
 rust-rustfft+default-devel \
 "
