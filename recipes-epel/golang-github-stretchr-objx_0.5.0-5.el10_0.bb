# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-stretchr-objx"
PV = "0.5.0"
PR = "5.el10_0"
PACKAGES = " \
 golang-github-stretchr-objx-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-stretchr-objx-0.5.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c63b21bc7c5658bad54fc66a8ebb9ae884bf435681b6366681f0bda63a9266cd"

URI_x86_64_v2_golang-github-stretchr-objx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-stretchr-objx-devel-0.5.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-stretchr-objx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-stretchr-objx-devel}"
SRC_URI[x86_64_v2_golang-github-stretchr-objx-devel.sha256sum] = "48ebbf0cb129120bdd3322e762aec96125bd41b1d4a96559a122e36451a99fc3"

URI_aarch64_golang-github-stretchr-objx-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-stretchr-objx-devel-0.5.0-5.el10_0.noarch.rpm;name=aarch64_golang-github-stretchr-objx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-stretchr-objx-devel}"
SRC_URI[aarch64_golang-github-stretchr-objx-devel.sha256sum] = "0d8d60776337c801b2da9d34920b8e1261c9e020149ecc12ab031e9af908a174"

RDEPENDS:golang-github-stretchr-objx-devel = " \
 go-filesystem \
 "
