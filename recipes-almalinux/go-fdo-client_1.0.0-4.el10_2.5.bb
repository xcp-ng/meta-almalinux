# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "go-fdo-client"
PV = "1.0.0"
PR = "4.el10_2.5"
PACKAGES = " \
 go-fdo-client \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/go-fdo-client-1.0.0-4.el10_2.5.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a87d41a9501d6c10961f37bab4879d5d671686c7c33d3ce5228d0798fe8b1928"

URI_x86_64_v2_go-fdo-client = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-fdo-client-1.0.0-4.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_go-fdo-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-fdo-client}"
SRC_URI[x86_64_v2_go-fdo-client.sha256sum] = "09b2315b63b01d4c2d044ffde9d6b85a35c7dc183a7e7e9a696b86a75b5694c6"

URI_aarch64_go-fdo-client = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-fdo-client-1.0.0-4.el10_2.5.aarch64.rpm;name=aarch64_go-fdo-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-fdo-client}"
SRC_URI[aarch64_go-fdo-client.sha256sum] = "ebeb8f6ec5269d0f579bba5ff27d11f5eb2edc3e32d1816e3ce34d6739921542"

RDEPENDS:go-fdo-client = " \
 glibc \
 "
