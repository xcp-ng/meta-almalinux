# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-python-multipart"
PV = "0.0.32"
PR = "1.el10_2"
PACKAGES = " \
 python3-python-multipart \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-python-multipart-0.0.32-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6e374040cc16f1927d41977de81aa87b2dd0dd139d9cbd0e028cbc583bbb6b0"

URI_x86_64_v2_python3-python-multipart = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-python-multipart-0.0.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-python-multipart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-python-multipart}"
SRC_URI[x86_64_v2_python3-python-multipart.sha256sum] = "699405238ea74778879a699bc658b5e0b8fbbadc7bd43c2a5bcf46f48667ef0c"

URI_aarch64_python3-python-multipart = "${EPEL_MIRROR}/aarch64/Packages/p/python3-python-multipart-0.0.32-1.el10_2.noarch.rpm;name=aarch64_python3-python-multipart;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-python-multipart}"
SRC_URI[aarch64_python3-python-multipart.sha256sum] = "77e18ccf0a5d9f80af39c8e4c3db1377af4d6977cd02ddd52afb30349c612a3e"

RDEPENDS:python3-python-multipart = " \
 python3 \
 "
