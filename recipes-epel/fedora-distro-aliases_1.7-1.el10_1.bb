# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fedora-distro-aliases"
PV = "1.7"
PR = "1.el10_1"
PACKAGES = " \
 python3-fedora-distro-aliases \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fedora-distro-aliases-1.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aeca1ef1bd76af8b2c21039b973dad8f5f32dfa8e943e669521366e72533eac9"

URI_x86_64_v2_python3-fedora-distro-aliases = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fedora-distro-aliases-1.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fedora-distro-aliases;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fedora-distro-aliases}"
SRC_URI[x86_64_v2_python3-fedora-distro-aliases.sha256sum] = "8bb38734a3292065045783bd4e20eb9fe5cc0fce66b530bca5b6085bad6ab81b"

URI_aarch64_python3-fedora-distro-aliases = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fedora-distro-aliases-1.7-1.el10_1.noarch.rpm;name=aarch64_python3-fedora-distro-aliases;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fedora-distro-aliases}"
SRC_URI[aarch64_python3-fedora-distro-aliases.sha256sum] = "2d1fd25bf2be036bd199948004d5da7bc46e5836df75b8fe4df8337a2941fa13"

RDEPENDS:python3-fedora-distro-aliases = " \
 python3 \
 python3-munch \
 python3-requests \
 "
