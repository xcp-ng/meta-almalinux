# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Algorithm-C3"
PV = "0.11"
PR = "10.el10_0"
PACKAGES = " \
 perl-Algorithm-C3 \
 perl-Algorithm-C3-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Algorithm-C3-0.11-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a4647d476bd368084f59a9b01b99335af80de59b40fa0180831a3b7e569a2bc"

URI_x86_64_v2_perl-Algorithm-C3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Algorithm-C3-0.11-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Algorithm-C3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Algorithm-C3}"
SRC_URI[x86_64_v2_perl-Algorithm-C3.sha256sum] = "95e3104df9037f4ac4283daa3d03fc232e5d20c49c59df5b03b6250fdcfa799d"

URI_x86_64_v2_perl-Algorithm-C3-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Algorithm-C3-tests-0.11-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Algorithm-C3-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Algorithm-C3-tests}"
SRC_URI[x86_64_v2_perl-Algorithm-C3-tests.sha256sum] = "88b4e51028987cb52ab680b470d7dce0975bb785e3cd2dbd289226134b3faae3"

URI_aarch64_perl-Algorithm-C3 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Algorithm-C3-0.11-10.el10_0.noarch.rpm;name=aarch64_perl-Algorithm-C3;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Algorithm-C3}"
SRC_URI[aarch64_perl-Algorithm-C3.sha256sum] = "5e244f2dd8cee00693489613c6ce07dbb3cc0db14797d895fbe30a3d1219bf78"

URI_aarch64_perl-Algorithm-C3-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Algorithm-C3-tests-0.11-10.el10_0.noarch.rpm;name=aarch64_perl-Algorithm-C3-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Algorithm-C3-tests}"
SRC_URI[aarch64_perl-Algorithm-C3-tests.sha256sum] = "d846c9a74fdd02591882f2697982084b0c54c0d3711eb95ff51d46a7ff05e016"

RDEPENDS:perl-Algorithm-C3 = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-Algorithm-C3-tests = " \
 bash \
 perl-Algorithm-C3 \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
