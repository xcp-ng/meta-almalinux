# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-arrayvec0.5"
PV = "0.5.2"
PR = "10.el10_0"
PACKAGES = " \
 rust-arrayvec0.5+array-sizes-129-255-devel \
 rust-arrayvec0.5+array-sizes-33-128-devel \
 rust-arrayvec0.5+default-devel \
 rust-arrayvec0.5+serde-devel \
 rust-arrayvec0.5+std-devel \
 rust-arrayvec0.5+unstable-const-fn-devel \
 rust-arrayvec0.5-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-arrayvec0.5-0.5.2-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "01bad33c16c9942cee567fba46a01974274efd61ca484e1bc6044250caf76d31"

URI_x86_64_v2_rust-arrayvec0.5+array-sizes-129-255-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrayvec0.5+array-sizes-129-255-devel-0.5.2-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrayvec0.5+array-sizes-129-255-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrayvec0.5+array-sizes-129-255-devel}"
SRC_URI[x86_64_v2_rust-arrayvec0.5+array-sizes-129-255-devel.sha256sum] = "50fcb9397941448026003b6f1ce3eb70de7b51cb72a7eecdcae7fe5cb712a040"

URI_x86_64_v2_rust-arrayvec0.5+array-sizes-33-128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrayvec0.5+array-sizes-33-128-devel-0.5.2-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrayvec0.5+array-sizes-33-128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrayvec0.5+array-sizes-33-128-devel}"
SRC_URI[x86_64_v2_rust-arrayvec0.5+array-sizes-33-128-devel.sha256sum] = "cba151ec22cee3b06c6d35406a928f1ed6859e9f73e26a1d062c8d1e08396424"

URI_x86_64_v2_rust-arrayvec0.5+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrayvec0.5+default-devel-0.5.2-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrayvec0.5+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrayvec0.5+default-devel}"
SRC_URI[x86_64_v2_rust-arrayvec0.5+default-devel.sha256sum] = "a31f5f710e0f2d285b33747533c2f328d9c8e5a14834b0318448967087a0d461"

URI_x86_64_v2_rust-arrayvec0.5+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrayvec0.5+serde-devel-0.5.2-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrayvec0.5+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrayvec0.5+serde-devel}"
SRC_URI[x86_64_v2_rust-arrayvec0.5+serde-devel.sha256sum] = "c4bb1db27c5adaf746d6edde0547670720aa6a60e50060daa4678f357d27330e"

URI_x86_64_v2_rust-arrayvec0.5+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrayvec0.5+std-devel-0.5.2-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrayvec0.5+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrayvec0.5+std-devel}"
SRC_URI[x86_64_v2_rust-arrayvec0.5+std-devel.sha256sum] = "ee06ce3545532253376d122b11e82b2128f1b94e9ca50001fc39a2357b18e8e7"

URI_x86_64_v2_rust-arrayvec0.5+unstable-const-fn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrayvec0.5+unstable-const-fn-devel-0.5.2-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrayvec0.5+unstable-const-fn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrayvec0.5+unstable-const-fn-devel}"
SRC_URI[x86_64_v2_rust-arrayvec0.5+unstable-const-fn-devel.sha256sum] = "51e620f6333d81858f9ed8b83dcbe30e7e4e3a38bf8ee9a20c72c1d0367f7f36"

URI_x86_64_v2_rust-arrayvec0.5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrayvec0.5-devel-0.5.2-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrayvec0.5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrayvec0.5-devel}"
SRC_URI[x86_64_v2_rust-arrayvec0.5-devel.sha256sum] = "e9ee253f4fa7ea81469ac626d00c02598e4cd79feec0f12a973d1f128b89ce5b"

URI_aarch64_rust-arrayvec0.5+array-sizes-129-255-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrayvec0.5+array-sizes-129-255-devel-0.5.2-10.el10_0.noarch.rpm;name=aarch64_rust-arrayvec0.5+array-sizes-129-255-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrayvec0.5+array-sizes-129-255-devel}"
SRC_URI[aarch64_rust-arrayvec0.5+array-sizes-129-255-devel.sha256sum] = "ff282c0a53bfbce50f64f36c5dc7de5d837bbad0016123cdf471e6f8432bf972"

URI_aarch64_rust-arrayvec0.5+array-sizes-33-128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrayvec0.5+array-sizes-33-128-devel-0.5.2-10.el10_0.noarch.rpm;name=aarch64_rust-arrayvec0.5+array-sizes-33-128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrayvec0.5+array-sizes-33-128-devel}"
SRC_URI[aarch64_rust-arrayvec0.5+array-sizes-33-128-devel.sha256sum] = "8d0226d69da1e8bc584ea1998769f49b1ed7a0efe243fa6fcb4a436e599f5096"

URI_aarch64_rust-arrayvec0.5+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrayvec0.5+default-devel-0.5.2-10.el10_0.noarch.rpm;name=aarch64_rust-arrayvec0.5+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrayvec0.5+default-devel}"
SRC_URI[aarch64_rust-arrayvec0.5+default-devel.sha256sum] = "832e5bd1f973f8ba928b0f52a76136e58813c5cec6ef0e6595339f4d543ef695"

URI_aarch64_rust-arrayvec0.5+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrayvec0.5+serde-devel-0.5.2-10.el10_0.noarch.rpm;name=aarch64_rust-arrayvec0.5+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrayvec0.5+serde-devel}"
SRC_URI[aarch64_rust-arrayvec0.5+serde-devel.sha256sum] = "15195eed4fab7849abbe36e98d925a345a048d021b1fad2f805a82da65dbe66a"

URI_aarch64_rust-arrayvec0.5+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrayvec0.5+std-devel-0.5.2-10.el10_0.noarch.rpm;name=aarch64_rust-arrayvec0.5+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrayvec0.5+std-devel}"
SRC_URI[aarch64_rust-arrayvec0.5+std-devel.sha256sum] = "020fb5109fedf29009e91a9abb10ac6d4af30bf0bb119fd08c8d568813558b4b"

URI_aarch64_rust-arrayvec0.5+unstable-const-fn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrayvec0.5+unstable-const-fn-devel-0.5.2-10.el10_0.noarch.rpm;name=aarch64_rust-arrayvec0.5+unstable-const-fn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrayvec0.5+unstable-const-fn-devel}"
SRC_URI[aarch64_rust-arrayvec0.5+unstable-const-fn-devel.sha256sum] = "bec0d00c3052c8794986c5adb6e7b1144dd9a5eaacffe14cca1248b643ac07ff"

URI_aarch64_rust-arrayvec0.5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrayvec0.5-devel-0.5.2-10.el10_0.noarch.rpm;name=aarch64_rust-arrayvec0.5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrayvec0.5-devel}"
SRC_URI[aarch64_rust-arrayvec0.5-devel.sha256sum] = "497daa5cf852adff577b750f1060b772c66b0c3d69df6f1743df6ead85656b63"

RDEPENDS:rust-arrayvec0.5+array-sizes-129-255-devel = " \
 cargo \
 rust-arrayvec0.5-devel \
 "
RDEPENDS:rust-arrayvec0.5+array-sizes-33-128-devel = " \
 cargo \
 rust-arrayvec0.5-devel \
 "
RDEPENDS:rust-arrayvec0.5+default-devel = " \
 cargo \
 rust-arrayvec0.5+std-devel \
 rust-arrayvec0.5-devel \
 "
RDEPENDS:rust-arrayvec0.5+serde-devel = " \
 cargo \
 rust-arrayvec0.5-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-arrayvec0.5+std-devel = " \
 cargo \
 rust-arrayvec0.5-devel \
 "
RDEPENDS:rust-arrayvec0.5+unstable-const-fn-devel = " \
 cargo \
 rust-arrayvec0.5-devel \
 "
RDEPENDS:rust-arrayvec0.5-devel = " \
 cargo \
 "
