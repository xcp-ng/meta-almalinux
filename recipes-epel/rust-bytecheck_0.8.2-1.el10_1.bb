# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bytecheck"
PV = "0.8.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-bytecheck+default-devel \
 rust-bytecheck+simdutf8-devel \
 rust-bytecheck+uuid-1-devel \
 rust-bytecheck-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bytecheck-0.8.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87b00bd0b1a43e6a4caaf210273f00636a0a2e88b85a6b44a8df3632cdd736bd"

URI_x86_64_v2_rust-bytecheck+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecheck+default-devel-0.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecheck+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecheck+default-devel}"
SRC_URI[x86_64_v2_rust-bytecheck+default-devel.sha256sum] = "b54763f2d7794bbd392c3ec9722e0d6e42d7229e174a6d5a72190153d8ee5f07"

URI_x86_64_v2_rust-bytecheck+simdutf8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecheck+simdutf8-devel-0.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecheck+simdutf8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecheck+simdutf8-devel}"
SRC_URI[x86_64_v2_rust-bytecheck+simdutf8-devel.sha256sum] = "5ade6caa096ff282aa0c50a180fe49bc61299ccdef38a82bfa66fb271e174f23"

URI_x86_64_v2_rust-bytecheck+uuid-1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecheck+uuid-1-devel-0.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecheck+uuid-1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecheck+uuid-1-devel}"
SRC_URI[x86_64_v2_rust-bytecheck+uuid-1-devel.sha256sum] = "f16d138641c9bcd958caedc8312214c82a9c83859e9c8ae664edc0c535998e01"

URI_x86_64_v2_rust-bytecheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecheck-devel-0.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecheck-devel}"
SRC_URI[x86_64_v2_rust-bytecheck-devel.sha256sum] = "1a64e7f7ac9903a5254c0a51384c2dc4b5710ceb1d848d2408af99b01d04aa16"

URI_aarch64_rust-bytecheck+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecheck+default-devel-0.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-bytecheck+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecheck+default-devel}"
SRC_URI[aarch64_rust-bytecheck+default-devel.sha256sum] = "1d9563b7d680ad1024921b4b49a39e80174cf1ecb2a3b524d49676861db8774f"

URI_aarch64_rust-bytecheck+simdutf8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecheck+simdutf8-devel-0.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-bytecheck+simdutf8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecheck+simdutf8-devel}"
SRC_URI[aarch64_rust-bytecheck+simdutf8-devel.sha256sum] = "48a8f435ff5e3b514fa6e7ec4a5b8eaa186b969b5271cb9e9f7133cb1941a7b0"

URI_aarch64_rust-bytecheck+uuid-1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecheck+uuid-1-devel-0.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-bytecheck+uuid-1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecheck+uuid-1-devel}"
SRC_URI[aarch64_rust-bytecheck+uuid-1-devel.sha256sum] = "995de72226b28b52fe0e7f4d5e55d87036dd9b5f702fe4ced891e425d37f3a67"

URI_aarch64_rust-bytecheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecheck-devel-0.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecheck-devel}"
SRC_URI[aarch64_rust-bytecheck-devel.sha256sum] = "982f53f7c81c859892c09794f98029c0aa670266506111cf6b2780b9db8d3623"

RDEPENDS:rust-bytecheck+default-devel = " \
 cargo \
 rust-bytecheck+simdutf8-devel \
 rust-bytecheck-devel \
 "
RDEPENDS:rust-bytecheck+simdutf8-devel = " \
 cargo \
 rust-bytecheck-devel \
 rust-simdutf8-devel \
 "
RDEPENDS:rust-bytecheck+uuid-1-devel = " \
 cargo \
 rust-bytecheck-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-bytecheck-devel = " \
 cargo \
 rust \
 rust-bytecheck_derive-devel \
 rust-ptr_meta-devel \
 rust-rancor-devel \
 "
