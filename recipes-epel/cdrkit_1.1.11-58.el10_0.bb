# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cdrkit"
PV = "1.1.11"
PR = "58.el10_0"
PACKAGES = " \
 dirsplit \
 genisoimage \
 icedax \
 libusal \
 libusal-devel \
 wodim \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/cdrkit-1.1.11-58.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "43a5ea49c6ee49668eb0dfcb25b9c2ee06a09196ae3b23c5f2fb92d4b6ee6f19"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dirsplit-1.1.11-58.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dirsplit;unpack=0"
SRC_URI[x86_64_v2_dirsplit.sha256sum] = "ba6843cf3b5138d4b81d3a989d1eef600c153f65c705316225ef0689e19c63c4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/genisoimage-1.1.11-58.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_genisoimage;unpack=0"
SRC_URI[x86_64_v2_genisoimage.sha256sum] = "15263cc68bda10bdf44d83aaa2e91632b3547a443dd27b3bbc4a5a270ff5b729"
RPROVIDES:genisoimage:append:x86_64_v2 = " virtual//usr/bin/mkisofs"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/icedax-1.1.11-58.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_icedax;unpack=0"
SRC_URI[x86_64_v2_icedax.sha256sum] = "64202febe5824020011cd7ce83328bb1ffddc10f97d39d09cc0ff0b3ee91bb6d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libusal-1.1.11-58.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libusal;unpack=0"
SRC_URI[x86_64_v2_libusal.sha256sum] = "fa70c884e87c9c52a44bdd820d64104f5337da8c443fe6f262cae7e44e26bc3e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libusal-devel-1.1.11-58.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libusal-devel;unpack=0"
SRC_URI[x86_64_v2_libusal-devel.sha256sum] = "5264ca7f33ef257fda0ef7a887936f380e0bc2804e56ff37f301b8ffb3736217"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wodim-1.1.11-58.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wodim;unpack=0"
SRC_URI[x86_64_v2_wodim.sha256sum] = "a7fe2162ae206feb128978395aff40bfa0e6dd0d9fc6fb59e192090bb0bcb48b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dirsplit-1.1.11-58.el10_0.aarch64.rpm;name=aarch64_dirsplit;unpack=0"
SRC_URI[aarch64_dirsplit.sha256sum] = "beaf3b53923e80d5172fd1082fdd8451514600135d6a2925aee15f434d8bd6b5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/genisoimage-1.1.11-58.el10_0.aarch64.rpm;name=aarch64_genisoimage;unpack=0"
SRC_URI[aarch64_genisoimage.sha256sum] = "3ca059ba1403b58b02342b9148fd9925e612199fa7a7c1de904f61bbabae364b"
RPROVIDES:genisoimage:append:aarch64 = " virtual//usr/bin/mkisofs"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/i/icedax-1.1.11-58.el10_0.aarch64.rpm;name=aarch64_icedax;unpack=0"
SRC_URI[aarch64_icedax.sha256sum] = "427ce39d7f3aeb11d11c518da1e23f1be49e590f51a510d556b903cbc8cdb412"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libusal-1.1.11-58.el10_0.aarch64.rpm;name=aarch64_libusal;unpack=0"
SRC_URI[aarch64_libusal.sha256sum] = "2105c928b6ba6ae8134274b8b41c16dead81f14c9b78c90a6b4b24e6946d2565"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libusal-devel-1.1.11-58.el10_0.aarch64.rpm;name=aarch64_libusal-devel;unpack=0"
SRC_URI[aarch64_libusal-devel.sha256sum] = "92dcc6dee2abc0e64d5e3fc75d2c05d659aae3aafb195cbbfddab4395815792d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/wodim-1.1.11-58.el10_0.aarch64.rpm;name=aarch64_wodim;unpack=0"
SRC_URI[aarch64_wodim.sha256sum] = "5f43cb832105e4208fb1e9bbf0a3f4ad5453a37e9461020883a09744fa32e861"

RDEPENDS:dirsplit = " \
 genisoimage \
 perl-File-Basename \
 perl-File-Path \
 perl-Getopt-Long \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:genisoimage = " \
 alternatives \
 bash \
 bzip2-libs \
 file-libs \
 glibc \
 libusal \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:icedax = " \
 alternatives \
 bash \
 cdparanoia \
 cdparanoia-libs \
 glibc \
 libusal \
 virtual/coreutils \
 vorbis-tools \
 "
RDEPENDS:libusal = " \
 glibc \
 "
RDEPENDS:libusal-devel = " \
 libusal \
 "
RDEPENDS:wodim = " \
 alternatives \
 bash \
 glibc \
 libcap \
 libusal \
 virtual/coreutils \
 "
