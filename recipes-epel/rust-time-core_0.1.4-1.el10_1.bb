# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-time-core"
PV = "0.1.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-time-core+default-devel \
 rust-time-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-time-core-0.1.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3286f5eeea55e887838a506c1e6c2ebe8a2f5add1e34a5aca55e549df8832c1a"

URI_x86_64_v2_rust-time-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time-core+default-devel-0.1.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time-core+default-devel}"
SRC_URI[x86_64_v2_rust-time-core+default-devel.sha256sum] = "809238085497d7e464f354ab6dce56cc54f846f581454b8dc5775f615ff65426"

URI_x86_64_v2_rust-time-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time-core-devel-0.1.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time-core-devel}"
SRC_URI[x86_64_v2_rust-time-core-devel.sha256sum] = "2e744aa55db18516c7df5717823059963d3e800a7f72a4cfd7c402cda9ced551"

URI_aarch64_rust-time-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time-core+default-devel-0.1.4-1.el10_1.noarch.rpm;name=aarch64_rust-time-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time-core+default-devel}"
SRC_URI[aarch64_rust-time-core+default-devel.sha256sum] = "b34a9bb41ea31e867ec6a597b1b87a0d65b03ee4d1a1df7e259da1eea23e230f"

URI_aarch64_rust-time-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time-core-devel-0.1.4-1.el10_1.noarch.rpm;name=aarch64_rust-time-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time-core-devel}"
SRC_URI[aarch64_rust-time-core-devel.sha256sum] = "abbdb85196f1824fa879fab185761b79244b4687312525be1342d769e18a1ffa"

RDEPENDS:rust-time-core+default-devel = " \
 cargo \
 rust-time-core-devel \
 "
RDEPENDS:rust-time-core-devel = " \
 cargo \
 rust \
 "
