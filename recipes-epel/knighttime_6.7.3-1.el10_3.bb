# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "knighttime"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 knighttime \
 knighttime-devel \
 knighttime-doc \
 knighttime-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/knighttime-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "455b2117043abd1338e4ba629abf0ac6edd2fa9019eebfddfe1123ab14a4834b"

URI_x86_64_v2_knighttime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knighttime-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knighttime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knighttime}"
SRC_URI[x86_64_v2_knighttime.sha256sum] = "71ccc7d2a7e1e8902c94eb3a23cb4790d8e5fff15f8bf599b2502ec3b360e2ff"

URI_x86_64_v2_knighttime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knighttime-devel-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knighttime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knighttime-devel}"
SRC_URI[x86_64_v2_knighttime-devel.sha256sum] = "97d53b8107ae41fe1366013e369863be86d6de39e6704d0eb90d7583df1200dd"

URI_x86_64_v2_knighttime-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knighttime-doc-6.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_knighttime-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knighttime-doc}"
SRC_URI[x86_64_v2_knighttime-doc.sha256sum] = "6cff082b7f5e25202885f4b0b91bab19a99e4b101e31abe3ceaf2ca979377ab4"

URI_x86_64_v2_knighttime-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knighttime-html-6.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_knighttime-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knighttime-html}"
SRC_URI[x86_64_v2_knighttime-html.sha256sum] = "233bd8e614ac0f1d803ea26fc0d7d045402371fe51b06286d483269b0bfd6254"

URI_aarch64_knighttime = "${EPEL_MIRROR}/aarch64/Packages/k/knighttime-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_knighttime;unpack=0"
SRC_URI:append = " ${URI_aarch64_knighttime}"
SRC_URI[aarch64_knighttime.sha256sum] = "4eac74fe608d04e529d03639e346cc08bb4b86fc8a6b99aef7cc289bd47e013b"

URI_aarch64_knighttime-devel = "${EPEL_MIRROR}/aarch64/Packages/k/knighttime-devel-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_knighttime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_knighttime-devel}"
SRC_URI[aarch64_knighttime-devel.sha256sum] = "cab7d35e636331c61597fd731c5fd358a8e3f11f63a9ffa19d9d3642e4416b2e"

URI_aarch64_knighttime-doc = "${EPEL_MIRROR}/aarch64/Packages/k/knighttime-doc-6.7.3-1.el10_3.noarch.rpm;name=aarch64_knighttime-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_knighttime-doc}"
SRC_URI[aarch64_knighttime-doc.sha256sum] = "68c6b95bc3a84cf5ea7a79a19373d44cf6db783714972b71cd79a074b654dfe3"

URI_aarch64_knighttime-html = "${EPEL_MIRROR}/aarch64/Packages/k/knighttime-html-6.7.3-1.el10_3.noarch.rpm;name=aarch64_knighttime-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_knighttime-html}"
SRC_URI[aarch64_knighttime-html.sha256sum] = "ff91520f908a9ef5bafe4fed362e90b0b4d9383490ef5a118cc3c005680f7fe5"

RDEPENDS:knighttime = " \
 bash \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kholidays \
 libstdc++ \
 qt6-qtbase \
 qt6-qtpositioning \
 "
RDEPENDS:knighttime-devel = " \
 cmake-filesystem \
 knighttime \
 "
RDEPENDS:knighttime-doc = " \
 "
RDEPENDS:knighttime-html = " \
 "
