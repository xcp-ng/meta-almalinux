# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnf"
PV = "4.20.0"
PR = "28.el10.alma.1"
PACKAGES = " \
 dnf \
 dnf-automatic \
 dnf-bootc \
 dnf-data \
 python3-dnf \
 yum \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/dnf-4.20.0-28.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b36ee864c9d5038970bb01b20ebf97856afae74ad2daf9a3cf8d1d6f31490051"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dnf-4.20.0-28.el10.alma.1.noarch.rpm;name=x86_64_v2_dnf;unpack=0"
SRC_URI[x86_64_v2_dnf.sha256sum] = "b9e1b1111c692854aac1e9c04e98ce83b2808a4c254bb4b19e37ec1f2197ff63"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dnf-automatic-4.20.0-28.el10.alma.1.noarch.rpm;name=x86_64_v2_dnf-automatic;unpack=0"
SRC_URI[x86_64_v2_dnf-automatic.sha256sum] = "4d3ce1496b40e13e6be46d2b1cdb29eb8f52efa76dd96f837a23eb57668579e3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dnf-bootc-4.20.0-28.el10.alma.1.noarch.rpm;name=x86_64_v2_dnf-bootc;unpack=0"
SRC_URI[x86_64_v2_dnf-bootc.sha256sum] = "c01e8a992182d329d752e11109cf89339c718f51bb3f3282485820c72c2337ba"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dnf-data-4.20.0-28.el10.alma.1.noarch.rpm;name=x86_64_v2_dnf-data;unpack=0"
SRC_URI[x86_64_v2_dnf-data.sha256sum] = "c3f105fd1a34abe2931ab61db771226a13fb6f0ecd9c8e4c12088737a7627932"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-dnf-4.20.0-28.el10.alma.1.noarch.rpm;name=x86_64_v2_python3-dnf;unpack=0"
SRC_URI[x86_64_v2_python3-dnf.sha256sum] = "2f85d3774ebc43b763b744cfeee6637b3abc87752e5b45e341380d266006b68a"
RPROVIDES:python3-dnf:append:x86_64_v2 = " virtual/python3-libdnf5_or__python3-dnf_and_python3-hawkey_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/yum-4.20.0-28.el10.alma.1.noarch.rpm;name=x86_64_v2_yum;unpack=0"
SRC_URI[x86_64_v2_yum.sha256sum] = "564b74c1ffa400c0ef390947f0c77bd547196d30de3e33c9a44612eb00f866df"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dnf-4.20.0-28.el10.alma.1.noarch.rpm;name=aarch64_dnf;unpack=0"
SRC_URI[aarch64_dnf.sha256sum] = "b9e1b1111c692854aac1e9c04e98ce83b2808a4c254bb4b19e37ec1f2197ff63"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dnf-automatic-4.20.0-28.el10.alma.1.noarch.rpm;name=aarch64_dnf-automatic;unpack=0"
SRC_URI[aarch64_dnf-automatic.sha256sum] = "4d3ce1496b40e13e6be46d2b1cdb29eb8f52efa76dd96f837a23eb57668579e3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dnf-bootc-4.20.0-28.el10.alma.1.noarch.rpm;name=aarch64_dnf-bootc;unpack=0"
SRC_URI[aarch64_dnf-bootc.sha256sum] = "c01e8a992182d329d752e11109cf89339c718f51bb3f3282485820c72c2337ba"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dnf-data-4.20.0-28.el10.alma.1.noarch.rpm;name=aarch64_dnf-data;unpack=0"
SRC_URI[aarch64_dnf-data.sha256sum] = "c3f105fd1a34abe2931ab61db771226a13fb6f0ecd9c8e4c12088737a7627932"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-dnf-4.20.0-28.el10.alma.1.noarch.rpm;name=aarch64_python3-dnf;unpack=0"
SRC_URI[aarch64_python3-dnf.sha256sum] = "2f85d3774ebc43b763b744cfeee6637b3abc87752e5b45e341380d266006b68a"
RPROVIDES:python3-dnf:append:aarch64 = " virtual/python3-libdnf5_or__python3-dnf_and_python3-hawkey_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/yum-4.20.0-28.el10.alma.1.noarch.rpm;name=aarch64_yum;unpack=0"
SRC_URI[aarch64_yum.sha256sum] = "564b74c1ffa400c0ef390947f0c77bd547196d30de3e33c9a44612eb00f866df"

RDEPENDS:dnf = " \
 bash \
 python3-dnf \
 virtual/coreutils \
 "
RDEPENDS:dnf-automatic = " \
 bash \
 python3 \
 python3-dnf \
 systemd \
 "
RDEPENDS:dnf-bootc = " \
 ostree \
 ostree-libs \
 python3-dnf \
 python3-gobject-base \
 util-linux-core \
 "
RDEPENDS:dnf-data = " \
 "
RDEPENDS:python3-dnf = " \
 dnf-data \
 libmodulemd \
 python3 \
 python3-hawkey \
 python3-libcomps \
 python3-libdnf \
 python3-rpm \
 "
RDEPENDS:yum = " \
 dnf \
 "
