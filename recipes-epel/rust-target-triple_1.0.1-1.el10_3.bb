# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-target-triple"
PV = "1.0.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-target-triple+default-devel \
 rust-target-triple-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-target-triple-1.0.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f79b9c8672805c133b560c08014166a43d00833014e89be465bdd15d671556c"

URI_x86_64_v2_rust-target-triple+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-triple+default-devel-1.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-triple+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-triple+default-devel}"
SRC_URI[x86_64_v2_rust-target-triple+default-devel.sha256sum] = "42e2d42dc9d1a1f4e390d0761a92f8645d4a6c9b928866ebced4b5a68c0f6487"

URI_x86_64_v2_rust-target-triple-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-triple-devel-1.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-triple-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-triple-devel}"
SRC_URI[x86_64_v2_rust-target-triple-devel.sha256sum] = "ff79e5b34ca7359b901eaa49a87aa69fe3dcdcd33821449309684cf541cbc196"

URI_aarch64_rust-target-triple+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-triple+default-devel-1.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-target-triple+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-triple+default-devel}"
SRC_URI[aarch64_rust-target-triple+default-devel.sha256sum] = "abb9b5d136197ea7a83e08c89ec5b12bad481d386f1ab952c537c96fee8d5551"

URI_aarch64_rust-target-triple-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-triple-devel-1.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-target-triple-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-triple-devel}"
SRC_URI[aarch64_rust-target-triple-devel.sha256sum] = "46812c7ae8dfa9003bcf3eeec183d59212afdff4105af467645b604b88a801ba"

RDEPENDS:rust-target-triple+default-devel = " \
 cargo \
 rust-target-triple-devel \
 "
RDEPENDS:rust-target-triple-devel = " \
 cargo \
 rust \
 "
