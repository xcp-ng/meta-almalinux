# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "amavisd-milter"
PV = "1.7.2"
PR = "9.el10_1"
PACKAGES = " \
 amavisd-milter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/amavisd-milter-1.7.2-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27cd505faa12206688c9ecba0e7b878e3d5401525bf8e2df95a1fdcaf0364c4a"

URI_x86_64_v2_amavisd-milter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/amavisd-milter-1.7.2-9.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_amavisd-milter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amavisd-milter}"
SRC_URI[x86_64_v2_amavisd-milter.sha256sum] = "62bb26d8f8548074ccbabb4ddf575b8ecf5ea45408b57d9f0210d28d2da68400"

URI_aarch64_amavisd-milter = "${EPEL_MIRROR}/aarch64/Packages/a/amavisd-milter-1.7.2-9.el10_1.aarch64.rpm;name=aarch64_amavisd-milter;unpack=0"
SRC_URI:append = " ${URI_aarch64_amavisd-milter}"
SRC_URI[aarch64_amavisd-milter.sha256sum] = "675f4abebc40bcb9da9473387b42c683068224ba2bc4cab245023e7baf4146c7"

RDEPENDS:amavisd-milter = " \
 amavis \
 bash \
 glibc \
 sendmail-milter \
 systemd \
 "
