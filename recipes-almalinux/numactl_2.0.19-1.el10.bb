# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "numactl"
PV = "2.0.19"
PR = "1.el10"
PACKAGES = " \
 numactl \
 numactl-devel \
 numactl-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/numactl-2.0.19-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6334c00fe8b580ae36825ddc9fcb3bb3d116d5e08d02d9713f5a45751f7da159"

URI_x86_64_v2_numactl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/numactl-2.0.19-1.el10.x86_64_v2.rpm;name=x86_64_v2_numactl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_numactl}"
SRC_URI[x86_64_v2_numactl.sha256sum] = "2617a54bdba758062f3c061320692194fbbe8f6536b8e8ee47c87ed28cb458e3"

URI_x86_64_v2_numactl-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/numactl-devel-2.0.19-1.el10.x86_64_v2.rpm;name=x86_64_v2_numactl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_numactl-devel}"
SRC_URI[x86_64_v2_numactl-devel.sha256sum] = "49e42fa1aa114de8da64c55c745467e2e923717578130a0ab18ef9933ae73d18"

URI_x86_64_v2_numactl-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/numactl-libs-2.0.19-1.el10.x86_64_v2.rpm;name=x86_64_v2_numactl-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_numactl-libs}"
SRC_URI[x86_64_v2_numactl-libs.sha256sum] = "5154fde3174f422ead162482d0de3e05ceca4628fe3ecdd345f95c2c64a7f2d5"

URI_aarch64_numactl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/numactl-2.0.19-1.el10.aarch64.rpm;name=aarch64_numactl;unpack=0"
SRC_URI:append = " ${URI_aarch64_numactl}"
SRC_URI[aarch64_numactl.sha256sum] = "ff268401282e09885309cf3d1d804c221812ac5bb853852c06c008835b964398"

URI_aarch64_numactl-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/numactl-devel-2.0.19-1.el10.aarch64.rpm;name=aarch64_numactl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_numactl-devel}"
SRC_URI[aarch64_numactl-devel.sha256sum] = "16ffa42cc0e9d4feb61e97076ec339db00d078de93878af6e62e2442ab0f1621"

URI_aarch64_numactl-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/numactl-libs-2.0.19-1.el10.aarch64.rpm;name=aarch64_numactl-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_numactl-libs}"
SRC_URI[aarch64_numactl-libs.sha256sum] = "90298b3c70382af8e0e0b9e1aeaae7d4e3d1d3e7295d46bf81e16eef57b85c0e"

RDEPENDS:numactl = " \
 glibc \
 numactl-libs \
 "
RDEPENDS:numactl-devel = " \
 numactl-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:numactl-libs:x86_64_v2 = " \
 glibc \
"
RDEPENDS:numactl-libs:aarch64 = " \
 glibc \
 libatomic \
"
