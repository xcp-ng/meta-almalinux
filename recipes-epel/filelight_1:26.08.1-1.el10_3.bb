# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "filelight"
PE = "1"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 filelight \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/f/filelight-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e5bf080140caf04227437d6eb3a2fb19442deb772e624fe8f6f9c1a23ff2e5aa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/filelight-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_filelight;unpack=0"
SRC_URI[x86_64_v2_filelight.sha256sum] = "914ad2366cfd54dbdf1d8d5c3b29a8c89cd4ef639e11bdd9bed739bc9bed4c99"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/filelight-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_filelight;unpack=0"
SRC_URI[aarch64_filelight.sha256sum] = "8729339f7a5f7207d829dad38af321a37f7bbdae808be2a9111489ac79a112ab"

RDEPENDS:filelight = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kquickcharts \
 kf6-kwidgetsaddons \
 kf6-qqc2-desktop-style \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
