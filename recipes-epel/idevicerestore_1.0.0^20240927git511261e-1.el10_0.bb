# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "idevicerestore"
PV = "1.0.0^20240927git511261e"
PR = "1.el10_0"
PACKAGES = " \
 idevicerestore \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/idevicerestore-1.0.0^20240927git511261e-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b540f281ac937d0c1237789de46947cde3e91c7d2ee444ea733e184c66e5be83"

URI_x86_64_v2_idevicerestore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/idevicerestore-1.0.0^20240927git511261e-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_idevicerestore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idevicerestore}"
SRC_URI[x86_64_v2_idevicerestore.sha256sum] = "9f17df5a38678a0b76323558aba4dc0a79abb6a1fa380c735da86ff476183854"

URI_aarch64_idevicerestore = "${EPEL_MIRROR}/aarch64/Packages/i/idevicerestore-1.0.0^20240927git511261e-1.el10_0.aarch64.rpm;name=aarch64_idevicerestore;unpack=0"
SRC_URI:append = " ${URI_aarch64_idevicerestore}"
SRC_URI[aarch64_idevicerestore.sha256sum] = "c70d21fc3edb60ab1fd6dbf213a3b2b30b2348e6cda2417ebcad45f23bb6010d"

RDEPENDS:idevicerestore = " \
 glibc \
 libimobiledevice \
 libimobiledevice-glue \
 libirecovery \
 libplist \
 libtatsu \
 libusbmuxd \
 libzip \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
