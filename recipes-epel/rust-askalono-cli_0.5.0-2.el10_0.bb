# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-askalono-cli"
PV = "0.5.0"
PR = "2.el10_0"
PACKAGES = " \
 askalono-cli \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-askalono-cli-0.5.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "73b8c61ab7234c4b292fc950e6088c7c3e38d166d9937ebc0b414cfce504c002"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/askalono-cli-0.5.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_askalono-cli;unpack=0"
SRC_URI[x86_64_v2_askalono-cli.sha256sum] = "a36f841aa18076bd07f08fb53d9b83749d33c79e781f5659eb4ebded6584c513"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/askalono-cli-0.5.0-2.el10_0.aarch64.rpm;name=aarch64_askalono-cli;unpack=0"
SRC_URI[aarch64_askalono-cli.sha256sum] = "7c40c4c6cd29ec00493086c22b3a5246e8ee208996b852d5d96531d98613c475"

RDEPENDS:askalono-cli = " \
 glibc \
 libgcc \
 libzstd \
 "
