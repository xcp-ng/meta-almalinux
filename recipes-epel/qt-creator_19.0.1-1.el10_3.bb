# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt-creator"
PV = "19.0.1"
PR = "1.el10_3"
PACKAGES = " \
 qt-creator \
 qt-creator-data \
 qt-creator-doc \
 qt-creator-translations \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt-creator-19.0.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f4af4b7fdd0562e7759613f7ddb37c134be42553afdd183d34c26bd7729d9c2"

URI_x86_64_v2_qt-creator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt-creator-19.0.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt-creator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt-creator}"
SRC_URI[x86_64_v2_qt-creator.sha256sum] = "6b5d1143a642d229acca6ddbf2c206a2537ae9cb9428d8b85b5e425ad6a445d9"

URI_x86_64_v2_qt-creator-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt-creator-data-19.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_qt-creator-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt-creator-data}"
SRC_URI[x86_64_v2_qt-creator-data.sha256sum] = "fe46475efe500a2852e1404533cb7244cacc65f7e7f654e65b17bb95669b1368"

URI_x86_64_v2_qt-creator-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt-creator-doc-19.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_qt-creator-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt-creator-doc}"
SRC_URI[x86_64_v2_qt-creator-doc.sha256sum] = "df7dc9cce00218c5142e4f477f5b183c0922aa63c2b6c65f3c6f8d650a87d508"

URI_x86_64_v2_qt-creator-translations = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt-creator-translations-19.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_qt-creator-translations;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt-creator-translations}"
SRC_URI[x86_64_v2_qt-creator-translations.sha256sum] = "9616019c9f132503eaf2845050b8769c7c94b378e054049d830f432d080d8c2d"

URI_aarch64_qt-creator = "${EPEL_MIRROR}/aarch64/Packages/q/qt-creator-19.0.1-1.el10_3.aarch64.rpm;name=aarch64_qt-creator;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt-creator}"
SRC_URI[aarch64_qt-creator.sha256sum] = "606e2966c6d300829019f5d6bc4ba4ee258a6dffe8601ae8cdf88b221e021674"

URI_aarch64_qt-creator-data = "${EPEL_MIRROR}/aarch64/Packages/q/qt-creator-data-19.0.1-1.el10_3.noarch.rpm;name=aarch64_qt-creator-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt-creator-data}"
SRC_URI[aarch64_qt-creator-data.sha256sum] = "b9d05cc78a5c62df74b7c62ead6eaa638457a341f945d28a20b21686ac4ed596"

URI_aarch64_qt-creator-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt-creator-doc-19.0.1-1.el10_3.noarch.rpm;name=aarch64_qt-creator-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt-creator-doc}"
SRC_URI[aarch64_qt-creator-doc.sha256sum] = "596a57e26c28a90ae276f461baf0c50926f277ec05ac3c1f633a87fc5a70c60c"

URI_aarch64_qt-creator-translations = "${EPEL_MIRROR}/aarch64/Packages/q/qt-creator-translations-19.0.1-1.el10_3.noarch.rpm;name=aarch64_qt-creator-translations;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt-creator-translations}"
SRC_URI[aarch64_qt-creator-translations.sha256sum] = "419ded9022a18444e6ed1461382e3a867412dc54a85b3fac583aeb99fa88e5d5"

RDEPENDS:qt-creator = " \
 bash \
 clang-libs \
 elfutils-libelf \
 elfutils-libs \
 glib2 \
 glibc \
 hicolor-icon-theme \
 libgcc \
 libstdc++ \
 libzstd \
 litehtml \
 llvm-libs \
 qt-creator-data \
 qt-creator-doc \
 qt-creator-translations \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtcharts \
 qt6-qtdeclarative \
 qt6-qtquick3d \
 qt6-qtserialport \
 qt6-qtsvg \
 qt6-qttools-libs-designer \
 qt6-qttools-libs-designercomponents \
 qt6-qttools-libs-help \
 qt6-qtwebengine \
 systemd-libs \
 xdg-utils \
 yaml-cpp \
 "
RDEPENDS:qt-creator-data = " \
 qt-creator \
 "
RDEPENDS:qt-creator-doc = " \
 qt-creator \
 "
RDEPENDS:qt-creator-translations = " \
 qt-creator-data \
 qt6-qttranslations \
 "
