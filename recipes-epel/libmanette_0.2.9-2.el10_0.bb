# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmanette"
PV = "0.2.9"
PR = "2.el10_0"
PACKAGES = " \
 libmanette \
 libmanette-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libmanette-0.2.9-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47042288b25e3eaf7f4cba5964b8b6e29c8d761f804165ca6f3d7b9f971d1a7d"

URI_x86_64_v2_libmanette = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmanette-0.2.9-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmanette;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmanette}"
SRC_URI[x86_64_v2_libmanette.sha256sum] = "05b4164ddd72dd8f584a408fa37377eb393257470b236f211310d2f7d883ce03"

URI_x86_64_v2_libmanette-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmanette-devel-0.2.9-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmanette-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmanette-devel}"
SRC_URI[x86_64_v2_libmanette-devel.sha256sum] = "a1b9b0307d27628783f9ea4ecfcd50193d6bebd488b55386c9a3380e7258fca4"

URI_aarch64_libmanette = "${EPEL_MIRROR}/aarch64/Packages/l/libmanette-0.2.9-2.el10_0.aarch64.rpm;name=aarch64_libmanette;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmanette}"
SRC_URI[aarch64_libmanette.sha256sum] = "6e523e805326a9390e1e30d43b8b8bff0b7d1890b6be43e2e7371c7c63659d4d"

URI_aarch64_libmanette-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libmanette-devel-0.2.9-2.el10_0.aarch64.rpm;name=aarch64_libmanette-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmanette-devel}"
SRC_URI[aarch64_libmanette-devel.sha256sum] = "2cb1664162bc3084da16a50076115b7fe5bd1c8edd0783c9abefbc153477d0db"

RDEPENDS:libmanette = " \
 glib2 \
 glibc \
 libevdev \
 libgcc \
 libgudev \
 "
RDEPENDS:libmanette-devel = " \
 glib2 \
 glib2-devel \
 glibc \
 libevdev-devel \
 libgcc \
 libgudev-devel \
 libmanette \
 pkgconf-pkg-config \
 "
