# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "e00compr"
PV = "1.0.1"
PR = "48.el10_0"
PACKAGES = " \
 e00compr \
 e00compr-devel \
 e00compr-libs \
 e00compr-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/e00compr-1.0.1-48.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1415f19878e77196d96332b097934ca0511d74131fdd731a425782576b786e12"

URI_x86_64_v2_e00compr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/e00compr-1.0.1-48.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_e00compr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_e00compr}"
SRC_URI[x86_64_v2_e00compr.sha256sum] = "fbf0a47824dbbb184099ae61960f4fd563b4cbd0d422be7341d95946ccc0f79c"

URI_x86_64_v2_e00compr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/e00compr-devel-1.0.1-48.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_e00compr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_e00compr-devel}"
SRC_URI[x86_64_v2_e00compr-devel.sha256sum] = "433bc6ab7baef0d091d9f449b01ca9f2b8b841436978d9aad9b988985c1b28cf"

URI_x86_64_v2_e00compr-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/e00compr-libs-1.0.1-48.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_e00compr-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_e00compr-libs}"
SRC_URI[x86_64_v2_e00compr-libs.sha256sum] = "9b44f960cf3ad83de6b68825c900e08717818e5689f31edfea862bc55f4f67d4"

URI_x86_64_v2_e00compr-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/e00compr-tools-1.0.1-48.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_e00compr-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_e00compr-tools}"
SRC_URI[x86_64_v2_e00compr-tools.sha256sum] = "775223dbc77fe1f19f7eea27697d889e7166ff8c0f4918d8f22f875719452e68"

URI_aarch64_e00compr = "${EPEL_MIRROR}/aarch64/Packages/e/e00compr-1.0.1-48.el10_0.aarch64.rpm;name=aarch64_e00compr;unpack=0"
SRC_URI:append = " ${URI_aarch64_e00compr}"
SRC_URI[aarch64_e00compr.sha256sum] = "c85e957b224a291553156fd69588296daef59526ae8f3633c3a49e31f837adf5"

URI_aarch64_e00compr-devel = "${EPEL_MIRROR}/aarch64/Packages/e/e00compr-devel-1.0.1-48.el10_0.aarch64.rpm;name=aarch64_e00compr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_e00compr-devel}"
SRC_URI[aarch64_e00compr-devel.sha256sum] = "8cfa7fd46c5ccd6cb6a4ec369353fb269f7866fed4dbd97ce03893f853a019c9"

URI_aarch64_e00compr-libs = "${EPEL_MIRROR}/aarch64/Packages/e/e00compr-libs-1.0.1-48.el10_0.aarch64.rpm;name=aarch64_e00compr-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_e00compr-libs}"
SRC_URI[aarch64_e00compr-libs.sha256sum] = "83da38129c09ff26c4fe38b3cd90a2848bd842d4bfb7a47b0ab287f9a374a04f"

URI_aarch64_e00compr-tools = "${EPEL_MIRROR}/aarch64/Packages/e/e00compr-tools-1.0.1-48.el10_0.aarch64.rpm;name=aarch64_e00compr-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_e00compr-tools}"
SRC_URI[aarch64_e00compr-tools.sha256sum] = "b159ead0494d4c87a12f9906a2055fc05fe3ab1efb834b5f740afe8f1d7e4687"

RDEPENDS:e00compr = " \
 e00compr-libs \
 e00compr-tools \
 "
RDEPENDS:e00compr-devel = " \
 e00compr-libs \
 "
RDEPENDS:e00compr-libs = " \
 glibc \
 "
RDEPENDS:e00compr-tools = " \
 e00compr-libs \
 glibc \
 "
