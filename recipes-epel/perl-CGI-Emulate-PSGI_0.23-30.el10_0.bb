# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-CGI-Emulate-PSGI"
PV = "0.23"
PR = "30.el10_0"
PACKAGES = " \
 perl-CGI-Emulate-PSGI \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-CGI-Emulate-PSGI-0.23-30.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "51f6431ccc77e73ca85d40fc6eb5b7a08601d619c242cf25e6d8746e7869debb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-CGI-Emulate-PSGI-0.23-30.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-CGI-Emulate-PSGI;unpack=0"
SRC_URI[x86_64_v2_perl-CGI-Emulate-PSGI.sha256sum] = "0f9a7bfa4642da34760b751f4a2aaa1c69eaab192d557994cac161e5e0eb716d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-CGI-Emulate-PSGI-0.23-30.el10_0.noarch.rpm;name=aarch64_perl-CGI-Emulate-PSGI;unpack=0"
SRC_URI[aarch64_perl-CGI-Emulate-PSGI.sha256sum] = "678746e82d83b427c919128a8a8a319a7f2391cb81a7ffde803aeda5e0297f7e"

RDEPENDS:perl-CGI-Emulate-PSGI = " \
 perl-Carp \
 perl-Exporter \
 perl-HTTP-Message \
 perl-IO \
 perl-POSIX \
 perl-SelectSaver \
 perl-base \
 perl-libs \
 "
