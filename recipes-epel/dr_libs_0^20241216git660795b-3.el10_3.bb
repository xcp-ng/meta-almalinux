# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dr_libs"
PV = "0^20241216git660795b"
PR = "3.el10_3"
PACKAGES = " \
 dr_flac-devel \
 dr_libs-devel \
 dr_libs-doc \
 dr_mp3-devel \
 dr_wav-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dr_libs-0^20241216git660795b-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "947247224ec3a2e87c9f6ba258b16d91bb1929d55c23aa2a2b45ce55604d94d5"

URI_x86_64_v2_dr_flac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dr_flac-devel-0.12.43^20241216git660795b-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_dr_flac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dr_flac-devel}"
SRC_URI[x86_64_v2_dr_flac-devel.sha256sum] = "774843ac4371d6bfe0b6e32d7be6ece6dd168f05f667769a60c16e625e4c8f9b"

URI_x86_64_v2_dr_libs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dr_libs-devel-0^20241216git660795b-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_dr_libs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dr_libs-devel}"
SRC_URI[x86_64_v2_dr_libs-devel.sha256sum] = "3ddc9756ae7c21021bc5477ef2f855db748a839b2f65fdb92e106eea143fabb1"

URI_x86_64_v2_dr_libs-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dr_libs-doc-0^20241216git660795b-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_dr_libs-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dr_libs-doc}"
SRC_URI[x86_64_v2_dr_libs-doc.sha256sum] = "83daba58016640fb32a8b2b09113baba6eb6e2c4ffe96b6bce23bf2db347ae19"

URI_x86_64_v2_dr_mp3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dr_mp3-devel-0.6.40^20241216git660795b-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_dr_mp3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dr_mp3-devel}"
SRC_URI[x86_64_v2_dr_mp3-devel.sha256sum] = "f4201341e6626105e04183e20f947da221efef0edd1bfebfef5830e0c6b10cb7"

URI_x86_64_v2_dr_wav-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dr_wav-devel-0.13.17^20241216git660795b-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_dr_wav-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dr_wav-devel}"
SRC_URI[x86_64_v2_dr_wav-devel.sha256sum] = "5fe3f781d3e9fa0a662c9dedfefb6e6cb399898f5bc725a1107c4c414a273c68"

URI_aarch64_dr_flac-devel = "${EPEL_MIRROR}/aarch64/Packages/d/dr_flac-devel-0.12.43^20241216git660795b-3.el10_3.noarch.rpm;name=aarch64_dr_flac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dr_flac-devel}"
SRC_URI[aarch64_dr_flac-devel.sha256sum] = "a4db939a6851d569a1d41e305aa9a2ca0f6f5f75547a4d7bed67fe4f960e200a"

URI_aarch64_dr_libs-devel = "${EPEL_MIRROR}/aarch64/Packages/d/dr_libs-devel-0^20241216git660795b-3.el10_3.noarch.rpm;name=aarch64_dr_libs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dr_libs-devel}"
SRC_URI[aarch64_dr_libs-devel.sha256sum] = "d78059f7485fd8a139c48f2753f00654c5734e3e6b4795ef524aa3eba19303d6"

URI_aarch64_dr_libs-doc = "${EPEL_MIRROR}/aarch64/Packages/d/dr_libs-doc-0^20241216git660795b-3.el10_3.noarch.rpm;name=aarch64_dr_libs-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_dr_libs-doc}"
SRC_URI[aarch64_dr_libs-doc.sha256sum] = "c7afce2b7d261938a6289b57242f24cdafd04efa808e8ae3f8529e0bb7c5e355"

URI_aarch64_dr_mp3-devel = "${EPEL_MIRROR}/aarch64/Packages/d/dr_mp3-devel-0.6.40^20241216git660795b-3.el10_3.noarch.rpm;name=aarch64_dr_mp3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dr_mp3-devel}"
SRC_URI[aarch64_dr_mp3-devel.sha256sum] = "e8c9a28ae4f573975e646143bd248890ad87f7425657be1e4883cc9839223d55"

URI_aarch64_dr_wav-devel = "${EPEL_MIRROR}/aarch64/Packages/d/dr_wav-devel-0.13.17^20241216git660795b-3.el10_3.noarch.rpm;name=aarch64_dr_wav-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dr_wav-devel}"
SRC_URI[aarch64_dr_wav-devel.sha256sum] = "d3f102d9af3e2cd3b27799866ea33a6f32d00e15f70ebaab00d3dc8815de30c9"

RDEPENDS:dr_flac-devel = " \
 "
RDEPENDS:dr_libs-devel = " \
 dr_flac-devel \
 dr_mp3-devel \
 dr_wav-devel \
 "
RDEPENDS:dr_libs-doc = " \
 "
RDEPENDS:dr_mp3-devel = " \
 "
RDEPENDS:dr_wav-devel = " \
 "
