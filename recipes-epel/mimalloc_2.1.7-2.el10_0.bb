# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mimalloc"
PV = "2.1.7"
PR = "2.el10_0"
PACKAGES = " \
 mimalloc \
 mimalloc-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/m/mimalloc-2.1.7-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2aae170b2302685df53dc5a351acf7b34d0d76771dcdb09183337cf61afc17dd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mimalloc-2.1.7-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mimalloc;unpack=0"
SRC_URI[x86_64_v2_mimalloc.sha256sum] = "c7533f485ce0294e79c1935fb1204d81857eb4e09475f4468669c9df8be5575c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mimalloc-devel-2.1.7-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mimalloc-devel;unpack=0"
SRC_URI[x86_64_v2_mimalloc-devel.sha256sum] = "a1d3722b4e8a5b9dce22389494d42ae34c7e3a92648d8f347f6bfbd1334b66ef"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/mimalloc-2.1.7-2.el10_0.aarch64.rpm;name=aarch64_mimalloc;unpack=0"
SRC_URI[aarch64_mimalloc.sha256sum] = "179dc881c29dce5dbdfee8acdd519c82e68a0ddf5bae7552f1bf7124366f59f4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/mimalloc-devel-2.1.7-2.el10_0.aarch64.rpm;name=aarch64_mimalloc-devel;unpack=0"
SRC_URI[aarch64_mimalloc-devel.sha256sum] = "e40d3d34f502e6f172c49fd978bc846e3ae0014c32ed2b9c4bdd67d4f088e144"

RDEPENDS:mimalloc = " \
 glibc \
 "
RDEPENDS:mimalloc-devel = " \
 cmake-filesystem \
 mimalloc \
 pkgconf-pkg-config \
 "
