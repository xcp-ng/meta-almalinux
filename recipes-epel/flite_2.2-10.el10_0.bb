# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "flite"
PV = "2.2"
PR = "10.el10_0"
PACKAGES = " \
 flite \
 flite-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/flite-2.2-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e43f025c0c830a7cfab3cc9f77c1cc6dcaab5ec4653c9c1d239ee3dcfb6aab0"

URI_x86_64_v2_flite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flite-2.2-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_flite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flite}"
SRC_URI[x86_64_v2_flite.sha256sum] = "841cb2fead819fb2400c6ec2ab714ddc1a3ea32c904ef2b0ba66b97abc021a26"

URI_x86_64_v2_flite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flite-devel-2.2-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_flite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flite-devel}"
SRC_URI[x86_64_v2_flite-devel.sha256sum] = "49c6d59a8d9a842e86792bec179f09ec5642611866481a8a1698019c996d6d1e"

URI_aarch64_flite = "${EPEL_MIRROR}/aarch64/Packages/f/flite-2.2-10.el10_0.aarch64.rpm;name=aarch64_flite;unpack=0"
SRC_URI:append = " ${URI_aarch64_flite}"
SRC_URI[aarch64_flite.sha256sum] = "f19fa52ced8d5ee409c57bca05088db8a99483a2b3ee07188ef7e1d30e5880dd"

URI_aarch64_flite-devel = "${EPEL_MIRROR}/aarch64/Packages/f/flite-devel-2.2-10.el10_0.aarch64.rpm;name=aarch64_flite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_flite-devel}"
SRC_URI[aarch64_flite-devel.sha256sum] = "2c8713d41a2daf83095734444ad1e52c3a0c366e4631c2cdc3748b777e38a518"

RDEPENDS:flite = " \
 glibc \
 pulseaudio-libs \
 "
RDEPENDS:flite-devel = " \
 flite \
 "
