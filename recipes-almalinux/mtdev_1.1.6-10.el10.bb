# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mtdev"
PV = "1.1.6"
PR = "10.el10"
PACKAGES = " \
 mtdev \
 mtdev-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mtdev-1.1.6-10.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "57ff57457ac4cfcf14d876f74a065cf6b499beaf193b6e6ca6591c36fe767c13"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mtdev-1.1.6-10.el10.x86_64_v2.rpm;name=x86_64_v2_mtdev;unpack=0"
SRC_URI[x86_64_v2_mtdev.sha256sum] = "9ad37eafbe57b8e2b0e225c3bc6b0fd8d62d854e4e6d04e03aea45684ac4708a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mtdev-devel-1.1.6-10.el10.x86_64_v2.rpm;name=x86_64_v2_mtdev-devel;unpack=0"
SRC_URI[x86_64_v2_mtdev-devel.sha256sum] = "d91db64747d304649451dca0ac655cf957ce1cc5ae0d92051298f5f192ee37c7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mtdev-1.1.6-10.el10.aarch64.rpm;name=aarch64_mtdev;unpack=0"
SRC_URI[aarch64_mtdev.sha256sum] = "1a5e7709abb63c31208843d22bb1aeb8e9e74690f1dcf6a60eaa6f6eee387f3e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mtdev-devel-1.1.6-10.el10.aarch64.rpm;name=aarch64_mtdev-devel;unpack=0"
SRC_URI[aarch64_mtdev-devel.sha256sum] = "f7a79cd238fdaaaed470f816d54f0d69d62dd082752e72f39a44926e1c9bd41c"

RDEPENDS:mtdev = " \
 glibc \
 "
RDEPENDS:mtdev-devel = " \
 glibc \
 mtdev \
 pkgconf-pkg-config \
 "
