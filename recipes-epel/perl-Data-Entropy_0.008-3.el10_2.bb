# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Data-Entropy"
PV = "0.008"
PR = "3.el10_2"
PACKAGES = " \
 perl-Data-Entropy \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Data-Entropy-0.008-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3a451eff62d0b55c61e03a10fa05389d111b4bd120bba957e2c69d049b14aa53"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Data-Entropy-0.008-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Data-Entropy;unpack=0"
SRC_URI[x86_64_v2_perl-Data-Entropy.sha256sum] = "045654abc66da7cd0d96cc8f983d679f40b547881a58d192493b86efe3100fc2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Data-Entropy-0.008-3.el10_2.noarch.rpm;name=aarch64_perl-Data-Entropy;unpack=0"
SRC_URI[aarch64_perl-Data-Entropy.sha256sum] = "254988d725a12b4b88034c11d508080ae5f1d680dbbc5f2aad31182f533c6d53"

RDEPENDS:perl-Data-Entropy = " \
 perl-Carp \
 perl-Crypt-Rijndael \
 perl-Crypt-URandom \
 perl-Data-Entropy \
 perl-Data-Float \
 perl-Errno \
 perl-Exporter \
 perl-HTTP-Lite \
 perl-IO \
 perl-Params-Classify \
 perl-constant \
 perl-libs \
 perl-parent \
 "
