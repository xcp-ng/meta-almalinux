# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-PBKDF2"
PV = "0.261630"
PR = "1.el10_3"
PACKAGES = " \
 perl-Crypt-PBKDF2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-PBKDF2-0.261630-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd01ce27952e308c56357c810f859e1f4d0dca4ff64a671ef22447494c60d613"

URI_x86_64_v2_perl-Crypt-PBKDF2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-PBKDF2-0.261630-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Crypt-PBKDF2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-PBKDF2}"
SRC_URI[x86_64_v2_perl-Crypt-PBKDF2.sha256sum] = "06be5b9de54eb57133ab13866cc4550d90f568903a1480165551e91dabe1eb27"

URI_aarch64_perl-Crypt-PBKDF2 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-PBKDF2-0.261630-1.el10_3.noarch.rpm;name=aarch64_perl-Crypt-PBKDF2;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-PBKDF2}"
SRC_URI[aarch64_perl-Crypt-PBKDF2.sha256sum] = "dc0e1a9f7afdec99fcba8d572a0c7d989eb4169768eb4a2536249ee7dd9d522c"

RDEPENDS:perl-Crypt-PBKDF2 = " \
 perl-Carp \
 perl-Crypt-URandom \
 perl-Digest \
 perl-Digest-HMAC \
 perl-Digest-SHA \
 perl-Digest-SHA3 \
 perl-MIME-Base64 \
 perl-Module-Runtime \
 perl-Moo \
 perl-Scalar-List-Utils \
 perl-Try-Tiny \
 perl-Type-Tiny \
 perl-libs \
 perl-namespace-autoclean \
 perl-strictures \
 "
