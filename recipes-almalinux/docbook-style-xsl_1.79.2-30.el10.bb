# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "docbook-style-xsl"
PV = "1.79.2"
PR = "30.el10"
PACKAGES = " \
 docbook-style-xsl \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/docbook-style-xsl-1.79.2-30.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f43db0229e2091a85470db5aa2bc55502b5c3a87187e5e6da6e554ae29aa5341"

URI_x86_64_v2_docbook-style-xsl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/docbook-style-xsl-1.79.2-30.el10.noarch.rpm;name=x86_64_v2_docbook-style-xsl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_docbook-style-xsl}"
SRC_URI[x86_64_v2_docbook-style-xsl.sha256sum] = "afc1b071a4e11a552c9c56084bdf64fd92b207ad9a3bc52b58141b0eccdaa0e2"

URI_aarch64_docbook-style-xsl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/docbook-style-xsl-1.79.2-30.el10.noarch.rpm;name=aarch64_docbook-style-xsl;unpack=0"
SRC_URI:append = " ${URI_aarch64_docbook-style-xsl}"
SRC_URI[aarch64_docbook-style-xsl.sha256sum] = "afc1b071a4e11a552c9c56084bdf64fd92b207ad9a3bc52b58141b0eccdaa0e2"

RDEPENDS:docbook-style-xsl = " \
 bash \
 docbook-dtds \
 libxml2 \
 xml-common \
 "
