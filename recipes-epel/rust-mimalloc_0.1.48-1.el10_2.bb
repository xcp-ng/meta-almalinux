# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mimalloc"
PV = "0.1.48"
PR = "1.el10_2"
PACKAGES = " \
 rust-mimalloc+debug-devel \
 rust-mimalloc+debug_in_debug-devel \
 rust-mimalloc+default-devel \
 rust-mimalloc+extended-devel \
 rust-mimalloc+local_dynamic_tls-devel \
 rust-mimalloc+no_thp-devel \
 rust-mimalloc+override-devel \
 rust-mimalloc+secure-devel \
 rust-mimalloc+v3-devel \
 rust-mimalloc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mimalloc-0.1.48-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a45b867f759eff21752ce748ec5ddc664dc0c2906c3f14f08af39dff068fd53a"

URI_x86_64_v2_rust-mimalloc+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+debug-devel-0.1.48-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+debug-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+debug-devel.sha256sum] = "f9295e0bd3b6b2c225a5536d9f9cee1bafe343858f105229897cfa4223456c6b"

URI_x86_64_v2_rust-mimalloc+debug_in_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+debug_in_debug-devel-0.1.48-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+debug_in_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+debug_in_debug-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+debug_in_debug-devel.sha256sum] = "0e28807b27b1445850f7315d83585c8ae55f32b0e563f1cd0d660e453885fec7"

URI_x86_64_v2_rust-mimalloc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+default-devel-0.1.48-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+default-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+default-devel.sha256sum] = "00fe36b72c540544ada71f444a44ae59283d769888020a5542f9b5823387d08b"

URI_x86_64_v2_rust-mimalloc+extended-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+extended-devel-0.1.48-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+extended-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+extended-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+extended-devel.sha256sum] = "29f2dc37d3ffd8b6de50eb59ed4ef58de96a841e31257d91ea0bf395d9b47e30"

URI_x86_64_v2_rust-mimalloc+local_dynamic_tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+local_dynamic_tls-devel-0.1.48-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+local_dynamic_tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+local_dynamic_tls-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+local_dynamic_tls-devel.sha256sum] = "05195e46ec38b96e295edf9a7f253d9fd328828cfa44d21daaab289f8bd48e83"

URI_x86_64_v2_rust-mimalloc+no_thp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+no_thp-devel-0.1.48-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+no_thp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+no_thp-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+no_thp-devel.sha256sum] = "8be4c3e8d62632134f4ff7a58a1ff9a8dd561f13260414bd62bdc46d4cc0e93e"

URI_x86_64_v2_rust-mimalloc+override-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+override-devel-0.1.48-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+override-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+override-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+override-devel.sha256sum] = "3591cdc7adfd08cb971e6d0dd883ceb9371a38486145b0083af78a6186afbb3e"

URI_x86_64_v2_rust-mimalloc+secure-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+secure-devel-0.1.48-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+secure-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+secure-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+secure-devel.sha256sum] = "0fb7ba592c4b448f3f2a789c8bb08c3e6585d691f1903816c63a3f04a6b7f809"

URI_x86_64_v2_rust-mimalloc+v3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+v3-devel-0.1.48-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+v3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+v3-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+v3-devel.sha256sum] = "d1d26b0c317dcbf20ecbfd92afbab1abd83b14ed343e56339c987d68d1f373e1"

URI_x86_64_v2_rust-mimalloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc-devel-0.1.48-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc-devel}"
SRC_URI[x86_64_v2_rust-mimalloc-devel.sha256sum] = "ae56be8bdeec0b7f524b6a6eb5fe394524fec88d44b4857c2432c842e9c7ed47"

URI_aarch64_rust-mimalloc+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+debug-devel-0.1.48-1.el10_2.noarch.rpm;name=aarch64_rust-mimalloc+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+debug-devel}"
SRC_URI[aarch64_rust-mimalloc+debug-devel.sha256sum] = "c4a81e66dc908b41cdb6ab04afb811398907d560c9257b983cf929963a5cb4f0"

URI_aarch64_rust-mimalloc+debug_in_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+debug_in_debug-devel-0.1.48-1.el10_2.noarch.rpm;name=aarch64_rust-mimalloc+debug_in_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+debug_in_debug-devel}"
SRC_URI[aarch64_rust-mimalloc+debug_in_debug-devel.sha256sum] = "683adf860fd394a12baeebb55668ca222b7f49a450ca9bd6c999fe9ba4e181e2"

URI_aarch64_rust-mimalloc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+default-devel-0.1.48-1.el10_2.noarch.rpm;name=aarch64_rust-mimalloc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+default-devel}"
SRC_URI[aarch64_rust-mimalloc+default-devel.sha256sum] = "7ad459b6b549c2fc3debf831d5ee49069b9af30bf39a1a3d340b16d9884fd50e"

URI_aarch64_rust-mimalloc+extended-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+extended-devel-0.1.48-1.el10_2.noarch.rpm;name=aarch64_rust-mimalloc+extended-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+extended-devel}"
SRC_URI[aarch64_rust-mimalloc+extended-devel.sha256sum] = "eca0b0032bffcfac0acc76b0dde7757d1c2bbb78a80e7fe6cb0a4cf1ad9f9c17"

URI_aarch64_rust-mimalloc+local_dynamic_tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+local_dynamic_tls-devel-0.1.48-1.el10_2.noarch.rpm;name=aarch64_rust-mimalloc+local_dynamic_tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+local_dynamic_tls-devel}"
SRC_URI[aarch64_rust-mimalloc+local_dynamic_tls-devel.sha256sum] = "a2291fd4c63b9fff6ab4093c82e87f72e882d3eb89324a38484373649a435ca3"

URI_aarch64_rust-mimalloc+no_thp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+no_thp-devel-0.1.48-1.el10_2.noarch.rpm;name=aarch64_rust-mimalloc+no_thp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+no_thp-devel}"
SRC_URI[aarch64_rust-mimalloc+no_thp-devel.sha256sum] = "874063b6430be1fd8395700690ebdce128727ee85dea160acda5eb03d15033da"

URI_aarch64_rust-mimalloc+override-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+override-devel-0.1.48-1.el10_2.noarch.rpm;name=aarch64_rust-mimalloc+override-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+override-devel}"
SRC_URI[aarch64_rust-mimalloc+override-devel.sha256sum] = "d766f11847bbb7acd5c6583afeacb438287b726f744a3c3d4e76e5089d658b69"

URI_aarch64_rust-mimalloc+secure-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+secure-devel-0.1.48-1.el10_2.noarch.rpm;name=aarch64_rust-mimalloc+secure-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+secure-devel}"
SRC_URI[aarch64_rust-mimalloc+secure-devel.sha256sum] = "428c3a91b5f5f6cdf47838a831944da59bb1fb18690d68eaba4a2292d14c58b6"

URI_aarch64_rust-mimalloc+v3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+v3-devel-0.1.48-1.el10_2.noarch.rpm;name=aarch64_rust-mimalloc+v3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+v3-devel}"
SRC_URI[aarch64_rust-mimalloc+v3-devel.sha256sum] = "abdd89dc6adc553d209ac70a5d6f42c95ff10a84db62affefd1d01ca7a033faf"

URI_aarch64_rust-mimalloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc-devel-0.1.48-1.el10_2.noarch.rpm;name=aarch64_rust-mimalloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc-devel}"
SRC_URI[aarch64_rust-mimalloc-devel.sha256sum] = "dd8f7aeee90c2f10294ca1d962f73fc9bce641dfe2d01f2c5dab9826829f7499"

RDEPENDS:rust-mimalloc+debug-devel = " \
 cargo \
 rust-libmimalloc-sys+debug-devel \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc+debug_in_debug-devel = " \
 cargo \
 rust-libmimalloc-sys+debug_in_debug-devel \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc+default-devel = " \
 cargo \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc+extended-devel = " \
 cargo \
 rust-libmimalloc-sys+extended-devel \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc+local_dynamic_tls-devel = " \
 cargo \
 rust-libmimalloc-sys+local_dynamic_tls-devel \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc+no_thp-devel = " \
 cargo \
 rust-libmimalloc-sys+no_thp-devel \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc+override-devel = " \
 cargo \
 rust-libmimalloc-sys+override-devel \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc+secure-devel = " \
 cargo \
 rust-libmimalloc-sys+secure-devel \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc+v3-devel = " \
 cargo \
 rust-libmimalloc-sys+v3-devel \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
