# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "guestfs-tools"
PV = "1.57.3"
PR = "1.el10.alma.1"
PACKAGES = " \
 guestfs-tools \
 virt-win-reg \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/guestfs-tools-1.57.3-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ceff245171a4e1b5fba149ee232fef1aedbed1596fb9905feb6df829b5418e88"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/guestfs-tools-1.57.3-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_guestfs-tools;unpack=0"
SRC_URI[x86_64_v2_guestfs-tools.sha256sum] = "3328acee373a7e24b612dd7df2cfe33ce13a8ae5ff146871f33beec6da9e3219"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/virt-win-reg-1.57.3-1.el10.alma.1.noarch.rpm;name=x86_64_v2_virt-win-reg;unpack=0"
SRC_URI[x86_64_v2_virt-win-reg.sha256sum] = "14340bf7f71ab53cd5569115bddb22d88d81ae886e1bfa966e42bab2adedfeee"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/guestfs-tools-1.57.3-1.el10.alma.1.aarch64.rpm;name=aarch64_guestfs-tools;unpack=0"
SRC_URI[aarch64_guestfs-tools.sha256sum] = "d8bc6d591972d3c333062871b3d0a410c2eeef51dd076fd5133c6d0f4c40eb0e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/virt-win-reg-1.57.3-1.el10.alma.1.noarch.rpm;name=aarch64_virt-win-reg;unpack=0"
SRC_URI[aarch64_virt-win-reg.sha256sum] = "14340bf7f71ab53cd5569115bddb22d88d81ae886e1bfa966e42bab2adedfeee"

RDEPENDS:guestfs-tools = " \
 curl \
 glib2 \
 glibc \
 gnupg2 \
 json-c \
 libgcc \
 libguestfs \
 libosinfo \
 libvirt-libs \
 libxcrypt \
 libxml2 \
 ncurses-libs \
 pcre2 \
 qemu-img \
 xz \
 xz-libs \
 "
RDEPENDS:virt-win-reg = " \
 perl-File-Basename \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-Pod-Usage \
 perl-Sys-Guestfs \
 perl-hivex \
 perl-interpreter \
 perl-libintl-perl \
 perl-libs \
 "
