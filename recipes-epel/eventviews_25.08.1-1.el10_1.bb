# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "eventviews"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 eventviews \
 eventviews-devel \
 eventviews-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/eventviews-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3df011601cf543aeb33cf2fb69dcb60ec395df3c4d1c0235f9eb36e87652e79a"

URI_x86_64_v2_eventviews = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/eventviews-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_eventviews;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_eventviews}"
SRC_URI[x86_64_v2_eventviews.sha256sum] = "ae25f9996186301bc7bae4d18023261850d99100016954c9312821223078fc64"

URI_x86_64_v2_eventviews-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/eventviews-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_eventviews-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_eventviews-devel}"
SRC_URI[x86_64_v2_eventviews-devel.sha256sum] = "063b212164ec3617849bc9b9a06c94f0ad9164095c96a5c35ed25837b2fb1cc1"

URI_x86_64_v2_eventviews-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/eventviews-doc-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_eventviews-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_eventviews-doc}"
SRC_URI[x86_64_v2_eventviews-doc.sha256sum] = "875b59bef23b0a65a0795a6081f99d1b4401805230d182b35ee62f5bea5f4c3d"

URI_aarch64_eventviews = "${EPEL_MIRROR}/aarch64/Packages/e/eventviews-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_eventviews;unpack=0"
SRC_URI:append = " ${URI_aarch64_eventviews}"
SRC_URI[aarch64_eventviews.sha256sum] = "85a603b556646800746b4798e93e87d2a29746bc47f78ff557779d3c6dc68731"

URI_aarch64_eventviews-devel = "${EPEL_MIRROR}/aarch64/Packages/e/eventviews-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_eventviews-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_eventviews-devel}"
SRC_URI[aarch64_eventviews-devel.sha256sum] = "58862ea7360cfa587b84b38797eccbdad43420c9fe399d0166440ef5410c6f08"

URI_aarch64_eventviews-doc = "${EPEL_MIRROR}/aarch64/Packages/e/eventviews-doc-25.08.1-1.el10_1.noarch.rpm;name=aarch64_eventviews-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_eventviews-doc}"
SRC_URI[aarch64_eventviews-doc.sha256sum] = "67168c98a26aef003924a93d7b2c5e36c4d08851c6bc035ed78c740dd2f0eed2"

RDEPENDS:eventviews = " \
 akonadi-calendar \
 akonadi-server \
 calendarsupport \
 glibc \
 kcalutils \
 kdiagram \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kitemmodels \
 kf6-kwidgetsaddons \
 libgcc \
 libkdepim \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:eventviews-devel = " \
 akonadi-calendar-devel \
 akonadi-server-devel \
 calendarsupport-devel \
 cmake-filesystem \
 eventviews \
 kcalutils-devel \
 kf6-kcalendarcore-devel \
 "
RDEPENDS:eventviews-doc = " \
 "
