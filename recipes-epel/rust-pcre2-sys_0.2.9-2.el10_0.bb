# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pcre2-sys"
PV = "0.2.9"
PR = "2.el10_0"
PACKAGES = " \
 rust-pcre2-sys+default-devel \
 rust-pcre2-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pcre2-sys-0.2.9-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "105c7efdab23acf69dc26a54cec664223192834002c0c0809d1aa48f542c65cd"

URI_x86_64_v2_rust-pcre2-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pcre2-sys+default-devel-0.2.9-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pcre2-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pcre2-sys+default-devel}"
SRC_URI[x86_64_v2_rust-pcre2-sys+default-devel.sha256sum] = "f76affb08619cf5cff8635713ad83e54d350d4c357c4b8e0abe4dbb6e726df32"

URI_x86_64_v2_rust-pcre2-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pcre2-sys-devel-0.2.9-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pcre2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pcre2-sys-devel}"
SRC_URI[x86_64_v2_rust-pcre2-sys-devel.sha256sum] = "14fb24cca975606254be9969e878c742e39d64c3fe298aa244d2043c679f54e6"

URI_aarch64_rust-pcre2-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pcre2-sys+default-devel-0.2.9-2.el10_0.noarch.rpm;name=aarch64_rust-pcre2-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pcre2-sys+default-devel}"
SRC_URI[aarch64_rust-pcre2-sys+default-devel.sha256sum] = "191402e0ea4ca40eaeb4cae35be97ebd9e6ab868692113ab0fc546df641a53f4"

URI_aarch64_rust-pcre2-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pcre2-sys-devel-0.2.9-2.el10_0.noarch.rpm;name=aarch64_rust-pcre2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pcre2-sys-devel}"
SRC_URI[aarch64_rust-pcre2-sys-devel.sha256sum] = "b5d82044e00040b6673e4030c63fbb0e0168e0b469533bf48afcb8f1dcb84a01"

RDEPENDS:rust-pcre2-sys+default-devel = " \
 cargo \
 rust-pcre2-sys-devel \
 "
RDEPENDS:rust-pcre2-sys-devel = " \
 cargo \
 pcre2-devel \
 rust-cc+default-devel \
 rust-cc+parallel-devel \
 rust-libc+default-devel \
 rust-pkg-config+default-devel \
 "
