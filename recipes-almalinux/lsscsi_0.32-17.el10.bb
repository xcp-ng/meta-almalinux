# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lsscsi"
PV = "0.32"
PR = "17.el10"
PACKAGES = " \
 lsscsi \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/lsscsi-0.32-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "816af3a968f87d1393dae3c0ccc22e0f0d73906d83322a55bb15a9d23ec5a27d"

URI_x86_64_v2_lsscsi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/lsscsi-0.32-17.el10.x86_64_v2.rpm;name=x86_64_v2_lsscsi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lsscsi}"
SRC_URI[x86_64_v2_lsscsi.sha256sum] = "10979a941269c7044d15a671fc06145cb4a8ccdc12a003c0ffabc702ebc73d7f"

URI_aarch64_lsscsi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/lsscsi-0.32-17.el10.aarch64.rpm;name=aarch64_lsscsi;unpack=0"
SRC_URI:append = " ${URI_aarch64_lsscsi}"
SRC_URI[aarch64_lsscsi.sha256sum] = "a43e0a311926f9e8c1628e0d2773788a2e6a1bfcabd6e7be26a76aa01ccf8a73"

RDEPENDS:lsscsi = " \
 glibc \
 "
