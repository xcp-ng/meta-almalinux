# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustls"
PV = "0.23.45"
PR = "1.el10_2"
PACKAGES = " \
 rust-rustls+brotli-devel \
 rust-rustls+custom-provider-devel \
 rust-rustls+default-devel \
 rust-rustls+hashbrown-devel \
 rust-rustls+log-devel \
 rust-rustls+logging-devel \
 rust-rustls+read_buf-devel \
 rust-rustls+ring-devel \
 rust-rustls+rustversion-devel \
 rust-rustls+std-devel \
 rust-rustls+tls12-devel \
 rust-rustls+zlib-devel \
 rust-rustls-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-rustls-0.23.45-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d448c713ac75a7268bfa3e51b01cd68ef0f1199029395f07e5e7cf57f376fb8e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+brotli-devel-0.23.45-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+brotli-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls+brotli-devel.sha256sum] = "7bcaa03a8d32356e5f4a268916b3a9eef0ed802424939029bad264e6534bd374"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+custom-provider-devel-0.23.45-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+custom-provider-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls+custom-provider-devel.sha256sum] = "32cab2c97c3645157fc08b923a3cb065958e886064e4cc89054e3d3dc26d9f73"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+default-devel-0.23.45-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls+default-devel.sha256sum] = "f80c96c94c3d5f40db4e6690027ea5688569fb4227f675cee7b01ea7fcdb697b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+hashbrown-devel-0.23.45-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+hashbrown-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls+hashbrown-devel.sha256sum] = "172c16c1482c51d206972c18a0cb9a53bedebdaee2c0eeb184305a3aa3eacb08"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+log-devel-0.23.45-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+log-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls+log-devel.sha256sum] = "900a8da8324dd7741c6e408b35995a84bd8a193fb7b9aaf66f99b77fdf80a8c1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+logging-devel-0.23.45-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+logging-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls+logging-devel.sha256sum] = "f5b6e849297a42b49a96c1f82cff2ddd0aa0b35d588070e0371d7c7612d2d02e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+read_buf-devel-0.23.45-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+read_buf-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls+read_buf-devel.sha256sum] = "05e210565aa39ac17761c21c26657d3daf3669c2e9395d3908e7c5624909e7d8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+ring-devel-0.23.45-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+ring-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls+ring-devel.sha256sum] = "d8f874beda6f173f8e6031d9e8ea8113bf2dd89e71552f897ed6701e6779e8fd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+rustversion-devel-0.23.45-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+rustversion-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls+rustversion-devel.sha256sum] = "1e18e98f9c2bd1c68ea9efabcd6382b752c673541ece191c03056c1a9409670c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+std-devel-0.23.45-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls+std-devel.sha256sum] = "f3736bf78912615a55e4858f05b32930e69ec37d2c3980aa837b6ad6ee8411ff"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+tls12-devel-0.23.45-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+tls12-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls+tls12-devel.sha256sum] = "62fd836d21fe5bbf50ebf9710c7a7e8219b00b7d2ef2b76060b7952cc4926d97"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+zlib-devel-0.23.45-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+zlib-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls+zlib-devel.sha256sum] = "edf8b08723504a488b72de704caba99f7155862043b5c77f9f01b1de5e2d3a5d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-devel-0.23.45-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls-devel.sha256sum] = "3ff6b737a40179d852917651135226aa8cf877df45afdf97744e678e4adb01bc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+brotli-devel-0.23.45-1.el10_2.noarch.rpm;name=aarch64_rust-rustls+brotli-devel;unpack=0"
SRC_URI[aarch64_rust-rustls+brotli-devel.sha256sum] = "83c75b14ae4f5cf3638cc4dbf9336a4427359e3ddd21118bf94d5c6b070c4152"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+custom-provider-devel-0.23.45-1.el10_2.noarch.rpm;name=aarch64_rust-rustls+custom-provider-devel;unpack=0"
SRC_URI[aarch64_rust-rustls+custom-provider-devel.sha256sum] = "bff43c71b4d67b5d6191b1c71019ba68121f9a4bf733ca6c8a22b8b385a968f5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+default-devel-0.23.45-1.el10_2.noarch.rpm;name=aarch64_rust-rustls+default-devel;unpack=0"
SRC_URI[aarch64_rust-rustls+default-devel.sha256sum] = "a55a136c7f5e881d00c5a7e1363a1639c89c60fa39903698163ceb274d5c9e14"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+hashbrown-devel-0.23.45-1.el10_2.noarch.rpm;name=aarch64_rust-rustls+hashbrown-devel;unpack=0"
SRC_URI[aarch64_rust-rustls+hashbrown-devel.sha256sum] = "e2824906066af760c6de040150d3985211de35405c057e30979cd5289fec0ea7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+log-devel-0.23.45-1.el10_2.noarch.rpm;name=aarch64_rust-rustls+log-devel;unpack=0"
SRC_URI[aarch64_rust-rustls+log-devel.sha256sum] = "86f001254bad7763983de3984f75ce45481e672cbe8d73cbb7c857b59e1a42db"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+logging-devel-0.23.45-1.el10_2.noarch.rpm;name=aarch64_rust-rustls+logging-devel;unpack=0"
SRC_URI[aarch64_rust-rustls+logging-devel.sha256sum] = "a100c1c47b9e448d243b8b373efb10535d2fc27f0c76a54f80f3c5a9793f88e2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+read_buf-devel-0.23.45-1.el10_2.noarch.rpm;name=aarch64_rust-rustls+read_buf-devel;unpack=0"
SRC_URI[aarch64_rust-rustls+read_buf-devel.sha256sum] = "c60a9e78d9ad897a908930a3df38296aa003eddb89c0996631fae1fdcdf04a93"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+ring-devel-0.23.45-1.el10_2.noarch.rpm;name=aarch64_rust-rustls+ring-devel;unpack=0"
SRC_URI[aarch64_rust-rustls+ring-devel.sha256sum] = "7a67ace10f75bb4c8e0f2edc1f73905df1d5cb19d2fb305002d27c3b204fb9ca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+rustversion-devel-0.23.45-1.el10_2.noarch.rpm;name=aarch64_rust-rustls+rustversion-devel;unpack=0"
SRC_URI[aarch64_rust-rustls+rustversion-devel.sha256sum] = "6d5ff2cb8ce4b20bc1c202b445d4984dc77df0b1458afb45925e2b785a7626e6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+std-devel-0.23.45-1.el10_2.noarch.rpm;name=aarch64_rust-rustls+std-devel;unpack=0"
SRC_URI[aarch64_rust-rustls+std-devel.sha256sum] = "be5e73ff58c037a098925debf2a1dfaabbe877e4c48ed813d01c1e974dc0ecda"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+tls12-devel-0.23.45-1.el10_2.noarch.rpm;name=aarch64_rust-rustls+tls12-devel;unpack=0"
SRC_URI[aarch64_rust-rustls+tls12-devel.sha256sum] = "eb83679ba8e82a5e0c73c5520401778df9378a9ad187fa03623d75d34160c31a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+zlib-devel-0.23.45-1.el10_2.noarch.rpm;name=aarch64_rust-rustls+zlib-devel;unpack=0"
SRC_URI[aarch64_rust-rustls+zlib-devel.sha256sum] = "fbe57daa1c3c7213a30aa53a98b7cca2343aecb21ead317b675bcc2f7d6a7f6c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-devel-0.23.45-1.el10_2.noarch.rpm;name=aarch64_rust-rustls-devel;unpack=0"
SRC_URI[aarch64_rust-rustls-devel.sha256sum] = "ba159555aeac468bec7fe253ecc1773de97a6c57ca84772268e6162798449106"

RDEPENDS:rust-rustls+brotli-devel = " \
 cargo \
 rust-brotli+std-devel \
 rust-brotli-decompressor+default-devel \
 rust-brotli-devel \
 rust-rustls+std-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+custom-provider-devel = " \
 cargo \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+default-devel = " \
 cargo \
 rust-rustls+logging-devel \
 rust-rustls+ring-devel \
 rust-rustls+std-devel \
 rust-rustls+tls12-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+hashbrown-devel = " \
 cargo \
 rust-hashbrown0.15+default-hasher-devel \
 rust-hashbrown0.15+inline-more-devel \
 rust-hashbrown0.15-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+logging-devel = " \
 cargo \
 rust-rustls+log-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+read_buf-devel = " \
 cargo \
 rust-rustls+rustversion-devel \
 rust-rustls+std-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+ring-devel = " \
 cargo \
 rust-ring+default-devel \
 rust-rustls-devel \
 rust-rustls-webpki+ring-devel \
 "
RDEPENDS:rust-rustls+rustversion-devel = " \
 cargo \
 rust-rustls-devel \
 rust-rustversion+default-devel \
 "
RDEPENDS:rust-rustls+std-devel = " \
 cargo \
 rust-once_cell+std-devel \
 rust-rustls-devel \
 rust-rustls-pki-types+std-devel \
 rust-rustls-webpki+std-devel \
 "
RDEPENDS:rust-rustls+tls12-devel = " \
 cargo \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+zlib-devel = " \
 cargo \
 rust-rustls-devel \
 rust-zlib-rs+default-devel \
 "
RDEPENDS:rust-rustls-devel = " \
 cargo \
 rust \
 rust-once_cell+alloc-devel \
 rust-once_cell+race-devel \
 rust-once_cell-devel \
 rust-rustls-pki-types+alloc-devel \
 rust-rustls-pki-types+default-devel \
 rust-rustls-webpki+alloc-devel \
 rust-rustls-webpki-devel \
 rust-subtle-devel \
 rust-zeroize+default-devel \
 "
