# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "falkon"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 falkon \
 falkon-kde \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/falkon-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e1ed0323f06831698690afadfe000a741cf12ef136d97e3a921da210144c9e3"

URI_x86_64_v2_falkon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/falkon-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_falkon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_falkon}"
SRC_URI[x86_64_v2_falkon.sha256sum] = "24ac985eb4dc669e2e91abfb4184afbdc2079062b4091a2630720f5122673c44"

URI_x86_64_v2_falkon-kde = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/falkon-kde-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_falkon-kde;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_falkon-kde}"
SRC_URI[x86_64_v2_falkon-kde.sha256sum] = "dd53b67166bdb3e0bdcd4bdd6f9a9861c1c7f4e5a3e01c4168c2fa2ec27f3410"

URI_aarch64_falkon = "${EPEL_MIRROR}/aarch64/Packages/f/falkon-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_falkon;unpack=0"
SRC_URI:append = " ${URI_aarch64_falkon}"
SRC_URI[aarch64_falkon.sha256sum] = "3c021996a2339d958f9fe27d0c593ccabe43f86e5ee47fdc447ad2fa572c18aa"

URI_aarch64_falkon-kde = "${EPEL_MIRROR}/aarch64/Packages/f/falkon-kde-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_falkon-kde;unpack=0"
SRC_URI:append = " ${URI_aarch64_falkon-kde}"
SRC_URI[aarch64_falkon-kde.sha256sum] = "ed3f419d4579fc0346d8014b0ad72ae10dff484c84f3ad49c03752ddc14fb892"

RDEPENDS:falkon = " \
 glibc \
 hicolor-icon-theme \
 kf6-karchive \
 libgcc \
 libstdc++ \
 libxcb \
 openssl-libs \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebchannel \
 qt6-qtwebengine \
 "
RDEPENDS:falkon-kde = " \
 falkon \
 glibc \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kio-core-libs \
 kf6-kjobwidgets \
 kf6-kwallet-libs \
 kf6-purpose \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
