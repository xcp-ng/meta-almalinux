# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "re2"
PE = "2"
PV = "20250812"
PR = "1.el10_0"
PACKAGES = " \
 python3-google-re2 \
 re2 \
 re2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/re2-20250812-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50b6772128fd59982c4d086d463299d1ec4bb6c2ed1504183269de9c0123f97c"

URI_x86_64_v2_python3-google-re2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-re2-1.1.20250812-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-google-re2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-re2}"
SRC_URI[x86_64_v2_python3-google-re2.sha256sum] = "bd3b39749c3720a48d51922c2545de8c468be765096b10cfa25bfe518d0c49a8"

URI_x86_64_v2_re2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/re2-20250812-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_re2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_re2}"
SRC_URI[x86_64_v2_re2.sha256sum] = "b9436916ac1a5ed4457eb65c7e25bb6394c765b1a5d5bda50cd608ebfd506f4f"

URI_x86_64_v2_re2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/re2-devel-20250812-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_re2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_re2-devel}"
SRC_URI[x86_64_v2_re2-devel.sha256sum] = "90acd291323481ac24794282a3fcd5532c5a96c9e998b7c5c830fee773574a26"

URI_aarch64_python3-google-re2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-re2-1.1.20250812-1.el10_0.aarch64.rpm;name=aarch64_python3-google-re2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-re2}"
SRC_URI[aarch64_python3-google-re2.sha256sum] = "7dc7099279f4cdda6f4a676e00cf954d61507826f16550b1a0c5d2d8a8072bd0"

URI_aarch64_re2 = "${EPEL_MIRROR}/aarch64/Packages/r/re2-20250812-1.el10_0.aarch64.rpm;name=aarch64_re2;unpack=0"
SRC_URI:append = " ${URI_aarch64_re2}"
SRC_URI[aarch64_re2.sha256sum] = "a91563a697a81e51cdf240a869256008eebf85ccd2e74a3ab33b1d6e0368c762"

URI_aarch64_re2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/re2-devel-20250812-1.el10_0.aarch64.rpm;name=aarch64_re2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_re2-devel}"
SRC_URI[aarch64_re2-devel.sha256sum] = "aa1355e3c34a4d9a28dff32850f51a65f4aecd1dcd4c15759d3b47b232603282"

RDEPENDS:python3-google-re2 = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 re2 \
 "
RDEPENDS:re2 = " \
 abseil-cpp \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 "
RDEPENDS:re2-devel = " \
 abseil-cpp-devel \
 cmake-filesystem \
 libicu-devel \
 pkgconf-pkg-config \
 re2 \
 "
