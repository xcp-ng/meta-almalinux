# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kglobalacceld"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 kglobalacceld \
 kglobalacceld-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kglobalacceld-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "54f8ff99b81f5aefaac20b00236f7d56d6b7129272ef5dbfff864a64ace62e5a"

URI_x86_64_v2_kglobalacceld = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kglobalacceld-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kglobalacceld;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kglobalacceld}"
SRC_URI[x86_64_v2_kglobalacceld.sha256sum] = "4cd64844367be56d524144865e929ad509f167798a8fb4d52daefd8cbf8b5c0f"

URI_x86_64_v2_kglobalacceld-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kglobalacceld-devel-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kglobalacceld-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kglobalacceld-devel}"
SRC_URI[x86_64_v2_kglobalacceld-devel.sha256sum] = "4a51c481a0dd8aa1ae85d031c1249375265f4fe1fd7978244ed76cb54e73b3ca"

URI_aarch64_kglobalacceld = "${EPEL_MIRROR}/aarch64/Packages/k/kglobalacceld-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_kglobalacceld;unpack=0"
SRC_URI:append = " ${URI_aarch64_kglobalacceld}"
SRC_URI[aarch64_kglobalacceld.sha256sum] = "41d3f7df405f904c62eee2bb8c6b64af05e602204d88324ae16fe853cc4c4665"

URI_aarch64_kglobalacceld-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kglobalacceld-devel-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_kglobalacceld-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kglobalacceld-devel}"
SRC_URI[aarch64_kglobalacceld-devel.sha256sum] = "937fe45d2cd4864832982408e0c7c028ba27475aae4a82ec03bdc1f37a4b6909"

RDEPENDS:kglobalacceld = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-kservice \
 kf6-kwindowsystem \
 libX11 \
 libstdc++ \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 xcb-util-keysyms \
 "
RDEPENDS:kglobalacceld-devel = " \
 cmake-filesystem \
 kglobalacceld \
 qt6-qtbase-devel \
 "
