# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kdnssd"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kdnssd \
 kf6-kdnssd-devel \
 kf6-kdnssd-doc \
 kf6-kdnssd-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kdnssd-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "972a4860bb552cf76f032a882f73a4b0a9df7d5464e3b0ebc238aff4e83fa165"

URI_x86_64_v2_kf6-kdnssd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdnssd-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdnssd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdnssd}"
SRC_URI[x86_64_v2_kf6-kdnssd.sha256sum] = "3ffb206ffdc39a7a94663688c65a06ae754c0a081c1f560240a023ba112e9268"

URI_x86_64_v2_kf6-kdnssd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdnssd-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdnssd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdnssd-devel}"
SRC_URI[x86_64_v2_kf6-kdnssd-devel.sha256sum] = "c8446c9b6746ea1d258763dace9476d9ff87fcbd6b04591407c62bbbe156e786"

URI_x86_64_v2_kf6-kdnssd-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdnssd-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdnssd-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdnssd-doc}"
SRC_URI[x86_64_v2_kf6-kdnssd-doc.sha256sum] = "5dc482cb9cb6c93ccfa74fbbb6791a1b1d4d311bf35990898428b3ad09b4b56e"

URI_x86_64_v2_kf6-kdnssd-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdnssd-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdnssd-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdnssd-html}"
SRC_URI[x86_64_v2_kf6-kdnssd-html.sha256sum] = "8d6130eaf738da4c98ed71e75118e0cd2df769a552da1fbc45673f0f4c229b71"

URI_aarch64_kf6-kdnssd = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdnssd-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kdnssd;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdnssd}"
SRC_URI[aarch64_kf6-kdnssd.sha256sum] = "abff75d8a715b48ca53c0f7dd293973ddf6ee1bd10b8c30a2bca423d332d8803"

URI_aarch64_kf6-kdnssd-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdnssd-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kdnssd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdnssd-devel}"
SRC_URI[aarch64_kf6-kdnssd-devel.sha256sum] = "9083d2168cd886c36ee8ac40072c5647904658c36ddd6b6c499de8e718e749de"

URI_aarch64_kf6-kdnssd-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdnssd-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kdnssd-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdnssd-doc}"
SRC_URI[aarch64_kf6-kdnssd-doc.sha256sum] = "64e6af42e869439f2a296d45471131770a4541410fe303e75b46f6655b2e6e59"

URI_aarch64_kf6-kdnssd-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdnssd-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kdnssd-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdnssd-html}"
SRC_URI[aarch64_kf6-kdnssd-html.sha256sum] = "018f6dce81dc8e6164c150baa0be09f0abff3b7f745df60e87a9b69e6fa08b20"

RDEPENDS:kf6-kdnssd = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 nss-mdns \
 qt6-qtbase \
 "
RDEPENDS:kf6-kdnssd-devel = " \
 cmake-filesystem \
 kf6-kdnssd \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kdnssd-doc = " \
 "
RDEPENDS:kf6-kdnssd-html = " \
 "
