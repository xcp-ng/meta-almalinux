# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures"
PV = "0.3.33"
PR = "1.el10_3"
PACKAGES = " \
 rust-futures+alloc-devel \
 rust-futures+async-await-devel \
 rust-futures+bilock-devel \
 rust-futures+cfg-target-has-atomic-devel \
 rust-futures+default-devel \
 rust-futures+executor-devel \
 rust-futures+futures-executor-devel \
 rust-futures+spin-devel \
 rust-futures+std-devel \
 rust-futures+thread-pool-devel \
 rust-futures+unstable-devel \
 rust-futures+write-all-vectored-devel \
 rust-futures-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-0.3.33-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36b9a18075960c4c7c9d6322e9638516eed4d7198a83d33a8e92749fac6a420d"

URI_x86_64_v2_rust-futures+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+alloc-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+alloc-devel}"
SRC_URI[x86_64_v2_rust-futures+alloc-devel.sha256sum] = "dd392b2d997b82bf8bf5abdbecf2d4c1a24506e6f5338402cb8346ae301b7203"

URI_x86_64_v2_rust-futures+async-await-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+async-await-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+async-await-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+async-await-devel}"
SRC_URI[x86_64_v2_rust-futures+async-await-devel.sha256sum] = "60e5e760ba86cba89b7748d79f56af9b5955500992e60bb387117fb4e145198a"

URI_x86_64_v2_rust-futures+bilock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+bilock-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+bilock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+bilock-devel}"
SRC_URI[x86_64_v2_rust-futures+bilock-devel.sha256sum] = "7171986b82081b4f659298a43e781c07161cc4d0e4efcaa869481bdc64247f04"

URI_x86_64_v2_rust-futures+cfg-target-has-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+cfg-target-has-atomic-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+cfg-target-has-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+cfg-target-has-atomic-devel}"
SRC_URI[x86_64_v2_rust-futures+cfg-target-has-atomic-devel.sha256sum] = "81aecb8bd75270a53f2a69db6f5c8f869cf7b711591fc39b30ca5ce8b39486a4"

URI_x86_64_v2_rust-futures+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+default-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+default-devel}"
SRC_URI[x86_64_v2_rust-futures+default-devel.sha256sum] = "ddedf2e1b6eb1ac0fd212393374a8cabf162b8ac20b2832383de658c90dfd878"

URI_x86_64_v2_rust-futures+executor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+executor-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+executor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+executor-devel}"
SRC_URI[x86_64_v2_rust-futures+executor-devel.sha256sum] = "6d653fa2f87cc0b45f6a587cbb25bd28a670d6218a7ebdffd359e7a563ea1f13"

URI_x86_64_v2_rust-futures+futures-executor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+futures-executor-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+futures-executor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+futures-executor-devel}"
SRC_URI[x86_64_v2_rust-futures+futures-executor-devel.sha256sum] = "b14b97e220292141bfbbafbcc0568f596e72a2f95f1fddae3a18e49630a90467"

URI_x86_64_v2_rust-futures+spin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+spin-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+spin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+spin-devel}"
SRC_URI[x86_64_v2_rust-futures+spin-devel.sha256sum] = "6119d6dba3f6ede657bec98cf05c823816a84119e842daa77a0de7b54e96e656"

URI_x86_64_v2_rust-futures+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+std-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+std-devel}"
SRC_URI[x86_64_v2_rust-futures+std-devel.sha256sum] = "c9e2f1eeb92f80411ec22215e1ef674015321aeaf42fa0b4ab7760bb4e455b89"

URI_x86_64_v2_rust-futures+thread-pool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+thread-pool-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+thread-pool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+thread-pool-devel}"
SRC_URI[x86_64_v2_rust-futures+thread-pool-devel.sha256sum] = "d8e06c21e5d846913f762af7806b09e67dd0fb8a2a0c9f660da182eb0662a880"

URI_x86_64_v2_rust-futures+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+unstable-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+unstable-devel}"
SRC_URI[x86_64_v2_rust-futures+unstable-devel.sha256sum] = "cdcb0e6cc9b2eb3b999e668e4b0dbd025107e79a6d9353efe9a24bd2b1f8a9cb"

URI_x86_64_v2_rust-futures+write-all-vectored-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+write-all-vectored-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+write-all-vectored-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+write-all-vectored-devel}"
SRC_URI[x86_64_v2_rust-futures+write-all-vectored-devel.sha256sum] = "7e0e43f69c21104fe3b5c68199fde706a917109d343183da6d137baf65cc6240"

URI_x86_64_v2_rust-futures-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-devel}"
SRC_URI[x86_64_v2_rust-futures-devel.sha256sum] = "9e163d4af4b8971659e68a03591aa50227ae33d48f8f2d30ed3e6eccce5ca521"

URI_aarch64_rust-futures+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+alloc-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+alloc-devel}"
SRC_URI[aarch64_rust-futures+alloc-devel.sha256sum] = "db437e7d5226055d83c66f46bcc9dbdd068a79c0a6fbffcb2384d3f9f1aabfc4"

URI_aarch64_rust-futures+async-await-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+async-await-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures+async-await-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+async-await-devel}"
SRC_URI[aarch64_rust-futures+async-await-devel.sha256sum] = "e70639b0b6f6a05cdcaf73b16d0952e8c6d24c3ae8a60f5eaaa3a407be9d741e"

URI_aarch64_rust-futures+bilock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+bilock-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures+bilock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+bilock-devel}"
SRC_URI[aarch64_rust-futures+bilock-devel.sha256sum] = "b1c3fc611d1a5693373495436e6e69e2609d9c85d3182d01d1da8cb0442f60b0"

URI_aarch64_rust-futures+cfg-target-has-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+cfg-target-has-atomic-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures+cfg-target-has-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+cfg-target-has-atomic-devel}"
SRC_URI[aarch64_rust-futures+cfg-target-has-atomic-devel.sha256sum] = "aac7fc138997bdf45b91a599d6556a3d827207db01ce2baf66156c7f62dcc200"

URI_aarch64_rust-futures+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+default-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+default-devel}"
SRC_URI[aarch64_rust-futures+default-devel.sha256sum] = "20f7d5b73c7825c14fc45ed5483ccbb1132f384f1975196397139b367666d315"

URI_aarch64_rust-futures+executor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+executor-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures+executor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+executor-devel}"
SRC_URI[aarch64_rust-futures+executor-devel.sha256sum] = "f3eba8b218a4dddc132b26e538f91b5705bf63cf1287cfeab5e8a2c2f160042a"

URI_aarch64_rust-futures+futures-executor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+futures-executor-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures+futures-executor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+futures-executor-devel}"
SRC_URI[aarch64_rust-futures+futures-executor-devel.sha256sum] = "283d5597903964fbcc3b5abe4233febd7311be2f0d94a9998f272fabbe1cd3ab"

URI_aarch64_rust-futures+spin-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+spin-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures+spin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+spin-devel}"
SRC_URI[aarch64_rust-futures+spin-devel.sha256sum] = "e4a609ac2683b6cedfec90b111feaab1e88f06b1c05da9d811208c9e6ccbf68c"

URI_aarch64_rust-futures+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+std-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+std-devel}"
SRC_URI[aarch64_rust-futures+std-devel.sha256sum] = "3aa592199998755f53be6af8b5068d8b4e756a2b66b67e88855518a98b0ca6ae"

URI_aarch64_rust-futures+thread-pool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+thread-pool-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures+thread-pool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+thread-pool-devel}"
SRC_URI[aarch64_rust-futures+thread-pool-devel.sha256sum] = "54dfd1f8a0fe7b08b647ccc6c690e7c4e277dd1eb93cc471e2a8db227926830c"

URI_aarch64_rust-futures+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+unstable-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+unstable-devel}"
SRC_URI[aarch64_rust-futures+unstable-devel.sha256sum] = "9cbba25f532c310090f939c561106017a804b87ef9ca01949c330e2b6a7674e3"

URI_aarch64_rust-futures+write-all-vectored-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+write-all-vectored-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures+write-all-vectored-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+write-all-vectored-devel}"
SRC_URI[aarch64_rust-futures+write-all-vectored-devel.sha256sum] = "45b79f1bcebe28bff92b9fef7dfa022f44cc1aa46f66297ced034f1bd458495e"

URI_aarch64_rust-futures-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-devel}"
SRC_URI[aarch64_rust-futures-devel.sha256sum] = "4445115abda43043cc7dfe7da5b58eb47ddc6362e270ff1bd34d6223944a6fee"

RDEPENDS:rust-futures+alloc-devel = " \
 cargo \
 rust-futures-channel+alloc-devel \
 rust-futures-core+alloc-devel \
 rust-futures-devel \
 rust-futures-sink+alloc-devel \
 rust-futures-task+alloc-devel \
 rust-futures-util+alloc-devel \
 "
RDEPENDS:rust-futures+async-await-devel = " \
 cargo \
 rust-futures-devel \
 rust-futures-util+async-await-devel \
 rust-futures-util+async-await-macro-devel \
 "
RDEPENDS:rust-futures+bilock-devel = " \
 cargo \
 rust-futures-devel \
 rust-futures-util+bilock-devel \
 "
RDEPENDS:rust-futures+cfg-target-has-atomic-devel = " \
 cargo \
 rust-futures-devel \
 "
RDEPENDS:rust-futures+default-devel = " \
 cargo \
 rust-futures+async-await-devel \
 rust-futures+executor-devel \
 rust-futures+std-devel \
 rust-futures-devel \
 "
RDEPENDS:rust-futures+executor-devel = " \
 cargo \
 rust-futures+std-devel \
 rust-futures-devel \
 rust-futures-executor+std-devel \
 rust-futures-executor-devel \
 "
RDEPENDS:rust-futures+futures-executor-devel = " \
 cargo \
 rust-futures-devel \
 rust-futures-executor-devel \
 "
RDEPENDS:rust-futures+spin-devel = " \
 cargo \
 rust-futures-devel \
 rust-futures-util+spin-devel \
 "
RDEPENDS:rust-futures+std-devel = " \
 cargo \
 rust-futures+alloc-devel \
 rust-futures-core+std-devel \
 rust-futures-devel \
 rust-futures-io+std-devel \
 rust-futures-sink+std-devel \
 rust-futures-task+std-devel \
 rust-futures-util+channel-devel \
 rust-futures-util+io-devel \
 rust-futures-util+std-devel \
 "
RDEPENDS:rust-futures+thread-pool-devel = " \
 cargo \
 rust-futures+executor-devel \
 rust-futures-devel \
 rust-futures-executor+thread-pool-devel \
 rust-futures-executor-devel \
 "
RDEPENDS:rust-futures+unstable-devel = " \
 cargo \
 rust-futures-channel+unstable-devel \
 rust-futures-core+unstable-devel \
 rust-futures-devel \
 rust-futures-io+unstable-devel \
 rust-futures-task+unstable-devel \
 rust-futures-util+unstable-devel \
 "
RDEPENDS:rust-futures+write-all-vectored-devel = " \
 cargo \
 rust-futures-devel \
 rust-futures-util+write-all-vectored-devel \
 "
RDEPENDS:rust-futures-devel = " \
 cargo \
 rust \
 rust-futures-channel+sink-devel \
 rust-futures-channel-devel \
 rust-futures-core-devel \
 rust-futures-io-devel \
 rust-futures-sink-devel \
 rust-futures-task-devel \
 rust-futures-util+sink-devel \
 rust-futures-util-devel \
 "
