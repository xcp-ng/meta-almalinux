# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-litemap"
PV = "0.7.3"
PR = "5.el10_0"
PACKAGES = " \
 rust-litemap+alloc-devel \
 rust-litemap+databake-devel \
 rust-litemap+default-devel \
 rust-litemap+serde-devel \
 rust-litemap+testing-devel \
 rust-litemap+yoke-devel \
 rust-litemap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-litemap-0.7.3-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e5e6e63964f54781900f1dec7424032f74ea2eab3c423ce4de3c833ab89a2aaa"

URI_x86_64_v2_rust-litemap+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap+alloc-devel-0.7.3-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litemap+alloc-devel}"
SRC_URI[x86_64_v2_rust-litemap+alloc-devel.sha256sum] = "fbfb83961a4dd43ee0776806a3dcdde7d0d74b40d745275aa73fa8e7b6d78d5e"

URI_x86_64_v2_rust-litemap+databake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap+databake-devel-0.7.3-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap+databake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litemap+databake-devel}"
SRC_URI[x86_64_v2_rust-litemap+databake-devel.sha256sum] = "914e479314cbb0977ed6fa641c7abd02b792c066aa364767c4e19e1f1bb9597f"

URI_x86_64_v2_rust-litemap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap+default-devel-0.7.3-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litemap+default-devel}"
SRC_URI[x86_64_v2_rust-litemap+default-devel.sha256sum] = "07cf3134ebf6ffa7b83e1c0e014652a07bc73841923947f228ccfe5a27da3805"

URI_x86_64_v2_rust-litemap+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap+serde-devel-0.7.3-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litemap+serde-devel}"
SRC_URI[x86_64_v2_rust-litemap+serde-devel.sha256sum] = "0d5dcb938fd0c75081c45742f2246f96d391885ac08dd4b7a62e944c5b415ecb"

URI_x86_64_v2_rust-litemap+testing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap+testing-devel-0.7.3-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap+testing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litemap+testing-devel}"
SRC_URI[x86_64_v2_rust-litemap+testing-devel.sha256sum] = "c18db6163d0bb42086eb097cf777794c0f13f819fdca14278768ea63ab8ac61e"

URI_x86_64_v2_rust-litemap+yoke-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap+yoke-devel-0.7.3-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap+yoke-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litemap+yoke-devel}"
SRC_URI[x86_64_v2_rust-litemap+yoke-devel.sha256sum] = "0474ce354df16de78fe6ac65397a0de3678a770e063b9b4e4b29b86a76836f75"

URI_x86_64_v2_rust-litemap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap-devel-0.7.3-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litemap-devel}"
SRC_URI[x86_64_v2_rust-litemap-devel.sha256sum] = "b9d9c9100e80acbe4426004a3488649da4f8262880105e8480bb695ccc788616"

URI_aarch64_rust-litemap+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap+alloc-devel-0.7.3-5.el10_0.noarch.rpm;name=aarch64_rust-litemap+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litemap+alloc-devel}"
SRC_URI[aarch64_rust-litemap+alloc-devel.sha256sum] = "9a4964665209d694959d78c474fbbdc458b0252124af7a906a796f88b01cefc2"

URI_aarch64_rust-litemap+databake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap+databake-devel-0.7.3-5.el10_0.noarch.rpm;name=aarch64_rust-litemap+databake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litemap+databake-devel}"
SRC_URI[aarch64_rust-litemap+databake-devel.sha256sum] = "3ec00dff474f00837ca193a267f42714e1faa5da3d2dd183347e4d97765fa33b"

URI_aarch64_rust-litemap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap+default-devel-0.7.3-5.el10_0.noarch.rpm;name=aarch64_rust-litemap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litemap+default-devel}"
SRC_URI[aarch64_rust-litemap+default-devel.sha256sum] = "5a93ffd74b4d6fa17bba9697e2819bfd5850b8220d7e26fd0c9db5a76da08834"

URI_aarch64_rust-litemap+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap+serde-devel-0.7.3-5.el10_0.noarch.rpm;name=aarch64_rust-litemap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litemap+serde-devel}"
SRC_URI[aarch64_rust-litemap+serde-devel.sha256sum] = "3f2862bb9fdaedba6e6ae08cf293696ef45367c03a4956452c295d9201f3514e"

URI_aarch64_rust-litemap+testing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap+testing-devel-0.7.3-5.el10_0.noarch.rpm;name=aarch64_rust-litemap+testing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litemap+testing-devel}"
SRC_URI[aarch64_rust-litemap+testing-devel.sha256sum] = "43bd287b0f92e4cbcd4cdb538a83440f39a46bdbaedd6334315de5b04006ee79"

URI_aarch64_rust-litemap+yoke-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap+yoke-devel-0.7.3-5.el10_0.noarch.rpm;name=aarch64_rust-litemap+yoke-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litemap+yoke-devel}"
SRC_URI[aarch64_rust-litemap+yoke-devel.sha256sum] = "5a5b51e64d3f7af472d377088b588febf969310dc95057f458e73892335f04f7"

URI_aarch64_rust-litemap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap-devel-0.7.3-5.el10_0.noarch.rpm;name=aarch64_rust-litemap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litemap-devel}"
SRC_URI[aarch64_rust-litemap-devel.sha256sum] = "b5e5d72fc167e762e3e0a82dae0836af7ef49502230fce005de6263b9080ee07"

RDEPENDS:rust-litemap+alloc-devel = " \
 cargo \
 rust-litemap-devel \
 "
RDEPENDS:rust-litemap+databake-devel = " \
 cargo \
 rust-databake-devel \
 rust-litemap-devel \
 "
RDEPENDS:rust-litemap+default-devel = " \
 cargo \
 rust-litemap+alloc-devel \
 rust-litemap-devel \
 "
RDEPENDS:rust-litemap+serde-devel = " \
 cargo \
 rust-litemap-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-litemap+testing-devel = " \
 cargo \
 rust-litemap+alloc-devel \
 rust-litemap-devel \
 "
RDEPENDS:rust-litemap+yoke-devel = " \
 cargo \
 rust-litemap-devel \
 rust-yoke+derive-devel \
 rust-yoke-devel \
 "
RDEPENDS:rust-litemap-devel = " \
 cargo \
 rust \
 "
