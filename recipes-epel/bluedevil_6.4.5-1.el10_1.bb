# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bluedevil"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 bluedevil \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bluedevil-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5158f4497d8b891cb2d905cf29eb197db6f6c853bc66c2d65aa55c0f47c84836"

URI_x86_64_v2_bluedevil = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluedevil-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bluedevil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluedevil}"
SRC_URI[x86_64_v2_bluedevil.sha256sum] = "abeb07dcd71144be8246e1eb56e4033807435ad6f66fc19cf0c9401088026f5b"

URI_aarch64_bluedevil = "${EPEL_MIRROR}/aarch64/Packages/b/bluedevil-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_bluedevil;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluedevil}"
SRC_URI[aarch64_bluedevil.sha256sum] = "b2af3dc40f6594cab1a14e15b354e8658794552e5fb5a9d03368a03ecbfa2561"

RDEPENDS:bluedevil = " \
 bluez \
 bluez-obexd \
 glibc \
 kf6-bluez-qt \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kded \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libstdc++ \
 pipewire-pulseaudio \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
