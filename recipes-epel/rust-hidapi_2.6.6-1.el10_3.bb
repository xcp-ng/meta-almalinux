# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hidapi"
PV = "2.6.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-hidapi+default-devel \
 rust-hidapi+linux-native-devel \
 rust-hidapi+linux-shared-hidraw-devel \
 rust-hidapi+linux-shared-libusb-devel \
 rust-hidapi-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hidapi-2.6.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f8fd5ad6a6feb825831989a64652bf098ebad7d58bab06ccc820cc9adb50df4"

URI_x86_64_v2_rust-hidapi+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hidapi+default-devel-2.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hidapi+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hidapi+default-devel}"
SRC_URI[x86_64_v2_rust-hidapi+default-devel.sha256sum] = "09e6d88447642e4ece6a8b9ea551a23d14781e63b85f21c33af5477ab381d93c"

URI_x86_64_v2_rust-hidapi+linux-native-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hidapi+linux-native-devel-2.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hidapi+linux-native-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hidapi+linux-native-devel}"
SRC_URI[x86_64_v2_rust-hidapi+linux-native-devel.sha256sum] = "f4dc88c42ad6a90bc0376677906221d26bd60b16bf42c1d41df0544d2a977700"

URI_x86_64_v2_rust-hidapi+linux-shared-hidraw-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hidapi+linux-shared-hidraw-devel-2.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hidapi+linux-shared-hidraw-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hidapi+linux-shared-hidraw-devel}"
SRC_URI[x86_64_v2_rust-hidapi+linux-shared-hidraw-devel.sha256sum] = "d0c3f7981cd8bcd5430f0cf6fa07789b04f01a159e068cddf0003e6a77ff2d20"

URI_x86_64_v2_rust-hidapi+linux-shared-libusb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hidapi+linux-shared-libusb-devel-2.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hidapi+linux-shared-libusb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hidapi+linux-shared-libusb-devel}"
SRC_URI[x86_64_v2_rust-hidapi+linux-shared-libusb-devel.sha256sum] = "ebddac19beb002fd6db44c534b8bc625df1f25f8d9187218b0b0702cc617b7e7"

URI_x86_64_v2_rust-hidapi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hidapi-devel-2.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hidapi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hidapi-devel}"
SRC_URI[x86_64_v2_rust-hidapi-devel.sha256sum] = "4b76d30ab716091d4d5ac4393a0c029409c4d4545a35be35f15a4dd621809290"

URI_aarch64_rust-hidapi+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hidapi+default-devel-2.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-hidapi+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hidapi+default-devel}"
SRC_URI[aarch64_rust-hidapi+default-devel.sha256sum] = "99930e6c00b674eccc617c762e3a37d3b653cef9fbecb9c93777b83f28cca83a"

URI_aarch64_rust-hidapi+linux-native-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hidapi+linux-native-devel-2.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-hidapi+linux-native-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hidapi+linux-native-devel}"
SRC_URI[aarch64_rust-hidapi+linux-native-devel.sha256sum] = "5411cabdd181ab5464fe2279d280e434086ea9e599800f7dd4844989fd9659df"

URI_aarch64_rust-hidapi+linux-shared-hidraw-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hidapi+linux-shared-hidraw-devel-2.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-hidapi+linux-shared-hidraw-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hidapi+linux-shared-hidraw-devel}"
SRC_URI[aarch64_rust-hidapi+linux-shared-hidraw-devel.sha256sum] = "bb3352fa752a55b8238967654ef215959e97b255524a768d4022e394778d0e89"

URI_aarch64_rust-hidapi+linux-shared-libusb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hidapi+linux-shared-libusb-devel-2.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-hidapi+linux-shared-libusb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hidapi+linux-shared-libusb-devel}"
SRC_URI[aarch64_rust-hidapi+linux-shared-libusb-devel.sha256sum] = "f4f19b49571836b68c072dbc3c65d7314f7fd02acd516eb47dd58c81313983aa"

URI_aarch64_rust-hidapi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hidapi-devel-2.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-hidapi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hidapi-devel}"
SRC_URI[aarch64_rust-hidapi-devel.sha256sum] = "ade653ea85478f0618e7f6b089a9600d23c18c8c82a4dfe662b11762ea963dab"

RDEPENDS:rust-hidapi+default-devel = " \
 cargo \
 rust-hidapi+linux-shared-hidraw-devel \
 rust-hidapi-devel \
 "
RDEPENDS:rust-hidapi+linux-native-devel = " \
 cargo \
 rust-hidapi-devel \
 rust-nix0.30+default-devel \
 rust-nix0.30+fs-devel \
 rust-nix0.30+ioctl-devel \
 rust-nix0.30+poll-devel \
 rust-udev+default-devel \
 "
RDEPENDS:rust-hidapi+linux-shared-hidraw-devel = " \
 cargo \
 hidapi-devel \
 rust-hidapi-devel \
 "
RDEPENDS:rust-hidapi+linux-shared-libusb-devel = " \
 cargo \
 hidapi-devel \
 libusb1-devel \
 rust-hidapi-devel \
 "
RDEPENDS:rust-hidapi-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 rust-pkg-config+default-devel \
 "
