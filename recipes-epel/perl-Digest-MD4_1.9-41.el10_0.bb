# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Digest-MD4"
PV = "1.9"
PR = "41.el10_0"
PACKAGES = " \
 perl-Digest-MD4 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Digest-MD4-1.9-41.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4fabdf520c3e7f7a0c0e7c0f024595216df5a09a25389faf80f6ef5ff49cad63"

URI_x86_64_v2_perl-Digest-MD4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Digest-MD4-1.9-41.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Digest-MD4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Digest-MD4}"
SRC_URI[x86_64_v2_perl-Digest-MD4.sha256sum] = "cbc04de5bb4f2d956cdb77fe26e2f4c15b89cfa6d17124f3c49a97ed4d097604"

URI_aarch64_perl-Digest-MD4 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Digest-MD4-1.9-41.el10_0.aarch64.rpm;name=aarch64_perl-Digest-MD4;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Digest-MD4}"
SRC_URI[aarch64_perl-Digest-MD4.sha256sum] = "ecf63a1583c4d9d0020328be0ca5237cf3e747a31da8d2ef6af38556ea84a8ed"

RDEPENDS:perl-Digest-MD4 = " \
 glibc \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
