# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "minidlna"
PV = "1.3.3"
PR = "13.el10_0"
PACKAGES = " \
 minidlna \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/minidlna-1.3.3-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2dd3f6c3f7ea34e4ad5679db4859a1494e230196d2b4c982ea037858a9569da5"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - minidlna: libavformat.so.61()(64bit)
# - minidlna: libavformat.so.61(LIBAVFORMAT_61)(64bit)
# - minidlna: libavutil.so.59()(64bit)
# - minidlna: libavutil.so.59(LIBAVUTIL_59)(64bit)

URI_x86_64_v2_minidlna = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/minidlna-1.3.3-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_minidlna;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_minidlna}"
SRC_URI[x86_64_v2_minidlna.sha256sum] = "fa90772b3a50e8bca17be8801c31a0c3275657afec99fadb944df232c3809e64"

URI_aarch64_minidlna = "${EPEL_MIRROR}/aarch64/Packages/m/minidlna-1.3.3-13.el10_0.aarch64.rpm;name=aarch64_minidlna;unpack=0"
SRC_URI:append = " ${URI_aarch64_minidlna}"
SRC_URI[aarch64_minidlna.sha256sum] = "de38e2a29ee6c2bce06daf8da6dc96ef33571b1b5572b4a1e7bb2d17caf916ae"

RDEPENDS:minidlna:x86_64_v2 = " \
 avahi-libs \
 bash \
 flac-libs \
 glibc \
 libexif \
 libid3tag \
 libjpeg-turbo \
 libogg \
 libvorbis \
 sqlite-libs \
 systemd \
"
RDEPENDS:minidlna:aarch64 = " \
 avahi-libs \
 bash \
 flac-libs \
 glibc \
 libavformat-free \
 libavutil-free \
 libexif \
 libid3tag \
 libjpeg-turbo \
 libogg \
 libvorbis \
 sqlite-libs \
 systemd \
"
