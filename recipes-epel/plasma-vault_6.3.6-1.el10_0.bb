# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-vault"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 plasma-vault \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-vault-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43414832db67c9cd5f9e17a8f44705100e8f70b0447587de2d923467ccddfa4f"

URI_x86_64_v2_plasma-vault = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-vault-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-vault;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-vault}"
SRC_URI[x86_64_v2_plasma-vault.sha256sum] = "aac15aefe3ac3d4f760abb0f8779e6a66d7381f31ce93df07aec8c9e4b57d30e"

URI_aarch64_plasma-vault = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-vault-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-vault;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-vault}"
SRC_URI[aarch64_plasma-vault.sha256sum] = "1da8911224c6119bb39bef00fe2683fe451a95a26a4fe952673f7b4b2f40e2d7"

RDEPENDS:plasma-vault = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libgcc \
 libksysguard \
 libplasma \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
