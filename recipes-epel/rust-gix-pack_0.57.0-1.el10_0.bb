# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-pack"
PV = "0.57.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-pack+default-devel \
 rust-gix-pack+document-features-devel \
 rust-gix-pack+generate-devel \
 rust-gix-pack+object-cache-dynamic-devel \
 rust-gix-pack+pack-cache-lru-dynamic-devel \
 rust-gix-pack+pack-cache-lru-static-devel \
 rust-gix-pack+serde-devel \
 rust-gix-pack+streaming-input-devel \
 rust-gix-pack-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-pack-0.57.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b5c768b669de4ba0901684941d12259723631c8f562451640a9d414138905e74"

URI_x86_64_v2_rust-gix-pack+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+default-devel-0.57.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+default-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+default-devel.sha256sum] = "729f0b5ac2216e5c958d48b321f4b2751e49045fd6765904edd8e3fddb95ce18"

URI_x86_64_v2_rust-gix-pack+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+document-features-devel-0.57.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+document-features-devel.sha256sum] = "c250a4eafd0c4863a4614076daa5a59da08023ac70e6098bed018e5968b791e4"

URI_x86_64_v2_rust-gix-pack+generate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+generate-devel-0.57.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+generate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+generate-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+generate-devel.sha256sum] = "e8a3b244546f67b11c8b02c8d846891683cd930ff574af2acbda2cbc5cbf4343"

URI_x86_64_v2_rust-gix-pack+object-cache-dynamic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+object-cache-dynamic-devel-0.57.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+object-cache-dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+object-cache-dynamic-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+object-cache-dynamic-devel.sha256sum] = "26fa0f9c806451fd60dcd19237fa4369d34874460d36915c1d9610807f375dd3"

URI_x86_64_v2_rust-gix-pack+pack-cache-lru-dynamic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+pack-cache-lru-dynamic-devel-0.57.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+pack-cache-lru-dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+pack-cache-lru-dynamic-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+pack-cache-lru-dynamic-devel.sha256sum] = "a013267a22209b62f49939900a06627eeb437d16b8ec8f72429896d8b3975d97"

URI_x86_64_v2_rust-gix-pack+pack-cache-lru-static-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+pack-cache-lru-static-devel-0.57.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+pack-cache-lru-static-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+pack-cache-lru-static-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+pack-cache-lru-static-devel.sha256sum] = "8424510988fad2f1dcca1133c81dbb31679a099ff959a0cd674e3a789f6bfcf4"

URI_x86_64_v2_rust-gix-pack+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+serde-devel-0.57.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+serde-devel.sha256sum] = "0d603a872f7328e532fb5e9a770d7f7aec2c65815b3ff92e3ebe2cd59205ef2d"

URI_x86_64_v2_rust-gix-pack+streaming-input-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+streaming-input-devel-0.57.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+streaming-input-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+streaming-input-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+streaming-input-devel.sha256sum] = "8e98ec30382874b784bab818d965a246ae349916e08815c8a18659f8d8f98f89"

URI_x86_64_v2_rust-gix-pack-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack-devel-0.57.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack-devel}"
SRC_URI[x86_64_v2_rust-gix-pack-devel.sha256sum] = "b480396838d59867354d6d1532d7f97fdc76b6b24ebef41123fc1ec0cf3cb98c"

URI_aarch64_rust-gix-pack+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+default-devel-0.57.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-pack+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+default-devel}"
SRC_URI[aarch64_rust-gix-pack+default-devel.sha256sum] = "448722edb7b401414360c8deb212e5aa85221eec632a3e1ab5245bb5523aab4e"

URI_aarch64_rust-gix-pack+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+document-features-devel-0.57.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-pack+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+document-features-devel}"
SRC_URI[aarch64_rust-gix-pack+document-features-devel.sha256sum] = "93e5944706b5a7276cddde8edf1487efa1556084532132501dbc858b956563b4"

URI_aarch64_rust-gix-pack+generate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+generate-devel-0.57.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-pack+generate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+generate-devel}"
SRC_URI[aarch64_rust-gix-pack+generate-devel.sha256sum] = "6714455dbf295a6bca44923f25509b093d00b2df057d2965fb41e920b779d16a"

URI_aarch64_rust-gix-pack+object-cache-dynamic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+object-cache-dynamic-devel-0.57.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-pack+object-cache-dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+object-cache-dynamic-devel}"
SRC_URI[aarch64_rust-gix-pack+object-cache-dynamic-devel.sha256sum] = "79d8855e4dfb104e780fdd5465e81e98b470c25b585133bf6eef19f558f799ba"

URI_aarch64_rust-gix-pack+pack-cache-lru-dynamic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+pack-cache-lru-dynamic-devel-0.57.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-pack+pack-cache-lru-dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+pack-cache-lru-dynamic-devel}"
SRC_URI[aarch64_rust-gix-pack+pack-cache-lru-dynamic-devel.sha256sum] = "2406ccb8adccdba2cc706b5ee46a2b024e45903876135d9f853b1102eccc2c5b"

URI_aarch64_rust-gix-pack+pack-cache-lru-static-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+pack-cache-lru-static-devel-0.57.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-pack+pack-cache-lru-static-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+pack-cache-lru-static-devel}"
SRC_URI[aarch64_rust-gix-pack+pack-cache-lru-static-devel.sha256sum] = "b45a1d5da84af99dcae2dfeaea186a632c5173260fdd0ebe8fc0137294f043dc"

URI_aarch64_rust-gix-pack+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+serde-devel-0.57.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-pack+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+serde-devel}"
SRC_URI[aarch64_rust-gix-pack+serde-devel.sha256sum] = "45bf5a572625b7955af702e467a515a16e95e216d85e11e3970da7f387bbe893"

URI_aarch64_rust-gix-pack+streaming-input-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+streaming-input-devel-0.57.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-pack+streaming-input-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+streaming-input-devel}"
SRC_URI[aarch64_rust-gix-pack+streaming-input-devel.sha256sum] = "a486ff33bb9447db3a6ff7ca714c0a28e739400778c3c1c6c4e7272930fe17fa"

URI_aarch64_rust-gix-pack-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack-devel-0.57.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-pack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack-devel}"
SRC_URI[aarch64_rust-gix-pack-devel.sha256sum] = "e7b4d18ffc30dc7c6b1b3b7daf608aeac235cca4f867476cde26338273087391"

RDEPENDS:rust-gix-pack+default-devel = " \
 cargo \
 rust-gix-pack+generate-devel \
 rust-gix-pack+streaming-input-devel \
 rust-gix-pack-devel \
 "
RDEPENDS:rust-gix-pack+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-pack-devel \
 "
RDEPENDS:rust-gix-pack+generate-devel = " \
 cargo \
 rust-gix-diff-devel \
 rust-gix-hashtable+default-devel \
 rust-gix-pack-devel \
 rust-gix-traverse+default-devel \
 rust-parking_lot-devel \
 "
RDEPENDS:rust-gix-pack+object-cache-dynamic-devel = " \
 cargo \
 rust-clru+default-devel \
 rust-gix-hashtable+default-devel \
 rust-gix-pack-devel \
 "
RDEPENDS:rust-gix-pack+pack-cache-lru-dynamic-devel = " \
 cargo \
 rust-clru+default-devel \
 rust-gix-pack-devel \
 "
RDEPENDS:rust-gix-pack+pack-cache-lru-static-devel = " \
 cargo \
 rust-gix-pack-devel \
 rust-uluru+default-devel \
 "
RDEPENDS:rust-gix-pack+serde-devel = " \
 cargo \
 rust-gix-object+serde-devel \
 rust-gix-pack-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-pack+streaming-input-devel = " \
 cargo \
 rust-gix-pack-devel \
 rust-gix-tempfile-devel \
 rust-parking_lot-devel \
 "
RDEPENDS:rust-gix-pack-devel = " \
 cargo \
 rust \
 rust-gix-chunk+default-devel \
 rust-gix-features+crc32-devel \
 rust-gix-features+default-devel \
 rust-gix-features+progress-devel \
 rust-gix-features+rustsha1-devel \
 rust-gix-features+zlib-devel \
 rust-gix-hash+default-devel \
 rust-gix-object+default-devel \
 rust-gix-path+default-devel \
 rust-memmap2+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 "
