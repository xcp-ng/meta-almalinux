# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libtracefs"
PV = "1.8.2"
PR = "1.el10"
PACKAGES = " \
 libtracefs \
 libtracefs-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libtracefs-1.8.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "17c6023ee7a440e900e5b277476d2531122e20088de81c61bc16e3e107215b7d"

URI_x86_64_v2_libtracefs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libtracefs-1.8.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_libtracefs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtracefs}"
SRC_URI[x86_64_v2_libtracefs.sha256sum] = "a9efbd206f3b2b04d55fea27626d170517568c69e309a224ed3c75540af7cae8"

URI_x86_64_v2_libtracefs-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libtracefs-devel-1.8.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_libtracefs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtracefs-devel}"
SRC_URI[x86_64_v2_libtracefs-devel.sha256sum] = "01901e2da46f818479238f5f9f5fe5373a432a88e2cc99d9a4e7780729784677"

URI_aarch64_libtracefs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libtracefs-1.8.2-1.el10.aarch64.rpm;name=aarch64_libtracefs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtracefs}"
SRC_URI[aarch64_libtracefs.sha256sum] = "cb748e89b650bb25cafbc2016ed904016d905ce72d859079df285873e64b9613"

URI_aarch64_libtracefs-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libtracefs-devel-1.8.2-1.el10.aarch64.rpm;name=aarch64_libtracefs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtracefs-devel}"
SRC_URI[aarch64_libtracefs-devel.sha256sum] = "07b78166b61504507d26755ecb4e15fa39b3c8d1b3e8cb65f7da346e2aaf57d3"

RDEPENDS:libtracefs = " \
 glibc \
 libtraceevent \
 "
RDEPENDS:libtracefs-devel = " \
 libtraceevent-devel \
 libtracefs \
 pkgconf-pkg-config \
 "
