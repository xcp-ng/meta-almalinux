# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-c"
PV = "0.23.4"
PR = "2.el10_1"
PACKAGES = " \
 rust-tree-sitter-c+default-devel \
 rust-tree-sitter-c-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-c-0.23.4-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa7513ff14b7de85c0652667a087fff007b18e51d98ba69a999794a5f59c0c1c"

URI_x86_64_v2_rust-tree-sitter-c+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-c+default-devel-0.23.4-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-c+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-c+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-c+default-devel.sha256sum] = "4235872707944f2fd100fd9852e5db5a237b8334d8bf84ccc28cdd63d649e27f"

URI_x86_64_v2_rust-tree-sitter-c-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-c-devel-0.23.4-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-c-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-c-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-c-devel.sha256sum] = "c298ee61cabad9749933eb27339d3c8a03076976b3901e825c72c4af4ae7a77c"

URI_aarch64_rust-tree-sitter-c+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-c+default-devel-0.23.4-2.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-c+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-c+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-c+default-devel.sha256sum] = "69f9316de6b3f22001e08d8cf86aeb18ca0afbfd5e4c6641b2889363e328a820"

URI_aarch64_rust-tree-sitter-c-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-c-devel-0.23.4-2.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-c-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-c-devel}"
SRC_URI[aarch64_rust-tree-sitter-c-devel.sha256sum] = "eb6fd9af8868ad5fdc0cfcb5241d3d09136505c117c29a01d44d1b5e24110570"

RDEPENDS:rust-tree-sitter-c+default-devel = " \
 cargo \
 rust-tree-sitter-c-devel \
 "
RDEPENDS:rust-tree-sitter-c-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
