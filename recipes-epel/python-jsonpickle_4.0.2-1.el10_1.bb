# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jsonpickle"
PV = "4.0.2"
PR = "1.el10_1"
PACKAGES = " \
 python3-jsonpickle \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-jsonpickle-4.0.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "20a50e42639fddeee105de6e9fbcf41a98ee09fc1c058ca2775f522ceb7bf40a"

URI_x86_64_v2_python3-jsonpickle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jsonpickle-4.0.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jsonpickle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jsonpickle}"
SRC_URI[x86_64_v2_python3-jsonpickle.sha256sum] = "e7e95ab24f04728a6867f94d835fa0b41eefed9989461dd71c3f8dad61fccdac"

URI_aarch64_python3-jsonpickle = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jsonpickle-4.0.2-1.el10_1.noarch.rpm;name=aarch64_python3-jsonpickle;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jsonpickle}"
SRC_URI[aarch64_python3-jsonpickle.sha256sum] = "029291ec83cd560d7780289d75a8971f26eb59aeca8375f93faf48f5016ddd5e"

RDEPENDS:python3-jsonpickle = " \
 python3 \
 "
