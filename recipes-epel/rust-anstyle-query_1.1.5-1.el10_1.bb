# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-anstyle-query"
PV = "1.1.5"
PR = "1.el10_1"
PACKAGES = " \
 rust-anstyle-query+default-devel \
 rust-anstyle-query-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-anstyle-query-1.1.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ebf96c1e975ab45476365def51180eb5fcb1755c7306df2169bfa6e20fa94bd8"

URI_x86_64_v2_rust-anstyle-query+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-query+default-devel-1.1.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-query+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-query+default-devel}"
SRC_URI[x86_64_v2_rust-anstyle-query+default-devel.sha256sum] = "7d6f34ed6de8fceabdd5df40c8b7fcec10ec6eab7dd272b14580c631d8f01248"

URI_x86_64_v2_rust-anstyle-query-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-query-devel-1.1.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-query-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-query-devel}"
SRC_URI[x86_64_v2_rust-anstyle-query-devel.sha256sum] = "f4a935d80b13826f0cf4cdaa8dfb3eeacfb672f365bbb89dc35d0b285bdbd812"

URI_aarch64_rust-anstyle-query+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-query+default-devel-1.1.5-1.el10_1.noarch.rpm;name=aarch64_rust-anstyle-query+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-query+default-devel}"
SRC_URI[aarch64_rust-anstyle-query+default-devel.sha256sum] = "1dfba0c75c35a32bc07a9b97589976a6e9b63deb9227190b51e7bde124a610a8"

URI_aarch64_rust-anstyle-query-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-query-devel-1.1.5-1.el10_1.noarch.rpm;name=aarch64_rust-anstyle-query-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-query-devel}"
SRC_URI[aarch64_rust-anstyle-query-devel.sha256sum] = "a573ba5c26aaaf88592376343c438d998a7ef309f9bbe9ee58ea40a5c3bae343"

RDEPENDS:rust-anstyle-query+default-devel = " \
 cargo \
 rust-anstyle-query-devel \
 "
RDEPENDS:rust-anstyle-query-devel = " \
 cargo \
 rust \
 "
