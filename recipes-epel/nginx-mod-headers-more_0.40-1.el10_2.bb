# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nginx-mod-headers-more"
PV = "0.40"
PR = "1.el10_2"
PACKAGES = " \
 nginx-mod-headers-more \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nginx-mod-headers-more-0.40-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc0f4da578d254c0dc62a64451646ffb6a65841588fb6c1157b5eec235cb9116"

URI_x86_64_v2_nginx-mod-headers-more = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nginx-mod-headers-more-0.40-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-headers-more;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-headers-more}"
SRC_URI[x86_64_v2_nginx-mod-headers-more.sha256sum] = "52c64868ec830733072e268ff1b8a64cc513383b8da0307363061de9480fe193"

URI_aarch64_nginx-mod-headers-more = "${EPEL_MIRROR}/aarch64/Packages/n/nginx-mod-headers-more-0.40-1.el10_2.aarch64.rpm;name=aarch64_nginx-mod-headers-more;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-headers-more}"
SRC_URI[aarch64_nginx-mod-headers-more.sha256sum] = "dc8a3a4b5d4e9a91ccc9f68d5b98c2658446eb17255367957f628d98feac9ae8"

RDEPENDS:nginx-mod-headers-more = " \
 glibc \
 nginx \
 "
