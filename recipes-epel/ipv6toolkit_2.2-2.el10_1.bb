# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ipv6toolkit"
PV = "2.2"
PR = "2.el10_1"
PACKAGES = " \
 ipv6toolkit \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/ipv6toolkit-2.2-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "607012ce1761d7cf1cbfb765ad65a96c1d56249ec458a7789b9384e8e37e9cf4"

URI_x86_64_v2_ipv6toolkit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ipv6toolkit-2.2-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ipv6toolkit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipv6toolkit}"
SRC_URI[x86_64_v2_ipv6toolkit.sha256sum] = "c951fb7f9c6d743ee376e303f6e6f27c230c72390950499a05ce118360f8015d"

URI_aarch64_ipv6toolkit = "${EPEL_MIRROR}/aarch64/Packages/i/ipv6toolkit-2.2-2.el10_1.aarch64.rpm;name=aarch64_ipv6toolkit;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipv6toolkit}"
SRC_URI[aarch64_ipv6toolkit.sha256sum] = "d8d5d68e21548d9a7b7cd4a2e7ad18e83fcbb108e817ef9127e02a371857bd62"

RDEPENDS:ipv6toolkit = " \
 curl \
 glibc \
 libpcap \
 perl-Crypt-X509 \
 perl-IPC-Open3 \
 perl-MIME-Base64 \
 perl-Net-DNS \
 perl-Net-IP \
 perl-Socket \
 perl-constant \
 perl-interpreter \
 "
