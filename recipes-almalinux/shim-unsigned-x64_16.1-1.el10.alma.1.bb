# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "shim-unsigned-x64"
PV = "16.1"
PR = "1.el10.alma.1"
PACKAGES:x86_64_v2 = " \
 shim-unsigned-x64 \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/shim-unsigned-x64-16.1-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2ae6facd3004922d994ab8fb732efb4902e3da6c16cd709f76a2089d707344d"

URI_x86_64_v2_shim-unsigned-x64 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/shim-unsigned-x64-16.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_shim-unsigned-x64;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_shim-unsigned-x64}"
SRC_URI[x86_64_v2_shim-unsigned-x64.sha256sum] = "cef989daeb44db7654d9c3926cc9628ee04ad2cb8970b7310813cfb0599940ce"

RDEPENDS:shim-unsigned-x64 = " \
 "
