# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustls-platform-verifier"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-rustls-platform-verifier+base64-devel \
 rust-rustls-platform-verifier+cert-logging-devel \
 rust-rustls-platform-verifier+dbg-devel \
 rust-rustls-platform-verifier+default-devel \
 rust-rustls-platform-verifier+ffi-testing-devel \
 rust-rustls-platform-verifier-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustls-platform-verifier-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f26413393d2eb13779eac2fca176123142b4c1d979ef1431ece827b4ca506cf3"

URI_x86_64_v2_rust-rustls-platform-verifier+base64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-platform-verifier+base64-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-platform-verifier+base64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-platform-verifier+base64-devel}"
SRC_URI[x86_64_v2_rust-rustls-platform-verifier+base64-devel.sha256sum] = "ff97a268a334b7bd3aafbf18b186ec1a6f149fc1ea906830e9ee674071663cbf"

URI_x86_64_v2_rust-rustls-platform-verifier+cert-logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-platform-verifier+cert-logging-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-platform-verifier+cert-logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-platform-verifier+cert-logging-devel}"
SRC_URI[x86_64_v2_rust-rustls-platform-verifier+cert-logging-devel.sha256sum] = "b0ae16ae8bb5f8288930f2d5c9463f345d3203ddfa0a0040ae4d01da1d62acfd"

URI_x86_64_v2_rust-rustls-platform-verifier+dbg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-platform-verifier+dbg-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-platform-verifier+dbg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-platform-verifier+dbg-devel}"
SRC_URI[x86_64_v2_rust-rustls-platform-verifier+dbg-devel.sha256sum] = "4ca7e71d4d329977e1fa7ab2f7f9a0b20a22f7a8aeea9c9afccf5aa5c345f3bd"

URI_x86_64_v2_rust-rustls-platform-verifier+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-platform-verifier+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-platform-verifier+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-platform-verifier+default-devel}"
SRC_URI[x86_64_v2_rust-rustls-platform-verifier+default-devel.sha256sum] = "da491c473d13e822cbf5abbb8342e03f4d7b10332a48c9be444da0a664214459"

URI_x86_64_v2_rust-rustls-platform-verifier+ffi-testing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-platform-verifier+ffi-testing-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-platform-verifier+ffi-testing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-platform-verifier+ffi-testing-devel}"
SRC_URI[x86_64_v2_rust-rustls-platform-verifier+ffi-testing-devel.sha256sum] = "9bfee7969c76e879c997cbb5636e6ca851c137029f9434884874883d0f98a8b1"

URI_x86_64_v2_rust-rustls-platform-verifier-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-platform-verifier-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-platform-verifier-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-platform-verifier-devel}"
SRC_URI[x86_64_v2_rust-rustls-platform-verifier-devel.sha256sum] = "31207652edde02359964e7b32fe4cac0d1b5671efda2f52a835b7ac5599f3705"

URI_aarch64_rust-rustls-platform-verifier+base64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-platform-verifier+base64-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-rustls-platform-verifier+base64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-platform-verifier+base64-devel}"
SRC_URI[aarch64_rust-rustls-platform-verifier+base64-devel.sha256sum] = "dcc6bb9dae6d65aaff8f4f211f7caac57bcfaf86e3cce40f1b2e882cd2dbb9be"

URI_aarch64_rust-rustls-platform-verifier+cert-logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-platform-verifier+cert-logging-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-rustls-platform-verifier+cert-logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-platform-verifier+cert-logging-devel}"
SRC_URI[aarch64_rust-rustls-platform-verifier+cert-logging-devel.sha256sum] = "03ce554a5d11b3df14c66a787216c69c60dc3303c4c1bf35a45a682b1ed2adba"

URI_aarch64_rust-rustls-platform-verifier+dbg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-platform-verifier+dbg-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-rustls-platform-verifier+dbg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-platform-verifier+dbg-devel}"
SRC_URI[aarch64_rust-rustls-platform-verifier+dbg-devel.sha256sum] = "4395ee3b8d2e7b8d482a283890d04ffab070566b4d0137113f730080984068c2"

URI_aarch64_rust-rustls-platform-verifier+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-platform-verifier+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-rustls-platform-verifier+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-platform-verifier+default-devel}"
SRC_URI[aarch64_rust-rustls-platform-verifier+default-devel.sha256sum] = "6c5b36fcccc3401477fab79a9c75113cd49714022efba9c4cf6a1103631b5764"

URI_aarch64_rust-rustls-platform-verifier+ffi-testing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-platform-verifier+ffi-testing-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-rustls-platform-verifier+ffi-testing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-platform-verifier+ffi-testing-devel}"
SRC_URI[aarch64_rust-rustls-platform-verifier+ffi-testing-devel.sha256sum] = "1e7f633cf0244c73a95302f4c6f1287bcf630c0e4bdadbd8461fbcaaf4d01f1b"

URI_aarch64_rust-rustls-platform-verifier-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-platform-verifier-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-rustls-platform-verifier-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-platform-verifier-devel}"
SRC_URI[aarch64_rust-rustls-platform-verifier-devel.sha256sum] = "fc4d94231faea6b5531472d34e945a48500c3a4b70d868acdbe528740f2e589a"

RDEPENDS:rust-rustls-platform-verifier+base64-devel = " \
 cargo \
 rust-base64_0.22+default-devel \
 rust-rustls-platform-verifier-devel \
 "
RDEPENDS:rust-rustls-platform-verifier+cert-logging-devel = " \
 cargo \
 rust-rustls-platform-verifier+base64-devel \
 rust-rustls-platform-verifier-devel \
 "
RDEPENDS:rust-rustls-platform-verifier+dbg-devel = " \
 cargo \
 rust-rustls-platform-verifier-devel \
 "
RDEPENDS:rust-rustls-platform-verifier+default-devel = " \
 cargo \
 rust-rustls-platform-verifier-devel \
 "
RDEPENDS:rust-rustls-platform-verifier+ffi-testing-devel = " \
 cargo \
 rust-rustls+ring-devel \
 rust-rustls-platform-verifier-devel \
 "
RDEPENDS:rust-rustls-platform-verifier-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-rustls+std-devel \
 rust-rustls-devel \
 rust-rustls-native-certs+default-devel \
 rust-rustls-webpki-devel \
 "
