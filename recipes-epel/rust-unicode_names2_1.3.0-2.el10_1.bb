# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unicode_names2"
PV = "1.3.0"
PR = "2.el10_1"
PACKAGES = " \
 rust-unicode_names2+default-devel \
 rust-unicode_names2+generator-timing-devel \
 rust-unicode_names2+no_std-devel \
 rust-unicode_names2+unstable-devel \
 rust-unicode_names2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unicode_names2-1.3.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f411907579d939ffc48b0d989570552dff3b011715c4a8bc1e03fc1955bfd653"

URI_x86_64_v2_rust-unicode_names2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode_names2+default-devel-1.3.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode_names2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode_names2+default-devel}"
SRC_URI[x86_64_v2_rust-unicode_names2+default-devel.sha256sum] = "048a6ada795956385f9668da6e62fd71cf59287ad1d222832ade05bc13a7b644"

URI_x86_64_v2_rust-unicode_names2+generator-timing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode_names2+generator-timing-devel-1.3.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode_names2+generator-timing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode_names2+generator-timing-devel}"
SRC_URI[x86_64_v2_rust-unicode_names2+generator-timing-devel.sha256sum] = "8f5aade193a49361e7fffa4f3b7e0514f59982347fcc5b030ff87438a3d274fd"

URI_x86_64_v2_rust-unicode_names2+no_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode_names2+no_std-devel-1.3.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode_names2+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode_names2+no_std-devel}"
SRC_URI[x86_64_v2_rust-unicode_names2+no_std-devel.sha256sum] = "0f77c61b163ab15c2a36f4f353b217a1f3db5945237ba0d76dffea3ace288462"

URI_x86_64_v2_rust-unicode_names2+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode_names2+unstable-devel-1.3.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode_names2+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode_names2+unstable-devel}"
SRC_URI[x86_64_v2_rust-unicode_names2+unstable-devel.sha256sum] = "3198c813ee5baf0e6001791f67353c57ef99f19339505d3ff47f0e52b9c9082f"

URI_x86_64_v2_rust-unicode_names2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode_names2-devel-1.3.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode_names2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode_names2-devel}"
SRC_URI[x86_64_v2_rust-unicode_names2-devel.sha256sum] = "a7a8eb7370d11b6d81a31b2b83218e169be785572a216bf49d08d686d6a298b7"

URI_aarch64_rust-unicode_names2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode_names2+default-devel-1.3.0-2.el10_1.noarch.rpm;name=aarch64_rust-unicode_names2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode_names2+default-devel}"
SRC_URI[aarch64_rust-unicode_names2+default-devel.sha256sum] = "5038e90b55839a901b66ed630f194888f954cd8627bb9fdf8bcf00af7856e726"

URI_aarch64_rust-unicode_names2+generator-timing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode_names2+generator-timing-devel-1.3.0-2.el10_1.noarch.rpm;name=aarch64_rust-unicode_names2+generator-timing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode_names2+generator-timing-devel}"
SRC_URI[aarch64_rust-unicode_names2+generator-timing-devel.sha256sum] = "ebe373fc3fb0c638bf0e327399e8cceff0d02f16ec7c4bfb7bd40ad41ed64a3f"

URI_aarch64_rust-unicode_names2+no_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode_names2+no_std-devel-1.3.0-2.el10_1.noarch.rpm;name=aarch64_rust-unicode_names2+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode_names2+no_std-devel}"
SRC_URI[aarch64_rust-unicode_names2+no_std-devel.sha256sum] = "288c8a25023f6e575b26e0a8eb7e26e171f271b0fcff014a3d3c7df9b9cce8fd"

URI_aarch64_rust-unicode_names2+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode_names2+unstable-devel-1.3.0-2.el10_1.noarch.rpm;name=aarch64_rust-unicode_names2+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode_names2+unstable-devel}"
SRC_URI[aarch64_rust-unicode_names2+unstable-devel.sha256sum] = "89e1cf7606baba9a3cb61f7b349424a068775433f36d934615f0b6f06aa135ea"

URI_aarch64_rust-unicode_names2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode_names2-devel-1.3.0-2.el10_1.noarch.rpm;name=aarch64_rust-unicode_names2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode_names2-devel}"
SRC_URI[aarch64_rust-unicode_names2-devel.sha256sum] = "cd4499ef67c5ec25be10ebeb262567fb690a03b41a7e73b88c80ed1ad078c542"

RDEPENDS:rust-unicode_names2+default-devel = " \
 cargo \
 rust-unicode_names2-devel \
 "
RDEPENDS:rust-unicode_names2+generator-timing-devel = " \
 cargo \
 rust-unicode_names2-devel \
 "
RDEPENDS:rust-unicode_names2+no_std-devel = " \
 cargo \
 rust-unicode_names2-devel \
 "
RDEPENDS:rust-unicode_names2+unstable-devel = " \
 cargo \
 rust-unicode_names2-devel \
 "
RDEPENDS:rust-unicode_names2-devel = " \
 cargo \
 rust \
 rust-phf-devel \
 rust-unicode_names2_generator+default-devel \
 "
