# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clamav"
PV = "1.4.2"
PR = "1.el10_0"
PACKAGES = " \
 clamav \
 clamav-data \
 clamav-devel \
 clamav-doc \
 clamav-filesystem \
 clamav-freshclam \
 clamav-lib \
 clamav-milter \
 clamd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/clamav-1.4.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "623c8ce962549a0db9f8d83176670709917df5abbccbd98d582338a9c5721b19"

URI_x86_64_v2_clamav = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-1.4.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamav;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamav}"
SRC_URI[x86_64_v2_clamav.sha256sum] = "783d89f5f90346850bf979597044b49f3913db7485e7b0abbc61eff562ae8846"

URI_x86_64_v2_clamav-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-data-1.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_clamav-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamav-data}"
SRC_URI[x86_64_v2_clamav-data.sha256sum] = "711cc018ae986755c91b48ea74e09280ad38e21a7b631fca69b2fef6293652d2"
RPROVIDES:clamav-data:x86_64_v2 = "virtual/data_clamav_"

URI_x86_64_v2_clamav-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-devel-1.4.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamav-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamav-devel}"
SRC_URI[x86_64_v2_clamav-devel.sha256sum] = "0ffae3df897ec2d6e9393a0b22f99895af1e75277f041d2b0fea0bf1e37917c7"

URI_x86_64_v2_clamav-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-doc-1.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_clamav-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamav-doc}"
SRC_URI[x86_64_v2_clamav-doc.sha256sum] = "335b59b2adf9ad5ffdbfae0191406bf5c885b60a7ec30101ad32f4079fc12238"

URI_x86_64_v2_clamav-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-filesystem-1.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_clamav-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamav-filesystem}"
SRC_URI[x86_64_v2_clamav-filesystem.sha256sum] = "1c1e3bfaba749c999fe364c5f0694d81628d6959b4afa7d6ae2e0380025800c6"

URI_x86_64_v2_clamav-freshclam = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-freshclam-1.4.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamav-freshclam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamav-freshclam}"
SRC_URI[x86_64_v2_clamav-freshclam.sha256sum] = "2c88d012f586ab709c03b6e9fe14fde1aa8d699e576a6c9a7cec7159a2bd2c4b"
RPROVIDES:clamav-freshclam:x86_64_v2 = "virtual/data_clamav_"

URI_x86_64_v2_clamav-lib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-lib-1.4.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamav-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamav-lib}"
SRC_URI[x86_64_v2_clamav-lib.sha256sum] = "1870f52e842b9709b077842e449b9d4ecac1779a3d6d6af0eac48b1ad3205dfc"

URI_x86_64_v2_clamav-milter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-milter-1.4.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamav-milter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamav-milter}"
SRC_URI[x86_64_v2_clamav-milter.sha256sum] = "aed46dd5cbea6cf8dd7e46dff5474a9ec41e8b32b9e327e1b4181bed6ea05a19"

URI_x86_64_v2_clamd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamd-1.4.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamd}"
SRC_URI[x86_64_v2_clamd.sha256sum] = "c1f4f7036322415133e16968f0998512f84c01e0917122f1db5bff53bfec898c"

URI_aarch64_clamav = "${EPEL_MIRROR}/aarch64/Packages/c/clamav-1.4.2-1.el10_0.aarch64.rpm;name=aarch64_clamav;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamav}"
SRC_URI[aarch64_clamav.sha256sum] = "bec7246a2c59d3c7627721af428b852a2ba84969b1188df1eac5b81fb353fab5"

URI_aarch64_clamav-data = "${EPEL_MIRROR}/aarch64/Packages/c/clamav-data-1.4.2-1.el10_0.noarch.rpm;name=aarch64_clamav-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamav-data}"
SRC_URI[aarch64_clamav-data.sha256sum] = "269d698107f046675ab683b2cfdd03c33eb37fa386b5a853d49cce717e9c6ceb"
RPROVIDES:clamav-data:aarch64 = "virtual/data_clamav_"

URI_aarch64_clamav-devel = "${EPEL_MIRROR}/aarch64/Packages/c/clamav-devel-1.4.2-1.el10_0.aarch64.rpm;name=aarch64_clamav-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamav-devel}"
SRC_URI[aarch64_clamav-devel.sha256sum] = "23207caeeca1007436829bb54a615e3291c712fa9d0be6aad25e2a6b278f9e27"

URI_aarch64_clamav-doc = "${EPEL_MIRROR}/aarch64/Packages/c/clamav-doc-1.4.2-1.el10_0.noarch.rpm;name=aarch64_clamav-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamav-doc}"
SRC_URI[aarch64_clamav-doc.sha256sum] = "e19df18da20dbf8a04f38e5c8ae7737818d37c45c28f04de33a756bfaf00fe1f"

URI_aarch64_clamav-filesystem = "${EPEL_MIRROR}/aarch64/Packages/c/clamav-filesystem-1.4.2-1.el10_0.noarch.rpm;name=aarch64_clamav-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamav-filesystem}"
SRC_URI[aarch64_clamav-filesystem.sha256sum] = "7baf40485075ee3ae17ec8016638e9ef5c774446671b749e45f1474b2962c215"

URI_aarch64_clamav-freshclam = "${EPEL_MIRROR}/aarch64/Packages/c/clamav-freshclam-1.4.2-1.el10_0.aarch64.rpm;name=aarch64_clamav-freshclam;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamav-freshclam}"
SRC_URI[aarch64_clamav-freshclam.sha256sum] = "c63f25d907e6ed42b99735c2d8f7919feb91b1c82f03f4895fdd7a5124e6fae9"
RPROVIDES:clamav-freshclam:aarch64 = "virtual/data_clamav_"

URI_aarch64_clamav-lib = "${EPEL_MIRROR}/aarch64/Packages/c/clamav-lib-1.4.2-1.el10_0.aarch64.rpm;name=aarch64_clamav-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamav-lib}"
SRC_URI[aarch64_clamav-lib.sha256sum] = "511dd2bc6381682c28776060744b68ac0cdd5889450f063d175e1db04a07b983"

URI_aarch64_clamav-milter = "${EPEL_MIRROR}/aarch64/Packages/c/clamav-milter-1.4.2-1.el10_0.aarch64.rpm;name=aarch64_clamav-milter;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamav-milter}"
SRC_URI[aarch64_clamav-milter.sha256sum] = "fd923edd421f948e96196bc4c32df0e62f08211921c76e16364ab84e0762549d"

URI_aarch64_clamd = "${EPEL_MIRROR}/aarch64/Packages/c/clamd-1.4.2-1.el10_0.aarch64.rpm;name=aarch64_clamd;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamd}"
SRC_URI[aarch64_clamd.sha256sum] = "6382f816bf9c2fb6c0a06b3c02b78e11d19003597b908253eb9e05709c2de749"

RDEPENDS:clamav = " \
 bash \
 clamav-filesystem \
 clamav-lib \
 glibc \
 json-c \
 libgcc \
 ncurses-libs \
 systemd \
 virtual/data_clamav_ \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:clamav-data = " \
 bash \
 clamav-filesystem \
 "
RDEPENDS:clamav-devel = " \
 bash \
 clamav-filesystem \
 clamav-freshclam \
 clamav-lib \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:clamav-doc = " \
 clamav-filesystem \
 "
RDEPENDS:clamav-filesystem = " \
 bash \
 shadow-utils \
 "
RDEPENDS:clamav-freshclam = " \
 bash \
 clamav-filesystem \
 clamav-lib \
 glibc \
 libgcc \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:clamav-lib = " \
 bzip2-libs \
 glibc \
 json-c \
 libgcc \
 libxml2 \
 openssl-libs \
 pcre2 \
 zlib-ng-compat \
 "
RDEPENDS:clamav-milter = " \
 bash \
 clamav-filesystem \
 clamav-lib \
 glibc \
 sendmail-milter \
 shadow-utils \
 "
RDEPENDS:clamd = " \
 bash \
 clamav-filesystem \
 clamav-lib \
 glibc \
 shadow-utils \
 systemd-libs \
 virtual/coreutils \
 virtual/data_clamav_ \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/data_clamav_"

PROVIDES:append:aarch64 = " rpm/virtual/data_clamav_"
