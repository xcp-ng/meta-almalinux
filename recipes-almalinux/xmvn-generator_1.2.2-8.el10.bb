# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xmvn-generator"
PV = "1.2.2"
PR = "8.el10"
PACKAGES = " \
 xmvn-generator \
 xmvn-generator-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/xmvn-generator-1.2.2-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e2562b25b98fac5d48d04f2ef26811dc3c9725d92f3578be35d929462df9b8fa"

URI_x86_64_v2_xmvn-generator = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xmvn-generator-1.2.2-8.el10.x86_64_v2.rpm;name=x86_64_v2_xmvn-generator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmvn-generator}"
SRC_URI[x86_64_v2_xmvn-generator.sha256sum] = "d98fea92efd247955f25631cf3c33e937cc9c54e432923933d9332b790d29614"

URI_x86_64_v2_xmvn-generator-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xmvn-generator-javadoc-1.2.2-8.el10.noarch.rpm;name=x86_64_v2_xmvn-generator-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmvn-generator-javadoc}"
SRC_URI[x86_64_v2_xmvn-generator-javadoc.sha256sum] = "68bdce3350892884b83cf8e5abf5ca081c6ef5e5f3b69f36428b0de7723ae48d"

URI_aarch64_xmvn-generator = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xmvn-generator-1.2.2-8.el10.aarch64.rpm;name=aarch64_xmvn-generator;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmvn-generator}"
SRC_URI[aarch64_xmvn-generator.sha256sum] = "5d1c14b5a8310abf77ca5b28048345c4d820e8adae72bbbdb454f3dc809e7c0d"

URI_aarch64_xmvn-generator-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xmvn-generator-javadoc-1.2.2-8.el10.noarch.rpm;name=aarch64_xmvn-generator-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmvn-generator-javadoc}"
SRC_URI[aarch64_xmvn-generator-javadoc.sha256sum] = "68bdce3350892884b83cf8e5abf5ca081c6ef5e5f3b69f36428b0de7723ae48d"

RDEPENDS:xmvn-generator = " \
 apache-commons-compress \
 java-21-openjdk-headless \
 javapackages-filesystem \
 lujavrite \
 objectweb-asm \
 rpm-build \
 "
RDEPENDS:xmvn-generator-javadoc = " \
 javapackages-filesystem \
 "
