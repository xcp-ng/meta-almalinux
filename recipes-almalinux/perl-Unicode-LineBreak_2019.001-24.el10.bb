# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Unicode-LineBreak"
PV = "2019.001"
PR = "24.el10"
PACKAGES = " \
 perl-Unicode-LineBreak \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Unicode-LineBreak-2019.001-24.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b14d618b21525445e0c4696a2643d1a26eef8bdc45ead5ad41e90a13b3c27cb7"

URI_x86_64_v2_perl-Unicode-LineBreak = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Unicode-LineBreak-2019.001-24.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Unicode-LineBreak;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Unicode-LineBreak}"
SRC_URI[x86_64_v2_perl-Unicode-LineBreak.sha256sum] = "d163769391081b3d2857c63541f6800745f62a32449e1e8c4f802444bb53d99b"

URI_aarch64_perl-Unicode-LineBreak = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Unicode-LineBreak-2019.001-24.el10.aarch64.rpm;name=aarch64_perl-Unicode-LineBreak;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Unicode-LineBreak}"
SRC_URI[aarch64_perl-Unicode-LineBreak.sha256sum] = "1aff7fadb0ee3f50a922ee0ab8f2e1e504ca9b49c3dd048700a91fd119a2f315"

RDEPENDS:perl-Unicode-LineBreak = " \
 glibc \
 perl-Carp \
 perl-Encode \
 perl-Exporter \
 perl-MIME-Charset \
 perl-Unicode-LineBreak \
 perl-constant \
 perl-libs \
 perl-overload \
 perl-vars \
 sombok \
 "
