# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-servant-server"
PV = "0.20"
PR = "1.el10_0"
PACKAGES = " \
 ghc-servant-server \
 ghc-servant-server-devel \
 ghc-servant-server-doc \
 ghc-servant-server-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-servant-server-0.20-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f36b7997f00f4546cc54cb899f55b4cbfef72e05d4104a70e5ab34cf625e78a9"

URI_x86_64_v2_ghc-servant-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-servant-server-0.20-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-servant-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-servant-server}"
SRC_URI[x86_64_v2_ghc-servant-server.sha256sum] = "e2854de333c2ee521845b2c28454b89de402cbcf543a1a31b9d017231144c80a"

URI_x86_64_v2_ghc-servant-server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-servant-server-devel-0.20-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-servant-server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-servant-server-devel}"
SRC_URI[x86_64_v2_ghc-servant-server-devel.sha256sum] = "381334acac786263804307ed0b688ef8ebb255fbfb07c0f703845abe5ce86719"

URI_x86_64_v2_ghc-servant-server-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-servant-server-doc-0.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-servant-server-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-servant-server-doc}"
SRC_URI[x86_64_v2_ghc-servant-server-doc.sha256sum] = "e2892f54ba225dd15de571182c97df67a486841b9f29ab8c5013b9a2833e30fa"

URI_x86_64_v2_ghc-servant-server-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-servant-server-prof-0.20-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-servant-server-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-servant-server-prof}"
SRC_URI[x86_64_v2_ghc-servant-server-prof.sha256sum] = "0cde745e2f90786e64c5ae335d2d98757ac9175fd91337a2188bfdbf60cd3275"

URI_aarch64_ghc-servant-server = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-servant-server-0.20-1.el10_0.aarch64.rpm;name=aarch64_ghc-servant-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-servant-server}"
SRC_URI[aarch64_ghc-servant-server.sha256sum] = "c727c16c11bdc24f59359bb6fe81b6f0c23dbdf38646d7d0525bfba9906de2c8"

URI_aarch64_ghc-servant-server-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-servant-server-devel-0.20-1.el10_0.aarch64.rpm;name=aarch64_ghc-servant-server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-servant-server-devel}"
SRC_URI[aarch64_ghc-servant-server-devel.sha256sum] = "be9569501840e8f489dbb8f9fd2ad5920516a7e004e9802901fd868fcacafe17"

URI_aarch64_ghc-servant-server-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-servant-server-doc-0.20-1.el10_0.noarch.rpm;name=aarch64_ghc-servant-server-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-servant-server-doc}"
SRC_URI[aarch64_ghc-servant-server-doc.sha256sum] = "d29cea0687070a3091a68a85891389be198f369ab1990bf801ab26bc020ddf16"

URI_aarch64_ghc-servant-server-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-servant-server-prof-0.20-1.el10_0.aarch64.rpm;name=aarch64_ghc-servant-server-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-servant-server-prof}"
SRC_URI[aarch64_ghc-servant-server-prof.sha256sum] = "edffecb77916cc18bb4cf3e41ae2ed75f83f9a6feaddf06a9afd46010fe58728"

RDEPENDS:ghc-servant-server = " \
 ghc-HUnit \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-appar \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-attoparsec-iso8601 \
 ghc-auto-update \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-basement \
 ghc-bifunctors \
 ghc-binary \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-boring \
 ghc-bsb-http-chunked \
 ghc-byteorder \
 ghc-bytestring \
 ghc-call-stack \
 ghc-case-insensitive \
 ghc-colour \
 ghc-comonad \
 ghc-constraints \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-crypton \
 ghc-crypton-x509 \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-dec \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-easy-file \
 ghc-exceptions \
 ghc-fast-logger \
 ghc-file-embed \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hourglass \
 ghc-http-api-data \
 ghc-http-date \
 ghc-http-media \
 ghc-http-types \
 ghc-http2 \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-conversion \
 ghc-integer-logarithms \
 ghc-iproute \
 ghc-memory \
 ghc-mime-types \
 ghc-mmorph \
 ghc-monad-control \
 ghc-mtl \
 ghc-network \
 ghc-network-byte-order \
 ghc-network-control \
 ghc-network-uri \
 ghc-old-locale \
 ghc-old-time \
 ghc-optparse-applicative \
 ghc-os-string \
 ghc-parsec \
 ghc-pem \
 ghc-pretty \
 ghc-prettyprinter \
 ghc-prettyprinter-ansi-terminal \
 ghc-primitive \
 ghc-process \
 ghc-psqueues \
 ghc-random \
 ghc-recv \
 ghc-resourcet \
 ghc-safe-exceptions \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-servant \
 ghc-simple-sendfile \
 ghc-singleton-bool \
 ghc-some \
 ghc-sop-core \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-string-conversions \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-compat \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-time-manager \
 ghc-transformers \
 ghc-transformers-base \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unix-compat \
 ghc-unix-time \
 ghc-unliftio \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-utf8-string \
 ghc-uuid-types \
 ghc-vault \
 ghc-vector \
 ghc-vector-stream \
 ghc-wai \
 ghc-wai-app-static \
 ghc-wai-extra \
 ghc-wai-logger \
 ghc-warp \
 ghc-witherable \
 ghc-word8 \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-servant-server-devel = " \
 ghc-base-compat-devel \
 ghc-base-devel \
 ghc-base64-bytestring-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-constraints-devel \
 ghc-containers-devel \
 ghc-exceptions-devel \
 ghc-filepath-devel \
 ghc-http-api-data-devel \
 ghc-http-media-devel \
 ghc-http-types-devel \
 ghc-monad-control-devel \
 ghc-mtl-devel \
 ghc-network-devel \
 ghc-network-uri-devel \
 ghc-resourcet-devel \
 ghc-servant-devel \
 ghc-servant-server \
 ghc-sop-core-devel \
 ghc-string-conversions-devel \
 ghc-tagged-devel \
 ghc-text-devel \
 ghc-transformers-base-devel \
 ghc-transformers-devel \
 ghc-wai-app-static-devel \
 ghc-wai-devel \
 ghc-word8-devel \
 glibc \
 gmp \
 libffi \
 zlib-ng-compat \
 "
RDEPENDS:ghc-servant-server-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-servant-server-prof = " \
 ghc-base-compat-prof \
 ghc-base-prof \
 ghc-base64-bytestring-prof \
 ghc-bytestring-prof \
 ghc-constraints-prof \
 ghc-containers-prof \
 ghc-exceptions-prof \
 ghc-filepath-prof \
 ghc-http-api-data-prof \
 ghc-http-media-prof \
 ghc-http-types-prof \
 ghc-monad-control-prof \
 ghc-mtl-prof \
 ghc-network-prof \
 ghc-network-uri-prof \
 ghc-resourcet-prof \
 ghc-servant-prof \
 ghc-servant-server-devel \
 ghc-sop-core-prof \
 ghc-string-conversions-prof \
 ghc-tagged-prof \
 ghc-text-prof \
 ghc-transformers-base-prof \
 ghc-transformers-prof \
 ghc-wai-app-static-prof \
 ghc-wai-prof \
 ghc-word8-prof \
 "
