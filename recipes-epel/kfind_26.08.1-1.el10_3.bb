# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kfind"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kfind \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kfind-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e422984f96e3b8b07cd509cfb810b148b943b3e81cb55fad300bd4a62e8f6993"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kfind-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kfind;unpack=0"
SRC_URI[x86_64_v2_kfind.sha256sum] = "b39360a4a1f76602111cddffe7322505d9e49f91566d285372628a158a1b54fe"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kfind-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kfind;unpack=0"
SRC_URI[aarch64_kfind.sha256sum] = "8d8db3a844ea15ee688ad8c90ac3b3431e3fee516006d1c7e4862c776bdf9007"

RDEPENDS:kfind = " \
 glibc \
 kf6-karchive \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
