# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ppc64-diag"
PV = "2.7.10"
PR = "2.el10"
PACKAGES = " \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/ppc64-diag-2.7.10-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c805723ae4247367c40520ae662334def27747fac215a8fbdd175485b782e94"

