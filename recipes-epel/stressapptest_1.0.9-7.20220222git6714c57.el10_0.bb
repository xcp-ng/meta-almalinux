# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "stressapptest"
PV = "1.0.9"
PR = "7.20220222git6714c57.el10_0"
PACKAGES = " \
 stressapptest \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/stressapptest-1.0.9-7.20220222git6714c57.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4d0208d77fcf65a62da8fda2348e326a3c94977d4470d28c82a613a88a010d79"

URI_aarch64_stressapptest = "${EPEL_MIRROR}/aarch64/Packages/s/stressapptest-1.0.9-7.20220222git6714c57.el10_0.aarch64.rpm;name=aarch64_stressapptest;unpack=0"
SRC_URI:append = " ${URI_aarch64_stressapptest}"
SRC_URI[aarch64_stressapptest.sha256sum] = "6719f31e0c7286c87664cae2af7eeeca3218fa7708ef00019daf7a67275a8205"

RDEPENDS:stressapptest = " \
 glibc \
 libgcc \
 libstdc++ \
 "
