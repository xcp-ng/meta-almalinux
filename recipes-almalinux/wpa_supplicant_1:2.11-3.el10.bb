# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wpa_supplicant"
PE = "1"
PV = "2.11"
PR = "3.el10"
PACKAGES = " \
 wpa_supplicant \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/wpa_supplicant-2.11-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a66ad1d81a4b7470363e0ae45d7401e6da5b985f2b557d579b8214773820221"

URI_x86_64_v2_wpa_supplicant = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/wpa_supplicant-2.11-3.el10.x86_64_v2.rpm;name=x86_64_v2_wpa_supplicant;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wpa_supplicant}"
SRC_URI[x86_64_v2_wpa_supplicant.sha256sum] = "324804a84912accc744cd20f964afa96f061763e47b02971874405c87f613711"

URI_aarch64_wpa_supplicant = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/wpa_supplicant-2.11-3.el10.aarch64.rpm;name=aarch64_wpa_supplicant;unpack=0"
SRC_URI:append = " ${URI_aarch64_wpa_supplicant}"
SRC_URI[aarch64_wpa_supplicant.sha256sum] = "29970db8d628bcb5adf9470c3edf894b72a71080196bca3148b18012d6f43d54"

RDEPENDS:wpa_supplicant = " \
 bash \
 dbus-libs \
 glibc \
 libnl3 \
 openssl-libs \
 systemd \
 "
