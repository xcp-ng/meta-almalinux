# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-io-lifetimes"
PV = "2.0.4"
PR = "4.el10_2"
PACKAGES = " \
 rust-io-lifetimes+async-std-devel \
 rust-io-lifetimes+close-devel \
 rust-io-lifetimes+default-devel \
 rust-io-lifetimes+libc-devel \
 rust-io-lifetimes+os_pipe-devel \
 rust-io-lifetimes+socket2-devel \
 rust-io-lifetimes+tokio-devel \
 rust-io-lifetimes-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-io-lifetimes-2.0.4-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f1836271ae26aac22acbf811dd8f4509339065d8db3a5d4aefed6df5f5f6d1dd"

URI_x86_64_v2_rust-io-lifetimes+async-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-lifetimes+async-std-devel-2.0.4-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-lifetimes+async-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-io-lifetimes+async-std-devel}"
SRC_URI[x86_64_v2_rust-io-lifetimes+async-std-devel.sha256sum] = "9f2f74a154b8e56f177cbe91b90ec351d2cf1de731715e11238d512230c0345b"

URI_x86_64_v2_rust-io-lifetimes+close-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-lifetimes+close-devel-2.0.4-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-lifetimes+close-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-io-lifetimes+close-devel}"
SRC_URI[x86_64_v2_rust-io-lifetimes+close-devel.sha256sum] = "89430441634519662c67109c8f60f5e02c99723a1486822e1c10a0abdc5ef7a3"

URI_x86_64_v2_rust-io-lifetimes+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-lifetimes+default-devel-2.0.4-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-lifetimes+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-io-lifetimes+default-devel}"
SRC_URI[x86_64_v2_rust-io-lifetimes+default-devel.sha256sum] = "6730e4e371b52896bbe3c1f978d53c4b0aedcc0617f8d873a542f2706d2477c6"

URI_x86_64_v2_rust-io-lifetimes+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-lifetimes+libc-devel-2.0.4-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-lifetimes+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-io-lifetimes+libc-devel}"
SRC_URI[x86_64_v2_rust-io-lifetimes+libc-devel.sha256sum] = "106f96d60280a82e192201b4291d448b76a2ba0663c19ebcfc40794c89c0aeee"

URI_x86_64_v2_rust-io-lifetimes+os_pipe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-lifetimes+os_pipe-devel-2.0.4-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-lifetimes+os_pipe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-io-lifetimes+os_pipe-devel}"
SRC_URI[x86_64_v2_rust-io-lifetimes+os_pipe-devel.sha256sum] = "6777e0312be3370d6561f9b4d932a5c308a8e37801d32b1a0f758cc43a913f17"

URI_x86_64_v2_rust-io-lifetimes+socket2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-lifetimes+socket2-devel-2.0.4-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-lifetimes+socket2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-io-lifetimes+socket2-devel}"
SRC_URI[x86_64_v2_rust-io-lifetimes+socket2-devel.sha256sum] = "91cdfee14d744384b8fd0e12bb9f99a13e41087b951ecf869a9f15191fea3ac3"

URI_x86_64_v2_rust-io-lifetimes+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-lifetimes+tokio-devel-2.0.4-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-lifetimes+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-io-lifetimes+tokio-devel}"
SRC_URI[x86_64_v2_rust-io-lifetimes+tokio-devel.sha256sum] = "076e50bd9af114f1832c481806a193ca7c322d1fc9472c796d520e199500b0c2"

URI_x86_64_v2_rust-io-lifetimes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-lifetimes-devel-2.0.4-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-lifetimes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-io-lifetimes-devel}"
SRC_URI[x86_64_v2_rust-io-lifetimes-devel.sha256sum] = "5c6c644a75bb0d04070c908df34c615ec238040e4171a38257a4714759dc31e5"

URI_aarch64_rust-io-lifetimes+async-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-io-lifetimes+async-std-devel-2.0.4-4.el10_2.noarch.rpm;name=aarch64_rust-io-lifetimes+async-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-io-lifetimes+async-std-devel}"
SRC_URI[aarch64_rust-io-lifetimes+async-std-devel.sha256sum] = "adc012150747b84e1a0823e74edf32462a80547520f3b1ec3799d8acda8acf07"

URI_aarch64_rust-io-lifetimes+close-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-io-lifetimes+close-devel-2.0.4-4.el10_2.noarch.rpm;name=aarch64_rust-io-lifetimes+close-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-io-lifetimes+close-devel}"
SRC_URI[aarch64_rust-io-lifetimes+close-devel.sha256sum] = "db5e965a2297795e3630d97c92871863ee033d033c78816627b455f3db47f6ff"

URI_aarch64_rust-io-lifetimes+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-io-lifetimes+default-devel-2.0.4-4.el10_2.noarch.rpm;name=aarch64_rust-io-lifetimes+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-io-lifetimes+default-devel}"
SRC_URI[aarch64_rust-io-lifetimes+default-devel.sha256sum] = "70e2d77fb921e54f973d51ce4417ba7d13c7e64160a2e869bba6d4f0fdfd8aac"

URI_aarch64_rust-io-lifetimes+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-io-lifetimes+libc-devel-2.0.4-4.el10_2.noarch.rpm;name=aarch64_rust-io-lifetimes+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-io-lifetimes+libc-devel}"
SRC_URI[aarch64_rust-io-lifetimes+libc-devel.sha256sum] = "10b7c85a76c76973d860425588e326f3cb27b23406792ac41c9d2e886b5e0ce2"

URI_aarch64_rust-io-lifetimes+os_pipe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-io-lifetimes+os_pipe-devel-2.0.4-4.el10_2.noarch.rpm;name=aarch64_rust-io-lifetimes+os_pipe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-io-lifetimes+os_pipe-devel}"
SRC_URI[aarch64_rust-io-lifetimes+os_pipe-devel.sha256sum] = "ba7693fcebeb1e5700f9042fa0ef80a411d174b5526820039e68f542dfb96ece"

URI_aarch64_rust-io-lifetimes+socket2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-io-lifetimes+socket2-devel-2.0.4-4.el10_2.noarch.rpm;name=aarch64_rust-io-lifetimes+socket2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-io-lifetimes+socket2-devel}"
SRC_URI[aarch64_rust-io-lifetimes+socket2-devel.sha256sum] = "4b57a8bf35c9563caca048b04ed996328aa91696ad42dedbf1e496a651c03149"

URI_aarch64_rust-io-lifetimes+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-io-lifetimes+tokio-devel-2.0.4-4.el10_2.noarch.rpm;name=aarch64_rust-io-lifetimes+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-io-lifetimes+tokio-devel}"
SRC_URI[aarch64_rust-io-lifetimes+tokio-devel.sha256sum] = "9068935e68b4ce246da4067972dbed6d6db448b9fb40f5c902b824dbde68486a"

URI_aarch64_rust-io-lifetimes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-io-lifetimes-devel-2.0.4-4.el10_2.noarch.rpm;name=aarch64_rust-io-lifetimes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-io-lifetimes-devel}"
SRC_URI[aarch64_rust-io-lifetimes-devel.sha256sum] = "a7e73ea18d145bda7e629f5d9b401b2e19109dad8158df90d11447e0979541b7"

RDEPENDS:rust-io-lifetimes+async-std-devel = " \
 cargo \
 rust-async-std+default-devel \
 rust-async-std+io_safety-devel \
 rust-io-lifetimes-devel \
 "
RDEPENDS:rust-io-lifetimes+close-devel = " \
 cargo \
 rust-io-lifetimes+libc-devel \
 rust-io-lifetimes-devel \
 "
RDEPENDS:rust-io-lifetimes+default-devel = " \
 cargo \
 rust-io-lifetimes-devel \
 "
RDEPENDS:rust-io-lifetimes+libc-devel = " \
 cargo \
 rust-io-lifetimes-devel \
 rust-libc+default-devel \
 "
RDEPENDS:rust-io-lifetimes+os_pipe-devel = " \
 cargo \
 rust-io-lifetimes-devel \
 rust-os_pipe+default-devel \
 rust-os_pipe+io_safety-devel \
 "
RDEPENDS:rust-io-lifetimes+socket2-devel = " \
 cargo \
 rust-io-lifetimes-devel \
 rust-socket2_0.5+default-devel \
 "
RDEPENDS:rust-io-lifetimes+tokio-devel = " \
 cargo \
 rust-io-lifetimes-devel \
 rust-tokio+default-devel \
 rust-tokio+fs-devel \
 rust-tokio+io-std-devel \
 rust-tokio+net-devel \
 rust-tokio+process-devel \
 "
RDEPENDS:rust-io-lifetimes-devel = " \
 cargo \
 rust \
 "
