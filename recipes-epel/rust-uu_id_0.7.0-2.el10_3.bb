# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_id"
PV = "0.7.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-uu_id+default-devel \
 rust-uu_id+feat_selinux-devel \
 rust-uu_id+selinux-devel \
 rust-uu_id+smack-devel \
 rust-uu_id-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_id-0.7.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aacb725d94d293980ce60f58887a04141c5928737345a25a8f3c70d7efed393d"

URI_x86_64_v2_rust-uu_id+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_id+default-devel-0.7.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_id+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_id+default-devel}"
SRC_URI[x86_64_v2_rust-uu_id+default-devel.sha256sum] = "de9f6fdf2f594b26d8c459ee2987b6362472a5b2f81a418b21ba7d755e430f27"

URI_x86_64_v2_rust-uu_id+feat_selinux-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_id+feat_selinux-devel-0.7.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_id+feat_selinux-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_id+feat_selinux-devel}"
SRC_URI[x86_64_v2_rust-uu_id+feat_selinux-devel.sha256sum] = "c02b9784083fa1cffcca1b95721a35137bdc871fc66c2cf0114efa5605520c3a"

URI_x86_64_v2_rust-uu_id+selinux-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_id+selinux-devel-0.7.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_id+selinux-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_id+selinux-devel}"
SRC_URI[x86_64_v2_rust-uu_id+selinux-devel.sha256sum] = "469ce68063f4fb3626d976466dc6a71cb08a1b3fdf7850b44ec1478de59702fc"

URI_x86_64_v2_rust-uu_id+smack-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_id+smack-devel-0.7.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_id+smack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_id+smack-devel}"
SRC_URI[x86_64_v2_rust-uu_id+smack-devel.sha256sum] = "eed8a68df2dc4359c16958a110e14864ed5381e70bd1c900b00423e6f80cc951"

URI_x86_64_v2_rust-uu_id-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_id-devel-0.7.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_id-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_id-devel}"
SRC_URI[x86_64_v2_rust-uu_id-devel.sha256sum] = "61e5628c0dcd165adc93b27f1d0d599b096bdb375710269129b19d41e1b2fcb1"

URI_aarch64_rust-uu_id+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_id+default-devel-0.7.0-2.el10_3.noarch.rpm;name=aarch64_rust-uu_id+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_id+default-devel}"
SRC_URI[aarch64_rust-uu_id+default-devel.sha256sum] = "079aaaf5ee55121871608f7284ceeb01f8fd3da91b4f89754dc89e9594108df2"

URI_aarch64_rust-uu_id+feat_selinux-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_id+feat_selinux-devel-0.7.0-2.el10_3.noarch.rpm;name=aarch64_rust-uu_id+feat_selinux-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_id+feat_selinux-devel}"
SRC_URI[aarch64_rust-uu_id+feat_selinux-devel.sha256sum] = "ed053d34321501ab107022323a9d5b482653aae45473ac20447e5184355047cd"

URI_aarch64_rust-uu_id+selinux-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_id+selinux-devel-0.7.0-2.el10_3.noarch.rpm;name=aarch64_rust-uu_id+selinux-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_id+selinux-devel}"
SRC_URI[aarch64_rust-uu_id+selinux-devel.sha256sum] = "f22d5d9b918fcbb7dae93f6fac4c34e22ce59380bd8c048e86a67a1e17100dd7"

URI_aarch64_rust-uu_id+smack-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_id+smack-devel-0.7.0-2.el10_3.noarch.rpm;name=aarch64_rust-uu_id+smack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_id+smack-devel}"
SRC_URI[aarch64_rust-uu_id+smack-devel.sha256sum] = "499d9f309890d1eeb29e114d5c3bd71ffaf165901c79320978785d100a472f32"

URI_aarch64_rust-uu_id-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_id-devel-0.7.0-2.el10_3.noarch.rpm;name=aarch64_rust-uu_id-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_id-devel}"
SRC_URI[aarch64_rust-uu_id-devel.sha256sum] = "e282b8f640b6c1ac7b932bfad4c2d1971f6fdf55a7a461b13dc086fae8d2ac84"

RDEPENDS:rust-uu_id+default-devel = " \
 cargo \
 rust-uu_id-devel \
 "
RDEPENDS:rust-uu_id+feat_selinux-devel = " \
 cargo \
 rust-uu_id+selinux-devel \
 rust-uu_id-devel \
 "
RDEPENDS:rust-uu_id+selinux-devel = " \
 cargo \
 rust-selinux+default-devel \
 rust-uu_id-devel \
 "
RDEPENDS:rust-uu_id+smack-devel = " \
 cargo \
 rust-uu_id-devel \
 rust-uucore+smack-devel \
 "
RDEPENDS:rust-uu_id-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uucore+default-devel \
 rust-uucore+entries-devel \
 rust-uucore+process-devel \
 "
