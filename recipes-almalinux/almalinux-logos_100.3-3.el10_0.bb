# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "almalinux-logos"
PV = "100.3"
PR = "3.el10_0"
PACKAGES = " \
 almalinux-backgrounds \
 almalinux-logos \
 almalinux-logos-httpd \
 almalinux-logos-ipa \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/almalinux-logos-100.3-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a735fb00d5a93fc53fa68fe3bab780605bb1f99706e5ed381e2e3fa557b7717"

URI_x86_64_v2_almalinux-backgrounds = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/almalinux-backgrounds-100.3-3.el10_0.noarch.rpm;name=x86_64_v2_almalinux-backgrounds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_almalinux-backgrounds}"
SRC_URI[x86_64_v2_almalinux-backgrounds.sha256sum] = "c4287a092c2d0ead9f40f022fe09154ffec180306484aab073769886c5a32a48"

URI_x86_64_v2_almalinux-logos = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/almalinux-logos-100.3-3.el10_0.x86_64_v2.rpm;name=x86_64_v2_almalinux-logos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_almalinux-logos}"
SRC_URI[x86_64_v2_almalinux-logos.sha256sum] = "4dc7fa14258df00d60a745f884d9a385ccc55000264012a643487e92b5d62fa4"

URI_x86_64_v2_almalinux-logos-httpd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/almalinux-logos-httpd-100.3-3.el10_0.noarch.rpm;name=x86_64_v2_almalinux-logos-httpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_almalinux-logos-httpd}"
SRC_URI[x86_64_v2_almalinux-logos-httpd.sha256sum] = "23511b0a83de40537fcce34f48936fb54d7de59251424be5c4220dd3ebd3dd87"

URI_x86_64_v2_almalinux-logos-ipa = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/almalinux-logos-ipa-100.3-3.el10_0.noarch.rpm;name=x86_64_v2_almalinux-logos-ipa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_almalinux-logos-ipa}"
SRC_URI[x86_64_v2_almalinux-logos-ipa.sha256sum] = "704a29c458ac77400fbfad97c4aa125dc091e73578fccca0656f201e0d29fb07"

URI_aarch64_almalinux-backgrounds = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/almalinux-backgrounds-100.3-3.el10_0.noarch.rpm;name=aarch64_almalinux-backgrounds;unpack=0"
SRC_URI:append = " ${URI_aarch64_almalinux-backgrounds}"
SRC_URI[aarch64_almalinux-backgrounds.sha256sum] = "c4287a092c2d0ead9f40f022fe09154ffec180306484aab073769886c5a32a48"

URI_aarch64_almalinux-logos = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/almalinux-logos-100.3-3.el10_0.aarch64.rpm;name=aarch64_almalinux-logos;unpack=0"
SRC_URI:append = " ${URI_aarch64_almalinux-logos}"
SRC_URI[aarch64_almalinux-logos.sha256sum] = "58482a7cd0d1b44115d6ad5134664494eb2858dfe80e073d363e8963d131d10e"

URI_aarch64_almalinux-logos-httpd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/almalinux-logos-httpd-100.3-3.el10_0.noarch.rpm;name=aarch64_almalinux-logos-httpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_almalinux-logos-httpd}"
SRC_URI[aarch64_almalinux-logos-httpd.sha256sum] = "23511b0a83de40537fcce34f48936fb54d7de59251424be5c4220dd3ebd3dd87"

URI_aarch64_almalinux-logos-ipa = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/almalinux-logos-ipa-100.3-3.el10_0.noarch.rpm;name=aarch64_almalinux-logos-ipa;unpack=0"
SRC_URI:append = " ${URI_aarch64_almalinux-logos-ipa}"
SRC_URI[aarch64_almalinux-logos-ipa.sha256sum] = "704a29c458ac77400fbfad97c4aa125dc091e73578fccca0656f201e0d29fb07"

RDEPENDS:almalinux-backgrounds = " \
 almalinux-logos \
 "
RDEPENDS:almalinux-logos = " \
 bash \
 virtual/coreutils \
 "
RDEPENDS:almalinux-logos-httpd = " \
 "
RDEPENDS:almalinux-logos-ipa = " \
 "
