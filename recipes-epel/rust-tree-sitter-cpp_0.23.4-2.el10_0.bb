# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-cpp"
PV = "0.23.4"
PR = "2.el10_0"
PACKAGES = " \
 rust-tree-sitter-cpp+default-devel \
 rust-tree-sitter-cpp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-cpp-0.23.4-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa387b992143e872c1aaa321edf96c514ae0288e34eec6ddc9f508f5b5f671d4"

URI_x86_64_v2_rust-tree-sitter-cpp+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-cpp+default-devel-0.23.4-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-cpp+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-cpp+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-cpp+default-devel.sha256sum] = "6af85daa0e9565ae89f93ba6b71e20e7e7fa02092f02d61c2fe8878bf9df0bf5"

URI_x86_64_v2_rust-tree-sitter-cpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-cpp-devel-0.23.4-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-cpp-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-cpp-devel.sha256sum] = "b0096fd8de427a2dee8c87024cb0d4c237800eaa9cbe72fb1f9768acc82ef1df"

URI_aarch64_rust-tree-sitter-cpp+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-cpp+default-devel-0.23.4-2.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-cpp+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-cpp+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-cpp+default-devel.sha256sum] = "cb5e88c00238df50292d1e33e2376047879a7e9df0a5d37bd537f1ea909f6c78"

URI_aarch64_rust-tree-sitter-cpp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-cpp-devel-0.23.4-2.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-cpp-devel}"
SRC_URI[aarch64_rust-tree-sitter-cpp-devel.sha256sum] = "359aad50e85352df5e737c891d735af246388c0ab5e5d0c7934391d4e9557b8b"

RDEPENDS:rust-tree-sitter-cpp+default-devel = " \
 cargo \
 rust-tree-sitter-cpp-devel \
 "
RDEPENDS:rust-tree-sitter-cpp-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
