# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_time_data"
PV = "2.2.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-icu_time_data+default-devel \
 rust-icu_time_data-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_time_data-2.2.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e76f6ed3cba824106e191e7bd83b9157ff763923645481183550dbd6ae3007d"

URI_x86_64_v2_rust-icu_time_data+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_time_data+default-devel-2.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_time_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_time_data+default-devel}"
SRC_URI[x86_64_v2_rust-icu_time_data+default-devel.sha256sum] = "47a5e21e8d18e45715af0894390242fbab53d82098ec47ff391fb9444da33c65"

URI_x86_64_v2_rust-icu_time_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_time_data-devel-2.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_time_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_time_data-devel}"
SRC_URI[x86_64_v2_rust-icu_time_data-devel.sha256sum] = "9706524928cb43c2d71ff8e4cbcf542f46117606427b399c6962b145598345d3"

URI_aarch64_rust-icu_time_data+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_time_data+default-devel-2.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-icu_time_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_time_data+default-devel}"
SRC_URI[aarch64_rust-icu_time_data+default-devel.sha256sum] = "ee269da8971529f442e3888faf681371370d6109b0b2d303a7cd2835c7165f5f"

URI_aarch64_rust-icu_time_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_time_data-devel-2.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-icu_time_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_time_data-devel}"
SRC_URI[aarch64_rust-icu_time_data-devel.sha256sum] = "fc5e17e663c8ae42f00e9ee0a42fbeef0a2b1e11408e983681b4ff4bcee0c847"

RDEPENDS:rust-icu_time_data+default-devel = " \
 cargo \
 rust-icu_time_data-devel \
 "
RDEPENDS:rust-icu_time_data-devel = " \
 cargo \
 rust \
 "
