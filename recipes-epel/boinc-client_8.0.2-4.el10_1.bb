# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "boinc-client"
PV = "8.0.2"
PR = "4.el10_1"
PACKAGES = " \
 boinc-client \
 boinc-client-devel \
 boinc-client-doc \
 boinc-client-static \
 boinc-manager \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/boinc-client-8.0.2-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d4c4c6ff6fd6804ba524cb399b1ac6a2f7b271e0b3a694f111bfe5cc9ff74a78"

URI_x86_64_v2_boinc-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/boinc-client-8.0.2-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_boinc-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boinc-client}"
SRC_URI[x86_64_v2_boinc-client.sha256sum] = "09d049e9378973812717e04a40bcb689944ffb2e108a10f46a67f7fddb79e4d1"

URI_x86_64_v2_boinc-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/boinc-client-devel-8.0.2-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_boinc-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boinc-client-devel}"
SRC_URI[x86_64_v2_boinc-client-devel.sha256sum] = "d5715f06c6535a96c609ca2e07d8c652f7765a2ea36fbbc0589f3b51f6b6f319"

URI_x86_64_v2_boinc-client-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/boinc-client-doc-8.0.2-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_boinc-client-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boinc-client-doc}"
SRC_URI[x86_64_v2_boinc-client-doc.sha256sum] = "ba7adb7ccb6134697fc8d995b64c87eb02226f44307f15da69edc8c665a835fc"

URI_x86_64_v2_boinc-client-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/boinc-client-static-8.0.2-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_boinc-client-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boinc-client-static}"
SRC_URI[x86_64_v2_boinc-client-static.sha256sum] = "cb19ffba15e52818d33a012b04d349379bbdc2485ae745bdcedabf6aa7247f07"

URI_x86_64_v2_boinc-manager = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/boinc-manager-8.0.2-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_boinc-manager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boinc-manager}"
SRC_URI[x86_64_v2_boinc-manager.sha256sum] = "36de8dd1d4f1593784dd15e4e07e217dd84944d152ba8799623a93aee95e5886"

URI_aarch64_boinc-client = "${EPEL_MIRROR}/aarch64/Packages/b/boinc-client-8.0.2-4.el10_1.aarch64.rpm;name=aarch64_boinc-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_boinc-client}"
SRC_URI[aarch64_boinc-client.sha256sum] = "a0ffb0c922c58ff4a2df1c30885927af125aa8607fad2d0ff437d7e1a8f7b98c"

URI_aarch64_boinc-client-devel = "${EPEL_MIRROR}/aarch64/Packages/b/boinc-client-devel-8.0.2-4.el10_1.aarch64.rpm;name=aarch64_boinc-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_boinc-client-devel}"
SRC_URI[aarch64_boinc-client-devel.sha256sum] = "3b2092fd57521e2f00ea6ba3e1a5d2def1889ef646f92c5dbb707be7906c17c1"

URI_aarch64_boinc-client-doc = "${EPEL_MIRROR}/aarch64/Packages/b/boinc-client-doc-8.0.2-4.el10_1.noarch.rpm;name=aarch64_boinc-client-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_boinc-client-doc}"
SRC_URI[aarch64_boinc-client-doc.sha256sum] = "36c9f5947f3878a2c57a040fac7883b7a09fd03c01e18a66d25f292def9f1701"

URI_aarch64_boinc-client-static = "${EPEL_MIRROR}/aarch64/Packages/b/boinc-client-static-8.0.2-4.el10_1.aarch64.rpm;name=aarch64_boinc-client-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_boinc-client-static}"
SRC_URI[aarch64_boinc-client-static.sha256sum] = "97420e3fd942fd55837a3d188bb9ee67e4937534b6914c30a27a5a68161f2ae7"

URI_aarch64_boinc-manager = "${EPEL_MIRROR}/aarch64/Packages/b/boinc-manager-8.0.2-4.el10_1.aarch64.rpm;name=aarch64_boinc-manager;unpack=0"
SRC_URI:append = " ${URI_aarch64_boinc-manager}"
SRC_URI[aarch64_boinc-manager.sha256sum] = "df52dc38be4f167585c2f70474166d994122833e8a48e8cf34706fad8481fba7"

RDEPENDS:boinc-client = " \
 atk \
 bash \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 libgcc \
 libjpeg-turbo \
 libstdc++ \
 logrotate \
 openssl-libs \
 pango \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:boinc-client-devel = " \
 boinc-client \
 libjpeg-turbo-devel \
 mariadb-connector-c-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:boinc-client-doc = " \
 boinc-client \
 "
RDEPENDS:boinc-client-static = " \
 boinc-client-devel \
 "
RDEPENDS:boinc-manager = " \
 boinc-client \
 glib2 \
 glibc \
 gtk3 \
 hicolor-icon-theme \
 libgcc \
 libnotify \
 libstdc++ \
 libxcb \
 wxBase \
 wxGTK \
 wxGTK-webview \
 "
