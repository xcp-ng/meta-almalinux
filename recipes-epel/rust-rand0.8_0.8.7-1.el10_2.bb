# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand0.8"
PV = "0.8.7"
PR = "1.el10_2"
PACKAGES = " \
 rust-rand0.8+alloc-devel \
 rust-rand0.8+default-devel \
 rust-rand0.8+getrandom-devel \
 rust-rand0.8+libc-devel \
 rust-rand0.8+log-devel \
 rust-rand0.8+min_const_gen-devel \
 rust-rand0.8+rand_chacha-devel \
 rust-rand0.8+serde-devel \
 rust-rand0.8+serde1-devel \
 rust-rand0.8+small_rng-devel \
 rust-rand0.8+std-devel \
 rust-rand0.8+std_rng-devel \
 rust-rand0.8-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand0.8-0.8.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa29335d2dc4513b7d8b37d59e2cf7daa2498328a1621a420c65d9d33c28ad10"

URI_x86_64_v2_rust-rand0.8+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+alloc-devel-0.8.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+alloc-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+alloc-devel.sha256sum] = "993bea574ab54aecd2ed7011a6e12f6694ab80e6083791e583f0351c328e9f0f"

URI_x86_64_v2_rust-rand0.8+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+default-devel-0.8.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+default-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+default-devel.sha256sum] = "0245cc634ec4e7cfc5637dbd8cb7dcbf071d4f1ec63259e0e19e75ef54ddb9d3"
RPROVIDES:rust-rand0.8+default-devel:x86_64_v2 = "virtual/crate_rand/default__ge_0.3.10_with_crate_rand/default__lt_0.9.0~"

URI_x86_64_v2_rust-rand0.8+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+getrandom-devel-0.8.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+getrandom-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+getrandom-devel.sha256sum] = "d5ca6475d221548799dc9270a5b0fe4135071ceb2ef01a5294ea78c0c26b3ba0"

URI_x86_64_v2_rust-rand0.8+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+libc-devel-0.8.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+libc-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+libc-devel.sha256sum] = "3729a99fa5ccb4d82be07821cb83f6bf45e181a55a9db2965fc2359a150c914a"

URI_x86_64_v2_rust-rand0.8+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+log-devel-0.8.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+log-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+log-devel.sha256sum] = "3bb339082c22201bdbd326d069df04b32de8dbfdb76121f7a49a4eb97c0c9cbc"

URI_x86_64_v2_rust-rand0.8+min_const_gen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+min_const_gen-devel-0.8.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+min_const_gen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+min_const_gen-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+min_const_gen-devel.sha256sum] = "544cf19639a1dea54eb8fcc1249948412926c0a47abfccb3b51cb9b18e9a338d"

URI_x86_64_v2_rust-rand0.8+rand_chacha-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+rand_chacha-devel-0.8.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+rand_chacha-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+rand_chacha-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+rand_chacha-devel.sha256sum] = "84060b8118f8c98e720288261d400727e335c32e2e704a0eae3cb45c6f807221"

URI_x86_64_v2_rust-rand0.8+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+serde-devel-0.8.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+serde-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+serde-devel.sha256sum] = "9aa7898da3d86e6ba9d33cc432f7a1c77926b4acd91c34cc5c5562b01025e7dc"

URI_x86_64_v2_rust-rand0.8+serde1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+serde1-devel-0.8.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+serde1-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+serde1-devel.sha256sum] = "8b9bb9101ac999f75c570a37f171db2ed46ae45675819b47b64a4702e7b6a5f4"

URI_x86_64_v2_rust-rand0.8+small_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+small_rng-devel-0.8.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+small_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+small_rng-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+small_rng-devel.sha256sum] = "8495aa4c000510e8cb8ce597692fc59f47f68abd849bf9a91860c66e02eb4086"

URI_x86_64_v2_rust-rand0.8+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+std-devel-0.8.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+std-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+std-devel.sha256sum] = "2428231e7e91f4887d4bd77dd246750653326cd211446ae34bd3411a23277652"

URI_x86_64_v2_rust-rand0.8+std_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+std_rng-devel-0.8.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+std_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+std_rng-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+std_rng-devel.sha256sum] = "538dcac2f6c92c7d5dc6543b6e655d9edb9cee7a76d7ed79054eec0e58e644b4"

URI_x86_64_v2_rust-rand0.8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8-devel-0.8.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8-devel}"
SRC_URI[x86_64_v2_rust-rand0.8-devel.sha256sum] = "a3e2953d95538a158d1eec379e3e466679c831024beb3bad48f26c3d53785fa3"

URI_aarch64_rust-rand0.8+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+alloc-devel-0.8.7-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.8+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+alloc-devel}"
SRC_URI[aarch64_rust-rand0.8+alloc-devel.sha256sum] = "592cce04e7640081663bdd7b788befe86d943c4dd524c9808cc7b5fa00865b1b"

URI_aarch64_rust-rand0.8+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+default-devel-0.8.7-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+default-devel}"
SRC_URI[aarch64_rust-rand0.8+default-devel.sha256sum] = "61fae332ac759d3337096b5b6af3f91d2ec3fcd847875452e221b3fe3ae74084"
RPROVIDES:rust-rand0.8+default-devel:aarch64 = "virtual/crate_rand/default__ge_0.3.10_with_crate_rand/default__lt_0.9.0~"

URI_aarch64_rust-rand0.8+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+getrandom-devel-0.8.7-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.8+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+getrandom-devel}"
SRC_URI[aarch64_rust-rand0.8+getrandom-devel.sha256sum] = "ccbff7c37abd02dc76e96b4b246c0d6c7e225e7ae06aa22619819dd98677a489"

URI_aarch64_rust-rand0.8+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+libc-devel-0.8.7-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.8+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+libc-devel}"
SRC_URI[aarch64_rust-rand0.8+libc-devel.sha256sum] = "f5941031cf3adf6224dd09844c903c40a2b0823453fc1b31c91cdc26e6b6e11c"

URI_aarch64_rust-rand0.8+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+log-devel-0.8.7-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.8+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+log-devel}"
SRC_URI[aarch64_rust-rand0.8+log-devel.sha256sum] = "3bc70dc2f957d80225d4832311796f2050a5ed331c6cdf6cb5e20a8e76947c67"

URI_aarch64_rust-rand0.8+min_const_gen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+min_const_gen-devel-0.8.7-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.8+min_const_gen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+min_const_gen-devel}"
SRC_URI[aarch64_rust-rand0.8+min_const_gen-devel.sha256sum] = "7c5b7335aba427ffb87282c5d27300467d6fabff6d683b3ad8f04a44d2191297"

URI_aarch64_rust-rand0.8+rand_chacha-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+rand_chacha-devel-0.8.7-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.8+rand_chacha-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+rand_chacha-devel}"
SRC_URI[aarch64_rust-rand0.8+rand_chacha-devel.sha256sum] = "12b4bc4bf9e9ea4c85cbbbdfe87e47bd3ab0b2774bccc57c95b22029e1ca372a"

URI_aarch64_rust-rand0.8+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+serde-devel-0.8.7-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.8+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+serde-devel}"
SRC_URI[aarch64_rust-rand0.8+serde-devel.sha256sum] = "548b077bcff81a63ce04e222fa7506d084b4526338bed6fc0da948b77658eb95"

URI_aarch64_rust-rand0.8+serde1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+serde1-devel-0.8.7-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.8+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+serde1-devel}"
SRC_URI[aarch64_rust-rand0.8+serde1-devel.sha256sum] = "9ffed817d5154b9ed1307584f21f6775ea75ae535d91cec640c34617ce00a363"

URI_aarch64_rust-rand0.8+small_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+small_rng-devel-0.8.7-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.8+small_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+small_rng-devel}"
SRC_URI[aarch64_rust-rand0.8+small_rng-devel.sha256sum] = "8116b8214f38e442eb272faaa49658d1a88fe1724d5aebed0826f73c46623bc1"

URI_aarch64_rust-rand0.8+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+std-devel-0.8.7-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.8+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+std-devel}"
SRC_URI[aarch64_rust-rand0.8+std-devel.sha256sum] = "257dadf35240126a65bba2888286fac643d880d0d099a39fe7564d826b69feb8"

URI_aarch64_rust-rand0.8+std_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+std_rng-devel-0.8.7-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.8+std_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+std_rng-devel}"
SRC_URI[aarch64_rust-rand0.8+std_rng-devel.sha256sum] = "71335e616e12ef42de2774b85a5ffaee05d986ea05e678fa664078eb522ab07c"

URI_aarch64_rust-rand0.8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8-devel-0.8.7-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8-devel}"
SRC_URI[aarch64_rust-rand0.8-devel.sha256sum] = "db8f54150dcf9c8d0d0eb77caf50298fa5a7000a83e344987cf6e59e1b65a73b"

RDEPENDS:rust-rand0.8+alloc-devel = " \
 cargo \
 rust-rand0.8-devel \
 rust-rand_core0.6+alloc-devel \
 "
RDEPENDS:rust-rand0.8+default-devel = " \
 cargo \
 rust-rand0.8+std-devel \
 rust-rand0.8+std_rng-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-rand0.8+getrandom-devel = " \
 cargo \
 rust-rand0.8-devel \
 rust-rand_core0.6+getrandom-devel \
 "
RDEPENDS:rust-rand0.8+libc-devel = " \
 cargo \
 rust-libc-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-rand0.8+log-devel = " \
 cargo \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-rand0.8+min_const_gen-devel = " \
 cargo \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-rand0.8+rand_chacha-devel = " \
 cargo \
 rust-rand0.8-devel \
 rust-rand_chacha0.3-devel \
 "
RDEPENDS:rust-rand0.8+serde-devel = " \
 cargo \
 rust-rand0.8-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand0.8+serde1-devel = " \
 cargo \
 rust-rand0.8+serde-devel \
 rust-rand0.8-devel \
 rust-rand_core0.6+serde1-devel \
 "
RDEPENDS:rust-rand0.8+small_rng-devel = " \
 cargo \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-rand0.8+std-devel = " \
 cargo \
 rust-rand0.8+alloc-devel \
 rust-rand0.8+getrandom-devel \
 rust-rand0.8+libc-devel \
 rust-rand0.8-devel \
 rust-rand_chacha0.3+std-devel \
 rust-rand_chacha0.3-devel \
 rust-rand_core0.6+std-devel \
 "
RDEPENDS:rust-rand0.8+std_rng-devel = " \
 cargo \
 rust-rand0.8+rand_chacha-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-rand0.8-devel = " \
 cargo \
 rust-rand_core0.6+default-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_rand/default__ge_0.3.10_with_crate_rand/default__lt_0.9.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_rand/default__ge_0.3.10_with_crate_rand/default__lt_0.9.0~"
