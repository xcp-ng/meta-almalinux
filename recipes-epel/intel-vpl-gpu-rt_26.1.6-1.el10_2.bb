# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "intel-vpl-gpu-rt"
PV = "26.1.6"
PR = "1.el10_2"
PACKAGES:x86_64_v2 = " \
 intel-vpl-gpu-rt \
 intel-vpl-gpu-rt-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/i/intel-vpl-gpu-rt-26.1.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "99e2708b949526d0aff8cc15bb05bd0e8e2487edba7eac888740877b3f3a29fb"

URI_x86_64_v2_intel-vpl-gpu-rt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-vpl-gpu-rt-26.1.6-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-vpl-gpu-rt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-vpl-gpu-rt}"
SRC_URI[x86_64_v2_intel-vpl-gpu-rt.sha256sum] = "987f911375c865e5e02b52ad5b7902159efd40df1d5094f623e91f8537e433c8"

URI_x86_64_v2_intel-vpl-gpu-rt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-vpl-gpu-rt-devel-26.1.6-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-vpl-gpu-rt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-vpl-gpu-rt-devel}"
SRC_URI[x86_64_v2_intel-vpl-gpu-rt-devel.sha256sum] = "fde23bb8000cbc9235f8c4b277a3c7073dbfc8c07ab4fbf96da1cf929a628001"

RDEPENDS:intel-vpl-gpu-rt = " \
 glibc \
 libdrm \
 libgcc \
 libstdc++ \
 libva \
 libvpl \
 "
RDEPENDS:intel-vpl-gpu-rt-devel = " \
 intel-vpl-gpu-rt \
 pkgconf-pkg-config \
 "
