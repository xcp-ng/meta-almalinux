# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sddm"
PV = "0.21.0"
PR = "4.el10_0"
PACKAGES = " \
 sddm \
 sddm-themes \
 sddm-wayland-generic \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/sddm-0.21.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "688b477985bc2632a58ecf9ff6c37631c0bab3ab0667600fb7461759417484a2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sddm-0.21.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sddm;unpack=0"
SRC_URI[x86_64_v2_sddm.sha256sum] = "064e3e07c8e370b14c97a249a1b5fc7aa541a9bc2a3e42e1b28214a75222a85a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sddm-themes-0.21.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_sddm-themes;unpack=0"
SRC_URI[x86_64_v2_sddm-themes.sha256sum] = "7516c302a95fda932341030f92e58bbcc4fa141d2abe8ac4ab04486c6909bf34"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sddm-wayland-generic-0.21.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_sddm-wayland-generic;unpack=0"
SRC_URI[x86_64_v2_sddm-wayland-generic.sha256sum] = "e9c86531a100f701595dc80838ba8fc774a3dc595c4ee10f7d0d456a1545a593"
RPROVIDES:sddm-wayland-generic:append:x86_64_v2 = " virtual/sddm-greeter-displayserver"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sddm-0.21.0-4.el10_0.aarch64.rpm;name=aarch64_sddm;unpack=0"
SRC_URI[aarch64_sddm.sha256sum] = "cee65bbd0626fdd53168b4ac2619b13053c70829d3432f3f9c77e03b3f6937a2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sddm-themes-0.21.0-4.el10_0.noarch.rpm;name=aarch64_sddm-themes;unpack=0"
SRC_URI[aarch64_sddm-themes.sha256sum] = "aafe5aa52fc83dd5e063a60450c279254d97746cca3e57a584e1119b2b092ab1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sddm-wayland-generic-0.21.0-4.el10_0.noarch.rpm;name=aarch64_sddm-wayland-generic;unpack=0"
SRC_URI[aarch64_sddm-wayland-generic.sha256sum] = "df382584929cf47a8c4c3aadead7b1d83786cb3c901aa881251af1b1a14345f0"
RPROVIDES:sddm-wayland-generic:append:aarch64 = " virtual/sddm-greeter-displayserver"

RDEPENDS:sddm = " \
 bash \
 glibc \
 libXau \
 libgcc \
 libstdc++ \
 libxcb \
 pam-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 shadow-utils \
 systemd \
 systemd-libs \
 virtual/sddm-greeter-displayserver \
 "
RDEPENDS:sddm-themes = " \
 sddm \
 "
RDEPENDS:sddm-wayland-generic = " \
 sddm \
 weston \
 "
