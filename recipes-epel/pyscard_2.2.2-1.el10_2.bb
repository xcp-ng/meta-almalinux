# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pyscard"
PV = "2.2.2"
PR = "1.el10_2"
PACKAGES = " \
 python3-pyscard \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/pyscard-2.2.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0cab7048a87741734b5355df62f8eac7aab2fbc007311705c77af3e7ead6af56"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyscard-2.2.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyscard;unpack=0"
SRC_URI[x86_64_v2_python3-pyscard.sha256sum] = "06f3259db786c9460541239ac23379f5c2d1d270d43de80678f72188d9b11e75"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-pyscard-2.2.2-1.el10_2.aarch64.rpm;name=aarch64_python3-pyscard;unpack=0"
SRC_URI[aarch64_python3-pyscard.sha256sum] = "7abe8c625ff29b0f645eb06388693d7aac42cc4cbfb5ee76b44f396145f385b2"

RDEPENDS:python3-pyscard = " \
 glibc \
 pcsc-lite \
 python3 \
 "
