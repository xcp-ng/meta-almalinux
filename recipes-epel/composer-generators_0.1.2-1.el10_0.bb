# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "composer-generators"
PV = "0.1.2"
PR = "1.el10_0"
PACKAGES = " \
 composer-generators \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/composer-generators-0.1.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1987a88fea7ce59eba5687974f78af99af17772c63e75baf87484b003851176c"

URI_x86_64_v2_composer-generators = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/composer-generators-0.1.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_composer-generators;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_composer-generators}"
SRC_URI[x86_64_v2_composer-generators.sha256sum] = "2cba66a34bbc43ba0b488effc6c79c0aaa9aaa2f29f5877a9513bccb8d5559fc"

URI_aarch64_composer-generators = "${EPEL_MIRROR}/aarch64/Packages/c/composer-generators-0.1.2-1.el10_0.noarch.rpm;name=aarch64_composer-generators;unpack=0"
SRC_URI:append = " ${URI_aarch64_composer-generators}"
SRC_URI[aarch64_composer-generators.sha256sum] = "5ed6b54061adda5a02c85fcf2175502b7f551d6e0165ae9d2ae263942dbab1e7"

RDEPENDS:composer-generators = " \
 php-cli \
 "
