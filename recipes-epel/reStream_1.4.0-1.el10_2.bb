# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "reStream"
PV = "1.4.0"
PR = "1.el10_2"
PACKAGES = " \
 reStream \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/reStream-1.4.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0dad900d30096467201368feb175bb99f9fb9681338ca63986479268b755f4d1"

URI_x86_64_v2_reStream = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/reStream-1.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_reStream;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_reStream}"
SRC_URI[x86_64_v2_reStream.sha256sum] = "b4112332cedb7f00847354b0164b20c6ef85d002160ebff55c392df7e6dd7c5d"

URI_aarch64_reStream = "${EPEL_MIRROR}/aarch64/Packages/r/reStream-1.4.0-1.el10_2.noarch.rpm;name=aarch64_reStream;unpack=0"
SRC_URI:append = " ${URI_aarch64_reStream}"
SRC_URI[aarch64_reStream.sha256sum] = "ad99212ea146d9a576e6c0a904e0cdc77d483116a75d403e5b3c650199ae32d3"

RDEPENDS:reStream = " \
 bash \
 ffmpeg-free \
 lz4 \
 openssh-clients \
 "
