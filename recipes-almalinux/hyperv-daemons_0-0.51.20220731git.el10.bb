# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyperv-daemons"
PV = "0"
PR = "0.51.20220731git.el10"
PACKAGES:x86_64_v2 = " \
 hyperv-daemons \
 hyperv-daemons-license \
 hyperv-tools \
 hypervfcopyd \
 hypervkvpd \
 hypervvssd \
"
PACKAGES:aarch64 = " \
 hyperv-daemons \
 hyperv-daemons-license \
 hyperv-tools \
 hypervkvpd \
 hypervvssd \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyperv-daemons-0-0.51.20220731git.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca39d98d0467b5b32450a421d5262315102d7f6c650891b029acd049fb5d68fc"

URI_x86_64_v2_hyperv-daemons = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyperv-daemons-0-0.51.20220731git.el10.x86_64_v2.rpm;name=x86_64_v2_hyperv-daemons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyperv-daemons}"
SRC_URI[x86_64_v2_hyperv-daemons.sha256sum] = "313365e4887a9b761f13a4e02d15d70963211527a1bf68b2b3d339953a20d750"

URI_x86_64_v2_hyperv-daemons-license = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyperv-daemons-license-0-0.51.20220731git.el10.noarch.rpm;name=x86_64_v2_hyperv-daemons-license;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyperv-daemons-license}"
SRC_URI[x86_64_v2_hyperv-daemons-license.sha256sum] = "b1cc228ebf6b0786da28233bcd88440ee928f7937dd6dff43b2e446dd00b71d9"

URI_x86_64_v2_hyperv-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyperv-tools-0-0.51.20220731git.el10.noarch.rpm;name=x86_64_v2_hyperv-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyperv-tools}"
SRC_URI[x86_64_v2_hyperv-tools.sha256sum] = "7aa5ce4a9962e3ad2dff9f2c7e8636af71548b3dcb4db8224355129365633618"

URI_x86_64_v2_hypervfcopyd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hypervfcopyd-0-0.51.20220731git.el10.x86_64_v2.rpm;name=x86_64_v2_hypervfcopyd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hypervfcopyd}"
SRC_URI[x86_64_v2_hypervfcopyd.sha256sum] = "7a468dc532d6930768c770e505df3a202d92f6334f32418cc5b72f07be559e8c"

URI_x86_64_v2_hypervkvpd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hypervkvpd-0-0.51.20220731git.el10.x86_64_v2.rpm;name=x86_64_v2_hypervkvpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hypervkvpd}"
SRC_URI[x86_64_v2_hypervkvpd.sha256sum] = "175bd7467dffa2e5ae0fb9d24765ab142cf4a38d35272cda46a1b88e418ff3f1"

URI_x86_64_v2_hypervvssd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hypervvssd-0-0.51.20220731git.el10.x86_64_v2.rpm;name=x86_64_v2_hypervvssd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hypervvssd}"
SRC_URI[x86_64_v2_hypervvssd.sha256sum] = "1d3ae6025246ffeccd4ac46c19f7e59721c3192a257ec16c86dcec61d084aaf6"

URI_aarch64_hyperv-daemons = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyperv-daemons-0-0.51.20220731git.el10.aarch64.rpm;name=aarch64_hyperv-daemons;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyperv-daemons}"
SRC_URI[aarch64_hyperv-daemons.sha256sum] = "30870201ed66e3e8e048e375953c3e53e450377cad781ababf5282669a2ebe49"

URI_aarch64_hyperv-daemons-license = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyperv-daemons-license-0-0.51.20220731git.el10.noarch.rpm;name=aarch64_hyperv-daemons-license;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyperv-daemons-license}"
SRC_URI[aarch64_hyperv-daemons-license.sha256sum] = "b1cc228ebf6b0786da28233bcd88440ee928f7937dd6dff43b2e446dd00b71d9"

URI_aarch64_hyperv-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyperv-tools-0-0.51.20220731git.el10.noarch.rpm;name=aarch64_hyperv-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyperv-tools}"
SRC_URI[aarch64_hyperv-tools.sha256sum] = "7aa5ce4a9962e3ad2dff9f2c7e8636af71548b3dcb4db8224355129365633618"

URI_aarch64_hypervkvpd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hypervkvpd-0-0.51.20220731git.el10.aarch64.rpm;name=aarch64_hypervkvpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_hypervkvpd}"
SRC_URI[aarch64_hypervkvpd.sha256sum] = "00ca8ff35e6bc2bb2a359af915df7141cb2464133e63d3d186ff7652737e0416"

URI_aarch64_hypervvssd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hypervvssd-0-0.51.20220731git.el10.aarch64.rpm;name=aarch64_hypervvssd;unpack=0"
SRC_URI:append = " ${URI_aarch64_hypervvssd}"
SRC_URI[aarch64_hypervvssd.sha256sum] = "b39b293222dee90f151d1355ccfb329f649ea3183867f5884dec88b8b6e30197"

RDEPENDS:hyperv-daemons:x86_64_v2 = " \
 hypervfcopyd \
 hypervkvpd \
 hypervvssd \
"
RDEPENDS:hyperv-daemons:aarch64 = " \
 hypervkvpd \
 hypervvssd \
"
RDEPENDS:hyperv-daemons-license = " \
 "
RDEPENDS:hyperv-tools = " \
 python3 \
 "
RDEPENDS:hypervfcopyd = " \
 bash \
 glibc \
 hyperv-daemons-license \
 systemd \
 "
RDEPENDS:hypervkvpd = " \
 bash \
 glibc \
 hyperv-daemons-license \
 systemd \
 "
RDEPENDS:hypervvssd = " \
 bash \
 glibc \
 hyperv-daemons-license \
 systemd \
 "
