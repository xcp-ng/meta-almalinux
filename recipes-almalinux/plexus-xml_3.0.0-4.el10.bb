# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plexus-xml"
PV = "3.0.0"
PR = "4.el10"
PACKAGES = " \
 plexus-xml \
 plexus-xml-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/plexus-xml-3.0.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4dc9c8d3764189cdfb442cc7337de4ff842f792d53d485f69c812ef2b8275276"

URI_x86_64_v2_plexus-xml = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/plexus-xml-3.0.0-4.el10.noarch.rpm;name=x86_64_v2_plexus-xml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plexus-xml}"
SRC_URI[x86_64_v2_plexus-xml.sha256sum] = "fcb2531a1bb6b5586a87131ee7326fa477bdc0c80c6f3e05c6478922cd4a535b"

URI_x86_64_v2_plexus-xml-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/plexus-xml-javadoc-3.0.0-4.el10.noarch.rpm;name=x86_64_v2_plexus-xml-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plexus-xml-javadoc}"
SRC_URI[x86_64_v2_plexus-xml-javadoc.sha256sum] = "7a90eeddc2474a193621eb4544a78d3eb70c92e01198f9e27c29afd399aa1f80"

URI_aarch64_plexus-xml = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/plexus-xml-3.0.0-4.el10.noarch.rpm;name=aarch64_plexus-xml;unpack=0"
SRC_URI:append = " ${URI_aarch64_plexus-xml}"
SRC_URI[aarch64_plexus-xml.sha256sum] = "fcb2531a1bb6b5586a87131ee7326fa477bdc0c80c6f3e05c6478922cd4a535b"

URI_aarch64_plexus-xml-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/plexus-xml-javadoc-3.0.0-4.el10.noarch.rpm;name=aarch64_plexus-xml-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_plexus-xml-javadoc}"
SRC_URI[aarch64_plexus-xml-javadoc.sha256sum] = "7a90eeddc2474a193621eb4544a78d3eb70c92e01198f9e27c29afd399aa1f80"

RDEPENDS:plexus-xml = " \
 javapackages-filesystem \
 "
RDEPENDS:plexus-xml-javadoc = " \
 javapackages-filesystem \
 "
