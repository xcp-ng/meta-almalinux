# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-compare"
PV = "0.1.0"
PR = "6.el10_3"
PACKAGES = " \
 rust-compare+default-devel \
 rust-compare-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-compare-0.1.0-6.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3b6f21d7b3c33402c30c193ea410d5091e71e928bbf11680e8c7718253d5e2b"

URI_x86_64_v2_rust-compare+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compare+default-devel-0.1.0-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compare+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compare+default-devel}"
SRC_URI[x86_64_v2_rust-compare+default-devel.sha256sum] = "26849aa984f9c65cad2c2dbe83ae60d39370b21a1c6129f1521adfd0598177e3"

URI_x86_64_v2_rust-compare-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compare-devel-0.1.0-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compare-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compare-devel}"
SRC_URI[x86_64_v2_rust-compare-devel.sha256sum] = "078b84cdd4d99e25ada446b9e564ddd674b74a0a432bef71cc9d87f33f28e3a3"

URI_aarch64_rust-compare+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compare+default-devel-0.1.0-6.el10_3.noarch.rpm;name=aarch64_rust-compare+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compare+default-devel}"
SRC_URI[aarch64_rust-compare+default-devel.sha256sum] = "923abb08b18721f4645b33c00563f02ce10cbd841894387a71dcd77ba7e02fc3"

URI_aarch64_rust-compare-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compare-devel-0.1.0-6.el10_3.noarch.rpm;name=aarch64_rust-compare-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compare-devel}"
SRC_URI[aarch64_rust-compare-devel.sha256sum] = "5a72db2f2332831464585c0106ebae57a048627b30bcc1e7f01734a6f9d7bd9c"

RDEPENDS:rust-compare+default-devel = " \
 cargo \
 rust-compare-devel \
 "
RDEPENDS:rust-compare-devel = " \
 cargo \
 "
