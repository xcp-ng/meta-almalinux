# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "py-radix"
PV = "1.1.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-py-radix \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/py-radix-1.1.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "afe5d3258f1eb8aee0e24803bf7befe2d3e1a8bd5b326f2c9217adb3afc7babd"

URI_x86_64_v2_python3-py-radix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-py-radix-1.1.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-py-radix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-py-radix}"
SRC_URI[x86_64_v2_python3-py-radix.sha256sum] = "dc4b598f7b3c77807e83414a94de9ecbd959a78abf78a8f0ee22c80fcf991921"

URI_aarch64_python3-py-radix = "${EPEL_MIRROR}/aarch64/Packages/p/python3-py-radix-1.1.0-1.el10_1.aarch64.rpm;name=aarch64_python3-py-radix;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-py-radix}"
SRC_URI[aarch64_python3-py-radix.sha256sum] = "09858d7b824269dc08095b61f244da5898d4b976169777c1abd00af6d3d93cb0"

RDEPENDS:python3-py-radix = " \
 glibc \
 python3 \
 "
