# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mockito"
PV = "1.7.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-mockito+color-devel \
 rust-mockito+colored-devel \
 rust-mockito+default-devel \
 rust-mockito+parking_lot-devel \
 rust-mockito-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mockito-1.7.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "03b5468cd77a38293beb6d9eb89375991cd85fb1625b59fb4ef588813927ab72"

URI_x86_64_v2_rust-mockito+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mockito+color-devel-1.7.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mockito+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mockito+color-devel}"
SRC_URI[x86_64_v2_rust-mockito+color-devel.sha256sum] = "2ad94c3d8e870bf8e7b4a1d2d5aaffe79b611e7aca39e4b8520f0b4bef98eb15"

URI_x86_64_v2_rust-mockito+colored-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mockito+colored-devel-1.7.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mockito+colored-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mockito+colored-devel}"
SRC_URI[x86_64_v2_rust-mockito+colored-devel.sha256sum] = "f0979d1b524946152ec48ac897138b46eefb4016d714cfff99055df877d92e33"

URI_x86_64_v2_rust-mockito+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mockito+default-devel-1.7.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mockito+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mockito+default-devel}"
SRC_URI[x86_64_v2_rust-mockito+default-devel.sha256sum] = "cf1630a4b5fff50d5139c38a7225c270834c45fb43267ad29fb18597eeaa359f"

URI_x86_64_v2_rust-mockito+parking_lot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mockito+parking_lot-devel-1.7.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mockito+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mockito+parking_lot-devel}"
SRC_URI[x86_64_v2_rust-mockito+parking_lot-devel.sha256sum] = "8e9cc53b71286d4464f5fd841f8666054a9c65805fcec361aca3aae55138dd0b"

URI_x86_64_v2_rust-mockito-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mockito-devel-1.7.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mockito-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mockito-devel}"
SRC_URI[x86_64_v2_rust-mockito-devel.sha256sum] = "427a54a9d3d84ec39b3cafa7560c99f5c9254ac8f4779698dd2012b1161c8006"

URI_aarch64_rust-mockito+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mockito+color-devel-1.7.2-1.el10_2.noarch.rpm;name=aarch64_rust-mockito+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mockito+color-devel}"
SRC_URI[aarch64_rust-mockito+color-devel.sha256sum] = "a33af15b6c11a952caf289f6c675956ff7d75693428ca48961039eda338af6cf"

URI_aarch64_rust-mockito+colored-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mockito+colored-devel-1.7.2-1.el10_2.noarch.rpm;name=aarch64_rust-mockito+colored-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mockito+colored-devel}"
SRC_URI[aarch64_rust-mockito+colored-devel.sha256sum] = "78ada7909bb54636c026d7e6e7e8ec1489ec26f7418d85cb2ccf98075e03e2f0"

URI_aarch64_rust-mockito+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mockito+default-devel-1.7.2-1.el10_2.noarch.rpm;name=aarch64_rust-mockito+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mockito+default-devel}"
SRC_URI[aarch64_rust-mockito+default-devel.sha256sum] = "54506e559c2588ac1283c2f64b42d9f693771818d4230228fa6a69c6ca239d2c"

URI_aarch64_rust-mockito+parking_lot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mockito+parking_lot-devel-1.7.2-1.el10_2.noarch.rpm;name=aarch64_rust-mockito+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mockito+parking_lot-devel}"
SRC_URI[aarch64_rust-mockito+parking_lot-devel.sha256sum] = "a7dfec078cd03b5e04cf18e38d3f056dec03145a83a222fe9b3ad0c47d7945b5"

URI_aarch64_rust-mockito-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mockito-devel-1.7.2-1.el10_2.noarch.rpm;name=aarch64_rust-mockito-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mockito-devel}"
SRC_URI[aarch64_rust-mockito-devel.sha256sum] = "060eb03ca2854e4e5625ed7f295bd5eddcf5acdb32dab818efaa4245bac66653"

RDEPENDS:rust-mockito+color-devel = " \
 cargo \
 rust-mockito+colored-devel \
 rust-mockito-devel \
 "
RDEPENDS:rust-mockito+colored-devel = " \
 cargo \
 rust-mockito-devel \
 virtual/crate_colored/default__ge_2.0.0_with_crate_colored/default__lt_4.0.0~ \
 "
RDEPENDS:rust-mockito+default-devel = " \
 cargo \
 rust-mockito+color-devel \
 rust-mockito+parking_lot-devel \
 rust-mockito-devel \
 "
RDEPENDS:rust-mockito+parking_lot-devel = " \
 cargo \
 rust-mockito-devel \
 rust-tokio+parking_lot-devel \
 "
RDEPENDS:rust-mockito-devel = " \
 cargo \
 rust \
 rust-assert-json-diff+default-devel \
 rust-bytes+default-devel \
 rust-futures-core+default-devel \
 rust-http+default-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-hyper+default-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+server-auto-devel \
 rust-hyper-util+tokio-devel \
 rust-log+default-devel \
 rust-pin-project-lite+default-devel \
 rust-rand0.9+default-devel \
 rust-regex+default-devel \
 rust-serde_json+default-devel \
 rust-serde_urlencoded+default-devel \
 rust-similar+default-devel \
 rust-tokio+default-devel \
 rust-tokio+net-devel \
 rust-tokio+rt-devel \
 rust-tokio+sync-devel \
 "
