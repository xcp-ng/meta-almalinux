# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "duf"
PV = "0.9.1"
PR = "3.el10_2"
PACKAGES = " \
 duf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/duf-0.9.1-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5297fc3f2f09061737da63010ef13a74b07dd0a5f46dc0fce88ac87902f0b6bd"

URI_x86_64_v2_duf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/duf-0.9.1-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_duf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_duf}"
SRC_URI[x86_64_v2_duf.sha256sum] = "de96722e1fa8b55e5c00596a2f20249e4a9e0891e1ee9538b0ff55c6900eb8ee"

URI_aarch64_duf = "${EPEL_MIRROR}/aarch64/Packages/d/duf-0.9.1-3.el10_2.aarch64.rpm;name=aarch64_duf;unpack=0"
SRC_URI:append = " ${URI_aarch64_duf}"
SRC_URI[aarch64_duf.sha256sum] = "85f6afbbcd87a7502c21e26eebbc7e89dc52083f110a7c8b98447360ec075c0d"

RDEPENDS:duf = " \
 glibc \
 "
