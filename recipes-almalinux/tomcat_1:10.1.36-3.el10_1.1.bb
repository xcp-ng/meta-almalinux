# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tomcat"
PE = "1"
PV = "10.1.36"
PR = "3.el10_1.1"
PACKAGES = " \
 tomcat \
 tomcat-admin-webapps \
 tomcat-docs-webapp \
 tomcat-el-5.0-api \
 tomcat-jsp-3.1-api \
 tomcat-lib \
 tomcat-servlet-6.0-api \
 tomcat-webapps \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tomcat-10.1.36-3.el10_1.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50966116c29ea714ee62518719bab5c058a0304588bb2e9f1cd549db3ca6aa13"

URI_x86_64_v2_tomcat = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat-10.1.36-3.el10_1.1.noarch.rpm;name=x86_64_v2_tomcat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat}"
SRC_URI[x86_64_v2_tomcat.sha256sum] = "07a55d764e26d9e004d70fc379fef7418209de1477face99db96b619960aa7d6"

URI_x86_64_v2_tomcat-admin-webapps = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat-admin-webapps-10.1.36-3.el10_1.1.noarch.rpm;name=x86_64_v2_tomcat-admin-webapps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat-admin-webapps}"
SRC_URI[x86_64_v2_tomcat-admin-webapps.sha256sum] = "21f3f37c3745d8423496c727fcb04f0a8fa2ad26004e198354ce33048b22ba8a"

URI_x86_64_v2_tomcat-docs-webapp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat-docs-webapp-10.1.36-3.el10_1.1.noarch.rpm;name=x86_64_v2_tomcat-docs-webapp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat-docs-webapp}"
SRC_URI[x86_64_v2_tomcat-docs-webapp.sha256sum] = "a860665fa635eac62ac3410f7015395051c79855afd2d87fcbbfed263a2fe7db"

URI_x86_64_v2_tomcat-el-5.0-api = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat-el-5.0-api-10.1.36-3.el10_1.1.noarch.rpm;name=x86_64_v2_tomcat-el-5.0-api;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat-el-5.0-api}"
SRC_URI[x86_64_v2_tomcat-el-5.0-api.sha256sum] = "5a868b537dc45b4c0aadf3689d391d23076c36eef971fc36b61f0280ee5be2e3"

URI_x86_64_v2_tomcat-jsp-3.1-api = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat-jsp-3.1-api-10.1.36-3.el10_1.1.noarch.rpm;name=x86_64_v2_tomcat-jsp-3.1-api;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat-jsp-3.1-api}"
SRC_URI[x86_64_v2_tomcat-jsp-3.1-api.sha256sum] = "01dada388b365d0eb45976174f1471e01a1ee8284359bbcae29bb412878121f5"

URI_x86_64_v2_tomcat-lib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat-lib-10.1.36-3.el10_1.1.noarch.rpm;name=x86_64_v2_tomcat-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat-lib}"
SRC_URI[x86_64_v2_tomcat-lib.sha256sum] = "98d17d674d7a9f674cc2c4b857bce28c7c7b538392c8cb496bdcd26e3de8c761"
RPROVIDES:tomcat-lib:x86_64_v2 = "virtual/mvn_org.apache.tomcat_tomcat-catalina_ virtual/mvn_org.apache.tomcat_tomcat-catalina__ge_9.0.62 virtual/mvn_org.apache.tomcat_tomcat-coyote_ virtual/mvn_org.apache.tomcat_tomcat-coyote__ge_9.0.62 virtual/mvn_org.apache.tomcat_tomcat-juli_ virtual/mvn_org.apache.tomcat_tomcat-juli__ge_9.0.62"

URI_x86_64_v2_tomcat-servlet-6.0-api = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat-servlet-6.0-api-10.1.36-3.el10_1.1.noarch.rpm;name=x86_64_v2_tomcat-servlet-6.0-api;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat-servlet-6.0-api}"
SRC_URI[x86_64_v2_tomcat-servlet-6.0-api.sha256sum] = "29a540da8e70157a499d70f2c3096c7a71c293bf352100e44e8968ff05af0205"

URI_x86_64_v2_tomcat-webapps = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat-webapps-10.1.36-3.el10_1.1.noarch.rpm;name=x86_64_v2_tomcat-webapps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat-webapps}"
SRC_URI[x86_64_v2_tomcat-webapps.sha256sum] = "29dabddd6a274fa0409110a277087f21f2967f7b066c8597e7bddd8dbaba1ab8"

URI_aarch64_tomcat = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat-10.1.36-3.el10_1.1.noarch.rpm;name=aarch64_tomcat;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat}"
SRC_URI[aarch64_tomcat.sha256sum] = "07a55d764e26d9e004d70fc379fef7418209de1477face99db96b619960aa7d6"

URI_aarch64_tomcat-admin-webapps = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat-admin-webapps-10.1.36-3.el10_1.1.noarch.rpm;name=aarch64_tomcat-admin-webapps;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat-admin-webapps}"
SRC_URI[aarch64_tomcat-admin-webapps.sha256sum] = "21f3f37c3745d8423496c727fcb04f0a8fa2ad26004e198354ce33048b22ba8a"

URI_aarch64_tomcat-docs-webapp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat-docs-webapp-10.1.36-3.el10_1.1.noarch.rpm;name=aarch64_tomcat-docs-webapp;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat-docs-webapp}"
SRC_URI[aarch64_tomcat-docs-webapp.sha256sum] = "a860665fa635eac62ac3410f7015395051c79855afd2d87fcbbfed263a2fe7db"

URI_aarch64_tomcat-el-5.0-api = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat-el-5.0-api-10.1.36-3.el10_1.1.noarch.rpm;name=aarch64_tomcat-el-5.0-api;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat-el-5.0-api}"
SRC_URI[aarch64_tomcat-el-5.0-api.sha256sum] = "5a868b537dc45b4c0aadf3689d391d23076c36eef971fc36b61f0280ee5be2e3"

URI_aarch64_tomcat-jsp-3.1-api = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat-jsp-3.1-api-10.1.36-3.el10_1.1.noarch.rpm;name=aarch64_tomcat-jsp-3.1-api;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat-jsp-3.1-api}"
SRC_URI[aarch64_tomcat-jsp-3.1-api.sha256sum] = "01dada388b365d0eb45976174f1471e01a1ee8284359bbcae29bb412878121f5"

URI_aarch64_tomcat-lib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat-lib-10.1.36-3.el10_1.1.noarch.rpm;name=aarch64_tomcat-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat-lib}"
SRC_URI[aarch64_tomcat-lib.sha256sum] = "98d17d674d7a9f674cc2c4b857bce28c7c7b538392c8cb496bdcd26e3de8c761"
RPROVIDES:tomcat-lib:aarch64 = "virtual/mvn_org.apache.tomcat_tomcat-catalina_ virtual/mvn_org.apache.tomcat_tomcat-catalina__ge_9.0.62 virtual/mvn_org.apache.tomcat_tomcat-coyote_ virtual/mvn_org.apache.tomcat_tomcat-coyote__ge_9.0.62 virtual/mvn_org.apache.tomcat_tomcat-juli_ virtual/mvn_org.apache.tomcat_tomcat-juli__ge_9.0.62"

URI_aarch64_tomcat-servlet-6.0-api = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat-servlet-6.0-api-10.1.36-3.el10_1.1.noarch.rpm;name=aarch64_tomcat-servlet-6.0-api;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat-servlet-6.0-api}"
SRC_URI[aarch64_tomcat-servlet-6.0-api.sha256sum] = "29a540da8e70157a499d70f2c3096c7a71c293bf352100e44e8968ff05af0205"

URI_aarch64_tomcat-webapps = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat-webapps-10.1.36-3.el10_1.1.noarch.rpm;name=aarch64_tomcat-webapps;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat-webapps}"
SRC_URI[aarch64_tomcat-webapps.sha256sum] = "29dabddd6a274fa0409110a277087f21f2967f7b066c8597e7bddd8dbaba1ab8"

RDEPENDS:tomcat = " \
 bash \
 java-21-openjdk-headless \
 javapackages-tools \
 shadow-utils \
 systemd \
 tomcat-lib \
 "
RDEPENDS:tomcat-admin-webapps = " \
 tomcat \
 "
RDEPENDS:tomcat-docs-webapp = " \
 tomcat \
 "
RDEPENDS:tomcat-el-5.0-api = " \
 javapackages-filesystem \
 "
RDEPENDS:tomcat-jsp-3.1-api = " \
 javapackages-filesystem \
 tomcat-el-5.0-api \
 tomcat-servlet-6.0-api \
 "
RDEPENDS:tomcat-lib = " \
 ecj \
 javapackages-filesystem \
 tomcat-el-5.0-api \
 tomcat-jsp-3.1-api \
 tomcat-servlet-6.0-api \
 virtual/coreutils \
 "
RDEPENDS:tomcat-servlet-6.0-api = " \
 javapackages-filesystem \
 "
RDEPENDS:tomcat-webapps = " \
 tomcat \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/mvn_org.apache.tomcat_tomcat-catalina_ rpm/virtual/mvn_org.apache.tomcat_tomcat-catalina__ge_9.0.62 rpm/virtual/mvn_org.apache.tomcat_tomcat-coyote_ rpm/virtual/mvn_org.apache.tomcat_tomcat-coyote__ge_9.0.62 rpm/virtual/mvn_org.apache.tomcat_tomcat-juli_ rpm/virtual/mvn_org.apache.tomcat_tomcat-juli__ge_9.0.62"

PROVIDES:append:aarch64 = " rpm/virtual/mvn_org.apache.tomcat_tomcat-catalina_ rpm/virtual/mvn_org.apache.tomcat_tomcat-catalina__ge_9.0.62 rpm/virtual/mvn_org.apache.tomcat_tomcat-coyote_ rpm/virtual/mvn_org.apache.tomcat_tomcat-coyote__ge_9.0.62 rpm/virtual/mvn_org.apache.tomcat_tomcat-juli_ rpm/virtual/mvn_org.apache.tomcat_tomcat-juli__ge_9.0.62"
