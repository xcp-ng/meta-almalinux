# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libavif"
PV = "1.0.4"
PR = "7.el10_0"
PACKAGES = " \
 avif-pixbuf-loader \
 libavif \
 libavif-devel \
 libavif-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libavif-1.0.4-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8e9e6ba456d391540d7a6ff36e959e888f683384f5da61b85d56e3c01d7585a"

URI_x86_64_v2_avif-pixbuf-loader = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/avif-pixbuf-loader-1.0.4-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_avif-pixbuf-loader;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avif-pixbuf-loader}"
SRC_URI[x86_64_v2_avif-pixbuf-loader.sha256sum] = "b90077e50b4a19c6c3a5f6fd69d1292dfb81f791ecf2054d93ad905bc058ac48"

URI_x86_64_v2_libavif = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libavif-1.0.4-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libavif;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libavif}"
SRC_URI[x86_64_v2_libavif.sha256sum] = "ee9436c2c4c5dcc6d20851c3429ec7790f9aad1e10f6264b33e0f995c7321f0a"

URI_x86_64_v2_libavif-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libavif-devel-1.0.4-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libavif-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libavif-devel}"
SRC_URI[x86_64_v2_libavif-devel.sha256sum] = "e866d2bc9f53ae48554b03f08c6949981017a1a849a8b4cfbdd0d28b4ad82bcb"

URI_x86_64_v2_libavif-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libavif-tools-1.0.4-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libavif-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libavif-tools}"
SRC_URI[x86_64_v2_libavif-tools.sha256sum] = "db9a99013dbbc9735a642653b55adb69ee4cb3fa8de985760438febf27bb6b6e"

URI_aarch64_avif-pixbuf-loader = "${EPEL_MIRROR}/aarch64/Packages/a/avif-pixbuf-loader-1.0.4-7.el10_0.aarch64.rpm;name=aarch64_avif-pixbuf-loader;unpack=0"
SRC_URI:append = " ${URI_aarch64_avif-pixbuf-loader}"
SRC_URI[aarch64_avif-pixbuf-loader.sha256sum] = "74e1aa2a4f41eb7c637db44fb0a519ed8d5598fbefc9be9fa7c0342305f93a8d"

URI_aarch64_libavif = "${EPEL_MIRROR}/aarch64/Packages/l/libavif-1.0.4-7.el10_0.aarch64.rpm;name=aarch64_libavif;unpack=0"
SRC_URI:append = " ${URI_aarch64_libavif}"
SRC_URI[aarch64_libavif.sha256sum] = "24166ede8a1fb78bdb0ac1f6acaa9199b5d411118965d08de3ef535d01d6a997"

URI_aarch64_libavif-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libavif-devel-1.0.4-7.el10_0.aarch64.rpm;name=aarch64_libavif-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libavif-devel}"
SRC_URI[aarch64_libavif-devel.sha256sum] = "f0e00fdf8262c69c8fed84bae1ceaa58d5759af04283ce7fc82bd5db7a472647"

URI_aarch64_libavif-tools = "${EPEL_MIRROR}/aarch64/Packages/l/libavif-tools-1.0.4-7.el10_0.aarch64.rpm;name=aarch64_libavif-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libavif-tools}"
SRC_URI[aarch64_libavif-tools.sha256sum] = "6fcf5261f3172acf19e2f455348931e4dca403e95ed5ba1894395d4b530e5a76"

RDEPENDS:avif-pixbuf-loader = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 libavif \
 "
RDEPENDS:libavif = " \
 glibc \
 libaom \
 libdav1d \
 libwebp \
 svt-av1-libs \
 "
RDEPENDS:libavif-devel = " \
 cmake-filesystem \
 libavif \
 pkgconf-pkg-config \
 "
RDEPENDS:libavif-tools = " \
 glibc \
 libavif \
 libjpeg-turbo \
 libpng \
 "
