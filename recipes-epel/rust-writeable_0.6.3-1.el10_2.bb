# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-writeable"
PV = "0.6.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-writeable+alloc-devel \
 rust-writeable+default-devel \
 rust-writeable+either-devel \
 rust-writeable-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-writeable-0.6.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "13edea12173b736779a8535cabeee2d65d008284190b41f90844803f9803ab4b"

URI_x86_64_v2_rust-writeable+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-writeable+alloc-devel-0.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-writeable+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-writeable+alloc-devel}"
SRC_URI[x86_64_v2_rust-writeable+alloc-devel.sha256sum] = "ad058c21f40678ec07049e0b538f42f0235fbd34c7a709a723f3ad1127cc561e"

URI_x86_64_v2_rust-writeable+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-writeable+default-devel-0.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-writeable+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-writeable+default-devel}"
SRC_URI[x86_64_v2_rust-writeable+default-devel.sha256sum] = "21118b930d866483f14fbea8da74543736a517028a7daf9d83f29498e84890ce"

URI_x86_64_v2_rust-writeable+either-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-writeable+either-devel-0.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-writeable+either-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-writeable+either-devel}"
SRC_URI[x86_64_v2_rust-writeable+either-devel.sha256sum] = "403cb455710d5bf4dfe02ce5b5753ef9abfea05b090106495528f8eafb66c84d"

URI_x86_64_v2_rust-writeable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-writeable-devel-0.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-writeable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-writeable-devel}"
SRC_URI[x86_64_v2_rust-writeable-devel.sha256sum] = "bf840cefebfa50fcf5b33af2d307cbd7e221777dce521eb9b450716867eb197d"

URI_aarch64_rust-writeable+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-writeable+alloc-devel-0.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-writeable+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-writeable+alloc-devel}"
SRC_URI[aarch64_rust-writeable+alloc-devel.sha256sum] = "34cca278791f658964674433074312e46588ff4f90b77fb5863809760390bb95"

URI_aarch64_rust-writeable+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-writeable+default-devel-0.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-writeable+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-writeable+default-devel}"
SRC_URI[aarch64_rust-writeable+default-devel.sha256sum] = "3c01a4503f8feca0b6347da134014ae5169dd0dd2634f6411be692970499bfa5"

URI_aarch64_rust-writeable+either-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-writeable+either-devel-0.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-writeable+either-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-writeable+either-devel}"
SRC_URI[aarch64_rust-writeable+either-devel.sha256sum] = "46ed4e5cd73a80db5d2009e08ccc0733d3832269dcbce74323b3f157e0553a94"

URI_aarch64_rust-writeable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-writeable-devel-0.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-writeable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-writeable-devel}"
SRC_URI[aarch64_rust-writeable-devel.sha256sum] = "2fa10ebf242abb8e24432050a3fa90b29bfbb84ba9bb9bb603b300aa10b40c0c"

RDEPENDS:rust-writeable+alloc-devel = " \
 cargo \
 rust-writeable-devel \
 "
RDEPENDS:rust-writeable+default-devel = " \
 cargo \
 rust-writeable+alloc-devel \
 rust-writeable-devel \
 "
RDEPENDS:rust-writeable+either-devel = " \
 cargo \
 rust-either-devel \
 rust-writeable-devel \
 "
RDEPENDS:rust-writeable-devel = " \
 cargo \
 rust \
 "
