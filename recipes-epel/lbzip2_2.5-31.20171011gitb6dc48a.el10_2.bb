# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lbzip2"
PV = "2.5"
PR = "31.20171011gitb6dc48a.el10_2"
PACKAGES = " \
 lbzip2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lbzip2-2.5-31.20171011gitb6dc48a.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f1d292dfa71867dc549d0f4416954f1b1848474209f3b59258d3c239e6d0b74b"

URI_x86_64_v2_lbzip2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lbzip2-2.5-31.20171011gitb6dc48a.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lbzip2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lbzip2}"
SRC_URI[x86_64_v2_lbzip2.sha256sum] = "cc1029810f50565a6ed705dca856b9b2a7b0195aa01f36443390d0017c4e524d"

URI_aarch64_lbzip2 = "${EPEL_MIRROR}/aarch64/Packages/l/lbzip2-2.5-31.20171011gitb6dc48a.el10_2.aarch64.rpm;name=aarch64_lbzip2;unpack=0"
SRC_URI:append = " ${URI_aarch64_lbzip2}"
SRC_URI[aarch64_lbzip2.sha256sum] = "f5de7643bb2ce4105f3d958bc4a48ab6c3fc1211d2ec1cca69ded67c17b48094"

RDEPENDS:lbzip2 = " \
 glibc \
 "
