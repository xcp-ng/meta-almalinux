# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-IO-Socket-Multicast"
PV = "1.12"
PR = "29.el10_0"
PACKAGES = " \
 perl-IO-Socket-Multicast \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-IO-Socket-Multicast-1.12-29.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6ee6ce703c92989ba78ecf153998d560383d064e577b009ca2052aa43f52ffc5"

URI_x86_64_v2_perl-IO-Socket-Multicast = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-IO-Socket-Multicast-1.12-29.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-IO-Socket-Multicast;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-IO-Socket-Multicast}"
SRC_URI[x86_64_v2_perl-IO-Socket-Multicast.sha256sum] = "08be0a2b5a6b34c1a6137ccf5ea3843ebf84f3369f6836572fe4f6fd604c9f1c"

URI_aarch64_perl-IO-Socket-Multicast = "${EPEL_MIRROR}/aarch64/Packages/p/perl-IO-Socket-Multicast-1.12-29.el10_0.aarch64.rpm;name=aarch64_perl-IO-Socket-Multicast;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-IO-Socket-Multicast}"
SRC_URI[aarch64_perl-IO-Socket-Multicast.sha256sum] = "cca0239f1116db0e56f5e61af6f2aa49b6482870ee05ff52eeff7649516db6e4"

RDEPENDS:perl-IO-Socket-Multicast = " \
 glibc \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-IO \
 perl-IO-Interface \
 perl-libs \
 perl-vars \
 "
