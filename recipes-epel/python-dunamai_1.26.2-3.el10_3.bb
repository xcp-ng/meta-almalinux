# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-dunamai"
PV = "1.26.2"
PR = "3.el10_3"
PACKAGES = " \
 python3-dunamai \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-dunamai-1.26.2-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6a9662544493c2e0178f14650d819453fae9edd0d0886dcba55f43f5d7e29abc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-dunamai-1.26.2-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-dunamai;unpack=0"
SRC_URI[x86_64_v2_python3-dunamai.sha256sum] = "95cb5d56975be19291d0fe349f925ac5b38d35b4396b26b2eac9c6c45a1cb525"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-dunamai-1.26.2-3.el10_3.noarch.rpm;name=aarch64_python3-dunamai;unpack=0"
SRC_URI[aarch64_python3-dunamai.sha256sum] = "290e4098c9807d5679a8201f64bd4d13534d15c97800218837fc342c98e82b13"

RDEPENDS:python3-dunamai = " \
 python3 \
 python3-packaging \
 "
