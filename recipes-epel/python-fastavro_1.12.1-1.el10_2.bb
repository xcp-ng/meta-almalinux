# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-fastavro"
PV = "1.12.1"
PR = "1.el10_2"
PACKAGES = " \
 python-fastavro-doc \
 python3-fastavro \
 python3-fastavro+codecs \
 python3-fastavro+lz4 \
 python3-fastavro+snappy \
 python3-fastavro+zstandard \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-fastavro-1.12.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ec4e668532cf4a6643e50a3c49b6b660c3f978687fedd90ac3b493a3a4580e9"

URI_x86_64_v2_python-fastavro-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-fastavro-doc-1.12.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python-fastavro-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-fastavro-doc}"
SRC_URI[x86_64_v2_python-fastavro-doc.sha256sum] = "b8d079452de8103ba6cd85da42f9965d2ee8a13dac80256b24e0604be62c50f8"

URI_x86_64_v2_python3-fastavro = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fastavro-1.12.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-fastavro;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fastavro}"
SRC_URI[x86_64_v2_python3-fastavro.sha256sum] = "9e73c4002b807b2259e59e9cbd71ca95c41b60a387d4780e960d064dfd100036"

URI_x86_64_v2_python3-fastavro+codecs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fastavro+codecs-1.12.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-fastavro+codecs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fastavro+codecs}"
SRC_URI[x86_64_v2_python3-fastavro+codecs.sha256sum] = "d10612eac1f441353005795f98df48372ab59c2368b7a8eedbde6c9682c91150"

URI_x86_64_v2_python3-fastavro+lz4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fastavro+lz4-1.12.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-fastavro+lz4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fastavro+lz4}"
SRC_URI[x86_64_v2_python3-fastavro+lz4.sha256sum] = "12214029907aaa77f3ada6c3129831ff7ffcfb860bf0c8cbb31d4a9801c7b4c0"

URI_x86_64_v2_python3-fastavro+snappy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fastavro+snappy-1.12.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-fastavro+snappy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fastavro+snappy}"
SRC_URI[x86_64_v2_python3-fastavro+snappy.sha256sum] = "2bc8dd34c71ca4b2d8d74327a3c5a7f61eabd5912c69f4e5be7810764650d0c4"

URI_x86_64_v2_python3-fastavro+zstandard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fastavro+zstandard-1.12.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-fastavro+zstandard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fastavro+zstandard}"
SRC_URI[x86_64_v2_python3-fastavro+zstandard.sha256sum] = "494a05022d4e1d38b5bbcc83d3f4aae800bbf38d132ec4d414fe302b633a8290"

URI_aarch64_python-fastavro-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-fastavro-doc-1.12.1-1.el10_2.aarch64.rpm;name=aarch64_python-fastavro-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-fastavro-doc}"
SRC_URI[aarch64_python-fastavro-doc.sha256sum] = "fa840b08c32eb417b1f2cc14a8b0686f3c9e08d41c9b7339ac5614088fdf8204"

URI_aarch64_python3-fastavro = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fastavro-1.12.1-1.el10_2.aarch64.rpm;name=aarch64_python3-fastavro;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fastavro}"
SRC_URI[aarch64_python3-fastavro.sha256sum] = "9a4883117548b556a8d775d4b387b0c16b2400af9d6f03b59d26dbb60adee72d"

URI_aarch64_python3-fastavro+codecs = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fastavro+codecs-1.12.1-1.el10_2.aarch64.rpm;name=aarch64_python3-fastavro+codecs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fastavro+codecs}"
SRC_URI[aarch64_python3-fastavro+codecs.sha256sum] = "1570c411acf21fa0828cdf04cfbb60c0bf62da6f9a6093566ce5a36d1931302b"

URI_aarch64_python3-fastavro+lz4 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fastavro+lz4-1.12.1-1.el10_2.aarch64.rpm;name=aarch64_python3-fastavro+lz4;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fastavro+lz4}"
SRC_URI[aarch64_python3-fastavro+lz4.sha256sum] = "fe8a88ee29cabed594dc225ae2ddfce3b02af0e1e28822d60d595671d91d37a0"

URI_aarch64_python3-fastavro+snappy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fastavro+snappy-1.12.1-1.el10_2.aarch64.rpm;name=aarch64_python3-fastavro+snappy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fastavro+snappy}"
SRC_URI[aarch64_python3-fastavro+snappy.sha256sum] = "2b61a2cc2b07f81a745946f2585c64c451b7e04890096747b8099c34f7a8aadd"

URI_aarch64_python3-fastavro+zstandard = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fastavro+zstandard-1.12.1-1.el10_2.aarch64.rpm;name=aarch64_python3-fastavro+zstandard;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fastavro+zstandard}"
SRC_URI[aarch64_python3-fastavro+zstandard.sha256sum] = "2a7d3558b45d97ec8af127d4b778aa0060f075dac4b41462698bb69526666f42"

RDEPENDS:python-fastavro-doc = " \
 "
RDEPENDS:python3-fastavro = " \
 glibc \
 python3 \
 "
RDEPENDS:python3-fastavro+codecs = " \
 python3 \
 python3-cramjam \
 python3-fastavro \
 python3-lz4 \
 python3-zstandard \
 "
RDEPENDS:python3-fastavro+lz4 = " \
 python3 \
 python3-fastavro \
 python3-lz4 \
 "
RDEPENDS:python3-fastavro+snappy = " \
 python3 \
 python3-cramjam \
 python3-fastavro \
 "
RDEPENDS:python3-fastavro+zstandard = " \
 python3 \
 python3-fastavro \
 python3-zstandard \
 "
