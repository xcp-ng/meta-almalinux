# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qttools"
PV = "5.15.18"
PR = "2.el10_3"
PACKAGES = " \
 qt5-assistant \
 qt5-designer \
 qt5-doctools \
 qt5-linguist \
 qt5-qdbusviewer \
 qt5-qttools \
 qt5-qttools-common \
 qt5-qttools-devel \
 qt5-qttools-examples \
 qt5-qttools-libs-designer \
 qt5-qttools-libs-designercomponents \
 qt5-qttools-libs-help \
 qt5-qttools-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qttools-5.15.18-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "afee89c94bed24f74a217ac7f7306101c6b44a23bbc348733fafd0d52fe1602e"

URI_x86_64_v2_qt5-assistant = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-assistant-5.15.18-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-assistant;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-assistant}"
SRC_URI[x86_64_v2_qt5-assistant.sha256sum] = "c6484ecce32699f93ae412badc09d764db8f2dfa98bd44fda9f36cf7d99ff5eb"

URI_x86_64_v2_qt5-designer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-designer-5.15.18-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-designer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-designer}"
SRC_URI[x86_64_v2_qt5-designer.sha256sum] = "5f74581d925bb151f1e85688ae94a0023773954a0d1ec9555e5b8fae36395ab7"

URI_x86_64_v2_qt5-doctools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-doctools-5.15.18-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-doctools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-doctools}"
SRC_URI[x86_64_v2_qt5-doctools.sha256sum] = "23f786002d34b1777e730bf42f0d26ce3b03148b5ab13057424c82a73e3277f5"

URI_x86_64_v2_qt5-linguist = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-linguist-5.15.18-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-linguist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-linguist}"
SRC_URI[x86_64_v2_qt5-linguist.sha256sum] = "c680165224068b52018de2369c9beaed0f8e65119741690f39d29a2e901dc097"

URI_x86_64_v2_qt5-qdbusviewer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qdbusviewer-5.15.18-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qdbusviewer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qdbusviewer}"
SRC_URI[x86_64_v2_qt5-qdbusviewer.sha256sum] = "3a4afef95489022b9cd81267508003a62bdf835873f9b9d16d34365fb6da27b4"

URI_x86_64_v2_qt5-qttools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-5.15.18-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qttools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qttools}"
SRC_URI[x86_64_v2_qt5-qttools.sha256sum] = "bee9b4ec077fec3da7786b136b40e311652aa0183bced24d2715b8e9df651eea"

URI_x86_64_v2_qt5-qttools-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-common-5.15.18-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qttools-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qttools-common}"
SRC_URI[x86_64_v2_qt5-qttools-common.sha256sum] = "71f802c06e88b2fde5d414ba44bf43a59e96eeea897eabb00e727dbd2daaf9c9"

URI_x86_64_v2_qt5-qttools-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-devel-5.15.18-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qttools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qttools-devel}"
SRC_URI[x86_64_v2_qt5-qttools-devel.sha256sum] = "65e9d235d5a2c9b5b93ebdd39a008e50c0df91faba84e40abc4050accbfb71ec"

URI_x86_64_v2_qt5-qttools-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-examples-5.15.18-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qttools-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qttools-examples}"
SRC_URI[x86_64_v2_qt5-qttools-examples.sha256sum] = "a207928e6af6581a3810691b4e67cad5276cd60a172acefe1176726aba02dcef"

URI_x86_64_v2_qt5-qttools-libs-designer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-libs-designer-5.15.18-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qttools-libs-designer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qttools-libs-designer}"
SRC_URI[x86_64_v2_qt5-qttools-libs-designer.sha256sum] = "39222715d1bd15367aee493a65982a3c81ee2add821efa33f870a28c107fe1d7"

URI_x86_64_v2_qt5-qttools-libs-designercomponents = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-libs-designercomponents-5.15.18-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qttools-libs-designercomponents;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qttools-libs-designercomponents}"
SRC_URI[x86_64_v2_qt5-qttools-libs-designercomponents.sha256sum] = "f8aeabd3baad4f55b7237ace5f7830371b262cade90ffef0bc616a9553e2b389"

URI_x86_64_v2_qt5-qttools-libs-help = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-libs-help-5.15.18-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qttools-libs-help;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qttools-libs-help}"
SRC_URI[x86_64_v2_qt5-qttools-libs-help.sha256sum] = "a2d5bc2ae0666d34abbf89134c1960367a83fa4a3f39a71e9954397fde2e2a25"

URI_x86_64_v2_qt5-qttools-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-static-5.15.18-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qttools-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qttools-static}"
SRC_URI[x86_64_v2_qt5-qttools-static.sha256sum] = "da6823912d645f438aafe9c1a03ee7b86a147831b9587143b66c02d9ca90679f"

URI_aarch64_qt5-assistant = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-assistant-5.15.18-2.el10_3.aarch64.rpm;name=aarch64_qt5-assistant;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-assistant}"
SRC_URI[aarch64_qt5-assistant.sha256sum] = "fd2ec0ebdbd9676c9cc21ff3056c598f98c6b27fba2283a4b45f6726d6137eb5"

URI_aarch64_qt5-designer = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-designer-5.15.18-2.el10_3.aarch64.rpm;name=aarch64_qt5-designer;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-designer}"
SRC_URI[aarch64_qt5-designer.sha256sum] = "b1034e2e7857cefa52f3f4e80752c20fce430c8b0f5f3cd9bd0ae9a58d2e0044"

URI_aarch64_qt5-doctools = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-doctools-5.15.18-2.el10_3.aarch64.rpm;name=aarch64_qt5-doctools;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-doctools}"
SRC_URI[aarch64_qt5-doctools.sha256sum] = "09900792ae040a8d7336152e504219ad222995129d063dc22a8352d3b44896e2"

URI_aarch64_qt5-linguist = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-linguist-5.15.18-2.el10_3.aarch64.rpm;name=aarch64_qt5-linguist;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-linguist}"
SRC_URI[aarch64_qt5-linguist.sha256sum] = "ab07f7db6f817c321e3a555f2e74fd2e82f85cfc7cab40b9279cd80ea84563ed"

URI_aarch64_qt5-qdbusviewer = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qdbusviewer-5.15.18-2.el10_3.aarch64.rpm;name=aarch64_qt5-qdbusviewer;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qdbusviewer}"
SRC_URI[aarch64_qt5-qdbusviewer.sha256sum] = "56166e41a125e164f58dd829625526aacbdacb0683760d70a5d85cf830012de1"

URI_aarch64_qt5-qttools = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-5.15.18-2.el10_3.aarch64.rpm;name=aarch64_qt5-qttools;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qttools}"
SRC_URI[aarch64_qt5-qttools.sha256sum] = "4bb1e6d2214d3343c2383b6ceb71c88f0f6e51867ed674291738ee575baaf15d"

URI_aarch64_qt5-qttools-common = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-common-5.15.18-2.el10_3.noarch.rpm;name=aarch64_qt5-qttools-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qttools-common}"
SRC_URI[aarch64_qt5-qttools-common.sha256sum] = "03643369b38cc8456bff5dd7bc97ea1e1cb7e8393ae8377a14fa249252378bb9"

URI_aarch64_qt5-qttools-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-devel-5.15.18-2.el10_3.aarch64.rpm;name=aarch64_qt5-qttools-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qttools-devel}"
SRC_URI[aarch64_qt5-qttools-devel.sha256sum] = "8f6aed287e4351fe9dbc79f99cc85c5941c26c849cc5f658a84cb92177eada52"

URI_aarch64_qt5-qttools-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-examples-5.15.18-2.el10_3.aarch64.rpm;name=aarch64_qt5-qttools-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qttools-examples}"
SRC_URI[aarch64_qt5-qttools-examples.sha256sum] = "7b0ed0946d7dc7e3c429fdf83f576f3885b57a352c998416c3bc7974e542d2e4"

URI_aarch64_qt5-qttools-libs-designer = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-libs-designer-5.15.18-2.el10_3.aarch64.rpm;name=aarch64_qt5-qttools-libs-designer;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qttools-libs-designer}"
SRC_URI[aarch64_qt5-qttools-libs-designer.sha256sum] = "599c12c38c686847a0308a4742437bc5564c3ce26f93301c679f62820ffb5245"

URI_aarch64_qt5-qttools-libs-designercomponents = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-libs-designercomponents-5.15.18-2.el10_3.aarch64.rpm;name=aarch64_qt5-qttools-libs-designercomponents;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qttools-libs-designercomponents}"
SRC_URI[aarch64_qt5-qttools-libs-designercomponents.sha256sum] = "dae6556d37fd7673a1e012fd6e19dcecb91a64aea43bda3b082a57d71774ed15"

URI_aarch64_qt5-qttools-libs-help = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-libs-help-5.15.18-2.el10_3.aarch64.rpm;name=aarch64_qt5-qttools-libs-help;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qttools-libs-help}"
SRC_URI[aarch64_qt5-qttools-libs-help.sha256sum] = "4673bddfda588d545f1c94b4f0a93bfe4445f1a9d3334299ebe9de04b1d602c8"

URI_aarch64_qt5-qttools-static = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-static-5.15.18-2.el10_3.aarch64.rpm;name=aarch64_qt5-qttools-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qttools-static}"
SRC_URI[aarch64_qt5-qttools-static.sha256sum] = "7556f3db58012e53fda32850fc4e39c34ab34694d68a6b0171e5125e91ff527f"

RDEPENDS:qt5-assistant = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qttools-common \
 qt5-qttools-libs-help \
 "
RDEPENDS:qt5-designer = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qttools-libs-designer \
 qt5-qttools-libs-designercomponents \
 "
RDEPENDS:qt5-doctools:x86_64_v2 = " \
 clang-libs \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qttools-libs-help \
"
RDEPENDS:qt5-doctools:aarch64 = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qttools-libs-help \
 virtual/libclang.so.21.1_LLVM_13__64bit_ \
 virtual/libclang.so.21.1___64bit_ \
"
RDEPENDS:qt5-linguist = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qttools-common \
 "
RDEPENDS:qt5-qdbusviewer = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qttools-common \
 "
RDEPENDS:qt5-qttools = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qttools-common \
 "
RDEPENDS:qt5-qttools-common = " \
 "
RDEPENDS:qt5-qttools-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt5-designer \
 qt5-doctools \
 qt5-linguist \
 qt5-qtbase \
 qt5-qtbase-devel \
 qt5-qtbase-gui \
 qt5-qttools \
 qt5-qttools-libs-designer \
 qt5-qttools-libs-designercomponents \
 qt5-qttools-libs-help \
 "
RDEPENDS:qt5-qttools-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qttools-common \
 qt5-qttools-libs-designer \
 qt5-qttools-libs-help \
 "
RDEPENDS:qt5-qttools-libs-designer = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qttools-common \
 "
RDEPENDS:qt5-qttools-libs-designercomponents = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qttools-common \
 qt5-qttools-libs-designer \
 "
RDEPENDS:qt5-qttools-libs-help = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qttools-common \
 "
RDEPENDS:qt5-qttools-static = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qttools-devel \
 "
