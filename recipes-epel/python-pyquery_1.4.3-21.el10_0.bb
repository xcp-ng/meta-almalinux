# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyquery"
PV = "1.4.3"
PR = "21.el10_0"
PACKAGES = " \
 python3-pyquery \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyquery-1.4.3-21.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78fb5c5014c9286a0e9fbc61fce6a8189ab83439ef37b31381b5a03dbd9083fc"

URI_x86_64_v2_python3-pyquery = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyquery-1.4.3-21.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pyquery;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyquery}"
SRC_URI[x86_64_v2_python3-pyquery.sha256sum] = "7e7853a1da60263e698f8acc639853498046f21df0eb47be5b9f143103a98316"

URI_aarch64_python3-pyquery = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyquery-1.4.3-21.el10_0.noarch.rpm;name=aarch64_python3-pyquery;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyquery}"
SRC_URI[aarch64_python3-pyquery.sha256sum] = "1ec173da5294b7d9d53b72d3d6add88cd222ed8a96977bbdb43566f6ab1dafd5"

RDEPENDS:python3-pyquery = " \
 python3 \
 python3-cssselect \
 python3-lxml \
 "
