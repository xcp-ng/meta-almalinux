# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-strum_macros"
PV = "0.26.4"
PR = "2.el10_0"
PACKAGES = " \
 rust-strum_macros+default-devel \
 rust-strum_macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-strum_macros-0.26.4-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ecd1f32d4127d98edbca345b9442dba4cd91e4c8d78ad0e14cd930d2e9549e85"

URI_x86_64_v2_rust-strum_macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum_macros+default-devel-0.26.4-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum_macros+default-devel}"
SRC_URI[x86_64_v2_rust-strum_macros+default-devel.sha256sum] = "6dc3039dcbe405de0e1251277f0dad1f696372ec819d0eab6340015934546c61"

URI_x86_64_v2_rust-strum_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum_macros-devel-0.26.4-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum_macros-devel}"
SRC_URI[x86_64_v2_rust-strum_macros-devel.sha256sum] = "c1f7caeb9b75fb4f672d8afcee6f5359c6e0a33550447125d6d753920e63fb83"

URI_aarch64_rust-strum_macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum_macros+default-devel-0.26.4-2.el10_0.noarch.rpm;name=aarch64_rust-strum_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum_macros+default-devel}"
SRC_URI[aarch64_rust-strum_macros+default-devel.sha256sum] = "4d3c5d20240858f1901d3dd449aedb1f6fe5c0fb6e0f8baf7e056bc45a8a3209"

URI_aarch64_rust-strum_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum_macros-devel-0.26.4-2.el10_0.noarch.rpm;name=aarch64_rust-strum_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum_macros-devel}"
SRC_URI[aarch64_rust-strum_macros-devel.sha256sum] = "3c10e0d32630608045f7ab6a1dcda7ee5e16bab1b60935d6250e9e4c122c5ec5"

RDEPENDS:rust-strum_macros+default-devel = " \
 cargo \
 rust-strum_macros-devel \
 "
RDEPENDS:rust-strum_macros-devel = " \
 cargo \
 rust-heck+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-rustversion+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+parsing-devel \
 "
