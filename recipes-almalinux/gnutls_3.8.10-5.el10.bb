# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnutls"
PV = "3.8.10"
PR = "5.el10"
PACKAGES = " \
 gnutls \
 gnutls-c++ \
 gnutls-dane \
 gnutls-devel \
 gnutls-fips \
 gnutls-utils \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/gnutls-3.8.10-5.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ea8d55ab48de9cbcc7b16970f538f35fdcf943eebf9d3b41a56bae7bed6bb47a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/gnutls-3.8.10-5.el10.x86_64_v2.rpm;name=x86_64_v2_gnutls;unpack=0"
SRC_URI[x86_64_v2_gnutls.sha256sum] = "59a0f09d7937f2c51f60ee229e7dc5b810b0a50599207e9f94f4201b1e47f6c4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnutls-c++-3.8.10-5.el10.x86_64_v2.rpm;name=x86_64_v2_gnutls-c++;unpack=0"
SRC_URI[x86_64_v2_gnutls-c++.sha256sum] = "c897f9a8169d390565c64148763bf5d164c6d0b3ecda218df5b76e14419fc721"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnutls-dane-3.8.10-5.el10.x86_64_v2.rpm;name=x86_64_v2_gnutls-dane;unpack=0"
SRC_URI[x86_64_v2_gnutls-dane.sha256sum] = "6fa1c699a4be352d32da00a051db88498645afad1d09e4399ca85a3c3e82c0cf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnutls-devel-3.8.10-5.el10.x86_64_v2.rpm;name=x86_64_v2_gnutls-devel;unpack=0"
SRC_URI[x86_64_v2_gnutls-devel.sha256sum] = "17d94cd6998a8b2ca29540af1779372f320ceeff7414af367fee558eb9ac224e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnutls-fips-3.8.10-5.el10.x86_64_v2.rpm;name=x86_64_v2_gnutls-fips;unpack=0"
SRC_URI[x86_64_v2_gnutls-fips.sha256sum] = "f92aebf53a1119b60e428dc8435ccfde559ab3104307bbe5f15bab32ea520d3d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnutls-utils-3.8.10-5.el10.x86_64_v2.rpm;name=x86_64_v2_gnutls-utils;unpack=0"
SRC_URI[x86_64_v2_gnutls-utils.sha256sum] = "e9feb155ae40f46eadf58fdd47b28184fb911b3de5605ae66b3e63706b2eed48"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/gnutls-3.8.10-5.el10.aarch64.rpm;name=aarch64_gnutls;unpack=0"
SRC_URI[aarch64_gnutls.sha256sum] = "65e463c1781b6ed3435fb19337a09203bf836f0a970ed81189c3b562d7206529"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnutls-c++-3.8.10-5.el10.aarch64.rpm;name=aarch64_gnutls-c++;unpack=0"
SRC_URI[aarch64_gnutls-c++.sha256sum] = "03bc8bfe60e958071d79ed9c0b8697f2e203851fb9d87ac140968efaa16fca70"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnutls-dane-3.8.10-5.el10.aarch64.rpm;name=aarch64_gnutls-dane;unpack=0"
SRC_URI[aarch64_gnutls-dane.sha256sum] = "446c23c7ae58f7c60ade7d156c6dc45df494f4af6c51636bbb949f566585f6d2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnutls-devel-3.8.10-5.el10.aarch64.rpm;name=aarch64_gnutls-devel;unpack=0"
SRC_URI[aarch64_gnutls-devel.sha256sum] = "52204b313493ad3091d566c4b4c7d1a3f2e9082f700c7983fbc2451a5813a70a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnutls-fips-3.8.10-5.el10.aarch64.rpm;name=aarch64_gnutls-fips;unpack=0"
SRC_URI[aarch64_gnutls-fips.sha256sum] = "17008435ad05be3d53fdb56a704020932309445e10bd9a4a7c375ed7fce7d23d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnutls-utils-3.8.10-5.el10.aarch64.rpm;name=aarch64_gnutls-utils;unpack=0"
SRC_URI[aarch64_gnutls-utils.sha256sum] = "aa7e798a1a4a3d763e6b08a2a6521905a484b73429adc5549d6cd33428bf7c32"

RDEPENDS:gnutls = " \
 crypto-policies \
 glibc \
 libidn2 \
 libtasn1 \
 libunistring \
 p11-kit \
 p11-kit-trust \
 "
RDEPENDS:gnutls-c++ = " \
 glibc \
 gnutls \
 libgcc \
 libidn2 \
 libstdc++ \
 libtasn1 \
 libunistring \
 p11-kit \
 "
RDEPENDS:gnutls-dane = " \
 glibc \
 gnutls \
 libidn2 \
 libtasn1 \
 libunistring \
 p11-kit \
 unbound-libs \
 "
RDEPENDS:gnutls-devel = " \
 gnutls \
 gnutls-c++ \
 gnutls-dane \
 gnutls-devel \
 libidn2-devel \
 libtasn1-devel \
 p11-kit-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:gnutls-fips = " \
 gnutls \
 "
RDEPENDS:gnutls-utils = " \
 glibc \
 gnutls \
 gnutls-dane \
 libtasn1 \
 "
