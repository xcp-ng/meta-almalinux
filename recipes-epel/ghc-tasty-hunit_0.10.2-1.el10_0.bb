# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-tasty-hunit"
PV = "0.10.2"
PR = "1.el10_0"
PACKAGES = " \
 ghc-tasty-hunit \
 ghc-tasty-hunit-devel \
 ghc-tasty-hunit-doc \
 ghc-tasty-hunit-prof \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/ghc-tasty-hunit-0.10.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d91f72e1ac316acf47043dcd1dbeaa9ea7d10f3358d235377da00e9c80d1125d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tasty-hunit-0.10.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tasty-hunit;unpack=0"
SRC_URI[x86_64_v2_ghc-tasty-hunit.sha256sum] = "9c039ecaa662dfeddb1b6469785a0c9089f5ddd849ca311bf8efdb4912386cb8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tasty-hunit-devel-0.10.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tasty-hunit-devel;unpack=0"
SRC_URI[x86_64_v2_ghc-tasty-hunit-devel.sha256sum] = "0278d1394ccf43c12eb7700d8c38c15a60c2858fd0afc6fa1d239d08b1b1a545"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tasty-hunit-doc-0.10.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-tasty-hunit-doc;unpack=0"
SRC_URI[x86_64_v2_ghc-tasty-hunit-doc.sha256sum] = "b24e5a56909c3069b0388ea162c898f29ead5ba7945f2dd21e589ecd247437b8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tasty-hunit-prof-0.10.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tasty-hunit-prof;unpack=0"
SRC_URI[x86_64_v2_ghc-tasty-hunit-prof.sha256sum] = "4966013d95740777b54340dcae153723e37b1a7734afbf2933fb97f88b157226"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-tasty-hunit-0.10.2-1.el10_0.aarch64.rpm;name=aarch64_ghc-tasty-hunit;unpack=0"
SRC_URI[aarch64_ghc-tasty-hunit.sha256sum] = "3c8020f893935c157fb79a29ccee2d0ebb27cc12aa0570e213935abc0691782c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-tasty-hunit-devel-0.10.2-1.el10_0.aarch64.rpm;name=aarch64_ghc-tasty-hunit-devel;unpack=0"
SRC_URI[aarch64_ghc-tasty-hunit-devel.sha256sum] = "3d1d446009df751f64a2d72294fa81998ed8c26b54de00824fb687a14910af9f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-tasty-hunit-doc-0.10.2-1.el10_0.noarch.rpm;name=aarch64_ghc-tasty-hunit-doc;unpack=0"
SRC_URI[aarch64_ghc-tasty-hunit-doc.sha256sum] = "71cd3322509249b7258210bbe1a220cde7d5683bdb3b365fbab1c464dc89e3d4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-tasty-hunit-prof-0.10.2-1.el10_0.aarch64.rpm;name=aarch64_ghc-tasty-hunit-prof;unpack=0"
SRC_URI[aarch64_ghc-tasty-hunit-prof.sha256sum] = "defe4189393d74ac70ab6b1f882f16fd63014352844713ae1989a6d24eb116a1"

RDEPENDS:ghc-tasty-hunit = " \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-call-stack \
 ghc-colour \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-optparse-applicative \
 ghc-pretty \
 ghc-prettyprinter \
 ghc-prettyprinter-ansi-terminal \
 ghc-process \
 ghc-stm \
 ghc-tagged \
 ghc-tasty \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-tasty-hunit-devel = " \
 ghc-base-devel \
 ghc-call-stack-devel \
 ghc-compiler \
 ghc-tasty-devel \
 ghc-tasty-hunit \
 "
RDEPENDS:ghc-tasty-hunit-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-tasty-hunit-prof = " \
 ghc-base-prof \
 ghc-call-stack-prof \
 ghc-tasty-hunit-devel \
 ghc-tasty-prof \
 "
