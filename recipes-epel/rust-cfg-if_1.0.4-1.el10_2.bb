# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cfg-if"
PV = "1.0.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-cfg-if+default-devel \
 rust-cfg-if-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cfg-if-1.0.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7fb372e39ceb758e9e92315a6b94888872cfb9e222b189bff154ca0bf048ca3"

URI_x86_64_v2_rust-cfg-if+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg-if+default-devel-1.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg-if+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfg-if+default-devel}"
SRC_URI[x86_64_v2_rust-cfg-if+default-devel.sha256sum] = "d4a77ba8647570e605997595b62a6b58c8b4212219ce6214079a795bcf5e4d4f"

URI_x86_64_v2_rust-cfg-if-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg-if-devel-1.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg-if-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfg-if-devel}"
SRC_URI[x86_64_v2_rust-cfg-if-devel.sha256sum] = "f7196c2131b6174c36151be203b1c53e394ed977c9f305fa3a149b14576dd426"

URI_aarch64_rust-cfg-if+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg-if+default-devel-1.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-cfg-if+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfg-if+default-devel}"
SRC_URI[aarch64_rust-cfg-if+default-devel.sha256sum] = "7f39999cfc6d99c943e0d092be7427c2d68544ddf1fbd3bbf23faaa6a3411c59"

URI_aarch64_rust-cfg-if-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg-if-devel-1.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-cfg-if-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfg-if-devel}"
SRC_URI[aarch64_rust-cfg-if-devel.sha256sum] = "59a7a64f0837299e5db5963728dc1498f51231bceacecc7cf12bf458adc138d7"

RDEPENDS:rust-cfg-if+default-devel = " \
 cargo \
 rust-cfg-if-devel \
 "
RDEPENDS:rust-cfg-if-devel = " \
 cargo \
 rust \
 "
