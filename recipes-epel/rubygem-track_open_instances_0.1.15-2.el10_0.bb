# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-track_open_instances"
PV = "0.1.15"
PR = "2.el10_0"
PACKAGES = " \
 rubygem-track_open_instances \
 rubygem-track_open_instances-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-track_open_instances-0.1.15-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3df8f313db6f0793ac666a420a0b3ecd8df2c76c369efc151e31dd22f58ae25c"

URI_x86_64_v2_rubygem-track_open_instances = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-track_open_instances-0.1.15-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-track_open_instances;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-track_open_instances}"
SRC_URI[x86_64_v2_rubygem-track_open_instances.sha256sum] = "2d42570ea318959d9520f8b53ef0b1cc8d3b7f60887060e16991edeb468a05b8"

URI_x86_64_v2_rubygem-track_open_instances-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-track_open_instances-doc-0.1.15-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-track_open_instances-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-track_open_instances-doc}"
SRC_URI[x86_64_v2_rubygem-track_open_instances-doc.sha256sum] = "66a3fed229707bac92f10146b7ac69b7f68143d6d260738985d2008a48f3dc63"

URI_aarch64_rubygem-track_open_instances = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-track_open_instances-0.1.15-2.el10_0.noarch.rpm;name=aarch64_rubygem-track_open_instances;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-track_open_instances}"
SRC_URI[aarch64_rubygem-track_open_instances.sha256sum] = "80f019cfbfbf81012f7b0b67454a1ca4994fac67c3cd57973ca70ab6e08b5f24"

URI_aarch64_rubygem-track_open_instances-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-track_open_instances-doc-0.1.15-2.el10_0.noarch.rpm;name=aarch64_rubygem-track_open_instances-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-track_open_instances-doc}"
SRC_URI[aarch64_rubygem-track_open_instances-doc.sha256sum] = "35833dd6bd0c1abcaa76de4ae1485b46ad1d0cac99a1cbc3f1a7e45389bdf342"

RDEPENDS:rubygem-track_open_instances = " \
 rubygems \
 "
RDEPENDS:rubygem-track_open_instances-doc = " \
 rubygem-track_open_instances \
 "
