# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "egl-gbm"
PE = "2"
PV = "1.1.2.1"
PR = "1.el10_0"
PACKAGES = " \
 egl-gbm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/egl-gbm-1.1.2.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e45e0375378693339e4e6c51abd65dc8bd2d81793cd540bf69aafc5ea67eb28"

URI_x86_64_v2_egl-gbm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/egl-gbm-1.1.2.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_egl-gbm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_egl-gbm}"
SRC_URI[x86_64_v2_egl-gbm.sha256sum] = "b98b8adce3f663cc00061d348ce3d10c732ca69fb92aa36ce85aa3ec70d711a3"

URI_aarch64_egl-gbm = "${EPEL_MIRROR}/aarch64/Packages/e/egl-gbm-1.1.2.1-1.el10_0.aarch64.rpm;name=aarch64_egl-gbm;unpack=0"
SRC_URI:append = " ${URI_aarch64_egl-gbm}"
SRC_URI[aarch64_egl-gbm.sha256sum] = "56933fac1fecf54f35923b6c04ab8aa07e2678bf910ad8d5bb64c7d631b22208"

RDEPENDS:egl-gbm = " \
 glibc \
 libdrm \
 mesa-libgbm \
 "
