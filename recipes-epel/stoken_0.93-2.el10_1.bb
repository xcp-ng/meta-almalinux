# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "stoken"
PV = "0.93"
PR = "2.el10_1"
PACKAGES = " \
 stoken-cli \
 stoken-devel \
 stoken-gui \
 stoken-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/stoken-0.93-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5252e0cebeb0ae7f0c6b39723dabc845b6c91edaa91513ddb3cf36ccf41002a2"

URI_x86_64_v2_stoken-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stoken-cli-0.93-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stoken-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stoken-cli}"
SRC_URI[x86_64_v2_stoken-cli.sha256sum] = "18ebfa7b924c526a1fe4e06df06cedcb53feb605b54802b910724d0fba93aa45"

URI_x86_64_v2_stoken-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stoken-devel-0.93-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stoken-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stoken-devel}"
SRC_URI[x86_64_v2_stoken-devel.sha256sum] = "d92a77c4e6b330e5ed0a490e6f7d9e211f62ec9af6deb1a9ef866807e766f98f"

URI_x86_64_v2_stoken-gui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stoken-gui-0.93-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stoken-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stoken-gui}"
SRC_URI[x86_64_v2_stoken-gui.sha256sum] = "bee2203fe600e92ba06da274e880d7a3ff6a279d9b63014f0fc59fdb40fdcd66"

URI_x86_64_v2_stoken-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stoken-libs-0.93-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stoken-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stoken-libs}"
SRC_URI[x86_64_v2_stoken-libs.sha256sum] = "f60bc11829d7a466786fd8b7efa3931e1dd95e71b2a9bd331520e67ddaa2f844"

URI_aarch64_stoken-cli = "${EPEL_MIRROR}/aarch64/Packages/s/stoken-cli-0.93-2.el10_1.aarch64.rpm;name=aarch64_stoken-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_stoken-cli}"
SRC_URI[aarch64_stoken-cli.sha256sum] = "f661b4b1acbe1d502e056f315e377617c32650b0483e0ce71c4f3d5b88d82efc"

URI_aarch64_stoken-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stoken-devel-0.93-2.el10_1.aarch64.rpm;name=aarch64_stoken-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stoken-devel}"
SRC_URI[aarch64_stoken-devel.sha256sum] = "cd76e5b65707013f0d83e27087fe375a2f1cc2176a57fb1b307330898810f1ab"

URI_aarch64_stoken-gui = "${EPEL_MIRROR}/aarch64/Packages/s/stoken-gui-0.93-2.el10_1.aarch64.rpm;name=aarch64_stoken-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_stoken-gui}"
SRC_URI[aarch64_stoken-gui.sha256sum] = "410f0470fd11a1dca871c2ef9589a5bd74499b19db7282b36696be60336f8ec5"

URI_aarch64_stoken-libs = "${EPEL_MIRROR}/aarch64/Packages/s/stoken-libs-0.93-2.el10_1.aarch64.rpm;name=aarch64_stoken-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_stoken-libs}"
SRC_URI[aarch64_stoken-libs.sha256sum] = "f22b820775cf17842bd6f16ca0ab10780f65b6677f919e53ef2d0ad368ec61b7"

RDEPENDS:stoken-cli = " \
 glibc \
 stoken-libs \
 "
RDEPENDS:stoken-devel = " \
 gmp-devel \
 libxml2-devel \
 nettle-devel \
 pkgconf-pkg-config \
 stoken-libs \
 "
RDEPENDS:stoken-gui = " \
 cairo \
 glib2 \
 glibc \
 gtk3 \
 stoken-libs \
 "
RDEPENDS:stoken-libs = " \
 glibc \
 gmp \
 libxml2 \
 nettle \
 "
