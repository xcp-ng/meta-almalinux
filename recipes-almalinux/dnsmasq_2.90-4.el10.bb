# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnsmasq"
PV = "2.90"
PR = "4.el10"
PACKAGES = " \
 dnsmasq \
 dnsmasq-utils \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dnsmasq-2.90-4.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5c005c1c905b67754e0cb768ea925164593bae9c929bfe0493938cae6161244b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dnsmasq-2.90-4.el10.x86_64_v2.rpm;name=x86_64_v2_dnsmasq;unpack=0"
SRC_URI[x86_64_v2_dnsmasq.sha256sum] = "304c9b10e89b5f543b51ae6f025a1335e7aebdc8bde4d0f44195217c20319ef6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dnsmasq-utils-2.90-4.el10.x86_64_v2.rpm;name=x86_64_v2_dnsmasq-utils;unpack=0"
SRC_URI[x86_64_v2_dnsmasq-utils.sha256sum] = "c612ef10136d5add599029fb148728dbb7492d087e11e8ece31d25d5c1990d57"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dnsmasq-2.90-4.el10.aarch64.rpm;name=aarch64_dnsmasq;unpack=0"
SRC_URI[aarch64_dnsmasq.sha256sum] = "d5dc3518591580b8549965635b188e3008239bc4c4f784ca39d1eae45341a939"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dnsmasq-utils-2.90-4.el10.aarch64.rpm;name=aarch64_dnsmasq-utils;unpack=0"
SRC_URI[aarch64_dnsmasq-utils.sha256sum] = "837ba6fb549c14ed665128192d406fd31de47804dfc3837a43e726fe8441873e"

RDEPENDS:dnsmasq = " \
 bash \
 dbus-libs \
 glibc \
 gmp \
 libidn2 \
 libnetfilter_conntrack \
 nettle \
 "
RDEPENDS:dnsmasq-utils = " \
 glibc \
 "
