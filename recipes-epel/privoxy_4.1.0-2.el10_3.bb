# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "privoxy"
PV = "4.1.0"
PR = "2.el10_3"
PACKAGES = " \
 privoxy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/privoxy-4.1.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d213bf960a10150fb0cb4d27a0fb5f7ab86e25ee41940a9242efd5154f1c48a3"

URI_x86_64_v2_privoxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/privoxy-4.1.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_privoxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_privoxy}"
SRC_URI[x86_64_v2_privoxy.sha256sum] = "8ea5b85745e6021ada5bbe64a0a2c62ebf97b47ce3d813d048394f739ff6446a"

URI_aarch64_privoxy = "${EPEL_MIRROR}/aarch64/Packages/p/privoxy-4.1.0-2.el10_3.aarch64.rpm;name=aarch64_privoxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_privoxy}"
SRC_URI[aarch64_privoxy.sha256sum] = "0f13cafc0d1b4a6832e4154d61986637c4e13db658465c86c2c2d0f6d2067969"

RDEPENDS:privoxy = " \
 bash \
 glibc \
 pcre2 \
 zlib-ng-compat \
 "
