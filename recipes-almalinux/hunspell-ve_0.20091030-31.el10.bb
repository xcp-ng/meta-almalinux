# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-ve"
PV = "0.20091030"
PR = "31.el10"
PACKAGES = " \
 hunspell-ve \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-ve-0.20091030-31.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "08fdab09b3ad3263042e426f4a9d3158551c2c173020f801e4f4b9e8c7f788c0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-ve-0.20091030-31.el10.noarch.rpm;name=x86_64_v2_hunspell-ve;unpack=0"
SRC_URI[x86_64_v2_hunspell-ve.sha256sum] = "d74009bd9542b025a37828249026887fe2fd7691fe237c430bd7770e4d3c85ea"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-ve-0.20091030-31.el10.noarch.rpm;name=aarch64_hunspell-ve;unpack=0"
SRC_URI[aarch64_hunspell-ve.sha256sum] = "d74009bd9542b025a37828249026887fe2fd7691fe237c430bd7770e4d3c85ea"

RDEPENDS:hunspell-ve = " \
 hunspell-filesystem \
 "
