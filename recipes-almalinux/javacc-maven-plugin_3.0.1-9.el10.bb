# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "javacc-maven-plugin"
PV = "3.0.1"
PR = "9.el10"
PACKAGES = " \
 javacc-maven-plugin \
 javacc-maven-plugin-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/javacc-maven-plugin-3.0.1-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "645303a147c7bc6f116baa4999b7ae7faed6e0e6c8934cfe868e081c2240c63f"

URI_x86_64_v2_javacc-maven-plugin = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/javacc-maven-plugin-3.0.1-9.el10.noarch.rpm;name=x86_64_v2_javacc-maven-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_javacc-maven-plugin}"
SRC_URI[x86_64_v2_javacc-maven-plugin.sha256sum] = "4b8613c93449e0a101536bc0f8818841b61020b25d44ec728f8390ea34618c32"

URI_x86_64_v2_javacc-maven-plugin-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/javacc-maven-plugin-javadoc-3.0.1-9.el10.noarch.rpm;name=x86_64_v2_javacc-maven-plugin-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_javacc-maven-plugin-javadoc}"
SRC_URI[x86_64_v2_javacc-maven-plugin-javadoc.sha256sum] = "98f665da4720c5d0b2e87dc7bb09f3fceef42416848436477036162bd8051991"

URI_aarch64_javacc-maven-plugin = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/javacc-maven-plugin-3.0.1-9.el10.noarch.rpm;name=aarch64_javacc-maven-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_javacc-maven-plugin}"
SRC_URI[aarch64_javacc-maven-plugin.sha256sum] = "4b8613c93449e0a101536bc0f8818841b61020b25d44ec728f8390ea34618c32"

URI_aarch64_javacc-maven-plugin-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/javacc-maven-plugin-javadoc-3.0.1-9.el10.noarch.rpm;name=aarch64_javacc-maven-plugin-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_javacc-maven-plugin-javadoc}"
SRC_URI[aarch64_javacc-maven-plugin-javadoc.sha256sum] = "98f665da4720c5d0b2e87dc7bb09f3fceef42416848436477036162bd8051991"

RDEPENDS:javacc-maven-plugin = " \
 javacc \
 javapackages-filesystem \
 maven-lib \
 plexus-utils \
 "
RDEPENDS:javacc-maven-plugin-javadoc = " \
 javapackages-filesystem \
 "
