# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cryptoki-sys"
PV = "0.5.0"
PR = "2.el10_2"
PACKAGES = " \
 rust-cryptoki-sys+bindgen-devel \
 rust-cryptoki-sys+default-devel \
 rust-cryptoki-sys+generate-bindings-devel \
 rust-cryptoki-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cryptoki-sys-0.5.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e41f6d4d7f01258ec827c1cd09d8a755ee831e0f157fa27ae35168ad92a1262"

URI_x86_64_v2_rust-cryptoki-sys+bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cryptoki-sys+bindgen-devel-0.5.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cryptoki-sys+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cryptoki-sys+bindgen-devel}"
SRC_URI[x86_64_v2_rust-cryptoki-sys+bindgen-devel.sha256sum] = "5169f44b2d74413c5ee8a1aea21a1896f7bbaefccac1a783ab2e4c11bf5127c3"

URI_x86_64_v2_rust-cryptoki-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cryptoki-sys+default-devel-0.5.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cryptoki-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cryptoki-sys+default-devel}"
SRC_URI[x86_64_v2_rust-cryptoki-sys+default-devel.sha256sum] = "9a8f8056ede5668688a3344b37b504197c9e63b8f915046b338a0d9fe7502181"

URI_x86_64_v2_rust-cryptoki-sys+generate-bindings-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cryptoki-sys+generate-bindings-devel-0.5.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cryptoki-sys+generate-bindings-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cryptoki-sys+generate-bindings-devel}"
SRC_URI[x86_64_v2_rust-cryptoki-sys+generate-bindings-devel.sha256sum] = "9106bae123907d9e5927207e54e8f7c46db33d3e195511e32d29cdae800c48fd"

URI_x86_64_v2_rust-cryptoki-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cryptoki-sys-devel-0.5.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cryptoki-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cryptoki-sys-devel}"
SRC_URI[x86_64_v2_rust-cryptoki-sys-devel.sha256sum] = "b2397c4dbb535d931ddd746fbd515660d1d098e7d67e6ce79267352cc631d724"

URI_aarch64_rust-cryptoki-sys+bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cryptoki-sys+bindgen-devel-0.5.0-2.el10_2.noarch.rpm;name=aarch64_rust-cryptoki-sys+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cryptoki-sys+bindgen-devel}"
SRC_URI[aarch64_rust-cryptoki-sys+bindgen-devel.sha256sum] = "48fd81a59d0adc71a3905a43fd53dbc3351796c7c8551a06687e67c8a1619815"

URI_aarch64_rust-cryptoki-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cryptoki-sys+default-devel-0.5.0-2.el10_2.noarch.rpm;name=aarch64_rust-cryptoki-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cryptoki-sys+default-devel}"
SRC_URI[aarch64_rust-cryptoki-sys+default-devel.sha256sum] = "1e1b256a424b4712eb46c4fd2bfd0c7bb8b11eddc5e35e042109f1ede2d9b233"

URI_aarch64_rust-cryptoki-sys+generate-bindings-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cryptoki-sys+generate-bindings-devel-0.5.0-2.el10_2.noarch.rpm;name=aarch64_rust-cryptoki-sys+generate-bindings-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cryptoki-sys+generate-bindings-devel}"
SRC_URI[aarch64_rust-cryptoki-sys+generate-bindings-devel.sha256sum] = "8fc31d311282f2373e6d91ec461e69f4db5f3e18a5e655350c19c0bfdfdc00a7"

URI_aarch64_rust-cryptoki-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cryptoki-sys-devel-0.5.0-2.el10_2.noarch.rpm;name=aarch64_rust-cryptoki-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cryptoki-sys-devel}"
SRC_URI[aarch64_rust-cryptoki-sys-devel.sha256sum] = "9ac5aeb6bc058de55e83249b7c467e4a9a245b5a05477d6df96e0df268dc69ed"

RDEPENDS:rust-cryptoki-sys+bindgen-devel = " \
 cargo \
 rust-cryptoki-sys-devel \
 "
RDEPENDS:rust-cryptoki-sys+default-devel = " \
 cargo \
 rust-cryptoki-sys-devel \
 "
RDEPENDS:rust-cryptoki-sys+generate-bindings-devel = " \
 cargo \
 rust-cryptoki-sys-devel \
 "
RDEPENDS:rust-cryptoki-sys-devel = " \
 bash \
 cargo \
 rust \
 rust-bindgen+default-devel \
 rust-libloading+default-devel \
 "
