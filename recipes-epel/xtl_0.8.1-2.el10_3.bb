# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xtl"
PV = "0.8.1"
PR = "2.el10_3"
PACKAGES = " \
 xtl-devel \
 xtl-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xtl-0.8.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "03eeaac43aeefae8542a5a8f4e4b9f57e613c256093e53cc602d845fdf8e4eb5"

URI_x86_64_v2_xtl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xtl-devel-0.8.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xtl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xtl-devel}"
SRC_URI[x86_64_v2_xtl-devel.sha256sum] = "a12f3011464621b83e548ededa1090b900c9246ce19187587e56562410b5b9a5"

URI_x86_64_v2_xtl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xtl-doc-0.8.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xtl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xtl-doc}"
SRC_URI[x86_64_v2_xtl-doc.sha256sum] = "50668bddb32cf1839c90a45cdad6d097dce689d3cde514310bf75548481c8ac5"

URI_aarch64_xtl-devel = "${EPEL_MIRROR}/aarch64/Packages/x/xtl-devel-0.8.1-2.el10_3.aarch64.rpm;name=aarch64_xtl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xtl-devel}"
SRC_URI[aarch64_xtl-devel.sha256sum] = "c1cae6de1d128fe31e034e018797d192011e32faff19357cd1d1bfa8aa5a6fe6"

URI_aarch64_xtl-doc = "${EPEL_MIRROR}/aarch64/Packages/x/xtl-doc-0.8.1-2.el10_3.aarch64.rpm;name=aarch64_xtl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_xtl-doc}"
SRC_URI[aarch64_xtl-doc.sha256sum] = "66c0353485c2b3514ab252356f94884364e41d3f91cd5861d96ea7481ab2501b"

RDEPENDS:xtl-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
RDEPENDS:xtl-doc = " \
 "
