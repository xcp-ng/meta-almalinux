# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-cryptohash-md5"
PV = "0.11.101.0"
PR = "12.el10_0"
PACKAGES = " \
 ghc-cryptohash-md5 \
 ghc-cryptohash-md5-devel \
 ghc-cryptohash-md5-doc \
 ghc-cryptohash-md5-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-cryptohash-md5-0.11.101.0-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e11d767d33641c1253f1be0f38345761f433cdee91dca2e4c0d73ecaac9af99e"

URI_x86_64_v2_ghc-cryptohash-md5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cryptohash-md5-0.11.101.0-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cryptohash-md5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cryptohash-md5}"
SRC_URI[x86_64_v2_ghc-cryptohash-md5.sha256sum] = "dce59bb2514d08c69caa4665fd63ad979d1029feba538c01a3e150ec18c6ceb0"

URI_x86_64_v2_ghc-cryptohash-md5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cryptohash-md5-devel-0.11.101.0-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cryptohash-md5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cryptohash-md5-devel}"
SRC_URI[x86_64_v2_ghc-cryptohash-md5-devel.sha256sum] = "d4e62621ab3cf1bc782dfd20edc46a3b892680d8d3486cd47e658e427aebf95c"

URI_x86_64_v2_ghc-cryptohash-md5-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cryptohash-md5-doc-0.11.101.0-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-cryptohash-md5-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cryptohash-md5-doc}"
SRC_URI[x86_64_v2_ghc-cryptohash-md5-doc.sha256sum] = "af7e21c7aabd7efc158594780676dc3e62ecbd54c2281d8b7398a5a510790a7e"

URI_x86_64_v2_ghc-cryptohash-md5-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cryptohash-md5-prof-0.11.101.0-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cryptohash-md5-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cryptohash-md5-prof}"
SRC_URI[x86_64_v2_ghc-cryptohash-md5-prof.sha256sum] = "e530cff9c5d29f60cfaaf44ab71113fc9e995e60599f76b3873da43b9a8eb5b7"

URI_aarch64_ghc-cryptohash-md5 = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cryptohash-md5-0.11.101.0-12.el10_0.aarch64.rpm;name=aarch64_ghc-cryptohash-md5;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cryptohash-md5}"
SRC_URI[aarch64_ghc-cryptohash-md5.sha256sum] = "512ff1bf0a52d6c35774eb9b3c80a6f37c95473e591bfc8fe1b03976341611a1"

URI_aarch64_ghc-cryptohash-md5-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cryptohash-md5-devel-0.11.101.0-12.el10_0.aarch64.rpm;name=aarch64_ghc-cryptohash-md5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cryptohash-md5-devel}"
SRC_URI[aarch64_ghc-cryptohash-md5-devel.sha256sum] = "2ab5cc2cc4daceed7321e5d1daee3e60cf5c7f31dc72a1e3a26c21332727826f"

URI_aarch64_ghc-cryptohash-md5-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cryptohash-md5-doc-0.11.101.0-12.el10_0.noarch.rpm;name=aarch64_ghc-cryptohash-md5-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cryptohash-md5-doc}"
SRC_URI[aarch64_ghc-cryptohash-md5-doc.sha256sum] = "9abcb1a723c8f6807c1cc3f78af2d3533b252f94cfd0a9c69d8497baf2283b57"

URI_aarch64_ghc-cryptohash-md5-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cryptohash-md5-prof-0.11.101.0-12.el10_0.aarch64.rpm;name=aarch64_ghc-cryptohash-md5-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cryptohash-md5-prof}"
SRC_URI[aarch64_ghc-cryptohash-md5-prof.sha256sum] = "e236a911acf1b1cb90a1c743057fdb934d65a0d6d4dc66337f2b45f746c85827"

RDEPENDS:ghc-cryptohash-md5 = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-cryptohash-md5-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-cryptohash-md5 \
 "
RDEPENDS:ghc-cryptohash-md5-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-cryptohash-md5-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-cryptohash-md5-devel \
 "
