# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rccl-tests"
PV = "git20251211.5272cd1"
PR = "1.el10_3"
PACKAGES:x86_64_v2 = " \
 rccl-tests \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rccl-tests-git20251211.5272cd1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91b510c505c6a218c55d8f161d33a15391f2d907630a925173984a7ee64c3043"

URI_x86_64_v2_rccl-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rccl-tests-git20251211.5272cd1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rccl-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rccl-tests}"
SRC_URI[x86_64_v2_rccl-tests.sha256sum] = "4fca58284f2bca1baf097948f8a356029df2f7758404e10223d62350dcdba4b5"

RDEPENDS:rccl-tests = " \
 glibc \
 libgcc \
 libstdc++ \
 rccl \
 rocm-hip \
 "
