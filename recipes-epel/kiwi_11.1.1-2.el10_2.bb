# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kiwi"
PV = "11.1.1"
PR = "2.el10_2"
PACKAGES:x86_64_v2 = " \
 dracut-kiwi-lib \
 dracut-kiwi-live \
 dracut-kiwi-oem-dump \
 dracut-kiwi-oem-repart \
 dracut-kiwi-overlay \
 dracut-kiwi-verity \
 kiwi-cli \
 kiwi-pxeboot \
 kiwi-selinux \
 kiwi-systemdeps \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-boxbuild \
 kiwi-systemdeps-containers \
 kiwi-systemdeps-core \
 kiwi-systemdeps-disk-images \
 kiwi-systemdeps-filesystems \
 kiwi-systemdeps-image-validation \
 kiwi-systemdeps-iso-media \
 kiwi-systemdeps-stackbuild \
 python3-kiwi \
"
PACKAGES:aarch64 = " \
 dracut-kiwi-lib \
 dracut-kiwi-live \
 dracut-kiwi-oem-dump \
 dracut-kiwi-oem-repart \
 dracut-kiwi-overlay \
 dracut-kiwi-verity \
 kiwi-cli \
 kiwi-selinux \
 kiwi-systemdeps \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-boxbuild \
 kiwi-systemdeps-containers \
 kiwi-systemdeps-core \
 kiwi-systemdeps-disk-images \
 kiwi-systemdeps-filesystems \
 kiwi-systemdeps-image-validation \
 kiwi-systemdeps-iso-media \
 kiwi-systemdeps-stackbuild \
 python3-kiwi \
"

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kiwi-11.1.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ecbf4d57685e6c03a08c5f4f28cdbc24d53e49bea612fd2819012285beb1018c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-lib-11.1.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_dracut-kiwi-lib;unpack=0"
SRC_URI[x86_64_v2_dracut-kiwi-lib.sha256sum] = "51165310727ce99dbe48ab52b1262f53b52cff2ee3162012d6f7323935684104"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-live-11.1.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_dracut-kiwi-live;unpack=0"
SRC_URI[x86_64_v2_dracut-kiwi-live.sha256sum] = "afcdd247be56ceb3573af37c908f359a67437522c500aeb44a9a1e39384f20ef"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-oem-dump-11.1.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_dracut-kiwi-oem-dump;unpack=0"
SRC_URI[x86_64_v2_dracut-kiwi-oem-dump.sha256sum] = "54087f07fa0b64590620fa4339b024bdd2e7d2d1c05c15b91bc52f71a1a12c67"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-oem-repart-11.1.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_dracut-kiwi-oem-repart;unpack=0"
SRC_URI[x86_64_v2_dracut-kiwi-oem-repart.sha256sum] = "62bb574b4ff020a02646fb8997a2b23ee87f07b8aaf6f4c0ff69be16c16c4af1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-overlay-11.1.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_dracut-kiwi-overlay;unpack=0"
SRC_URI[x86_64_v2_dracut-kiwi-overlay.sha256sum] = "b266a5534dd4c4c6cfda67a35583136d818d8dcff6448035efca005393b8bbda"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-verity-11.1.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dracut-kiwi-verity;unpack=0"
SRC_URI[x86_64_v2_dracut-kiwi-verity.sha256sum] = "fc1bfdc238eeb080b56bb0bd12226c70470841752554d8407984aa4625d06aa0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-cli-11.1.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kiwi-cli;unpack=0"
SRC_URI[x86_64_v2_kiwi-cli.sha256sum] = "5913f89cf141bdac27f3132cca12f8df799fb29d3e4314ff7fb0702b7a210cc1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-pxeboot-11.1.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-pxeboot;unpack=0"
SRC_URI[x86_64_v2_kiwi-pxeboot.sha256sum] = "eddb4cd93aa12b392f5e1f608263c204636cd3e0cffe92c7b693203b2ef2da65"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-selinux-11.1.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kiwi-selinux;unpack=0"
SRC_URI[x86_64_v2_kiwi-selinux.sha256sum] = "b7ed9ad4008b785227fd9730042e9b83a1e353a8308cee9c25e771f331026e5b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-11.1.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps;unpack=0"
SRC_URI[x86_64_v2_kiwi-systemdeps.sha256sum] = "d521cdd82b33584e821280b6c645ccc4bd986f8f62ff286c16a7a3f831dda240"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-bootloaders-11.1.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-bootloaders;unpack=0"
SRC_URI[x86_64_v2_kiwi-systemdeps-bootloaders.sha256sum] = "3cd3ca88819c92b5122f5cd514f5341dd6dcc278b46a30d336737ca1a414e944"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-boxbuild-11.1.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-boxbuild;unpack=0"
SRC_URI[x86_64_v2_kiwi-systemdeps-boxbuild.sha256sum] = "0e739518a8c3c385a87890ea908010589864e9b005835043cd4af515fb50444e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-containers-11.1.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-containers;unpack=0"
SRC_URI[x86_64_v2_kiwi-systemdeps-containers.sha256sum] = "04500e70c5db3cf49c5ef93fb239f6eaa7b8b53a5326612e35eca9a646642cfa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-core-11.1.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-core;unpack=0"
SRC_URI[x86_64_v2_kiwi-systemdeps-core.sha256sum] = "b92abfcc679684ceb2fcc1694b6980fdadc60df2beac9165614caf26eb067768"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-disk-images-11.1.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-disk-images;unpack=0"
SRC_URI[x86_64_v2_kiwi-systemdeps-disk-images.sha256sum] = "e9a9a90550af3c92e6ec9c06974ba34174df09665d45ee2133e639558a50ac04"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-filesystems-11.1.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-filesystems;unpack=0"
SRC_URI[x86_64_v2_kiwi-systemdeps-filesystems.sha256sum] = "24ed243b862f3758b8a9bb24d90a3f3d0e97d1d822432af4a398b107fce594d5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-image-validation-11.1.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-image-validation;unpack=0"
SRC_URI[x86_64_v2_kiwi-systemdeps-image-validation.sha256sum] = "defe2096e3335d689e94170bfae16e24ce15b3c1751ebd32ea5e6a775e8b23db"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-iso-media-11.1.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-iso-media;unpack=0"
SRC_URI[x86_64_v2_kiwi-systemdeps-iso-media.sha256sum] = "b7b32056802cc3e579a09d9be4752ee25a84e3f8da25e10ef113d8766c198d8a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-stackbuild-11.1.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-stackbuild;unpack=0"
SRC_URI[x86_64_v2_kiwi-systemdeps-stackbuild.sha256sum] = "1bb442ac3171e6c80762a8610b001a44ca05670321e1236697e5b7a4bf5cf554"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kiwi-11.1.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-kiwi;unpack=0"
SRC_URI[x86_64_v2_python3-kiwi.sha256sum] = "384278aa3e37bafe213cb296f5a21443f0249908a1ad72543f5155b25ade832f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-lib-11.1.1-2.el10_2.noarch.rpm;name=aarch64_dracut-kiwi-lib;unpack=0"
SRC_URI[aarch64_dracut-kiwi-lib.sha256sum] = "08c4b4cf27af00a01df68f3b45a76681d61a3202c244de270e9f5491dcc3220a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-live-11.1.1-2.el10_2.noarch.rpm;name=aarch64_dracut-kiwi-live;unpack=0"
SRC_URI[aarch64_dracut-kiwi-live.sha256sum] = "eb1cc520c8ee1aa79b0fb166fb1c8b1bcca43ac79d456cd888ee1643d58f4115"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-oem-dump-11.1.1-2.el10_2.noarch.rpm;name=aarch64_dracut-kiwi-oem-dump;unpack=0"
SRC_URI[aarch64_dracut-kiwi-oem-dump.sha256sum] = "9c31332b09b405e4f212774bca95fb6867549c385b89439a5030ad085ab0f9bc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-oem-repart-11.1.1-2.el10_2.noarch.rpm;name=aarch64_dracut-kiwi-oem-repart;unpack=0"
SRC_URI[aarch64_dracut-kiwi-oem-repart.sha256sum] = "bc48794a3e927dd8b32500c1eac427abc368c671b2c2f9e505f093e9403ea944"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-overlay-11.1.1-2.el10_2.noarch.rpm;name=aarch64_dracut-kiwi-overlay;unpack=0"
SRC_URI[aarch64_dracut-kiwi-overlay.sha256sum] = "f5db2c442cb59fa6413137405f77b09e001557ee3be8c5bac8f2c5fc325f1d16"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-verity-11.1.1-2.el10_2.aarch64.rpm;name=aarch64_dracut-kiwi-verity;unpack=0"
SRC_URI[aarch64_dracut-kiwi-verity.sha256sum] = "2b9234abfc05385c37f8a5d38c318d4f7e51b47b283efd659bea6ffce5d5331c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-cli-11.1.1-2.el10_2.noarch.rpm;name=aarch64_kiwi-cli;unpack=0"
SRC_URI[aarch64_kiwi-cli.sha256sum] = "b94475cbc8ec1cdb46c083e12880662e3827c2be222f025052597d2d35bb7c3f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-selinux-11.1.1-2.el10_2.noarch.rpm;name=aarch64_kiwi-selinux;unpack=0"
SRC_URI[aarch64_kiwi-selinux.sha256sum] = "abf4888d4a3cd997eb7c3b8b0b0abac88f18341975b137961dd8e46f1b708ca1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-11.1.1-2.el10_2.aarch64.rpm;name=aarch64_kiwi-systemdeps;unpack=0"
SRC_URI[aarch64_kiwi-systemdeps.sha256sum] = "e1d689f4a8f9a5e5f7a215d76c6914f3a47e374d733b86f5e30f515caea7da7c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-bootloaders-11.1.1-2.el10_2.aarch64.rpm;name=aarch64_kiwi-systemdeps-bootloaders;unpack=0"
SRC_URI[aarch64_kiwi-systemdeps-bootloaders.sha256sum] = "61abdf5c9588b03adbea7b41559d1d2cf8305b46877f9ca27cea0a1b9c34765b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-boxbuild-11.1.1-2.el10_2.aarch64.rpm;name=aarch64_kiwi-systemdeps-boxbuild;unpack=0"
SRC_URI[aarch64_kiwi-systemdeps-boxbuild.sha256sum] = "99b2061a4a9fd7f0705d0d5e7d8ecb10c91d3b68941f7c782203bd9bd95bbef7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-containers-11.1.1-2.el10_2.aarch64.rpm;name=aarch64_kiwi-systemdeps-containers;unpack=0"
SRC_URI[aarch64_kiwi-systemdeps-containers.sha256sum] = "799c80f736c71115e156334199ec81cedc6ca9d3bd51872407eee8d9e0574de6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-core-11.1.1-2.el10_2.aarch64.rpm;name=aarch64_kiwi-systemdeps-core;unpack=0"
SRC_URI[aarch64_kiwi-systemdeps-core.sha256sum] = "6d85e242c3b836692ba190c75a1d0fe16c2ee38a897dfa6d879d1ae7ae3c59c8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-disk-images-11.1.1-2.el10_2.aarch64.rpm;name=aarch64_kiwi-systemdeps-disk-images;unpack=0"
SRC_URI[aarch64_kiwi-systemdeps-disk-images.sha256sum] = "79c83c982e2afd17be0fe31b4473e41d360e1f1e8488cf836a9d89243309bb91"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-filesystems-11.1.1-2.el10_2.aarch64.rpm;name=aarch64_kiwi-systemdeps-filesystems;unpack=0"
SRC_URI[aarch64_kiwi-systemdeps-filesystems.sha256sum] = "0a313634b099ac56b6f0868edae8a8ee39f4cfd1c397597a97c6943765422465"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-image-validation-11.1.1-2.el10_2.aarch64.rpm;name=aarch64_kiwi-systemdeps-image-validation;unpack=0"
SRC_URI[aarch64_kiwi-systemdeps-image-validation.sha256sum] = "5ae808101d2771e7dc4e96f96c7065aacb9b71704be1d25e8d5ba887f95f5f52"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-iso-media-11.1.1-2.el10_2.aarch64.rpm;name=aarch64_kiwi-systemdeps-iso-media;unpack=0"
SRC_URI[aarch64_kiwi-systemdeps-iso-media.sha256sum] = "0fb0a4bd6d45ee4a1d24a689cfebb321196f26976710f97746580e7ef9d56178"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-stackbuild-11.1.1-2.el10_2.aarch64.rpm;name=aarch64_kiwi-systemdeps-stackbuild;unpack=0"
SRC_URI[aarch64_kiwi-systemdeps-stackbuild.sha256sum] = "a91e1909c80bc03a1010fe16be3243b22ead07037309f6af983fa4c1a9349302"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-kiwi-11.1.1-2.el10_2.noarch.rpm;name=aarch64_python3-kiwi;unpack=0"
SRC_URI[aarch64_python3-kiwi.sha256sum] = "6a40629fff1f0e1896021adff1f114578b83e7aadc74bb50ad155a00b67c7675"

RDEPENDS:dracut-kiwi-lib = " \
 bash \
 bc \
 cryptsetup \
 curl \
 device-mapper \
 dialog \
 dracut \
 e2fsprogs \
 gdisk \
 grep \
 kpartx \
 lvm2 \
 mdadm \
 parted \
 pv \
 util-linux \
 virtual/coreutils \
 xfsprogs \
 xz \
 "
RDEPENDS:dracut-kiwi-live = " \
 bash \
 device-mapper \
 dialog \
 dracut \
 dracut-kiwi-lib \
 dracut-network \
 e2fsprogs \
 parted \
 util-linux \
 xfsprogs \
 "
RDEPENDS:dracut-kiwi-oem-dump = " \
 bash \
 dracut-kiwi-lib \
 gawk \
 kexec-tools \
 "
RDEPENDS:dracut-kiwi-oem-repart = " \
 bash \
 dracut-kiwi-lib \
 "
RDEPENDS:dracut-kiwi-overlay = " \
 bash \
 dracut \
 dracut-kiwi-lib \
 util-linux \
 "
RDEPENDS:dracut-kiwi-verity = " \
 bash \
 dracut \
 dracut-kiwi-lib \
 glibc \
 "
RDEPENDS:kiwi-cli = " \
 bash-completion \
 kiwi-selinux \
 python3-kiwi \
 "
RDEPENDS:kiwi-pxeboot = " \
 syslinux \
 tftp-server \
 "
RDEPENDS:kiwi-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 "
RDEPENDS:kiwi-systemdeps = " \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-containers \
 kiwi-systemdeps-core \
 kiwi-systemdeps-disk-images \
 kiwi-systemdeps-filesystems \
 kiwi-systemdeps-iso-media \
 "
RDEPENDS:kiwi-systemdeps-bootloaders:x86_64_v2 = " \
 grub2-efi-x64 \
 grub2-efi-x64-modules \
 grub2-pc \
 grub2-pc-modules \
 grub2-tools \
 grub2-tools-efi \
 grub2-tools-extra \
 grub2-tools-minimal \
 kiwi-systemdeps-core \
"
RDEPENDS:kiwi-systemdeps-bootloaders:aarch64 = " \
 grub2-efi-aa64-modules \
 grub2-tools \
 grub2-tools-extra \
 grub2-tools-minimal \
 kiwi-systemdeps-core \
"
RDEPENDS:kiwi-systemdeps-boxbuild = " \
 kiwi-systemdeps-core \
 qemu-kvm \
 "
RDEPENDS:kiwi-systemdeps-containers = " \
 appx-util \
 buildah \
 skopeo \
 "
RDEPENDS:kiwi-systemdeps-core = " \
 dnf \
 file \
 lsof \
 microdnf \
 mtools \
 openssl \
 python3-dnf \
 rsync \
 screen \
 sed \
 tar \
 xz \
 "
RDEPENDS:kiwi-systemdeps-disk-images = " \
 cryptsetup \
 gdisk \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-filesystems \
 kiwi-systemdeps-iso-media \
 kpartx \
 lvm2 \
 mdadm \
 open-vmdk \
 util-linux \
 "
RDEPENDS:kiwi-systemdeps-filesystems = " \
 dosfstools \
 e2fsprogs \
 erofs-utils \
 kiwi-systemdeps-core \
 qemu-img \
 squashfs-tools \
 xfsprogs \
 "
RDEPENDS:kiwi-systemdeps-image-validation = " \
 python3-solv \
 "
RDEPENDS:kiwi-systemdeps-iso-media:x86_64_v2 = " \
 grub2-efi-x64-cdboot \
 isomd5sum \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-core \
 kiwi-systemdeps-filesystems \
 syslinux \
 syslinux-nonlinux \
 xorriso \
"
RDEPENDS:kiwi-systemdeps-iso-media:aarch64 = " \
 grub2-efi-aa64-cdboot \
 isomd5sum \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-core \
 kiwi-systemdeps-filesystems \
 xorriso \
"
RDEPENDS:kiwi-systemdeps-stackbuild = " \
 kiwi-systemdeps-containers \
 kiwi-systemdeps-core \
 podman \
 rsync \
 "
RDEPENDS:python3-kiwi = " \
 kiwi-systemdeps-core \
 python3 \
 python3-cerberus \
 python3-lxml \
 python3-progressbar2 \
 python3-pyyaml \
 python3-requests \
 python3-simplejson \
 python3-typer \
 "
