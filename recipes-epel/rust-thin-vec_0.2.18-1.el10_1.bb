# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-thin-vec"
PV = "0.2.18"
PR = "1.el10_1"
PACKAGES = " \
 rust-thin-vec+const_new-devel \
 rust-thin-vec+default-devel \
 rust-thin-vec+gecko-ffi-devel \
 rust-thin-vec+serde-devel \
 rust-thin-vec+std-devel \
 rust-thin-vec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-thin-vec-0.2.18-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9cd0de9a7a45e13b6c62a161e99658c724a05295c96a65ac74ebb0ca220a6556"

URI_x86_64_v2_rust-thin-vec+const_new-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thin-vec+const_new-devel-0.2.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thin-vec+const_new-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thin-vec+const_new-devel}"
SRC_URI[x86_64_v2_rust-thin-vec+const_new-devel.sha256sum] = "1d08ea7a120caa8eb1bbbbc4ede54e7400e7e713a609aa44aebb60cc080bb1ac"

URI_x86_64_v2_rust-thin-vec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thin-vec+default-devel-0.2.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thin-vec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thin-vec+default-devel}"
SRC_URI[x86_64_v2_rust-thin-vec+default-devel.sha256sum] = "ac9ee17f15ebb01540b471dbf88443bd16cc83e4ff57442aad8ce7ea76fcc6b3"

URI_x86_64_v2_rust-thin-vec+gecko-ffi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thin-vec+gecko-ffi-devel-0.2.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thin-vec+gecko-ffi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thin-vec+gecko-ffi-devel}"
SRC_URI[x86_64_v2_rust-thin-vec+gecko-ffi-devel.sha256sum] = "65594b18b5c1370cd837ed42929c84b4c498556dfb638053561da5d4b6db76bd"

URI_x86_64_v2_rust-thin-vec+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thin-vec+serde-devel-0.2.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thin-vec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thin-vec+serde-devel}"
SRC_URI[x86_64_v2_rust-thin-vec+serde-devel.sha256sum] = "80b319d38522f8c0db4049461b3148e78daad1c3224984642fa9fc230e179e94"

URI_x86_64_v2_rust-thin-vec+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thin-vec+std-devel-0.2.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thin-vec+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thin-vec+std-devel}"
SRC_URI[x86_64_v2_rust-thin-vec+std-devel.sha256sum] = "21066b8f674fd07a12f3550f3db95e750a20db6b025f2f850f6d5685a68d6b1a"

URI_x86_64_v2_rust-thin-vec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thin-vec-devel-0.2.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thin-vec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thin-vec-devel}"
SRC_URI[x86_64_v2_rust-thin-vec-devel.sha256sum] = "3851dd3fb3eb872b23f4a7c728af8d8c316292672b78d585bf488a4528c2594e"

URI_aarch64_rust-thin-vec+const_new-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thin-vec+const_new-devel-0.2.18-1.el10_1.noarch.rpm;name=aarch64_rust-thin-vec+const_new-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thin-vec+const_new-devel}"
SRC_URI[aarch64_rust-thin-vec+const_new-devel.sha256sum] = "c027a1ec566374dbefcfe29760eafa462b19649b92096e0bb85175bcf8ee6b02"

URI_aarch64_rust-thin-vec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thin-vec+default-devel-0.2.18-1.el10_1.noarch.rpm;name=aarch64_rust-thin-vec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thin-vec+default-devel}"
SRC_URI[aarch64_rust-thin-vec+default-devel.sha256sum] = "fec7a4f8bb86e31f530972987fd7c705c91ae1ff4d79306ee5235086d77df7fb"

URI_aarch64_rust-thin-vec+gecko-ffi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thin-vec+gecko-ffi-devel-0.2.18-1.el10_1.noarch.rpm;name=aarch64_rust-thin-vec+gecko-ffi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thin-vec+gecko-ffi-devel}"
SRC_URI[aarch64_rust-thin-vec+gecko-ffi-devel.sha256sum] = "a4a91c2de7fc2e769bc34510b76b0d6cd2dc313bae0ab339593f5701930a5ffc"

URI_aarch64_rust-thin-vec+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thin-vec+serde-devel-0.2.18-1.el10_1.noarch.rpm;name=aarch64_rust-thin-vec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thin-vec+serde-devel}"
SRC_URI[aarch64_rust-thin-vec+serde-devel.sha256sum] = "7a5dc7a41858a050ed96dc753e611165c3f1a116b24f105db396d3f679e60bee"

URI_aarch64_rust-thin-vec+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thin-vec+std-devel-0.2.18-1.el10_1.noarch.rpm;name=aarch64_rust-thin-vec+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thin-vec+std-devel}"
SRC_URI[aarch64_rust-thin-vec+std-devel.sha256sum] = "45cb6fd45226eeaf7437774f41e03f438eca657ed38baec44de6598c9e4a0100"

URI_aarch64_rust-thin-vec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thin-vec-devel-0.2.18-1.el10_1.noarch.rpm;name=aarch64_rust-thin-vec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thin-vec-devel}"
SRC_URI[aarch64_rust-thin-vec-devel.sha256sum] = "6737b0db17fc58edf0c0ee969bbadb00d2c6e422ba22765426b71abf48b7ddaf"

RDEPENDS:rust-thin-vec+const_new-devel = " \
 cargo \
 rust-thin-vec-devel \
 "
RDEPENDS:rust-thin-vec+default-devel = " \
 cargo \
 rust-thin-vec+std-devel \
 rust-thin-vec-devel \
 "
RDEPENDS:rust-thin-vec+gecko-ffi-devel = " \
 cargo \
 rust-thin-vec-devel \
 "
RDEPENDS:rust-thin-vec+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-thin-vec-devel \
 "
RDEPENDS:rust-thin-vec+std-devel = " \
 cargo \
 rust-thin-vec-devel \
 "
RDEPENDS:rust-thin-vec-devel = " \
 cargo \
 rust \
 "
