# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-enum-iterator-derive"
PV = "1.5.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-enum-iterator-derive+default-devel \
 rust-enum-iterator-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-enum-iterator-derive-1.5.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "189bb4b50354e52a2ecea755a56fac47df81f7bc0f5a8aba0a70d9e2ac97bca2"

URI_x86_64_v2_rust-enum-iterator-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enum-iterator-derive+default-devel-1.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enum-iterator-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enum-iterator-derive+default-devel}"
SRC_URI[x86_64_v2_rust-enum-iterator-derive+default-devel.sha256sum] = "c2db550288a0408c2d00a16e7dbfc76c8392d22f343dafaa2f9e5af94f3d09ae"

URI_x86_64_v2_rust-enum-iterator-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enum-iterator-derive-devel-1.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enum-iterator-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enum-iterator-derive-devel}"
SRC_URI[x86_64_v2_rust-enum-iterator-derive-devel.sha256sum] = "832334ccec3448df734ad93b87ef5e8421b49848b62dd802f510dc8ed5ed952d"

URI_aarch64_rust-enum-iterator-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enum-iterator-derive+default-devel-1.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-enum-iterator-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enum-iterator-derive+default-devel}"
SRC_URI[aarch64_rust-enum-iterator-derive+default-devel.sha256sum] = "f4b661cb5b07b8a702de847648d0b0cade8f148d2e8b52d30af52fa361735706"

URI_aarch64_rust-enum-iterator-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enum-iterator-derive-devel-1.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-enum-iterator-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enum-iterator-derive-devel}"
SRC_URI[aarch64_rust-enum-iterator-derive-devel.sha256sum] = "f33326ceede571c4f8c6400ae3adf145af8e2f274c4aa14f261d1cbb3d802008"

RDEPENDS:rust-enum-iterator-derive+default-devel = " \
 cargo \
 rust-enum-iterator-derive-devel \
 "
RDEPENDS:rust-enum-iterator-derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 "
