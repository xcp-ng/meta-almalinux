# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vaultwarden-web"
PV = "2024.6.2c"
PR = "1.el10_0"
PACKAGES = " \
 vaultwarden-web \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vaultwarden-web-2024.6.2c-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "94d9a773c5a387fd2e38c469160849633276521b48c72955f47f31bca4688ecb"

URI_x86_64_v2_vaultwarden-web = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vaultwarden-web-2024.6.2c-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_vaultwarden-web;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vaultwarden-web}"
SRC_URI[x86_64_v2_vaultwarden-web.sha256sum] = "bd5ce9d3ffd9bc8feb3ce148692da19a00d6bacf11d75f83f3b2bf9a47c8fb93"

URI_aarch64_vaultwarden-web = "${EPEL_MIRROR}/aarch64/Packages/v/vaultwarden-web-2024.6.2c-1.el10_0.noarch.rpm;name=aarch64_vaultwarden-web;unpack=0"
SRC_URI:append = " ${URI_aarch64_vaultwarden-web}"
SRC_URI[aarch64_vaultwarden-web.sha256sum] = "ba8eb515edb64643bad96ab3e76efb17ec0ab96843bff2b8e38d7877e61c4234"

RDEPENDS:vaultwarden-web = " \
 "
