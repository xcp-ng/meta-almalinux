# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-color_quant"
PV = "1.1.0"
PR = "11.el10_0"
PACKAGES = " \
 rust-color_quant+default-devel \
 rust-color_quant-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-color_quant-1.1.0-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "753d51b1f1fd55dd72a306804ee1ea88fae69abb264ef2dabda9045ff2b44a07"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-color_quant+default-devel-1.1.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-color_quant+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-color_quant+default-devel.sha256sum] = "aa17cb240d9ce31becc756ecda66f45a58994f1297095155aa44b1a25a926df4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-color_quant-devel-1.1.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-color_quant-devel;unpack=0"
SRC_URI[x86_64_v2_rust-color_quant-devel.sha256sum] = "6ae31327c3e7152015ad7984409dbec15445bded5d04c80c6b0e4a6ddeeb7007"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-color_quant+default-devel-1.1.0-11.el10_0.noarch.rpm;name=aarch64_rust-color_quant+default-devel;unpack=0"
SRC_URI[aarch64_rust-color_quant+default-devel.sha256sum] = "aaf30002f6a79d36f7679879cb8eacaadb0b3397894858727d320cdebb5df1dd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-color_quant-devel-1.1.0-11.el10_0.noarch.rpm;name=aarch64_rust-color_quant-devel;unpack=0"
SRC_URI[aarch64_rust-color_quant-devel.sha256sum] = "a4dea4e8cb82e0d85a3bc1f23231c89832e7ba3a74a0d0c2c02a89bfb2308494"

RDEPENDS:rust-color_quant+default-devel = " \
 cargo \
 rust-color_quant-devel \
 "
RDEPENDS:rust-color_quant-devel = " \
 cargo \
 "
