# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tiny_http"
PV = "0.12.0"
PR = "8.el10_2"
PACKAGES = " \
 rust-tiny_http+default-devel \
 rust-tiny_http+openssl-devel \
 rust-tiny_http+ssl-devel \
 rust-tiny_http+ssl-openssl-devel \
 rust-tiny_http+zeroize-devel \
 rust-tiny_http-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tiny_http-0.12.0-8.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c799d337df141ff8d09a4020d9b627a6f5382c1ec1b642851219d013b71e59ea"

URI_x86_64_v2_rust-tiny_http+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiny_http+default-devel-0.12.0-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiny_http+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiny_http+default-devel}"
SRC_URI[x86_64_v2_rust-tiny_http+default-devel.sha256sum] = "40eca1859d9f7bc5490613c894efd1205fed2f6299baf4c9c3dcf398fb4962e5"

URI_x86_64_v2_rust-tiny_http+openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiny_http+openssl-devel-0.12.0-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiny_http+openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiny_http+openssl-devel}"
SRC_URI[x86_64_v2_rust-tiny_http+openssl-devel.sha256sum] = "b0f00ca1c60d8badfdda6bff19d490ccbbef0bb3a914129b768be368cf7ff40f"

URI_x86_64_v2_rust-tiny_http+ssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiny_http+ssl-devel-0.12.0-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiny_http+ssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiny_http+ssl-devel}"
SRC_URI[x86_64_v2_rust-tiny_http+ssl-devel.sha256sum] = "0401593e6af792a164d305df17d50a30f5831b0d136b5527750268f741ab1977"

URI_x86_64_v2_rust-tiny_http+ssl-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiny_http+ssl-openssl-devel-0.12.0-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiny_http+ssl-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiny_http+ssl-openssl-devel}"
SRC_URI[x86_64_v2_rust-tiny_http+ssl-openssl-devel.sha256sum] = "f74a5957318bc455c16cb7d2b4b666f5fc7f9dee8b3cb32a0957541889b8f8f1"

URI_x86_64_v2_rust-tiny_http+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiny_http+zeroize-devel-0.12.0-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiny_http+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiny_http+zeroize-devel}"
SRC_URI[x86_64_v2_rust-tiny_http+zeroize-devel.sha256sum] = "f442612f5a0da223e35ad7e76ae65c3ca219fe3c791ad8dd072bb7b019b4c2e1"

URI_x86_64_v2_rust-tiny_http-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiny_http-devel-0.12.0-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiny_http-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiny_http-devel}"
SRC_URI[x86_64_v2_rust-tiny_http-devel.sha256sum] = "4597352290bfaacb2bfba6d50b8a5f35303fe967f3e4bdcc4e5614c77120835c"

URI_aarch64_rust-tiny_http+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiny_http+default-devel-0.12.0-8.el10_2.noarch.rpm;name=aarch64_rust-tiny_http+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiny_http+default-devel}"
SRC_URI[aarch64_rust-tiny_http+default-devel.sha256sum] = "293f7da99042f761398161c6088a43c58cd8a7413d99b0bc6c49ea2e6793d5c3"

URI_aarch64_rust-tiny_http+openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiny_http+openssl-devel-0.12.0-8.el10_2.noarch.rpm;name=aarch64_rust-tiny_http+openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiny_http+openssl-devel}"
SRC_URI[aarch64_rust-tiny_http+openssl-devel.sha256sum] = "8e6db1f46b33cf558b7edba39c7bc2142a13b8b3a3dd9463cce276fc825bf814"

URI_aarch64_rust-tiny_http+ssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiny_http+ssl-devel-0.12.0-8.el10_2.noarch.rpm;name=aarch64_rust-tiny_http+ssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiny_http+ssl-devel}"
SRC_URI[aarch64_rust-tiny_http+ssl-devel.sha256sum] = "fb5d5580ee23478981d0d5f9485ad4b6fefb405c8254a8124399379221844103"

URI_aarch64_rust-tiny_http+ssl-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiny_http+ssl-openssl-devel-0.12.0-8.el10_2.noarch.rpm;name=aarch64_rust-tiny_http+ssl-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiny_http+ssl-openssl-devel}"
SRC_URI[aarch64_rust-tiny_http+ssl-openssl-devel.sha256sum] = "0e6207facc3a4b4f97067ffa71d40daf07ba448aaa3d0c81f7d34b218c6e1005"

URI_aarch64_rust-tiny_http+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiny_http+zeroize-devel-0.12.0-8.el10_2.noarch.rpm;name=aarch64_rust-tiny_http+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiny_http+zeroize-devel}"
SRC_URI[aarch64_rust-tiny_http+zeroize-devel.sha256sum] = "513a71c97eaa6003fdc067a56bbdfcf454ce72026a264ff3062434eaa854d9e5"

URI_aarch64_rust-tiny_http-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiny_http-devel-0.12.0-8.el10_2.noarch.rpm;name=aarch64_rust-tiny_http-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiny_http-devel}"
SRC_URI[aarch64_rust-tiny_http-devel.sha256sum] = "0773de35473b6825f5ed70bb1f89ad60d227ea404a53f734016f8d054ed17c79"

RDEPENDS:rust-tiny_http+default-devel = " \
 cargo \
 rust-tiny_http-devel \
 "
RDEPENDS:rust-tiny_http+openssl-devel = " \
 cargo \
 rust-openssl+default-devel \
 rust-tiny_http-devel \
 "
RDEPENDS:rust-tiny_http+ssl-devel = " \
 cargo \
 rust-tiny_http+ssl-openssl-devel \
 rust-tiny_http-devel \
 "
RDEPENDS:rust-tiny_http+ssl-openssl-devel = " \
 cargo \
 rust-tiny_http+openssl-devel \
 rust-tiny_http+zeroize-devel \
 rust-tiny_http-devel \
 "
RDEPENDS:rust-tiny_http+zeroize-devel = " \
 cargo \
 rust-tiny_http-devel \
 rust-zeroize+default-devel \
 "
RDEPENDS:rust-tiny_http-devel = " \
 cargo \
 rust-ascii+default-devel \
 rust-chunked_transfer+default-devel \
 rust-httpdate+default-devel \
 rust-log+default-devel \
 "
