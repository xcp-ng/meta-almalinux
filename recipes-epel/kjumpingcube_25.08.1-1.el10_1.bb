# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kjumpingcube"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kjumpingcube \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kjumpingcube-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c1c2c0f88709a2bbdc8c5dcf392d605c6eb3cbdaa306deaa5a3b6c1cb1b8bb3"

URI_x86_64_v2_kjumpingcube = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kjumpingcube-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kjumpingcube;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kjumpingcube}"
SRC_URI[x86_64_v2_kjumpingcube.sha256sum] = "d19deabc822c4a79dc4be6a28ff57d5360878f0b09adf84e91ce67ba24177fe9"

URI_aarch64_kjumpingcube = "${EPEL_MIRROR}/aarch64/Packages/k/kjumpingcube-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kjumpingcube;unpack=0"
SRC_URI:append = " ${URI_aarch64_kjumpingcube}"
SRC_URI[aarch64_kjumpingcube.sha256sum] = "fa20262e1b5a07315ae8b121ac87b9f98f3bb5bce075f3d5434252cc9952fb10"

RDEPENDS:kjumpingcube = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
