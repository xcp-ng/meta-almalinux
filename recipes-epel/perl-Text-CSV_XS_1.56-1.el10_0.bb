# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Text-CSV_XS"
PV = "1.56"
PR = "1.el10_0"
PACKAGES = " \
 perl-Text-CSV_XS \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Text-CSV_XS-1.56-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d4f1348ec8a3944f582d25765c86ec48de168821cfe2f373e8dc798bd503b71e"

URI_x86_64_v2_perl-Text-CSV_XS = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Text-CSV_XS-1.56-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Text-CSV_XS;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Text-CSV_XS}"
SRC_URI[x86_64_v2_perl-Text-CSV_XS.sha256sum] = "6d60f0e853d597e24eb189dd3e4928b6493787da5c6d00ef8b5fe2d268716218"

URI_aarch64_perl-Text-CSV_XS = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Text-CSV_XS-1.56-1.el10_0.aarch64.rpm;name=aarch64_perl-Text-CSV_XS;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Text-CSV_XS}"
SRC_URI[aarch64_perl-Text-CSV_XS.sha256sum] = "c8f9931e61c0ad4fe1b17aacd114da639821386e7ed62677f300f2662d708b31"

RDEPENDS:perl-Text-CSV_XS = " \
 glibc \
 perl-Carp \
 perl-Encode \
 perl-Exporter \
 perl-IO \
 perl-UNIVERSAL-isa \
 perl-libs \
 perl-vars \
 "
