# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "marble"
PE = "1"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 marble \
 marble-astro \
 marble-astro-devel \
 marble-common \
 marble-plasma \
 marble-qt \
 marble-widget-data \
 marble-widget-qt6 \
 marble-widget-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/marble-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f9791d8797b559b62011a91ae4d70f0c362cc9838e5336585281e19107529da"

URI_x86_64_v2_marble = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble}"
SRC_URI[x86_64_v2_marble.sha256sum] = "8ca67fd7490afec1547159c6d1b96a4d6863861c2c7dba8ea756e9d4c4581423"

URI_x86_64_v2_marble-astro = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-astro-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble-astro;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble-astro}"
SRC_URI[x86_64_v2_marble-astro.sha256sum] = "6a29060c5d7aedd4d78290f8d94512922c1cc637bc969842a1efdd37b310dd47"

URI_x86_64_v2_marble-astro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-astro-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble-astro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble-astro-devel}"
SRC_URI[x86_64_v2_marble-astro-devel.sha256sum] = "ddf2b974e2a96f05965fbd62404756520747d578728c0cf8dc5e19ff3a090372"

URI_x86_64_v2_marble-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-common-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_marble-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble-common}"
SRC_URI[x86_64_v2_marble-common.sha256sum] = "bcd231f697d3d4a0614070cafcd446404d3f84e9825acbe0622aed2ebaab71f1"

URI_x86_64_v2_marble-plasma = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-plasma-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble-plasma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble-plasma}"
SRC_URI[x86_64_v2_marble-plasma.sha256sum] = "e5f21b4a100318ab1f222fad048856b18ef08aabf9d38652fc8d76e8e2c8358f"

URI_x86_64_v2_marble-qt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-qt-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble-qt}"
SRC_URI[x86_64_v2_marble-qt.sha256sum] = "8acb6b471621a7ab0e19e4a85a391fcd93840ec57b9d3555c74bb6bccc99507a"

URI_x86_64_v2_marble-widget-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-widget-data-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_marble-widget-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble-widget-data}"
SRC_URI[x86_64_v2_marble-widget-data.sha256sum] = "024d3137d0e757f94098b3dcd95d15e28ec22fac92d86a5048903342f32f35f9"

URI_x86_64_v2_marble-widget-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-widget-qt6-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble-widget-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble-widget-qt6}"
SRC_URI[x86_64_v2_marble-widget-qt6.sha256sum] = "6564f2f5ec2aa3651a2c0d50a4d3a8a718d3330e965e90e1976f640ece6fd7c7"

URI_x86_64_v2_marble-widget-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-widget-qt6-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble-widget-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble-widget-qt6-devel}"
SRC_URI[x86_64_v2_marble-widget-qt6-devel.sha256sum] = "410b7105a1e4e047e3b0bf29a91b472717eb8c7574cbd8001d9a341cd0a5def2"

URI_aarch64_marble = "${EPEL_MIRROR}/aarch64/Packages/m/marble-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_marble;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble}"
SRC_URI[aarch64_marble.sha256sum] = "e6016c2c76086b2a6c4a10f68e00b2120df484a7bf6ab9a74263fefde7270ba1"

URI_aarch64_marble-astro = "${EPEL_MIRROR}/aarch64/Packages/m/marble-astro-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_marble-astro;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble-astro}"
SRC_URI[aarch64_marble-astro.sha256sum] = "4f686b05b02fbfe9099c82058445d2be52d69cafa16b7a90719710250af5dd2e"

URI_aarch64_marble-astro-devel = "${EPEL_MIRROR}/aarch64/Packages/m/marble-astro-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_marble-astro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble-astro-devel}"
SRC_URI[aarch64_marble-astro-devel.sha256sum] = "1ec5362b7d0a1f3a664bf729b31de726cf76149554cdbf40b1330e0b6db1e4f4"

URI_aarch64_marble-common = "${EPEL_MIRROR}/aarch64/Packages/m/marble-common-25.08.1-1.el10_1.noarch.rpm;name=aarch64_marble-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble-common}"
SRC_URI[aarch64_marble-common.sha256sum] = "b0241792c872d0b223c5810f5eb3c6d07d1caf636c744e2685909cd121b156a4"

URI_aarch64_marble-plasma = "${EPEL_MIRROR}/aarch64/Packages/m/marble-plasma-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_marble-plasma;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble-plasma}"
SRC_URI[aarch64_marble-plasma.sha256sum] = "71c7dede2c08410ac72b680791f3e1d415a15662d3e0a47224561f0bc92b37e0"

URI_aarch64_marble-qt = "${EPEL_MIRROR}/aarch64/Packages/m/marble-qt-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_marble-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble-qt}"
SRC_URI[aarch64_marble-qt.sha256sum] = "f4f476c50d9077f790a84cb4482720acef12751a0ad7524909d9999ab7b3e9dc"

URI_aarch64_marble-widget-data = "${EPEL_MIRROR}/aarch64/Packages/m/marble-widget-data-25.08.1-1.el10_1.noarch.rpm;name=aarch64_marble-widget-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble-widget-data}"
SRC_URI[aarch64_marble-widget-data.sha256sum] = "fa3d68e860ceece91b6e2adeed0c00c0341e255183513178bec969c10255d6ff"

URI_aarch64_marble-widget-qt6 = "${EPEL_MIRROR}/aarch64/Packages/m/marble-widget-qt6-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_marble-widget-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble-widget-qt6}"
SRC_URI[aarch64_marble-widget-qt6.sha256sum] = "0636aa66f21f376bc5e77765c23eb82080e2b91fdbdf4daf30618ea5275e4198"

URI_aarch64_marble-widget-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/m/marble-widget-qt6-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_marble-widget-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble-widget-qt6-devel}"
SRC_URI[aarch64_marble-widget-qt6-devel.sha256sum] = "35cf0cb5221d9f24180f0c2de14f4967e2d606cc843edbef34919965371419a9"

RDEPENDS:marble = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 marble-widget-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebengine \
 "
RDEPENDS:marble-astro = " \
 glibc \
 libstdc++ \
 marble-common \
 "
RDEPENDS:marble-astro-devel = " \
 cmake-filesystem \
 marble-astro \
 "
RDEPENDS:marble-common = " \
 "
RDEPENDS:marble-plasma = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-krunner \
 libstdc++ \
 marble-common \
 marble-widget-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:marble-qt = " \
 glibc \
 libstdc++ \
 marble-common \
 marble-widget-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:marble-widget-data = " \
 marble-common \
 "
RDEPENDS:marble-widget-qt6 = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 marble-astro \
 marble-widget-data \
 phonon-qt6 \
 protobuf \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtpositioning \
 qt6-qtserialport \
 qt6-qtsvg \
 qt6-qtwebchannel \
 qt6-qtwebengine \
 shapelib \
 zlib-ng-compat \
 "
RDEPENDS:marble-widget-qt6-devel = " \
 cmake-filesystem \
 marble-widget-qt6 \
 qt6-qt5compat-devel \
 qt6-qtbase-devel \
 qt6-qtwebengine-devel \
 "
