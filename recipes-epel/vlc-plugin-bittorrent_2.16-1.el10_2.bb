# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vlc-plugin-bittorrent"
PV = "2.16"
PR = "1.el10_2"
PACKAGES = " \
 vlc-plugin-bittorrent \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vlc-plugin-bittorrent-2.16-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be5215d4c99f84daa11c54213f6d3755c4caf930d214a7533f2ac05cc6c06a85"

URI_x86_64_v2_vlc-plugin-bittorrent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-bittorrent-2.16-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-bittorrent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-bittorrent}"
SRC_URI[x86_64_v2_vlc-plugin-bittorrent.sha256sum] = "1297365ea6cc7d796f4155bfe3a1c91da9789aa63ffca780db551cb2f34dd7df"

URI_aarch64_vlc-plugin-bittorrent = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-bittorrent-2.16-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugin-bittorrent;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-bittorrent}"
SRC_URI[aarch64_vlc-plugin-bittorrent.sha256sum] = "af6deacb9c85b046cce3fdab4c6a39d2a43f81e52659114b54ceaaf8974f73f9"

RDEPENDS:vlc-plugin-bittorrent = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 rb_libtorrent \
 vlc-libs \
 vlc-plugins-base \
 "
