# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reflink-copy"
PV = "0.1.24"
PR = "1.el10_0"
PACKAGES = " \
 rust-reflink-copy+default-devel \
 rust-reflink-copy+tracing-devel \
 rust-reflink-copy-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reflink-copy-0.1.24-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "867066082b8bd05ab81edf770eced216712e9df43e8bdea304775e0a15b1ce36"

URI_x86_64_v2_rust-reflink-copy+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reflink-copy+default-devel-0.1.24-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reflink-copy+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reflink-copy+default-devel}"
SRC_URI[x86_64_v2_rust-reflink-copy+default-devel.sha256sum] = "ca9355a0f8f5cd0f6f16f715c1a15eb8d37a2b65944746cde8258b47101f9f1f"

URI_x86_64_v2_rust-reflink-copy+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reflink-copy+tracing-devel-0.1.24-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reflink-copy+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reflink-copy+tracing-devel}"
SRC_URI[x86_64_v2_rust-reflink-copy+tracing-devel.sha256sum] = "cb25de8bfef3b44ee55a5ae00cd1fa47180f141245a260b9e0edd3dc956793a8"

URI_x86_64_v2_rust-reflink-copy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reflink-copy-devel-0.1.24-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reflink-copy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reflink-copy-devel}"
SRC_URI[x86_64_v2_rust-reflink-copy-devel.sha256sum] = "d709471509a5211ddd352de8f70bc39ebfb1fe46dbca43345a1e95fa88dd1c56"

URI_aarch64_rust-reflink-copy+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reflink-copy+default-devel-0.1.24-1.el10_0.noarch.rpm;name=aarch64_rust-reflink-copy+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reflink-copy+default-devel}"
SRC_URI[aarch64_rust-reflink-copy+default-devel.sha256sum] = "1aedeb36c1aac937121a1f1f5adc3d03f54d84cc6f7b788abc9ee0f1df3b1432"

URI_aarch64_rust-reflink-copy+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reflink-copy+tracing-devel-0.1.24-1.el10_0.noarch.rpm;name=aarch64_rust-reflink-copy+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reflink-copy+tracing-devel}"
SRC_URI[aarch64_rust-reflink-copy+tracing-devel.sha256sum] = "0cb3642b13a97ced17a08dfce4c98e2625bb0392d0f41093221c040480ca4641"

URI_aarch64_rust-reflink-copy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reflink-copy-devel-0.1.24-1.el10_0.noarch.rpm;name=aarch64_rust-reflink-copy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reflink-copy-devel}"
SRC_URI[aarch64_rust-reflink-copy-devel.sha256sum] = "5c897cd4ce33e7cb2d7e3f079f4080276dc285a6a08147603738a4220839c297"

RDEPENDS:rust-reflink-copy+default-devel = " \
 cargo \
 rust-reflink-copy-devel \
 "
RDEPENDS:rust-reflink-copy+tracing-devel = " \
 cargo \
 rust-reflink-copy-devel \
 rust-tracing-attributes+default-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-reflink-copy-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 rust-rustix+fs-devel \
 rust-rustix+std-devel \
 rust-rustix-devel \
 "
