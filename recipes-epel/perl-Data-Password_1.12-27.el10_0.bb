# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Data-Password"
PV = "1.12"
PR = "27.el10_0"
PACKAGES = " \
 perl-Data-Password \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Data-Password-1.12-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b095b066f02aff0cc150df9089aeb07929d479db96e4cd5db95c2d383abf1bc"

URI_x86_64_v2_perl-Data-Password = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Data-Password-1.12-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Data-Password;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Data-Password}"
SRC_URI[x86_64_v2_perl-Data-Password.sha256sum] = "c52d33000df1570e360eda5f6e738835f3ef5f6d91f7c8ff6c92d5ad494cb674"

URI_aarch64_perl-Data-Password = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Data-Password-1.12-27.el10_0.noarch.rpm;name=aarch64_perl-Data-Password;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Data-Password}"
SRC_URI[aarch64_perl-Data-Password.sha256sum] = "be93c89088945845ea462fb0643053c62690eef825751398768022d056bd2a77"

RDEPENDS:perl-Data-Password = " \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
