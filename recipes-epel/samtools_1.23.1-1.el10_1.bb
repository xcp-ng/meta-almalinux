# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "samtools"
PV = "1.23.1"
PR = "1.el10_1"
PACKAGES = " \
 samtools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/samtools-1.23.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d7100b69b7c019492e52040316aad49b044648e83a814d6ce614745f626ce38e"

URI_x86_64_v2_samtools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/samtools-1.23.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_samtools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samtools}"
SRC_URI[x86_64_v2_samtools.sha256sum] = "c736ee7064d6c840eda228e6559d4b48157781b1760b9dbb1abfd7b9072df91e"

URI_aarch64_samtools = "${EPEL_MIRROR}/aarch64/Packages/s/samtools-1.23.1-1.el10_1.aarch64.rpm;name=aarch64_samtools;unpack=0"
SRC_URI:append = " ${URI_aarch64_samtools}"
SRC_URI[aarch64_samtools.sha256sum] = "3752964c2a5fdeb5f49c6ea28dd6d761c563c492b7162a838fb32827c5129429"

RDEPENDS:samtools = " \
 glibc \
 htslib \
 ncurses-libs \
 perl-interpreter \
 zlib-ng-compat \
 "
