# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-DAV"
PV = "1.3.4"
PR = "20.el10_0"
PACKAGES = " \
 ghc-DAV \
 ghc-DAV-devel \
 ghc-DAV-doc \
 ghc-DAV-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-DAV-1.3.4-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e1d1758898df86be688f07dbab8657edfc2a9dc27635860ed8cd251cd11e5942"

URI_x86_64_v2_ghc-DAV = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-DAV-1.3.4-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-DAV;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-DAV}"
SRC_URI[x86_64_v2_ghc-DAV.sha256sum] = "c5dd2441d9218c36cbbc572e6b23740f8a2af69455af20bf932326000eb4d461"

URI_x86_64_v2_ghc-DAV-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-DAV-devel-1.3.4-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-DAV-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-DAV-devel}"
SRC_URI[x86_64_v2_ghc-DAV-devel.sha256sum] = "37217e230690795e5f1d9ff287aa3ef63f7fe2483b75bb7c8171c20c9af4d658"

URI_x86_64_v2_ghc-DAV-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-DAV-doc-1.3.4-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-DAV-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-DAV-doc}"
SRC_URI[x86_64_v2_ghc-DAV-doc.sha256sum] = "e834a8150c9e14f84003cba1d5315e9dadfd9611b16eb1c623400cb6b31f2790"

URI_x86_64_v2_ghc-DAV-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-DAV-prof-1.3.4-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-DAV-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-DAV-prof}"
SRC_URI[x86_64_v2_ghc-DAV-prof.sha256sum] = "7998dcdadcbd6416bad6eb44e65e436c832718e240221d81bb3725ed702833f6"

URI_aarch64_ghc-DAV = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-DAV-1.3.4-20.el10_0.aarch64.rpm;name=aarch64_ghc-DAV;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-DAV}"
SRC_URI[aarch64_ghc-DAV.sha256sum] = "6abf64f8ce554761b9215a6ec3d1dbffc43e18ec0fa7ae2b38ea84daa62ec5e3"

URI_aarch64_ghc-DAV-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-DAV-devel-1.3.4-20.el10_0.aarch64.rpm;name=aarch64_ghc-DAV-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-DAV-devel}"
SRC_URI[aarch64_ghc-DAV-devel.sha256sum] = "69f546cdc36860906ff5529a310f16692b02396037a503bd9e1894bd82343f73"

URI_aarch64_ghc-DAV-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-DAV-doc-1.3.4-20.el10_0.noarch.rpm;name=aarch64_ghc-DAV-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-DAV-doc}"
SRC_URI[aarch64_ghc-DAV-doc.sha256sum] = "517bd4cdee827d316d0c3a48c4e0353a646c921647f24b7fe5536a4aee3e6c30"

URI_aarch64_ghc-DAV-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-DAV-prof-1.3.4-20.el10_0.aarch64.rpm;name=aarch64_ghc-DAV-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-DAV-prof}"
SRC_URI[aarch64_ghc-DAV-prof.sha256sum] = "6780b75faf1cf26fad93377df7ac4712305761533f63c7cca351ad9b0dbaff1e"

RDEPENDS:ghc-DAV = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-adjunctions \
 ghc-aeson \
 ghc-appar \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-basement \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-byteorder \
 ghc-bytestring \
 ghc-call-stack \
 ghc-case-insensitive \
 ghc-cereal \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-crypton \
 ghc-crypton-connection \
 ghc-crypton-x509 \
 ghc-crypton-x509-store \
 ghc-crypton-x509-system \
 ghc-crypton-x509-validation \
 ghc-data-default \
 ghc-data-default-class \
 ghc-data-default-instances-containers \
 ghc-data-default-instances-dlist \
 ghc-data-default-instances-old-locale \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-file-embed \
 ghc-filepath \
 ghc-free \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hourglass \
 ghc-http-client \
 ghc-http-client-tls \
 ghc-http-types \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-invariant \
 ghc-iproute \
 ghc-kan-extensions \
 ghc-lens \
 ghc-memory \
 ghc-mime-types \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-network-uri \
 ghc-old-locale \
 ghc-old-time \
 ghc-os-string \
 ghc-parallel \
 ghc-parsec \
 ghc-pem \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-profunctors \
 ghc-random \
 ghc-reflection \
 ghc-resourcet \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-semigroups \
 ghc-shakespeare \
 ghc-socks \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-compat \
 ghc-th-lift \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-tls \
 ghc-transformers \
 ghc-transformers-base \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-unix \
 ghc-unix-time \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-utf8-string \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-void \
 ghc-witherable \
 ghc-xml-conduit \
 ghc-xml-hamlet \
 ghc-xml-types \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-DAV-devel = " \
 ghc-DAV \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-case-insensitive-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-data-default-devel \
 ghc-exceptions-devel \
 ghc-http-client-devel \
 ghc-http-client-tls-devel \
 ghc-http-types-devel \
 ghc-lens-devel \
 ghc-mtl-devel \
 ghc-transformers-base-devel \
 ghc-transformers-compat-devel \
 ghc-transformers-devel \
 ghc-utf8-string-devel \
 ghc-xml-conduit-devel \
 ghc-xml-hamlet-devel \
 glibc \
 gmp \
 libffi \
 ncurses-libs \
 zlib-ng-compat \
 "
RDEPENDS:ghc-DAV-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-DAV-prof = " \
 ghc-DAV-devel \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-case-insensitive-prof \
 ghc-containers-prof \
 ghc-data-default-prof \
 ghc-exceptions-prof \
 ghc-http-client-prof \
 ghc-http-client-tls-prof \
 ghc-http-types-prof \
 ghc-lens-prof \
 ghc-mtl-prof \
 ghc-transformers-base-prof \
 ghc-transformers-compat-prof \
 ghc-transformers-prof \
 ghc-utf8-string-prof \
 ghc-xml-conduit-prof \
 ghc-xml-hamlet-prof \
 "
