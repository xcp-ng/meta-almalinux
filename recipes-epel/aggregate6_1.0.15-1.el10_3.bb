# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aggregate6"
PV = "1.0.15"
PR = "1.el10_3"
PACKAGES = " \
 aggregate6 \
 python3-aggregate6 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aggregate6-1.0.15-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ecd34f5ccbbfe0c714798f91e87072c797ddc2b2733a048c52b117648cb9e92"

URI_x86_64_v2_aggregate6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aggregate6-1.0.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_aggregate6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aggregate6}"
SRC_URI[x86_64_v2_aggregate6.sha256sum] = "ce369d6252197b8d92794cedf2394c6268928aa3034246bc6725b844381d2736"

URI_x86_64_v2_python3-aggregate6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-aggregate6-1.0.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-aggregate6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-aggregate6}"
SRC_URI[x86_64_v2_python3-aggregate6.sha256sum] = "39a17aea4478975ee2a0dc044fff76ab344b7a6e5323ea6b9291a67bcaa7c18d"

URI_aarch64_aggregate6 = "${EPEL_MIRROR}/aarch64/Packages/a/aggregate6-1.0.15-1.el10_3.noarch.rpm;name=aarch64_aggregate6;unpack=0"
SRC_URI:append = " ${URI_aarch64_aggregate6}"
SRC_URI[aarch64_aggregate6.sha256sum] = "3d177237e7d8c72715896bdd756f40c2df3a56adc41718648e10d1fd5dc7521e"

URI_aarch64_python3-aggregate6 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-aggregate6-1.0.15-1.el10_3.noarch.rpm;name=aarch64_python3-aggregate6;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-aggregate6}"
SRC_URI[aarch64_python3-aggregate6.sha256sum] = "70d4fc71c8b7ab77f7c2e202ee82c5e56bc41c956061d0191ce5b5dba6e7507f"

RDEPENDS:aggregate6 = " \
 python3 \
 python3-aggregate6 \
 "
RDEPENDS:python3-aggregate6 = " \
 python3 \
 python3-py-radix \
 "
