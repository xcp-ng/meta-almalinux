# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-steampunk-spotter"
PV = "5.6.0"
PR = "3.el10_1"
PACKAGES = " \
 python3-steampunk-spotter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-steampunk-spotter-5.6.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c956b2c2ef041757fe249097da480f5c17dbfc52afdcca6a2c715a06985041a"

URI_x86_64_v2_python3-steampunk-spotter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-steampunk-spotter-5.6.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-steampunk-spotter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-steampunk-spotter}"
SRC_URI[x86_64_v2_python3-steampunk-spotter.sha256sum] = "f1ed4fdce926d609be245dc5016568820f1ada8a13cd52a7736310cf41174a00"

URI_aarch64_python3-steampunk-spotter = "${EPEL_MIRROR}/aarch64/Packages/p/python3-steampunk-spotter-5.6.0-3.el10_1.noarch.rpm;name=aarch64_python3-steampunk-spotter;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-steampunk-spotter}"
SRC_URI[aarch64_python3-steampunk-spotter.sha256sum] = "4bf0494ad39ba60e8a7826b5d37f1569c8f6466841e231fa120f3519f5baf78c"

RDEPENDS:python3-steampunk-spotter = " \
 python3 \
 python3-colorama \
 python3-detect-secrets \
 python3-pydantic \
 python3-requests \
 python3-rich \
 python3-ruamel-yaml \
 "
