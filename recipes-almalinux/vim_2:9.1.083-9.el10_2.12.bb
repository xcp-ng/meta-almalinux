# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vim"
PE = "2"
PV = "9.1.083"
PR = "9.el10_2.12"
PACKAGES = " \
 vim-X11 \
 vim-common \
 vim-data \
 vim-enhanced \
 vim-filesystem \
 vim-minimal \
 xxd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/vim-9.1.083-9.el10_2.12.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2670005bfb76408cbaa0ee12e4c59ab2ad265b7f1684b9f7ea0e25c714cc9afe"

URI_x86_64_v2_vim-X11 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vim-X11-9.1.083-9.el10_2.12.x86_64_v2.rpm;name=x86_64_v2_vim-X11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vim-X11}"
SRC_URI[x86_64_v2_vim-X11.sha256sum] = "6e3d2eac70e13ea7520bbc453314b0d6d09c7c785faad12b0c09deddb475355d"
RPROVIDES:vim-X11:x86_64_v2 = "virtual/vim-enhanced_or_vim-X11"

URI_x86_64_v2_vim-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vim-common-9.1.083-9.el10_2.12.x86_64_v2.rpm;name=x86_64_v2_vim-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vim-common}"
SRC_URI[x86_64_v2_vim-common.sha256sum] = "e7825c480444fb15a84ff596b569f98ce0610b0b1e55e9b16f76d94116a7f66d"

URI_x86_64_v2_vim-data = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/vim-data-9.1.083-9.el10_2.12.noarch.rpm;name=x86_64_v2_vim-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vim-data}"
SRC_URI[x86_64_v2_vim-data.sha256sum] = "5b736089a07c6439dc37a021c32026bbdfb8e24b93fb34abc79149c62f187f16"

URI_x86_64_v2_vim-enhanced = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vim-enhanced-9.1.083-9.el10_2.12.x86_64_v2.rpm;name=x86_64_v2_vim-enhanced;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vim-enhanced}"
SRC_URI[x86_64_v2_vim-enhanced.sha256sum] = "50ad672efdc2df4ef8c88f9e51afb36c1b1a7238fe6ecf4e0e336854db8c2449"
RPROVIDES:vim-enhanced:x86_64_v2 = "virtual/vim-enhanced_or_vim-X11"

URI_x86_64_v2_vim-filesystem = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/vim-filesystem-9.1.083-9.el10_2.12.noarch.rpm;name=x86_64_v2_vim-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vim-filesystem}"
SRC_URI[x86_64_v2_vim-filesystem.sha256sum] = "3c2582457904d55da8957534beb9b5db4fa1b5fd46336818b97f1c75a18ae61c"

URI_x86_64_v2_vim-minimal = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/vim-minimal-9.1.083-9.el10_2.12.x86_64_v2.rpm;name=x86_64_v2_vim-minimal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vim-minimal}"
SRC_URI[x86_64_v2_vim-minimal.sha256sum] = "2feee74fc46eab2dc469adb5af88b6d8c17905c45d5a9ba2e176c29b2a7b43f7"

URI_x86_64_v2_xxd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xxd-9.1.083-9.el10_2.12.x86_64_v2.rpm;name=x86_64_v2_xxd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xxd}"
SRC_URI[x86_64_v2_xxd.sha256sum] = "560e6b4bc2fc2335bbd243471a8055c985a71c73e87c89ec19047a417008ecec"

URI_aarch64_vim-X11 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vim-X11-9.1.083-9.el10_2.12.aarch64.rpm;name=aarch64_vim-X11;unpack=0"
SRC_URI:append = " ${URI_aarch64_vim-X11}"
SRC_URI[aarch64_vim-X11.sha256sum] = "de3a1655f08e36b50e763133998c3f3e55f8357e537f34d562f675215cc52d62"
RPROVIDES:vim-X11:aarch64 = "virtual/vim-enhanced_or_vim-X11"

URI_aarch64_vim-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vim-common-9.1.083-9.el10_2.12.aarch64.rpm;name=aarch64_vim-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_vim-common}"
SRC_URI[aarch64_vim-common.sha256sum] = "cce60fc8141233c58a1c4bf8f5b4b7fb9a28445cb2a17747fa866d0a6b2738c8"

URI_aarch64_vim-data = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/vim-data-9.1.083-9.el10_2.12.noarch.rpm;name=aarch64_vim-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_vim-data}"
SRC_URI[aarch64_vim-data.sha256sum] = "5b736089a07c6439dc37a021c32026bbdfb8e24b93fb34abc79149c62f187f16"

URI_aarch64_vim-enhanced = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vim-enhanced-9.1.083-9.el10_2.12.aarch64.rpm;name=aarch64_vim-enhanced;unpack=0"
SRC_URI:append = " ${URI_aarch64_vim-enhanced}"
SRC_URI[aarch64_vim-enhanced.sha256sum] = "4b398190dd889152c155117a7b6382b39d87e63cd67e79a800f60d06b6badce3"
RPROVIDES:vim-enhanced:aarch64 = "virtual/vim-enhanced_or_vim-X11"

URI_aarch64_vim-filesystem = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/vim-filesystem-9.1.083-9.el10_2.12.noarch.rpm;name=aarch64_vim-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_vim-filesystem}"
SRC_URI[aarch64_vim-filesystem.sha256sum] = "3c2582457904d55da8957534beb9b5db4fa1b5fd46336818b97f1c75a18ae61c"

URI_aarch64_vim-minimal = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/vim-minimal-9.1.083-9.el10_2.12.aarch64.rpm;name=aarch64_vim-minimal;unpack=0"
SRC_URI:append = " ${URI_aarch64_vim-minimal}"
SRC_URI[aarch64_vim-minimal.sha256sum] = "e461c315befff6a65a1e16ba0841f3cf0ffff788e8272a35f689ae88939b290c"

URI_aarch64_xxd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xxd-9.1.083-9.el10_2.12.aarch64.rpm;name=aarch64_xxd;unpack=0"
SRC_URI:append = " ${URI_aarch64_xxd}"
SRC_URI[aarch64_xxd.sha256sum] = "8de0cbfc5604799eef56aba714d8cc6e86960c9d9d6a751a8bd7022ae4b2c103"

RDEPENDS:vim-X11 = " \
 bash \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 hicolor-icon-theme \
 libICE \
 libSM \
 libX11 \
 libXt \
 libacl \
 libattr \
 libcanberra \
 libselinux \
 ncurses-libs \
 pango \
 vim-common \
 "
RDEPENDS:vim-common = " \
 bash \
 vim-data \
 vim-filesystem \
 xxd \
 "
RDEPENDS:vim-data = " \
 "
RDEPENDS:vim-enhanced = " \
 bash \
 glibc \
 libacl \
 libselinux \
 ncurses-libs \
 vim-common \
 which \
 "
RDEPENDS:vim-filesystem = " \
 "
RDEPENDS:vim-minimal = " \
 bash \
 glibc \
 libacl \
 libselinux \
 ncurses-libs \
 vim-data \
 "
RDEPENDS:xxd = " \
 glibc \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/vim-enhanced_or_vim-X11"

PROVIDES:append:aarch64 = " rpm/virtual/vim-enhanced_or_vim-X11"
