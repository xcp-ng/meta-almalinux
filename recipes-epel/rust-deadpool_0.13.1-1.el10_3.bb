# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-deadpool"
PV = "0.13.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-deadpool+default-devel \
 rust-deadpool+managed-devel \
 rust-deadpool+rt_smol_2-devel \
 rust-deadpool+rt_tokio_1-devel \
 rust-deadpool+serde-devel \
 rust-deadpool+unmanaged-devel \
 rust-deadpool-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-deadpool-0.13.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3e111a1cc961902d73c5716a9c51a5a715e0d359855f528919258c86ae97ac00"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool+default-devel-0.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-deadpool+default-devel.sha256sum] = "e9807d069487d8d22e168edb328675e334820e7d16092d8c066f5a2b4b5ba1fa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool+managed-devel-0.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool+managed-devel;unpack=0"
SRC_URI[x86_64_v2_rust-deadpool+managed-devel.sha256sum] = "d596e30fc3d85649db0b7e63671bc12c0dfd4ced9c3f7f00fe479aad6ea93f96"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool+rt_smol_2-devel-0.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool+rt_smol_2-devel;unpack=0"
SRC_URI[x86_64_v2_rust-deadpool+rt_smol_2-devel.sha256sum] = "bdba32ed1d4b708f5f5310776fe2639bd57407ed7c9aa39d2169c1eb8589745e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool+rt_tokio_1-devel-0.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool+rt_tokio_1-devel;unpack=0"
SRC_URI[x86_64_v2_rust-deadpool+rt_tokio_1-devel.sha256sum] = "b37e2adcf085623374753dcffeb174aa5288259c6e24b24ee8bbabc6c7aaf908"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool+serde-devel-0.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-deadpool+serde-devel.sha256sum] = "a2f4904788b4e40b9ad1112062a5b0c1c2ed5f2ab10522354a59a5c1478513f3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool+unmanaged-devel-0.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool+unmanaged-devel;unpack=0"
SRC_URI[x86_64_v2_rust-deadpool+unmanaged-devel.sha256sum] = "adb6c52a52763ab5da5c957188fb8d90fa278de69f43ad5d30441427d9eb49d0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool-devel-0.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool-devel;unpack=0"
SRC_URI[x86_64_v2_rust-deadpool-devel.sha256sum] = "194ec385bc3a28167288d1ee5593262a8ad432c3bc6d0c6f2b4eddfbff00ef66"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool+default-devel-0.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-deadpool+default-devel;unpack=0"
SRC_URI[aarch64_rust-deadpool+default-devel.sha256sum] = "25d280cfcef50af9b6df6b0c0f841baaf9484226a6f557048ff9e81225242408"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool+managed-devel-0.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-deadpool+managed-devel;unpack=0"
SRC_URI[aarch64_rust-deadpool+managed-devel.sha256sum] = "8b1acf9cc60cdcaa8fde811a1920f971ac41b7512ab851f5c21a2738f898924c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool+rt_smol_2-devel-0.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-deadpool+rt_smol_2-devel;unpack=0"
SRC_URI[aarch64_rust-deadpool+rt_smol_2-devel.sha256sum] = "5c9499a95eb15e4e722c6e5f357acdb9c45ea9c133001c10c7c1e7ac5810c38a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool+rt_tokio_1-devel-0.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-deadpool+rt_tokio_1-devel;unpack=0"
SRC_URI[aarch64_rust-deadpool+rt_tokio_1-devel.sha256sum] = "667689e780209d58de0d27afa3bb1a115e66feb14eb9cac0d39d571db7f18ba7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool+serde-devel-0.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-deadpool+serde-devel;unpack=0"
SRC_URI[aarch64_rust-deadpool+serde-devel.sha256sum] = "f1d87e36cff2881549da5f21d490b141eeb893befee3ba9c5759961b27ae69da"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool+unmanaged-devel-0.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-deadpool+unmanaged-devel;unpack=0"
SRC_URI[aarch64_rust-deadpool+unmanaged-devel.sha256sum] = "f360deb96b0fdfb8fa8559ec835c421ed5d7b76549b04d6a88ad108fbf5513ef"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool-devel-0.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-deadpool-devel;unpack=0"
SRC_URI[aarch64_rust-deadpool-devel.sha256sum] = "a1f7368960256d8645d1d86ca79ee6f097a137c4f17c9973b9138f5589215603"

RDEPENDS:rust-deadpool+default-devel = " \
 cargo \
 rust-deadpool+managed-devel \
 rust-deadpool+unmanaged-devel \
 rust-deadpool-devel \
 "
RDEPENDS:rust-deadpool+managed-devel = " \
 cargo \
 rust-deadpool-devel \
 "
RDEPENDS:rust-deadpool+rt_smol_2-devel = " \
 cargo \
 rust-deadpool-devel \
 rust-deadpool-runtime+smol_2-devel \
 "
RDEPENDS:rust-deadpool+rt_tokio_1-devel = " \
 cargo \
 rust-deadpool-devel \
 rust-deadpool-runtime+tokio_1-devel \
 "
RDEPENDS:rust-deadpool+serde-devel = " \
 cargo \
 rust-deadpool-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-deadpool+unmanaged-devel = " \
 cargo \
 rust-deadpool-devel \
 "
RDEPENDS:rust-deadpool-devel = " \
 cargo \
 rust \
 rust-deadpool-runtime+default-devel \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 "
