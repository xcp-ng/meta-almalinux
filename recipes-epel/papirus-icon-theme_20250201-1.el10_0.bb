# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "papirus-icon-theme"
PV = "20250201"
PR = "1.el10_0"
PACKAGES = " \
 epapirus-icon-theme \
 papirus-icon-theme \
 papirus-icon-theme-dark \
 papirus-icon-theme-light \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/papirus-icon-theme-20250201-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d2c854e6204452b575881c528304374aa56fed9f9a0247587e66f85d0495aa25"

URI_x86_64_v2_epapirus-icon-theme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/epapirus-icon-theme-20250201-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_epapirus-icon-theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_epapirus-icon-theme}"
SRC_URI[x86_64_v2_epapirus-icon-theme.sha256sum] = "e18e11f77118e2bda0acbede5cc93274a371c18f81462e4dc8e5d55f83208870"

URI_x86_64_v2_papirus-icon-theme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/papirus-icon-theme-20250201-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_papirus-icon-theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_papirus-icon-theme}"
SRC_URI[x86_64_v2_papirus-icon-theme.sha256sum] = "316e310f8351c56ae44070dd6d68df94fe28635b12dd598a2075658105c7c911"

URI_x86_64_v2_papirus-icon-theme-dark = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/papirus-icon-theme-dark-20250201-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_papirus-icon-theme-dark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_papirus-icon-theme-dark}"
SRC_URI[x86_64_v2_papirus-icon-theme-dark.sha256sum] = "02de840055476742def07f4fb48636c27dd3ad2a71ac50eedca4307baeb83472"

URI_x86_64_v2_papirus-icon-theme-light = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/papirus-icon-theme-light-20250201-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_papirus-icon-theme-light;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_papirus-icon-theme-light}"
SRC_URI[x86_64_v2_papirus-icon-theme-light.sha256sum] = "5beefe16b3285630b13035508b9596d491d46b7424e250610a0460e1d4afadd4"

URI_aarch64_epapirus-icon-theme = "${EPEL_MIRROR}/aarch64/Packages/e/epapirus-icon-theme-20250201-1.el10_0.noarch.rpm;name=aarch64_epapirus-icon-theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_epapirus-icon-theme}"
SRC_URI[aarch64_epapirus-icon-theme.sha256sum] = "605152bd9495f12c50b580aff5ac3495021ea5c0c494d0e8bfaa0d87b695a683"

URI_aarch64_papirus-icon-theme = "${EPEL_MIRROR}/aarch64/Packages/p/papirus-icon-theme-20250201-1.el10_0.noarch.rpm;name=aarch64_papirus-icon-theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_papirus-icon-theme}"
SRC_URI[aarch64_papirus-icon-theme.sha256sum] = "280fc1a616bc60967622aa8c78033d63f06ce941f2f4b64d89064770d0264a2b"

URI_aarch64_papirus-icon-theme-dark = "${EPEL_MIRROR}/aarch64/Packages/p/papirus-icon-theme-dark-20250201-1.el10_0.noarch.rpm;name=aarch64_papirus-icon-theme-dark;unpack=0"
SRC_URI:append = " ${URI_aarch64_papirus-icon-theme-dark}"
SRC_URI[aarch64_papirus-icon-theme-dark.sha256sum] = "ff72be8ff431604ee6a3d6f4f37478e0b3c322a027fa813b44e0f270ba319be1"

URI_aarch64_papirus-icon-theme-light = "${EPEL_MIRROR}/aarch64/Packages/p/papirus-icon-theme-light-20250201-1.el10_0.noarch.rpm;name=aarch64_papirus-icon-theme-light;unpack=0"
SRC_URI:append = " ${URI_aarch64_papirus-icon-theme-light}"
SRC_URI[aarch64_papirus-icon-theme-light.sha256sum] = "79ddc77a2548105af45048abf42c6df3e0de14764e3fcfc319385facda857ccc"

RDEPENDS:epapirus-icon-theme = " \
 bash \
 papirus-icon-theme \
 "
RDEPENDS:papirus-icon-theme = " \
 bash \
 "
RDEPENDS:papirus-icon-theme-dark = " \
 papirus-icon-theme \
 "
RDEPENDS:papirus-icon-theme-light = " \
 papirus-icon-theme \
 "
