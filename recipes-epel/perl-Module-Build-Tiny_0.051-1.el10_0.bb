# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Module-Build-Tiny"
PV = "0.051"
PR = "1.el10_0"
PACKAGES = " \
 perl-Module-Build-Tiny \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Module-Build-Tiny-0.051-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "88b2d05e16d003deec1d27122a18656eb877e26875e3fd7b480b21a615b6d571"

URI_x86_64_v2_perl-Module-Build-Tiny = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Module-Build-Tiny-0.051-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Module-Build-Tiny;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Module-Build-Tiny}"
SRC_URI[x86_64_v2_perl-Module-Build-Tiny.sha256sum] = "7857739786440dfe568b3e7836c62aadae63fd490b95fa153c3a773d8a2408c0"

URI_aarch64_perl-Module-Build-Tiny = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Module-Build-Tiny-0.051-1.el10_0.noarch.rpm;name=aarch64_perl-Module-Build-Tiny;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Module-Build-Tiny}"
SRC_URI[aarch64_perl-Module-Build-Tiny.sha256sum] = "af3c71d8840e6e0ae19dfbf08d0088543754808f6a5c4ff9f26c80c90138910b"

RDEPENDS:perl-Module-Build-Tiny = " \
 perl-CPAN-Meta \
 perl-CPAN-Requirements-Dynamic \
 perl-DynaLoader \
 perl-Exporter \
 perl-ExtUtils-CBuilder \
 perl-ExtUtils-Config \
 perl-ExtUtils-Helpers \
 perl-ExtUtils-Install \
 perl-ExtUtils-InstallPaths \
 perl-ExtUtils-ParseXS \
 perl-File-Basename \
 perl-File-Find \
 perl-File-Path \
 perl-Getopt-Long \
 perl-JSON-PP \
 perl-PathTools \
 perl-Test-Harness \
 perl-libs \
 perl-podlators \
 "
