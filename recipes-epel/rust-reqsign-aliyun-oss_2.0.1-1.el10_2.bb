# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-aliyun-oss"
PV = "2.0.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-reqsign-aliyun-oss+default-devel \
 rust-reqsign-aliyun-oss-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-aliyun-oss-2.0.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50590e15c5d68000b00ccdd589d743c7901fb5b01c04ed390b9ceee3d520cbe3"

URI_x86_64_v2_rust-reqsign-aliyun-oss+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-aliyun-oss+default-devel-2.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-aliyun-oss+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-aliyun-oss+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign-aliyun-oss+default-devel.sha256sum] = "4475d1cd64dbb1904fcde17a871861e79f1229fede52cc2f8a54da0c4f315990"

URI_x86_64_v2_rust-reqsign-aliyun-oss-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-aliyun-oss-devel-2.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-aliyun-oss-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-aliyun-oss-devel}"
SRC_URI[x86_64_v2_rust-reqsign-aliyun-oss-devel.sha256sum] = "5cac5a994e8495a267bec6784daef49d61a69be7b8b262f1be9a5e89e831d8be"

URI_aarch64_rust-reqsign-aliyun-oss+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-aliyun-oss+default-devel-2.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-reqsign-aliyun-oss+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-aliyun-oss+default-devel}"
SRC_URI[aarch64_rust-reqsign-aliyun-oss+default-devel.sha256sum] = "d1b5f5f334396d58a8fbf643c31da80a05ad41179e9524d8a73ec156379245cc"

URI_aarch64_rust-reqsign-aliyun-oss-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-aliyun-oss-devel-2.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-reqsign-aliyun-oss-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-aliyun-oss-devel}"
SRC_URI[aarch64_rust-reqsign-aliyun-oss-devel.sha256sum] = "faa3421135c5a67510eb1efc3ef30af7235eb067af2197f97daa40877c520117"

RDEPENDS:rust-reqsign-aliyun-oss+default-devel = " \
 cargo \
 rust-reqsign-aliyun-oss-devel \
 "
RDEPENDS:rust-reqsign-aliyun-oss-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-async-trait+default-devel \
 rust-http+default-devel \
 rust-log+default-devel \
 rust-percent-encoding+default-devel \
 rust-reqsign-core+default-devel \
 rust-reqwest0.12+json-devel \
 rust-reqwest0.12-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 "
