# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "java-latest-openjdk-portable"
PE = "1"
PV = "26.0.0.0.35"
PR = "1.rolling.el8"
PACKAGES = " \
 java-latest-openjdk-portable \
 java-latest-openjdk-portable-devel \
 java-latest-openjdk-portable-devel-fastdebug \
 java-latest-openjdk-portable-devel-slowdebug \
 java-latest-openjdk-portable-docs \
 java-latest-openjdk-portable-fastdebug \
 java-latest-openjdk-portable-misc \
 java-latest-openjdk-portable-slowdebug \
 java-latest-openjdk-portable-sources \
 java-latest-openjdk-portable-static-libs \
 java-latest-openjdk-portable-static-libs-fastdebug \
 java-latest-openjdk-portable-static-libs-slowdebug \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/java-latest-openjdk-portable-26.0.0.0.35-1.rolling.el8.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "667c5093b14af96879842ae5ec4bcb9351e7149821b99b7b4550199d86c25f67"

URI_x86_64_v2_java-latest-openjdk-portable = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-26.0.0.0.35-1.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable.sha256sum] = "dc1e84e1f6e6171065357dad57b476ed86ce97bfaf437b5d24814ed8a844d101"

URI_x86_64_v2_java-latest-openjdk-portable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-devel-26.0.0.0.35-1.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable-devel}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-devel.sha256sum] = "ae2109c1a3e39205d9d7813b594bc1a2203eeaa5cad61d7f65526d61f87dafce"

URI_x86_64_v2_java-latest-openjdk-portable-devel-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-devel-fastdebug-26.0.0.0.35-1.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-devel-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable-devel-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-devel-fastdebug.sha256sum] = "7e0a001ddb4a4cfabadc479e7333df8b22537e7794c09f0751129b8051a482cf"

URI_x86_64_v2_java-latest-openjdk-portable-devel-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-devel-slowdebug-26.0.0.0.35-1.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-devel-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable-devel-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-devel-slowdebug.sha256sum] = "682121e957478b3a99e6ed227966db335a1ef2f3fec57b2856494f9443dad52c"

URI_x86_64_v2_java-latest-openjdk-portable-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-docs-26.0.0.0.35-1.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable-docs}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-docs.sha256sum] = "7fd0315f3f5a6d4efff92dc40046deedc2d2bfed0e46b0d2e6bbba6f165484d3"

URI_x86_64_v2_java-latest-openjdk-portable-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-fastdebug-26.0.0.0.35-1.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-fastdebug.sha256sum] = "6e1637a0c0c7558e2df63f9cf007ba914802af024fba26089447b635847ca38d"

URI_x86_64_v2_java-latest-openjdk-portable-misc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-misc-26.0.0.0.35-1.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-misc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable-misc}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-misc.sha256sum] = "f1beb2ae8d2c917fbc389436675a02a39a8ca57caf73d5699f3bddb8e6ff119d"

URI_x86_64_v2_java-latest-openjdk-portable-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-slowdebug-26.0.0.0.35-1.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-slowdebug.sha256sum] = "49fe7153be95302f83467bd7423330d17725d0e94bf85a226b4f65fb0ebe2e9d"

URI_x86_64_v2_java-latest-openjdk-portable-sources = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-sources-26.0.0.0.35-1.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-sources;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable-sources}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-sources.sha256sum] = "09ce1b168499a61e7e7a462b0b3c21cfc194d4db326dbd9fa581510023450ae7"

URI_x86_64_v2_java-latest-openjdk-portable-static-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-static-libs-26.0.0.0.35-1.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-static-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable-static-libs}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-static-libs.sha256sum] = "a124d7f85cc44a411a95253efd6f422789e947d8e13456c7b246d0ddbebab100"

URI_x86_64_v2_java-latest-openjdk-portable-static-libs-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-static-libs-fastdebug-26.0.0.0.35-1.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-static-libs-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable-static-libs-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-static-libs-fastdebug.sha256sum] = "62add0be3b5c9d1f1f6d941c91856eab6cdfe7d613579404302872362b9b42c8"

URI_x86_64_v2_java-latest-openjdk-portable-static-libs-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-static-libs-slowdebug-26.0.0.0.35-1.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-static-libs-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable-static-libs-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-static-libs-slowdebug.sha256sum] = "baeb6581791b44d9de1447ab14d8268f442c2f8afbf073a32d5fa0383b724a06"

URI_aarch64_java-latest-openjdk-portable = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-26.0.0.0.35-1.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable}"
SRC_URI[aarch64_java-latest-openjdk-portable.sha256sum] = "a4ad8feab95318a06d80e206348c24364c6f9b59e03344d73671dcd66db7e9e6"

URI_aarch64_java-latest-openjdk-portable-devel = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-devel-26.0.0.0.35-1.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-devel}"
SRC_URI[aarch64_java-latest-openjdk-portable-devel.sha256sum] = "6a16aca1dcaa70eb73a556d02c0a2e8c97e301e353986e5e5e2dd163d0ff13ba"

URI_aarch64_java-latest-openjdk-portable-devel-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-devel-fastdebug-26.0.0.0.35-1.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-devel-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-devel-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-portable-devel-fastdebug.sha256sum] = "a19a5ff1a451698f938a27f952aea4267931928045b236b5448f111f0c5d507d"

URI_aarch64_java-latest-openjdk-portable-devel-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-devel-slowdebug-26.0.0.0.35-1.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-devel-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-devel-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-portable-devel-slowdebug.sha256sum] = "27260f548e6c36f5e9e81ea20653b5be3bddf5a3aa9d6f2d3c05bcf1859ec0c2"

URI_aarch64_java-latest-openjdk-portable-docs = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-docs-26.0.0.0.35-1.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-docs}"
SRC_URI[aarch64_java-latest-openjdk-portable-docs.sha256sum] = "da5f8205ef02434fee37291c1634a6b74572f61530d17b4becbd628a6bc1399f"

URI_aarch64_java-latest-openjdk-portable-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-fastdebug-26.0.0.0.35-1.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-portable-fastdebug.sha256sum] = "7ae4f9a509fb7b2cefb3998024ac45aff556856ec57e6271f3b05d00e0b9a06a"

URI_aarch64_java-latest-openjdk-portable-misc = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-misc-26.0.0.0.35-1.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-misc;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-misc}"
SRC_URI[aarch64_java-latest-openjdk-portable-misc.sha256sum] = "d7086e7c665dbf45dce118b578818a0e0f14d233f4327300bf5c887493366ebe"

URI_aarch64_java-latest-openjdk-portable-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-slowdebug-26.0.0.0.35-1.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-portable-slowdebug.sha256sum] = "8ba58d8b0cabe2adf281536982e7657b3f2354023ed5daf7b71e01de436cf1cc"

URI_aarch64_java-latest-openjdk-portable-sources = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-sources-26.0.0.0.35-1.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-sources;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-sources}"
SRC_URI[aarch64_java-latest-openjdk-portable-sources.sha256sum] = "dc09bdf59bddf2fe6280af1afad90e5da082df702c6223f9ce2f97ac7290ff23"

URI_aarch64_java-latest-openjdk-portable-static-libs = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-static-libs-26.0.0.0.35-1.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-static-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-static-libs}"
SRC_URI[aarch64_java-latest-openjdk-portable-static-libs.sha256sum] = "0fff1ed072e0dc0f90b1f3cce3d3fd734960fec063e6c12c60db660088288c5f"

URI_aarch64_java-latest-openjdk-portable-static-libs-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-static-libs-fastdebug-26.0.0.0.35-1.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-static-libs-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-static-libs-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-portable-static-libs-fastdebug.sha256sum] = "061dbf299bda66a2069124d5239d9380d7793b7f0159884b49882a38d6b4776d"

URI_aarch64_java-latest-openjdk-portable-static-libs-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-static-libs-slowdebug-26.0.0.0.35-1.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-static-libs-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-static-libs-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-portable-static-libs-slowdebug.sha256sum] = "2baf1c1db9794656e2f00bf31e707b3a3e20952442373e90a84cabf5a486fb18"

RDEPENDS:java-latest-openjdk-portable = " \
 "
RDEPENDS:java-latest-openjdk-portable-devel = " \
 "
RDEPENDS:java-latest-openjdk-portable-devel-fastdebug = " \
 "
RDEPENDS:java-latest-openjdk-portable-devel-slowdebug = " \
 "
RDEPENDS:java-latest-openjdk-portable-docs = " \
 "
RDEPENDS:java-latest-openjdk-portable-fastdebug = " \
 "
RDEPENDS:java-latest-openjdk-portable-misc = " \
 "
RDEPENDS:java-latest-openjdk-portable-slowdebug = " \
 "
RDEPENDS:java-latest-openjdk-portable-sources = " \
 "
RDEPENDS:java-latest-openjdk-portable-static-libs = " \
 "
RDEPENDS:java-latest-openjdk-portable-static-libs-fastdebug = " \
 "
RDEPENDS:java-latest-openjdk-portable-static-libs-slowdebug = " \
 "
