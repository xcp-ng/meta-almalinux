# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kidletime"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kidletime \
 kf6-kidletime-devel \
 kf6-kidletime-doc \
 kf6-kidletime-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kidletime-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f0fba4ae0966cd50a4b7eb5b1ee4b20b03e27c7a8de58863034b90e3cb537a24"

URI_x86_64_v2_kf6-kidletime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kidletime-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kidletime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kidletime}"
SRC_URI[x86_64_v2_kf6-kidletime.sha256sum] = "3a32c3d24dff8c03e82e0e408a800366e76d4b7d3dafca60d7ab542492a08a43"

URI_x86_64_v2_kf6-kidletime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kidletime-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kidletime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kidletime-devel}"
SRC_URI[x86_64_v2_kf6-kidletime-devel.sha256sum] = "1b4efffea7d0e3944f940a6adb080269cd91a0450394cc242afa7293a81c56d2"

URI_x86_64_v2_kf6-kidletime-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kidletime-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kidletime-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kidletime-doc}"
SRC_URI[x86_64_v2_kf6-kidletime-doc.sha256sum] = "6b3f76a8814edb6273178176489c80971396d2108ab1fba7c2db192cb2db8bb3"

URI_x86_64_v2_kf6-kidletime-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kidletime-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kidletime-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kidletime-html}"
SRC_URI[x86_64_v2_kf6-kidletime-html.sha256sum] = "6038ed929a81def1c273264a6a47c78921720329c90b7badb2b0e035a9ad7ef8"

URI_aarch64_kf6-kidletime = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kidletime-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kidletime;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kidletime}"
SRC_URI[aarch64_kf6-kidletime.sha256sum] = "c38a16ba4129739f4ac9f19f3683bb28f165d00d01577ba78df8676cc9ab331b"

URI_aarch64_kf6-kidletime-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kidletime-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kidletime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kidletime-devel}"
SRC_URI[aarch64_kf6-kidletime-devel.sha256sum] = "12835d7191c19fcf75af40b57d637384133924c6e429d74be0aebfb64d2918d9"

URI_aarch64_kf6-kidletime-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kidletime-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kidletime-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kidletime-doc}"
SRC_URI[aarch64_kf6-kidletime-doc.sha256sum] = "7d4b80e9e0ba99d6a607224629d25a72b38f89d73417d25660ba7ff3341a9635"

URI_aarch64_kf6-kidletime-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kidletime-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kidletime-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kidletime-html}"
SRC_URI[aarch64_kf6-kidletime-html.sha256sum] = "4e8fde27d236708599cefca8d6d2f93fe1ea965f5855cf152a413e50f6df4ac8"

RDEPENDS:kf6-kidletime = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 libwayland-client \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kidletime-devel = " \
 cmake-filesystem \
 kf6-kidletime \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kidletime-doc = " \
 "
RDEPENDS:kf6-kidletime-html = " \
 "
