# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libxcrypt"
PV = "4.4.36"
PR = "10.el10"
PACKAGES = " \
 libxcrypt \
 libxcrypt-compat \
 libxcrypt-devel \
 libxcrypt-static \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libxcrypt-4.4.36-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c8c23ad1cca6c5ae9eb3ef5d42b6cfa6c48d1b4e53f12c8f20afe2b7744ed9a"

URI_x86_64_v2_libxcrypt = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libxcrypt-4.4.36-10.el10.x86_64_v2.rpm;name=x86_64_v2_libxcrypt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxcrypt}"
SRC_URI[x86_64_v2_libxcrypt.sha256sum] = "c184529c73318313d486a814a98c7e909dbd03dcf08e536d90b57e25b4a18c2e"

URI_x86_64_v2_libxcrypt-compat = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libxcrypt-compat-4.4.36-10.el10.x86_64_v2.rpm;name=x86_64_v2_libxcrypt-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxcrypt-compat}"
SRC_URI[x86_64_v2_libxcrypt-compat.sha256sum] = "7fecba48f517a5cfaee49f127e8ea150b63dd701f7844c193205fb98962eddee"

URI_x86_64_v2_libxcrypt-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libxcrypt-devel-4.4.36-10.el10.x86_64_v2.rpm;name=x86_64_v2_libxcrypt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxcrypt-devel}"
SRC_URI[x86_64_v2_libxcrypt-devel.sha256sum] = "d117408e5feca7cd9a28353c5abb04d87b5f2f5ccbba6d8a8ca699de7cef5c1f"

URI_x86_64_v2_libxcrypt-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libxcrypt-static-4.4.36-10.el10.x86_64_v2.rpm;name=x86_64_v2_libxcrypt-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxcrypt-static}"
SRC_URI[x86_64_v2_libxcrypt-static.sha256sum] = "7f4979029741d05b6ca18d72a355c304503a8676275ee0c4fddf8b9ab0ce3435"

URI_aarch64_libxcrypt = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libxcrypt-4.4.36-10.el10.aarch64.rpm;name=aarch64_libxcrypt;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxcrypt}"
SRC_URI[aarch64_libxcrypt.sha256sum] = "a4c4b29b6f5bcbe498dfb101e058fb2ac3b78e032cf380db7169411c103c9c39"

URI_aarch64_libxcrypt-compat = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libxcrypt-compat-4.4.36-10.el10.aarch64.rpm;name=aarch64_libxcrypt-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxcrypt-compat}"
SRC_URI[aarch64_libxcrypt-compat.sha256sum] = "5b39783880d36a3d009ec2d133bdd4977b5e005a7f01c034e6b43870fae052b0"

URI_aarch64_libxcrypt-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libxcrypt-devel-4.4.36-10.el10.aarch64.rpm;name=aarch64_libxcrypt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxcrypt-devel}"
SRC_URI[aarch64_libxcrypt-devel.sha256sum] = "09f529b4131c31f3ed45df3266e12a33ef7d8f1f83eef7ef03e75759dfdf54c8"

URI_aarch64_libxcrypt-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libxcrypt-static-4.4.36-10.el10.aarch64.rpm;name=aarch64_libxcrypt-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxcrypt-static}"
SRC_URI[aarch64_libxcrypt-static.sha256sum] = "c99e404e46fe1f4630abf51d1bde72482f3fdecc566e3a35b07221db6d9b785a"

RDEPENDS:libxcrypt = " \
 glibc \
 "
RDEPENDS:libxcrypt-compat = " \
 glibc \
 libxcrypt \
 "
RDEPENDS:libxcrypt-devel = " \
 glibc-devel \
 libxcrypt \
 pkgconf-pkg-config \
 "
RDEPENDS:libxcrypt-static = " \
 glibc-static \
 libxcrypt-devel \
 "
