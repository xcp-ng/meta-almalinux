# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-catkin_pkg"
PV = "1.1.1"
PR = "1.el10_2"
PACKAGES = " \
 python-catkin_pkg-doc \
 python3-catkin_pkg \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-catkin_pkg-1.1.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b841939ae1cbbc6985f92b3508cf993e478aaaa8b592d054e07daa7861de5ed7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-catkin_pkg-doc-1.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-catkin_pkg-doc;unpack=0"
SRC_URI[x86_64_v2_python-catkin_pkg-doc.sha256sum] = "dc41f92772b9df15cc3ef7233bcb4d3edf5d0646cc30d01d4554a5e6cfec938f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-catkin_pkg-1.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-catkin_pkg;unpack=0"
SRC_URI[x86_64_v2_python3-catkin_pkg.sha256sum] = "53cfbdc6056d3992c8aea5575f18a414106579b12f50a78f31604e23774b3c02"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-catkin_pkg-doc-1.1.1-1.el10_2.noarch.rpm;name=aarch64_python-catkin_pkg-doc;unpack=0"
SRC_URI[aarch64_python-catkin_pkg-doc.sha256sum] = "2ea821c4bdd5e24bb8eb4aecfd885f93526376a3e3dcb5aaa001af2f58aee539"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-catkin_pkg-1.1.1-1.el10_2.noarch.rpm;name=aarch64_python3-catkin_pkg;unpack=0"
SRC_URI[aarch64_python3-catkin_pkg.sha256sum] = "69f5a83650f104588aa68bf3919432b94fa15558219d72fff48355d61dd4a49e"

RDEPENDS:python-catkin_pkg-doc = " \
 "
RDEPENDS:python3-catkin_pkg = " \
 python3 \
 python3-dateutil \
 python3-docutils \
 python3-packaging \
 python3-pyparsing \
 "
