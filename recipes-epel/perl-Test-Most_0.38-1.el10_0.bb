# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-Most"
PV = "0.38"
PR = "1.el10_0"
PACKAGES = " \
 perl-Test-Most \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Test-Most-0.38-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4fe98446b2f7442e5810fd155f7fd858e202d92e67680130bf71e2ac52345329"

URI_x86_64_v2_perl-Test-Most = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-Most-0.38-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-Most;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-Most}"
SRC_URI[x86_64_v2_perl-Test-Most.sha256sum] = "d4cdc8452dea4434943eafeccb1ef3c30a539da86641db92da32865d6c529830"

URI_aarch64_perl-Test-Most = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-Most-0.38-1.el10_0.noarch.rpm;name=aarch64_perl-Test-Most;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-Most}"
SRC_URI[aarch64_perl-Test-Most.sha256sum] = "8188293e545160b57903c9b897f9bd47959111ff076c9ab0901d35dc77c37fd6"

RDEPENDS:perl-Test-Most = " \
 perl-Carp \
 perl-Data-Dumper \
 perl-Data-Dumper-Names \
 perl-Exception-Class \
 perl-Exporter \
 perl-Test-Deep \
 perl-Test-Differences \
 perl-Test-Exception \
 perl-Test-Harness \
 perl-Test-Most \
 perl-Test-Simple \
 perl-Test-Warn \
 perl-Time-HiRes \
 perl-base \
 perl-libs \
 "
