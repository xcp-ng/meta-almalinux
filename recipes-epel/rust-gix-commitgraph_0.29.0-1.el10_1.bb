# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-commitgraph"
PV = "0.29.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-commitgraph+default-devel \
 rust-gix-commitgraph+document-features-devel \
 rust-gix-commitgraph+serde-devel \
 rust-gix-commitgraph-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-commitgraph-0.29.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "83206ad9b9ba7c72b40f065fbc47b8fa586d0c5d5e03f2c24ac8182fde418b29"

URI_x86_64_v2_rust-gix-commitgraph+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-commitgraph+default-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-commitgraph+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-commitgraph+default-devel}"
SRC_URI[x86_64_v2_rust-gix-commitgraph+default-devel.sha256sum] = "f0a3265985da029a2e95acf554cb64a9231da4ccbfcf49cfd2e82ce1958b8dd1"

URI_x86_64_v2_rust-gix-commitgraph+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-commitgraph+document-features-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-commitgraph+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-commitgraph+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-commitgraph+document-features-devel.sha256sum] = "3a0899cfc05eed0a25147a3f0ceec88e6790e597639c821019c54a289c626b85"

URI_x86_64_v2_rust-gix-commitgraph+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-commitgraph+serde-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-commitgraph+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-commitgraph+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-commitgraph+serde-devel.sha256sum] = "01368ac9ab38f0ba4b14dacbc9cc7fb1832133e09c14f86fcceff4caa45b65bf"

URI_x86_64_v2_rust-gix-commitgraph-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-commitgraph-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-commitgraph-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-commitgraph-devel}"
SRC_URI[x86_64_v2_rust-gix-commitgraph-devel.sha256sum] = "34974333582b375dcc41058005bb7ac1bbeb21a39325ffd5720d30606bf84435"

URI_aarch64_rust-gix-commitgraph+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-commitgraph+default-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-commitgraph+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-commitgraph+default-devel}"
SRC_URI[aarch64_rust-gix-commitgraph+default-devel.sha256sum] = "990be79018c6653d5738c578dbdfd65b86c4a3c4f8d636434c9ea491691850a8"

URI_aarch64_rust-gix-commitgraph+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-commitgraph+document-features-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-commitgraph+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-commitgraph+document-features-devel}"
SRC_URI[aarch64_rust-gix-commitgraph+document-features-devel.sha256sum] = "44f0b5d96253c4274da8aa8f3b27b4547f241c6438acaef39f837a674ceef08a"

URI_aarch64_rust-gix-commitgraph+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-commitgraph+serde-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-commitgraph+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-commitgraph+serde-devel}"
SRC_URI[aarch64_rust-gix-commitgraph+serde-devel.sha256sum] = "a4714beed0c266033f145eb278509b6458955b6a69c53ce072351552abe0fb72"

URI_aarch64_rust-gix-commitgraph-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-commitgraph-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-commitgraph-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-commitgraph-devel}"
SRC_URI[aarch64_rust-gix-commitgraph-devel.sha256sum] = "3bc1a539d50a8fb76df2404501605164e0c358d67b22fbdd01ad0c0561dd96ea"

RDEPENDS:rust-gix-commitgraph+default-devel = " \
 cargo \
 rust-gix-commitgraph-devel \
 "
RDEPENDS:rust-gix-commitgraph+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-commitgraph-devel \
 "
RDEPENDS:rust-gix-commitgraph+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-commitgraph-devel \
 rust-gix-hash+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-commitgraph-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-chunk+default-devel \
 rust-gix-hash+default-devel \
 rust-memmap2+default-devel \
 rust-thiserror+default-devel \
 "
