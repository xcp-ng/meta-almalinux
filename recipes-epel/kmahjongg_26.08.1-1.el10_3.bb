# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmahjongg"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kmahjongg \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kmahjongg-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cdc4b780b5c4397db4dab81a36f85f835b65df8623886fa04abf7e7846e3a9ed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmahjongg-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmahjongg;unpack=0"
SRC_URI[x86_64_v2_kmahjongg.sha256sum] = "62e2973ebcff04e5a11eb452696e39f1c5b2ea0cdbc9bd5d05fbaf7347f28417"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kmahjongg-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kmahjongg;unpack=0"
SRC_URI[aarch64_kmahjongg.sha256sum] = "f68e6b875a55574384c86cb7e6d823c29151ef4b6b85d44936c5862e83929333"

RDEPENDS:kmahjongg = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libkmahjongg \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
