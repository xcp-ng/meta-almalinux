# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kxmlgui"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kxmlgui \
 kf6-kxmlgui-devel \
 kf6-kxmlgui-doc \
 kf6-kxmlgui-html \
 python3-kf6-kxmlgui \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kxmlgui-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7be92fbbdf1fa4832c43cb0a329627e614b83d97e2aa8c7eacfed6cbf690723f"

URI_x86_64_v2_kf6-kxmlgui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kxmlgui-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kxmlgui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kxmlgui}"
SRC_URI[x86_64_v2_kf6-kxmlgui.sha256sum] = "0a9465beaed17bd4034163c5aa590be925446a4b96ef75c108406cd0996af0e4"

URI_x86_64_v2_kf6-kxmlgui-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kxmlgui-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kxmlgui-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kxmlgui-devel}"
SRC_URI[x86_64_v2_kf6-kxmlgui-devel.sha256sum] = "9f5b392c1e5933d2089a85281b7872806d664b142bb9831ba9a9964ea90f7c70"

URI_x86_64_v2_kf6-kxmlgui-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kxmlgui-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kxmlgui-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kxmlgui-doc}"
SRC_URI[x86_64_v2_kf6-kxmlgui-doc.sha256sum] = "2aafdd1387f044c77628cd4ae84c7dc9c95b813e1259b944e296e82deb7820fe"

URI_x86_64_v2_kf6-kxmlgui-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kxmlgui-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kxmlgui-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kxmlgui-html}"
SRC_URI[x86_64_v2_kf6-kxmlgui-html.sha256sum] = "ba1451e6224855cf4ff2f669f94382fa51d6303a92ca06d08c1c65c40a2fd109"

URI_x86_64_v2_python3-kf6-kxmlgui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-kxmlgui-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-kxmlgui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kf6-kxmlgui}"
SRC_URI[x86_64_v2_python3-kf6-kxmlgui.sha256sum] = "db47386d2d3f723f946098d1c17b9eb322589cda35ba2b0d5978693ff57ed52a"

URI_aarch64_kf6-kxmlgui = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kxmlgui-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kxmlgui;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kxmlgui}"
SRC_URI[aarch64_kf6-kxmlgui.sha256sum] = "f76522a185e1fe21e870ba82544f77c7a05f3c8f2f779fb2f9a5341a907cea85"

URI_aarch64_kf6-kxmlgui-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kxmlgui-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kxmlgui-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kxmlgui-devel}"
SRC_URI[aarch64_kf6-kxmlgui-devel.sha256sum] = "c5b086967dd708b206e9823863f2ac4de6c18516b3cebff61e5f68b04a00157a"

URI_aarch64_kf6-kxmlgui-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kxmlgui-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kxmlgui-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kxmlgui-doc}"
SRC_URI[aarch64_kf6-kxmlgui-doc.sha256sum] = "151b9ad52a9d142b0013a56851d31304b7b8498a3d2c58cc68cee5ce40b27b22"

URI_aarch64_kf6-kxmlgui-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kxmlgui-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kxmlgui-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kxmlgui-html}"
SRC_URI[aarch64_kf6-kxmlgui-html.sha256sum] = "bb6b595c5d52bbb56f1eff47ba432e6212c61abd18745e452c450fb260453c69"

URI_aarch64_python3-kf6-kxmlgui = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-kxmlgui-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_python3-kf6-kxmlgui;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kf6-kxmlgui}"
SRC_URI[aarch64_python3-kf6-kxmlgui.sha256sum] = "0edd02ee36bee46c60117425d660c4221cc9df8c813f45e1d23a9eb9cbb3ea66"

RDEPENDS:kf6-kxmlgui = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kitemviews \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kxmlgui-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kconfig-devel \
 kf6-kconfigwidgets-devel \
 kf6-kguiaddons-devel \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kxmlgui-doc = " \
 "
RDEPENDS:kf6-kxmlgui-html = " \
 "
RDEPENDS:python3-kf6-kxmlgui = " \
 glibc \
 kf6-kxmlgui \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
