# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xfsprogs"
PV = "6.16.0"
PR = "1.el10"
PACKAGES = " \
 xfsprogs \
 xfsprogs-devel \
 xfsprogs-xfs_scrub \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/xfsprogs-6.16.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9758490c4b49b9f50d6c359bab44dcfdfc8552e267754f8405c3847b8324cd4"

URI_x86_64_v2_xfsprogs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/xfsprogs-6.16.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_xfsprogs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xfsprogs}"
SRC_URI[x86_64_v2_xfsprogs.sha256sum] = "fe1ca467b32e83c84adb7ff3bd901c75f66790c9649f584cd29374654324084f"

URI_x86_64_v2_xfsprogs-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xfsprogs-devel-6.16.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_xfsprogs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xfsprogs-devel}"
SRC_URI[x86_64_v2_xfsprogs-devel.sha256sum] = "c2866ea84fba84aa81518dede6241f97dbdf197aa88878340beba8acac1a5978"

URI_x86_64_v2_xfsprogs-xfs_scrub = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xfsprogs-xfs_scrub-6.16.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_xfsprogs-xfs_scrub;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xfsprogs-xfs_scrub}"
SRC_URI[x86_64_v2_xfsprogs-xfs_scrub.sha256sum] = "6640590cbb5a6aa751e100b42cf1f20861da535b9af55f1fb889c5d2fbb65295"

URI_aarch64_xfsprogs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/xfsprogs-6.16.0-1.el10.aarch64.rpm;name=aarch64_xfsprogs;unpack=0"
SRC_URI:append = " ${URI_aarch64_xfsprogs}"
SRC_URI[aarch64_xfsprogs.sha256sum] = "428d498492054307ffdfc2add9e0e6020741c2b3ba6dc0015d40db10fb67bfaf"

URI_aarch64_xfsprogs-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xfsprogs-devel-6.16.0-1.el10.aarch64.rpm;name=aarch64_xfsprogs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xfsprogs-devel}"
SRC_URI[aarch64_xfsprogs-devel.sha256sum] = "b55e475fc0c0925d99da6bfcbd7ecf55c242070ed1a217706562b6ced90bd8b5"

URI_aarch64_xfsprogs-xfs_scrub = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xfsprogs-xfs_scrub-6.16.0-1.el10.aarch64.rpm;name=aarch64_xfsprogs-xfs_scrub;unpack=0"
SRC_URI:append = " ${URI_aarch64_xfsprogs-xfs_scrub}"
SRC_URI[aarch64_xfsprogs-xfs_scrub.sha256sum] = "c7de87548a7914c98f644dc39bb90e58c9ad00b98ac1c2303872bf93e4879f44"

RDEPENDS:xfsprogs = " \
 bash \
 glibc \
 inih \
 libblkid \
 libedit \
 libuuid \
 python3 \
 userspace-rcu \
 "
RDEPENDS:xfsprogs-devel = " \
 libuuid-devel \
 xfsprogs \
 "
RDEPENDS:xfsprogs-xfs_scrub = " \
 bash \
 glibc \
 libicu \
 python3 \
 userspace-rcu \
 util-linux \
 xfsprogs \
 "
