# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-hashicorp-lru"
PV = "0.5.4"
PR = "14.el10_0"
PACKAGES = " \
 golang-github-hashicorp-lru-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-hashicorp-lru-0.5.4-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "16a4bde926614b4e5e44cc24803b3aedbb79c704053087f689cf331a1df98063"

URI_x86_64_v2_golang-github-hashicorp-lru-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-hashicorp-lru-devel-0.5.4-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-hashicorp-lru-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-hashicorp-lru-devel}"
SRC_URI[x86_64_v2_golang-github-hashicorp-lru-devel.sha256sum] = "18d20ce25dc6eaa39d2b55550b3c9c03b178d94ae7409cadb74d2e872f8a2d1a"

URI_aarch64_golang-github-hashicorp-lru-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-hashicorp-lru-devel-0.5.4-14.el10_0.noarch.rpm;name=aarch64_golang-github-hashicorp-lru-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-hashicorp-lru-devel}"
SRC_URI[aarch64_golang-github-hashicorp-lru-devel.sha256sum] = "bb6651ae909a06288ddb12562fdd89b9b93ed7fa185d12f2a3f5abaefdd4cc9e"

RDEPENDS:golang-github-hashicorp-lru-devel = " \
 go-filesystem \
 "
