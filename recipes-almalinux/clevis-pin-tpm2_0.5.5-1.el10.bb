# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clevis-pin-tpm2"
PV = "0.5.5"
PR = "1.el10"
PACKAGES = " \
 clevis-pin-tpm2 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/clevis-pin-tpm2-0.5.5-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c9e76e4516d2fc334a8800669c57152da766174104cecb673ed6624f0d4a475"

URI_x86_64_v2_clevis-pin-tpm2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clevis-pin-tpm2-0.5.5-1.el10.x86_64_v2.rpm;name=x86_64_v2_clevis-pin-tpm2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clevis-pin-tpm2}"
SRC_URI[x86_64_v2_clevis-pin-tpm2.sha256sum] = "7022b15b621c4d53e3210cf4d6a70a559f64ea5539db24a2a35ddce06c98f0e1"

URI_aarch64_clevis-pin-tpm2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clevis-pin-tpm2-0.5.5-1.el10.aarch64.rpm;name=aarch64_clevis-pin-tpm2;unpack=0"
SRC_URI:append = " ${URI_aarch64_clevis-pin-tpm2}"
SRC_URI[aarch64_clevis-pin-tpm2.sha256sum] = "055986a4112c3743c8d96ada1a8626176f2d7b8e69cdef20581d65c1f5c254b0"

RDEPENDS:clevis-pin-tpm2 = " \
 clevis \
 glibc \
 libgcc \
 openssl-libs \
 tpm2-tss \
 "
