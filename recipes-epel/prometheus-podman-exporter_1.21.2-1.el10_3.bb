# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "prometheus-podman-exporter"
PV = "1.21.2"
PR = "1.el10_3"
PACKAGES = " \
 prometheus-podman-exporter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/prometheus-podman-exporter-1.21.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69829f556767b01fa07f960259864d682d8c6fe9eb9ac92487000a7452b57dba"

URI_x86_64_v2_prometheus-podman-exporter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/prometheus-podman-exporter-1.21.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_prometheus-podman-exporter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_prometheus-podman-exporter}"
SRC_URI[x86_64_v2_prometheus-podman-exporter.sha256sum] = "8bb0c965f745b3cf68e842fc626aea47a0f66e70cada5122313ccfc58adc6463"

URI_aarch64_prometheus-podman-exporter = "${EPEL_MIRROR}/aarch64/Packages/p/prometheus-podman-exporter-1.21.2-1.el10_3.aarch64.rpm;name=aarch64_prometheus-podman-exporter;unpack=0"
SRC_URI:append = " ${URI_aarch64_prometheus-podman-exporter}"
SRC_URI[aarch64_prometheus-podman-exporter.sha256sum] = "d84c299dd82dfcdab8cc5d571c4307a5b8437ea567c12a9f134e331b260d16fd"

RDEPENDS:prometheus-podman-exporter = " \
 bash \
 glibc \
 gpgme2 \
 "
