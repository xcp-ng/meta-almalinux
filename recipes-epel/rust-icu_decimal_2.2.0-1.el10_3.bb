# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_decimal"
PV = "2.2.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-icu_decimal+alloc-devel \
 rust-icu_decimal+compiled_data-devel \
 rust-icu_decimal+datagen-devel \
 rust-icu_decimal+default-devel \
 rust-icu_decimal+ryu-devel \
 rust-icu_decimal+serde-devel \
 rust-icu_decimal+unstable-devel \
 rust-icu_decimal-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_decimal-2.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf96af66230fab0ef4638626d6255a161727eae97ca2c2e0a0ed4d2510226084"

URI_x86_64_v2_rust-icu_decimal+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_decimal+alloc-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_decimal+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_decimal+alloc-devel}"
SRC_URI[x86_64_v2_rust-icu_decimal+alloc-devel.sha256sum] = "aead69565dffa34baefdf0fa6840c9f1ab448a8fecaa30bbeee96bfbe59bd9e1"

URI_x86_64_v2_rust-icu_decimal+compiled_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_decimal+compiled_data-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_decimal+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_decimal+compiled_data-devel}"
SRC_URI[x86_64_v2_rust-icu_decimal+compiled_data-devel.sha256sum] = "2bc3cd61c38834c28aa33fb13c4ec8b55e290fb151566a04a1b39a78b5c7259c"

URI_x86_64_v2_rust-icu_decimal+datagen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_decimal+datagen-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_decimal+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_decimal+datagen-devel}"
SRC_URI[x86_64_v2_rust-icu_decimal+datagen-devel.sha256sum] = "f1b1e1e8c0d9841ace00034b2f2d8ae56b938ca478e08769b3031e862c43e819"

URI_x86_64_v2_rust-icu_decimal+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_decimal+default-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_decimal+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_decimal+default-devel}"
SRC_URI[x86_64_v2_rust-icu_decimal+default-devel.sha256sum] = "ebe968182b6e16cae7bfeeb0a988edab1a94b6f39402fcbe8716b150fc09a655"

URI_x86_64_v2_rust-icu_decimal+ryu-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_decimal+ryu-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_decimal+ryu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_decimal+ryu-devel}"
SRC_URI[x86_64_v2_rust-icu_decimal+ryu-devel.sha256sum] = "d871512ac0dfcdf537bbe07e1f2cce29546f97d4bbf24c8ef69949aa58eb6e55"

URI_x86_64_v2_rust-icu_decimal+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_decimal+serde-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_decimal+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_decimal+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_decimal+serde-devel.sha256sum] = "a55e67c8f1cca17263453ceb321fd75b3292a5ea5ec07386c8b751b5e6bca06f"

URI_x86_64_v2_rust-icu_decimal+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_decimal+unstable-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_decimal+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_decimal+unstable-devel}"
SRC_URI[x86_64_v2_rust-icu_decimal+unstable-devel.sha256sum] = "8b5a4eb6c3d769b8746d0a3befaa8c493767b606e6f13dada9521bf45ae6604d"

URI_x86_64_v2_rust-icu_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_decimal-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_decimal-devel}"
SRC_URI[x86_64_v2_rust-icu_decimal-devel.sha256sum] = "d1ffcfc7cd9cf18d33e9f53899c006cc08cbef12b5be36802cf68a771711b5c7"

URI_aarch64_rust-icu_decimal+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_decimal+alloc-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_decimal+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_decimal+alloc-devel}"
SRC_URI[aarch64_rust-icu_decimal+alloc-devel.sha256sum] = "aaf824be1afe6d01cbfffb76c36600f98544ab3ed5becaff468aec9aff059367"

URI_aarch64_rust-icu_decimal+compiled_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_decimal+compiled_data-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_decimal+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_decimal+compiled_data-devel}"
SRC_URI[aarch64_rust-icu_decimal+compiled_data-devel.sha256sum] = "3d53f659913aa28c57a717fb02e9bb53ba06d7162f9403f157acf8c70e667afa"

URI_aarch64_rust-icu_decimal+datagen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_decimal+datagen-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_decimal+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_decimal+datagen-devel}"
SRC_URI[aarch64_rust-icu_decimal+datagen-devel.sha256sum] = "0b5f53ed4c9c12893bf2d5e0efb8353e1a571add8e384ef7cf7159a612e798cd"

URI_aarch64_rust-icu_decimal+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_decimal+default-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_decimal+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_decimal+default-devel}"
SRC_URI[aarch64_rust-icu_decimal+default-devel.sha256sum] = "a7b9fb4700d9c433d0ed9510dd0ef373c1cee76fd5a0beb0e8f5dfcaaad53029"

URI_aarch64_rust-icu_decimal+ryu-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_decimal+ryu-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_decimal+ryu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_decimal+ryu-devel}"
SRC_URI[aarch64_rust-icu_decimal+ryu-devel.sha256sum] = "d46210dd8d6347fdaa49f63a0428fa102b3337488a3f19cc8f73a1c57db15eaa"

URI_aarch64_rust-icu_decimal+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_decimal+serde-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_decimal+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_decimal+serde-devel}"
SRC_URI[aarch64_rust-icu_decimal+serde-devel.sha256sum] = "ea7f07c9c19934e3145da6ff2bb56eb893004b1be66691969a615305e9f1d54f"

URI_aarch64_rust-icu_decimal+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_decimal+unstable-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_decimal+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_decimal+unstable-devel}"
SRC_URI[aarch64_rust-icu_decimal+unstable-devel.sha256sum] = "e3eb3784f8af5ed25e72397905aad251eaf552a1ecab95f65251e1b68fd33474"

URI_aarch64_rust-icu_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_decimal-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_decimal-devel}"
SRC_URI[aarch64_rust-icu_decimal-devel.sha256sum] = "84ac2a36f570aedb799fb65942640ebb4c46e6b520e012bfa1399ab5d1823af8"

RDEPENDS:rust-icu_decimal+alloc-devel = " \
 cargo \
 rust-icu_decimal-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerovec+alloc-devel \
 "
RDEPENDS:rust-icu_decimal+compiled_data-devel = " \
 cargo \
 rust-icu_decimal-devel \
 rust-icu_decimal_data-devel \
 rust-icu_locale+compiled_data-devel \
 rust-icu_locale-devel \
 rust-icu_plurals+compiled_data-devel \
 rust-icu_plurals-devel \
 rust-icu_provider+baked-devel \
 "
RDEPENDS:rust-icu_decimal+datagen-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-icu_decimal+alloc-devel \
 rust-icu_decimal+serde-devel \
 rust-icu_decimal-devel \
 rust-icu_plurals+datagen-devel \
 rust-icu_plurals-devel \
 rust-icu_provider+export-devel \
 rust-zerovec+databake-devel \
 "
RDEPENDS:rust-icu_decimal+default-devel = " \
 cargo \
 rust-icu_decimal+compiled_data-devel \
 rust-icu_decimal-devel \
 "
RDEPENDS:rust-icu_decimal+ryu-devel = " \
 cargo \
 rust-fixed_decimal+ryu-devel \
 rust-icu_decimal-devel \
 "
RDEPENDS:rust-icu_decimal+serde-devel = " \
 cargo \
 rust-icu_decimal+alloc-devel \
 rust-icu_decimal-devel \
 rust-icu_pattern+serde-devel \
 rust-icu_pattern+zerovec-devel \
 rust-icu_pattern-devel \
 rust-icu_plurals+serde-devel \
 rust-icu_plurals-devel \
 rust-icu_provider+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerovec+serde-devel \
 "
RDEPENDS:rust-icu_decimal+unstable-devel = " \
 cargo \
 rust-icu_decimal-devel \
 rust-icu_pattern+zerovec-devel \
 rust-icu_pattern-devel \
 rust-icu_plurals-devel \
 "
RDEPENDS:rust-icu_decimal-devel = " \
 cargo \
 rust \
 rust-displaydoc-devel \
 rust-fixed_decimal-devel \
 rust-icu_locale_core-devel \
 rust-icu_provider-devel \
 rust-writeable-devel \
 rust-zerovec+alloc-devel \
 rust-zerovec-devel \
 "
