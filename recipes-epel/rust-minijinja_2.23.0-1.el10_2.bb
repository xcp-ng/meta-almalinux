# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-minijinja"
PV = "2.23.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-minijinja+adjacent_loop_items-devel \
 rust-minijinja+builtins-devel \
 rust-minijinja+custom_syntax-devel \
 rust-minijinja+debug-devel \
 rust-minijinja+default-devel \
 rust-minijinja+deserialization-devel \
 rust-minijinja+fuel-devel \
 rust-minijinja+indexmap-devel \
 rust-minijinja+internal_debug-devel \
 rust-minijinja+internal_safe_search-devel \
 rust-minijinja+json-devel \
 rust-minijinja+key_interning-devel \
 rust-minijinja+loader-devel \
 rust-minijinja+loop_controls-devel \
 rust-minijinja+macros-devel \
 rust-minijinja+multi_template-devel \
 rust-minijinja+percent-encoding-devel \
 rust-minijinja+preserve_order-devel \
 rust-minijinja+serde-devel \
 rust-minijinja+serde_json-devel \
 rust-minijinja+speedups-devel \
 rust-minijinja+stacker-devel \
 rust-minijinja+std_collections-devel \
 rust-minijinja+unicase-devel \
 rust-minijinja+unicode-devel \
 rust-minijinja+unicode-ident-devel \
 rust-minijinja+unstable_machinery-devel \
 rust-minijinja+unstable_machinery_serde-devel \
 rust-minijinja+urlencode-devel \
 rust-minijinja+v_htmlescape-devel \
 rust-minijinja-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-minijinja-2.23.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6fcb33127407b395e8f058ce63c28d47b7745ce7516c503d501b12cf6f4cb3d9"

URI_x86_64_v2_rust-minijinja+adjacent_loop_items-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+adjacent_loop_items-devel-2.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+adjacent_loop_items-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+adjacent_loop_items-devel}"
SRC_URI[x86_64_v2_rust-minijinja+adjacent_loop_items-devel.sha256sum] = "7be18b858a8d836e12425a16c5891086741b2a0bb7c862ffd40d06d596efb6c3"

URI_x86_64_v2_rust-minijinja+builtins-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+builtins-devel-2.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+builtins-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+builtins-devel}"
SRC_URI[x86_64_v2_rust-minijinja+builtins-devel.sha256sum] = "24dacfb4ce1e673068a1e54478f85cb506866f9258ea8ebfbf1f40abee4a3abc"

URI_x86_64_v2_rust-minijinja+custom_syntax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+custom_syntax-devel-2.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+custom_syntax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+custom_syntax-devel}"
SRC_URI[x86_64_v2_rust-minijinja+custom_syntax-devel.sha256sum] = "1417cd52d66cd674c799174465b495962239f95eadf73e9293564427b351e9e2"

URI_x86_64_v2_rust-minijinja+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+debug-devel-2.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+debug-devel}"
SRC_URI[x86_64_v2_rust-minijinja+debug-devel.sha256sum] = "63b44aaeaf7664de11efa9028323297ad19d167732d0471eda9b1ec5718d781d"

URI_x86_64_v2_rust-minijinja+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+default-devel-2.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+default-devel}"
SRC_URI[x86_64_v2_rust-minijinja+default-devel.sha256sum] = "90933322ecde4b415102dffb5f4355f25cfc58c03a743fc092664dce64bf6861"

URI_x86_64_v2_rust-minijinja+deserialization-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+deserialization-devel-2.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+deserialization-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+deserialization-devel}"
SRC_URI[x86_64_v2_rust-minijinja+deserialization-devel.sha256sum] = "a1f8a028b6b6014a9a76d1b934aca84f4c8505ff32f032096cdacc4b5b161e53"

URI_x86_64_v2_rust-minijinja+fuel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+fuel-devel-2.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+fuel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+fuel-devel}"
SRC_URI[x86_64_v2_rust-minijinja+fuel-devel.sha256sum] = "2c579c85dd32f74d7521858cd1ca0f1e38d302a2f6e0a8af2651668fe9939521"

URI_x86_64_v2_rust-minijinja+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+indexmap-devel-2.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+indexmap-devel}"
SRC_URI[x86_64_v2_rust-minijinja+indexmap-devel.sha256sum] = "b14e65aa2602c15571d0769d4cd3bca5567894a9187d049bef7981ccbbed6275"

URI_x86_64_v2_rust-minijinja+internal_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+internal_debug-devel-2.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+internal_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+internal_debug-devel}"
SRC_URI[x86_64_v2_rust-minijinja+internal_debug-devel.sha256sum] = "b164c8090666cd5793d9e5971490f4c705abbd825341b10bac2a138a3658066a"

URI_x86_64_v2_rust-minijinja+internal_safe_search-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+internal_safe_search-devel-2.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+internal_safe_search-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+internal_safe_search-devel}"
SRC_URI[x86_64_v2_rust-minijinja+internal_safe_search-devel.sha256sum] = "89fcc645776bd6f833f737995050f31acbd6e7a26183e6049c53c150a3d93546"

URI_x86_64_v2_rust-minijinja+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+json-devel-2.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+json-devel}"
SRC_URI[x86_64_v2_rust-minijinja+json-devel.sha256sum] = "876551292675d8a940d9b49f9acc05fff577b59995df956315eaef9e28af789f"

URI_x86_64_v2_rust-minijinja+key_interning-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+key_interning-devel-2.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+key_interning-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+key_interning-devel}"
SRC_URI[x86_64_v2_rust-minijinja+key_interning-devel.sha256sum] = "648b5b0d7e228b30fbcf3e3c72b718e163252edf0f74d9bd16b0e55b217eec29"

URI_x86_64_v2_rust-minijinja+loader-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+loader-devel-2.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+loader-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+loader-devel}"
SRC_URI[x86_64_v2_rust-minijinja+loader-devel.sha256sum] = "329236f6643a7069ccd0d228b781fec895b6bb33e633dfd7c734c68d2b18d0fa"

URI_x86_64_v2_rust-minijinja+loop_controls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+loop_controls-devel-2.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+loop_controls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+loop_controls-devel}"
SRC_URI[x86_64_v2_rust-minijinja+loop_controls-devel.sha256sum] = "be6b5a6b910a4909e5186dcba6a576cda6cec803f8747b413628144358145dbd"

URI_x86_64_v2_rust-minijinja+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+macros-devel-2.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+macros-devel}"
SRC_URI[x86_64_v2_rust-minijinja+macros-devel.sha256sum] = "edc81760b38b5f59218f0a778e2cca25a74803ef3aa2919e73bd133cb1bd12f6"

URI_x86_64_v2_rust-minijinja+multi_template-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+multi_template-devel-2.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+multi_template-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+multi_template-devel}"
SRC_URI[x86_64_v2_rust-minijinja+multi_template-devel.sha256sum] = "3345efa824e89b3a26eef4c7e0e6bac572f0eb1e9eb48c72287c111096d30b16"

URI_x86_64_v2_rust-minijinja+percent-encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+percent-encoding-devel-2.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+percent-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+percent-encoding-devel}"
SRC_URI[x86_64_v2_rust-minijinja+percent-encoding-devel.sha256sum] = "81083da6cff76a1f928b66c519026bf377acd596ac3f90c0aa46460329180ed9"

URI_x86_64_v2_rust-minijinja+preserve_order-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+preserve_order-devel-2.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+preserve_order-devel}"
SRC_URI[x86_64_v2_rust-minijinja+preserve_order-devel.sha256sum] = "28042aa9faf11a3ed0998e9d2c6a4738cc5331d383f828d4f8ba813614c9ec83"

URI_x86_64_v2_rust-minijinja+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+serde-devel-2.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+serde-devel}"
SRC_URI[x86_64_v2_rust-minijinja+serde-devel.sha256sum] = "3b0f68cd29d1e3686f105efe11c5265bc6348e079a403934f549fd9283b544a7"

URI_x86_64_v2_rust-minijinja+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+serde_json-devel-2.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+serde_json-devel}"
SRC_URI[x86_64_v2_rust-minijinja+serde_json-devel.sha256sum] = "c0eebf127748f60490ceb2cd56fcb5dcb05a82fc99a3ff74163f59b30c389474"

URI_x86_64_v2_rust-minijinja+speedups-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+speedups-devel-2.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+speedups-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+speedups-devel}"
SRC_URI[x86_64_v2_rust-minijinja+speedups-devel.sha256sum] = "0e88b9fa9f8ba881d3eb5bf971abc5b35313e76c769f64498d667a5b2d58ba11"

URI_x86_64_v2_rust-minijinja+stacker-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+stacker-devel-2.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+stacker-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+stacker-devel}"
SRC_URI[x86_64_v2_rust-minijinja+stacker-devel.sha256sum] = "c500c327f393bfc7758089c09e1dbc02051c92a19ac2fa4acac41c2ed7e4ce2f"

URI_x86_64_v2_rust-minijinja+std_collections-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+std_collections-devel-2.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+std_collections-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+std_collections-devel}"
SRC_URI[x86_64_v2_rust-minijinja+std_collections-devel.sha256sum] = "e163ee713565f96edd0898fc042e318a303ff7fe5f7b1734c96b184661ad2784"

URI_x86_64_v2_rust-minijinja+unicase-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+unicase-devel-2.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+unicase-devel}"
SRC_URI[x86_64_v2_rust-minijinja+unicase-devel.sha256sum] = "691634452e5373604be499806810b7175bbc84f2b47df91a1408ad802eceab91"

URI_x86_64_v2_rust-minijinja+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+unicode-devel-2.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+unicode-devel}"
SRC_URI[x86_64_v2_rust-minijinja+unicode-devel.sha256sum] = "9e8c2dbd4686ee0888e705dffa870926d1406bfe94053af8e7e8a8366e8cc729"

URI_x86_64_v2_rust-minijinja+unicode-ident-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+unicode-ident-devel-2.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+unicode-ident-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+unicode-ident-devel}"
SRC_URI[x86_64_v2_rust-minijinja+unicode-ident-devel.sha256sum] = "c34394bef287860dc4e2c6f4c126f7726dc43f0962e01ecb9d4448dfdaef5333"

URI_x86_64_v2_rust-minijinja+unstable_machinery-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+unstable_machinery-devel-2.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+unstable_machinery-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+unstable_machinery-devel}"
SRC_URI[x86_64_v2_rust-minijinja+unstable_machinery-devel.sha256sum] = "9fff56dd28d32574c78b20cc119635db5ac7ce214b77923e0b4c66294968b708"

URI_x86_64_v2_rust-minijinja+unstable_machinery_serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+unstable_machinery_serde-devel-2.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+unstable_machinery_serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+unstable_machinery_serde-devel}"
SRC_URI[x86_64_v2_rust-minijinja+unstable_machinery_serde-devel.sha256sum] = "546be5219f3c1f222bbe2d6603be7cfd711e3034e251a791e8e26c1cb3c3d75f"

URI_x86_64_v2_rust-minijinja+urlencode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+urlencode-devel-2.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+urlencode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+urlencode-devel}"
SRC_URI[x86_64_v2_rust-minijinja+urlencode-devel.sha256sum] = "a5eecd0559bb5d09645cae242c7c77ee169aca780a785f225066729beb11e7e1"

URI_x86_64_v2_rust-minijinja+v_htmlescape-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+v_htmlescape-devel-2.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+v_htmlescape-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+v_htmlescape-devel}"
SRC_URI[x86_64_v2_rust-minijinja+v_htmlescape-devel.sha256sum] = "673512c17bb3c8ce3bcb3acf42695b52093a854f9413ec7bc679a7b8e9f7199f"

URI_x86_64_v2_rust-minijinja-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja-devel-2.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja-devel}"
SRC_URI[x86_64_v2_rust-minijinja-devel.sha256sum] = "dc3594948d058f1387ad73ca46474047b8fa3f5974652d2e38fd74a0423e00f6"

URI_aarch64_rust-minijinja+adjacent_loop_items-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+adjacent_loop_items-devel-2.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+adjacent_loop_items-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+adjacent_loop_items-devel}"
SRC_URI[aarch64_rust-minijinja+adjacent_loop_items-devel.sha256sum] = "c5f5f28251c606667700444d2893418ddbfef1e97aa773b5c93f8599fc1a2de4"

URI_aarch64_rust-minijinja+builtins-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+builtins-devel-2.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+builtins-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+builtins-devel}"
SRC_URI[aarch64_rust-minijinja+builtins-devel.sha256sum] = "f9d1f4baf4fe194a43c6351a9e9746b3f72d7c6c86de75748f9f169efb8e5892"

URI_aarch64_rust-minijinja+custom_syntax-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+custom_syntax-devel-2.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+custom_syntax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+custom_syntax-devel}"
SRC_URI[aarch64_rust-minijinja+custom_syntax-devel.sha256sum] = "822091311c825d0513e7cc424adc32ba753401954a1e9c886b93923da2b33d0c"

URI_aarch64_rust-minijinja+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+debug-devel-2.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+debug-devel}"
SRC_URI[aarch64_rust-minijinja+debug-devel.sha256sum] = "099fb0d1567d8d951a58c343bac6e10742a55ab1dd409cd47871024e8385820a"

URI_aarch64_rust-minijinja+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+default-devel-2.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+default-devel}"
SRC_URI[aarch64_rust-minijinja+default-devel.sha256sum] = "4777cdd84e56af42ac80bbb4b84d62aab7f0149d25f05b100da11471016fb701"

URI_aarch64_rust-minijinja+deserialization-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+deserialization-devel-2.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+deserialization-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+deserialization-devel}"
SRC_URI[aarch64_rust-minijinja+deserialization-devel.sha256sum] = "abe55022bbe81d09fae8814cb1a8ba42186dd414686e732477e9d942693efe53"

URI_aarch64_rust-minijinja+fuel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+fuel-devel-2.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+fuel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+fuel-devel}"
SRC_URI[aarch64_rust-minijinja+fuel-devel.sha256sum] = "6ed9e18e03716bf5b08c84b78e680b3ac4314212c8630e8b91ef39e15cdbaade"

URI_aarch64_rust-minijinja+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+indexmap-devel-2.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+indexmap-devel}"
SRC_URI[aarch64_rust-minijinja+indexmap-devel.sha256sum] = "f21e33d4152b6afcd82ce554bd675cc45ba7d869efb45f222060edab56950451"

URI_aarch64_rust-minijinja+internal_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+internal_debug-devel-2.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+internal_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+internal_debug-devel}"
SRC_URI[aarch64_rust-minijinja+internal_debug-devel.sha256sum] = "7dd8f26863d22b3ded98c0767135b5988b56f383c63349898eda6e14a95cf670"

URI_aarch64_rust-minijinja+internal_safe_search-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+internal_safe_search-devel-2.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+internal_safe_search-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+internal_safe_search-devel}"
SRC_URI[aarch64_rust-minijinja+internal_safe_search-devel.sha256sum] = "b2e00e156c5bd79476e7238e118a0dea4058ef4b21faf20eae5f847431ea6674"

URI_aarch64_rust-minijinja+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+json-devel-2.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+json-devel}"
SRC_URI[aarch64_rust-minijinja+json-devel.sha256sum] = "bd8af7d4b1545f7d8d93fa83433e057bda1a50e59bd2e4e9b4545464a683638b"

URI_aarch64_rust-minijinja+key_interning-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+key_interning-devel-2.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+key_interning-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+key_interning-devel}"
SRC_URI[aarch64_rust-minijinja+key_interning-devel.sha256sum] = "f6eadcfb05fb4da6ecc34b2e4f1e10248bfcb76b744d35c5459fc6ecdaf523e1"

URI_aarch64_rust-minijinja+loader-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+loader-devel-2.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+loader-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+loader-devel}"
SRC_URI[aarch64_rust-minijinja+loader-devel.sha256sum] = "d0c8219eb792145780ff6cada4ef2804fd3273983ba9801f708027a124793ae8"

URI_aarch64_rust-minijinja+loop_controls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+loop_controls-devel-2.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+loop_controls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+loop_controls-devel}"
SRC_URI[aarch64_rust-minijinja+loop_controls-devel.sha256sum] = "947df2625ce1c45ba451008d9fec63b5f08162087ca4b727f31d9162bbeb04bb"

URI_aarch64_rust-minijinja+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+macros-devel-2.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+macros-devel}"
SRC_URI[aarch64_rust-minijinja+macros-devel.sha256sum] = "292c2ac4ecd2a425ab2fd9b722e3599cd2ed520aaf207758475f1cda3714eb61"

URI_aarch64_rust-minijinja+multi_template-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+multi_template-devel-2.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+multi_template-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+multi_template-devel}"
SRC_URI[aarch64_rust-minijinja+multi_template-devel.sha256sum] = "3fa29e241add27762befc701f858360a422a817adfdd92e3a7a12a01ba0a0f2f"

URI_aarch64_rust-minijinja+percent-encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+percent-encoding-devel-2.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+percent-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+percent-encoding-devel}"
SRC_URI[aarch64_rust-minijinja+percent-encoding-devel.sha256sum] = "90e9ed4a2460c1bbec2e1e8e39e04cdab151c0702d2d49c64c7202a02996b430"

URI_aarch64_rust-minijinja+preserve_order-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+preserve_order-devel-2.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+preserve_order-devel}"
SRC_URI[aarch64_rust-minijinja+preserve_order-devel.sha256sum] = "c73ccbc8f565a6bc75db90fecffa545a4ab47da03164aeb3f0786277acc1c37d"

URI_aarch64_rust-minijinja+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+serde-devel-2.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+serde-devel}"
SRC_URI[aarch64_rust-minijinja+serde-devel.sha256sum] = "cc999a304f74296317304b05d92bba1180391ecde8c93df06a59d789d0cdf815"

URI_aarch64_rust-minijinja+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+serde_json-devel-2.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+serde_json-devel}"
SRC_URI[aarch64_rust-minijinja+serde_json-devel.sha256sum] = "3c030f84aa35bae38a898fe4117d68a663cc97ae18b5563272c73776ec1b86cf"

URI_aarch64_rust-minijinja+speedups-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+speedups-devel-2.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+speedups-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+speedups-devel}"
SRC_URI[aarch64_rust-minijinja+speedups-devel.sha256sum] = "f5a43bb54bc534b597d8b2baf91d5284a9f5afb06616c9529cc670f478659251"

URI_aarch64_rust-minijinja+stacker-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+stacker-devel-2.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+stacker-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+stacker-devel}"
SRC_URI[aarch64_rust-minijinja+stacker-devel.sha256sum] = "7f08a9985934bd2d07f3705e0fc0611d79a8d3133a12afed762cf13326c4d034"

URI_aarch64_rust-minijinja+std_collections-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+std_collections-devel-2.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+std_collections-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+std_collections-devel}"
SRC_URI[aarch64_rust-minijinja+std_collections-devel.sha256sum] = "2cbcf02e51d0fd7536c6c22e673e544bfda515a51ff2b53d74a06a40f7c6840d"

URI_aarch64_rust-minijinja+unicase-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+unicase-devel-2.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+unicase-devel}"
SRC_URI[aarch64_rust-minijinja+unicase-devel.sha256sum] = "230ff0edad3dfcb4cc165a764a991e1cf4bd71b4ad5792fcaaa6af4080135de6"

URI_aarch64_rust-minijinja+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+unicode-devel-2.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+unicode-devel}"
SRC_URI[aarch64_rust-minijinja+unicode-devel.sha256sum] = "5b7ea943cb9e96734fd9a4403d84d6f1448fcc7b623c29dabedad7cd127f7db0"

URI_aarch64_rust-minijinja+unicode-ident-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+unicode-ident-devel-2.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+unicode-ident-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+unicode-ident-devel}"
SRC_URI[aarch64_rust-minijinja+unicode-ident-devel.sha256sum] = "98def8b4bf9c73f2f2b9f83b782d4df8302eb7346f75dc4e62681a65338b84f6"

URI_aarch64_rust-minijinja+unstable_machinery-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+unstable_machinery-devel-2.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+unstable_machinery-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+unstable_machinery-devel}"
SRC_URI[aarch64_rust-minijinja+unstable_machinery-devel.sha256sum] = "a53f1cc9d9bb745ebc6c333f960f5d5d773bb1afcb4c8d652143d68b176f493f"

URI_aarch64_rust-minijinja+unstable_machinery_serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+unstable_machinery_serde-devel-2.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+unstable_machinery_serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+unstable_machinery_serde-devel}"
SRC_URI[aarch64_rust-minijinja+unstable_machinery_serde-devel.sha256sum] = "ba6c3ae7b750270625958b38db0c8a6cd6ae766e972b5f734335b1483c20ba3c"

URI_aarch64_rust-minijinja+urlencode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+urlencode-devel-2.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+urlencode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+urlencode-devel}"
SRC_URI[aarch64_rust-minijinja+urlencode-devel.sha256sum] = "21270e9d1036437b95265bb33ec778c47cc0c1d222bf6172b7a9952cecdbee25"

URI_aarch64_rust-minijinja+v_htmlescape-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+v_htmlescape-devel-2.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+v_htmlescape-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+v_htmlescape-devel}"
SRC_URI[aarch64_rust-minijinja+v_htmlescape-devel.sha256sum] = "12a72f752a1093ff5a398877353498d2f199b3b4de874cb8cebcb4a813a3059d"

URI_aarch64_rust-minijinja-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja-devel-2.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja-devel}"
SRC_URI[aarch64_rust-minijinja-devel.sha256sum] = "551fb3cc08346408511dc7373640b0589078e5ddf8db7de500608fac49b0bf51"

RDEPENDS:rust-minijinja+adjacent_loop_items-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+builtins-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+custom_syntax-devel = " \
 cargo \
 rust-aho-corasick-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+debug-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+default-devel = " \
 cargo \
 rust-minijinja+adjacent_loop_items-devel \
 rust-minijinja+builtins-devel \
 rust-minijinja+debug-devel \
 rust-minijinja+deserialization-devel \
 rust-minijinja+macros-devel \
 rust-minijinja+multi_template-devel \
 rust-minijinja+serde-devel \
 rust-minijinja+std_collections-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+deserialization-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+fuel-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+indexmap-devel = " \
 cargo \
 rust-indexmap+default-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+internal_debug-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+internal_safe_search-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+json-devel = " \
 cargo \
 rust-minijinja+serde_json-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+key_interning-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+loader-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+loop_controls-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+macros-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+multi_template-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+percent-encoding-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-percent-encoding+default-devel \
 "
RDEPENDS:rust-minijinja+preserve_order-devel = " \
 cargo \
 rust-minijinja+indexmap-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+serde-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+serde_json-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-minijinja+speedups-devel = " \
 cargo \
 rust-minijinja+v_htmlescape-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+stacker-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-stacker+default-devel \
 "
RDEPENDS:rust-minijinja+std_collections-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+unicase-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-unicase+default-devel \
 "
RDEPENDS:rust-minijinja+unicode-devel = " \
 cargo \
 rust-minijinja+unicase-devel \
 rust-minijinja+unicode-ident-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+unicode-ident-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-unicode-ident+default-devel \
 "
RDEPENDS:rust-minijinja+unstable_machinery-devel = " \
 cargo \
 rust-minijinja+internal_debug-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+unstable_machinery_serde-devel = " \
 cargo \
 rust-minijinja+unstable_machinery-devel \
 rust-minijinja-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-minijinja+urlencode-devel = " \
 cargo \
 rust-minijinja+percent-encoding-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+v_htmlescape-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-v_htmlescape+default-devel \
 "
RDEPENDS:rust-minijinja-devel = " \
 cargo \
 rust \
 rust-memo-map+default-devel \
 rust-serde+default-devel \
 "
