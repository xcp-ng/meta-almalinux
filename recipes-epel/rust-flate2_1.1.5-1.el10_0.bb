# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-flate2"
PV = "1.1.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-flate2+any_impl-devel \
 rust-flate2+any_zlib-devel \
 rust-flate2+default-devel \
 rust-flate2+libz-ng-sys-devel \
 rust-flate2+libz-rs-sys-devel \
 rust-flate2+libz-sys-devel \
 rust-flate2+miniz-sys-devel \
 rust-flate2+miniz_oxide-devel \
 rust-flate2+rust_backend-devel \
 rust-flate2+zlib-default-devel \
 rust-flate2+zlib-devel \
 rust-flate2+zlib-ng-devel \
 rust-flate2+zlib-rs-devel \
 rust-flate2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-flate2-1.1.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "79b239d5705f5519dcb44f7322105f41a9f3d034c0738c5b638691e4f37a2618"

URI_x86_64_v2_rust-flate2+any_impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+any_impl-devel-1.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+any_impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+any_impl-devel}"
SRC_URI[x86_64_v2_rust-flate2+any_impl-devel.sha256sum] = "e77ce317c92356808a6ec44bd7739dcb0434d87b18751ad4b8c3f29fb0324010"

URI_x86_64_v2_rust-flate2+any_zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+any_zlib-devel-1.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+any_zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+any_zlib-devel}"
SRC_URI[x86_64_v2_rust-flate2+any_zlib-devel.sha256sum] = "45269ba6ab6752900131fe62873018fced9017c81382c5c91b48a32493db7ded"

URI_x86_64_v2_rust-flate2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+default-devel-1.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+default-devel}"
SRC_URI[x86_64_v2_rust-flate2+default-devel.sha256sum] = "ecac75c581966df2b8911bab6ec7715f0318b44d20ec6e5f27265ef640e6cc3f"

URI_x86_64_v2_rust-flate2+libz-ng-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+libz-ng-sys-devel-1.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+libz-ng-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+libz-ng-sys-devel}"
SRC_URI[x86_64_v2_rust-flate2+libz-ng-sys-devel.sha256sum] = "5c4489f1ca72641fe24756fbaefc793b4fa2d3fdd50cc5eafc7ff0f2f50d1354"

URI_x86_64_v2_rust-flate2+libz-rs-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+libz-rs-sys-devel-1.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+libz-rs-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+libz-rs-sys-devel}"
SRC_URI[x86_64_v2_rust-flate2+libz-rs-sys-devel.sha256sum] = "3324acb0d0a75f0d2b161a689891b5a4025d4a9f066b8ef3b1e80d1805928c3f"

URI_x86_64_v2_rust-flate2+libz-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+libz-sys-devel-1.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+libz-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+libz-sys-devel}"
SRC_URI[x86_64_v2_rust-flate2+libz-sys-devel.sha256sum] = "7d91bdfaefc62d0812ae5852aa84d0fa3c288fae5d4f1459f3946edc5561245a"

URI_x86_64_v2_rust-flate2+miniz-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+miniz-sys-devel-1.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+miniz-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+miniz-sys-devel}"
SRC_URI[x86_64_v2_rust-flate2+miniz-sys-devel.sha256sum] = "6616ea39899ea35df50d3e54205a9ca78e1c914bf638e470a0a49fd2833d0bcf"

URI_x86_64_v2_rust-flate2+miniz_oxide-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+miniz_oxide-devel-1.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+miniz_oxide-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+miniz_oxide-devel}"
SRC_URI[x86_64_v2_rust-flate2+miniz_oxide-devel.sha256sum] = "f15a1e892a6c3f36589dfd0d6e52c0ad6bd559cc2f23d1dc43961d390fa6be84"

URI_x86_64_v2_rust-flate2+rust_backend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+rust_backend-devel-1.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+rust_backend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+rust_backend-devel}"
SRC_URI[x86_64_v2_rust-flate2+rust_backend-devel.sha256sum] = "8fa2ef894b22731af442ba757f8854d338c28bc91831372ff37a14b1626d9d69"

URI_x86_64_v2_rust-flate2+zlib-default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+zlib-default-devel-1.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+zlib-default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+zlib-default-devel}"
SRC_URI[x86_64_v2_rust-flate2+zlib-default-devel.sha256sum] = "5cf9084e9300527c801ad3a4017e9b7a76607ff5bcd4164a920515e8a074db43"

URI_x86_64_v2_rust-flate2+zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+zlib-devel-1.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+zlib-devel}"
SRC_URI[x86_64_v2_rust-flate2+zlib-devel.sha256sum] = "ec40f8e4084c19e085584cd5f352fa37748bd76b5df00f136d0b20b0b5ea391e"

URI_x86_64_v2_rust-flate2+zlib-ng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+zlib-ng-devel-1.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+zlib-ng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+zlib-ng-devel}"
SRC_URI[x86_64_v2_rust-flate2+zlib-ng-devel.sha256sum] = "61e678abaa5caf0be004b383427afddbab9d46cbf85d9c717c59048eb4a26791"

URI_x86_64_v2_rust-flate2+zlib-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+zlib-rs-devel-1.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+zlib-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+zlib-rs-devel}"
SRC_URI[x86_64_v2_rust-flate2+zlib-rs-devel.sha256sum] = "13bf4d9e06cf8834f31fb8f079f562421183dff5b493f919714f0deac0d998b0"

URI_x86_64_v2_rust-flate2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2-devel-1.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2-devel}"
SRC_URI[x86_64_v2_rust-flate2-devel.sha256sum] = "68d0fc3e0fc5319ef74a3c176ffe1afd85eb892c33b39860f6c9fd97b993de12"

URI_aarch64_rust-flate2+any_impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+any_impl-devel-1.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-flate2+any_impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+any_impl-devel}"
SRC_URI[aarch64_rust-flate2+any_impl-devel.sha256sum] = "2a52b576c7cad14f3e440f62e62e2b6a18ae1fa18a446c51b0889148be872af8"

URI_aarch64_rust-flate2+any_zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+any_zlib-devel-1.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-flate2+any_zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+any_zlib-devel}"
SRC_URI[aarch64_rust-flate2+any_zlib-devel.sha256sum] = "2d8130fbfa50a06d7ae54ac28bad0e7e12916d46d1781bbc78886cb3792b2800"

URI_aarch64_rust-flate2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+default-devel-1.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-flate2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+default-devel}"
SRC_URI[aarch64_rust-flate2+default-devel.sha256sum] = "d7e0fb4c6917abbc97812cf3900bad08a6efec9afd7686b3398d3c1d6a75e78a"

URI_aarch64_rust-flate2+libz-ng-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+libz-ng-sys-devel-1.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-flate2+libz-ng-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+libz-ng-sys-devel}"
SRC_URI[aarch64_rust-flate2+libz-ng-sys-devel.sha256sum] = "eaaaa13955a3f8b3d936e194e100ed3521373248531ce010fd411aad70d86b17"

URI_aarch64_rust-flate2+libz-rs-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+libz-rs-sys-devel-1.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-flate2+libz-rs-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+libz-rs-sys-devel}"
SRC_URI[aarch64_rust-flate2+libz-rs-sys-devel.sha256sum] = "4b51cb8f708aaecf36fc8854ad09dd076f2a6c5f51e117ab00b05157d692297b"

URI_aarch64_rust-flate2+libz-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+libz-sys-devel-1.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-flate2+libz-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+libz-sys-devel}"
SRC_URI[aarch64_rust-flate2+libz-sys-devel.sha256sum] = "af8452dc760b400238bbca4301298a57f34599f5607a70a7e7768de5c3703b0e"

URI_aarch64_rust-flate2+miniz-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+miniz-sys-devel-1.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-flate2+miniz-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+miniz-sys-devel}"
SRC_URI[aarch64_rust-flate2+miniz-sys-devel.sha256sum] = "db40553d7db9bdac7576817eff0055c8e549b0ccf37d59067ae6b34d609a0483"

URI_aarch64_rust-flate2+miniz_oxide-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+miniz_oxide-devel-1.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-flate2+miniz_oxide-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+miniz_oxide-devel}"
SRC_URI[aarch64_rust-flate2+miniz_oxide-devel.sha256sum] = "035b350e33ef81fd5bb27fc694af62d70cbc4723a3e2e8457ce8522a643491c3"

URI_aarch64_rust-flate2+rust_backend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+rust_backend-devel-1.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-flate2+rust_backend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+rust_backend-devel}"
SRC_URI[aarch64_rust-flate2+rust_backend-devel.sha256sum] = "b3c148ad79b2bcecf53d3aea2f6b106da030a4e913ef15cdbb6bff7929025649"

URI_aarch64_rust-flate2+zlib-default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+zlib-default-devel-1.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-flate2+zlib-default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+zlib-default-devel}"
SRC_URI[aarch64_rust-flate2+zlib-default-devel.sha256sum] = "adcc0b2461c6e26e7b56362ea535155314336199038e2d43f4c5085ee5ec90ca"

URI_aarch64_rust-flate2+zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+zlib-devel-1.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-flate2+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+zlib-devel}"
SRC_URI[aarch64_rust-flate2+zlib-devel.sha256sum] = "b0df3ad6c699dfb1580ff2840bfafc7f6bc0da1c159c187534289061ffe1e8cd"

URI_aarch64_rust-flate2+zlib-ng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+zlib-ng-devel-1.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-flate2+zlib-ng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+zlib-ng-devel}"
SRC_URI[aarch64_rust-flate2+zlib-ng-devel.sha256sum] = "165ff797d003a9b7d7ed3c8b4f9893b505c21a7f7b15881255b3ee6d26c11311"

URI_aarch64_rust-flate2+zlib-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+zlib-rs-devel-1.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-flate2+zlib-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+zlib-rs-devel}"
SRC_URI[aarch64_rust-flate2+zlib-rs-devel.sha256sum] = "5076f0adef5c1d22850c5d9b50ff626d73b2bf96821d92e4d4016d5d5cc47780"

URI_aarch64_rust-flate2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2-devel-1.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-flate2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2-devel}"
SRC_URI[aarch64_rust-flate2-devel.sha256sum] = "d928ee1cee72093ce0be852177b5d93661973f5d11b293f553f5699e172091ab"

RDEPENDS:rust-flate2+any_impl-devel = " \
 cargo \
 rust-flate2-devel \
 "
RDEPENDS:rust-flate2+any_zlib-devel = " \
 cargo \
 rust-flate2+any_impl-devel \
 rust-flate2-devel \
 "
RDEPENDS:rust-flate2+default-devel = " \
 cargo \
 rust-flate2+rust_backend-devel \
 rust-flate2-devel \
 "
RDEPENDS:rust-flate2+libz-ng-sys-devel = " \
 cargo \
 rust-flate2-devel \
 rust-libz-ng-sys+default-devel \
 "
RDEPENDS:rust-flate2+libz-rs-sys-devel = " \
 cargo \
 rust-flate2-devel \
 rust-libz-rs-sys+rust-allocator-devel \
 rust-libz-rs-sys+std-devel \
 rust-libz-rs-sys-devel \
 "
RDEPENDS:rust-flate2+libz-sys-devel = " \
 cargo \
 rust-flate2-devel \
 rust-libz-sys-devel \
 "
RDEPENDS:rust-flate2+miniz-sys-devel = " \
 cargo \
 rust-flate2+rust_backend-devel \
 rust-flate2-devel \
 "
RDEPENDS:rust-flate2+miniz_oxide-devel = " \
 cargo \
 rust-flate2-devel \
 rust-miniz_oxide+simd-devel \
 rust-miniz_oxide+with-alloc-devel \
 rust-miniz_oxide-devel \
 "
RDEPENDS:rust-flate2+rust_backend-devel = " \
 cargo \
 rust-flate2+any_impl-devel \
 rust-flate2+miniz_oxide-devel \
 rust-flate2-devel \
 "
RDEPENDS:rust-flate2+zlib-default-devel = " \
 cargo \
 rust-flate2+any_zlib-devel \
 rust-flate2-devel \
 rust-libz-sys+default-devel \
 rust-libz-sys-devel \
 "
RDEPENDS:rust-flate2+zlib-devel = " \
 cargo \
 rust-flate2+any_zlib-devel \
 rust-flate2+libz-sys-devel \
 rust-flate2-devel \
 "
RDEPENDS:rust-flate2+zlib-ng-devel = " \
 cargo \
 rust-flate2+any_zlib-devel \
 rust-flate2+libz-ng-sys-devel \
 rust-flate2-devel \
 "
RDEPENDS:rust-flate2+zlib-rs-devel = " \
 cargo \
 rust-flate2+any_zlib-devel \
 rust-flate2+libz-rs-sys-devel \
 rust-flate2-devel \
 "
RDEPENDS:rust-flate2-devel = " \
 cargo \
 rust \
 rust-crc32fast+default-devel \
 "
