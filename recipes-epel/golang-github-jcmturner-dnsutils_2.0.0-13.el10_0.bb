# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-jcmturner-dnsutils"
PV = "2.0.0"
PR = "13.el10_0"
PACKAGES = " \
 golang-github-jcmturner-dnsutils-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-jcmturner-dnsutils-2.0.0-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43c9865069a90bcc92b28c56d1be9445e75ca4621cb41e1e9547f1977da7659c"

URI_x86_64_v2_golang-github-jcmturner-dnsutils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-jcmturner-dnsutils-devel-2.0.0-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-jcmturner-dnsutils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-jcmturner-dnsutils-devel}"
SRC_URI[x86_64_v2_golang-github-jcmturner-dnsutils-devel.sha256sum] = "7f21e400c84e4c16b318a2ff099423921507646cfb87876ece876fba4384a201"

URI_aarch64_golang-github-jcmturner-dnsutils-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-jcmturner-dnsutils-devel-2.0.0-13.el10_0.noarch.rpm;name=aarch64_golang-github-jcmturner-dnsutils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-jcmturner-dnsutils-devel}"
SRC_URI[aarch64_golang-github-jcmturner-dnsutils-devel.sha256sum] = "2a001f6e4787d773e28ed24203d17de41d839abc81f4648a762ae21a7e1b5ce2"

RDEPENDS:golang-github-jcmturner-dnsutils-devel = " \
 go-filesystem \
 "
