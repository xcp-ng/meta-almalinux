# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "marshalparser"
PV = "0.4.0"
PR = "5.el10"
PACKAGES = " \
 marshalparser \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/marshalparser-0.4.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "877f2405791c18a63adef763db9b94637d4aadc5ff8bc655e47b05ce631be09e"

URI_x86_64_v2_marshalparser = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/marshalparser-0.4.0-5.el10.noarch.rpm;name=x86_64_v2_marshalparser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marshalparser}"
SRC_URI[x86_64_v2_marshalparser.sha256sum] = "c9bbbbfffffe5deaf7453b6defe358493a8028dc9eddeeffc43824d88f35849d"

URI_aarch64_marshalparser = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/marshalparser-0.4.0-5.el10.noarch.rpm;name=aarch64_marshalparser;unpack=0"
SRC_URI:append = " ${URI_aarch64_marshalparser}"
SRC_URI[aarch64_marshalparser.sha256sum] = "c9bbbbfffffe5deaf7453b6defe358493a8028dc9eddeeffc43824d88f35849d"

RDEPENDS:marshalparser = " \
 python3 \
 "
