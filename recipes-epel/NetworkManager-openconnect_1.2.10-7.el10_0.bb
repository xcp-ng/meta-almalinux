# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "NetworkManager-openconnect"
PV = "1.2.10"
PR = "7.el10_0"
PACKAGES = " \
 NetworkManager-openconnect \
 NetworkManager-openconnect-gnome \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/NetworkManager-openconnect-1.2.10-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7385a3e4873233748e89578a0c8b0eb7b0deeebd95148ecfd36ff21c2f61ba2"

URI_x86_64_v2_NetworkManager-openconnect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/NetworkManager-openconnect-1.2.10-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-openconnect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-openconnect}"
SRC_URI[x86_64_v2_NetworkManager-openconnect.sha256sum] = "f3c91d4f09c403a1b818ec12da374df82e857d6e95e20756e985e1150ce2b89e"

URI_x86_64_v2_NetworkManager-openconnect-gnome = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/NetworkManager-openconnect-gnome-1.2.10-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-openconnect-gnome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-openconnect-gnome}"
SRC_URI[x86_64_v2_NetworkManager-openconnect-gnome.sha256sum] = "24ba44a90c9e05c89fee70dce5602821335fb2b5aa330433034293f9baa65dc5"

URI_aarch64_NetworkManager-openconnect = "${EPEL_MIRROR}/aarch64/Packages/n/NetworkManager-openconnect-1.2.10-7.el10_0.aarch64.rpm;name=aarch64_NetworkManager-openconnect;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-openconnect}"
SRC_URI[aarch64_NetworkManager-openconnect.sha256sum] = "3a440517c79c2c213c0ddae40e43c30d56d675bb7a6264066abd773e5274582f"

URI_aarch64_NetworkManager-openconnect-gnome = "${EPEL_MIRROR}/aarch64/Packages/n/NetworkManager-openconnect-gnome-1.2.10-7.el10_0.aarch64.rpm;name=aarch64_NetworkManager-openconnect-gnome;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-openconnect-gnome}"
SRC_URI[aarch64_NetworkManager-openconnect-gnome.sha256sum] = "4edc16fe8163ae19fa62bca190b7bd0825e82674ab874be762376ae20502c513"

RDEPENDS:NetworkManager-openconnect = " \
 NetworkManager \
 NetworkManager-libnm \
 bash \
 dbus-common \
 glib2 \
 glibc \
 libgcc \
 openconnect \
 shadow-utils \
 "
RDEPENDS:NetworkManager-openconnect-gnome = " \
 NetworkManager-libnm \
 NetworkManager-openconnect \
 atk \
 cairo \
 cairo-gobject \
 gcr3 \
 gcr3-base \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 graphene \
 gtk3 \
 gtk4 \
 harfbuzz \
 libnma \
 libnma-gtk4 \
 libsecret \
 libsoup3 \
 libxml2 \
 openconnect \
 pango \
 vulkan-loader \
 webkit2gtk4.1 \
 "
