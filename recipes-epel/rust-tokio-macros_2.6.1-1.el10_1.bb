# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio-macros"
PV = "2.6.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-tokio-macros+default-devel \
 rust-tokio-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-macros-2.6.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "23ac41d161e82b13695c5f66abb5d5a693c6861138fe87ce61f91a83e7fcb160"

URI_x86_64_v2_rust-tokio-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-macros+default-devel-2.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-macros+default-devel}"
SRC_URI[x86_64_v2_rust-tokio-macros+default-devel.sha256sum] = "f8b8adec4bcdaa033108f82541d7a3373327ca10dd4a0d86f8d10bc47c1ca8c2"

URI_x86_64_v2_rust-tokio-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-macros-devel-2.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-macros-devel}"
SRC_URI[x86_64_v2_rust-tokio-macros-devel.sha256sum] = "4d1af3431b04195f2629c055c797bda3d42d7a16ba6c9132db8dd35a5347a38b"

URI_aarch64_rust-tokio-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-macros+default-devel-2.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-macros+default-devel}"
SRC_URI[aarch64_rust-tokio-macros+default-devel.sha256sum] = "e12e35c5d6c03be46202514f87c94c89320f4c17225bbe3604d09720942b9681"

URI_aarch64_rust-tokio-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-macros-devel-2.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-macros-devel}"
SRC_URI[aarch64_rust-tokio-macros-devel.sha256sum] = "24178341234b2b3879c88b23599364666cfdb6fad9e2310c82c8378f6be6c1f3"

RDEPENDS:rust-tokio-macros+default-devel = " \
 cargo \
 rust-tokio-macros-devel \
 "
RDEPENDS:rust-tokio-macros-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
