# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kaccounts-providers"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kaccounts-providers \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kaccounts-providers-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4efd331a91802a7fe4b0c661486bd67c2a91e35535690d35e78f3feba032ef7c"

URI_x86_64_v2_kaccounts-providers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kaccounts-providers-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kaccounts-providers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kaccounts-providers}"
SRC_URI[x86_64_v2_kaccounts-providers.sha256sum] = "4e0f82d347d4c88303e5731eee1569f1c22aa149702c776985809429c89615fb"

URI_aarch64_kaccounts-providers = "${EPEL_MIRROR}/aarch64/Packages/k/kaccounts-providers-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kaccounts-providers;unpack=0"
SRC_URI:append = " ${URI_aarch64_kaccounts-providers}"
SRC_URI[aarch64_kaccounts-providers.sha256sum] = "3d8e75ba69926361f4034423eed25d92d817aeb7a2769582a3456aa60204d078"

RDEPENDS:kaccounts-providers = " \
 glibc \
 kaccounts-integration-qt6 \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kpackage \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebengine \
 signon-plugin-oauth2 \
 signon-ui \
 "
