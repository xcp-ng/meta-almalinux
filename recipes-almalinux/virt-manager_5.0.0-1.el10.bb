# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "virt-manager"
PV = "5.0.0"
PR = "1.el10"
PACKAGES = " \
 virt-install \
 virt-manager \
 virt-manager-common \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/virt-manager-5.0.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "33d77a1156045fef6f296c17afb4e309b9a7668e3aef7e8fdaa261e8b5353d82"

URI_x86_64_v2_virt-install = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/virt-install-5.0.0-1.el10.noarch.rpm;name=x86_64_v2_virt-install;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virt-install}"
SRC_URI[x86_64_v2_virt-install.sha256sum] = "200864675d278f3cddc11ebd80bd42d0bbea423b25306f13165331afea5b5079"

URI_x86_64_v2_virt-manager = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/virt-manager-5.0.0-1.el10.noarch.rpm;name=x86_64_v2_virt-manager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virt-manager}"
SRC_URI[x86_64_v2_virt-manager.sha256sum] = "2fdd870278528196682c62c9023828180b1171d79ec6e6aad4c88a016312f615"

URI_x86_64_v2_virt-manager-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/virt-manager-common-5.0.0-1.el10.noarch.rpm;name=x86_64_v2_virt-manager-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virt-manager-common}"
SRC_URI[x86_64_v2_virt-manager-common.sha256sum] = "4e725f2b10a8636c9c897d6dda847b24fde39f06bc8fa179658244f23e696e00"

URI_aarch64_virt-install = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/virt-install-5.0.0-1.el10.noarch.rpm;name=aarch64_virt-install;unpack=0"
SRC_URI:append = " ${URI_aarch64_virt-install}"
SRC_URI[aarch64_virt-install.sha256sum] = "200864675d278f3cddc11ebd80bd42d0bbea423b25306f13165331afea5b5079"

URI_aarch64_virt-manager = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/virt-manager-5.0.0-1.el10.noarch.rpm;name=aarch64_virt-manager;unpack=0"
SRC_URI:append = " ${URI_aarch64_virt-manager}"
SRC_URI[aarch64_virt-manager.sha256sum] = "2fdd870278528196682c62c9023828180b1171d79ec6e6aad4c88a016312f615"

URI_aarch64_virt-manager-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/virt-manager-common-5.0.0-1.el10.noarch.rpm;name=aarch64_virt-manager-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_virt-manager-common}"
SRC_URI[aarch64_virt-manager-common.sha256sum] = "4e725f2b10a8636c9c897d6dda847b24fde39f06bc8fa179658244f23e696e00"

RDEPENDS:virt-install = " \
 libvirt-client \
 python3 \
 virt-manager-common \
 "
RDEPENDS:virt-manager = " \
 dconf \
 gtk-vnc2 \
 gtk3 \
 libvirt-glib \
 python3 \
 python3-gobject \
 virt-manager-common \
 vte291 \
 "
RDEPENDS:virt-manager-common = " \
 libosinfo \
 python3-argcomplete \
 python3-gobject-base \
 python3-libvirt \
 python3-libxml2 \
 python3-requests \
 xorriso \
 "
