# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-miette-derive"
PV = "7.6.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-miette-derive+default-devel \
 rust-miette-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-miette-derive-7.6.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ffaf61493e1d90b645bd99a9bd7e2a976d0586ca1968ca38bfea9883ec14658f"

URI_x86_64_v2_rust-miette-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miette-derive+default-devel-7.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miette-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miette-derive+default-devel}"
SRC_URI[x86_64_v2_rust-miette-derive+default-devel.sha256sum] = "1e583d05b341f7d89e667d48165aed0bb9667a25b6e87f957218ce37c592ca8d"

URI_x86_64_v2_rust-miette-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miette-derive-devel-7.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miette-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miette-derive-devel}"
SRC_URI[x86_64_v2_rust-miette-derive-devel.sha256sum] = "79604e8f2b476fd95f4fda0e296661961db46b401b3fbbcaa4f863e0131969f5"

URI_aarch64_rust-miette-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miette-derive+default-devel-7.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-miette-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miette-derive+default-devel}"
SRC_URI[aarch64_rust-miette-derive+default-devel.sha256sum] = "44525658f9cd0a28993d86cd4c85adc095eedde31873780d9ca4adef7be468ea"

URI_aarch64_rust-miette-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miette-derive-devel-7.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-miette-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miette-derive-devel}"
SRC_URI[aarch64_rust-miette-derive-devel.sha256sum] = "ab2e1b3f4a11e879f9d77505f1fc19a053675df03789029ff78f86476e1bd900"

RDEPENDS:rust-miette-derive+default-devel = " \
 cargo \
 rust-miette-derive-devel \
 "
RDEPENDS:rust-miette-derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
