# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-digest-io"
PV = "0.1.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-digest-io+default-devel \
 rust-digest-io-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-digest-io-0.1.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "18d2b94370414e278e36209f308314095e4f947168abc42c53b6b711f6c0cd90"

URI_x86_64_v2_rust-digest-io+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest-io+default-devel-0.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest-io+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest-io+default-devel}"
SRC_URI[x86_64_v2_rust-digest-io+default-devel.sha256sum] = "7b5fbd0018db66fd0ee6d92f13df034c9670e9b824d79b42fd739b6c279654df"

URI_x86_64_v2_rust-digest-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest-io-devel-0.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest-io-devel}"
SRC_URI[x86_64_v2_rust-digest-io-devel.sha256sum] = "ea1dd8d7ef08a3d2a0d63f7cc97ade0e520ba4ecebe78c77674db34d13e582f6"

URI_aarch64_rust-digest-io+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest-io+default-devel-0.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-digest-io+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest-io+default-devel}"
SRC_URI[aarch64_rust-digest-io+default-devel.sha256sum] = "4e6b6959b917ecadbcf2af72a67c83a5a5630d03b6102ea30ad16a5bad7c2911"

URI_aarch64_rust-digest-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest-io-devel-0.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-digest-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest-io-devel}"
SRC_URI[aarch64_rust-digest-io-devel.sha256sum] = "ee7ba118fa5e60f57515ca396c5cfeb34bd2775dc4a774e61c1419bbcf86bc6b"

RDEPENDS:rust-digest-io+default-devel = " \
 cargo \
 rust-digest-io-devel \
 "
RDEPENDS:rust-digest-io-devel = " \
 cargo \
 rust \
 rust-digest+default-devel \
 "
