# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdegraphics-mobipocket"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kdegraphics-mobipocket \
 kdegraphics-mobipocket-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kdegraphics-mobipocket-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cb31d22b8e901defb602b4fd181dddbf90bcef6691e1c8fadcc83916bfd22887"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdegraphics-mobipocket-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdegraphics-mobipocket;unpack=0"
SRC_URI[x86_64_v2_kdegraphics-mobipocket.sha256sum] = "3245d541fe249fee3328665494b81defa74a3e911960a4ec2accf9a4fcd3d3f3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdegraphics-mobipocket-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdegraphics-mobipocket-devel;unpack=0"
SRC_URI[x86_64_v2_kdegraphics-mobipocket-devel.sha256sum] = "c9ecd3bf601961dc9cd1a90d5cfbc238b891224dce65ce1397c6657fa19d83be"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kdegraphics-mobipocket-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kdegraphics-mobipocket;unpack=0"
SRC_URI[aarch64_kdegraphics-mobipocket.sha256sum] = "ececb3cbf63a35d7dd92f8154edd2f2afaa20112ace964dbadd87513eb249a94"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kdegraphics-mobipocket-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kdegraphics-mobipocket-devel;unpack=0"
SRC_URI[aarch64_kdegraphics-mobipocket-devel.sha256sum] = "eb0b474c601db505da004a0211af4f705210c7d3d39e02cc962b2ccae4613da9"

RDEPENDS:kdegraphics-mobipocket = " \
 glibc \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kdegraphics-mobipocket-devel = " \
 cmake-filesystem \
 kdegraphics-mobipocket \
 "
