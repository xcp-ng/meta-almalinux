# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-sec"
PV = "0.12.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-sec+default-devel \
 rust-gix-sec+document-features-devel \
 rust-gix-sec+serde-devel \
 rust-gix-sec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-sec-0.12.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ac15a37edc7d7d29d658c5f07629fcb49196ffd2566f018d77c2b03bec66a1a"

URI_x86_64_v2_rust-gix-sec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-sec+default-devel-0.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-sec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-sec+default-devel}"
SRC_URI[x86_64_v2_rust-gix-sec+default-devel.sha256sum] = "906da2a1466e59331e39a38b8e489e06c4511d73bed0a6acc47f344cd4b9696c"

URI_x86_64_v2_rust-gix-sec+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-sec+document-features-devel-0.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-sec+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-sec+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-sec+document-features-devel.sha256sum] = "17d52803d26b7a0a9e9b8686d20781225aa81381b2d46efd1208f94f3adc4736"

URI_x86_64_v2_rust-gix-sec+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-sec+serde-devel-0.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-sec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-sec+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-sec+serde-devel.sha256sum] = "df49bf375e8e4a230c187654e455f01c4210ee42c4fc3dc51a9e5b890907267a"

URI_x86_64_v2_rust-gix-sec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-sec-devel-0.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-sec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-sec-devel}"
SRC_URI[x86_64_v2_rust-gix-sec-devel.sha256sum] = "416c4ec1cac3ede75d6c77642b37f67d9f368ca581971c189c096ceea65ee6bb"

URI_aarch64_rust-gix-sec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-sec+default-devel-0.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-sec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-sec+default-devel}"
SRC_URI[aarch64_rust-gix-sec+default-devel.sha256sum] = "82514c68154330185fc8a3837412fba483de0d161e872df61a4290d6ad2ff898"

URI_aarch64_rust-gix-sec+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-sec+document-features-devel-0.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-sec+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-sec+document-features-devel}"
SRC_URI[aarch64_rust-gix-sec+document-features-devel.sha256sum] = "beda46f6b9f94978ca85a94ecdb5c2deedae408ca2effb92bbe351841726db05"

URI_aarch64_rust-gix-sec+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-sec+serde-devel-0.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-sec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-sec+serde-devel}"
SRC_URI[aarch64_rust-gix-sec+serde-devel.sha256sum] = "66fa73ea48a2d36a598dd329921d5b31897ea715ce5a351d93822ff91b3f53a9"

URI_aarch64_rust-gix-sec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-sec-devel-0.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-sec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-sec-devel}"
SRC_URI[aarch64_rust-gix-sec-devel.sha256sum] = "9f116d0d4ea1d7dabfc0380c23bb66b30aa833d2449bd34bdaddc97450035bf3"

RDEPENDS:rust-gix-sec+default-devel = " \
 cargo \
 rust-gix-sec-devel \
 "
RDEPENDS:rust-gix-sec+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-sec-devel \
 "
RDEPENDS:rust-gix-sec+serde-devel = " \
 cargo \
 rust-bitflags+serde-devel \
 rust-gix-sec-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-sec-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-libc+default-devel \
 "
