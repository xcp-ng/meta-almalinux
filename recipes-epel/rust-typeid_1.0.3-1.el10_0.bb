# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-typeid"
PV = "1.0.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-typeid+default-devel \
 rust-typeid-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-typeid-1.0.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "61a027718f28e75b15fc1bf154100cbdfc9572f467aa2f3843f503f01dcd590d"

URI_x86_64_v2_rust-typeid+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typeid+default-devel-1.0.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typeid+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typeid+default-devel}"
SRC_URI[x86_64_v2_rust-typeid+default-devel.sha256sum] = "93c0315b3bd15a4deafa78d8529cf620a5bcc66ded88c50ac2a00821a394c4e2"

URI_x86_64_v2_rust-typeid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typeid-devel-1.0.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typeid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typeid-devel}"
SRC_URI[x86_64_v2_rust-typeid-devel.sha256sum] = "f58f212779cb1a9f32a65c9b0874144d82afcd60265640da31dfd395a57ae1c6"

URI_aarch64_rust-typeid+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typeid+default-devel-1.0.3-1.el10_0.noarch.rpm;name=aarch64_rust-typeid+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typeid+default-devel}"
SRC_URI[aarch64_rust-typeid+default-devel.sha256sum] = "ac80ae8f2fd44fd33d1a6d24dd8227cc47c1adae68714351400a6e26599c564f"

URI_aarch64_rust-typeid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typeid-devel-1.0.3-1.el10_0.noarch.rpm;name=aarch64_rust-typeid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typeid-devel}"
SRC_URI[aarch64_rust-typeid-devel.sha256sum] = "c2f9ed644a9eda5fc074db323a1ba8b350b074a0f35f46da58140af231095e99"

RDEPENDS:rust-typeid+default-devel = " \
 cargo \
 rust-typeid-devel \
 "
RDEPENDS:rust-typeid-devel = " \
 cargo \
 rust \
 "
