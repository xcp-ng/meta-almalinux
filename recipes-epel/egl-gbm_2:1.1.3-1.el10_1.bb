# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "egl-gbm"
PE = "2"
PV = "1.1.3"
PR = "1.el10_1"
PACKAGES = " \
 egl-gbm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/egl-gbm-1.1.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "444b130054f006cea4761b027b949c35749367430f5ab41d3f7c436a0dd65bb2"

URI_x86_64_v2_egl-gbm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/egl-gbm-1.1.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_egl-gbm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_egl-gbm}"
SRC_URI[x86_64_v2_egl-gbm.sha256sum] = "7786bcf8e3731cebf08652884ca3aeae786a793b20256bb0a0ebf9d2466bf561"

URI_aarch64_egl-gbm = "${EPEL_MIRROR}/aarch64/Packages/e/egl-gbm-1.1.3-1.el10_1.aarch64.rpm;name=aarch64_egl-gbm;unpack=0"
SRC_URI:append = " ${URI_aarch64_egl-gbm}"
SRC_URI[aarch64_egl-gbm.sha256sum] = "78e8b34f12dcd2de37bbef957c8325132f19fae5ce07a67dcbe373149e7b2554"

RDEPENDS:egl-gbm = " \
 glibc \
 libdrm \
 mesa-libgbm \
 "
