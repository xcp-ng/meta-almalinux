# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bgpq4"
PV = "1.16"
PR = "1.el10_1"
PACKAGES = " \
 bgpq4 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bgpq4-1.16-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78c31ef7b5ad74d9ffc08a429ba069e4699326a576848c1d9bd00039c3870d6d"

URI_x86_64_v2_bgpq4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bgpq4-1.16-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bgpq4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bgpq4}"
SRC_URI[x86_64_v2_bgpq4.sha256sum] = "187e5d079dce73e885906a5276f504c8ab8cbcba97c5d37699c04b71ff8ae8b2"

URI_aarch64_bgpq4 = "${EPEL_MIRROR}/aarch64/Packages/b/bgpq4-1.16-1.el10_1.aarch64.rpm;name=aarch64_bgpq4;unpack=0"
SRC_URI:append = " ${URI_aarch64_bgpq4}"
SRC_URI[aarch64_bgpq4.sha256sum] = "7beb4f92bf4e78baacecb16d0a5ef489146ca7ba33cab08347776705eb359ec2"

RDEPENDS:bgpq4 = " \
 glibc \
 "
