# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mio"
PV = "1.2.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-mio+default-devel \
 rust-mio+log-devel \
 rust-mio+net-devel \
 rust-mio+os-ext-devel \
 rust-mio+os-poll-devel \
 rust-mio-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-mio-1.2.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1ad21eea763031e865cfb514669c73bc0828df9d32731c9cb05194843d51b3ff"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio+default-devel-1.2.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-mio+default-devel.sha256sum] = "319144c661bff5ed7d651f68bff572bedfc0fd35ea7c7016de50c7d3cf06d3f0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio+log-devel-1.2.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio+log-devel;unpack=0"
SRC_URI[x86_64_v2_rust-mio+log-devel.sha256sum] = "986f3b29487740f0962906c1fe5c2db5d6e647d220c37fda14410eb7be8b9d5b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio+net-devel-1.2.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio+net-devel;unpack=0"
SRC_URI[x86_64_v2_rust-mio+net-devel.sha256sum] = "24e35f3f75198b217e28c67418f20dceec2bee4665b52bcedacac63d20fecfee"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio+os-ext-devel-1.2.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio+os-ext-devel;unpack=0"
SRC_URI[x86_64_v2_rust-mio+os-ext-devel.sha256sum] = "0f1a2c4689a5b9311d33145214feb2f11d0df046c6e190825e5fd7c9be53b563"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio+os-poll-devel-1.2.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio+os-poll-devel;unpack=0"
SRC_URI[x86_64_v2_rust-mio+os-poll-devel.sha256sum] = "612adcac88a3a7a242247cbf7522d88f3be94f03bd10132dd3c0f640fef99735"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio-devel-1.2.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio-devel;unpack=0"
SRC_URI[x86_64_v2_rust-mio-devel.sha256sum] = "aab27141f20f9fe7c5c8a5618f22f06e822d31079542d3e33d5398efde1d6209"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-mio+default-devel-1.2.3-1.el10_3.noarch.rpm;name=aarch64_rust-mio+default-devel;unpack=0"
SRC_URI[aarch64_rust-mio+default-devel.sha256sum] = "0b2a686fb4e3153455067b45bf104299cdea7b7bface59e0824a20bcd8d18e1a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-mio+log-devel-1.2.3-1.el10_3.noarch.rpm;name=aarch64_rust-mio+log-devel;unpack=0"
SRC_URI[aarch64_rust-mio+log-devel.sha256sum] = "9a4daa26c1468d46cb554811c8cf07178837507496feeeaa0f42b81434c9873d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-mio+net-devel-1.2.3-1.el10_3.noarch.rpm;name=aarch64_rust-mio+net-devel;unpack=0"
SRC_URI[aarch64_rust-mio+net-devel.sha256sum] = "a45ba1958a9cbf978dea7410e6f76cb46e90ee9f158fd187d9bf0359a2669d54"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-mio+os-ext-devel-1.2.3-1.el10_3.noarch.rpm;name=aarch64_rust-mio+os-ext-devel;unpack=0"
SRC_URI[aarch64_rust-mio+os-ext-devel.sha256sum] = "a90a46de883321dbf0fafffb42ed4e6d56a2251f0967f3e280c06c3a3d4d7d5d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-mio+os-poll-devel-1.2.3-1.el10_3.noarch.rpm;name=aarch64_rust-mio+os-poll-devel;unpack=0"
SRC_URI[aarch64_rust-mio+os-poll-devel.sha256sum] = "de4b5b47ec3510b575ff4fcf919dfdd1f118688730cef6a6ccdff4c010c39c62"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-mio-devel-1.2.3-1.el10_3.noarch.rpm;name=aarch64_rust-mio-devel;unpack=0"
SRC_URI[aarch64_rust-mio-devel.sha256sum] = "d3977ca2b94785b95e9e49b553cfc19bac2f55a0c57def8e94ba9571c37dfe59"

RDEPENDS:rust-mio+default-devel = " \
 cargo \
 rust-mio+log-devel \
 rust-mio-devel \
 "
RDEPENDS:rust-mio+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-mio-devel \
 "
RDEPENDS:rust-mio+net-devel = " \
 cargo \
 rust-mio-devel \
 "
RDEPENDS:rust-mio+os-ext-devel = " \
 cargo \
 rust-mio+os-poll-devel \
 rust-mio-devel \
 "
RDEPENDS:rust-mio+os-poll-devel = " \
 cargo \
 rust-mio-devel \
 "
RDEPENDS:rust-mio-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
