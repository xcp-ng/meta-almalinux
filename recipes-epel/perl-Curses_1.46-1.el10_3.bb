# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Curses"
PV = "1.46"
PR = "1.el10_3"
PACKAGES = " \
 perl-Curses \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Curses-1.46-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a07df516757e8fdc0fdc5f58f5c4474b3d395369073ec8c28a1e334d658cd222"

URI_x86_64_v2_perl-Curses = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Curses-1.46-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Curses;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Curses}"
SRC_URI[x86_64_v2_perl-Curses.sha256sum] = "aa55c6cd758b32fec5770b8ce6b01163b05c53deb8b5732082f6721896c4efb5"

URI_aarch64_perl-Curses = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Curses-1.46-1.el10_3.aarch64.rpm;name=aarch64_perl-Curses;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Curses}"
SRC_URI[aarch64_perl-Curses.sha256sum] = "e9159864632eef5d3ae3bf3ecb34afa7c32db6baf0b6776bf6002ab0f711cbd8"

RDEPENDS:perl-Curses = " \
 glibc \
 ncurses-libs \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 "
