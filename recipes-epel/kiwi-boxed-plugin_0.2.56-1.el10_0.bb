# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kiwi-boxed-plugin"
PV = "0.2.56"
PR = "1.el10_0"
PACKAGES = " \
 kiwi-boxed-plugin \
 python3-kiwi-boxed-plugin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kiwi-boxed-plugin-0.2.56-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bce40b11e22aabe1821f0edc2404cb52dde51719d21371853863f5a202e0584c"

URI_x86_64_v2_kiwi-boxed-plugin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-boxed-plugin-0.2.56-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kiwi-boxed-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-boxed-plugin}"
SRC_URI[x86_64_v2_kiwi-boxed-plugin.sha256sum] = "b55ca656aa0666744cc99aaae84748284f945ad3574382fe3c8e29495d57ca15"

URI_x86_64_v2_python3-kiwi-boxed-plugin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kiwi-boxed-plugin-0.2.56-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-kiwi-boxed-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kiwi-boxed-plugin}"
SRC_URI[x86_64_v2_python3-kiwi-boxed-plugin.sha256sum] = "3c5f29cde5c73779a6ec7a5bce61df61d72e9b698ae30ae30c1c237602dd53d3"

URI_aarch64_kiwi-boxed-plugin = "${EPEL_MIRROR}/aarch64/Packages/k/kiwi-boxed-plugin-0.2.56-1.el10_0.noarch.rpm;name=aarch64_kiwi-boxed-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiwi-boxed-plugin}"
SRC_URI[aarch64_kiwi-boxed-plugin.sha256sum] = "db8448f65b85f3ac16bdba1ea46d6b6c6c487fa6e330c7055a878a7d41385100"

URI_aarch64_python3-kiwi-boxed-plugin = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kiwi-boxed-plugin-0.2.56-1.el10_0.noarch.rpm;name=aarch64_python3-kiwi-boxed-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kiwi-boxed-plugin}"
SRC_URI[aarch64_python3-kiwi-boxed-plugin.sha256sum] = "7a416fc9b7034fe3c04f78cff7dcdfb9399333e57ee49cdc8265ca764f81032c"

RDEPENDS:kiwi-boxed-plugin = " \
 python3-kiwi-boxed-plugin \
 "
RDEPENDS:python3-kiwi-boxed-plugin = " \
 python3 \
 python3-cerberus \
 python3-docopt-ng \
 python3-kiwi \
 python3-progressbar2 \
 python3-pyyaml \
 python3-requests \
 qemu-kvm \
 "
