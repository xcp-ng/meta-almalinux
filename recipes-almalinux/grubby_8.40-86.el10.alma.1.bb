# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grubby"
PV = "8.40"
PR = "86.el10.alma.1"
PACKAGES = " \
 grubby \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/grubby-8.40-86.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c33b671946103ade3c507b1e833e643ce6fdfe27916143a7d1b09c301aa93577"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grubby-8.40-86.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_grubby;unpack=0"
SRC_URI[x86_64_v2_grubby.sha256sum] = "94f10735dee5f1ca276b5b9e99f1b96da5a92ddcfebdcb5317ce18e0115f46b0"
RPROVIDES:grubby:append:x86_64_v2 = " virtual/grubby_or_sdubby"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grubby-8.40-86.el10.alma.1.aarch64.rpm;name=aarch64_grubby;unpack=0"
SRC_URI[aarch64_grubby.sha256sum] = "1cdf50fc07272c949d990cc9104cc8ee2498d7e60f57849e8cbb939460ec819c"
RPROVIDES:grubby:append:aarch64 = " virtual/grubby_or_sdubby"

RDEPENDS:grubby = " \
 bash \
 findutils \
 grub2-tools \
 grub2-tools-minimal \
 util-linux \
 "
