# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-virt-firmware"
PV = "24.11"
PR = "2.el10_0"
PACKAGES = " \
 python3-virt-firmware \
 uki-direct \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-virt-firmware-24.11-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8a57e4c8986aef49965153af16ca3d21b96fa0a86425608497f271df696832f0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-virt-firmware-24.11-2.el10_0.noarch.rpm;name=x86_64_v2_python3-virt-firmware;unpack=0"
SRC_URI[x86_64_v2_python3-virt-firmware.sha256sum] = "f8a25777fe63d2f779fe57824dd96a296eeb1a8944eecb969978163e5bc4054c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/uki-direct-24.11-2.el10_0.noarch.rpm;name=x86_64_v2_uki-direct;unpack=0"
SRC_URI[x86_64_v2_uki-direct.sha256sum] = "24c34c3b7b6b22895c20e6dd74ba0863f09d1f7564935dd69aa9fd5678de1307"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-virt-firmware-24.11-2.el10_0.noarch.rpm;name=aarch64_python3-virt-firmware;unpack=0"
SRC_URI[aarch64_python3-virt-firmware.sha256sum] = "f8a25777fe63d2f779fe57824dd96a296eeb1a8944eecb969978163e5bc4054c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/uki-direct-24.11-2.el10_0.noarch.rpm;name=aarch64_uki-direct;unpack=0"
SRC_URI[aarch64_uki-direct.sha256sum] = "24c34c3b7b6b22895c20e6dd74ba0863f09d1f7564935dd69aa9fd5678de1307"

RDEPENDS:python3-virt-firmware = " \
 python3 \
 python3-cryptography \
 python3-pefile \
 python3-setuptools \
 "
RDEPENDS:uki-direct = " \
 bash \
 python3-virt-firmware \
 "
