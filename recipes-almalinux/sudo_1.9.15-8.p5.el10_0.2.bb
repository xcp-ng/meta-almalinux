# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sudo"
PV = "1.9.15"
PR = "8.p5.el10_0.2"
PACKAGES = " \
 sudo \
 sudo-python-plugin \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/sudo-1.9.15-8.p5.el10_0.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a43d262cd67f092f052ad8db1c77f3d2f4480cbf90e1cbeca7c823bf68a1c53f"

URI_x86_64_v2_sudo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sudo-1.9.15-8.p5.el10_0.2.x86_64_v2.rpm;name=x86_64_v2_sudo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sudo}"
SRC_URI[x86_64_v2_sudo.sha256sum] = "5485c16e3d7bf3abe1e972ae6d1586e9a94b19264e93e726b9334433fed05741"

URI_x86_64_v2_sudo-python-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sudo-python-plugin-1.9.15-8.p5.el10_0.2.x86_64_v2.rpm;name=x86_64_v2_sudo-python-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sudo-python-plugin}"
SRC_URI[x86_64_v2_sudo-python-plugin.sha256sum] = "92e5b51fb7f4ffca90b75ad4cb14271d739d78c3c6f35562188d9d1bc4af3d78"

URI_aarch64_sudo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sudo-1.9.15-8.p5.el10_0.2.aarch64.rpm;name=aarch64_sudo;unpack=0"
SRC_URI:append = " ${URI_aarch64_sudo}"
SRC_URI[aarch64_sudo.sha256sum] = "abacee43c7f4836b00aed572ab44a50b1645713455fce38bdfc66917559b41ff"

URI_aarch64_sudo-python-plugin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sudo-python-plugin-1.9.15-8.p5.el10_0.2.aarch64.rpm;name=aarch64_sudo-python-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_sudo-python-plugin}"
SRC_URI[aarch64_sudo-python-plugin.sha256sum] = "ee26881b4666e6cb02b98d1dd9ffb12f24054594186d598920d435b3bedf5140"

RDEPENDS:sudo = " \
 audit-libs \
 glibc \
 libselinux \
 openldap \
 pam \
 pam-libs \
 zlib-ng-compat \
 "
RDEPENDS:sudo-python-plugin = " \
 glibc \
 python3-libs \
 sudo \
 "
