# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-DateTime-TimeZone"
PV = "2.69"
PR = "1.el10_3"
PACKAGES = " \
 perl-DateTime-TimeZone \
 perl-DateTime-TimeZone-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-DateTime-TimeZone-2.69-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3784b87f8a187b5edac4c25c834f6971fac0b8bdf95c48477a2511c3bef19bf2"

URI_x86_64_v2_perl-DateTime-TimeZone = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DateTime-TimeZone-2.69-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-DateTime-TimeZone;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-DateTime-TimeZone}"
SRC_URI[x86_64_v2_perl-DateTime-TimeZone.sha256sum] = "f38c43388e6dfa8e9f7a408400ad3691a97bea7765d654f9400587104e1d3ff5"

URI_x86_64_v2_perl-DateTime-TimeZone-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DateTime-TimeZone-tests-2.69-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-DateTime-TimeZone-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-DateTime-TimeZone-tests}"
SRC_URI[x86_64_v2_perl-DateTime-TimeZone-tests.sha256sum] = "b999554bff6e00f26e5695370bd4d11dfb74f6d3b9529c22e877292cacecd8d1"

URI_aarch64_perl-DateTime-TimeZone = "${EPEL_MIRROR}/aarch64/Packages/p/perl-DateTime-TimeZone-2.69-1.el10_3.noarch.rpm;name=aarch64_perl-DateTime-TimeZone;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-DateTime-TimeZone}"
SRC_URI[aarch64_perl-DateTime-TimeZone.sha256sum] = "1962f3cb6f71075766b15db7e4f7c047fefe16f6f205f2507960968c55b97f09"

URI_aarch64_perl-DateTime-TimeZone-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-DateTime-TimeZone-tests-2.69-1.el10_3.noarch.rpm;name=aarch64_perl-DateTime-TimeZone-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-DateTime-TimeZone-tests}"
SRC_URI[aarch64_perl-DateTime-TimeZone-tests.sha256sum] = "4165629aeaf1fbd7c856ccc10b80fb54587edcefdacde5602363bad83dca7355"

RDEPENDS:perl-DateTime-TimeZone = " \
 perl-Class-Singleton \
 perl-DateTime \
 perl-DateTime-TimeZone \
 perl-DateTime-TimeZone-Tzfile \
 perl-File-Basename \
 perl-File-Compare \
 perl-File-Find \
 perl-Module-Runtime \
 perl-Params-ValidationCompiler \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Specio \
 perl-Try-Tiny \
 perl-constant \
 perl-libs \
 perl-namespace-autoclean \
 perl-parent \
 "
RDEPENDS:perl-DateTime-TimeZone-tests = " \
 bash \
 perl-DateTime \
 perl-DateTime-TimeZone \
 perl-ExtUtils-MakeMaker \
 perl-File-Basename \
 perl-File-Path \
 perl-File-Temp \
 perl-PathTools \
 perl-Storable \
 perl-Sys-Hostname \
 perl-Test-Fatal \
 perl-Test-Harness \
 perl-Test-Output \
 perl-Test-Requires \
 perl-Test-Simple \
 perl-Test-Taint \
 perl-Try-Tiny \
 perl-base \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-overload \
 "
