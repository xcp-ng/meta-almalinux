# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmicrohttpd"
PE = "1"
PV = "1.0.0"
PR = "3.el10"
PACKAGES = " \
 libmicrohttpd \
 libmicrohttpd-devel \
 libmicrohttpd-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libmicrohttpd-1.0.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "387a05d3e536ff29e1491944dbebd6a464793a91752676e1ef93d92a886279cf"

URI_x86_64_v2_libmicrohttpd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libmicrohttpd-1.0.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_libmicrohttpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmicrohttpd}"
SRC_URI[x86_64_v2_libmicrohttpd.sha256sum] = "5f8c198cd3cf6ee5091ebb8c00b4b9b53cd33d2cb7bb0f7ad386647ab2820b75"

URI_x86_64_v2_libmicrohttpd-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libmicrohttpd-devel-1.0.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_libmicrohttpd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmicrohttpd-devel}"
SRC_URI[x86_64_v2_libmicrohttpd-devel.sha256sum] = "0ddb26e1e6925d9f5a9b17005843abbc084ba158fdf45398f4710aaca29520a4"

URI_x86_64_v2_libmicrohttpd-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libmicrohttpd-doc-1.0.0-3.el10.noarch.rpm;name=x86_64_v2_libmicrohttpd-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmicrohttpd-doc}"
SRC_URI[x86_64_v2_libmicrohttpd-doc.sha256sum] = "330479b68078b4d7b736fef810b2f3bad905a0f1a36806cfddcdb3306b02c1dd"

URI_aarch64_libmicrohttpd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libmicrohttpd-1.0.0-3.el10.aarch64.rpm;name=aarch64_libmicrohttpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmicrohttpd}"
SRC_URI[aarch64_libmicrohttpd.sha256sum] = "c81475667f41f0fd9941638b45d7f249aeb222db5fc2ca2499c88d077eed75c3"

URI_aarch64_libmicrohttpd-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libmicrohttpd-devel-1.0.0-3.el10.aarch64.rpm;name=aarch64_libmicrohttpd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmicrohttpd-devel}"
SRC_URI[aarch64_libmicrohttpd-devel.sha256sum] = "00a9aa1a0d3e7875ccd665ed59aefb2e897e21e713177a9160306ac5613904ac"

URI_aarch64_libmicrohttpd-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libmicrohttpd-doc-1.0.0-3.el10.noarch.rpm;name=aarch64_libmicrohttpd-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmicrohttpd-doc}"
SRC_URI[aarch64_libmicrohttpd-doc.sha256sum] = "330479b68078b4d7b736fef810b2f3bad905a0f1a36806cfddcdb3306b02c1dd"

RDEPENDS:libmicrohttpd = " \
 glibc \
 gnutls \
 info \
 "
RDEPENDS:libmicrohttpd-devel = " \
 gnutls-devel \
 libmicrohttpd \
 pkgconf-pkg-config \
 "
RDEPENDS:libmicrohttpd-doc = " \
 bash \
 libmicrohttpd \
 "
