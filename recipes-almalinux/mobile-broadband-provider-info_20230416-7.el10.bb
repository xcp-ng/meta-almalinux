# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mobile-broadband-provider-info"
PV = "20230416"
PR = "7.el10"
PACKAGES = " \
 mobile-broadband-provider-info \
 mobile-broadband-provider-info-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mobile-broadband-provider-info-20230416-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a2a98c4dd1a2e9db164e251047a51d8ca9e1b20da80d36ce53e37e31a3b93f7"

URI_x86_64_v2_mobile-broadband-provider-info = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mobile-broadband-provider-info-20230416-7.el10.noarch.rpm;name=x86_64_v2_mobile-broadband-provider-info;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mobile-broadband-provider-info}"
SRC_URI[x86_64_v2_mobile-broadband-provider-info.sha256sum] = "f07386102b078bc2d46226c39664d9f8181d914e8560c8c5431c67110f2eaa53"

URI_x86_64_v2_mobile-broadband-provider-info-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mobile-broadband-provider-info-devel-20230416-7.el10.noarch.rpm;name=x86_64_v2_mobile-broadband-provider-info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mobile-broadband-provider-info-devel}"
SRC_URI[x86_64_v2_mobile-broadband-provider-info-devel.sha256sum] = "2fc1ea61b519f7ca86311d2e93c080601f42bd7ab1f6da8b1b5d4765e48862a0"

URI_aarch64_mobile-broadband-provider-info = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mobile-broadband-provider-info-20230416-7.el10.noarch.rpm;name=aarch64_mobile-broadband-provider-info;unpack=0"
SRC_URI:append = " ${URI_aarch64_mobile-broadband-provider-info}"
SRC_URI[aarch64_mobile-broadband-provider-info.sha256sum] = "f07386102b078bc2d46226c39664d9f8181d914e8560c8c5431c67110f2eaa53"

URI_aarch64_mobile-broadband-provider-info-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mobile-broadband-provider-info-devel-20230416-7.el10.noarch.rpm;name=aarch64_mobile-broadband-provider-info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mobile-broadband-provider-info-devel}"
SRC_URI[aarch64_mobile-broadband-provider-info-devel.sha256sum] = "2fc1ea61b519f7ca86311d2e93c080601f42bd7ab1f6da8b1b5d4765e48862a0"

RDEPENDS:mobile-broadband-provider-info = " \
 "
RDEPENDS:mobile-broadband-provider-info-devel = " \
 mobile-broadband-provider-info \
 pkgconf-pkg-config \
 "
