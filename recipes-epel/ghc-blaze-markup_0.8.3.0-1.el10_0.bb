# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-blaze-markup"
PV = "0.8.3.0"
PR = "1.el10_0"
PACKAGES = " \
 ghc-blaze-markup \
 ghc-blaze-markup-devel \
 ghc-blaze-markup-doc \
 ghc-blaze-markup-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-blaze-markup-0.8.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48367bda608dfab5d2fddc63a601e19290e3f89f2f9a41c3d32b6f231051ecaf"

URI_x86_64_v2_ghc-blaze-markup = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-blaze-markup-0.8.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-blaze-markup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-blaze-markup}"
SRC_URI[x86_64_v2_ghc-blaze-markup.sha256sum] = "28b3d5a6b1df81fb11cf018c642667fef8a97a25272e7fa0bf309646ce78c74f"

URI_x86_64_v2_ghc-blaze-markup-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-blaze-markup-devel-0.8.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-blaze-markup-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-blaze-markup-devel}"
SRC_URI[x86_64_v2_ghc-blaze-markup-devel.sha256sum] = "da88e14f2bb66949d5124cc2d38f081d9c537a92aa0bd77171a7dd578a97e3c7"

URI_x86_64_v2_ghc-blaze-markup-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-blaze-markup-doc-0.8.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-blaze-markup-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-blaze-markup-doc}"
SRC_URI[x86_64_v2_ghc-blaze-markup-doc.sha256sum] = "501d6060e3eeecbdaf5066a7da5ce3195e653820d38e2ccbf2078a66b1189d45"

URI_x86_64_v2_ghc-blaze-markup-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-blaze-markup-prof-0.8.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-blaze-markup-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-blaze-markup-prof}"
SRC_URI[x86_64_v2_ghc-blaze-markup-prof.sha256sum] = "4ac99b46e6443bf88d30e70790211ef6d080dee51d503eb8d4685da929b5fa09"

URI_aarch64_ghc-blaze-markup = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-blaze-markup-0.8.3.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-blaze-markup;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-blaze-markup}"
SRC_URI[aarch64_ghc-blaze-markup.sha256sum] = "b510a1da1728acd5060e3fcdcedda7b977a2078de38eb07cec0f7e078f31fe85"

URI_aarch64_ghc-blaze-markup-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-blaze-markup-devel-0.8.3.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-blaze-markup-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-blaze-markup-devel}"
SRC_URI[aarch64_ghc-blaze-markup-devel.sha256sum] = "8bd27c7b4913834b65371d87bed23fd268cfad51ae9ce29f6bfb8ce04f73dde2"

URI_aarch64_ghc-blaze-markup-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-blaze-markup-doc-0.8.3.0-1.el10_0.noarch.rpm;name=aarch64_ghc-blaze-markup-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-blaze-markup-doc}"
SRC_URI[aarch64_ghc-blaze-markup-doc.sha256sum] = "ab55e17eb02e4d3bca2cf14e3b6e7eeeef73c7fa1840d644d8bc55723283d478"

URI_aarch64_ghc-blaze-markup-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-blaze-markup-prof-0.8.3.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-blaze-markup-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-blaze-markup-prof}"
SRC_URI[aarch64_ghc-blaze-markup-prof.sha256sum] = "be891deaf769a31bfd7346c831403bee724a3ff721c025025ef2ddf5c9770b61"

RDEPENDS:ghc-blaze-markup = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-blaze-builder \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 glibc \
 gmp \
 "
RDEPENDS:ghc-blaze-markup-devel = " \
 ghc-base-devel \
 ghc-blaze-builder-devel \
 ghc-blaze-markup \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-text-devel \
 "
RDEPENDS:ghc-blaze-markup-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-blaze-markup-prof = " \
 ghc-base-prof \
 ghc-blaze-builder-prof \
 ghc-blaze-markup-devel \
 ghc-bytestring-prof \
 ghc-text-prof \
 "
