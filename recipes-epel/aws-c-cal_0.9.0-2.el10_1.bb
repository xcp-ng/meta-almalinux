# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aws-c-cal"
PV = "0.9.0"
PR = "2.el10_1"
PACKAGES = " \
 aws-c-cal \
 aws-c-cal-devel \
 aws-c-cal-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aws-c-cal-0.9.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "95d658d5251e7d27d34f661c3bf0c333f9341e038d4dff3f99c46e5e99a3c048"

URI_x86_64_v2_aws-c-cal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-cal-0.9.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-cal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-cal}"
SRC_URI[x86_64_v2_aws-c-cal.sha256sum] = "fc4c79cc9dc18b95aa93229b6a0ac2a2f3b270faa21746f4b5ed052b281a4825"

URI_x86_64_v2_aws-c-cal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-cal-devel-0.9.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-cal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-cal-devel}"
SRC_URI[x86_64_v2_aws-c-cal-devel.sha256sum] = "9b88da69e156d7faa2a41eb951a8bea9a9d2eda8c9bfef844062d2865c803ed3"

URI_x86_64_v2_aws-c-cal-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-cal-libs-0.9.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-cal-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-cal-libs}"
SRC_URI[x86_64_v2_aws-c-cal-libs.sha256sum] = "2550bb129a5b43cbaf359aff1decc1a100383711738ddc9b099041b8dce1f42c"

URI_aarch64_aws-c-cal = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-cal-0.9.0-2.el10_1.aarch64.rpm;name=aarch64_aws-c-cal;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-cal}"
SRC_URI[aarch64_aws-c-cal.sha256sum] = "41ad6a8a9718d772c51da1893f21e5195f9fbc9608658c4d792fee690e2c4a97"

URI_aarch64_aws-c-cal-devel = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-cal-devel-0.9.0-2.el10_1.aarch64.rpm;name=aarch64_aws-c-cal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-cal-devel}"
SRC_URI[aarch64_aws-c-cal-devel.sha256sum] = "213531268afba4d275fa5800cc2356dbbbb2fcfaad43b83b4ee7d59fd9ac0c20"

URI_aarch64_aws-c-cal-libs = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-cal-libs-0.9.0-2.el10_1.aarch64.rpm;name=aarch64_aws-c-cal-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-cal-libs}"
SRC_URI[aarch64_aws-c-cal-libs.sha256sum] = "2d30f821858c76fca35163c775c63caa4d103662ed1fa372712715089ffbf51c"

RDEPENDS:aws-c-cal = " \
 "
RDEPENDS:aws-c-cal-devel = " \
 aws-c-cal-libs \
 aws-c-common-devel \
 cmake-filesystem \
 openssl-devel \
 "
RDEPENDS:aws-c-cal-libs = " \
 aws-c-cal \
 aws-c-common-libs \
 glibc \
 openssl-libs \
 "
