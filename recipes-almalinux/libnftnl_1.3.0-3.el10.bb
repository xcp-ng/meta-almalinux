# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libnftnl"
PV = "1.3.0"
PR = "3.el10"
PACKAGES = " \
 libnftnl \
 libnftnl-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libnftnl-1.3.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85434d8723419f272d8bdb24bd17fd67b62f0799a0948953b7e655f5e99809f3"

URI_x86_64_v2_libnftnl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libnftnl-1.3.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_libnftnl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnftnl}"
SRC_URI[x86_64_v2_libnftnl.sha256sum] = "6f68509db3328ff7b02c8b7d6fb5790d01e0e74eb4a0918c2161f08b9d6d6302"

URI_x86_64_v2_libnftnl-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libnftnl-devel-1.3.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_libnftnl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnftnl-devel}"
SRC_URI[x86_64_v2_libnftnl-devel.sha256sum] = "8cc57e5de7aabedab8fc36866024623a38c22f5dfd63920c5c52db5ce7f41867"

URI_aarch64_libnftnl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libnftnl-1.3.0-3.el10.aarch64.rpm;name=aarch64_libnftnl;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnftnl}"
SRC_URI[aarch64_libnftnl.sha256sum] = "d4e14fdf5776599fdf4d1bb0487b73bc718db736e8e13cced090cce97ed88329"

URI_aarch64_libnftnl-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libnftnl-devel-1.3.0-3.el10.aarch64.rpm;name=aarch64_libnftnl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnftnl-devel}"
SRC_URI[aarch64_libnftnl-devel.sha256sum] = "300b8683d02aa84deb24d5ca6395aaacb901b3c629ff225d6b07d1f62ebb4875"

RDEPENDS:libnftnl = " \
 glibc \
 libmnl \
 "
RDEPENDS:libnftnl-devel = " \
 libmnl-devel \
 libnftnl \
 pkgconf-pkg-config \
 "
