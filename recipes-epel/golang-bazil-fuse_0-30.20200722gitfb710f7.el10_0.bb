# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-bazil-fuse"
PV = "0"
PR = "30.20200722gitfb710f7.el10_0"
PACKAGES = " \
 golang-bazil-fuse-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-bazil-fuse-0-30.20200722gitfb710f7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "058ad83de808369ad279bbc73f7a572fb03747c23a0b2e29ac64398c3481e594"

URI_aarch64_golang-bazil-fuse-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-bazil-fuse-devel-0-30.20200722gitfb710f7.el10_0.noarch.rpm;name=aarch64_golang-bazil-fuse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-bazil-fuse-devel}"
SRC_URI[aarch64_golang-bazil-fuse-devel.sha256sum] = "92fe4c4df130d388ff9ff64a83ad700e29595c93d20be28b92e05aabb153fc26"

RDEPENDS:golang-bazil-fuse-devel = " \
 go-filesystem \
 golang-github-tv42-httpunix-devel \
 golang-x-sys-devel \
 "
