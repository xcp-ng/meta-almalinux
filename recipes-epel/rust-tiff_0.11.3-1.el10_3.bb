# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tiff"
PV = "0.11.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-tiff+default-devel \
 rust-tiff+deflate-devel \
 rust-tiff+fax-devel \
 rust-tiff+jpeg-devel \
 rust-tiff+lzw-devel \
 rust-tiff+webp-devel \
 rust-tiff+zstd-devel \
 rust-tiff-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tiff-0.11.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cadc59c1e30ff09518a293507a3a1770cb4244922820724579562d7606732b4b"

URI_x86_64_v2_rust-tiff+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiff+default-devel-0.11.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiff+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiff+default-devel}"
SRC_URI[x86_64_v2_rust-tiff+default-devel.sha256sum] = "60d6b69051575e4c82348a5167461095f98e9300f48c02079790047bff7ea1d9"

URI_x86_64_v2_rust-tiff+deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiff+deflate-devel-0.11.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiff+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiff+deflate-devel}"
SRC_URI[x86_64_v2_rust-tiff+deflate-devel.sha256sum] = "1cf9d6d0dfb56fe875a3bbdca39aa3addb44512da36a81464c6197308aaa4b9e"

URI_x86_64_v2_rust-tiff+fax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiff+fax-devel-0.11.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiff+fax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiff+fax-devel}"
SRC_URI[x86_64_v2_rust-tiff+fax-devel.sha256sum] = "fe114408dbfde5414cb3abde985a27de9ebfcf586563d4983a0fb95da1c93566"

URI_x86_64_v2_rust-tiff+jpeg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiff+jpeg-devel-0.11.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiff+jpeg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiff+jpeg-devel}"
SRC_URI[x86_64_v2_rust-tiff+jpeg-devel.sha256sum] = "952d6df82e6664d9b117c0126d7adb1d78c27a933910939a83b8bccde2e9a109"

URI_x86_64_v2_rust-tiff+lzw-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiff+lzw-devel-0.11.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiff+lzw-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiff+lzw-devel}"
SRC_URI[x86_64_v2_rust-tiff+lzw-devel.sha256sum] = "599484479ea5fbce7dca5d9b69187caec9cb24249105bc368679e9823a06b978"

URI_x86_64_v2_rust-tiff+webp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiff+webp-devel-0.11.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiff+webp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiff+webp-devel}"
SRC_URI[x86_64_v2_rust-tiff+webp-devel.sha256sum] = "14fdf16b653e88cf0f3dfc59aaf6380e660ee9288e9bd7d37fc5126510ef8a92"

URI_x86_64_v2_rust-tiff+zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiff+zstd-devel-0.11.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiff+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiff+zstd-devel}"
SRC_URI[x86_64_v2_rust-tiff+zstd-devel.sha256sum] = "5fc36880bf705dffbe45916e647225a21a8729d59ab5f73e9f2534485577c3a8"

URI_x86_64_v2_rust-tiff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiff-devel-0.11.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiff-devel}"
SRC_URI[x86_64_v2_rust-tiff-devel.sha256sum] = "d0764364e7eb7701691a38ebe27845ea00cd334d47f8abf996cdc429d21d0bcf"

URI_aarch64_rust-tiff+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiff+default-devel-0.11.3-1.el10_3.noarch.rpm;name=aarch64_rust-tiff+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiff+default-devel}"
SRC_URI[aarch64_rust-tiff+default-devel.sha256sum] = "98432d57b462a4111789a7037cba3b9f9fb8d8156219cb5880979b6c3e32a880"

URI_aarch64_rust-tiff+deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiff+deflate-devel-0.11.3-1.el10_3.noarch.rpm;name=aarch64_rust-tiff+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiff+deflate-devel}"
SRC_URI[aarch64_rust-tiff+deflate-devel.sha256sum] = "1f9a6cb8632ca439d28976738917372ed691fbb06814801d23cf17a95fd60929"

URI_aarch64_rust-tiff+fax-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiff+fax-devel-0.11.3-1.el10_3.noarch.rpm;name=aarch64_rust-tiff+fax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiff+fax-devel}"
SRC_URI[aarch64_rust-tiff+fax-devel.sha256sum] = "1871b13e4bb5ae340b0ef15bdabda407f5a574ffeaad18f1039125e47f2680e6"

URI_aarch64_rust-tiff+jpeg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiff+jpeg-devel-0.11.3-1.el10_3.noarch.rpm;name=aarch64_rust-tiff+jpeg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiff+jpeg-devel}"
SRC_URI[aarch64_rust-tiff+jpeg-devel.sha256sum] = "664f4125e45e3b1e90c2f68b02a5922e849fd3bead8383db12037a51b6aaeecf"

URI_aarch64_rust-tiff+lzw-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiff+lzw-devel-0.11.3-1.el10_3.noarch.rpm;name=aarch64_rust-tiff+lzw-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiff+lzw-devel}"
SRC_URI[aarch64_rust-tiff+lzw-devel.sha256sum] = "af7f90a364a60f0c48a4e9a4b5caf01af07bdbd413cce13f8a4f6c2734da4fda"

URI_aarch64_rust-tiff+webp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiff+webp-devel-0.11.3-1.el10_3.noarch.rpm;name=aarch64_rust-tiff+webp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiff+webp-devel}"
SRC_URI[aarch64_rust-tiff+webp-devel.sha256sum] = "1a4fe6329d44564b2fe4ebd361851511e13842ee01765eef88d7d2072c287382"

URI_aarch64_rust-tiff+zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiff+zstd-devel-0.11.3-1.el10_3.noarch.rpm;name=aarch64_rust-tiff+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiff+zstd-devel}"
SRC_URI[aarch64_rust-tiff+zstd-devel.sha256sum] = "9a0fb269564b1ca3c346dac3efecbac93291d13dbfb07ab48f9e493c713fc55b"

URI_aarch64_rust-tiff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiff-devel-0.11.3-1.el10_3.noarch.rpm;name=aarch64_rust-tiff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiff-devel}"
SRC_URI[aarch64_rust-tiff-devel.sha256sum] = "6d4d253d98e6261faba2b61d588e2fb72014491cca68d5f89a786638aedfa620"

RDEPENDS:rust-tiff+default-devel = " \
 cargo \
 rust-tiff+deflate-devel \
 rust-tiff+fax-devel \
 rust-tiff+jpeg-devel \
 rust-tiff+lzw-devel \
 rust-tiff-devel \
 "
RDEPENDS:rust-tiff+deflate-devel = " \
 cargo \
 rust-flate2+default-devel \
 rust-tiff-devel \
 "
RDEPENDS:rust-tiff+fax-devel = " \
 cargo \
 rust-fax+default-devel \
 rust-tiff-devel \
 "
RDEPENDS:rust-tiff+jpeg-devel = " \
 cargo \
 rust-tiff-devel \
 rust-zune-jpeg+default-devel \
 "
RDEPENDS:rust-tiff+lzw-devel = " \
 cargo \
 rust-tiff-devel \
 rust-weezl+default-devel \
 "
RDEPENDS:rust-tiff+webp-devel = " \
 cargo \
 rust-image-webp+default-devel \
 rust-tiff-devel \
 "
RDEPENDS:rust-tiff+zstd-devel = " \
 cargo \
 rust-tiff-devel \
 rust-zstd+default-devel \
 "
RDEPENDS:rust-tiff-devel = " \
 cargo \
 rust \
 rust-half+default-devel \
 rust-quick-error+default-devel \
 "
