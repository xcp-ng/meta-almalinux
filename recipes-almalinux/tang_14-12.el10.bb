# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tang"
PV = "14"
PR = "12.el10"
PACKAGES = " \
 tang \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tang-14-12.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "39c9dc3005b3a5731cdb3a8ceed0cb6b2aaaa6b0fbc354c1f82ac4ec5d8d3772"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tang-14-12.el10.x86_64_v2.rpm;name=x86_64_v2_tang;unpack=0"
SRC_URI[x86_64_v2_tang.sha256sum] = "a23067dff641c8b645a07a3bdb6dd0d748a357c1c25bfd28090e91eb823d7b3e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tang-14-12.el10.aarch64.rpm;name=aarch64_tang;unpack=0"
SRC_URI[aarch64_tang.sha256sum] = "ebb3386b849c86bdc7266c385cef3222a814f78d8c9b1a1915825b908852824f"

RDEPENDS:tang = " \
 bash \
 glibc \
 grep \
 jansson \
 jose \
 libgcc \
 libjose \
 llhttp \
 sed \
 shadow-utils \
 virtual/coreutils \
 "
