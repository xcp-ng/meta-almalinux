# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nx-libs"
PV = "3.5.99.27"
PR = "6.el10_1"
PACKAGES = " \
 libNX_X11 \
 libNX_X11-devel \
 libXcomp \
 libXcomp-devel \
 libXcompshad \
 libXcompshad-devel \
 nx-libs \
 nx-libs-devel \
 nx-proto-devel \
 nxagent \
 nxdialog \
 nxproxy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nx-libs-3.5.99.27-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b0c51e2f120c77daad4e9b8cdfa0c01f6864f8a59afe3ed082302d4ed73d8d65"

URI_x86_64_v2_libNX_X11 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libNX_X11-3.5.99.27-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libNX_X11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libNX_X11}"
SRC_URI[x86_64_v2_libNX_X11.sha256sum] = "9ad5f0b9fa7b6ee4579c37291b9eec051f5fc213e9bedc869e3983928d8bf146"

URI_x86_64_v2_libNX_X11-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libNX_X11-devel-3.5.99.27-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libNX_X11-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libNX_X11-devel}"
SRC_URI[x86_64_v2_libNX_X11-devel.sha256sum] = "237cdfd85021e137a170027d6a08eac686c42e3dcadd00f47b081fd20c39e451"

URI_x86_64_v2_libXcomp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libXcomp-3.5.99.27-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libXcomp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXcomp}"
SRC_URI[x86_64_v2_libXcomp.sha256sum] = "ecb3fbe8519283322f5faf28cdc85784b241995cc581ce81e5d1dba243314c14"

URI_x86_64_v2_libXcomp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libXcomp-devel-3.5.99.27-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libXcomp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXcomp-devel}"
SRC_URI[x86_64_v2_libXcomp-devel.sha256sum] = "30f823547912aa69e99fcdee85fe13e839f7df183fd30ecaefb1775629c4be1c"

URI_x86_64_v2_libXcompshad = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libXcompshad-3.5.99.27-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libXcompshad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXcompshad}"
SRC_URI[x86_64_v2_libXcompshad.sha256sum] = "1ba2a725f856e89fb95a2173152c2fdc07984050b7bbfba64c049523dface553"

URI_x86_64_v2_libXcompshad-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libXcompshad-devel-3.5.99.27-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libXcompshad-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXcompshad-devel}"
SRC_URI[x86_64_v2_libXcompshad-devel.sha256sum] = "ce14dd9f504133bffd7578fd628ef8cadf8f504264065dfff7945ef3fff5bb2f"

URI_x86_64_v2_nx-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nx-libs-3.5.99.27-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nx-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nx-libs}"
SRC_URI[x86_64_v2_nx-libs.sha256sum] = "2f7f213c9d14b48c553f2e161356537fee42284e999ad6ba3b856e9ea28c08fc"

URI_x86_64_v2_nx-libs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nx-libs-devel-3.5.99.27-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nx-libs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nx-libs-devel}"
SRC_URI[x86_64_v2_nx-libs-devel.sha256sum] = "a0cfabd55232ba6adbe0561500ce76a74694d6efb91e10d6c32439af8e3c8c9f"

URI_x86_64_v2_nx-proto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nx-proto-devel-3.5.99.27-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nx-proto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nx-proto-devel}"
SRC_URI[x86_64_v2_nx-proto-devel.sha256sum] = "1a91f7c9020627747a5ceec5378451d665f09e64f57b418ea51c1ee6aaeda0ca"

URI_x86_64_v2_nxagent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nxagent-3.5.99.27-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nxagent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nxagent}"
SRC_URI[x86_64_v2_nxagent.sha256sum] = "42340c63898fd219310edc7011e24f3f2fda807ad69c6f3bcc6e721ffb017444"

URI_x86_64_v2_nxdialog = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nxdialog-3.5.99.27-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nxdialog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nxdialog}"
SRC_URI[x86_64_v2_nxdialog.sha256sum] = "732605e9fb28d7576df05daac63a1da4ae05478812e53ca605eef4feca866606"

URI_x86_64_v2_nxproxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nxproxy-3.5.99.27-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nxproxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nxproxy}"
SRC_URI[x86_64_v2_nxproxy.sha256sum] = "7b37f91bc1b0443c2d4f09d3ed38c793e87bb746f5d77359e69a00f7ead53f1f"

URI_aarch64_libNX_X11 = "${EPEL_MIRROR}/aarch64/Packages/l/libNX_X11-3.5.99.27-6.el10_1.aarch64.rpm;name=aarch64_libNX_X11;unpack=0"
SRC_URI:append = " ${URI_aarch64_libNX_X11}"
SRC_URI[aarch64_libNX_X11.sha256sum] = "46e57251fa9b27e2887bb7309d7af5fdd5df9c6f9a11e668ed886fbfa6c17f02"

URI_aarch64_libNX_X11-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libNX_X11-devel-3.5.99.27-6.el10_1.aarch64.rpm;name=aarch64_libNX_X11-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libNX_X11-devel}"
SRC_URI[aarch64_libNX_X11-devel.sha256sum] = "80c98eaea52e784d07b2ca45ed53d2761152d5124da9c42af0ebf9bc52699409"

URI_aarch64_libXcomp = "${EPEL_MIRROR}/aarch64/Packages/l/libXcomp-3.5.99.27-6.el10_1.aarch64.rpm;name=aarch64_libXcomp;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXcomp}"
SRC_URI[aarch64_libXcomp.sha256sum] = "ccadcc434e970971c0a6239e380d7433ba61430f7eaa265806a97e6fd8dcc9ec"

URI_aarch64_libXcomp-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libXcomp-devel-3.5.99.27-6.el10_1.aarch64.rpm;name=aarch64_libXcomp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXcomp-devel}"
SRC_URI[aarch64_libXcomp-devel.sha256sum] = "44ed6b9cf4c0efcf4d0ad624d0444b3a74fe55f6c96dbf9d5802edc4c5986c9e"

URI_aarch64_libXcompshad = "${EPEL_MIRROR}/aarch64/Packages/l/libXcompshad-3.5.99.27-6.el10_1.aarch64.rpm;name=aarch64_libXcompshad;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXcompshad}"
SRC_URI[aarch64_libXcompshad.sha256sum] = "f24531f5526cdee58056e65db1cac9fff5597d8534e819a1eca4b333751c8f0e"

URI_aarch64_libXcompshad-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libXcompshad-devel-3.5.99.27-6.el10_1.aarch64.rpm;name=aarch64_libXcompshad-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXcompshad-devel}"
SRC_URI[aarch64_libXcompshad-devel.sha256sum] = "d88cccd654fdd42ee5e80ba98ab4432cabf04e78d15548c28a7e88bd0915dea6"

URI_aarch64_nx-libs = "${EPEL_MIRROR}/aarch64/Packages/n/nx-libs-3.5.99.27-6.el10_1.aarch64.rpm;name=aarch64_nx-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nx-libs}"
SRC_URI[aarch64_nx-libs.sha256sum] = "fe9c0d2bc724f12d3691e14afbcf900ab55a1b18e684bfeae0400473205536bc"

URI_aarch64_nx-libs-devel = "${EPEL_MIRROR}/aarch64/Packages/n/nx-libs-devel-3.5.99.27-6.el10_1.aarch64.rpm;name=aarch64_nx-libs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nx-libs-devel}"
SRC_URI[aarch64_nx-libs-devel.sha256sum] = "03d517e8f1f2d00e0abfadcfcf19e9d3077a1789008e439f823a8f96e4f5f83d"

URI_aarch64_nx-proto-devel = "${EPEL_MIRROR}/aarch64/Packages/n/nx-proto-devel-3.5.99.27-6.el10_1.aarch64.rpm;name=aarch64_nx-proto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nx-proto-devel}"
SRC_URI[aarch64_nx-proto-devel.sha256sum] = "323f0e820bd4f1fb89b87163048f9c86e546dc1a242ccc21234b9d48bdc5aa01"

URI_aarch64_nxagent = "${EPEL_MIRROR}/aarch64/Packages/n/nxagent-3.5.99.27-6.el10_1.aarch64.rpm;name=aarch64_nxagent;unpack=0"
SRC_URI:append = " ${URI_aarch64_nxagent}"
SRC_URI[aarch64_nxagent.sha256sum] = "3f7835c57ed7a7f48751cf68efdf0e4f95880b2f36bb4ecbecccaee5fad3f6aa"

URI_aarch64_nxdialog = "${EPEL_MIRROR}/aarch64/Packages/n/nxdialog-3.5.99.27-6.el10_1.aarch64.rpm;name=aarch64_nxdialog;unpack=0"
SRC_URI:append = " ${URI_aarch64_nxdialog}"
SRC_URI[aarch64_nxdialog.sha256sum] = "a045380475dd28a7b911c8a019eaf06a9cb1533239150ab92bde957dfccc3b42"

URI_aarch64_nxproxy = "${EPEL_MIRROR}/aarch64/Packages/n/nxproxy-3.5.99.27-6.el10_1.aarch64.rpm;name=aarch64_nxproxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_nxproxy}"
SRC_URI[aarch64_nxproxy.sha256sum] = "4dbbeb19ba49ce2e9be2f6da740870517b1b34eb541bcc0c240631ffda64b5ca"

RDEPENDS:libNX_X11 = " \
 glibc \
 libXcomp \
 libXdmcp \
 libjpeg-turbo \
 libpng \
 nx-libs \
 zlib-ng-compat \
 "
RDEPENDS:libNX_X11-devel = " \
 libNX_X11 \
 nx-proto-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libXcomp = " \
 glibc \
 libgcc \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 nx-libs \
 zlib-ng-compat \
 "
RDEPENDS:libXcomp-devel = " \
 libX11-devel \
 libXcomp \
 libpng-devel \
 nx-proto-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libXcompshad = " \
 glibc \
 libNX_X11 \
 libX11 \
 libXcomp \
 libXdamage \
 libXdmcp \
 libXext \
 libXfixes \
 libXrandr \
 libXtst \
 libgcc \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 nx-libs \
 zlib-ng-compat \
 "
RDEPENDS:libXcompshad-devel = " \
 libNX_X11-devel \
 libX11-devel \
 libXcomp-devel \
 libXcompshad \
 nx-libs-devel \
 nx-proto-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:nx-libs = " \
 "
RDEPENDS:nx-libs-devel = " \
 libNX_X11-devel \
 nx-libs \
 nx-proto-devel \
 "
RDEPENDS:nx-proto-devel = " \
 "
RDEPENDS:nxagent = " \
 glibc \
 libNX_X11 \
 libX11 \
 libXcomp \
 libXcomposite \
 libXcompshad \
 libXdmcp \
 libXext \
 libXfixes \
 libXfont2 \
 libXinerama \
 libXpm \
 libXrender \
 libgcc \
 libjpeg-turbo \
 libpng \
 libtirpc \
 libxml2 \
 pixman \
 zlib-ng-compat \
 "
RDEPENDS:nxdialog = " \
 python3 \
 "
RDEPENDS:nxproxy = " \
 glibc \
 libXcomp \
 "
