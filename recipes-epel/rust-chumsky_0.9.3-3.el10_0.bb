# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-chumsky"
PV = "0.9.3"
PR = "3.el10_0"
PACKAGES = " \
 rust-chumsky+ahash-devel \
 rust-chumsky+default-devel \
 rust-chumsky+nightly-devel \
 rust-chumsky+spill-stack-devel \
 rust-chumsky+stacker-devel \
 rust-chumsky+std-devel \
 rust-chumsky-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-chumsky-0.9.3-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b7d65d5e572074dce0946e849506c1c56518484de873fdb7882dcc5078eff613"

URI_x86_64_v2_rust-chumsky+ahash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chumsky+ahash-devel-0.9.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chumsky+ahash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chumsky+ahash-devel}"
SRC_URI[x86_64_v2_rust-chumsky+ahash-devel.sha256sum] = "3916952fab763fa35b1f4d4dbfe21ff11be57362701e48ce99e9dd804050b7dc"

URI_x86_64_v2_rust-chumsky+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chumsky+default-devel-0.9.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chumsky+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chumsky+default-devel}"
SRC_URI[x86_64_v2_rust-chumsky+default-devel.sha256sum] = "83406dcaa87adcf51ec59032bf486cf6391ed16e6125b5d98b2e956dcd1618e3"

URI_x86_64_v2_rust-chumsky+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chumsky+nightly-devel-0.9.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chumsky+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chumsky+nightly-devel}"
SRC_URI[x86_64_v2_rust-chumsky+nightly-devel.sha256sum] = "8372b507ae7c65dfd7b61a46b6da46aed23ab87d4f5d1103f95052d105aa2440"

URI_x86_64_v2_rust-chumsky+spill-stack-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chumsky+spill-stack-devel-0.9.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chumsky+spill-stack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chumsky+spill-stack-devel}"
SRC_URI[x86_64_v2_rust-chumsky+spill-stack-devel.sha256sum] = "1dc68c375f3fff1892344cb35e87c07ae3d11c673e3ca3b722d9ffef316e31d0"

URI_x86_64_v2_rust-chumsky+stacker-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chumsky+stacker-devel-0.9.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chumsky+stacker-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chumsky+stacker-devel}"
SRC_URI[x86_64_v2_rust-chumsky+stacker-devel.sha256sum] = "4238adfd9e48d47a9cc7c7a8be23cb9bd1a3817bcd43f993f3f27d619d8d0dc5"

URI_x86_64_v2_rust-chumsky+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chumsky+std-devel-0.9.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chumsky+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chumsky+std-devel}"
SRC_URI[x86_64_v2_rust-chumsky+std-devel.sha256sum] = "68fc39f0e37f4fc67fdac0380a1cb167f95c0a5ec48392f9a6f49b326012ddee"

URI_x86_64_v2_rust-chumsky-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chumsky-devel-0.9.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chumsky-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chumsky-devel}"
SRC_URI[x86_64_v2_rust-chumsky-devel.sha256sum] = "8ce623b36bc6c441f62735f354ba6a47a7e1b2638cfc7a88cfdf64dae386c1a3"

URI_aarch64_rust-chumsky+ahash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chumsky+ahash-devel-0.9.3-3.el10_0.noarch.rpm;name=aarch64_rust-chumsky+ahash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chumsky+ahash-devel}"
SRC_URI[aarch64_rust-chumsky+ahash-devel.sha256sum] = "5ad97cacbe5fcf3336a4a44f07a60664945dc112e2134fa50484eb8589845073"

URI_aarch64_rust-chumsky+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chumsky+default-devel-0.9.3-3.el10_0.noarch.rpm;name=aarch64_rust-chumsky+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chumsky+default-devel}"
SRC_URI[aarch64_rust-chumsky+default-devel.sha256sum] = "815b91cdcd5f76991e2f1f11ae23c71fbd192cc0b0a35b6c4dc9c2a77ac7fc93"

URI_aarch64_rust-chumsky+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chumsky+nightly-devel-0.9.3-3.el10_0.noarch.rpm;name=aarch64_rust-chumsky+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chumsky+nightly-devel}"
SRC_URI[aarch64_rust-chumsky+nightly-devel.sha256sum] = "5535af3f0fe07242990ec3861db040edd4b1d536f544b0fc21a94a3912ce440c"

URI_aarch64_rust-chumsky+spill-stack-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chumsky+spill-stack-devel-0.9.3-3.el10_0.noarch.rpm;name=aarch64_rust-chumsky+spill-stack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chumsky+spill-stack-devel}"
SRC_URI[aarch64_rust-chumsky+spill-stack-devel.sha256sum] = "9afe125b7244486f2e1ff43cc17f2ad4137d23a583f402be82cb4e054bf4661a"

URI_aarch64_rust-chumsky+stacker-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chumsky+stacker-devel-0.9.3-3.el10_0.noarch.rpm;name=aarch64_rust-chumsky+stacker-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chumsky+stacker-devel}"
SRC_URI[aarch64_rust-chumsky+stacker-devel.sha256sum] = "94f04ec62b6a28f28bb47fd551c6f81bd902a6fc14e4536f7b3b6367897266f5"

URI_aarch64_rust-chumsky+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chumsky+std-devel-0.9.3-3.el10_0.noarch.rpm;name=aarch64_rust-chumsky+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chumsky+std-devel}"
SRC_URI[aarch64_rust-chumsky+std-devel.sha256sum] = "5edd01e3b4f3354864a04f17917975305769e309392dda0929d32f8268c83095"

URI_aarch64_rust-chumsky-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chumsky-devel-0.9.3-3.el10_0.noarch.rpm;name=aarch64_rust-chumsky-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chumsky-devel}"
SRC_URI[aarch64_rust-chumsky-devel.sha256sum] = "f5aa7254b759d084407dcdbe2d8e57e00edcef4dc47c0a3b610f5b5137dd2952"

RDEPENDS:rust-chumsky+ahash-devel = " \
 cargo \
 rust-chumsky-devel \
 "
RDEPENDS:rust-chumsky+default-devel = " \
 cargo \
 rust-chumsky+ahash-devel \
 rust-chumsky+spill-stack-devel \
 rust-chumsky+std-devel \
 rust-chumsky-devel \
 "
RDEPENDS:rust-chumsky+nightly-devel = " \
 cargo \
 rust-chumsky-devel \
 "
RDEPENDS:rust-chumsky+spill-stack-devel = " \
 cargo \
 rust-chumsky+stacker-devel \
 rust-chumsky+std-devel \
 rust-chumsky-devel \
 "
RDEPENDS:rust-chumsky+stacker-devel = " \
 cargo \
 rust-chumsky-devel \
 rust-stacker+default-devel \
 "
RDEPENDS:rust-chumsky+std-devel = " \
 cargo \
 rust-chumsky-devel \
 "
RDEPENDS:rust-chumsky-devel = " \
 cargo \
 rust-hashbrown0.14+default-devel \
 "
