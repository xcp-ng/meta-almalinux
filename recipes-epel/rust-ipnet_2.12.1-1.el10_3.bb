# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ipnet"
PV = "2.12.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-ipnet+default-devel \
 rust-ipnet+heapless-devel \
 rust-ipnet+schemars08-devel \
 rust-ipnet+schemars1-devel \
 rust-ipnet+ser_as_str-devel \
 rust-ipnet+serde-devel \
 rust-ipnet+std-devel \
 rust-ipnet-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ipnet-2.12.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8da03588da69fe66400e1169b4bcf69509f0bca993f739b81bd3fc57c7f2d47c"

URI_x86_64_v2_rust-ipnet+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+default-devel-2.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ipnet+default-devel}"
SRC_URI[x86_64_v2_rust-ipnet+default-devel.sha256sum] = "fbc38ebfb21dcebfbc8aaffc20bb47a04e9148678fd37c7d220c3b4cf9515922"

URI_x86_64_v2_rust-ipnet+heapless-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+heapless-devel-2.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ipnet+heapless-devel}"
SRC_URI[x86_64_v2_rust-ipnet+heapless-devel.sha256sum] = "cf8c4416b01cb9e9a84057072c00f0ca3d457e73ca81e87f04531688163bbea0"

URI_x86_64_v2_rust-ipnet+schemars08-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+schemars08-devel-2.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+schemars08-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ipnet+schemars08-devel}"
SRC_URI[x86_64_v2_rust-ipnet+schemars08-devel.sha256sum] = "1de12099ca612ad1fa22d91505e7ab521be59fe1fd1b8d9ae2ff05339636388a"

URI_x86_64_v2_rust-ipnet+schemars1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+schemars1-devel-2.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+schemars1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ipnet+schemars1-devel}"
SRC_URI[x86_64_v2_rust-ipnet+schemars1-devel.sha256sum] = "961d037df0166d0e6ce4f8d3be30c7bd53f8bd97775f74d33d1c580f1e3ced42"

URI_x86_64_v2_rust-ipnet+ser_as_str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+ser_as_str-devel-2.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+ser_as_str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ipnet+ser_as_str-devel}"
SRC_URI[x86_64_v2_rust-ipnet+ser_as_str-devel.sha256sum] = "09109481ae75ed47f46f1b8fe64e4baf74eb2345ae79648f9ff4ea21a5feb166"

URI_x86_64_v2_rust-ipnet+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+serde-devel-2.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ipnet+serde-devel}"
SRC_URI[x86_64_v2_rust-ipnet+serde-devel.sha256sum] = "f7b0c99b3a8102e8cd1964b08208261137550dbd89f41c2be2f886c28a2e1f0e"

URI_x86_64_v2_rust-ipnet+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+std-devel-2.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ipnet+std-devel}"
SRC_URI[x86_64_v2_rust-ipnet+std-devel.sha256sum] = "35e5c16bcb7636a02569a2518f2950d0cc3ab67338e19a4aabea9a1bb51260c0"

URI_x86_64_v2_rust-ipnet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet-devel-2.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ipnet-devel}"
SRC_URI[x86_64_v2_rust-ipnet-devel.sha256sum] = "b2e701e152340bbebb2a40fdc194964eb2f0cff2bb77b05899a1cf2cbe4e22d8"

URI_aarch64_rust-ipnet+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+default-devel-2.12.1-1.el10_3.noarch.rpm;name=aarch64_rust-ipnet+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ipnet+default-devel}"
SRC_URI[aarch64_rust-ipnet+default-devel.sha256sum] = "407bbc4e5ea62fbd5dc35893d37f03cc63f904af73cad4329c7ea0ae1220c07a"

URI_aarch64_rust-ipnet+heapless-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+heapless-devel-2.12.1-1.el10_3.noarch.rpm;name=aarch64_rust-ipnet+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ipnet+heapless-devel}"
SRC_URI[aarch64_rust-ipnet+heapless-devel.sha256sum] = "35872a2b24e67e9199025debaa91c8fbb93798ded4926ef159f91429affccfc0"

URI_aarch64_rust-ipnet+schemars08-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+schemars08-devel-2.12.1-1.el10_3.noarch.rpm;name=aarch64_rust-ipnet+schemars08-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ipnet+schemars08-devel}"
SRC_URI[aarch64_rust-ipnet+schemars08-devel.sha256sum] = "2f882b74087c638d068873cc818776c6724bbeb5d60fde62c023d771425e6b6e"

URI_aarch64_rust-ipnet+schemars1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+schemars1-devel-2.12.1-1.el10_3.noarch.rpm;name=aarch64_rust-ipnet+schemars1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ipnet+schemars1-devel}"
SRC_URI[aarch64_rust-ipnet+schemars1-devel.sha256sum] = "1ea10b072f262ec24424a2a84bc792cffd2a8892af3b4597c2db5338d82ebfb5"

URI_aarch64_rust-ipnet+ser_as_str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+ser_as_str-devel-2.12.1-1.el10_3.noarch.rpm;name=aarch64_rust-ipnet+ser_as_str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ipnet+ser_as_str-devel}"
SRC_URI[aarch64_rust-ipnet+ser_as_str-devel.sha256sum] = "cf9fd297a8ffa52cde5eff10cd10a80c69c6071052a03a1e04979913b2c3bdb1"

URI_aarch64_rust-ipnet+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+serde-devel-2.12.1-1.el10_3.noarch.rpm;name=aarch64_rust-ipnet+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ipnet+serde-devel}"
SRC_URI[aarch64_rust-ipnet+serde-devel.sha256sum] = "0f4753b154ab5431272406a55352252e62c8acc30110cb09a82598691c53bf96"

URI_aarch64_rust-ipnet+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+std-devel-2.12.1-1.el10_3.noarch.rpm;name=aarch64_rust-ipnet+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ipnet+std-devel}"
SRC_URI[aarch64_rust-ipnet+std-devel.sha256sum] = "321387c7d1dc4e609c68871363308a43215ca53ba84f5c1a435e44925f4fc251"

URI_aarch64_rust-ipnet-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet-devel-2.12.1-1.el10_3.noarch.rpm;name=aarch64_rust-ipnet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ipnet-devel}"
SRC_URI[aarch64_rust-ipnet-devel.sha256sum] = "51439594e85ddd831af19b1e87025d32b69b0577425c3773c49fe7b4747cd431"

RDEPENDS:rust-ipnet+default-devel = " \
 cargo \
 rust-ipnet+std-devel \
 rust-ipnet-devel \
 "
RDEPENDS:rust-ipnet+heapless-devel = " \
 cargo \
 rust-ipnet+serde-devel \
 rust-ipnet-devel \
 virtual/crate_heapless/default__ge_0.0.0_with_crate_heapless/default__lt_1.0.0~ \
 "
RDEPENDS:rust-ipnet+schemars08-devel = " \
 cargo \
 rust-ipnet-devel \
 rust-schemars0.8-devel \
 "
RDEPENDS:rust-ipnet+schemars1-devel = " \
 cargo \
 rust-ipnet-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-ipnet+ser_as_str-devel = " \
 cargo \
 rust-ipnet-devel \
 virtual/crate_heapless/default__ge_0.0.0_with_crate_heapless/default__lt_1.0.0~ \
 "
RDEPENDS:rust-ipnet+serde-devel = " \
 cargo \
 rust-ipnet-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-ipnet+std-devel = " \
 cargo \
 rust-ipnet-devel \
 "
RDEPENDS:rust-ipnet-devel = " \
 cargo \
 "
