# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-rpm-nvr"
PV = "0.1.2"
PR = "10.el10_0"
PACKAGES = " \
 ghc-rpm-nvr \
 ghc-rpm-nvr-devel \
 ghc-rpm-nvr-doc \
 ghc-rpm-nvr-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-rpm-nvr-0.1.2-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "02ccdcb25a1d9a3a8d2493af5ec70cfdbe9d152f41ed79dbb5ce90e117c9a24a"

URI_x86_64_v2_ghc-rpm-nvr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-rpm-nvr-0.1.2-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-rpm-nvr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-rpm-nvr}"
SRC_URI[x86_64_v2_ghc-rpm-nvr.sha256sum] = "84ef79c3b6d64d0b1efa8131fce01953c9b266a6ab067f4e60ebe9112df7eb9b"

URI_x86_64_v2_ghc-rpm-nvr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-rpm-nvr-devel-0.1.2-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-rpm-nvr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-rpm-nvr-devel}"
SRC_URI[x86_64_v2_ghc-rpm-nvr-devel.sha256sum] = "deba115bff1118aa338b8bab1fd21290cf89ff866f523315ddfa80118a19d6de"

URI_x86_64_v2_ghc-rpm-nvr-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-rpm-nvr-doc-0.1.2-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-rpm-nvr-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-rpm-nvr-doc}"
SRC_URI[x86_64_v2_ghc-rpm-nvr-doc.sha256sum] = "5bfd20032d7151f2c91ac74a932d6f51ef9a12b38b847a254ced2de0a132fa93"

URI_x86_64_v2_ghc-rpm-nvr-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-rpm-nvr-prof-0.1.2-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-rpm-nvr-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-rpm-nvr-prof}"
SRC_URI[x86_64_v2_ghc-rpm-nvr-prof.sha256sum] = "a46b5ff0524370ce44c70665f22316c3d7612c7b7bf69438716cfa26306bd6b8"

URI_aarch64_ghc-rpm-nvr = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-rpm-nvr-0.1.2-10.el10_0.aarch64.rpm;name=aarch64_ghc-rpm-nvr;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-rpm-nvr}"
SRC_URI[aarch64_ghc-rpm-nvr.sha256sum] = "248481f3f05fc49a785d05066b828a3a9ae445d0c9e9ab71a991dd8612b7a97a"

URI_aarch64_ghc-rpm-nvr-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-rpm-nvr-devel-0.1.2-10.el10_0.aarch64.rpm;name=aarch64_ghc-rpm-nvr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-rpm-nvr-devel}"
SRC_URI[aarch64_ghc-rpm-nvr-devel.sha256sum] = "49867f23ddc93d4ec9dc249dd5745c4232ddc218380072a86f2b1de715bd6254"

URI_aarch64_ghc-rpm-nvr-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-rpm-nvr-doc-0.1.2-10.el10_0.noarch.rpm;name=aarch64_ghc-rpm-nvr-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-rpm-nvr-doc}"
SRC_URI[aarch64_ghc-rpm-nvr-doc.sha256sum] = "7c1737eef7731b96292d735bd2443a6da19e652562ef7ec54206eb2e3734cb64"

URI_aarch64_ghc-rpm-nvr-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-rpm-nvr-prof-0.1.2-10.el10_0.aarch64.rpm;name=aarch64_ghc-rpm-nvr-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-rpm-nvr-prof}"
SRC_URI[aarch64_ghc-rpm-nvr-prof.sha256sum] = "e3a747fc929bf96792b2941dc5498e825a2f4c7df3db676ba72c6f875b6b2e38"

RDEPENDS:ghc-rpm-nvr = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-clock \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-extra \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-process \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-rpm-nvr-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-extra-devel \
 ghc-filepath-devel \
 ghc-rpm-nvr \
 "
RDEPENDS:ghc-rpm-nvr-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-rpm-nvr-prof = " \
 ghc-base-prof \
 ghc-extra-prof \
 ghc-filepath-prof \
 ghc-rpm-nvr-devel \
 "
