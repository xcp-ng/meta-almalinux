# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-priority-queue"
PV = "2.7.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-priority-queue+benchmarks-devel \
 rust-priority-queue+default-devel \
 rust-priority-queue+serde-devel \
 rust-priority-queue+std-devel \
 rust-priority-queue-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-priority-queue-2.7.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b64596eaf03e80e70a6e8179a5117321f8b1f3388ab5fb9da3741a4b94a7523"

URI_x86_64_v2_rust-priority-queue+benchmarks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-priority-queue+benchmarks-devel-2.7.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-priority-queue+benchmarks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-priority-queue+benchmarks-devel}"
SRC_URI[x86_64_v2_rust-priority-queue+benchmarks-devel.sha256sum] = "4bdd45885cf2f75c81718280c175cf58ca23ea193f1858442c3d2ac37e696d79"

URI_x86_64_v2_rust-priority-queue+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-priority-queue+default-devel-2.7.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-priority-queue+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-priority-queue+default-devel}"
SRC_URI[x86_64_v2_rust-priority-queue+default-devel.sha256sum] = "e2a8bc14e8ae13f1ada715597ea8adc72eb461fb7b3717ef66db725651332f02"

URI_x86_64_v2_rust-priority-queue+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-priority-queue+serde-devel-2.7.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-priority-queue+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-priority-queue+serde-devel}"
SRC_URI[x86_64_v2_rust-priority-queue+serde-devel.sha256sum] = "11860e020bae27361b271ab976559498c7e51a66e727c8fc7eb5a85074462788"

URI_x86_64_v2_rust-priority-queue+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-priority-queue+std-devel-2.7.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-priority-queue+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-priority-queue+std-devel}"
SRC_URI[x86_64_v2_rust-priority-queue+std-devel.sha256sum] = "b8accdbe4a82e9818748e09dbccb14e1639377dc0e4f2e023c0a300ae72d975d"

URI_x86_64_v2_rust-priority-queue-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-priority-queue-devel-2.7.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-priority-queue-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-priority-queue-devel}"
SRC_URI[x86_64_v2_rust-priority-queue-devel.sha256sum] = "7ef12f35578dd9a52efa2009093f2dfaa23dcff145644e95991cc39372cef388"

URI_aarch64_rust-priority-queue+benchmarks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-priority-queue+benchmarks-devel-2.7.0-1.el10_2.noarch.rpm;name=aarch64_rust-priority-queue+benchmarks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-priority-queue+benchmarks-devel}"
SRC_URI[aarch64_rust-priority-queue+benchmarks-devel.sha256sum] = "f7402d59c9ec655394f96aa593286d6afe6717abf70f421b89644a5abe1536a9"

URI_aarch64_rust-priority-queue+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-priority-queue+default-devel-2.7.0-1.el10_2.noarch.rpm;name=aarch64_rust-priority-queue+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-priority-queue+default-devel}"
SRC_URI[aarch64_rust-priority-queue+default-devel.sha256sum] = "b4d053a87f36ab9c519008c9aab497f7634ad0515e74ee9f7ddbbbe52d157c2d"

URI_aarch64_rust-priority-queue+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-priority-queue+serde-devel-2.7.0-1.el10_2.noarch.rpm;name=aarch64_rust-priority-queue+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-priority-queue+serde-devel}"
SRC_URI[aarch64_rust-priority-queue+serde-devel.sha256sum] = "daa26d2ba845c1b6fa293b8d67869bcbeb48903f1e846f96368f400305cb83b7"

URI_aarch64_rust-priority-queue+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-priority-queue+std-devel-2.7.0-1.el10_2.noarch.rpm;name=aarch64_rust-priority-queue+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-priority-queue+std-devel}"
SRC_URI[aarch64_rust-priority-queue+std-devel.sha256sum] = "a0918587a4ded0507dc34613cb57ec816da003e44fdffc2640367e3025754408"

URI_aarch64_rust-priority-queue-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-priority-queue-devel-2.7.0-1.el10_2.noarch.rpm;name=aarch64_rust-priority-queue-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-priority-queue-devel}"
SRC_URI[aarch64_rust-priority-queue-devel.sha256sum] = "968261b891d227887176bde490307df466852a8553f19c858629a585e825b26d"

RDEPENDS:rust-priority-queue+benchmarks-devel = " \
 cargo \
 rust-priority-queue-devel \
 "
RDEPENDS:rust-priority-queue+default-devel = " \
 cargo \
 rust-priority-queue+std-devel \
 rust-priority-queue-devel \
 "
RDEPENDS:rust-priority-queue+serde-devel = " \
 cargo \
 rust-priority-queue-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-priority-queue+std-devel = " \
 cargo \
 rust-indexmap+std-devel \
 rust-priority-queue-devel \
 rust-serde+alloc-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-priority-queue-devel = " \
 cargo \
 rust \
 rust-equivalent+default-devel \
 rust-indexmap-devel \
 "
