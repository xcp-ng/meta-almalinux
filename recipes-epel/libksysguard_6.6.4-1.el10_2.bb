# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libksysguard"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 libksysguard \
 libksysguard-common \
 libksysguard-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libksysguard-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d569b0655520fb72994eb865822da2d8bbe243fadce000105318ae1e2fcfd12a"

URI_x86_64_v2_libksysguard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksysguard-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libksysguard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libksysguard}"
SRC_URI[x86_64_v2_libksysguard.sha256sum] = "f063e32a9aa93ee439f0906556aa104c80f22d5ca49cdd2e5e4f4347edf8dea1"

URI_x86_64_v2_libksysguard-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksysguard-common-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libksysguard-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libksysguard-common}"
SRC_URI[x86_64_v2_libksysguard-common.sha256sum] = "6783c010030216b3ba414bdcd19eb096ee9f8c3141ee76fe57c801cfbadbffe0"

URI_x86_64_v2_libksysguard-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksysguard-devel-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libksysguard-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libksysguard-devel}"
SRC_URI[x86_64_v2_libksysguard-devel.sha256sum] = "95b0a38d14123f82d073944e9b4595c28ce2d9c0f87030b82edba31cef120536"

URI_aarch64_libksysguard = "${EPEL_MIRROR}/aarch64/Packages/l/libksysguard-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_libksysguard;unpack=0"
SRC_URI:append = " ${URI_aarch64_libksysguard}"
SRC_URI[aarch64_libksysguard.sha256sum] = "34be6666d0bd427b1f6f595eeb27614acdb74687fd7c6082406f809d9454db42"

URI_aarch64_libksysguard-common = "${EPEL_MIRROR}/aarch64/Packages/l/libksysguard-common-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_libksysguard-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_libksysguard-common}"
SRC_URI[aarch64_libksysguard-common.sha256sum] = "61ea1befc4f57ea140fb27a64e5783e99ef3003b375d3f0694b23a7c0bda28f5"

URI_aarch64_libksysguard-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libksysguard-devel-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_libksysguard-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libksysguard-devel}"
SRC_URI[aarch64_libksysguard-devel.sha256sum] = "68b9a5160acfb2974a4ab85e4760a81eb7a2ca14403bc12d2c4ea771cbccf95f"

RDEPENDS:libksysguard = " \
 glibc \
 kf6-kauth \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kpackage \
 kf6-kservice \
 kf6-solid \
 libdrm \
 libgcc \
 libksysguard-common \
 libnl3 \
 libpcap \
 libstdc++ \
 lm_sensors-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:libksysguard-common = " \
 glibc \
 kf6-kauth \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:libksysguard-devel = " \
 cmake-filesystem \
 kf6-kconfig-devel \
 kf6-ki18n-devel \
 kf6-kiconthemes-devel \
 libksysguard \
 qt6-qtbase-devel \
 "
