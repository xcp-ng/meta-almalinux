# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ambient-id"
PV = "0.0.11"
PR = "1.el10_3"
PACKAGES = " \
 rust-ambient-id+default-devel \
 rust-ambient-id+native-tls-devel \
 rust-ambient-id+reqwest-middleware-devel \
 rust-ambient-id+rustls-devel \
 rust-ambient-id-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ambient-id-0.0.11-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "97cdd82b1f30f3928944d7b31c235f616ca285e42dcca352bad2a19785cef88f"

URI_x86_64_v2_rust-ambient-id+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ambient-id+default-devel-0.0.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ambient-id+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ambient-id+default-devel}"
SRC_URI[x86_64_v2_rust-ambient-id+default-devel.sha256sum] = "156fbf9d12d03fb89673174e7a1ebb15bc59d3861cd8b7924556863fedf9d182"

URI_x86_64_v2_rust-ambient-id+native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ambient-id+native-tls-devel-0.0.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ambient-id+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ambient-id+native-tls-devel}"
SRC_URI[x86_64_v2_rust-ambient-id+native-tls-devel.sha256sum] = "7a3f30064e1a7d552e2bb672aad8677db7f34014620783039dda513601ef52bf"

URI_x86_64_v2_rust-ambient-id+reqwest-middleware-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ambient-id+reqwest-middleware-devel-0.0.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ambient-id+reqwest-middleware-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ambient-id+reqwest-middleware-devel}"
SRC_URI[x86_64_v2_rust-ambient-id+reqwest-middleware-devel.sha256sum] = "1f0a5f4160fd50badfae83715982d9e0c9ce0a9b3ff3ad4696f9480aecb4f57e"

URI_x86_64_v2_rust-ambient-id+rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ambient-id+rustls-devel-0.0.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ambient-id+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ambient-id+rustls-devel}"
SRC_URI[x86_64_v2_rust-ambient-id+rustls-devel.sha256sum] = "71726a0114200cf5dc023969a829cbcde51541af426181fa8dc9c7e8f5f7237d"

URI_x86_64_v2_rust-ambient-id-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ambient-id-devel-0.0.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ambient-id-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ambient-id-devel}"
SRC_URI[x86_64_v2_rust-ambient-id-devel.sha256sum] = "c60745828b1818fc5a2f472c315a27e8f9c7bf513ca44459034053d36af0130a"

URI_aarch64_rust-ambient-id+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ambient-id+default-devel-0.0.11-1.el10_3.noarch.rpm;name=aarch64_rust-ambient-id+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ambient-id+default-devel}"
SRC_URI[aarch64_rust-ambient-id+default-devel.sha256sum] = "c93bd99c203cd8000dfea2ed974f4a567e42d8e7d2c8409b58bc993b59c0d4b2"

URI_aarch64_rust-ambient-id+native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ambient-id+native-tls-devel-0.0.11-1.el10_3.noarch.rpm;name=aarch64_rust-ambient-id+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ambient-id+native-tls-devel}"
SRC_URI[aarch64_rust-ambient-id+native-tls-devel.sha256sum] = "4d993aff8e12adf639e21df54aa147af73841a978fbd9ccaf07d0427710f44fa"

URI_aarch64_rust-ambient-id+reqwest-middleware-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ambient-id+reqwest-middleware-devel-0.0.11-1.el10_3.noarch.rpm;name=aarch64_rust-ambient-id+reqwest-middleware-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ambient-id+reqwest-middleware-devel}"
SRC_URI[aarch64_rust-ambient-id+reqwest-middleware-devel.sha256sum] = "af3a0060440f5ca1025f689272a6003296ab98807ce271c5523aff7f4ecc875b"

URI_aarch64_rust-ambient-id+rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ambient-id+rustls-devel-0.0.11-1.el10_3.noarch.rpm;name=aarch64_rust-ambient-id+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ambient-id+rustls-devel}"
SRC_URI[aarch64_rust-ambient-id+rustls-devel.sha256sum] = "5d4391f3b7a6a4fac394d66133bcc3452997bc8c9ed41bce36f4289189a1fa09"

URI_aarch64_rust-ambient-id-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ambient-id-devel-0.0.11-1.el10_3.noarch.rpm;name=aarch64_rust-ambient-id-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ambient-id-devel}"
SRC_URI[aarch64_rust-ambient-id-devel.sha256sum] = "378014e55cd97362b5b65f187309d160d75cd9624cc42cae9a46148adae2a07d"

RDEPENDS:rust-ambient-id+default-devel = " \
 cargo \
 rust-ambient-id+reqwest-middleware-devel \
 rust-ambient-id+rustls-devel \
 rust-ambient-id-devel \
 "
RDEPENDS:rust-ambient-id+native-tls-devel = " \
 cargo \
 rust-ambient-id-devel \
 rust-reqwest+native-tls-devel \
 "
RDEPENDS:rust-ambient-id+reqwest-middleware-devel = " \
 cargo \
 rust-ambient-id-devel \
 rust-astral-reqwest-middleware+default-devel \
 rust-astral-reqwest-middleware+query-devel \
 "
RDEPENDS:rust-ambient-id+rustls-devel = " \
 cargo \
 rust-ambient-id-devel \
 rust-reqwest+rustls-devel \
 "
RDEPENDS:rust-ambient-id-devel = " \
 cargo \
 rust-reqwest+deflate-devel \
 rust-reqwest+gzip-devel \
 rust-reqwest+http2-devel \
 rust-reqwest+json-devel \
 rust-reqwest+query-devel \
 rust-reqwest-devel \
 rust-secrecy+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-thiserror+default-devel \
 "
