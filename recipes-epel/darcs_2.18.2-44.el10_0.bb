# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "darcs"
PV = "2.18.2"
PR = "44.el10_0"
PACKAGES = " \
 darcs \
 ghc-darcs \
 ghc-darcs-devel \
 ghc-darcs-doc \
 ghc-darcs-prof \
 ghc-data-ordlist \
 ghc-data-ordlist-devel \
 ghc-data-ordlist-doc \
 ghc-data-ordlist-prof \
 ghc-strict-identity \
 ghc-strict-identity-devel \
 ghc-strict-identity-doc \
 ghc-strict-identity-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/darcs-2.18.2-44.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "377a1ca867710d508243f0a5eba0a58e73989c085429ad260a33d462d5a71f20"

URI_x86_64_v2_darcs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/darcs-2.18.2-44.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_darcs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_darcs}"
SRC_URI[x86_64_v2_darcs.sha256sum] = "16719e13dcde7a3e97943a075a9cb0cde96126fc1431336ef585decc88fd618a"

URI_x86_64_v2_ghc-darcs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-darcs-2.18.2-44.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-darcs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-darcs}"
SRC_URI[x86_64_v2_ghc-darcs.sha256sum] = "d8bbed9770627fcd2931235151ae37a517ee1ca098fa87ab244268725462f8da"

URI_x86_64_v2_ghc-darcs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-darcs-devel-2.18.2-44.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-darcs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-darcs-devel}"
SRC_URI[x86_64_v2_ghc-darcs-devel.sha256sum] = "b817fa2d6ef19ab9cb58620439fc951836213f2d2dd572eacc2a8fffd78a5905"

URI_x86_64_v2_ghc-darcs-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-darcs-doc-2.18.2-44.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-darcs-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-darcs-doc}"
SRC_URI[x86_64_v2_ghc-darcs-doc.sha256sum] = "695bc9cfcc3b7c29ad72c5ac766b246390a334a6e84b16a2b31b656ab0684c11"

URI_x86_64_v2_ghc-darcs-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-darcs-prof-2.18.2-44.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-darcs-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-darcs-prof}"
SRC_URI[x86_64_v2_ghc-darcs-prof.sha256sum] = "bb783c04521c2c1d4b314aaa5769feea6d3518c12f6a448ddcff243b82ee9c70"

URI_x86_64_v2_ghc-data-ordlist = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-ordlist-0.4.7.0-44.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-data-ordlist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-ordlist}"
SRC_URI[x86_64_v2_ghc-data-ordlist.sha256sum] = "4de664466d7ef59b276305392806c9b98093d52b628351f766b48e36ed467cc3"

URI_x86_64_v2_ghc-data-ordlist-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-ordlist-devel-0.4.7.0-44.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-data-ordlist-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-ordlist-devel}"
SRC_URI[x86_64_v2_ghc-data-ordlist-devel.sha256sum] = "f8752e171ede21f584669d2389f898f20b13048a60c54b644b407164f88702a9"

URI_x86_64_v2_ghc-data-ordlist-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-ordlist-doc-0.4.7.0-44.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-data-ordlist-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-ordlist-doc}"
SRC_URI[x86_64_v2_ghc-data-ordlist-doc.sha256sum] = "b40462ed09bc1c0a91d87e0b449b78c3c51c0cf9d2aaa138881120278a1ac565"

URI_x86_64_v2_ghc-data-ordlist-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-ordlist-prof-0.4.7.0-44.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-data-ordlist-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-ordlist-prof}"
SRC_URI[x86_64_v2_ghc-data-ordlist-prof.sha256sum] = "10fb3b29f701240762b28c1004d51fa3acb2633bcb62eb2b5aff8dc640912440"

URI_x86_64_v2_ghc-strict-identity = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-strict-identity-0.1.0.0-44.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-strict-identity;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-strict-identity}"
SRC_URI[x86_64_v2_ghc-strict-identity.sha256sum] = "691b37f87a82af08efe3d209ddeb9f865178b675cc2054340107e33cc87546c6"

URI_x86_64_v2_ghc-strict-identity-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-strict-identity-devel-0.1.0.0-44.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-strict-identity-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-strict-identity-devel}"
SRC_URI[x86_64_v2_ghc-strict-identity-devel.sha256sum] = "4a0362f4caee5be26d50faca4f46a7583e184f9e930bbbff9a205de8958a417b"

URI_x86_64_v2_ghc-strict-identity-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-strict-identity-doc-0.1.0.0-44.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-strict-identity-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-strict-identity-doc}"
SRC_URI[x86_64_v2_ghc-strict-identity-doc.sha256sum] = "8108c835796d92fb47d92b98a86e4efa15346775dc54a8aa02525beb9c4e1d21"

URI_x86_64_v2_ghc-strict-identity-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-strict-identity-prof-0.1.0.0-44.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-strict-identity-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-strict-identity-prof}"
SRC_URI[x86_64_v2_ghc-strict-identity-prof.sha256sum] = "a9340c36e7472adf572cdec1879bd26b96eeb397776cb836cba7d7598435f73b"

URI_aarch64_darcs = "${EPEL_MIRROR}/aarch64/Packages/d/darcs-2.18.2-44.el10_0.aarch64.rpm;name=aarch64_darcs;unpack=0"
SRC_URI:append = " ${URI_aarch64_darcs}"
SRC_URI[aarch64_darcs.sha256sum] = "4d9f2b6cd96ed873bb7f4c4f83d734a73ed3d6e920831e6bd0c70abf5436bcdc"

URI_aarch64_ghc-darcs = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-darcs-2.18.2-44.el10_0.aarch64.rpm;name=aarch64_ghc-darcs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-darcs}"
SRC_URI[aarch64_ghc-darcs.sha256sum] = "f44e08c37cb9bc457fda1efe0eb838664ff58ff4bb7d92725400fd3ee7ac7a28"

URI_aarch64_ghc-darcs-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-darcs-devel-2.18.2-44.el10_0.aarch64.rpm;name=aarch64_ghc-darcs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-darcs-devel}"
SRC_URI[aarch64_ghc-darcs-devel.sha256sum] = "d75f30128869d18387ec3dcb5541c3c82c5a953334e238faa50c495ad70a5e4c"

URI_aarch64_ghc-darcs-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-darcs-doc-2.18.2-44.el10_0.noarch.rpm;name=aarch64_ghc-darcs-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-darcs-doc}"
SRC_URI[aarch64_ghc-darcs-doc.sha256sum] = "5438e35f9bb28e228d1164cf11ae712aae2dbe043000e00497923a82f26b6943"

URI_aarch64_ghc-darcs-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-darcs-prof-2.18.2-44.el10_0.aarch64.rpm;name=aarch64_ghc-darcs-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-darcs-prof}"
SRC_URI[aarch64_ghc-darcs-prof.sha256sum] = "1092008b28a27929de2b73a36bd84315dcd152bf05df6de67bce731c7a396c52"

URI_aarch64_ghc-data-ordlist = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-ordlist-0.4.7.0-44.el10_0.aarch64.rpm;name=aarch64_ghc-data-ordlist;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-ordlist}"
SRC_URI[aarch64_ghc-data-ordlist.sha256sum] = "9192c6c6aadd8237bfe0fd1cac1c4dc663d72adf90baf6d9cfb787ff054aafc3"

URI_aarch64_ghc-data-ordlist-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-ordlist-devel-0.4.7.0-44.el10_0.aarch64.rpm;name=aarch64_ghc-data-ordlist-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-ordlist-devel}"
SRC_URI[aarch64_ghc-data-ordlist-devel.sha256sum] = "8d1e99578353b34346840a6cbb671ac3550031ac9c9cd77f7e4f5008ebb7d735"

URI_aarch64_ghc-data-ordlist-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-ordlist-doc-0.4.7.0-44.el10_0.noarch.rpm;name=aarch64_ghc-data-ordlist-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-ordlist-doc}"
SRC_URI[aarch64_ghc-data-ordlist-doc.sha256sum] = "e959992f308f7278c670f962279b2b218548b24923404731cf226f3aa1bb98a0"

URI_aarch64_ghc-data-ordlist-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-ordlist-prof-0.4.7.0-44.el10_0.aarch64.rpm;name=aarch64_ghc-data-ordlist-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-ordlist-prof}"
SRC_URI[aarch64_ghc-data-ordlist-prof.sha256sum] = "c48cddc2dcb318e60bc4f46628c94c6bd2a79f2015d1b7ac90a7e61fbe261343"

URI_aarch64_ghc-strict-identity = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-strict-identity-0.1.0.0-44.el10_0.aarch64.rpm;name=aarch64_ghc-strict-identity;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-strict-identity}"
SRC_URI[aarch64_ghc-strict-identity.sha256sum] = "73e3f64197cad10573953a79a8e38a0f1c37166e9ec3f04ef66e6503982265bc"

URI_aarch64_ghc-strict-identity-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-strict-identity-devel-0.1.0.0-44.el10_0.aarch64.rpm;name=aarch64_ghc-strict-identity-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-strict-identity-devel}"
SRC_URI[aarch64_ghc-strict-identity-devel.sha256sum] = "dc85de343ccd0ba19c6eda374cf540f1a6bdb26e17b200fbf06e1f88045f6aa0"

URI_aarch64_ghc-strict-identity-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-strict-identity-doc-0.1.0.0-44.el10_0.noarch.rpm;name=aarch64_ghc-strict-identity-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-strict-identity-doc}"
SRC_URI[aarch64_ghc-strict-identity-doc.sha256sum] = "658d5fa7dce0485a72362cba1c822da736632ff70af8266086b7ebabf2c6864e"

URI_aarch64_ghc-strict-identity-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-strict-identity-prof-0.1.0.0-44.el10_0.aarch64.rpm;name=aarch64_ghc-strict-identity-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-strict-identity-prof}"
SRC_URI[aarch64_ghc-strict-identity-prof.sha256sum] = "facc4996828493469b5bdc34bb87e4493bc4edfeef60f9ec1ea760cef0e663fd"

RDEPENDS:darcs = " \
 glibc \
 gmp \
 libffi \
 ncurses-libs \
 zlib-ng-compat \
 "
RDEPENDS:ghc-darcs = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-appar \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base16-bytestring \
 ghc-base64-bytestring \
 ghc-basement \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-boring \
 ghc-byteorder \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-cereal \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-constraints \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-crypton \
 ghc-crypton-connection \
 ghc-crypton-x509 \
 ghc-crypton-x509-store \
 ghc-crypton-x509-system \
 ghc-crypton-x509-validation \
 ghc-cryptonite \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-data-ordlist \
 ghc-deepseq \
 ghc-digest \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-fgl \
 ghc-filepath \
 ghc-filtrable \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-haskeline \
 ghc-hourglass \
 ghc-html \
 ghc-http-client \
 ghc-http-client-tls \
 ghc-http-conduit \
 ghc-http-types \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-iproute \
 ghc-memory \
 ghc-mime-types \
 ghc-mmap \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-network-uri \
 ghc-old-locale \
 ghc-old-time \
 ghc-os-string \
 ghc-parsec \
 ghc-pem \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-regex-applicative \
 ghc-regex-base \
 ghc-regex-tdfa \
 ghc-resourcet \
 ghc-safe \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-socks \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-strict-identity \
 ghc-tagged \
 ghc-tar \
 ghc-template-haskell \
 ghc-temporary \
 ghc-terminal-size \
 ghc-terminfo \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-compat \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-tls \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-unix \
 ghc-unix-compat \
 ghc-unix-time \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-utf8-string \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-witherable \
 ghc-zip-archive \
 ghc-zlib \
 glibc \
 gmp \
 ncurses-libs \
 zlib-ng-compat \
 "
RDEPENDS:ghc-darcs-devel = " \
 ghc-array-devel \
 ghc-async-devel \
 ghc-attoparsec-devel \
 ghc-base-devel \
 ghc-base16-bytestring-devel \
 ghc-binary-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-conduit-devel \
 ghc-constraints-devel \
 ghc-containers-devel \
 ghc-cryptonite-devel \
 ghc-darcs \
 ghc-data-ordlist-devel \
 ghc-directory-devel \
 ghc-exceptions-devel \
 ghc-fgl-devel \
 ghc-filepath-devel \
 ghc-hashable-devel \
 ghc-haskeline-devel \
 ghc-html-devel \
 ghc-http-conduit-devel \
 ghc-http-types-devel \
 ghc-memory-devel \
 ghc-mmap-devel \
 ghc-mtl-devel \
 ghc-network-devel \
 ghc-network-uri-devel \
 ghc-old-time-devel \
 ghc-parsec-devel \
 ghc-process-devel \
 ghc-regex-applicative-devel \
 ghc-regex-base-devel \
 ghc-regex-tdfa-devel \
 ghc-safe-devel \
 ghc-stm-devel \
 ghc-strict-identity-devel \
 ghc-tar-devel \
 ghc-temporary-devel \
 ghc-terminal-size-devel \
 ghc-terminfo-devel \
 ghc-text-devel \
 ghc-time-devel \
 ghc-tls-devel \
 ghc-transformers-devel \
 ghc-unix-compat-devel \
 ghc-unix-devel \
 ghc-utf8-string-devel \
 ghc-vector-devel \
 ghc-zip-archive-devel \
 ghc-zlib-devel \
 "
RDEPENDS:ghc-darcs-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-darcs-prof = " \
 ghc-array-prof \
 ghc-async-prof \
 ghc-attoparsec-prof \
 ghc-base-prof \
 ghc-base16-bytestring-prof \
 ghc-binary-prof \
 ghc-bytestring-prof \
 ghc-conduit-prof \
 ghc-constraints-prof \
 ghc-containers-prof \
 ghc-cryptonite-prof \
 ghc-darcs-devel \
 ghc-data-ordlist-prof \
 ghc-directory-prof \
 ghc-exceptions-prof \
 ghc-fgl-prof \
 ghc-filepath-prof \
 ghc-hashable-prof \
 ghc-haskeline-prof \
 ghc-html-prof \
 ghc-http-conduit-prof \
 ghc-http-types-prof \
 ghc-memory-prof \
 ghc-mmap-prof \
 ghc-mtl-prof \
 ghc-network-prof \
 ghc-network-uri-prof \
 ghc-old-time-prof \
 ghc-parsec-prof \
 ghc-process-prof \
 ghc-regex-applicative-prof \
 ghc-regex-base-prof \
 ghc-regex-tdfa-prof \
 ghc-safe-prof \
 ghc-stm-prof \
 ghc-strict-identity-prof \
 ghc-tar-prof \
 ghc-temporary-prof \
 ghc-terminal-size-prof \
 ghc-terminfo-prof \
 ghc-text-prof \
 ghc-time-prof \
 ghc-tls-prof \
 ghc-transformers-prof \
 ghc-unix-compat-prof \
 ghc-unix-prof \
 ghc-utf8-string-prof \
 ghc-vector-prof \
 ghc-zip-archive-prof \
 ghc-zlib-prof \
 "
RDEPENDS:ghc-data-ordlist = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-data-ordlist-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-data-ordlist \
 "
RDEPENDS:ghc-data-ordlist-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-data-ordlist-prof = " \
 ghc-base-prof \
 ghc-data-ordlist-devel \
 "
RDEPENDS:ghc-strict-identity = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-strict-identity-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-strict-identity \
 "
RDEPENDS:ghc-strict-identity-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-strict-identity-prof = " \
 ghc-base-prof \
 ghc-strict-identity-devel \
 "
