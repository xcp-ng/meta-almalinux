# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-streebog"
PV = "0.11.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-streebog+alloc-devel \
 rust-streebog+default-devel \
 rust-streebog+oid-devel \
 rust-streebog+zeroize-devel \
 rust-streebog-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-streebog-0.11.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fda564f8e4440b28e5767233f65aabe7de04d2711c0cd54e47e252ed17886e85"

URI_x86_64_v2_rust-streebog+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-streebog+alloc-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-streebog+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-streebog+alloc-devel}"
SRC_URI[x86_64_v2_rust-streebog+alloc-devel.sha256sum] = "05728f8855f51a2e723c873e3b2dc62dc3a985e34923c8c12db2e6abec29007d"

URI_x86_64_v2_rust-streebog+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-streebog+default-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-streebog+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-streebog+default-devel}"
SRC_URI[x86_64_v2_rust-streebog+default-devel.sha256sum] = "62e2a66b2f6b1c306bce7667316b5f7e2ec7ebe798891c0887bc3c55881c2914"

URI_x86_64_v2_rust-streebog+oid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-streebog+oid-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-streebog+oid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-streebog+oid-devel}"
SRC_URI[x86_64_v2_rust-streebog+oid-devel.sha256sum] = "90392b20aa83e1e577bdd62931a81162c85e4f5a6a6170c2d4ee72769f192426"

URI_x86_64_v2_rust-streebog+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-streebog+zeroize-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-streebog+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-streebog+zeroize-devel}"
SRC_URI[x86_64_v2_rust-streebog+zeroize-devel.sha256sum] = "e68248e771342b2da1ce1b814178b3c2c13923a7bd321d109c7bfd3f42498fd3"

URI_x86_64_v2_rust-streebog-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-streebog-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-streebog-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-streebog-devel}"
SRC_URI[x86_64_v2_rust-streebog-devel.sha256sum] = "2f43782f056e23dfbbb06c8e75a14bd27037915c36f287ed01557ec76b01aae2"

URI_aarch64_rust-streebog+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-streebog+alloc-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-streebog+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-streebog+alloc-devel}"
SRC_URI[aarch64_rust-streebog+alloc-devel.sha256sum] = "081c9c7ae15ab2521f680624e6fe55c9c893319e166ba4290c50a977419db603"

URI_aarch64_rust-streebog+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-streebog+default-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-streebog+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-streebog+default-devel}"
SRC_URI[aarch64_rust-streebog+default-devel.sha256sum] = "bc561a0f321599855150f2d88d458058f938434021f9f9e59bb0d72eadaf67c8"

URI_aarch64_rust-streebog+oid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-streebog+oid-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-streebog+oid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-streebog+oid-devel}"
SRC_URI[aarch64_rust-streebog+oid-devel.sha256sum] = "de974a9bcc1faa055b246fcb46aaa4d717243937193c5ba28b70838b17253d50"

URI_aarch64_rust-streebog+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-streebog+zeroize-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-streebog+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-streebog+zeroize-devel}"
SRC_URI[aarch64_rust-streebog+zeroize-devel.sha256sum] = "392cc3d99857136eece35a63f861bad9df04aa8d7e1f0694fb4e966e604e12dc"

URI_aarch64_rust-streebog-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-streebog-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-streebog-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-streebog-devel}"
SRC_URI[aarch64_rust-streebog-devel.sha256sum] = "77bac34fff6a9d45f4593dba05364d4b94ae164139d4adde0422048563435a97"

RDEPENDS:rust-streebog+alloc-devel = " \
 cargo \
 rust-digest+alloc-devel \
 rust-streebog-devel \
 "
RDEPENDS:rust-streebog+default-devel = " \
 cargo \
 rust-streebog+alloc-devel \
 rust-streebog+oid-devel \
 rust-streebog-devel \
 "
RDEPENDS:rust-streebog+oid-devel = " \
 cargo \
 rust-digest+oid-devel \
 rust-streebog-devel \
 "
RDEPENDS:rust-streebog+zeroize-devel = " \
 cargo \
 rust-digest+zeroize-devel \
 rust-streebog-devel \
 "
RDEPENDS:rust-streebog-devel = " \
 cargo \
 rust \
 rust-digest+default-devel \
 "
