# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pydantic-core"
PV = "2.23.4"
PR = "1.el10_0"
PACKAGES = " \
 python3-pydantic-core \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pydantic-core-2.23.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a30275a306f6a738588ef680eaba29949370d55d8f582c0dedcdb36ce1848532"

URI_x86_64_v2_python3-pydantic-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pydantic-core-2.23.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pydantic-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pydantic-core}"
SRC_URI[x86_64_v2_python3-pydantic-core.sha256sum] = "f61cfc785f981a2115b1e41481ded469d30bf0121530f59ae32e22305af8ca33"

URI_aarch64_python3-pydantic-core = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pydantic-core-2.23.4-1.el10_0.aarch64.rpm;name=aarch64_python3-pydantic-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pydantic-core}"
SRC_URI[aarch64_python3-pydantic-core.sha256sum] = "2d8a30f30d10c1c0d9dd3a645b1e6de0cdaf7448a7bf5a60a9e9d0b9607bf71d"

RDEPENDS:python3-pydantic-core = " \
 glibc \
 libgcc \
 python3 \
 python3-typing-extensions \
 "
