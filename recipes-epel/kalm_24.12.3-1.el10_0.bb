# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kalm"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kalm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kalm-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e5ab625e4821561a284a7a667b8ccda20069aa3ae53e797f27e75fe7e18b45d"

URI_x86_64_v2_kalm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kalm-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kalm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kalm}"
SRC_URI[x86_64_v2_kalm.sha256sum] = "22d0ff461e8d1c1426d556aad73d41bf9970e6cc36ad116c0295045b9a90039b"

URI_aarch64_kalm = "${EPEL_MIRROR}/aarch64/Packages/k/kalm-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kalm;unpack=0"
SRC_URI:append = " ${URI_aarch64_kalm}"
SRC_URI[aarch64_kalm.sha256sum] = "0fff39a1a6192c84ca8bc19ec370df238944c648b3842dc1747aa79d5e28b655"

RDEPENDS:kalm = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kirigami-addons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
