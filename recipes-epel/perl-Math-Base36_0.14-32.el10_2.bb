# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Math-Base36"
PV = "0.14"
PR = "32.el10_2"
PACKAGES = " \
 perl-Math-Base36 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Math-Base36-0.14-32.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7c24947f7f615dd673a4b67d5d31f1cb1c786c95aa7b19d86b35ac0e826ee0b"

URI_x86_64_v2_perl-Math-Base36 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Math-Base36-0.14-32.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Math-Base36;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Math-Base36}"
SRC_URI[x86_64_v2_perl-Math-Base36.sha256sum] = "62984fa5ffce5751a82aefac1319f58cd7853f2eb08c10eda18d55108e302549"

URI_aarch64_perl-Math-Base36 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Math-Base36-0.14-32.el10_2.noarch.rpm;name=aarch64_perl-Math-Base36;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Math-Base36}"
SRC_URI[aarch64_perl-Math-Base36.sha256sum] = "16cbc79ff6679225475ce4fdf66c005cb4901ddb6b53bb5bf8d74e4d5a397ca5"

RDEPENDS:perl-Math-Base36 = " \
 perl-Carp \
 perl-Exporter \
 perl-Math-BigInt \
 perl-base \
 perl-libs \
 "
