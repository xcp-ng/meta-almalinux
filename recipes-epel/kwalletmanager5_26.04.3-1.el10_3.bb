# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kwalletmanager5"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kwalletmanager5 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kwalletmanager5-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8ffae8b18fb9ec0325b867ebf172bfa48b2e69c815456f2b778fdfe8e01c6761"

URI_x86_64_v2_kwalletmanager5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwalletmanager5-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwalletmanager5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwalletmanager5}"
SRC_URI[x86_64_v2_kwalletmanager5.sha256sum] = "3555f52c729a5b003368dd6ea49f6cecf48c646bf459991ae61b3db67dec6e0e"

URI_aarch64_kwalletmanager5 = "${EPEL_MIRROR}/aarch64/Packages/k/kwalletmanager5-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kwalletmanager5;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwalletmanager5}"
SRC_URI[aarch64_kwalletmanager5.sha256sum] = "4e09b73e2f9965e688e0f8a52e38f82b078030a0bf2916363725325f1cb0aba6"

RDEPENDS:kwalletmanager5 = " \
 glibc \
 kf6-karchive \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kitemviews \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
