# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sound-theme-freedesktop"
PV = "0.8"
PR = "23.el10"
PACKAGES = " \
 sound-theme-freedesktop \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/sound-theme-freedesktop-0.8-23.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "70999025a28ecdd0a98dfb81127dffa50b510caa3241851413914bd468a70e32"

URI_x86_64_v2_sound-theme-freedesktop = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sound-theme-freedesktop-0.8-23.el10.noarch.rpm;name=x86_64_v2_sound-theme-freedesktop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sound-theme-freedesktop}"
SRC_URI[x86_64_v2_sound-theme-freedesktop.sha256sum] = "1d3c7a122470ae4df0b99bec4fef6b096bbacd8542306feb6c34937cd54b19e2"

URI_aarch64_sound-theme-freedesktop = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sound-theme-freedesktop-0.8-23.el10.noarch.rpm;name=aarch64_sound-theme-freedesktop;unpack=0"
SRC_URI:append = " ${URI_aarch64_sound-theme-freedesktop}"
SRC_URI[aarch64_sound-theme-freedesktop.sha256sum] = "1d3c7a122470ae4df0b99bec4fef6b096bbacd8542306feb6c34937cd54b19e2"

RDEPENDS:sound-theme-freedesktop = " \
 bash \
 virtual/coreutils \
 "
