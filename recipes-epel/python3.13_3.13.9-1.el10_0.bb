# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.13"
PV = "3.13.9"
PR = "1.el10_0"
PACKAGES = " \
 python3.13 \
 python3.13-debug \
 python3.13-devel \
 python3.13-freethreading \
 python3.13-freethreading-debug \
 python3.13-idle \
 python3.13-libs \
 python3.13-test \
 python3.13-tkinter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python3.13-3.13.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f9128f7d423ee6cb11131b178c8e1df1af5b8b4e98ab31ec83e1cc378f14c96"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - python3.13-freethreading: (python3.13-wheel-wheel if python3.13-setuptools-wheel < 71)
# - python3.13-test: (python3.13-wheel-wheel if python3.13-setuptools-wheel < 71)

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - python3.13-freethreading: (python3.13-wheel-wheel if python3.13-setuptools-wheel < 71)
# - python3.13-test: (python3.13-wheel-wheel if python3.13-setuptools-wheel < 71)

URI_x86_64_v2_python3.13 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-3.13.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3.13;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13}"
SRC_URI[x86_64_v2_python3.13.sha256sum] = "f82176ba75cc8b4b3882465fea9aaff71f3eca5a92e2176e56d0fab756b00752"

URI_x86_64_v2_python3.13-debug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-debug-3.13.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3.13-debug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-debug}"
SRC_URI[x86_64_v2_python3.13-debug.sha256sum] = "acfb3c3ad11da51005f3d4fd8c6e69a1602f92689cb9801d53e159bda33e82be"

URI_x86_64_v2_python3.13-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-devel-3.13.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3.13-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-devel}"
SRC_URI[x86_64_v2_python3.13-devel.sha256sum] = "64c9985525ccb80d86661b34a5aff11f2a66798d30bf498dd7f727037c946fa8"

URI_x86_64_v2_python3.13-freethreading = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-freethreading-3.13.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3.13-freethreading;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-freethreading}"
SRC_URI[x86_64_v2_python3.13-freethreading.sha256sum] = "fc703c3d81342419e70482562e63bfd02878c57e73fe221c97f944a13ab1b7c5"

URI_x86_64_v2_python3.13-freethreading-debug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-freethreading-debug-3.13.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3.13-freethreading-debug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-freethreading-debug}"
SRC_URI[x86_64_v2_python3.13-freethreading-debug.sha256sum] = "25c2c6b1fa5600de3b9fe073c5df3ee55f7650992ed5fde2baa4436684bf3670"

URI_x86_64_v2_python3.13-idle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-idle-3.13.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3.13-idle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-idle}"
SRC_URI[x86_64_v2_python3.13-idle.sha256sum] = "619c4ec5093e689d922cad5030213e3e9b14c947342eb0f1644fd9e8590ab7d5"

URI_x86_64_v2_python3.13-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-libs-3.13.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3.13-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-libs}"
SRC_URI[x86_64_v2_python3.13-libs.sha256sum] = "05b39c761ca94c7a7830eba95ad62471a0ca1fb4d0eae68ab50903ed56225951"

URI_x86_64_v2_python3.13-test = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-test-3.13.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3.13-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-test}"
SRC_URI[x86_64_v2_python3.13-test.sha256sum] = "ab99bcff7ad40c31581a4756a76ff082cbe604524cba6aac49f9c9908048a0da"

URI_x86_64_v2_python3.13-tkinter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-tkinter-3.13.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3.13-tkinter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-tkinter}"
SRC_URI[x86_64_v2_python3.13-tkinter.sha256sum] = "22721894ca5e511d275935f95d0e89d8fa7eba598539308b11e4a3ff5505730e"

URI_aarch64_python3.13 = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-3.13.9-1.el10_0.aarch64.rpm;name=aarch64_python3.13;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13}"
SRC_URI[aarch64_python3.13.sha256sum] = "0a2d1be7cb879bc1ba01e87cc32d8deded246b01202d5c574c75157c7580b180"

URI_aarch64_python3.13-debug = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-debug-3.13.9-1.el10_0.aarch64.rpm;name=aarch64_python3.13-debug;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-debug}"
SRC_URI[aarch64_python3.13-debug.sha256sum] = "0c960f46f498a64efa0ae6c05866113f42bb48f1dbc2c2afc7165d84777081b6"

URI_aarch64_python3.13-devel = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-devel-3.13.9-1.el10_0.aarch64.rpm;name=aarch64_python3.13-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-devel}"
SRC_URI[aarch64_python3.13-devel.sha256sum] = "6d91f69f57396f1350a95d6699bd32c128dabf80ee68502e786aabfa37818de7"

URI_aarch64_python3.13-freethreading = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-freethreading-3.13.9-1.el10_0.aarch64.rpm;name=aarch64_python3.13-freethreading;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-freethreading}"
SRC_URI[aarch64_python3.13-freethreading.sha256sum] = "9fcee91ec1a9c7ef3cd8eff412b95b79a279d0910a608f7dd6d1f1ff904023f3"

URI_aarch64_python3.13-freethreading-debug = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-freethreading-debug-3.13.9-1.el10_0.aarch64.rpm;name=aarch64_python3.13-freethreading-debug;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-freethreading-debug}"
SRC_URI[aarch64_python3.13-freethreading-debug.sha256sum] = "de5cc3a44eb1e680b0c332cc3d76bc7e24c87846006a3b52385a25d8c5d2128a"

URI_aarch64_python3.13-idle = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-idle-3.13.9-1.el10_0.aarch64.rpm;name=aarch64_python3.13-idle;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-idle}"
SRC_URI[aarch64_python3.13-idle.sha256sum] = "a6bbef80e3edf9283adde18de474a19aebf3f2eb700afd81b507a009e9ea4e70"

URI_aarch64_python3.13-libs = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-libs-3.13.9-1.el10_0.aarch64.rpm;name=aarch64_python3.13-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-libs}"
SRC_URI[aarch64_python3.13-libs.sha256sum] = "c0d7723a99c48198b7118b9c7ff3f98b7f90e36acbe1fa777eb6bf37193583f9"

URI_aarch64_python3.13-test = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-test-3.13.9-1.el10_0.aarch64.rpm;name=aarch64_python3.13-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-test}"
SRC_URI[aarch64_python3.13-test.sha256sum] = "b05fe66ca9c7bd0b62415be08040816aa2e4248542075aca71906dcdd0670e8f"

URI_aarch64_python3.13-tkinter = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-tkinter-3.13.9-1.el10_0.aarch64.rpm;name=aarch64_python3.13-tkinter;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-tkinter}"
SRC_URI[aarch64_python3.13-tkinter.sha256sum] = "a991926cb8c58bf127821642d0b33e51543c49a608dbf61b9a7e04f9c11743b5"

RDEPENDS:python3.13 = " \
 glibc \
 python3.13-libs \
 "
RDEPENDS:python3.13-debug = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libgcc \
 libuuid \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 pkgconf-pkg-config \
 python3.13 \
 python3.13-devel \
 python3.13-idle \
 python3.13-libs \
 python3.13-test \
 python3.13-tkinter \
 readline \
 sqlite-libs \
 tcl \
 tk \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3.13-devel = " \
 bash \
 pkgconf-pkg-config \
 python-rpm-macros \
 python3-rpm-generators \
 python3-rpm-macros \
 python3.13 \
 python3.13-libs \
 "
RDEPENDS:python3.13-freethreading = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libgcc \
 libuuid \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 pkgconf-pkg-config \
 python3.13-pip-wheel \
 python3.13-setuptools-wheel \
 readline \
 sqlite-libs \
 tcl \
 tk \
 tzdata \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3.13-freethreading-debug = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libgcc \
 libuuid \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 pkgconf-pkg-config \
 python3.13-freethreading \
 readline \
 sqlite-libs \
 tcl \
 tk \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3.13-idle = " \
 python3.13 \
 python3.13-tkinter \
 "
RDEPENDS:python3.13-libs = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libuuid \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 python3.13-pip-wheel \
 readline \
 sqlite-libs \
 tzdata \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3.13-test = " \
 bash \
 glibc \
 libgcc \
 python3.13 \
 python3.13-libs \
 python3.13-setuptools-wheel \
 "
RDEPENDS:python3.13-tkinter = " \
 glibc \
 python3.13 \
 tcl \
 tk \
 "
