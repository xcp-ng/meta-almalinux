# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-webbrowser"
PV = "1.2.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-webbrowser+default-devel \
 rust-webbrowser+disable-wsl-devel \
 rust-webbrowser+hardened-devel \
 rust-webbrowser-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-webbrowser-1.2.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fa5ed95dae55d64e721f2f7326a00dec51cb0b04849058af5a3e36144b8b31b7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-webbrowser+default-devel-1.2.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-webbrowser+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-webbrowser+default-devel.sha256sum] = "69c9a6f7dd4540679b8bc5a36be505f144605d7d9a63d88b2979fe624a47286f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-webbrowser+disable-wsl-devel-1.2.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-webbrowser+disable-wsl-devel;unpack=0"
SRC_URI[x86_64_v2_rust-webbrowser+disable-wsl-devel.sha256sum] = "a1fb6223df983d4cc7aad041ee817c345aad1e70555155efb786e77c728a1ecf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-webbrowser+hardened-devel-1.2.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-webbrowser+hardened-devel;unpack=0"
SRC_URI[x86_64_v2_rust-webbrowser+hardened-devel.sha256sum] = "fb33e12e0891654feec9393e6e88a6f66156e1122796244cbc10f4f0932263bb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-webbrowser-devel-1.2.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-webbrowser-devel;unpack=0"
SRC_URI[x86_64_v2_rust-webbrowser-devel.sha256sum] = "4535e40b877055012c5b15a3a4f7b107e8fe6831c1859b2010c88567dfcc6383"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-webbrowser+default-devel-1.2.4-1.el10_2.noarch.rpm;name=aarch64_rust-webbrowser+default-devel;unpack=0"
SRC_URI[aarch64_rust-webbrowser+default-devel.sha256sum] = "81ba203320078c38d9eeac300468ee281133225bb594386f59823a768394f9e6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-webbrowser+disable-wsl-devel-1.2.4-1.el10_2.noarch.rpm;name=aarch64_rust-webbrowser+disable-wsl-devel;unpack=0"
SRC_URI[aarch64_rust-webbrowser+disable-wsl-devel.sha256sum] = "8396e4291741452eaf0174757072a7e6459272cccbdfbc799caf079ba6260bfb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-webbrowser+hardened-devel-1.2.4-1.el10_2.noarch.rpm;name=aarch64_rust-webbrowser+hardened-devel;unpack=0"
SRC_URI[aarch64_rust-webbrowser+hardened-devel.sha256sum] = "ba21ce3d62f8d26797735f563c2b9de399747a7d54a4abee3bbd0fb7afb7a42d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-webbrowser-devel-1.2.4-1.el10_2.noarch.rpm;name=aarch64_rust-webbrowser-devel;unpack=0"
SRC_URI[aarch64_rust-webbrowser-devel.sha256sum] = "7e505cfad0a77c617d8fd75ac50facab9fe52246e604fc7d3542531e9fc2f72f"

RDEPENDS:rust-webbrowser+default-devel = " \
 cargo \
 rust-webbrowser-devel \
 "
RDEPENDS:rust-webbrowser+disable-wsl-devel = " \
 cargo \
 rust-webbrowser-devel \
 "
RDEPENDS:rust-webbrowser+hardened-devel = " \
 cargo \
 rust-webbrowser-devel \
 "
RDEPENDS:rust-webbrowser-devel = " \
 cargo \
 rust \
 rust-log-devel \
 rust-url+std-devel \
 rust-url-devel \
 "
