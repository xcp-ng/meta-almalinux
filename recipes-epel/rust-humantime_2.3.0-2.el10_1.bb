# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-humantime"
PV = "2.3.0"
PR = "2.el10_1"
PACKAGES = " \
 rust-humantime+default-devel \
 rust-humantime+mu-devel \
 rust-humantime-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-humantime-2.3.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c862ae350a626914d0ffd7a7c0740b64959bcf512f2e91db976d04ad3d72fd8"

URI_x86_64_v2_rust-humantime+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-humantime+default-devel-2.3.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-humantime+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-humantime+default-devel}"
SRC_URI[x86_64_v2_rust-humantime+default-devel.sha256sum] = "779a88e4f31da0345e3a0c3a0785ead3281e95aeb5cd627bf53d9f37c44a914c"

URI_x86_64_v2_rust-humantime+mu-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-humantime+mu-devel-2.3.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-humantime+mu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-humantime+mu-devel}"
SRC_URI[x86_64_v2_rust-humantime+mu-devel.sha256sum] = "47f24a7ec833d80bc7a6eb6b1550c6064e30ef4bd51334c98798764f056f033a"

URI_x86_64_v2_rust-humantime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-humantime-devel-2.3.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-humantime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-humantime-devel}"
SRC_URI[x86_64_v2_rust-humantime-devel.sha256sum] = "5b0500902a0b4ac8218ac43a4da345d3daeeba2d4a664e7ab322dcc05f8d6f3d"

URI_aarch64_rust-humantime+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-humantime+default-devel-2.3.0-2.el10_1.noarch.rpm;name=aarch64_rust-humantime+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-humantime+default-devel}"
SRC_URI[aarch64_rust-humantime+default-devel.sha256sum] = "e47bb6292a19fddb960ed614fd4e04252e420369707a3df3b68bce4f0ef32485"

URI_aarch64_rust-humantime+mu-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-humantime+mu-devel-2.3.0-2.el10_1.noarch.rpm;name=aarch64_rust-humantime+mu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-humantime+mu-devel}"
SRC_URI[aarch64_rust-humantime+mu-devel.sha256sum] = "2543503631ef8bf2d70b7d5b3cbe0c32671380fb33088c66accabe0eaf8e8a3f"

URI_aarch64_rust-humantime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-humantime-devel-2.3.0-2.el10_1.noarch.rpm;name=aarch64_rust-humantime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-humantime-devel}"
SRC_URI[aarch64_rust-humantime-devel.sha256sum] = "86bed4063f5b14d2ac2eca0139c14ce46963bf1a966b6be26e074406df8fe6c0"

RDEPENDS:rust-humantime+default-devel = " \
 cargo \
 rust-humantime-devel \
 "
RDEPENDS:rust-humantime+mu-devel = " \
 cargo \
 rust-humantime-devel \
 "
RDEPENDS:rust-humantime-devel = " \
 cargo \
 "
