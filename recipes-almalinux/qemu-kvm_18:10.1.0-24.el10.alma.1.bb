# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qemu-kvm"
PE = "18"
PV = "10.1.0"
PR = "24.el10.alma.1"
PACKAGES:x86_64_v2 = " \
 qemu-guest-agent \
 qemu-img \
 qemu-kvm \
 qemu-kvm-audio-pa \
 qemu-kvm-block-blkio \
 qemu-kvm-block-curl \
 qemu-kvm-block-rbd \
 qemu-kvm-common \
 qemu-kvm-core \
 qemu-kvm-device-display-virtio-gpu \
 qemu-kvm-device-display-virtio-gpu-pci \
 qemu-kvm-device-display-virtio-vga \
 qemu-kvm-device-usb-host \
 qemu-kvm-device-usb-redirect \
 qemu-kvm-docs \
 qemu-kvm-tools \
 qemu-kvm-ui-egl-headless \
 qemu-kvm-ui-opengl \
 qemu-kvm-ui-spice \
 qemu-pr-helper \
"
PACKAGES:aarch64 = " \
 qemu-guest-agent \
 qemu-img \
 qemu-kvm \
 qemu-kvm-audio-pa \
 qemu-kvm-block-blkio \
 qemu-kvm-block-curl \
 qemu-kvm-block-rbd \
 qemu-kvm-common \
 qemu-kvm-core \
 qemu-kvm-device-display-virtio-gpu \
 qemu-kvm-device-display-virtio-gpu-pci \
 qemu-kvm-device-usb-host \
 qemu-kvm-device-usb-redirect \
 qemu-kvm-docs \
 qemu-kvm-tools \
 qemu-kvm-ui-spice \
 qemu-pr-helper \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qemu-kvm-10.1.0-24.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0288e0140a9d38b0eef9308c6840e601cce895695dc3a0b2a9ff93184dccbf2"

URI_x86_64_v2_qemu-guest-agent = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-guest-agent-10.1.0-24.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-guest-agent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-guest-agent}"
SRC_URI[x86_64_v2_qemu-guest-agent.sha256sum] = "11de98d59ff51b7a5bc6673ab2b3219a60ca6de6412bc385330f988c05976700"

URI_x86_64_v2_qemu-img = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-img-10.1.0-24.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-img;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-img}"
SRC_URI[x86_64_v2_qemu-img.sha256sum] = "2dc653ccd993562e614defe786fb096d2a4b0e031f6fdbda8baedf12a63f88ce"

URI_x86_64_v2_qemu-kvm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-10.1.0-24.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm}"
SRC_URI[x86_64_v2_qemu-kvm.sha256sum] = "8ac4f0550337dc7c7c5471cf59bfc56abddd0ac3f26a46d93d70359f0d1fc90a"

URI_x86_64_v2_qemu-kvm-audio-pa = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-audio-pa-10.1.0-24.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-audio-pa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-audio-pa}"
SRC_URI[x86_64_v2_qemu-kvm-audio-pa.sha256sum] = "e01d781566821bbe16a505c2be86af7c5c6b7a64d9cd96389cf2697dfb769f1c"

URI_x86_64_v2_qemu-kvm-block-blkio = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-block-blkio-10.1.0-24.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-block-blkio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-block-blkio}"
SRC_URI[x86_64_v2_qemu-kvm-block-blkio.sha256sum] = "c4f1fd96892e913974f648a73231600e6f228cffa8aba73374e23bc46b71086a"

URI_x86_64_v2_qemu-kvm-block-curl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-block-curl-10.1.0-24.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-block-curl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-block-curl}"
SRC_URI[x86_64_v2_qemu-kvm-block-curl.sha256sum] = "801ca76650d2984243be717e6e918131f8d77dc47dcc97ec985fa814ba224833"

URI_x86_64_v2_qemu-kvm-block-rbd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-block-rbd-10.1.0-24.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-block-rbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-block-rbd}"
SRC_URI[x86_64_v2_qemu-kvm-block-rbd.sha256sum] = "decceefcb1d48114f695196efbd363331c04961b07bd2d32b01d6cf68bfa743c"

URI_x86_64_v2_qemu-kvm-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-common-10.1.0-24.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-common}"
SRC_URI[x86_64_v2_qemu-kvm-common.sha256sum] = "4423fc984acdd49a45df0a04564d82aa1cb9ecba4b1a0f3c9646893b53471f95"

URI_x86_64_v2_qemu-kvm-core = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-core-10.1.0-24.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-core}"
SRC_URI[x86_64_v2_qemu-kvm-core.sha256sum] = "cc1443cd925e79e32b49eafeab8452379f7bd4848369ed0a399e60acb40caaa6"

URI_x86_64_v2_qemu-kvm-device-display-virtio-gpu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-display-virtio-gpu-10.1.0-24.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-device-display-virtio-gpu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-device-display-virtio-gpu}"
SRC_URI[x86_64_v2_qemu-kvm-device-display-virtio-gpu.sha256sum] = "d411f244b2095d42102fd34e3e3018049f774a0298bae87937ffa0a341df2153"

URI_x86_64_v2_qemu-kvm-device-display-virtio-gpu-pci = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-display-virtio-gpu-pci-10.1.0-24.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-device-display-virtio-gpu-pci;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-device-display-virtio-gpu-pci}"
SRC_URI[x86_64_v2_qemu-kvm-device-display-virtio-gpu-pci.sha256sum] = "8f7d9983f897b4ce3a5f02b2735f8062a7e5ee43758474ce8ba4f561c77e733a"

URI_x86_64_v2_qemu-kvm-device-display-virtio-vga = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-display-virtio-vga-10.1.0-24.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-device-display-virtio-vga;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-device-display-virtio-vga}"
SRC_URI[x86_64_v2_qemu-kvm-device-display-virtio-vga.sha256sum] = "7b847c548628905363a7939eb012ac2220256072843f5aecfbf8d6ecb1a7ca27"

URI_x86_64_v2_qemu-kvm-device-usb-host = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-usb-host-10.1.0-24.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-device-usb-host;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-device-usb-host}"
SRC_URI[x86_64_v2_qemu-kvm-device-usb-host.sha256sum] = "c271c53c9581b64e3ef7b89c7e686a374775df942398f9f6736d06c8b1df38a9"

URI_x86_64_v2_qemu-kvm-device-usb-redirect = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-usb-redirect-10.1.0-24.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-device-usb-redirect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-device-usb-redirect}"
SRC_URI[x86_64_v2_qemu-kvm-device-usb-redirect.sha256sum] = "c1f13c2e422418cd9990b0216d772f4e051a9b3f7dea89812e9fc604226f256c"

URI_x86_64_v2_qemu-kvm-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-docs-10.1.0-24.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-docs}"
SRC_URI[x86_64_v2_qemu-kvm-docs.sha256sum] = "43c8b1b9d81aec6051cd1b76d59fa846a76633676f22d801877eb448108fe95b"

URI_x86_64_v2_qemu-kvm-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-tools-10.1.0-24.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-tools}"
SRC_URI[x86_64_v2_qemu-kvm-tools.sha256sum] = "25c757555c07e3fd87c708e8c7f1b217b1813eb6e704dd421f8ae9087c59b292"

URI_x86_64_v2_qemu-kvm-ui-egl-headless = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-ui-egl-headless-10.1.0-24.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-ui-egl-headless;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-ui-egl-headless}"
SRC_URI[x86_64_v2_qemu-kvm-ui-egl-headless.sha256sum] = "9c7a122a92bdcda30e7c36f68dd5668c732045c846d7385e505f4ffd9a345fc5"

URI_x86_64_v2_qemu-kvm-ui-opengl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-ui-opengl-10.1.0-24.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-ui-opengl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-ui-opengl}"
SRC_URI[x86_64_v2_qemu-kvm-ui-opengl.sha256sum] = "de104e8d861aa6eb5c0fd70cbc6327c42b1907bc1981a9b0ea3b77cb82d256f6"

URI_x86_64_v2_qemu-kvm-ui-spice = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-ui-spice-10.1.0-24.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-ui-spice;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-ui-spice}"
SRC_URI[x86_64_v2_qemu-kvm-ui-spice.sha256sum] = "f4d0f4f858719e16485d9c7b59f87c2d5b45926c6f67fa9ea36e96f805cd2f99"

URI_x86_64_v2_qemu-pr-helper = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-pr-helper-10.1.0-24.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-pr-helper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-pr-helper}"
SRC_URI[x86_64_v2_qemu-pr-helper.sha256sum] = "6ae37e9b0599217b4de2e400232eadc2de3310c3d929f7156ca337b9a83820b4"

URI_aarch64_qemu-guest-agent = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-guest-agent-10.1.0-24.el10.alma.1.aarch64.rpm;name=aarch64_qemu-guest-agent;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-guest-agent}"
SRC_URI[aarch64_qemu-guest-agent.sha256sum] = "df92de89e42dc50a4bf0a9c7c84650265424fee084eb2c8a971dc35a03ad594b"

URI_aarch64_qemu-img = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-img-10.1.0-24.el10.alma.1.aarch64.rpm;name=aarch64_qemu-img;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-img}"
SRC_URI[aarch64_qemu-img.sha256sum] = "b350d4775f9cd93322d4e634761240ccb45d33a4326ec18aa8b146e507e30d22"

URI_aarch64_qemu-kvm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-10.1.0-24.el10.alma.1.aarch64.rpm;name=aarch64_qemu-kvm;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm}"
SRC_URI[aarch64_qemu-kvm.sha256sum] = "5fb814ff28f0159164d76572631f4375c75046ea536f0885d95f2ecd5cfc321f"

URI_aarch64_qemu-kvm-audio-pa = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-audio-pa-10.1.0-24.el10.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-audio-pa;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-audio-pa}"
SRC_URI[aarch64_qemu-kvm-audio-pa.sha256sum] = "b192d7aedd3d64c0fbb8c5996a8f253ff701485555a6b0732ffcfe984946c868"

URI_aarch64_qemu-kvm-block-blkio = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-block-blkio-10.1.0-24.el10.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-block-blkio;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-block-blkio}"
SRC_URI[aarch64_qemu-kvm-block-blkio.sha256sum] = "699384ea31cb8df4ff297b0ee1d74b981ef8516a15620b9a69ecf4fdc4eadde8"

URI_aarch64_qemu-kvm-block-curl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-block-curl-10.1.0-24.el10.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-block-curl;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-block-curl}"
SRC_URI[aarch64_qemu-kvm-block-curl.sha256sum] = "49c1ac2cbdfcb9d86e11202552c79850616b1b28f460b6ef9f3ae1b6a46840bb"

URI_aarch64_qemu-kvm-block-rbd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-block-rbd-10.1.0-24.el10.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-block-rbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-block-rbd}"
SRC_URI[aarch64_qemu-kvm-block-rbd.sha256sum] = "74f154fb170cebb152538d7080714c6f473adcc2141ec20930f7731a9a1d63a0"

URI_aarch64_qemu-kvm-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-common-10.1.0-24.el10.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-common}"
SRC_URI[aarch64_qemu-kvm-common.sha256sum] = "4052da01325ec0019298fb9b15d54dad59f33d4798ab1abd8921f0f0f3fb9705"

URI_aarch64_qemu-kvm-core = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-core-10.1.0-24.el10.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-core}"
SRC_URI[aarch64_qemu-kvm-core.sha256sum] = "8e385a34f55230dc54b74ccb2975cc016bd44d412abec450464e1faf181ce021"

URI_aarch64_qemu-kvm-device-display-virtio-gpu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-device-display-virtio-gpu-10.1.0-24.el10.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-device-display-virtio-gpu;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-device-display-virtio-gpu}"
SRC_URI[aarch64_qemu-kvm-device-display-virtio-gpu.sha256sum] = "c7f843c4a76f0d2783bc16e08177a749bbdd6248d355c41cdc0e7baab7f36e36"

URI_aarch64_qemu-kvm-device-display-virtio-gpu-pci = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-device-display-virtio-gpu-pci-10.1.0-24.el10.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-device-display-virtio-gpu-pci;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-device-display-virtio-gpu-pci}"
SRC_URI[aarch64_qemu-kvm-device-display-virtio-gpu-pci.sha256sum] = "49f8e65adff9c949e727aadfeda6b377e005aec3d415d8388266f05fed935cab"

URI_aarch64_qemu-kvm-device-usb-host = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-device-usb-host-10.1.0-24.el10.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-device-usb-host;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-device-usb-host}"
SRC_URI[aarch64_qemu-kvm-device-usb-host.sha256sum] = "3636f8cc7bf749fcf10ebe010fac1a14842e37b801696ba05b3c7bdb58fee453"

URI_aarch64_qemu-kvm-device-usb-redirect = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-device-usb-redirect-10.1.0-24.el10.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-device-usb-redirect;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-device-usb-redirect}"
SRC_URI[aarch64_qemu-kvm-device-usb-redirect.sha256sum] = "7f9d58aa5283aa675f7558fb230bf198f07fa2371b4021f3f14e373728c0254f"

URI_aarch64_qemu-kvm-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-docs-10.1.0-24.el10.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-docs}"
SRC_URI[aarch64_qemu-kvm-docs.sha256sum] = "a94ef647697b36c78f667944d5a47f6febc2e4d6851e83d00eed430bf2ad8c39"

URI_aarch64_qemu-kvm-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-tools-10.1.0-24.el10.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-tools}"
SRC_URI[aarch64_qemu-kvm-tools.sha256sum] = "8e922b2c36e9998453b8db4017a32a540e470ffde6c77306b0f6cf77929240a8"

URI_aarch64_qemu-kvm-ui-spice = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-ui-spice-10.1.0-24.el10.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-ui-spice;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-ui-spice}"
SRC_URI[aarch64_qemu-kvm-ui-spice.sha256sum] = "494a034812f0c8657931377a56c486c96f6564b2ca32887d2a6fa4b493486ab3"

URI_aarch64_qemu-pr-helper = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-pr-helper-10.1.0-24.el10.alma.1.aarch64.rpm;name=aarch64_qemu-pr-helper;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-pr-helper}"
SRC_URI[aarch64_qemu-pr-helper.sha256sum] = "e88918d75e39b1f619d33b61d8f0b0c85acc109202936606a52356bb838abe39"

RDEPENDS:qemu-guest-agent = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 liburing \
 numactl-libs \
 systemd \
 systemd-libs \
 "
RDEPENDS:qemu-img = " \
 glib2 \
 glibc \
 gnutls \
 libaio \
 libgcc \
 libselinux \
 liburing \
 libzstd \
 numactl-libs \
 zlib-ng-compat \
 "
RDEPENDS:qemu-kvm:x86_64_v2 = " \
 qemu-kvm-audio-pa \
 qemu-kvm-block-blkio \
 qemu-kvm-block-rbd \
 qemu-kvm-core \
 qemu-kvm-device-display-virtio-gpu \
 qemu-kvm-device-display-virtio-gpu-pci \
 qemu-kvm-device-display-virtio-vga \
 qemu-kvm-device-usb-host \
 qemu-kvm-device-usb-redirect \
 qemu-kvm-docs \
 qemu-kvm-tools \
 qemu-kvm-ui-egl-headless \
 qemu-kvm-ui-opengl \
 qemu-kvm-ui-spice \
 qemu-pr-helper \
 virtiofsd \
"
RDEPENDS:qemu-kvm:aarch64 = " \
 qemu-kvm-audio-pa \
 qemu-kvm-block-blkio \
 qemu-kvm-block-rbd \
 qemu-kvm-core \
 qemu-kvm-device-display-virtio-gpu \
 qemu-kvm-device-display-virtio-gpu-pci \
 qemu-kvm-device-usb-host \
 qemu-kvm-device-usb-redirect \
 qemu-kvm-docs \
 qemu-kvm-tools \
 qemu-kvm-ui-spice \
 qemu-pr-helper \
 virtiofsd \
"
RDEPENDS:qemu-kvm-audio-pa = " \
 glibc \
 pulseaudio-libs \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-block-blkio = " \
 glibc \
 libblkio \
 libgcc \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-block-curl = " \
 glibc \
 libgcc \
 qemu-kvm-common \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:qemu-kvm-block-rbd = " \
 glibc \
 libgcc \
 librados2 \
 librbd1 \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-common:x86_64_v2 = " \
 bash \
 glib2 \
 glibc \
 glibc-common \
 gnutls \
 ipxe-roms-qemu \
 libcap-ng \
 libgcc \
 seabios-bin \
 seavgabios-bin \
 shadow-utils \
 systemd \
"
RDEPENDS:qemu-kvm-common:aarch64 = " \
 bash \
 glib2 \
 glibc \
 glibc-common \
 gnutls \
 libcap-ng \
 libgcc \
 shadow-utils \
 systemd \
"
RDEPENDS:qemu-kvm-core:x86_64_v2 = " \
 capstone \
 cyrus-sasl-lib \
 edk2-ovmf \
 glib2 \
 glibc \
 gnutls \
 keyutils-libs \
 libaio \
 libfdt \
 libgcc \
 libpng \
 libseccomp \
 libslirp \
 liburing \
 libusb1 \
 libzstd \
 lzo \
 numactl-libs \
 pixman \
 qemu-img \
 qemu-kvm-common \
 snappy \
 zlib-ng-compat \
"
RDEPENDS:qemu-kvm-core:aarch64 = " \
 capstone \
 cyrus-sasl-lib \
 edk2-aarch64 \
 glib2 \
 glibc \
 gnutls \
 keyutils-libs \
 libaio \
 libfdt \
 libgcc \
 libpng \
 libseccomp \
 libslirp \
 liburing \
 libusb1 \
 libzstd \
 lzo \
 numactl-libs \
 pixman \
 qemu-img \
 qemu-kvm-common \
 snappy \
 zlib-ng-compat \
"
RDEPENDS:qemu-kvm-device-display-virtio-gpu = " \
 glibc \
 pixman \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-device-display-virtio-gpu-pci = " \
 glibc \
 qemu-kvm-common \
 qemu-kvm-device-display-virtio-gpu \
 "
RDEPENDS:qemu-kvm-device-display-virtio-vga = " \
 glibc \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-device-usb-host = " \
 glibc \
 libusb1 \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-device-usb-redirect = " \
 glibc \
 libgcc \
 qemu-kvm-common \
 usbredir \
 "
RDEPENDS:qemu-kvm-docs = " \
 "
RDEPENDS:qemu-kvm-tools = " \
 glib2 \
 glibc \
 libgcc \
 libxkbcommon \
 python3 \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:qemu-kvm-ui-egl-headless = " \
 glibc \
 libepoxy \
 pixman \
 qemu-kvm-common \
 qemu-kvm-ui-opengl \
 "
RDEPENDS:qemu-kvm-ui-opengl = " \
 glibc \
 libepoxy \
 libgcc \
 mesa-dri-drivers \
 mesa-libEGL \
 mesa-libGL \
 mesa-libgbm \
 pixman \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-ui-spice:x86_64_v2 = " \
 glibc \
 libgcc \
 pixman \
 qemu-kvm-common \
 qemu-kvm-ui-opengl \
 spice-server \
"
RDEPENDS:qemu-kvm-ui-spice:aarch64 = " \
 glibc \
 libgcc \
 pixman \
 qemu-kvm-common \
 spice-server \
"
RDEPENDS:qemu-pr-helper = " \
 device-mapper-multipath-libs \
 glib2 \
 glibc \
 gnutls \
 libcap-ng \
 libgcc \
 liburing \
 numactl-libs \
 systemd-libs \
 "
