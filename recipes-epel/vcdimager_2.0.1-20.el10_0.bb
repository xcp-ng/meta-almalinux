# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vcdimager"
PV = "2.0.1"
PR = "20.el10_0"
PACKAGES = " \
 vcdimager \
 vcdimager-devel \
 vcdimager-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vcdimager-2.0.1-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6056c89ce8032373dc4f40ce0fc54b90753be2751235b68a3f06fdceb7fb3e69"

URI_x86_64_v2_vcdimager = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vcdimager-2.0.1-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vcdimager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vcdimager}"
SRC_URI[x86_64_v2_vcdimager.sha256sum] = "98c9411926f78734ac9b591d28395f38b0ce53b633ca2995c1a26e42dd341fa6"

URI_x86_64_v2_vcdimager-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vcdimager-devel-2.0.1-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vcdimager-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vcdimager-devel}"
SRC_URI[x86_64_v2_vcdimager-devel.sha256sum] = "948152edfa77ffb767ec5e200b7fbcd5387cb96c52f7d464eae7f6ad6042a20b"

URI_x86_64_v2_vcdimager-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vcdimager-libs-2.0.1-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vcdimager-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vcdimager-libs}"
SRC_URI[x86_64_v2_vcdimager-libs.sha256sum] = "59b2f6608aa3bd4d6ea9154366720e97849fa8e5f3c53ce63ce1a2e6416c296c"

URI_aarch64_vcdimager = "${EPEL_MIRROR}/aarch64/Packages/v/vcdimager-2.0.1-20.el10_0.aarch64.rpm;name=aarch64_vcdimager;unpack=0"
SRC_URI:append = " ${URI_aarch64_vcdimager}"
SRC_URI[aarch64_vcdimager.sha256sum] = "b49164c9bcc97d78e67ef4f7478811a1a4f2c1077ab5f7d03eb339a19e0b026c"

URI_aarch64_vcdimager-devel = "${EPEL_MIRROR}/aarch64/Packages/v/vcdimager-devel-2.0.1-20.el10_0.aarch64.rpm;name=aarch64_vcdimager-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vcdimager-devel}"
SRC_URI[aarch64_vcdimager-devel.sha256sum] = "426e67ab0a24bee71bddd289c34dc310de585ba8c4b73ad0ac6873074be19690"

URI_aarch64_vcdimager-libs = "${EPEL_MIRROR}/aarch64/Packages/v/vcdimager-libs-2.0.1-20.el10_0.aarch64.rpm;name=aarch64_vcdimager-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_vcdimager-libs}"
SRC_URI[aarch64_vcdimager-libs.sha256sum] = "33dc0f8af5f312b5be87fb7ec9779e158eada9cbbd9920c1c0732621af9c21be"

RDEPENDS:vcdimager = " \
 glibc \
 libcdio \
 libxml2 \
 popt \
 vcdimager-libs \
 "
RDEPENDS:vcdimager-devel = " \
 libcdio-devel \
 pkgconf-pkg-config \
 vcdimager-libs \
 "
RDEPENDS:vcdimager-libs = " \
 glibc \
 libcdio \
 "
