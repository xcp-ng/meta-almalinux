# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-zig"
PV = "1.1.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-tree-sitter-zig+default-devel \
 rust-tree-sitter-zig-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-zig-1.1.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "60ab8d773f5031a4cd0a35537ce091245f19854a3e6c2fcbc40af0c2f5577bad"

URI_x86_64_v2_rust-tree-sitter-zig+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-zig+default-devel-1.1.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-zig+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-zig+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-zig+default-devel.sha256sum] = "3736bc72efadebf5b2e0ca7e7da041e7d4e43cf75f5b271876b414106cf9729d"

URI_x86_64_v2_rust-tree-sitter-zig-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-zig-devel-1.1.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-zig-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-zig-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-zig-devel.sha256sum] = "e1cd3c4fd4b8c4ae38cc710c6744eb0277a92f557ffb741d3e212cb738813965"

URI_aarch64_rust-tree-sitter-zig+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-zig+default-devel-1.1.2-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-zig+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-zig+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-zig+default-devel.sha256sum] = "3dff7cce7b5ab680ffdda4b3912aa58e02ad3309cdc45a3fefbca09299342437"

URI_aarch64_rust-tree-sitter-zig-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-zig-devel-1.1.2-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-zig-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-zig-devel}"
SRC_URI[aarch64_rust-tree-sitter-zig-devel.sha256sum] = "e6194985e76aeaee4502a9f7650066b10266aa59d7b0a14525ab8074bc2413da"

RDEPENDS:rust-tree-sitter-zig+default-devel = " \
 cargo \
 rust-tree-sitter-zig-devel \
 "
RDEPENDS:rust-tree-sitter-zig-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
