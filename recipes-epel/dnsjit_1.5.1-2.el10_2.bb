# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnsjit"
PV = "1.5.1"
PR = "2.el10_2"
PACKAGES = " \
 dnsjit \
 dnsjit-devel \
 dnsjit-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dnsjit-1.5.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "efd612cbce27c912905b15bd21f917655d546de51ce1b0f2a21274501a07391b"

URI_x86_64_v2_dnsjit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dnsjit-1.5.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dnsjit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnsjit}"
SRC_URI[x86_64_v2_dnsjit.sha256sum] = "77928e7388628c5c433229c89e66983a581f19d64b4e4503f4e6dad874275b0e"

URI_x86_64_v2_dnsjit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dnsjit-devel-1.5.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dnsjit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnsjit-devel}"
SRC_URI[x86_64_v2_dnsjit-devel.sha256sum] = "e3f6b60166364f20ac1c4a4c542342f67d62ab3d0160647dd0076b0720afbe63"

URI_x86_64_v2_dnsjit-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dnsjit-examples-1.5.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_dnsjit-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnsjit-examples}"
SRC_URI[x86_64_v2_dnsjit-examples.sha256sum] = "ef7973f9001fea814aabe4e2940de9581378aaab4c365dc03b35c8dde348af51"

URI_aarch64_dnsjit = "${EPEL_MIRROR}/aarch64/Packages/d/dnsjit-1.5.1-2.el10_2.aarch64.rpm;name=aarch64_dnsjit;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnsjit}"
SRC_URI[aarch64_dnsjit.sha256sum] = "81fdf5f2e9cd707bf989d49d24eafa0e6e33f74d25b125abb6aa87aa60dac216"

URI_aarch64_dnsjit-devel = "${EPEL_MIRROR}/aarch64/Packages/d/dnsjit-devel-1.5.1-2.el10_2.aarch64.rpm;name=aarch64_dnsjit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnsjit-devel}"
SRC_URI[aarch64_dnsjit-devel.sha256sum] = "87f6dc784456c6a7f717d211195bee94490ba0ac39494467cc49677cd9b0bebc"

URI_aarch64_dnsjit-examples = "${EPEL_MIRROR}/aarch64/Packages/d/dnsjit-examples-1.5.1-2.el10_2.noarch.rpm;name=aarch64_dnsjit-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnsjit-examples}"
SRC_URI[aarch64_dnsjit-examples.sha256sum] = "6818bfddb6670d3ec643cc7f2e81a18e2fe4c56c57cddd49d004943057283154"

RDEPENDS:dnsjit = " \
 glibc \
 gnutls \
 libgcc \
 libpcap \
 libzstd \
 lmdb-libs \
 luajit \
 lz4-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:dnsjit-devel = " \
 ck-devel \
 dnsjit \
 gnutls-devel \
 libpcap-devel \
 libzstd-devel \
 lmdb-devel \
 luajit-devel \
 lz4-devel \
 xz-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:dnsjit-examples = " \
 dnsjit \
 "
