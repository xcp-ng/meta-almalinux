# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-event-listener"
PV = "5.4.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-event-listener+critical-section-devel \
 rust-event-listener+default-devel \
 rust-event-listener+parking-devel \
 rust-event-listener+portable-atomic-devel \
 rust-event-listener+portable-atomic-util-devel \
 rust-event-listener+portable_atomic_crate-devel \
 rust-event-listener+std-devel \
 rust-event-listener-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-event-listener-5.4.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "741a8abfbae8918dd8a2b276bbfdab071a9e190015b69a9a26fb8bb132b588ad"

URI_x86_64_v2_rust-event-listener+critical-section-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener+critical-section-devel-5.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener+critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener+critical-section-devel}"
SRC_URI[x86_64_v2_rust-event-listener+critical-section-devel.sha256sum] = "2da1f67c4e8349c3eb93f7f9c2a281b0cf0045ff0d2f398a40d79ddda27bf816"

URI_x86_64_v2_rust-event-listener+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener+default-devel-5.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener+default-devel}"
SRC_URI[x86_64_v2_rust-event-listener+default-devel.sha256sum] = "f3aab09d3bd47bd4be79c5c51aee3f02538c46611520de200baa3a6c7e5e389a"

URI_x86_64_v2_rust-event-listener+parking-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener+parking-devel-5.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener+parking-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener+parking-devel}"
SRC_URI[x86_64_v2_rust-event-listener+parking-devel.sha256sum] = "b8ec172977f87d6a5081b785ce657f65978529199bd06485c1d07f5eb16da826"

URI_x86_64_v2_rust-event-listener+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener+portable-atomic-devel-5.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-event-listener+portable-atomic-devel.sha256sum] = "399acb697f489fbf6146854921330c3ee9f527a83d7f3b4d07e142fc6e226b2e"

URI_x86_64_v2_rust-event-listener+portable-atomic-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener+portable-atomic-util-devel-5.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener+portable-atomic-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener+portable-atomic-util-devel}"
SRC_URI[x86_64_v2_rust-event-listener+portable-atomic-util-devel.sha256sum] = "4929f38d39ecdebe0597c6c8bf224492ff5f09d8c0da7d36e170a183d80f5401"

URI_x86_64_v2_rust-event-listener+portable_atomic_crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener+portable_atomic_crate-devel-5.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener+portable_atomic_crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener+portable_atomic_crate-devel}"
SRC_URI[x86_64_v2_rust-event-listener+portable_atomic_crate-devel.sha256sum] = "0b0ddc9dda87e95d7e469b519b963a5702ea87fa23096f253fe54d8cd6473554"

URI_x86_64_v2_rust-event-listener+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener+std-devel-5.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener+std-devel}"
SRC_URI[x86_64_v2_rust-event-listener+std-devel.sha256sum] = "5add0254f0600e5195f86ef20f9626262be25692d5075a361a665650b203d3f3"

URI_x86_64_v2_rust-event-listener-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener-devel-5.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener-devel}"
SRC_URI[x86_64_v2_rust-event-listener-devel.sha256sum] = "6797700d22e0d2dae9636e7677ce62ebc597d4b0d899aea138251a4ae8585a9c"

URI_aarch64_rust-event-listener+critical-section-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener+critical-section-devel-5.4.1-1.el10_1.noarch.rpm;name=aarch64_rust-event-listener+critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener+critical-section-devel}"
SRC_URI[aarch64_rust-event-listener+critical-section-devel.sha256sum] = "2167fc265b7599961bcb151b77cf8dd42f12ee0429f3111ab205fe5cba684939"

URI_aarch64_rust-event-listener+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener+default-devel-5.4.1-1.el10_1.noarch.rpm;name=aarch64_rust-event-listener+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener+default-devel}"
SRC_URI[aarch64_rust-event-listener+default-devel.sha256sum] = "7fc71febcadee30483d46a30037118011b13d71171f870c9d590843be0138ae9"

URI_aarch64_rust-event-listener+parking-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener+parking-devel-5.4.1-1.el10_1.noarch.rpm;name=aarch64_rust-event-listener+parking-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener+parking-devel}"
SRC_URI[aarch64_rust-event-listener+parking-devel.sha256sum] = "dc49477ab2ecb51e7b79434386fa768cab012a15fe5fa1174827393359aa27eb"

URI_aarch64_rust-event-listener+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener+portable-atomic-devel-5.4.1-1.el10_1.noarch.rpm;name=aarch64_rust-event-listener+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener+portable-atomic-devel}"
SRC_URI[aarch64_rust-event-listener+portable-atomic-devel.sha256sum] = "a98e3912899faf487cffc57944d652b85cfc42d45b89f20d1bec6e43234f18a7"

URI_aarch64_rust-event-listener+portable-atomic-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener+portable-atomic-util-devel-5.4.1-1.el10_1.noarch.rpm;name=aarch64_rust-event-listener+portable-atomic-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener+portable-atomic-util-devel}"
SRC_URI[aarch64_rust-event-listener+portable-atomic-util-devel.sha256sum] = "cde99765ed6b619775827f717c60486fbe7162118d75568c7a81551dee00cbe9"

URI_aarch64_rust-event-listener+portable_atomic_crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener+portable_atomic_crate-devel-5.4.1-1.el10_1.noarch.rpm;name=aarch64_rust-event-listener+portable_atomic_crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener+portable_atomic_crate-devel}"
SRC_URI[aarch64_rust-event-listener+portable_atomic_crate-devel.sha256sum] = "b4fbf14105118a8e95ab7562709a62c3c6a2f35e65f10f3462225c28f3c7363b"

URI_aarch64_rust-event-listener+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener+std-devel-5.4.1-1.el10_1.noarch.rpm;name=aarch64_rust-event-listener+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener+std-devel}"
SRC_URI[aarch64_rust-event-listener+std-devel.sha256sum] = "2788677d147e431cbb08fb42ef5faac73e722dc756fa484badf935b90cd8a6b5"

URI_aarch64_rust-event-listener-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener-devel-5.4.1-1.el10_1.noarch.rpm;name=aarch64_rust-event-listener-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener-devel}"
SRC_URI[aarch64_rust-event-listener-devel.sha256sum] = "5f1a8b1bf27a012f9defd1c4dd1e53c28e7c3a12116115a67e9167c69f696157"

RDEPENDS:rust-event-listener+critical-section-devel = " \
 cargo \
 rust-critical-section-devel \
 rust-event-listener-devel \
 "
RDEPENDS:rust-event-listener+default-devel = " \
 cargo \
 rust-event-listener+std-devel \
 rust-event-listener-devel \
 "
RDEPENDS:rust-event-listener+parking-devel = " \
 cargo \
 rust-event-listener-devel \
 rust-parking+default-devel \
 "
RDEPENDS:rust-event-listener+portable-atomic-devel = " \
 cargo \
 rust-concurrent-queue+portable-atomic-devel \
 rust-event-listener+portable-atomic-util-devel \
 rust-event-listener+portable_atomic_crate-devel \
 rust-event-listener-devel \
 "
RDEPENDS:rust-event-listener+portable-atomic-util-devel = " \
 cargo \
 rust-event-listener-devel \
 rust-portable-atomic-util+alloc-devel \
 rust-portable-atomic-util-devel \
 "
RDEPENDS:rust-event-listener+portable_atomic_crate-devel = " \
 cargo \
 rust-event-listener-devel \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-event-listener+std-devel = " \
 cargo \
 rust-concurrent-queue+std-devel \
 rust-event-listener+parking-devel \
 rust-event-listener-devel \
 "
RDEPENDS:rust-event-listener-devel = " \
 cargo \
 rust \
 rust-concurrent-queue-devel \
 rust-pin-project-lite+default-devel \
 "
