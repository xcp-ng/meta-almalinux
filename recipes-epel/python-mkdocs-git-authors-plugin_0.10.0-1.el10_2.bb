# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-mkdocs-git-authors-plugin"
PV = "0.10.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-mkdocs-git-authors-plugin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-mkdocs-git-authors-plugin-0.10.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b1d13e0476de8011eb624ce8769360237f21b31834e7abc0ffd932e9bf795d74"

URI_x86_64_v2_python3-mkdocs-git-authors-plugin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mkdocs-git-authors-plugin-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mkdocs-git-authors-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mkdocs-git-authors-plugin}"
SRC_URI[x86_64_v2_python3-mkdocs-git-authors-plugin.sha256sum] = "6bb8dc97fed1d173c9a97aef1c77bc3b6dba3031fcb41b36399ffcad68ee232f"

URI_aarch64_python3-mkdocs-git-authors-plugin = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mkdocs-git-authors-plugin-0.10.0-1.el10_2.noarch.rpm;name=aarch64_python3-mkdocs-git-authors-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mkdocs-git-authors-plugin}"
SRC_URI[aarch64_python3-mkdocs-git-authors-plugin.sha256sum] = "1ff64951463d5ab2973df1720c7a0168ef1c8cab97e5edc0cef74744837e87e3"

RDEPENDS:python3-mkdocs-git-authors-plugin = " \
 mkdocs \
 python3 \
 "
