# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gpsd-epel"
PE = "1"
PV = "3.25"
PR = "17.el10_0"
PACKAGES = " \
 gpsd-devel \
 gpsd-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gpsd-epel-3.25-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "baf6021e6c7187655acfa2ad9bfb77e3c36b1189984611a796ae702735c802bd"

URI_x86_64_v2_gpsd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gpsd-devel-3.25-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gpsd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpsd-devel}"
SRC_URI[x86_64_v2_gpsd-devel.sha256sum] = "9bcc93c8313a1d0d0da27b1bca69269fd48dae35c4b541e0bbce1937b75114ae"

URI_x86_64_v2_gpsd-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gpsd-libs-3.25-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gpsd-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpsd-libs}"
SRC_URI[x86_64_v2_gpsd-libs.sha256sum] = "5214ca0011bd3b7ec2d39b3790110d4ce1fdd98f4214c6fec398658ef409f4fe"

URI_aarch64_gpsd-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gpsd-devel-3.25-17.el10_0.aarch64.rpm;name=aarch64_gpsd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpsd-devel}"
SRC_URI[aarch64_gpsd-devel.sha256sum] = "58ac57bd345dc2d1f66c148136bf611ab00a2ac516be84ea9d7a7d9514a0ca21"

URI_aarch64_gpsd-libs = "${EPEL_MIRROR}/aarch64/Packages/g/gpsd-libs-3.25-17.el10_0.aarch64.rpm;name=aarch64_gpsd-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpsd-libs}"
SRC_URI[aarch64_gpsd-libs.sha256sum] = "f385bb59d1e7e3ebe722e5ef3f514fdc33fcbfef266e94dda89a977bf33a3623"

RDEPENDS:gpsd-devel = " \
 gpsd-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:gpsd-libs:x86_64_v2 = " \
 dbus-libs \
 glibc \
 libstdc++ \
"
RDEPENDS:gpsd-libs:aarch64 = " \
 dbus-libs \
 glibc \
"
