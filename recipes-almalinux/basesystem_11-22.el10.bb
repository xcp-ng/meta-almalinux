# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "basesystem"
PV = "11"
PR = "22.el10"
PACKAGES = " \
 basesystem \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/basesystem-11-22.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f070b25ac356ab7d10f1309f5cc966d1e9cf1ffd619d149cbafcb970418e42b"

URI_x86_64_v2_basesystem = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/basesystem-11-22.el10.noarch.rpm;name=x86_64_v2_basesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_basesystem}"
SRC_URI[x86_64_v2_basesystem.sha256sum] = "ce290f8c5998442e68cbc7e2351f43c2d5bb05a9d109058fc457487b9c267796"

URI_aarch64_basesystem = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/basesystem-11-22.el10.noarch.rpm;name=aarch64_basesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_basesystem}"
SRC_URI[aarch64_basesystem.sha256sum] = "ce290f8c5998442e68cbc7e2351f43c2d5bb05a9d109058fc457487b9c267796"

RDEPENDS:basesystem = " \
 filesystem \
 setup \
 "
