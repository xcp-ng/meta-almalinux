# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "granatier"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 granatier \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/granatier-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f1c6d48a4bdcf758de5d3089b01be507310dd2b499bf615000c5e6f253d7d03b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/granatier-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_granatier;unpack=0"
SRC_URI[x86_64_v2_granatier.sha256sum] = "26e4ebf8a0767777bd03a263edb4f98982c2b7c4032e6a3fc6c949b5fad07ba9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/granatier-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_granatier;unpack=0"
SRC_URI[aarch64_granatier.sha256sum] = "fae5277d4dcaf8030e8c9a5c30150b8b3a757d0aa4f07522b90245a12384ca8a"

RDEPENDS:granatier = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
