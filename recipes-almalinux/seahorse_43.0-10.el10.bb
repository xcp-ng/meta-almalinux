# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "seahorse"
PV = "43.0"
PR = "10.el10"
PACKAGES = " \
 seahorse \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/seahorse-43.0-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e48d7af06090634f868f25b5e13c1b6c3e327cf3ae7142447035826cc5963676"

URI_x86_64_v2_seahorse = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/seahorse-43.0-10.el10.x86_64_v2.rpm;name=x86_64_v2_seahorse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_seahorse}"
SRC_URI[x86_64_v2_seahorse.sha256sum] = "426aa644b1a7abcf4e4b88ec2f3d16fc6e4163b49af87f1651c03ad3fe8937db"

URI_aarch64_seahorse = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/seahorse-43.0-10.el10.aarch64.rpm;name=aarch64_seahorse;unpack=0"
SRC_URI:append = " ${URI_aarch64_seahorse}"
SRC_URI[aarch64_seahorse.sha256sum] = "ac6a4d3b2f9f8c96d21c256b6a98cb2e53a7383682f6051a6666a21580a51c06"

RDEPENDS:seahorse = " \
 gcr3 \
 gcr3-base \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gpgme \
 gtk3 \
 libgcc \
 libhandy \
 libpwquality \
 libsecret \
 libsoup3 \
 openldap \
 pinentry-gnome3 \
 "
