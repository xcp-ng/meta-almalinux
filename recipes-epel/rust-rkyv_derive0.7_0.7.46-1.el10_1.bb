# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rkyv_derive0.7"
PV = "0.7.46"
PR = "1.el10_1"
PACKAGES = " \
 rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel \
 rust-rkyv_derive0.7+archive_be-devel \
 rust-rkyv_derive0.7+archive_le-devel \
 rust-rkyv_derive0.7+copy-devel \
 rust-rkyv_derive0.7+default-devel \
 rust-rkyv_derive0.7+strict-devel \
 rust-rkyv_derive0.7-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rkyv_derive0.7-0.7.46-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1263f36159f1f942e88f745a115870440d6ba6c8d679f4bb5356e95d7cb5f603"

URI_x86_64_v2_rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel-0.7.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel}"
SRC_URI[x86_64_v2_rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel.sha256sum] = "39ecb5e110c6af1977e65afc7c23aaa551ba31ed3fdc8ebe9be3fc142b2b4562"

URI_x86_64_v2_rust-rkyv_derive0.7+archive_be-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv_derive0.7+archive_be-devel-0.7.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv_derive0.7+archive_be-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv_derive0.7+archive_be-devel}"
SRC_URI[x86_64_v2_rust-rkyv_derive0.7+archive_be-devel.sha256sum] = "c6fa2f80b030c3271777b6fdd79d811b41ff99c6eda306bb822cd0a8fef9a71b"

URI_x86_64_v2_rust-rkyv_derive0.7+archive_le-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv_derive0.7+archive_le-devel-0.7.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv_derive0.7+archive_le-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv_derive0.7+archive_le-devel}"
SRC_URI[x86_64_v2_rust-rkyv_derive0.7+archive_le-devel.sha256sum] = "4e9d126123048015bc01ad37ad2c52653eab1d23c2c644bc6f1f4a3b4cf32ea7"

URI_x86_64_v2_rust-rkyv_derive0.7+copy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv_derive0.7+copy-devel-0.7.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv_derive0.7+copy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv_derive0.7+copy-devel}"
SRC_URI[x86_64_v2_rust-rkyv_derive0.7+copy-devel.sha256sum] = "f7dfb576e3ba6aff234cf67bc7b492c029274ab74a14b2517c44f8cfc31d219f"

URI_x86_64_v2_rust-rkyv_derive0.7+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv_derive0.7+default-devel-0.7.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv_derive0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv_derive0.7+default-devel}"
SRC_URI[x86_64_v2_rust-rkyv_derive0.7+default-devel.sha256sum] = "0319ba947317c0508d18a69d6053c68843281a023262b15f375c0854bf6075cc"

URI_x86_64_v2_rust-rkyv_derive0.7+strict-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv_derive0.7+strict-devel-0.7.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv_derive0.7+strict-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv_derive0.7+strict-devel}"
SRC_URI[x86_64_v2_rust-rkyv_derive0.7+strict-devel.sha256sum] = "b0f32e6293e5cf159ae3dfc1eda865d8d8cbf436926cfe170e008208e53ef4e0"

URI_x86_64_v2_rust-rkyv_derive0.7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv_derive0.7-devel-0.7.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv_derive0.7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv_derive0.7-devel}"
SRC_URI[x86_64_v2_rust-rkyv_derive0.7-devel.sha256sum] = "be6c30cee9b926b039c3368b4831d7d76ca518d00ea4f12aaaa304de900efd81"

URI_aarch64_rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel-0.7.46-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel}"
SRC_URI[aarch64_rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel.sha256sum] = "4d36d2e48fb7c1dfd464086eaaf681f586bb4002001c079a5281689bddbf3bf0"

URI_aarch64_rust-rkyv_derive0.7+archive_be-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv_derive0.7+archive_be-devel-0.7.46-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv_derive0.7+archive_be-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv_derive0.7+archive_be-devel}"
SRC_URI[aarch64_rust-rkyv_derive0.7+archive_be-devel.sha256sum] = "442711352dde7791cfc216bc4b198b2a2eff04df8c4bf1d2d2e23ca02d8b8843"

URI_aarch64_rust-rkyv_derive0.7+archive_le-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv_derive0.7+archive_le-devel-0.7.46-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv_derive0.7+archive_le-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv_derive0.7+archive_le-devel}"
SRC_URI[aarch64_rust-rkyv_derive0.7+archive_le-devel.sha256sum] = "2663756308e4c92131ef6d4cc7af97a5320af535edd9222d248abb6b197e4916"

URI_aarch64_rust-rkyv_derive0.7+copy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv_derive0.7+copy-devel-0.7.46-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv_derive0.7+copy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv_derive0.7+copy-devel}"
SRC_URI[aarch64_rust-rkyv_derive0.7+copy-devel.sha256sum] = "8447c34a17dba745445965e2c5a6ad1aadd59d0c776b5695646a5d64212fdda1"

URI_aarch64_rust-rkyv_derive0.7+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv_derive0.7+default-devel-0.7.46-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv_derive0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv_derive0.7+default-devel}"
SRC_URI[aarch64_rust-rkyv_derive0.7+default-devel.sha256sum] = "4acdac706bd9288a9c1dca58f44ad91420efd640dcd6f043b6b1c5f271d7dbb0"

URI_aarch64_rust-rkyv_derive0.7+strict-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv_derive0.7+strict-devel-0.7.46-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv_derive0.7+strict-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv_derive0.7+strict-devel}"
SRC_URI[aarch64_rust-rkyv_derive0.7+strict-devel.sha256sum] = "96559c0da4da34dfcdee49bd9bcffba03d60dffd45bdd4bcbba7142b5424b761"

URI_aarch64_rust-rkyv_derive0.7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv_derive0.7-devel-0.7.46-1.el10_1.noarch.rpm;name=aarch64_rust-rkyv_derive0.7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv_derive0.7-devel}"
SRC_URI[aarch64_rust-rkyv_derive0.7-devel.sha256sum] = "582600ee7d01504fd18360f7b901c913dd6bd53756ba86e79f6b982e8f9f8cb7"

RDEPENDS:rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel = " \
 cargo \
 rust-rkyv_derive0.7-devel \
 "
RDEPENDS:rust-rkyv_derive0.7+archive_be-devel = " \
 cargo \
 rust-rkyv_derive0.7-devel \
 "
RDEPENDS:rust-rkyv_derive0.7+archive_le-devel = " \
 cargo \
 rust-rkyv_derive0.7-devel \
 "
RDEPENDS:rust-rkyv_derive0.7+copy-devel = " \
 cargo \
 rust-rkyv_derive0.7-devel \
 "
RDEPENDS:rust-rkyv_derive0.7+default-devel = " \
 cargo \
 rust-rkyv_derive0.7-devel \
 "
RDEPENDS:rust-rkyv_derive0.7+strict-devel = " \
 cargo \
 rust-rkyv_derive0.7-devel \
 "
RDEPENDS:rust-rkyv_derive0.7-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn1+default-devel \
 "
