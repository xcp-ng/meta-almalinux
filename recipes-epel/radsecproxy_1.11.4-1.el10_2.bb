# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "radsecproxy"
PV = "1.11.4"
PR = "1.el10_2"
PACKAGES = " \
 radsecproxy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/radsecproxy-1.11.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a5874632cbc349de4b116afa43ea5fb79003078e59ba441f87d27672d87d28d9"

URI_x86_64_v2_radsecproxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radsecproxy-1.11.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_radsecproxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_radsecproxy}"
SRC_URI[x86_64_v2_radsecproxy.sha256sum] = "5af73691a499aa115c0f4bfe699b140b932229d6b0feed3198bfa2f67af169b7"

URI_aarch64_radsecproxy = "${EPEL_MIRROR}/aarch64/Packages/r/radsecproxy-1.11.4-1.el10_2.aarch64.rpm;name=aarch64_radsecproxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_radsecproxy}"
SRC_URI[aarch64_radsecproxy.sha256sum] = "6af64f37d1e8387550cbe412d98d73f53b7ff0b28b17a7eccd6c56c0171ec4fc"

RDEPENDS:radsecproxy = " \
 bash \
 glibc \
 logrotate \
 nettle \
 openssl-libs \
 shadow-utils \
 systemd \
 "
