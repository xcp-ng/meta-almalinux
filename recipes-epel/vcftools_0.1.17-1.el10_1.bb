# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vcftools"
PV = "0.1.17"
PR = "1.el10_1"
PACKAGES = " \
 vcftools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vcftools-0.1.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "db49a43cdf753cb79b6f8e6a728d5590de9d61bd831aec47c9cc213d85eea871"

URI_x86_64_v2_vcftools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vcftools-0.1.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vcftools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vcftools}"
SRC_URI[x86_64_v2_vcftools.sha256sum] = "c8a4c917513e1441ef11303f63d3a4ead27f62d56a94f39551853ce6f0ed7dd5"

URI_aarch64_vcftools = "${EPEL_MIRROR}/aarch64/Packages/v/vcftools-0.1.17-1.el10_1.aarch64.rpm;name=aarch64_vcftools;unpack=0"
SRC_URI:append = " ${URI_aarch64_vcftools}"
SRC_URI[aarch64_vcftools.sha256sum] = "8f8757397c36f6b9a2e3f30f26d188e2bdeee3476ee7e7051e2ebff1c074a780"

RDEPENDS:vcftools = " \
 glibc \
 libgcc \
 libstdc++ \
 perl-Carp \
 perl-Data-Dumper \
 perl-Exporter \
 perl-FindBin \
 perl-IO \
 perl-IPC-Open3 \
 perl-POSIX \
 perl-Scalar-List-Utils \
 perl-base \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-vars \
 vcftools \
 zlib-ng-compat \
 "
