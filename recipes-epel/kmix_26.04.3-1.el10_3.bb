# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmix"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kmix \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmix-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9b9bb2f89d3a9cc48c2b29e2c3b021b210a8a272bbac659b0e97cfc55590b4f4"

URI_x86_64_v2_kmix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmix-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmix}"
SRC_URI[x86_64_v2_kmix.sha256sum] = "ffbffc067cc6dee3b6e62487a39bec153344dc6f33f879a931fb6af04cba5585"

URI_aarch64_kmix = "${EPEL_MIRROR}/aarch64/Packages/k/kmix-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kmix;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmix}"
SRC_URI[aarch64_kmix.sha256sum] = "678085d61450f42e5e61f4a7073d913cc2180c9312ecd813874df667c9287731"

RDEPENDS:kmix = " \
 alsa-lib \
 bash \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-knotifications \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-solid \
 libcanberra \
 libstdc++ \
 pulseaudio-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
