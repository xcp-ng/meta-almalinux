# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kjournald"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kjournald \
 kjournald-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kjournald-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e650b8d6fb113159573e1b5410426a45bea40a0b33a2bd6fb4143f53e209d13"

URI_x86_64_v2_kjournald = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kjournald-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kjournald;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kjournald}"
SRC_URI[x86_64_v2_kjournald.sha256sum] = "ec9db81e6c80e52fa64fe78f3c62a561c335bd84773a3be75e56b6708967a70c"

URI_x86_64_v2_kjournald-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kjournald-libs-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kjournald-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kjournald-libs}"
SRC_URI[x86_64_v2_kjournald-libs.sha256sum] = "3908889198e0e49b97b47d64f59980244b2eb4f82b7ecc26fca50ad35b4df12c"

URI_aarch64_kjournald = "${EPEL_MIRROR}/aarch64/Packages/k/kjournald-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kjournald;unpack=0"
SRC_URI:append = " ${URI_aarch64_kjournald}"
SRC_URI[aarch64_kjournald.sha256sum] = "c255af3e68f4cfb4a858554ff70dc472c40536aa4a293a53f5ba15c9fb44a17e"

URI_aarch64_kjournald-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kjournald-libs-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kjournald-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kjournald-libs}"
SRC_URI[aarch64_kjournald-libs.sha256sum] = "d69adcc147cdb32afcd8ce9497d2e0ea8736ac6ea2c76f0f288b51b4d5f40375"

RDEPENDS:kjournald = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kirigami \
 kjournald-libs \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kjournald-libs = " \
 glibc \
 kf6-ki18n \
 kjournald \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 systemd-libs \
 "
