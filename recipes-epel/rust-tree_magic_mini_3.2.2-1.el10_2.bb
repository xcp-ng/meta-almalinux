# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree_magic_mini"
PV = "3.2.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-tree_magic_mini+default-devel \
 rust-tree_magic_mini+with-gpl-data-devel \
 rust-tree_magic_mini-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree_magic_mini-3.2.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c0ad2127d045ef1ca8f59be6213b3f0300a927da458cf0fd5f3d704a315c1ee"

URI_x86_64_v2_rust-tree_magic_mini+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree_magic_mini+default-devel-3.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree_magic_mini+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree_magic_mini+default-devel}"
SRC_URI[x86_64_v2_rust-tree_magic_mini+default-devel.sha256sum] = "a7109fadb974fb9b0ad08359c48fdc5c8cfbc3d5aa13dfff46bbf63aea99e37c"

URI_x86_64_v2_rust-tree_magic_mini+with-gpl-data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree_magic_mini+with-gpl-data-devel-3.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree_magic_mini+with-gpl-data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree_magic_mini+with-gpl-data-devel}"
SRC_URI[x86_64_v2_rust-tree_magic_mini+with-gpl-data-devel.sha256sum] = "742fd2af9663f77377360a127e99ffabb18df9161b433a18f31156209a4021bc"

URI_x86_64_v2_rust-tree_magic_mini-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree_magic_mini-devel-3.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree_magic_mini-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree_magic_mini-devel}"
SRC_URI[x86_64_v2_rust-tree_magic_mini-devel.sha256sum] = "bfcd6c331f1d7facc552f9103b066b3fab25a2ffa914a7e06f17cdb09d09b1ea"

URI_aarch64_rust-tree_magic_mini+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree_magic_mini+default-devel-3.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-tree_magic_mini+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree_magic_mini+default-devel}"
SRC_URI[aarch64_rust-tree_magic_mini+default-devel.sha256sum] = "bfe31e4005226b4f0631ee02929dc38ad84073fc78a065c371ebdc171a4a2db1"

URI_aarch64_rust-tree_magic_mini+with-gpl-data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree_magic_mini+with-gpl-data-devel-3.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-tree_magic_mini+with-gpl-data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree_magic_mini+with-gpl-data-devel}"
SRC_URI[aarch64_rust-tree_magic_mini+with-gpl-data-devel.sha256sum] = "7c43897222de5037910609566c4bd415495e9aaafd2479e6c349de4a801f2e41"

URI_aarch64_rust-tree_magic_mini-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree_magic_mini-devel-3.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-tree_magic_mini-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree_magic_mini-devel}"
SRC_URI[aarch64_rust-tree_magic_mini-devel.sha256sum] = "a51df0515d1746066104bab39c5146b59206118bd7db03c7d181cc9284625e92"

RDEPENDS:rust-tree_magic_mini+default-devel = " \
 cargo \
 rust-tree_magic_mini-devel \
 "
RDEPENDS:rust-tree_magic_mini+with-gpl-data-devel = " \
 cargo \
 rust-tree_magic_db+default-devel \
 rust-tree_magic_mini-devel \
 "
RDEPENDS:rust-tree_magic_mini-devel = " \
 cargo \
 rust \
 rust-memchr+default-devel \
 rust-nom+default-devel \
 rust-petgraph-devel \
 "
