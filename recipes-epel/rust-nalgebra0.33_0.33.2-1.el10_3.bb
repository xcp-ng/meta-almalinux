# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-nalgebra0.33"
PV = "0.33.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-nalgebra0.33+alloc-devel \
 rust-nalgebra0.33+arbitrary-devel \
 rust-nalgebra0.33+bytemuck-devel \
 rust-nalgebra0.33+compare-devel \
 rust-nalgebra0.33+convert-bytemuck-devel \
 rust-nalgebra0.33+convert-mint-devel \
 rust-nalgebra0.33+debug-devel \
 rust-nalgebra0.33+default-devel \
 rust-nalgebra0.33+io-devel \
 rust-nalgebra0.33+libm-devel \
 rust-nalgebra0.33+libm-force-devel \
 rust-nalgebra0.33+macros-devel \
 rust-nalgebra0.33+matrixcompare-core-devel \
 rust-nalgebra0.33+matrixmultiply-devel \
 rust-nalgebra0.33+mint-devel \
 rust-nalgebra0.33+nalgebra-macros-devel \
 rust-nalgebra0.33+pest-devel \
 rust-nalgebra0.33+pest_derive-devel \
 rust-nalgebra0.33+proptest-devel \
 rust-nalgebra0.33+proptest-support-devel \
 rust-nalgebra0.33+quickcheck-devel \
 rust-nalgebra0.33+rand-devel \
 rust-nalgebra0.33+rand-no-std-devel \
 rust-nalgebra0.33+rand-package-devel \
 rust-nalgebra0.33+rand_distr-devel \
 rust-nalgebra0.33+rayon-devel \
 rust-nalgebra0.33+serde-devel \
 rust-nalgebra0.33+serde-serialize-devel \
 rust-nalgebra0.33+serde-serialize-no-std-devel \
 rust-nalgebra0.33+slow-tests-devel \
 rust-nalgebra0.33+sparse-devel \
 rust-nalgebra0.33+std-devel \
 rust-nalgebra0.33-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-nalgebra0.33-0.33.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ba49628dcf3892afad53870966fd07daba01d640a2d93be2e8b10c6370e5953"

URI_x86_64_v2_rust-nalgebra0.33+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra0.33+alloc-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra0.33+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra0.33+alloc-devel}"
SRC_URI[x86_64_v2_rust-nalgebra0.33+alloc-devel.sha256sum] = "4eb89f82a0aff45625c4ac475afe17d885cf2539623486bb4b42419a9b55bd3f"

URI_x86_64_v2_rust-nalgebra0.33+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra0.33+arbitrary-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra0.33+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra0.33+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-nalgebra0.33+arbitrary-devel.sha256sum] = "ff960ff8fa60fab60771746ea4acd976cddfd986e0c3d1ea7361b7aeec565c0e"

URI_x86_64_v2_rust-nalgebra0.33+bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra0.33+bytemuck-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra0.33+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra0.33+bytemuck-devel}"
SRC_URI[x86_64_v2_rust-nalgebra0.33+bytemuck-devel.sha256sum] = "9e65b504d46efe36c206be68b6b7dbda123b836d62047cb089b05243fac0375d"

URI_x86_64_v2_rust-nalgebra0.33+compare-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra0.33+compare-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra0.33+compare-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra0.33+compare-devel}"
SRC_URI[x86_64_v2_rust-nalgebra0.33+compare-devel.sha256sum] = "57f07d84bb9614c461734e6d9f9a02b2d7127a0d55526ac50ac9c8ce6da64bfb"

URI_x86_64_v2_rust-nalgebra0.33+convert-bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra0.33+convert-bytemuck-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra0.33+convert-bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra0.33+convert-bytemuck-devel}"
SRC_URI[x86_64_v2_rust-nalgebra0.33+convert-bytemuck-devel.sha256sum] = "2020b68fe1cd680dee9c426bb70e06e87b2cd8d723cea08a611184e5e26739fd"

URI_x86_64_v2_rust-nalgebra0.33+convert-mint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra0.33+convert-mint-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra0.33+convert-mint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra0.33+convert-mint-devel}"
SRC_URI[x86_64_v2_rust-nalgebra0.33+convert-mint-devel.sha256sum] = "69dd79cb66045721780669348f76c8d5f689a92b2b115a3181747d8fbebcff01"

URI_x86_64_v2_rust-nalgebra0.33+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra0.33+debug-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra0.33+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra0.33+debug-devel}"
SRC_URI[x86_64_v2_rust-nalgebra0.33+debug-devel.sha256sum] = "5b39aaa864d82c36fa6101c9bcfff10304ced9bc8673e15af4409fed62ba4f58"

URI_x86_64_v2_rust-nalgebra0.33+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra0.33+default-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra0.33+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra0.33+default-devel}"
SRC_URI[x86_64_v2_rust-nalgebra0.33+default-devel.sha256sum] = "04ea098ff004edce655056bb9b737637317968f6d470f2b6ef719493776fc6da"

URI_x86_64_v2_rust-nalgebra0.33+io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra0.33+io-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra0.33+io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra0.33+io-devel}"
SRC_URI[x86_64_v2_rust-nalgebra0.33+io-devel.sha256sum] = "af0f23cd31acdfb1ef5d12edc9216b9f0b0566cd095c1d3fd220cd61c23ad1c5"

URI_x86_64_v2_rust-nalgebra0.33+libm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra0.33+libm-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra0.33+libm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra0.33+libm-devel}"
SRC_URI[x86_64_v2_rust-nalgebra0.33+libm-devel.sha256sum] = "2c43cb26aabdf9bd11553769001fdb62b8b4e8a7d04d4791ab394ebbdb706a9b"

URI_x86_64_v2_rust-nalgebra0.33+libm-force-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra0.33+libm-force-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra0.33+libm-force-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra0.33+libm-force-devel}"
SRC_URI[x86_64_v2_rust-nalgebra0.33+libm-force-devel.sha256sum] = "49f4566cc7240b713b0336c1d89484bd7f41daa251da125199bcdc4efa573b56"

URI_x86_64_v2_rust-nalgebra0.33+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra0.33+macros-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra0.33+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra0.33+macros-devel}"
SRC_URI[x86_64_v2_rust-nalgebra0.33+macros-devel.sha256sum] = "9b1847a83aef9c450b1f49d9604a290f067fdf3f47037d155c8ae7a471d041f0"

URI_x86_64_v2_rust-nalgebra0.33+matrixcompare-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra0.33+matrixcompare-core-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra0.33+matrixcompare-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra0.33+matrixcompare-core-devel}"
SRC_URI[x86_64_v2_rust-nalgebra0.33+matrixcompare-core-devel.sha256sum] = "8712a7085b39b159a29ad3bfdef59f271f8f22eac120d7232221db8d417a232f"

URI_x86_64_v2_rust-nalgebra0.33+matrixmultiply-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra0.33+matrixmultiply-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra0.33+matrixmultiply-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra0.33+matrixmultiply-devel}"
SRC_URI[x86_64_v2_rust-nalgebra0.33+matrixmultiply-devel.sha256sum] = "d4a9a85de673fbfc3731191aed512edfb2bed6f62093dca80d5d9618a4adb12a"

URI_x86_64_v2_rust-nalgebra0.33+mint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra0.33+mint-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra0.33+mint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra0.33+mint-devel}"
SRC_URI[x86_64_v2_rust-nalgebra0.33+mint-devel.sha256sum] = "bbe0de447be22525d4aa315bc7311fe90685db9870e29e0d177f5a63ec0ee20e"

URI_x86_64_v2_rust-nalgebra0.33+nalgebra-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra0.33+nalgebra-macros-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra0.33+nalgebra-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra0.33+nalgebra-macros-devel}"
SRC_URI[x86_64_v2_rust-nalgebra0.33+nalgebra-macros-devel.sha256sum] = "a371500e2b3c0a35ac221d31317dee2f9b978ac045ac7ab4ef04167e0c006f66"

URI_x86_64_v2_rust-nalgebra0.33+pest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra0.33+pest-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra0.33+pest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra0.33+pest-devel}"
SRC_URI[x86_64_v2_rust-nalgebra0.33+pest-devel.sha256sum] = "ed32089dde309a20067e28f5b87442e659d178f331d392af687234e8b434405c"

URI_x86_64_v2_rust-nalgebra0.33+pest_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra0.33+pest_derive-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra0.33+pest_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra0.33+pest_derive-devel}"
SRC_URI[x86_64_v2_rust-nalgebra0.33+pest_derive-devel.sha256sum] = "4904476c4792631dc230f99faf736f67a7a04e92db072adb6f7e26ef65b60137"

URI_x86_64_v2_rust-nalgebra0.33+proptest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra0.33+proptest-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra0.33+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra0.33+proptest-devel}"
SRC_URI[x86_64_v2_rust-nalgebra0.33+proptest-devel.sha256sum] = "5fb1e6c1aa32fc16e645502f82ea34c28fdb48e050b45aca8826c654e2a2e600"

URI_x86_64_v2_rust-nalgebra0.33+proptest-support-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra0.33+proptest-support-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra0.33+proptest-support-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra0.33+proptest-support-devel}"
SRC_URI[x86_64_v2_rust-nalgebra0.33+proptest-support-devel.sha256sum] = "91fa9ec34c0f4c0b695ae64dcf171edafdeebdc94965c345f17b9b98c88c4f8a"

URI_x86_64_v2_rust-nalgebra0.33+quickcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra0.33+quickcheck-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra0.33+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra0.33+quickcheck-devel}"
SRC_URI[x86_64_v2_rust-nalgebra0.33+quickcheck-devel.sha256sum] = "0cde5bf7643d33355bc6d10471b1ebb267aa4e43018fda8f565ce7e314514ad5"

URI_x86_64_v2_rust-nalgebra0.33+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra0.33+rand-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra0.33+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra0.33+rand-devel}"
SRC_URI[x86_64_v2_rust-nalgebra0.33+rand-devel.sha256sum] = "b64b27029bba1891d5b110386e4cf7a1354ecfa14df48ace0026d6ce64f1afe6"

URI_x86_64_v2_rust-nalgebra0.33+rand-no-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra0.33+rand-no-std-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra0.33+rand-no-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra0.33+rand-no-std-devel}"
SRC_URI[x86_64_v2_rust-nalgebra0.33+rand-no-std-devel.sha256sum] = "275d03d6f276467cfd1a8c08b854b3e311666f99385a3ada694846ec8cbf9ec9"

URI_x86_64_v2_rust-nalgebra0.33+rand-package-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra0.33+rand-package-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra0.33+rand-package-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra0.33+rand-package-devel}"
SRC_URI[x86_64_v2_rust-nalgebra0.33+rand-package-devel.sha256sum] = "bf5d4192fb47f80c366cc6b70643fa097d41709ae6f4f0ce381ccfb47d8684e7"

URI_x86_64_v2_rust-nalgebra0.33+rand_distr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra0.33+rand_distr-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra0.33+rand_distr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra0.33+rand_distr-devel}"
SRC_URI[x86_64_v2_rust-nalgebra0.33+rand_distr-devel.sha256sum] = "a5b0bed9627a69ded8325da55f46f24420a249a27734f0e7ec1e5a95f700221a"

URI_x86_64_v2_rust-nalgebra0.33+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra0.33+rayon-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra0.33+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra0.33+rayon-devel}"
SRC_URI[x86_64_v2_rust-nalgebra0.33+rayon-devel.sha256sum] = "4193666498530e4eaeaa490a0576bec8291b121395e04925a8c9cd4c06d3c6e7"

URI_x86_64_v2_rust-nalgebra0.33+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra0.33+serde-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra0.33+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra0.33+serde-devel}"
SRC_URI[x86_64_v2_rust-nalgebra0.33+serde-devel.sha256sum] = "9fcb90d1d7e84851d802b9dee58d0964fd582d435c4473309dbd0a604ce72e45"

URI_x86_64_v2_rust-nalgebra0.33+serde-serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra0.33+serde-serialize-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra0.33+serde-serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra0.33+serde-serialize-devel}"
SRC_URI[x86_64_v2_rust-nalgebra0.33+serde-serialize-devel.sha256sum] = "c6ac6e9036cdcfd5649da783b88a90c34f63c2327cc8b85de7cc10ff2945a2af"

URI_x86_64_v2_rust-nalgebra0.33+serde-serialize-no-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra0.33+serde-serialize-no-std-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra0.33+serde-serialize-no-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra0.33+serde-serialize-no-std-devel}"
SRC_URI[x86_64_v2_rust-nalgebra0.33+serde-serialize-no-std-devel.sha256sum] = "00319845a18daa273296cd333f94e3f0c56121f21b3f4dc89674e34c61110213"

URI_x86_64_v2_rust-nalgebra0.33+slow-tests-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra0.33+slow-tests-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra0.33+slow-tests-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra0.33+slow-tests-devel}"
SRC_URI[x86_64_v2_rust-nalgebra0.33+slow-tests-devel.sha256sum] = "ff97d1e22b665173f84545c0b3f3a7441d1897909990079b5b9fd365dfe36061"

URI_x86_64_v2_rust-nalgebra0.33+sparse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra0.33+sparse-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra0.33+sparse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra0.33+sparse-devel}"
SRC_URI[x86_64_v2_rust-nalgebra0.33+sparse-devel.sha256sum] = "b18cf4742a76300697b7fe6446b5860f186636efd13c8c82ace5cd52d8f3fef7"

URI_x86_64_v2_rust-nalgebra0.33+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra0.33+std-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra0.33+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra0.33+std-devel}"
SRC_URI[x86_64_v2_rust-nalgebra0.33+std-devel.sha256sum] = "8f7cb7ef8872a21ea8d4cf4d58a6ce96e968b9754076270da36834d27ae9cafa"

URI_x86_64_v2_rust-nalgebra0.33-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra0.33-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra0.33-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra0.33-devel}"
SRC_URI[x86_64_v2_rust-nalgebra0.33-devel.sha256sum] = "2ec9beb5e9314c2c14c814d22bbfda26d88fe157b278e41efaf19f832fe4c0e6"

URI_aarch64_rust-nalgebra0.33+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra0.33+alloc-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra0.33+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra0.33+alloc-devel}"
SRC_URI[aarch64_rust-nalgebra0.33+alloc-devel.sha256sum] = "8e2a9268137c12e0c524845453bbd655184a3247594a3c51e14464ddbb000929"

URI_aarch64_rust-nalgebra0.33+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra0.33+arbitrary-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra0.33+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra0.33+arbitrary-devel}"
SRC_URI[aarch64_rust-nalgebra0.33+arbitrary-devel.sha256sum] = "ec30e0ac5003906dd36dd5ade5c92db36342c4f23f1b961bdd087c6dd78e6e48"

URI_aarch64_rust-nalgebra0.33+bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra0.33+bytemuck-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra0.33+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra0.33+bytemuck-devel}"
SRC_URI[aarch64_rust-nalgebra0.33+bytemuck-devel.sha256sum] = "d9174b7b77eb4d97bbdb1282fc458fd4a0ed30a902e24ea6f177b43e59f95056"

URI_aarch64_rust-nalgebra0.33+compare-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra0.33+compare-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra0.33+compare-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra0.33+compare-devel}"
SRC_URI[aarch64_rust-nalgebra0.33+compare-devel.sha256sum] = "70ac06f12f7014b7c159fe98b9e025f732ec99db5c5f6340965f9223af49f3c8"

URI_aarch64_rust-nalgebra0.33+convert-bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra0.33+convert-bytemuck-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra0.33+convert-bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra0.33+convert-bytemuck-devel}"
SRC_URI[aarch64_rust-nalgebra0.33+convert-bytemuck-devel.sha256sum] = "834a785f8514dbac62400b651f1aa1db773fd1df1ee8c07032718f6dcf635a47"

URI_aarch64_rust-nalgebra0.33+convert-mint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra0.33+convert-mint-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra0.33+convert-mint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra0.33+convert-mint-devel}"
SRC_URI[aarch64_rust-nalgebra0.33+convert-mint-devel.sha256sum] = "8e0a736a63814ab1e3d2f51a135b4404b2e031788a0e09c468b6ae6cdcf1568e"

URI_aarch64_rust-nalgebra0.33+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra0.33+debug-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra0.33+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra0.33+debug-devel}"
SRC_URI[aarch64_rust-nalgebra0.33+debug-devel.sha256sum] = "9332f33d76d30345506e0da24563977c34c4b6051932e4b235c7cc9b58cd3cce"

URI_aarch64_rust-nalgebra0.33+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra0.33+default-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra0.33+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra0.33+default-devel}"
SRC_URI[aarch64_rust-nalgebra0.33+default-devel.sha256sum] = "ad77979a9cd3d179d9bbdfa25f6efad56201f4cf13a89ad60f0ea34668b05ea7"

URI_aarch64_rust-nalgebra0.33+io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra0.33+io-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra0.33+io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra0.33+io-devel}"
SRC_URI[aarch64_rust-nalgebra0.33+io-devel.sha256sum] = "63f6420a214a3d844f78719d606d81ca2ed453b109fa50b9ccb91133fd264928"

URI_aarch64_rust-nalgebra0.33+libm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra0.33+libm-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra0.33+libm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra0.33+libm-devel}"
SRC_URI[aarch64_rust-nalgebra0.33+libm-devel.sha256sum] = "3d4cf0f15588c89e249e578d0b98f3967f613b7b9fad22a47742df52ffaf56e0"

URI_aarch64_rust-nalgebra0.33+libm-force-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra0.33+libm-force-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra0.33+libm-force-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra0.33+libm-force-devel}"
SRC_URI[aarch64_rust-nalgebra0.33+libm-force-devel.sha256sum] = "b9377adea72aa90b64206300d103fcbc77cd00648ffeff5854d02e6e3eb63f5a"

URI_aarch64_rust-nalgebra0.33+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra0.33+macros-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra0.33+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra0.33+macros-devel}"
SRC_URI[aarch64_rust-nalgebra0.33+macros-devel.sha256sum] = "dd20861f893ce7593873b6e1475885b1944e071f1a7118f88719d297b1d7ab00"

URI_aarch64_rust-nalgebra0.33+matrixcompare-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra0.33+matrixcompare-core-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra0.33+matrixcompare-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra0.33+matrixcompare-core-devel}"
SRC_URI[aarch64_rust-nalgebra0.33+matrixcompare-core-devel.sha256sum] = "103fe06863d61adaea0c27350fa5c3bb9a23a5aad7eac5a2bc3aa98ac9691ee5"

URI_aarch64_rust-nalgebra0.33+matrixmultiply-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra0.33+matrixmultiply-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra0.33+matrixmultiply-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra0.33+matrixmultiply-devel}"
SRC_URI[aarch64_rust-nalgebra0.33+matrixmultiply-devel.sha256sum] = "7d93453ea9d4d2e86cc162933efe0eab4f6e94b49cbcfaa9ad996206e008d7bc"

URI_aarch64_rust-nalgebra0.33+mint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra0.33+mint-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra0.33+mint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra0.33+mint-devel}"
SRC_URI[aarch64_rust-nalgebra0.33+mint-devel.sha256sum] = "e0f28d4f84825a5619bdbfcb5a52ac1f5c7ea856080b8c4ea7bfb023c4bae18e"

URI_aarch64_rust-nalgebra0.33+nalgebra-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra0.33+nalgebra-macros-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra0.33+nalgebra-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra0.33+nalgebra-macros-devel}"
SRC_URI[aarch64_rust-nalgebra0.33+nalgebra-macros-devel.sha256sum] = "36af61453d2af71a3bc03d1db77f41e54004f53456b197aa462eb305d20b73d5"

URI_aarch64_rust-nalgebra0.33+pest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra0.33+pest-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra0.33+pest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra0.33+pest-devel}"
SRC_URI[aarch64_rust-nalgebra0.33+pest-devel.sha256sum] = "4645bf412de5024c953630b6ceaf80525ad5471f182c2e9ccd35d6dcaa297dfe"

URI_aarch64_rust-nalgebra0.33+pest_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra0.33+pest_derive-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra0.33+pest_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra0.33+pest_derive-devel}"
SRC_URI[aarch64_rust-nalgebra0.33+pest_derive-devel.sha256sum] = "5bb75fbd5ad43a8e409892dfb822225dd156f4473be4c0541dd16cc3e7052aaf"

URI_aarch64_rust-nalgebra0.33+proptest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra0.33+proptest-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra0.33+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra0.33+proptest-devel}"
SRC_URI[aarch64_rust-nalgebra0.33+proptest-devel.sha256sum] = "25153cd37fd05d30e692df4acf778512e3a5f960eee2ed224f7c8951f7158790"

URI_aarch64_rust-nalgebra0.33+proptest-support-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra0.33+proptest-support-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra0.33+proptest-support-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra0.33+proptest-support-devel}"
SRC_URI[aarch64_rust-nalgebra0.33+proptest-support-devel.sha256sum] = "fa1970e705c54759e1164d8aa328653925afa6b4364a98e489e91b95b734d67d"

URI_aarch64_rust-nalgebra0.33+quickcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra0.33+quickcheck-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra0.33+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra0.33+quickcheck-devel}"
SRC_URI[aarch64_rust-nalgebra0.33+quickcheck-devel.sha256sum] = "516fda0e3cebca0c03a7275564e4314b40fe9e6162daea34cbddf57a02fe53b8"

URI_aarch64_rust-nalgebra0.33+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra0.33+rand-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra0.33+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra0.33+rand-devel}"
SRC_URI[aarch64_rust-nalgebra0.33+rand-devel.sha256sum] = "eeac301c35d0f0467f82741c9742bc911c77f3c66e05d7824d762fbcc486c7fc"

URI_aarch64_rust-nalgebra0.33+rand-no-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra0.33+rand-no-std-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra0.33+rand-no-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra0.33+rand-no-std-devel}"
SRC_URI[aarch64_rust-nalgebra0.33+rand-no-std-devel.sha256sum] = "780fa575ade98f2c40b796086b1bde12529fc5e6ab7be7a9a865d09862c331b3"

URI_aarch64_rust-nalgebra0.33+rand-package-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra0.33+rand-package-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra0.33+rand-package-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra0.33+rand-package-devel}"
SRC_URI[aarch64_rust-nalgebra0.33+rand-package-devel.sha256sum] = "83e5751864f3da2fe12bfc805b3fc304fc7b2948dbdeb608bf90275b66dab3ce"

URI_aarch64_rust-nalgebra0.33+rand_distr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra0.33+rand_distr-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra0.33+rand_distr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra0.33+rand_distr-devel}"
SRC_URI[aarch64_rust-nalgebra0.33+rand_distr-devel.sha256sum] = "2f6ce86bb4b5ef328b9a733358b1adc519ae494c4f294580e6be08beb09b6cf0"

URI_aarch64_rust-nalgebra0.33+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra0.33+rayon-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra0.33+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra0.33+rayon-devel}"
SRC_URI[aarch64_rust-nalgebra0.33+rayon-devel.sha256sum] = "6d625d029ba6393240ef1978e276c35092eb1196cba284e164bafd2a1eaf6eb0"

URI_aarch64_rust-nalgebra0.33+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra0.33+serde-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra0.33+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra0.33+serde-devel}"
SRC_URI[aarch64_rust-nalgebra0.33+serde-devel.sha256sum] = "46862105f3b34b1a5b9fab5704f318ee5a72de92bc7183d9618295c3a7049f5f"

URI_aarch64_rust-nalgebra0.33+serde-serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra0.33+serde-serialize-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra0.33+serde-serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra0.33+serde-serialize-devel}"
SRC_URI[aarch64_rust-nalgebra0.33+serde-serialize-devel.sha256sum] = "981ef9880ba3dbedfadbceecc7c45a9057b32c673f55523ef3bf99ed7fc09456"

URI_aarch64_rust-nalgebra0.33+serde-serialize-no-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra0.33+serde-serialize-no-std-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra0.33+serde-serialize-no-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra0.33+serde-serialize-no-std-devel}"
SRC_URI[aarch64_rust-nalgebra0.33+serde-serialize-no-std-devel.sha256sum] = "7610512a6a5487e7de2ec874abb467e2b791ab1cee6de0513658f51d7ed90b78"

URI_aarch64_rust-nalgebra0.33+slow-tests-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra0.33+slow-tests-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra0.33+slow-tests-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra0.33+slow-tests-devel}"
SRC_URI[aarch64_rust-nalgebra0.33+slow-tests-devel.sha256sum] = "fa7f94fea33ed59696d9a2c113b9de5cffe5f17223fe097034f02cde90b84aa0"

URI_aarch64_rust-nalgebra0.33+sparse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra0.33+sparse-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra0.33+sparse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra0.33+sparse-devel}"
SRC_URI[aarch64_rust-nalgebra0.33+sparse-devel.sha256sum] = "ee2f62a4457e19517f34c32ec9ea7f4d27ea7829f8a793ac20631d158ab62ff6"

URI_aarch64_rust-nalgebra0.33+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra0.33+std-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra0.33+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra0.33+std-devel}"
SRC_URI[aarch64_rust-nalgebra0.33+std-devel.sha256sum] = "e771232517fd1be0a6f64287e1980637c433725a0a2f4098b42e56987e57e9c5"

URI_aarch64_rust-nalgebra0.33-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra0.33-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra0.33-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra0.33-devel}"
SRC_URI[aarch64_rust-nalgebra0.33-devel.sha256sum] = "bd44faf11739e4360d3d0680c2e411a3821230730c5de8239c449168817978a6"

RDEPENDS:rust-nalgebra0.33+alloc-devel = " \
 cargo \
 rust-nalgebra0.33-devel \
 "
RDEPENDS:rust-nalgebra0.33+arbitrary-devel = " \
 cargo \
 rust-nalgebra0.33+quickcheck-devel \
 rust-nalgebra0.33-devel \
 "
RDEPENDS:rust-nalgebra0.33+bytemuck-devel = " \
 cargo \
 rust-bytemuck+default-devel \
 rust-nalgebra0.33-devel \
 "
RDEPENDS:rust-nalgebra0.33+compare-devel = " \
 cargo \
 rust-nalgebra0.33+matrixcompare-core-devel \
 rust-nalgebra0.33-devel \
 "
RDEPENDS:rust-nalgebra0.33+convert-bytemuck-devel = " \
 cargo \
 rust-nalgebra0.33+bytemuck-devel \
 rust-nalgebra0.33-devel \
 rust-num-complex+bytemuck-devel \
 "
RDEPENDS:rust-nalgebra0.33+convert-mint-devel = " \
 cargo \
 rust-nalgebra0.33+mint-devel \
 rust-nalgebra0.33-devel \
 "
RDEPENDS:rust-nalgebra0.33+debug-devel = " \
 cargo \
 rust-approx+num-complex-devel \
 rust-nalgebra0.33+rand-devel \
 rust-nalgebra0.33-devel \
 "
RDEPENDS:rust-nalgebra0.33+default-devel = " \
 cargo \
 rust-nalgebra0.33+macros-devel \
 rust-nalgebra0.33+std-devel \
 rust-nalgebra0.33-devel \
 "
RDEPENDS:rust-nalgebra0.33+io-devel = " \
 cargo \
 rust-nalgebra0.33+pest-devel \
 rust-nalgebra0.33+pest_derive-devel \
 rust-nalgebra0.33-devel \
 "
RDEPENDS:rust-nalgebra0.33+libm-devel = " \
 cargo \
 rust-nalgebra0.33-devel \
 rust-simba+libm-devel \
 "
RDEPENDS:rust-nalgebra0.33+libm-force-devel = " \
 cargo \
 rust-nalgebra0.33-devel \
 rust-simba+libm_force-devel \
 "
RDEPENDS:rust-nalgebra0.33+macros-devel = " \
 cargo \
 rust-nalgebra0.33+nalgebra-macros-devel \
 rust-nalgebra0.33-devel \
 "
RDEPENDS:rust-nalgebra0.33+matrixcompare-core-devel = " \
 cargo \
 rust-matrixcompare-core+default-devel \
 rust-nalgebra0.33-devel \
 "
RDEPENDS:rust-nalgebra0.33+matrixmultiply-devel = " \
 cargo \
 rust-matrixmultiply+default-devel \
 rust-nalgebra0.33-devel \
 "
RDEPENDS:rust-nalgebra0.33+mint-devel = " \
 cargo \
 rust-mint+default-devel \
 rust-nalgebra0.33-devel \
 "
RDEPENDS:rust-nalgebra0.33+nalgebra-macros-devel = " \
 cargo \
 rust-nalgebra-macros0.2+default-devel \
 rust-nalgebra0.33-devel \
 "
RDEPENDS:rust-nalgebra0.33+pest-devel = " \
 cargo \
 rust-nalgebra0.33-devel \
 rust-pest+default-devel \
 "
RDEPENDS:rust-nalgebra0.33+pest_derive-devel = " \
 cargo \
 rust-nalgebra0.33-devel \
 rust-pest_derive+default-devel \
 "
RDEPENDS:rust-nalgebra0.33+proptest-devel = " \
 cargo \
 rust-nalgebra0.33-devel \
 rust-proptest+std-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-nalgebra0.33+proptest-support-devel = " \
 cargo \
 rust-nalgebra0.33+proptest-devel \
 rust-nalgebra0.33-devel \
 "
RDEPENDS:rust-nalgebra0.33+quickcheck-devel = " \
 cargo \
 rust-nalgebra0.33-devel \
 rust-quickcheck+default-devel \
 "
RDEPENDS:rust-nalgebra0.33+rand-devel = " \
 cargo \
 rust-nalgebra0.33+rand-no-std-devel \
 rust-nalgebra0.33+rand_distr-devel \
 rust-nalgebra0.33-devel \
 rust-rand0.8+std-devel \
 rust-rand0.8+std_rng-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-nalgebra0.33+rand-no-std-devel = " \
 cargo \
 rust-nalgebra0.33+rand-package-devel \
 rust-nalgebra0.33-devel \
 "
RDEPENDS:rust-nalgebra0.33+rand-package-devel = " \
 cargo \
 rust-nalgebra0.33-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-nalgebra0.33+rand_distr-devel = " \
 cargo \
 rust-nalgebra0.33-devel \
 rust-rand_distr0.4-devel \
 "
RDEPENDS:rust-nalgebra0.33+rayon-devel = " \
 cargo \
 rust-nalgebra0.33-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-nalgebra0.33+serde-devel = " \
 cargo \
 rust-nalgebra0.33-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-nalgebra0.33+serde-serialize-devel = " \
 cargo \
 rust-nalgebra0.33+serde-serialize-no-std-devel \
 rust-nalgebra0.33-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-nalgebra0.33+serde-serialize-no-std-devel = " \
 cargo \
 rust-nalgebra0.33+serde-devel \
 rust-nalgebra0.33-devel \
 rust-num-complex+serde-devel \
 "
RDEPENDS:rust-nalgebra0.33+slow-tests-devel = " \
 cargo \
 rust-nalgebra0.33-devel \
 "
RDEPENDS:rust-nalgebra0.33+sparse-devel = " \
 cargo \
 rust-nalgebra0.33-devel \
 "
RDEPENDS:rust-nalgebra0.33+std-devel = " \
 cargo \
 rust-approx+std-devel \
 rust-nalgebra0.33+matrixmultiply-devel \
 rust-nalgebra0.33-devel \
 rust-num-complex+std-devel \
 rust-num-rational+std-devel \
 rust-num-traits+std-devel \
 rust-simba+std-devel \
 "
RDEPENDS:rust-nalgebra0.33-devel = " \
 cargo \
 rust-approx-devel \
 rust-num-complex-devel \
 rust-num-rational-devel \
 rust-num-traits-devel \
 rust-simba-devel \
 rust-typenum+default-devel \
 "
