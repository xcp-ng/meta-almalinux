# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-webencodings"
PV = "0.5.1"
PR = "27.el10_0"
PACKAGES = " \
 python-webencodings-doc \
 python3-webencodings \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-webencodings-0.5.1-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c5826a91d7f2c037843b78ed23372b897ce01d1afe9b1c55f88511d0334bcf2b"

URI_x86_64_v2_python-webencodings-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-webencodings-doc-0.5.1-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-webencodings-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-webencodings-doc}"
SRC_URI[x86_64_v2_python-webencodings-doc.sha256sum] = "8231ee3e8a8b8e1048806077c2ce763625813147048706164d8e59983e3feb17"

URI_x86_64_v2_python3-webencodings = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-webencodings-0.5.1-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-webencodings;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-webencodings}"
SRC_URI[x86_64_v2_python3-webencodings.sha256sum] = "9cf41a2827b2630b367919ce8217c2b4cbc8140ac13c10e09abb491b17dca29a"

URI_aarch64_python-webencodings-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-webencodings-doc-0.5.1-27.el10_0.noarch.rpm;name=aarch64_python-webencodings-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-webencodings-doc}"
SRC_URI[aarch64_python-webencodings-doc.sha256sum] = "a03ccbf8607084e55d9ea95b7c116787e3f8e74acd801769ddf422a6354a9a24"

URI_aarch64_python3-webencodings = "${EPEL_MIRROR}/aarch64/Packages/p/python3-webencodings-0.5.1-27.el10_0.noarch.rpm;name=aarch64_python3-webencodings;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-webencodings}"
SRC_URI[aarch64_python3-webencodings.sha256sum] = "f3320cf72f63ba72df008befed34624ad829aee4d2cf07fcb8df674d0e3a55c8"

RDEPENDS:python-webencodings-doc = " \
 "
RDEPENDS:python3-webencodings = " \
 python3 \
 "
