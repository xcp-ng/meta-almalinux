# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-object"
PV = "0.38.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-object+all-devel \
 rust-object+archive-devel \
 rust-object+build-devel \
 rust-object+build_core-devel \
 rust-object+cargo-all-devel \
 rust-object+coff-devel \
 rust-object+compression-devel \
 rust-object+default-devel \
 rust-object+doc-devel \
 rust-object+elf-devel \
 rust-object+macho-devel \
 rust-object+pe-devel \
 rust-object+read-devel \
 rust-object+read_core-devel \
 rust-object+std-devel \
 rust-object+unaligned-devel \
 rust-object+unstable-all-devel \
 rust-object+unstable-devel \
 rust-object+write-devel \
 rust-object+write_core-devel \
 rust-object+write_std-devel \
 rust-object+xcoff-devel \
 rust-object-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-object-0.38.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "600ca279fc6df12f2ef2d1dee5d039a4bd2fef4fc7f48485e16b5cc849ad7fba"

URI_x86_64_v2_rust-object+all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+all-devel-0.38.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+all-devel}"
SRC_URI[x86_64_v2_rust-object+all-devel.sha256sum] = "e1027c44db73cd800f0459616c7379e05b2c9ec3b13b628fc639ddc5c6b50630"

URI_x86_64_v2_rust-object+archive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+archive-devel-0.38.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+archive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+archive-devel}"
SRC_URI[x86_64_v2_rust-object+archive-devel.sha256sum] = "e3102c7180c43f7813d2c1062b4a8fa8d9d58e49d6f0d4b6a8ae1ceeab1e6c79"

URI_x86_64_v2_rust-object+build-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+build-devel-0.38.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+build-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+build-devel}"
SRC_URI[x86_64_v2_rust-object+build-devel.sha256sum] = "a15c757e8eaf54c54ea20bd9fd34915285e57f371e67e5f1b89abcd2fa69717d"
RPROVIDES:rust-object+build-devel:x86_64_v2 = "virtual/crate_object/build__ge_0.35.0_with_crate_object/build__lt_0.39.0~"

URI_x86_64_v2_rust-object+build_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+build_core-devel-0.38.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+build_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+build_core-devel}"
SRC_URI[x86_64_v2_rust-object+build_core-devel.sha256sum] = "4287197059e62706b8c3aacd98e680a3b70966c24d3cd4c8e85b234fcd4d7a66"

URI_x86_64_v2_rust-object+cargo-all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+cargo-all-devel-0.38.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+cargo-all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+cargo-all-devel}"
SRC_URI[x86_64_v2_rust-object+cargo-all-devel.sha256sum] = "6a46c699af4baada6bf2e7f84d649c8349307d0728773fa1f3847292da1da25f"

URI_x86_64_v2_rust-object+coff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+coff-devel-0.38.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+coff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+coff-devel}"
SRC_URI[x86_64_v2_rust-object+coff-devel.sha256sum] = "d1a4d677cd01d800363a039f82acc5cbd8ab6cc753a328248acf03d73260949a"

URI_x86_64_v2_rust-object+compression-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+compression-devel-0.38.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+compression-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+compression-devel}"
SRC_URI[x86_64_v2_rust-object+compression-devel.sha256sum] = "f0f8dbe1b6cc505b5e1d5463470266aa0cc2dbe2cc1d51575c17468465f41cd4"

URI_x86_64_v2_rust-object+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+default-devel-0.38.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+default-devel}"
SRC_URI[x86_64_v2_rust-object+default-devel.sha256sum] = "fa990a1f3c5799e9a46d1c6bc42ddebe69208b4092cd9c0a187c4346eedb563c"

URI_x86_64_v2_rust-object+doc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+doc-devel-0.38.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+doc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+doc-devel}"
SRC_URI[x86_64_v2_rust-object+doc-devel.sha256sum] = "6d273338b2778b7dc5410dbbfc25a61c939329fad5503f978d49464f501a8628"

URI_x86_64_v2_rust-object+elf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+elf-devel-0.38.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+elf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+elf-devel}"
SRC_URI[x86_64_v2_rust-object+elf-devel.sha256sum] = "ce4e4d34a4a73eb59358e91de9e1198a83a5766c2eef77291a259370e4d39f55"
RPROVIDES:rust-object+elf-devel:x86_64_v2 = "virtual/crate_object/elf__ge_0.35.0_with_crate_object/elf__lt_0.39.0~"

URI_x86_64_v2_rust-object+macho-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+macho-devel-0.38.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+macho-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+macho-devel}"
SRC_URI[x86_64_v2_rust-object+macho-devel.sha256sum] = "1735b667409b53e196e05bfa377f346d24ff8966f2c3dffa8856857aaccfb092"

URI_x86_64_v2_rust-object+pe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+pe-devel-0.38.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+pe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+pe-devel}"
SRC_URI[x86_64_v2_rust-object+pe-devel.sha256sum] = "36d9db62fc063ec877cbb6018e335033f85617776cb48c438e7f67742847748a"

URI_x86_64_v2_rust-object+read-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+read-devel-0.38.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+read-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+read-devel}"
SRC_URI[x86_64_v2_rust-object+read-devel.sha256sum] = "d4b256e4f4dc05444b3c9c7bf07d7fd7a76d2a43187d9220ff40ca2194eb5a38"

URI_x86_64_v2_rust-object+read_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+read_core-devel-0.38.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+read_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+read_core-devel}"
SRC_URI[x86_64_v2_rust-object+read_core-devel.sha256sum] = "2e4aea04ddd783a54e132a0ff17624a78ee9cf50f0d6fe6aea19828fff749f3d"

URI_x86_64_v2_rust-object+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+std-devel-0.38.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+std-devel}"
SRC_URI[x86_64_v2_rust-object+std-devel.sha256sum] = "2001f04f4d805f38203e0b4615196e06817216728340ca04691d306356c96141"

URI_x86_64_v2_rust-object+unaligned-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+unaligned-devel-0.38.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+unaligned-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+unaligned-devel}"
SRC_URI[x86_64_v2_rust-object+unaligned-devel.sha256sum] = "2ff8d241f8848e7202acc1b7effa09b8dde94d96de87a6bf713993539dd7dbb8"

URI_x86_64_v2_rust-object+unstable-all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+unstable-all-devel-0.38.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+unstable-all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+unstable-all-devel}"
SRC_URI[x86_64_v2_rust-object+unstable-all-devel.sha256sum] = "ae45effd0c200761853ad8ce73cb0bc6b7e7a107a2c121d78db9891e790de67a"

URI_x86_64_v2_rust-object+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+unstable-devel-0.38.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+unstable-devel}"
SRC_URI[x86_64_v2_rust-object+unstable-devel.sha256sum] = "9b0df72bac45102d208ba236ef608c1ad970af22d1cba3d33448da6cf6811128"

URI_x86_64_v2_rust-object+write-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+write-devel-0.38.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+write-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+write-devel}"
SRC_URI[x86_64_v2_rust-object+write-devel.sha256sum] = "a3507697fb535a000acd09b2007842a20c7ffdfbc87ba3b08d605658e8720d69"

URI_x86_64_v2_rust-object+write_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+write_core-devel-0.38.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+write_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+write_core-devel}"
SRC_URI[x86_64_v2_rust-object+write_core-devel.sha256sum] = "d8f0e0d100129af2caea4d6ab9a456592cb392e6893488f6a041421970f773ad"

URI_x86_64_v2_rust-object+write_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+write_std-devel-0.38.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+write_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+write_std-devel}"
SRC_URI[x86_64_v2_rust-object+write_std-devel.sha256sum] = "e5471e32003e00a8c54062c99b2396edadaf5d5a77f9fdfc7ccb80afd25446a7"

URI_x86_64_v2_rust-object+xcoff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+xcoff-devel-0.38.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+xcoff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+xcoff-devel}"
SRC_URI[x86_64_v2_rust-object+xcoff-devel.sha256sum] = "2b246c4e7569618f63e6896c94ffad2ded82ddd70f24df34262f16db98d939ac"

URI_x86_64_v2_rust-object-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object-devel-0.38.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object-devel}"
SRC_URI[x86_64_v2_rust-object-devel.sha256sum] = "36225f97c64f77b24affbcaad9a18c03fc4ff04cd1c1c28abf6c8ab51fada7b7"
RPROVIDES:rust-object-devel:x86_64_v2 = "virtual/crate_object__ge_0.35.0_with_crate_object__lt_0.39.0~"

URI_aarch64_rust-object+all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+all-devel-0.38.1-1.el10_2.noarch.rpm;name=aarch64_rust-object+all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+all-devel}"
SRC_URI[aarch64_rust-object+all-devel.sha256sum] = "2bc8df2f884c7da0d4810bbcda4aa4875c6929b5b6c3ea8e7a2d9947b5e8a8ba"

URI_aarch64_rust-object+archive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+archive-devel-0.38.1-1.el10_2.noarch.rpm;name=aarch64_rust-object+archive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+archive-devel}"
SRC_URI[aarch64_rust-object+archive-devel.sha256sum] = "0d759d8145dfdfa8d1b5eeb044d8baa260fa5b18fb2348b46907ab5d1e3b3e15"

URI_aarch64_rust-object+build-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+build-devel-0.38.1-1.el10_2.noarch.rpm;name=aarch64_rust-object+build-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+build-devel}"
SRC_URI[aarch64_rust-object+build-devel.sha256sum] = "c281cebfab017c6a86c63ba05b68355da03b096de09be0f3b80de6a740ee4cc4"
RPROVIDES:rust-object+build-devel:aarch64 = "virtual/crate_object/build__ge_0.35.0_with_crate_object/build__lt_0.39.0~"

URI_aarch64_rust-object+build_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+build_core-devel-0.38.1-1.el10_2.noarch.rpm;name=aarch64_rust-object+build_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+build_core-devel}"
SRC_URI[aarch64_rust-object+build_core-devel.sha256sum] = "ef602885c8f169ae85509987b913619cbd6e3dff825f23d3f3858026576213a4"

URI_aarch64_rust-object+cargo-all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+cargo-all-devel-0.38.1-1.el10_2.noarch.rpm;name=aarch64_rust-object+cargo-all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+cargo-all-devel}"
SRC_URI[aarch64_rust-object+cargo-all-devel.sha256sum] = "c6238be58524d4dd532824adb8285a52cdc603903a0f362cecab828f71562a13"

URI_aarch64_rust-object+coff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+coff-devel-0.38.1-1.el10_2.noarch.rpm;name=aarch64_rust-object+coff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+coff-devel}"
SRC_URI[aarch64_rust-object+coff-devel.sha256sum] = "d1f7643ac7cc20825deedb50926fde70558906d622724a0b1c2427e7b1a67d0d"

URI_aarch64_rust-object+compression-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+compression-devel-0.38.1-1.el10_2.noarch.rpm;name=aarch64_rust-object+compression-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+compression-devel}"
SRC_URI[aarch64_rust-object+compression-devel.sha256sum] = "b57ab5df8ed4af6a2209e2a29fd639d13ff5837535ce540d6f1b7f0e2eb8ff45"

URI_aarch64_rust-object+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+default-devel-0.38.1-1.el10_2.noarch.rpm;name=aarch64_rust-object+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+default-devel}"
SRC_URI[aarch64_rust-object+default-devel.sha256sum] = "c983b24b9a85ee03113e80b1258eaf1c1d813d5eec827d997f15b789cc6d17b6"

URI_aarch64_rust-object+doc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+doc-devel-0.38.1-1.el10_2.noarch.rpm;name=aarch64_rust-object+doc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+doc-devel}"
SRC_URI[aarch64_rust-object+doc-devel.sha256sum] = "ae7836aeb302532a3c9957eb9b147242c77ca4e65e50a25f04c7f7c2618c5eff"

URI_aarch64_rust-object+elf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+elf-devel-0.38.1-1.el10_2.noarch.rpm;name=aarch64_rust-object+elf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+elf-devel}"
SRC_URI[aarch64_rust-object+elf-devel.sha256sum] = "ad246462ee04c533bdd3fa552c971e8b811cfea0d073f573a8b25a42e704f44e"
RPROVIDES:rust-object+elf-devel:aarch64 = "virtual/crate_object/elf__ge_0.35.0_with_crate_object/elf__lt_0.39.0~"

URI_aarch64_rust-object+macho-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+macho-devel-0.38.1-1.el10_2.noarch.rpm;name=aarch64_rust-object+macho-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+macho-devel}"
SRC_URI[aarch64_rust-object+macho-devel.sha256sum] = "141c5322694a19514eb48ab74f29c2c63e495fecbc903bce2666dbb7d925ac97"

URI_aarch64_rust-object+pe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+pe-devel-0.38.1-1.el10_2.noarch.rpm;name=aarch64_rust-object+pe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+pe-devel}"
SRC_URI[aarch64_rust-object+pe-devel.sha256sum] = "ef38432c8aef257856f2cf4130a93ea2fef8fccc49a7357ce723522cd67a426c"

URI_aarch64_rust-object+read-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+read-devel-0.38.1-1.el10_2.noarch.rpm;name=aarch64_rust-object+read-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+read-devel}"
SRC_URI[aarch64_rust-object+read-devel.sha256sum] = "253d4accd6ba82f69c489c1c678272a69f0dcda4513cee4a352f8072fd039c2d"

URI_aarch64_rust-object+read_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+read_core-devel-0.38.1-1.el10_2.noarch.rpm;name=aarch64_rust-object+read_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+read_core-devel}"
SRC_URI[aarch64_rust-object+read_core-devel.sha256sum] = "eea069fb30ce1ea7a5bf8eaa00e23d8d0b2d0e35c0ec6abc1471cc422a397f05"

URI_aarch64_rust-object+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+std-devel-0.38.1-1.el10_2.noarch.rpm;name=aarch64_rust-object+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+std-devel}"
SRC_URI[aarch64_rust-object+std-devel.sha256sum] = "bc2867518117bb32742b3c1f74abe02c779735b082b2890634ea381ced7653ae"

URI_aarch64_rust-object+unaligned-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+unaligned-devel-0.38.1-1.el10_2.noarch.rpm;name=aarch64_rust-object+unaligned-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+unaligned-devel}"
SRC_URI[aarch64_rust-object+unaligned-devel.sha256sum] = "ef87316b6615d30d90707db6c51b2ad3bc152bf6eae512b6da8ef7c6900bb26b"

URI_aarch64_rust-object+unstable-all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+unstable-all-devel-0.38.1-1.el10_2.noarch.rpm;name=aarch64_rust-object+unstable-all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+unstable-all-devel}"
SRC_URI[aarch64_rust-object+unstable-all-devel.sha256sum] = "7b92a54f8d4de02ce68f3d44563175ef8793eea94a1899bc2757d98aa185a829"

URI_aarch64_rust-object+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+unstable-devel-0.38.1-1.el10_2.noarch.rpm;name=aarch64_rust-object+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+unstable-devel}"
SRC_URI[aarch64_rust-object+unstable-devel.sha256sum] = "3cbb93ac17909725ae2ee13b966270770cd274466efe38e1752e2e17713d1871"

URI_aarch64_rust-object+write-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+write-devel-0.38.1-1.el10_2.noarch.rpm;name=aarch64_rust-object+write-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+write-devel}"
SRC_URI[aarch64_rust-object+write-devel.sha256sum] = "efc9f0e08df5b905c99776b381798b38bc5ba80104171e98832a1e40b6c65492"

URI_aarch64_rust-object+write_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+write_core-devel-0.38.1-1.el10_2.noarch.rpm;name=aarch64_rust-object+write_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+write_core-devel}"
SRC_URI[aarch64_rust-object+write_core-devel.sha256sum] = "2ec6220ef0581361839fab1bca1a05ab9cc1b46d6f3aded666e633ff5a9e0509"

URI_aarch64_rust-object+write_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+write_std-devel-0.38.1-1.el10_2.noarch.rpm;name=aarch64_rust-object+write_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+write_std-devel}"
SRC_URI[aarch64_rust-object+write_std-devel.sha256sum] = "a87a433b020f787e019bae4823bb3c026aaee1a11b886b7f0e5a5fba3d04570d"

URI_aarch64_rust-object+xcoff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+xcoff-devel-0.38.1-1.el10_2.noarch.rpm;name=aarch64_rust-object+xcoff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+xcoff-devel}"
SRC_URI[aarch64_rust-object+xcoff-devel.sha256sum] = "f14ff1f25d853bfcb1ad08dfc1bd71882dd92271ae7ccc7bf5a5144a5adbd6f4"

URI_aarch64_rust-object-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object-devel-0.38.1-1.el10_2.noarch.rpm;name=aarch64_rust-object-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object-devel}"
SRC_URI[aarch64_rust-object-devel.sha256sum] = "f0ad30a448233a81b9bc0fa0845d9d55ef591d225b4a29d6bd8d9c9a06cbea82"
RPROVIDES:rust-object-devel:aarch64 = "virtual/crate_object__ge_0.35.0_with_crate_object__lt_0.39.0~"

RDEPENDS:rust-object+all-devel = " \
 cargo \
 rust-object+build-devel \
 rust-object+compression-devel \
 rust-object+read-devel \
 rust-object+std-devel \
 rust-object+write-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+archive-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object+build-devel = " \
 cargo \
 rust-object+build_core-devel \
 rust-object+elf-devel \
 rust-object+write_std-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+build_core-devel = " \
 cargo \
 rust-object+read_core-devel \
 rust-object+write_core-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+cargo-all-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object+coff-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object+compression-devel = " \
 cargo \
 rust-flate2+default-devel \
 rust-object+std-devel \
 rust-object-devel \
 rust-ruzstd+default-devel \
 "
RDEPENDS:rust-object+default-devel = " \
 cargo \
 rust-object+compression-devel \
 rust-object+read-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+doc-devel = " \
 cargo \
 rust-object+archive-devel \
 rust-object+build_core-devel \
 rust-object+coff-devel \
 rust-object+compression-devel \
 rust-object+elf-devel \
 rust-object+macho-devel \
 rust-object+pe-devel \
 rust-object+read_core-devel \
 rust-object+std-devel \
 rust-object+write_std-devel \
 rust-object+xcoff-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+elf-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object+macho-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object+pe-devel = " \
 cargo \
 rust-object+coff-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+read-devel = " \
 cargo \
 rust-object+archive-devel \
 rust-object+coff-devel \
 rust-object+elf-devel \
 rust-object+macho-devel \
 rust-object+pe-devel \
 rust-object+read_core-devel \
 rust-object+unaligned-devel \
 rust-object+xcoff-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+read_core-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object+std-devel = " \
 cargo \
 rust-memchr+std-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+unaligned-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object+unstable-all-devel = " \
 cargo \
 rust-object+all-devel \
 rust-object+unstable-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+unstable-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object+write-devel = " \
 cargo \
 rust-object+coff-devel \
 rust-object+elf-devel \
 rust-object+macho-devel \
 rust-object+pe-devel \
 rust-object+write_std-devel \
 rust-object+xcoff-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+write_core-devel = " \
 cargo \
 rust-crc32fast-devel \
 rust-hashbrown+default-hasher-devel \
 rust-hashbrown-devel \
 rust-indexmap-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+write_std-devel = " \
 cargo \
 rust-crc32fast+std-devel \
 rust-crc32fast-devel \
 rust-indexmap+std-devel \
 rust-indexmap-devel \
 rust-object+std-devel \
 rust-object+write_core-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+xcoff-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object-devel = " \
 cargo \
 rust \
 rust-memchr-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_object/build__ge_0.35.0_with_crate_object/build__lt_0.39.0~ rpm/virtual/crate_object/elf__ge_0.35.0_with_crate_object/elf__lt_0.39.0~ rpm/virtual/crate_object__ge_0.35.0_with_crate_object__lt_0.39.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_object/build__ge_0.35.0_with_crate_object/build__lt_0.39.0~ rpm/virtual/crate_object/elf__ge_0.35.0_with_crate_object/elf__lt_0.39.0~ rpm/virtual/crate_object__ge_0.35.0_with_crate_object__lt_0.39.0~"
