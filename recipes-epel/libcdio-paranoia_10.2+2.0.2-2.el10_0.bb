# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libcdio-paranoia"
PV = "10.2+2.0.2"
PR = "2.el10_0"
PACKAGES = " \
 libcdio-paranoia \
 libcdio-paranoia-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libcdio-paranoia-10.2+2.0.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3a0e0a8af942d38b6d0553386f051eaca26a1beac10c8f364a097a1d0dd27b95"

URI_x86_64_v2_libcdio-paranoia = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcdio-paranoia-10.2+2.0.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcdio-paranoia;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcdio-paranoia}"
SRC_URI[x86_64_v2_libcdio-paranoia.sha256sum] = "2a5ad3891eb4b61e9b49f5800895402da61a8e8b32ca9802d1002057f95083fd"

URI_x86_64_v2_libcdio-paranoia-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcdio-paranoia-devel-10.2+2.0.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcdio-paranoia-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcdio-paranoia-devel}"
SRC_URI[x86_64_v2_libcdio-paranoia-devel.sha256sum] = "8b796f76720b105aff1a02cae78c8ca9b7f731871347cf4f06710084f0fce415"

URI_aarch64_libcdio-paranoia = "${EPEL_MIRROR}/aarch64/Packages/l/libcdio-paranoia-10.2+2.0.2-2.el10_0.aarch64.rpm;name=aarch64_libcdio-paranoia;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcdio-paranoia}"
SRC_URI[aarch64_libcdio-paranoia.sha256sum] = "1225b28c48b470ecd1d0d7fd8f790fc6fc87be9c5c6e93fe5fa7dd75bca71dbc"

URI_aarch64_libcdio-paranoia-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libcdio-paranoia-devel-10.2+2.0.2-2.el10_0.aarch64.rpm;name=aarch64_libcdio-paranoia-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcdio-paranoia-devel}"
SRC_URI[aarch64_libcdio-paranoia-devel.sha256sum] = "3cdf8a9971a871d95416b98127860927a13bc52bf5ddbf5440082a2bb55956f9"

RDEPENDS:libcdio-paranoia = " \
 glibc \
 libcdio \
 "
RDEPENDS:libcdio-paranoia-devel = " \
 libcdio-devel \
 libcdio-paranoia \
 pkgconf-pkg-config \
 "
