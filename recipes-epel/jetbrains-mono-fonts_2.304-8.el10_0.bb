# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jetbrains-mono-fonts"
PV = "2.304"
PR = "8.el10_0"
PACKAGES = " \
 jetbrains-mono-fonts \
 jetbrains-mono-fonts-all \
 jetbrains-mono-nl-fonts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/jetbrains-mono-fonts-2.304-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc3b4494464dc75fad74af538fa83d24e36112900331469eace9b980f6842bb2"

URI_x86_64_v2_jetbrains-mono-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jetbrains-mono-fonts-2.304-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_jetbrains-mono-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jetbrains-mono-fonts}"
SRC_URI[x86_64_v2_jetbrains-mono-fonts.sha256sum] = "0dfd04cf464126cc60e4e6626936af834fb01b7ef49642ee04db6e78a0b671db"

URI_x86_64_v2_jetbrains-mono-fonts-all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jetbrains-mono-fonts-all-2.304-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_jetbrains-mono-fonts-all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jetbrains-mono-fonts-all}"
SRC_URI[x86_64_v2_jetbrains-mono-fonts-all.sha256sum] = "6c42277808d2069a159490ce88a098cbed9f085cea989264057134670fc1c894"

URI_x86_64_v2_jetbrains-mono-nl-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jetbrains-mono-nl-fonts-2.304-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_jetbrains-mono-nl-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jetbrains-mono-nl-fonts}"
SRC_URI[x86_64_v2_jetbrains-mono-nl-fonts.sha256sum] = "1066190f240c08e8fc5d0e0a9344fb95f56b5df9e0950fe7e4c2bfbf4e81c401"

URI_aarch64_jetbrains-mono-fonts = "${EPEL_MIRROR}/aarch64/Packages/j/jetbrains-mono-fonts-2.304-8.el10_0.noarch.rpm;name=aarch64_jetbrains-mono-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_jetbrains-mono-fonts}"
SRC_URI[aarch64_jetbrains-mono-fonts.sha256sum] = "45e63a4e685d34251b9165f09dadc8c583155964863619ee24c22bfb6bb48252"

URI_aarch64_jetbrains-mono-fonts-all = "${EPEL_MIRROR}/aarch64/Packages/j/jetbrains-mono-fonts-all-2.304-8.el10_0.noarch.rpm;name=aarch64_jetbrains-mono-fonts-all;unpack=0"
SRC_URI:append = " ${URI_aarch64_jetbrains-mono-fonts-all}"
SRC_URI[aarch64_jetbrains-mono-fonts-all.sha256sum] = "0eb6ea352392c6e833e3227090072d230433fc4d12dcf259c7c31e000aec4617"

URI_aarch64_jetbrains-mono-nl-fonts = "${EPEL_MIRROR}/aarch64/Packages/j/jetbrains-mono-nl-fonts-2.304-8.el10_0.noarch.rpm;name=aarch64_jetbrains-mono-nl-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_jetbrains-mono-nl-fonts}"
SRC_URI[aarch64_jetbrains-mono-nl-fonts.sha256sum] = "98294cd043046c8c4a89a1ca3067a4cf211fdfcb9ccc548e8ebc94ee1a91f39b"

RDEPENDS:jetbrains-mono-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:jetbrains-mono-fonts-all = " \
 jetbrains-mono-fonts \
 jetbrains-mono-nl-fonts \
 "
RDEPENDS:jetbrains-mono-nl-fonts = " \
 fonts-filesystem \
 "
