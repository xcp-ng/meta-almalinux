# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libpipeline"
PV = "1.5.7"
PR = "7.el10"
PACKAGES = " \
 libpipeline \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libpipeline-1.5.7-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d7829c21fddd8efd8f445614a8da1da16dec0fc45f70dab493674e7e9177300"

URI_x86_64_v2_libpipeline = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libpipeline-1.5.7-7.el10.x86_64_v2.rpm;name=x86_64_v2_libpipeline;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpipeline}"
SRC_URI[x86_64_v2_libpipeline.sha256sum] = "43f492d5cfa82e4dab85b381e3a94612bcd014afd455393c99b0d50f5042eeaa"

URI_aarch64_libpipeline = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libpipeline-1.5.7-7.el10.aarch64.rpm;name=aarch64_libpipeline;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpipeline}"
SRC_URI[aarch64_libpipeline.sha256sum] = "61c3c3e2707f3aa7201fc57bab14add2e927bee10b354b95f2c438bd5073af31"

RDEPENDS:libpipeline = " \
 glibc \
 "
