# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cbindgen"
PV = "0.29.0"
PR = "2.el10"
PACKAGES = " \
 cbindgen \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/cbindgen-0.29.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d138c1873cd5f77d70d69354bcd31a5486ed89ba3dde5a15f75bae5f3c97d87"

URI_x86_64_v2_cbindgen = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/cbindgen-0.29.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_cbindgen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cbindgen}"
SRC_URI[x86_64_v2_cbindgen.sha256sum] = "a4a2f8cc38b7880b0e7d26b53555c16fc638eba46fa5221dbc99933b1a7422cc"

URI_aarch64_cbindgen = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/cbindgen-0.29.0-2.el10.aarch64.rpm;name=aarch64_cbindgen;unpack=0"
SRC_URI:append = " ${URI_aarch64_cbindgen}"
SRC_URI[aarch64_cbindgen.sha256sum] = "afe60119f7143fb77e74393d290785e4436a47db99bd5bb0b25762b46d9badf6"

RDEPENDS:cbindgen = " \
 glibc \
 libgcc \
 "
