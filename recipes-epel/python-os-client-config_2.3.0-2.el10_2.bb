# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-os-client-config"
PV = "2.3.0"
PR = "2.el10_2"
PACKAGES = " \
 python-os-client-config-doc \
 python3-os-client-config \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-os-client-config-2.3.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf372bc53759fa525dc743269b1b66a154acd2afcf463a1abe81266d2c2a0490"

URI_x86_64_v2_python-os-client-config-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-os-client-config-doc-2.3.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-os-client-config-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-os-client-config-doc}"
SRC_URI[x86_64_v2_python-os-client-config-doc.sha256sum] = "c0b0781c1560cc4437093bd48e82035e2260d571dac623ab1ddaa83d18a9d82f"

URI_x86_64_v2_python3-os-client-config = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-os-client-config-2.3.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-os-client-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-os-client-config}"
SRC_URI[x86_64_v2_python3-os-client-config.sha256sum] = "8592473f51bfcc5d9ab79e49bd584ed6c057cb8264b0fd1aa0e109f205124b02"

URI_aarch64_python-os-client-config-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-os-client-config-doc-2.3.0-2.el10_2.noarch.rpm;name=aarch64_python-os-client-config-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-os-client-config-doc}"
SRC_URI[aarch64_python-os-client-config-doc.sha256sum] = "3fe0e0551c9fd8dfb2556ab36c688c9610ce7f37a8c5317d6344c8dfdac33149"

URI_aarch64_python3-os-client-config = "${EPEL_MIRROR}/aarch64/Packages/p/python3-os-client-config-2.3.0-2.el10_2.noarch.rpm;name=aarch64_python3-os-client-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-os-client-config}"
SRC_URI[aarch64_python3-os-client-config.sha256sum] = "8d33788bf52f842af58269dd9db8057bbe0e63c07927c0bdcd53b4e50d3f3b9c"

RDEPENDS:python-os-client-config-doc = " \
 "
RDEPENDS:python3-os-client-config = " \
 python3 \
 python3-openstacksdk \
 python3-pbr \
 "
