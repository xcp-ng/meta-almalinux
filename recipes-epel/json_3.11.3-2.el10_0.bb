# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "json"
PV = "3.11.3"
PR = "2.el10_0"
PACKAGES = " \
 json-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/json-3.11.3-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d98f9c3ea97d3879ac032194ac2464f89a97dcba315dbc20adf0fb3ad762c365"

URI_x86_64_v2_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/json-devel-3.11.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_json-devel}"
SRC_URI[x86_64_v2_json-devel.sha256sum] = "aea5da53db4be0d4f3552c7259de7fe5a85fde6304c42a5eda030c25fab8899d"

URI_aarch64_json-devel = "${EPEL_MIRROR}/aarch64/Packages/j/json-devel-3.11.3-2.el10_0.aarch64.rpm;name=aarch64_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_json-devel}"
SRC_URI[aarch64_json-devel.sha256sum] = "0f76add832c64737b6cfcbb487aac8ab94232132db95cc44d56bd62226d3fdb3"

RDEPENDS:json-devel = " \
 cmake-filesystem \
 libstdc++-devel \
 pkgconf-pkg-config \
 "
