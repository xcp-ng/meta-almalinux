# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lexertl17"
PE = "1"
PV = "1.1.3"
PR = "1.el10_0"
PACKAGES = " \
 lexertl17-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lexertl17-1.1.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c63be344fdab5cbdbf14e87abe7be67f679ae4b30c665218235409fa0b8d110a"

URI_x86_64_v2_lexertl17-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lexertl17-devel-1.1.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lexertl17-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lexertl17-devel}"
SRC_URI[x86_64_v2_lexertl17-devel.sha256sum] = "bd9609ebed9058cbfadb21275e82bb9743f18f4d2c07c9b7e908530435516c3c"

URI_aarch64_lexertl17-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lexertl17-devel-1.1.3-1.el10_0.aarch64.rpm;name=aarch64_lexertl17-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lexertl17-devel}"
SRC_URI[aarch64_lexertl17-devel.sha256sum] = "f2b94d6e9b3e4530e5d359b918a1c9f37718a4af526f8811c0f5a10987af9eaf"

RDEPENDS:lexertl17-devel = " \
 cmake-filesystem \
 "
