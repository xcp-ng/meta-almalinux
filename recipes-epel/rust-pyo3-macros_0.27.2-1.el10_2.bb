# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-macros"
PV = "0.27.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-pyo3-macros+default-devel \
 rust-pyo3-macros+experimental-async-devel \
 rust-pyo3-macros+experimental-inspect-devel \
 rust-pyo3-macros+multiple-pymethods-devel \
 rust-pyo3-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-macros-0.27.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90dc6b4ccd6a72e74e719de438eb4112a16ad05fe0ce0665762f507662137844"

URI_x86_64_v2_rust-pyo3-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros+default-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros+default-devel.sha256sum] = "8eaa2a669a95d3cdc71e96f6dff2de07af85e7da11e387a75ea815dfe30fca83"

URI_x86_64_v2_rust-pyo3-macros+experimental-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros+experimental-async-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros+experimental-async-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros+experimental-async-devel.sha256sum] = "2bcc0d6dd2a88cdae0cc52415b116bcbf73593f363ccb644458338531281754d"

URI_x86_64_v2_rust-pyo3-macros+experimental-inspect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros+experimental-inspect-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros+experimental-inspect-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros+experimental-inspect-devel.sha256sum] = "6fad9b9cded8035d6b02ae619d1f260e3edc11235246d55bef94809ab2040702"

URI_x86_64_v2_rust-pyo3-macros+multiple-pymethods-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros+multiple-pymethods-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros+multiple-pymethods-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros+multiple-pymethods-devel.sha256sum] = "3aeb841112fbce6fe7abb4679fe8e37af099b6c94c103b6315fb8ee2105e8e56"

URI_x86_64_v2_rust-pyo3-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-devel.sha256sum] = "992973319bc8f002284e259377601616b9ce3fbc94da5fd8591d5a44c07ac571"

URI_aarch64_rust-pyo3-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros+default-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros+default-devel}"
SRC_URI[aarch64_rust-pyo3-macros+default-devel.sha256sum] = "d3e524e807e5d5e9630b617453ab1592ec5f8e84fb47e5d5329a8870d394bed2"

URI_aarch64_rust-pyo3-macros+experimental-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros+experimental-async-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-macros+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros+experimental-async-devel}"
SRC_URI[aarch64_rust-pyo3-macros+experimental-async-devel.sha256sum] = "fb46da852ea88a8053674d4ff7b1a04acd3837a9b5e7333e0009584b22818645"

URI_aarch64_rust-pyo3-macros+experimental-inspect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros+experimental-inspect-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-macros+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros+experimental-inspect-devel}"
SRC_URI[aarch64_rust-pyo3-macros+experimental-inspect-devel.sha256sum] = "aabe1b90ac3e7c54fdfd0f0334224dc438f167854ab1bc5c2469d7dec7f2bcc9"

URI_aarch64_rust-pyo3-macros+multiple-pymethods-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros+multiple-pymethods-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-macros+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros+multiple-pymethods-devel}"
SRC_URI[aarch64_rust-pyo3-macros+multiple-pymethods-devel.sha256sum] = "3af8816780d5b7e619100083ff6b455db4852fc7ddb2d877392a8e1a5d20c2fc"

URI_aarch64_rust-pyo3-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-devel}"
SRC_URI[aarch64_rust-pyo3-macros-devel.sha256sum] = "cd06e352854cd68233ffb9d1d821cbaa36ffcfff273f96b07af6d2d80aca0b1d"

RDEPENDS:rust-pyo3-macros+default-devel = " \
 cargo \
 rust-pyo3-macros-devel \
 "
RDEPENDS:rust-pyo3-macros+experimental-async-devel = " \
 cargo \
 rust-pyo3-macros-backend+experimental-async-devel \
 rust-pyo3-macros-devel \
 "
RDEPENDS:rust-pyo3-macros+experimental-inspect-devel = " \
 cargo \
 rust-pyo3-macros-backend+experimental-inspect-devel \
 rust-pyo3-macros-devel \
 "
RDEPENDS:rust-pyo3-macros+multiple-pymethods-devel = " \
 cargo \
 rust-pyo3-macros-devel \
 "
RDEPENDS:rust-pyo3-macros-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 rust-pyo3-macros-backend+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 "
