# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "knavalbattle"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 knavalbattle \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/knavalbattle-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce8b5617ab8fbe8d0d4249b1fceb566d8621949f0dfa49cbbf8a754c7a791bfd"

URI_x86_64_v2_knavalbattle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knavalbattle-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knavalbattle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knavalbattle}"
SRC_URI[x86_64_v2_knavalbattle.sha256sum] = "bb680bca233adf845a28ab5bc5d6b19a34de3f5f58be843d33dd29b2454584d4"

URI_aarch64_knavalbattle = "${EPEL_MIRROR}/aarch64/Packages/k/knavalbattle-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_knavalbattle;unpack=0"
SRC_URI:append = " ${URI_aarch64_knavalbattle}"
SRC_URI[aarch64_knavalbattle.sha256sum] = "89c02b702b198b3c5d16ac350e52308c037b65225fc5c6c655ed7bc927d17397"

RDEPENDS:knavalbattle = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdnssd \
 kf6-ki18n \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
