# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-lcov-result"
PV = "0.5.3"
PR = "1.el10_1"
PACKAGES = " \
 python3-colcon-lcov-result \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-lcov-result-0.5.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a268a59f825b7493093e7e7626f6df61fe9732faf38096f5959880fcf10d2b72"

URI_x86_64_v2_python3-colcon-lcov-result = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-lcov-result-0.5.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-lcov-result;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-lcov-result}"
SRC_URI[x86_64_v2_python3-colcon-lcov-result.sha256sum] = "339d2893fe2bb4e1a8d84a24d1fca1c267de60955024691a2894ce2037629fb6"

URI_aarch64_python3-colcon-lcov-result = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-lcov-result-0.5.3-1.el10_1.noarch.rpm;name=aarch64_python3-colcon-lcov-result;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-lcov-result}"
SRC_URI[aarch64_python3-colcon-lcov-result.sha256sum] = "423e1a64c71ad2f1c8de553051d5f676019d985e27e58d83975d7f2f71e18df5"

RDEPENDS:python3-colcon-lcov-result = " \
 python3 \
 python3-colcon-core \
 "
