# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hickory-proto"
PV = "0.26.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-hickory-proto+access-control-devel \
 rust-hickory-proto+default-devel \
 rust-hickory-proto+mdns-devel \
 rust-hickory-proto+no-std-rand-devel \
 rust-hickory-proto+serde-devel \
 rust-hickory-proto+std-devel \
 rust-hickory-proto+testing-devel \
 rust-hickory-proto-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-hickory-proto-0.26.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c8f36fb6cae9666f186c4eec8969fec1903679b314bbb8c6749ca06da458f1fd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+access-control-devel-0.26.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+access-control-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hickory-proto+access-control-devel.sha256sum] = "2223fad5825d7939e6ae1a6eb98971c65a861b8786a2f658070fd49bcca3e2c9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+default-devel-0.26.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hickory-proto+default-devel.sha256sum] = "cbbc2b23f0a5e7a475df83179a52c96d9bcd0013d760a4983b1dc4310c2c53b1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+mdns-devel-0.26.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+mdns-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hickory-proto+mdns-devel.sha256sum] = "33c44f9c022ae39022d6ce2a046d41fb7aa4d5ebb76c90775e68e4e408ccd2a0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+no-std-rand-devel-0.26.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+no-std-rand-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hickory-proto+no-std-rand-devel.sha256sum] = "5c6115c12c9f4a88f52874b1197689a1aa0ef1285c59596d58c08ba54707c682"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+serde-devel-0.26.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hickory-proto+serde-devel.sha256sum] = "4447e6f551fa1e844430183288caa9df59b3638d9edab6643c0339547b678a90"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+std-devel-0.26.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hickory-proto+std-devel.sha256sum] = "1bd8d51589a95e1a89f674c429bdff66334e0b4750f7c1f85c896219b45697f3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+testing-devel-0.26.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+testing-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hickory-proto+testing-devel.sha256sum] = "8e678db2e5d0c541a255febf8dab4f3d4beb1cdd19f5892439bd69de454c424a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto-devel-0.26.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hickory-proto-devel.sha256sum] = "c166148e330fa70028934eb667277f5287b363bbf94ddaaa5672b39107d17287"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+access-control-devel-0.26.3-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-proto+access-control-devel;unpack=0"
SRC_URI[aarch64_rust-hickory-proto+access-control-devel.sha256sum] = "28d5ddbe17ef6de3d42884292110d5819389f25c9c52d8d99e5d8300420c3d89"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+default-devel-0.26.3-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-proto+default-devel;unpack=0"
SRC_URI[aarch64_rust-hickory-proto+default-devel.sha256sum] = "098572897ce5943f56bc4c49f7bfe63291da0f7a51e9e93746540ccb0fcaa519"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+mdns-devel-0.26.3-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-proto+mdns-devel;unpack=0"
SRC_URI[aarch64_rust-hickory-proto+mdns-devel.sha256sum] = "3e2a2f9faeb8c3a31e49bd85593612bbd5808a8d0c264d34fec2f84e5e889cb9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+no-std-rand-devel-0.26.3-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-proto+no-std-rand-devel;unpack=0"
SRC_URI[aarch64_rust-hickory-proto+no-std-rand-devel.sha256sum] = "914f59f6c2258bcb46bcb7674d4c1ef807c031ff4cc43ec6a9e50e2d48f6c244"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+serde-devel-0.26.3-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-proto+serde-devel;unpack=0"
SRC_URI[aarch64_rust-hickory-proto+serde-devel.sha256sum] = "890a6ddd743f3ab72d4a686974e101715f4834403efbf3c2b98a156cd4047ae5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+std-devel-0.26.3-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-proto+std-devel;unpack=0"
SRC_URI[aarch64_rust-hickory-proto+std-devel.sha256sum] = "6be2404005a86d23caf86b844e4a4fd85f76df73b753126d5a78e13af8d13a16"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+testing-devel-0.26.3-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-proto+testing-devel;unpack=0"
SRC_URI[aarch64_rust-hickory-proto+testing-devel.sha256sum] = "3a1542f02a1fba6f5ae41c167c0103849eacefdf1479d8616db0322871778601"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto-devel-0.26.3-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-proto-devel;unpack=0"
SRC_URI[aarch64_rust-hickory-proto-devel.sha256sum] = "fdbb050b33ade0b1c5fb75da45e1c7c544e2d326182ca81aa52c9319051389c9"

RDEPENDS:rust-hickory-proto+access-control-devel = " \
 cargo \
 rust-hickory-proto+std-devel \
 rust-hickory-proto-devel \
 rust-prefix-trie+default-devel \
 "
RDEPENDS:rust-hickory-proto+default-devel = " \
 cargo \
 rust-hickory-proto+std-devel \
 rust-hickory-proto-devel \
 "
RDEPENDS:rust-hickory-proto+mdns-devel = " \
 cargo \
 rust-hickory-proto-devel \
 "
RDEPENDS:rust-hickory-proto+no-std-rand-devel = " \
 cargo \
 rust-critical-section+default-devel \
 rust-hickory-proto-devel \
 rust-once_cell+critical-section-devel \
 "
RDEPENDS:rust-hickory-proto+serde-devel = " \
 cargo \
 rust-hickory-proto+std-devel \
 rust-hickory-proto-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-url+serde-devel \
 "
RDEPENDS:rust-hickory-proto+std-devel = " \
 cargo \
 rust-data-encoding+std-devel \
 rust-hickory-proto-devel \
 rust-ipnet+std-devel \
 rust-rand+std-devel \
 rust-rand+thread_rng-devel \
 rust-ring+default-devel \
 rust-ring+std-devel \
 rust-thiserror+std-devel \
 rust-tracing+std-devel \
 rust-url+std-devel \
 "
RDEPENDS:rust-hickory-proto+testing-devel = " \
 cargo \
 rust-hickory-proto+std-devel \
 rust-hickory-proto-devel \
 "
RDEPENDS:rust-hickory-proto-devel = " \
 cargo \
 rust \
 rust-data-encoding+alloc-devel \
 rust-data-encoding-devel \
 rust-idna+alloc-devel \
 rust-idna+compiled_data-devel \
 rust-idna-devel \
 rust-ipnet-devel \
 rust-once_cell+critical-section-devel \
 rust-once_cell-devel \
 rust-rand+alloc-devel \
 rust-rand+std_rng-devel \
 rust-rand-devel \
 rust-thiserror-devel \
 rust-tinyvec+alloc-devel \
 rust-tinyvec+default-devel \
 rust-tracing-devel \
 rust-url-devel \
 "
