# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-mattn-colorable"
PV = "0.1.13"
PR = "6.el10_0"
PACKAGES = " \
 golang-github-mattn-colorable-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-mattn-colorable-0.1.13-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5bee574f4182b636fd16c66d36f3cea63873b06bd062f9bc3c5bf6cbeeae203e"

URI_x86_64_v2_golang-github-mattn-colorable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-mattn-colorable-devel-0.1.13-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-mattn-colorable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-mattn-colorable-devel}"
SRC_URI[x86_64_v2_golang-github-mattn-colorable-devel.sha256sum] = "45af13d049c7885542839b83d1ca5747581d44c15ae9d1701f562b0e49d80e9d"

URI_aarch64_golang-github-mattn-colorable-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-mattn-colorable-devel-0.1.13-6.el10_0.noarch.rpm;name=aarch64_golang-github-mattn-colorable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-mattn-colorable-devel}"
SRC_URI[aarch64_golang-github-mattn-colorable-devel.sha256sum] = "7cdd9a43a045ece64a7df11aed16a7c1e18c3dd86c806a5039357950be2a2531"

RDEPENDS:golang-github-mattn-colorable-devel = " \
 go-filesystem \
 golang-github-mattn-isatty-devel \
 "
