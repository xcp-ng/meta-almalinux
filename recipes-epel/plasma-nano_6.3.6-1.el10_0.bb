# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-nano"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 plasma-nano \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-nano-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9a26c1fcb202ce031e92c5ed447f37a6292f0c1864b94b1b2e02bc4789a5ef75"

URI_x86_64_v2_plasma-nano = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nano-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nano;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-nano}"
SRC_URI[x86_64_v2_plasma-nano.sha256sum] = "f97f68fd1987c0100124d1230f25bfb75e2f86e296669c0279801398eed8913a"

URI_aarch64_plasma-nano = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-nano-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-nano;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-nano}"
SRC_URI[aarch64_plasma-nano.sha256sum] = "3d67c86788cb74b7e1c23a811cc66cd304d56a18045595af8939e97648afcb2c"

RDEPENDS:plasma-nano = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kpackage \
 kf6-kservice \
 kf6-kwindowsystem \
 kwayland \
 libplasma \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
