# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vte291"
PV = "0.78.1"
PR = "1.el10"
PACKAGES = " \
 vte-profile \
 vte291 \
 vte291-devel \
 vte291-gtk4 \
 vte291-gtk4-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/vte291-0.78.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2c03102cb63aec5a7017abd05f2f5aa0c23eadbac52ed9aa38e2677d91d254e0"

URI_x86_64_v2_vte-profile = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vte-profile-0.78.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_vte-profile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vte-profile}"
SRC_URI[x86_64_v2_vte-profile.sha256sum] = "04104a9aec97fc67f6808696b6ee73815aee253c6267cfe5f00744dfb4e82c96"

URI_x86_64_v2_vte291 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vte291-0.78.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_vte291;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vte291}"
SRC_URI[x86_64_v2_vte291.sha256sum] = "2d74e2f1abc91f961dc5cbfd8845007d20e0bc6403da550046b7b6db2e9603c0"

URI_x86_64_v2_vte291-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/vte291-devel-0.78.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_vte291-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vte291-devel}"
SRC_URI[x86_64_v2_vte291-devel.sha256sum] = "a3673c374816e1cecfb637b64b02f60504bee73afa16ff32b1bd6ede2e165060"

URI_x86_64_v2_vte291-gtk4 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vte291-gtk4-0.78.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_vte291-gtk4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vte291-gtk4}"
SRC_URI[x86_64_v2_vte291-gtk4.sha256sum] = "9bc28412c2a5640a8eb7509cfe6bbe8f59d003b142217db50ada557055c3678c"

URI_x86_64_v2_vte291-gtk4-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/vte291-gtk4-devel-0.78.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_vte291-gtk4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vte291-gtk4-devel}"
SRC_URI[x86_64_v2_vte291-gtk4-devel.sha256sum] = "b57e6b5d56ac684fb97aaa41597592f8ed77ffe37914359977d59caceb481b79"

URI_aarch64_vte-profile = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vte-profile-0.78.1-1.el10.aarch64.rpm;name=aarch64_vte-profile;unpack=0"
SRC_URI:append = " ${URI_aarch64_vte-profile}"
SRC_URI[aarch64_vte-profile.sha256sum] = "8b744b0fdb9045d8f52c9a681be44966fab22c3baabfa8d8f353d0e63264ec12"

URI_aarch64_vte291 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vte291-0.78.1-1.el10.aarch64.rpm;name=aarch64_vte291;unpack=0"
SRC_URI:append = " ${URI_aarch64_vte291}"
SRC_URI[aarch64_vte291.sha256sum] = "cbaf298ba95319ea6c25ca9c68abe4b3fb0b09f0b223d9fa691b77d361b514a3"

URI_aarch64_vte291-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/vte291-devel-0.78.1-1.el10.aarch64.rpm;name=aarch64_vte291-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vte291-devel}"
SRC_URI[aarch64_vte291-devel.sha256sum] = "10732b12b406eb75ff214a026458898ac7b5ebc5ff80e5b83289f2465a090191"

URI_aarch64_vte291-gtk4 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vte291-gtk4-0.78.1-1.el10.aarch64.rpm;name=aarch64_vte291-gtk4;unpack=0"
SRC_URI:append = " ${URI_aarch64_vte291-gtk4}"
SRC_URI[aarch64_vte291-gtk4.sha256sum] = "71fff8c1dca4252ef0f49ed3d7a6f4e4e3d3773167a7168de1174db522640bd6"

URI_aarch64_vte291-gtk4-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/vte291-gtk4-devel-0.78.1-1.el10.aarch64.rpm;name=aarch64_vte291-gtk4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vte291-gtk4-devel}"
SRC_URI[aarch64_vte291-gtk4-devel.sha256sum] = "dce599a40b9fee9666c54c89266018a5d0d57589025279d8be04ba711c5b82ff"

RDEPENDS:vte-profile = " \
 glibc \
 "
RDEPENDS:vte291 = " \
 atk \
 cairo \
 cairo-gobject \
 fribidi \
 glib2 \
 glibc \
 gnutls \
 gtk3 \
 libgcc \
 libicu \
 libstdc++ \
 lz4-libs \
 pango \
 pcre2 \
 systemd-libs \
 vte-profile \
 "
RDEPENDS:vte291-devel = " \
 cairo \
 cairo-devel \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glib2-devel \
 glibc \
 gtk3 \
 gtk3-devel \
 libgcc \
 libstdc++ \
 pango \
 pango-devel \
 pkgconf-pkg-config \
 vte291 \
 "
RDEPENDS:vte291-gtk4 = " \
 cairo \
 cairo-gobject \
 fribidi \
 glib2 \
 glibc \
 gnutls \
 graphene \
 gtk4 \
 libgcc \
 libicu \
 libstdc++ \
 lz4-libs \
 pango \
 pcre2 \
 systemd-libs \
 vte291 \
 "
RDEPENDS:vte291-gtk4-devel = " \
 cairo \
 cairo-devel \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glib2-devel \
 glibc \
 gtk4 \
 gtk4-devel \
 libgcc \
 libstdc++ \
 pango \
 pango-devel \
 pkgconf-pkg-config \
 vte291-devel \
 vte291-gtk4 \
 "
