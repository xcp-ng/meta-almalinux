# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libvma"
PV = "9.8.60"
PR = "3.el10"
PACKAGES = " \
 libvma \
 libvma-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libvma-9.8.60-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7bfbc2b18f637491bbe49adbf95f1450b69e06c1a7724f2f12f978f24448cb19"

URI_x86_64_v2_libvma = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvma-9.8.60-3.el10.x86_64_v2.rpm;name=x86_64_v2_libvma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvma}"
SRC_URI[x86_64_v2_libvma.sha256sum] = "528c27b4af3752ae5bc2c4521385c32232a0ca2a1d1752fc74a3e2409f84f8f9"

URI_x86_64_v2_libvma-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvma-utils-9.8.60-3.el10.x86_64_v2.rpm;name=x86_64_v2_libvma-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvma-utils}"
SRC_URI[x86_64_v2_libvma-utils.sha256sum] = "2b00ff9d2a309795b8000505f65b2939a12fdf218bb6292bd80f8675158ee193"

URI_aarch64_libvma = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvma-9.8.60-3.el10.aarch64.rpm;name=aarch64_libvma;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvma}"
SRC_URI[aarch64_libvma.sha256sum] = "96bf9d456c6b8dbe722138750128872574f23a7f926370f340a3227c379c1ef5"

URI_aarch64_libvma-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvma-utils-9.8.60-3.el10.aarch64.rpm;name=aarch64_libvma-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvma-utils}"
SRC_URI[aarch64_libvma-utils.sha256sum] = "86a574684a40417642ceeaa8617e89885bca451caa48b037a5190a4e79af3a50"

RDEPENDS:libvma = " \
 bash \
 glibc \
 libgcc \
 libibverbs \
 libnl3 \
 librdmacm \
 libstdc++ \
 "
RDEPENDS:libvma-utils = " \
 glibc \
 libgcc \
 libstdc++ \
 libvma \
 "
