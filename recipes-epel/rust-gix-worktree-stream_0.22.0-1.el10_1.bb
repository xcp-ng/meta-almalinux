# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-worktree-stream"
PV = "0.22.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-worktree-stream+default-devel \
 rust-gix-worktree-stream-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-worktree-stream-0.22.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "34cd5fbc1903009bb84c0862fead332c868490773f705f60ab88e6080a23a8da"

URI_x86_64_v2_rust-gix-worktree-stream+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree-stream+default-devel-0.22.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree-stream+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree-stream+default-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree-stream+default-devel.sha256sum] = "005a537479010a04050c431675c353701f44b6c299c38d0f3014489cb9a1a92e"

URI_x86_64_v2_rust-gix-worktree-stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree-stream-devel-0.22.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree-stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree-stream-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree-stream-devel.sha256sum] = "0ee5a91a76eb60d88a01347645921ebcd2f87aee743f89bd223ec3b2b16edcad"

URI_aarch64_rust-gix-worktree-stream+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree-stream+default-devel-0.22.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-worktree-stream+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree-stream+default-devel}"
SRC_URI[aarch64_rust-gix-worktree-stream+default-devel.sha256sum] = "723dbf541166a8cc16b46fada81b9d88ce535e8e06cc637c60d6b0f78072e54d"

URI_aarch64_rust-gix-worktree-stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree-stream-devel-0.22.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-worktree-stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree-stream-devel}"
SRC_URI[aarch64_rust-gix-worktree-stream-devel.sha256sum] = "86e160aa2b7db562608a85f69ecbbfd9665d6229ce4a459371bca50ecf967251"

RDEPENDS:rust-gix-worktree-stream+default-devel = " \
 cargo \
 rust-gix-worktree-stream-devel \
 "
RDEPENDS:rust-gix-worktree-stream-devel = " \
 cargo \
 rust \
 rust-gix-attributes+default-devel \
 rust-gix-features+default-devel \
 rust-gix-features+io-pipe-devel \
 rust-gix-features+progress-devel \
 rust-gix-filter+default-devel \
 rust-gix-fs+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-object+default-devel \
 rust-gix-path+default-devel \
 rust-gix-traverse+default-devel \
 rust-parking_lot+default-devel \
 rust-thiserror+default-devel \
 "
