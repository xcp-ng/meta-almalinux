# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clide"
PV = "0.9"
PR = "36.20160305git11c0895.el10_0"
PACKAGES = " \
 clide \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/clide-0.9-36.20160305git11c0895.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f8f9a9630447713efe105118e71d363deb4f6576686948ba5a4c60e470bc8a9"

URI_x86_64_v2_clide = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clide-0.9-36.20160305git11c0895.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_clide;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clide}"
SRC_URI[x86_64_v2_clide.sha256sum] = "38b9b994e5a99d4455ee29c84425ebc7dddc448e2eddf9a79299cdcc2dc35e4f"

URI_aarch64_clide = "${EPEL_MIRROR}/aarch64/Packages/c/clide-0.9-36.20160305git11c0895.el10_0.noarch.rpm;name=aarch64_clide;unpack=0"
SRC_URI:append = " ${URI_aarch64_clide}"
SRC_URI[aarch64_clide.sha256sum] = "e681fefecaa80cdbf49765107e83976ca437aa4150e0e0b48b539ac4b19f0d37"

RDEPENDS:clide = " \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 "
