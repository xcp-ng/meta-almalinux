# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "udunits2"
PV = "2.2.28"
PR = "9.el10_1"
PACKAGES = " \
 udunits2 \
 udunits2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/udunits2-2.2.28-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb356ed25b2d9426dd783b41f9b1a139aa765c58dcaa273d9709186fe2d35db9"

URI_x86_64_v2_udunits2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/udunits2-2.2.28-9.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_udunits2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_udunits2}"
SRC_URI[x86_64_v2_udunits2.sha256sum] = "a3bf9fd3dccdcc8b58281b7700eb3a0496293999924509d9bb9ad55f77f610f3"

URI_x86_64_v2_udunits2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/udunits2-devel-2.2.28-9.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_udunits2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_udunits2-devel}"
SRC_URI[x86_64_v2_udunits2-devel.sha256sum] = "25710883515a0765a829208805ef8854c78a7f99484c3732feca6298d79837b7"

URI_aarch64_udunits2 = "${EPEL_MIRROR}/aarch64/Packages/u/udunits2-2.2.28-9.el10_1.aarch64.rpm;name=aarch64_udunits2;unpack=0"
SRC_URI:append = " ${URI_aarch64_udunits2}"
SRC_URI[aarch64_udunits2.sha256sum] = "b3bfae66caed4f41234cd641c6d0dabde084cdca473cb7a56aa5d0f82cec6f3b"

URI_aarch64_udunits2-devel = "${EPEL_MIRROR}/aarch64/Packages/u/udunits2-devel-2.2.28-9.el10_1.aarch64.rpm;name=aarch64_udunits2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_udunits2-devel}"
SRC_URI[aarch64_udunits2-devel.sha256sum] = "29c0a6fddcd141afdb79a5bfe4fcfb15b539d7a3ecbd5af2bdb3ea868cda7c84"

RDEPENDS:udunits2 = " \
 expat \
 glibc \
 "
RDEPENDS:udunits2-devel = " \
 udunits2 \
 "
