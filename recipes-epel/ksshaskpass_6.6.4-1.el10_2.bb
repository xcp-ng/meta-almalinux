# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksshaskpass"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 ksshaskpass \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ksshaskpass-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a5c1285c96f8be752ca8f2361fb60696e8fccb310abed47d997a553703018da1"

URI_x86_64_v2_ksshaskpass = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksshaskpass-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksshaskpass;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksshaskpass}"
SRC_URI[x86_64_v2_ksshaskpass.sha256sum] = "ea3d080c3c412e1b371d0ff90b8d284dd765d730ba4fbd140431a8a81d9a22d4"

URI_aarch64_ksshaskpass = "${EPEL_MIRROR}/aarch64/Packages/k/ksshaskpass-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_ksshaskpass;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksshaskpass}"
SRC_URI[aarch64_ksshaskpass.sha256sum] = "7f789842ae7bd2eccfada09a89c4d13be2bae9ee75a000f333c686b6210a80df"

RDEPENDS:ksshaskpass = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
