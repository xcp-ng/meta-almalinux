# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.14"
PV = "3.14.7"
PR = "2.el10_2"
PACKAGES = " \
 python3.14 \
 python3.14-debug \
 python3.14-devel \
 python3.14-freethreading \
 python3.14-freethreading-debug \
 python3.14-freethreading-devel \
 python3.14-freethreading-idle \
 python3.14-freethreading-libs \
 python3.14-freethreading-test \
 python3.14-freethreading-tkinter \
 python3.14-idle \
 python3.14-libs \
 python3.14-test \
 python3.14-tkinter \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python3.14-3.14.7-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e0ae893002b38d4aea7af315edf80fa1f657f501af291f8ff7957b403f362570"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - python3.14-freethreading-test: (python3.14-wheel-wheel if python3.14-setuptools-wheel < 71)
# - python3.14-test: (python3.14-wheel-wheel if python3.14-setuptools-wheel < 71)

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - python3.14-freethreading-test: (python3.14-wheel-wheel if python3.14-setuptools-wheel < 71)
# - python3.14-test: (python3.14-wheel-wheel if python3.14-setuptools-wheel < 71)

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-3.14.7-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3.14;unpack=0"
SRC_URI[x86_64_v2_python3.14.sha256sum] = "0f5170d0d4a6366b8721c4e9c2122707c5ef8e407bcd01bb515afbaf575870f6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-debug-3.14.7-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3.14-debug;unpack=0"
SRC_URI[x86_64_v2_python3.14-debug.sha256sum] = "4bc7312e5ddb4d7a66101457a2cf0efda7b82e59844d38246df9311b40331044"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-devel-3.14.7-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3.14-devel;unpack=0"
SRC_URI[x86_64_v2_python3.14-devel.sha256sum] = "d2627eab63db07e0cc6189f94513b985590f889d1900aec72b88ed8e5d71d0c8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-freethreading-3.14.7-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3.14-freethreading;unpack=0"
SRC_URI[x86_64_v2_python3.14-freethreading.sha256sum] = "3e97ec1a19f45fb1267b1cd5ee5c730ba8207749a303403563ce802ec2e4ba55"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-freethreading-debug-3.14.7-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3.14-freethreading-debug;unpack=0"
SRC_URI[x86_64_v2_python3.14-freethreading-debug.sha256sum] = "15131ca28861404ce38ccdc33d53ea0a09e80562d25ef24d7f793088bcc20d25"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-freethreading-devel-3.14.7-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3.14-freethreading-devel;unpack=0"
SRC_URI[x86_64_v2_python3.14-freethreading-devel.sha256sum] = "906abefdac75412d797a663d22ccfb356dc4eb7dd8affd83a5a0465c7810ebbf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-freethreading-idle-3.14.7-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3.14-freethreading-idle;unpack=0"
SRC_URI[x86_64_v2_python3.14-freethreading-idle.sha256sum] = "52747795ccb69e18365e3a5f31f4d4e2140f831bc5c11ac1578659ac7a1efa51"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-freethreading-libs-3.14.7-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3.14-freethreading-libs;unpack=0"
SRC_URI[x86_64_v2_python3.14-freethreading-libs.sha256sum] = "af11cf7b58ae920245f97b4208dbf08d03448cdb74d14ebb6b95e01178032f1a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-freethreading-test-3.14.7-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3.14-freethreading-test;unpack=0"
SRC_URI[x86_64_v2_python3.14-freethreading-test.sha256sum] = "d16bd220abbc8078d31028fdf8835c439222edd4b80f561aad694999c171f8d6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-freethreading-tkinter-3.14.7-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3.14-freethreading-tkinter;unpack=0"
SRC_URI[x86_64_v2_python3.14-freethreading-tkinter.sha256sum] = "3b1cfa732d8dfaf2fdccee111c8f7a7286ebea8ea11d560d5d1045ff6a8269f8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-idle-3.14.7-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3.14-idle;unpack=0"
SRC_URI[x86_64_v2_python3.14-idle.sha256sum] = "162e452d46e5460d9f34d16c40dd9a4eb962e7f570ec10105c6e72b26af01b58"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-libs-3.14.7-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3.14-libs;unpack=0"
SRC_URI[x86_64_v2_python3.14-libs.sha256sum] = "f4ee533350ccabedf24477c74ad639fa180c0ba0faa31aff8486f0b857bb606c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-test-3.14.7-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3.14-test;unpack=0"
SRC_URI[x86_64_v2_python3.14-test.sha256sum] = "dd5d47b25f130e9c25d8d298110819760923cd592696d1defb0bab01955bf063"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-tkinter-3.14.7-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3.14-tkinter;unpack=0"
SRC_URI[x86_64_v2_python3.14-tkinter.sha256sum] = "14656cd8159c0c8cf04fb037dd2ab6f33c58d8a04c18fc15560e3a1b1a8aa36f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-3.14.7-2.el10_2.aarch64.rpm;name=aarch64_python3.14;unpack=0"
SRC_URI[aarch64_python3.14.sha256sum] = "c12e2b503f609bdd0f9e0ac50bd0e59b18d38c052391bfd10bd636e9bf0aa92e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-debug-3.14.7-2.el10_2.aarch64.rpm;name=aarch64_python3.14-debug;unpack=0"
SRC_URI[aarch64_python3.14-debug.sha256sum] = "14f9aabc2fcd7e2ffd9f151515cba990c09e1dac8c36823f4ff1867a779325af"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-devel-3.14.7-2.el10_2.aarch64.rpm;name=aarch64_python3.14-devel;unpack=0"
SRC_URI[aarch64_python3.14-devel.sha256sum] = "76f2f6df968bf2c197769735a5aa26608d83916af9d5a665b8c82c5d00731617"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-freethreading-3.14.7-2.el10_2.aarch64.rpm;name=aarch64_python3.14-freethreading;unpack=0"
SRC_URI[aarch64_python3.14-freethreading.sha256sum] = "99b0e60df34142ebedfd9423f1d9b454c33e8a5db46e5fb7423428644d4ae62d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-freethreading-debug-3.14.7-2.el10_2.aarch64.rpm;name=aarch64_python3.14-freethreading-debug;unpack=0"
SRC_URI[aarch64_python3.14-freethreading-debug.sha256sum] = "c37032d0fea57430656d7ac719b5b911674c6eb2767d886a9bb4b35167d6415d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-freethreading-devel-3.14.7-2.el10_2.aarch64.rpm;name=aarch64_python3.14-freethreading-devel;unpack=0"
SRC_URI[aarch64_python3.14-freethreading-devel.sha256sum] = "ea3fd94f9a9b5477a1583e306db415c4e8171baa54afb1f2f66cade5702c1a2b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-freethreading-idle-3.14.7-2.el10_2.aarch64.rpm;name=aarch64_python3.14-freethreading-idle;unpack=0"
SRC_URI[aarch64_python3.14-freethreading-idle.sha256sum] = "02cece9fd3045cf91bc28fbf91375c58d4ab05391f71509e379fdf2aa1a8af00"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-freethreading-libs-3.14.7-2.el10_2.aarch64.rpm;name=aarch64_python3.14-freethreading-libs;unpack=0"
SRC_URI[aarch64_python3.14-freethreading-libs.sha256sum] = "9bfd74c67765a43542808adf938e8a81028aa8d62e71835d33ac143b84c57ba4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-freethreading-test-3.14.7-2.el10_2.aarch64.rpm;name=aarch64_python3.14-freethreading-test;unpack=0"
SRC_URI[aarch64_python3.14-freethreading-test.sha256sum] = "f7ec5ab8e101cba0fa6e7a7ce5d12d86b51b685565ade040d4408e1c38ca2de4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-freethreading-tkinter-3.14.7-2.el10_2.aarch64.rpm;name=aarch64_python3.14-freethreading-tkinter;unpack=0"
SRC_URI[aarch64_python3.14-freethreading-tkinter.sha256sum] = "28f7ee0c1d61a43d671e05386bea1fb756f351dba7a5e147ade875d3c6cd3ee3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-idle-3.14.7-2.el10_2.aarch64.rpm;name=aarch64_python3.14-idle;unpack=0"
SRC_URI[aarch64_python3.14-idle.sha256sum] = "a14e40f2a80a5725c56d14e5c067b1c2f25b38ba141ab20a99d5ea0a8ab3bfc7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-libs-3.14.7-2.el10_2.aarch64.rpm;name=aarch64_python3.14-libs;unpack=0"
SRC_URI[aarch64_python3.14-libs.sha256sum] = "ae7dbc120cdc07ef726c25dbac844c7e1f143c4a269294c80c722ae549c18236"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-test-3.14.7-2.el10_2.aarch64.rpm;name=aarch64_python3.14-test;unpack=0"
SRC_URI[aarch64_python3.14-test.sha256sum] = "a2b6555509aab2b47f08812d4af60952f72a465d7ed89a7e8c14590bd61efb53"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-tkinter-3.14.7-2.el10_2.aarch64.rpm;name=aarch64_python3.14-tkinter;unpack=0"
SRC_URI[aarch64_python3.14-tkinter.sha256sum] = "6b56c3bf948b7af07ce9f05166850decc8300495eaf9aef37e56338d93a58d13"

RDEPENDS:python3.14 = " \
 glibc \
 python3.14-libs \
 "
RDEPENDS:python3.14-debug = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libgcc \
 libuuid \
 libzstd \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 pkgconf-pkg-config \
 python3.14 \
 python3.14-devel \
 python3.14-idle \
 python3.14-libs \
 python3.14-test \
 python3.14-tkinter \
 readline \
 sqlite-libs \
 tcl \
 tk \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3.14-devel = " \
 bash \
 pkgconf-pkg-config \
 python-rpm-macros \
 python3-rpm-generators \
 python3-rpm-macros \
 python3.14 \
 python3.14-libs \
 "
RDEPENDS:python3.14-freethreading = " \
 glibc \
 python3.14-freethreading-libs \
 "
RDEPENDS:python3.14-freethreading-debug = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libgcc \
 libuuid \
 libzstd \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 pkgconf-pkg-config \
 python3.14-freethreading \
 python3.14-freethreading-devel \
 python3.14-freethreading-idle \
 python3.14-freethreading-libs \
 python3.14-freethreading-test \
 python3.14-freethreading-tkinter \
 readline \
 sqlite-libs \
 tcl \
 tk \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3.14-freethreading-devel = " \
 bash \
 pkgconf-pkg-config \
 python3.14-freethreading \
 python3.14-freethreading-libs \
 "
RDEPENDS:python3.14-freethreading-idle = " \
 python3.14-freethreading \
 python3.14-freethreading-tkinter \
 "
RDEPENDS:python3.14-freethreading-libs = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libuuid \
 libzstd \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 python3.14-pip-wheel \
 readline \
 sqlite-libs \
 tzdata \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3.14-freethreading-test = " \
 bash \
 glibc \
 libgcc \
 python3.14-freethreading \
 python3.14-freethreading-libs \
 python3.14-setuptools-wheel \
 "
RDEPENDS:python3.14-freethreading-tkinter = " \
 glibc \
 python3.14-freethreading \
 tcl \
 tk \
 "
RDEPENDS:python3.14-idle = " \
 python3.14 \
 python3.14-tkinter \
 "
RDEPENDS:python3.14-libs = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libuuid \
 libzstd \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 python3.14-pip-wheel \
 readline \
 sqlite-libs \
 tzdata \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3.14-test = " \
 bash \
 glibc \
 libgcc \
 python3.14 \
 python3.14-libs \
 python3.14-setuptools-wheel \
 "
RDEPENDS:python3.14-tkinter = " \
 glibc \
 python3.14 \
 tcl \
 tk \
 "
