# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-File-Next"
PV = "1.18"
PR = "17.el10_0"
PACKAGES = " \
 perl-File-Next \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-File-Next-1.18-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36c655085371c92d383be23705e4d1c98e5c6d0da3e256a20d883a7daefbb431"

URI_x86_64_v2_perl-File-Next = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-File-Next-1.18-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-File-Next;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-Next}"
SRC_URI[x86_64_v2_perl-File-Next.sha256sum] = "f9a9324b8cb756eec7e9f081652049fadfbbf4c558ad71870e2420e73b222947"

URI_aarch64_perl-File-Next = "${EPEL_MIRROR}/aarch64/Packages/p/perl-File-Next-1.18-17.el10_0.noarch.rpm;name=aarch64_perl-File-Next;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-Next}"
SRC_URI[aarch64_perl-File-Next.sha256sum] = "757028988d89cdcfc789f98d49dbd663f06a35d3604905871a0f6e25a7d5d3fd"

RDEPENDS:perl-File-Next = " \
 perl-PathTools \
 perl-libs \
 "
