# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-syntax-highlighting"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-syntax-highlighting \
 kf6-syntax-highlighting-devel \
 kf6-syntax-highlighting-doc \
 kf6-syntax-highlighting-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-syntax-highlighting-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f09bd4f1335da3e0ed377a1b3efb5f2e97491f87ebe54e9cfc93617423b1be6a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syntax-highlighting-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-syntax-highlighting;unpack=0"
SRC_URI[x86_64_v2_kf6-syntax-highlighting.sha256sum] = "399467e1e7f71889c3e5d83f70a3ae02d14b8af49f33e38ed530a00f84935381"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syntax-highlighting-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-syntax-highlighting-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-syntax-highlighting-devel.sha256sum] = "d82bbe44d1411de28cade219d8250073f46b847bfb3dfd5b79cbc99f41dd1744"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syntax-highlighting-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-syntax-highlighting-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-syntax-highlighting-doc.sha256sum] = "0a84dabb0b00093a0fbfb66ad329d16c2220ffde13c31fbf14dc1d03d0749784"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syntax-highlighting-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-syntax-highlighting-html;unpack=0"
SRC_URI[x86_64_v2_kf6-syntax-highlighting-html.sha256sum] = "9b3162c63f94b846bb296864bb725431d26b07f7ba1cf0bc9429ef13a913e195"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-syntax-highlighting-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-syntax-highlighting;unpack=0"
SRC_URI[aarch64_kf6-syntax-highlighting.sha256sum] = "2086ffc867e968e8332cc159c35486837df40ce4e5551f70f44165b582ba2749"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-syntax-highlighting-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-syntax-highlighting-devel;unpack=0"
SRC_URI[aarch64_kf6-syntax-highlighting-devel.sha256sum] = "6ab69c649b0e41d46e65671437350bb086aa8b5a5571a28f96c593e859a2e58b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-syntax-highlighting-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-syntax-highlighting-doc;unpack=0"
SRC_URI[aarch64_kf6-syntax-highlighting-doc.sha256sum] = "44a48ce73159620d86a073b935d4cd74c79a863780eb5ea7b8b252693c930cfa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-syntax-highlighting-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-syntax-highlighting-html;unpack=0"
SRC_URI[aarch64_kf6-syntax-highlighting-html.sha256sum] = "34e2a67a08730bbb6c33bcd6407cfd6aadae51c2cd6a1ea2cec766bc9f3584de"

RDEPENDS:kf6-syntax-highlighting = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-syntax-highlighting-devel = " \
 cmake-filesystem \
 kf6-syntax-highlighting \
 "
RDEPENDS:kf6-syntax-highlighting-doc = " \
 "
RDEPENDS:kf6-syntax-highlighting-html = " \
 "
