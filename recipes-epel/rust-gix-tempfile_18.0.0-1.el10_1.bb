# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-tempfile"
PV = "18.0.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-tempfile+default-devel \
 rust-gix-tempfile+document-features-devel \
 rust-gix-tempfile+hp-hashmap-devel \
 rust-gix-tempfile+signals-devel \
 rust-gix-tempfile-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-tempfile-18.0.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5852730e92fb85aef352b0f218fd03469e9199096bbe6563eef7d51a10eb495d"

URI_x86_64_v2_rust-gix-tempfile+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-tempfile+default-devel-18.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-tempfile+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-tempfile+default-devel}"
SRC_URI[x86_64_v2_rust-gix-tempfile+default-devel.sha256sum] = "c6ec6e1ee604e95dbc9bd7d56e9eebe293a75181e98624944cef98cb2a40e673"

URI_x86_64_v2_rust-gix-tempfile+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-tempfile+document-features-devel-18.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-tempfile+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-tempfile+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-tempfile+document-features-devel.sha256sum] = "20e172dfb7d1f2ce06011653965c8cbb977f10be27f0d5b156b9ebbcd77910f3"

URI_x86_64_v2_rust-gix-tempfile+hp-hashmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-tempfile+hp-hashmap-devel-18.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-tempfile+hp-hashmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-tempfile+hp-hashmap-devel}"
SRC_URI[x86_64_v2_rust-gix-tempfile+hp-hashmap-devel.sha256sum] = "6b1464e040eabbf5a0dee292b9007cac4a6081e0d6c643b2fd0ee5a7d387aeaa"

URI_x86_64_v2_rust-gix-tempfile+signals-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-tempfile+signals-devel-18.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-tempfile+signals-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-tempfile+signals-devel}"
SRC_URI[x86_64_v2_rust-gix-tempfile+signals-devel.sha256sum] = "cf94a2ec8092bc3c29a018a091b3c17805e37b1ac0fdf5164d7ee9486f7868b7"

URI_x86_64_v2_rust-gix-tempfile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-tempfile-devel-18.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-tempfile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-tempfile-devel}"
SRC_URI[x86_64_v2_rust-gix-tempfile-devel.sha256sum] = "e728c687e1301b84d358e2434a190cd52f8283d45c0d2e5671d5e16f38d169a3"

URI_aarch64_rust-gix-tempfile+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-tempfile+default-devel-18.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-tempfile+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-tempfile+default-devel}"
SRC_URI[aarch64_rust-gix-tempfile+default-devel.sha256sum] = "b20c2d325318f762a37469c1767f538e8035bfc2cb9641ee076fc63eeae8ffe1"

URI_aarch64_rust-gix-tempfile+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-tempfile+document-features-devel-18.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-tempfile+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-tempfile+document-features-devel}"
SRC_URI[aarch64_rust-gix-tempfile+document-features-devel.sha256sum] = "fed5ef20507eaa2427ab1f741336a7f262ebf381b7ecd8fdb6b23df5f8665a58"

URI_aarch64_rust-gix-tempfile+hp-hashmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-tempfile+hp-hashmap-devel-18.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-tempfile+hp-hashmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-tempfile+hp-hashmap-devel}"
SRC_URI[aarch64_rust-gix-tempfile+hp-hashmap-devel.sha256sum] = "91526b6137cf629f09a9a3510e906e08bdfe0fb6a0fb2b3849eb827e47036ac2"

URI_aarch64_rust-gix-tempfile+signals-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-tempfile+signals-devel-18.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-tempfile+signals-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-tempfile+signals-devel}"
SRC_URI[aarch64_rust-gix-tempfile+signals-devel.sha256sum] = "2d552e94ab00dc20148878c104922096f7730097da578314395783770093093e"

URI_aarch64_rust-gix-tempfile-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-tempfile-devel-18.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-tempfile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-tempfile-devel}"
SRC_URI[aarch64_rust-gix-tempfile-devel.sha256sum] = "0ae22dd77fd1e9d3c9b2f77ee267b7275ddb0bafb54d85b171bace78e6512db7"

RDEPENDS:rust-gix-tempfile+default-devel = " \
 cargo \
 rust-gix-tempfile+hp-hashmap-devel \
 rust-gix-tempfile-devel \
 "
RDEPENDS:rust-gix-tempfile+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-tempfile-devel \
 "
RDEPENDS:rust-gix-tempfile+hp-hashmap-devel = " \
 cargo \
 rust-dashmap+default-devel \
 rust-gix-tempfile-devel \
 "
RDEPENDS:rust-gix-tempfile+signals-devel = " \
 cargo \
 rust-gix-tempfile-devel \
 rust-signal-hook-devel \
 rust-signal-hook-registry+default-devel \
 "
RDEPENDS:rust-gix-tempfile-devel = " \
 cargo \
 rust \
 rust-gix-fs+default-devel \
 rust-libc-devel \
 rust-once_cell+race-devel \
 rust-once_cell+std-devel \
 rust-once_cell-devel \
 rust-parking_lot+default-devel \
 rust-tempfile+default-devel \
 "
