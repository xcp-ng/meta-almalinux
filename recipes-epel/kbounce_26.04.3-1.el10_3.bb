# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kbounce"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kbounce \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kbounce-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3bd95014bce8033a3c4f35ee571431f20842c1a538a395f7e24f7aab83de436"

URI_x86_64_v2_kbounce = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kbounce-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kbounce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kbounce}"
SRC_URI[x86_64_v2_kbounce.sha256sum] = "57de4a3f441a9bf393a347dee3dcfadfcd24285b7709f2a1251bdbf61dde9e7f"

URI_aarch64_kbounce = "${EPEL_MIRROR}/aarch64/Packages/k/kbounce-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kbounce;unpack=0"
SRC_URI:append = " ${URI_aarch64_kbounce}"
SRC_URI[aarch64_kbounce.sha256sum] = "7f39c50854ef0d2a20231feab17dc092cc6a09fd95110fc301880359ca58aad7"

RDEPENDS:kbounce = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
