# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nodejs-packaging"
PV = "2023.10"
PR = "9.el10_0"
PACKAGES = " \
 nodejs-packaging \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nodejs-packaging-2023.10-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cfef7753f4cb8ef2adfc2c2583bf9e2b12be999b0976e3b131d0596c20b8d6b7"

URI_x86_64_v2_nodejs-packaging = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-packaging-2023.10-9.el10_0.noarch.rpm;name=x86_64_v2_nodejs-packaging;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs-packaging}"
SRC_URI[x86_64_v2_nodejs-packaging.sha256sum] = "77ed7d6846ba534d705102ef894a1b377814d5a9fb0cf9d9d3afe573ebeaa5c4"

URI_aarch64_nodejs-packaging = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-packaging-2023.10-9.el10_0.noarch.rpm;name=aarch64_nodejs-packaging;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs-packaging}"
SRC_URI[aarch64_nodejs-packaging.sha256sum] = "77ed7d6846ba534d705102ef894a1b377814d5a9fb0cf9d9d3afe573ebeaa5c4"

RDEPENDS:nodejs-packaging = " \
 python3 \
 redhat-rpm-config \
 "
