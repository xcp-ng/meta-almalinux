# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ntfs-3g"
PE = "2"
PV = "2022.10.3"
PR = "9.el10_0"
PACKAGES = " \
 ntfs-3g \
 ntfs-3g-devel \
 ntfs-3g-libs \
 ntfsprogs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/ntfs-3g-2022.10.3-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b34fb1c35717977e49173df72cd0803dccf0598e61a2fc0ad72b5b3563b5839d"

URI_x86_64_v2_ntfs-3g = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ntfs-3g-2022.10.3-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ntfs-3g;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ntfs-3g}"
SRC_URI[x86_64_v2_ntfs-3g.sha256sum] = "f63c646a16fe06230dc4c1dbb72ae140cb37c537fef6902542bb2e66df6a47b4"

URI_x86_64_v2_ntfs-3g-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ntfs-3g-devel-2022.10.3-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ntfs-3g-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ntfs-3g-devel}"
SRC_URI[x86_64_v2_ntfs-3g-devel.sha256sum] = "e7b7120c8bc135fc49bdb4c3ccb15c0947c85f7849f9a28e98d4e687c1e8956f"

URI_x86_64_v2_ntfs-3g-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ntfs-3g-libs-2022.10.3-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ntfs-3g-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ntfs-3g-libs}"
SRC_URI[x86_64_v2_ntfs-3g-libs.sha256sum] = "7e692d8565117ff3117fad655f216e8ca0c5f2e65bba19dc418f993bf276b907"

URI_x86_64_v2_ntfsprogs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ntfsprogs-2022.10.3-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ntfsprogs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ntfsprogs}"
SRC_URI[x86_64_v2_ntfsprogs.sha256sum] = "5b3f380656d9137df4b50e5f10a97d3609e05b75a1c7dba1632ee674ae9f65f0"

URI_aarch64_ntfs-3g = "${EPEL_MIRROR}/aarch64/Packages/n/ntfs-3g-2022.10.3-9.el10_0.aarch64.rpm;name=aarch64_ntfs-3g;unpack=0"
SRC_URI:append = " ${URI_aarch64_ntfs-3g}"
SRC_URI[aarch64_ntfs-3g.sha256sum] = "48a4a9019f7cfed4d7501a4595de7d9244f628bc28cbeaea8f62b325cfe48b6e"

URI_aarch64_ntfs-3g-devel = "${EPEL_MIRROR}/aarch64/Packages/n/ntfs-3g-devel-2022.10.3-9.el10_0.aarch64.rpm;name=aarch64_ntfs-3g-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ntfs-3g-devel}"
SRC_URI[aarch64_ntfs-3g-devel.sha256sum] = "a298970534df980cb857658d7e87c879959c3add5821cb177bd34c97093abe61"

URI_aarch64_ntfs-3g-libs = "${EPEL_MIRROR}/aarch64/Packages/n/ntfs-3g-libs-2022.10.3-9.el10_0.aarch64.rpm;name=aarch64_ntfs-3g-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ntfs-3g-libs}"
SRC_URI[aarch64_ntfs-3g-libs.sha256sum] = "96bcb74f28d00dd8af8c2ce479d2a4b1851efb8e781fd43e14243545ad041dee"

URI_aarch64_ntfsprogs = "${EPEL_MIRROR}/aarch64/Packages/n/ntfsprogs-2022.10.3-9.el10_0.aarch64.rpm;name=aarch64_ntfsprogs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ntfsprogs}"
SRC_URI[aarch64_ntfsprogs.sha256sum] = "954de88888150ec0e963406b856036ab2814b4c8147e11cf4b2d25c96693afd3"

RDEPENDS:ntfs-3g = " \
 glibc \
 ntfs-3g-libs \
 "
RDEPENDS:ntfs-3g-devel = " \
 ntfs-3g-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:ntfs-3g-libs = " \
 glibc \
 "
RDEPENDS:ntfsprogs = " \
 glibc \
 gnutls \
 libgcrypt \
 libuuid \
 ntfs-3g-libs \
 "
