# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rpki-client"
PV = "9.9"
PR = "1.el10_2"
PACKAGES = " \
 rpki-client \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rpki-client-9.9-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c6f1ca0de8b2c7c6516fc0a5a2fdb82a1b1f761ae35a8edd1feb72dcbc646371"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpki-client-9.9-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rpki-client;unpack=0"
SRC_URI[x86_64_v2_rpki-client.sha256sum] = "7249dd8fc6cade761594f53b9a7b7348ec8baed84ab54fc11f4e98787bbb1d5f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rpki-client-9.9-1.el10_2.aarch64.rpm;name=aarch64_rpki-client;unpack=0"
SRC_URI[aarch64_rpki-client.sha256sum] = "77b05f9cb506904007eda6f4c292d815a50acc65354db44f04631bca7bd1efbb"

RDEPENDS:rpki-client = " \
 bash \
 expat \
 glibc \
 libretls \
 openssl-libs \
 rsync \
 shadow-utils \
 systemd \
 zlib-ng-compat \
 "
