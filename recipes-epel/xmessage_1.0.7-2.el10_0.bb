# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xmessage"
PV = "1.0.7"
PR = "2.el10_0"
PACKAGES = " \
 xmessage \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xmessage-1.0.7-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3bb7b12a70996a8c07ee7cc3c640b1a35db6eaccd0b3c81e14ef4d7d974f3961"

URI_x86_64_v2_xmessage = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xmessage-1.0.7-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xmessage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmessage}"
SRC_URI[x86_64_v2_xmessage.sha256sum] = "3cb96ea9bdb34f785846701cf697866ac2bea8df2dcba9cce8697423c9f4ab55"

URI_aarch64_xmessage = "${EPEL_MIRROR}/aarch64/Packages/x/xmessage-1.0.7-2.el10_0.aarch64.rpm;name=aarch64_xmessage;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmessage}"
SRC_URI[aarch64_xmessage.sha256sum] = "8c720f1171f6fb26a7778f5c5c13c137222b154f1eff81dd976b08db2af3b239"

RDEPENDS:xmessage = " \
 glibc \
 libX11 \
 libXaw \
 libXt \
 "
