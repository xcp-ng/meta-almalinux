# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "softhsm"
PV = "2.6.1"
PR = "16.el10_0"
PACKAGES = " \
 softhsm \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/softhsm-2.6.1-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "725403def9ac613c729489fa3e7b54ee6a6948040ee7b1c1fc3140a81925a535"

URI_x86_64_v2_softhsm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/softhsm-2.6.1-16.el10_0.x86_64_v2.rpm;name=x86_64_v2_softhsm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_softhsm}"
SRC_URI[x86_64_v2_softhsm.sha256sum] = "1dc7523b2d468080e6d5dc525a42e6931c64134d6a47417f72a1cdbba2aa31e3"

URI_aarch64_softhsm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/softhsm-2.6.1-16.el10_0.aarch64.rpm;name=aarch64_softhsm;unpack=0"
SRC_URI:append = " ${URI_aarch64_softhsm}"
SRC_URI[aarch64_softhsm.sha256sum] = "1809788d0ccd37a70cbba2c80aee51e5688da9f2a96b58ce5c4cfed9c6c55231"

RDEPENDS:softhsm = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 p11-kit \
 shadow-utils \
 sqlite-libs \
 "
