# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtimageformats"
PV = "6.8.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qtimageformats \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtimageformats-6.8.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d5290af8446a1d59ba3b661508c8de5902d2c91cd1577cfbee83ebd6feaae85d"

URI_x86_64_v2_qt6-qtimageformats = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtimageformats-6.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtimageformats;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtimageformats}"
SRC_URI[x86_64_v2_qt6-qtimageformats.sha256sum] = "b60a983342ffd0d2378434960daef6447b70b2636e6f4ab48ddb01a5f22ea827"

URI_aarch64_qt6-qtimageformats = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtimageformats-6.8.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtimageformats;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtimageformats}"
SRC_URI[aarch64_qt6-qtimageformats.sha256sum] = "59f5da11a8ca6f66766e44bc9ec41b90edcc0c1c5c4c73bf8027e35bf369960c"

RDEPENDS:qt6-qtimageformats = " \
 cmake-filesystem \
 glibc \
 jasper-libs \
 libmng \
 libstdc++ \
 libtiff \
 libwebp \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
