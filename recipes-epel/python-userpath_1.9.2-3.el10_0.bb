# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-userpath"
PV = "1.9.2"
PR = "3.el10_0"
PACKAGES = " \
 python3-userpath \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-userpath-1.9.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd25cdd89b737ca54cd17028134302ddef686506ef60c37b4abc1cab39d4c595"

URI_x86_64_v2_python3-userpath = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-userpath-1.9.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-userpath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-userpath}"
SRC_URI[x86_64_v2_python3-userpath.sha256sum] = "eb49904d1cc8bfd1ca974728cdf44660d6988ea5b2f48b6dc2dd3f9c6c609aae"

URI_aarch64_python3-userpath = "${EPEL_MIRROR}/aarch64/Packages/p/python3-userpath-1.9.2-3.el10_0.noarch.rpm;name=aarch64_python3-userpath;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-userpath}"
SRC_URI[aarch64_python3-userpath.sha256sum] = "94e22c875e0f2af0d3767e442034ac7bd0d3b67ce254312cd7affc25b1a62eb6"

RDEPENDS:python3-userpath = " \
 python3 \
 python3-click \
 "
