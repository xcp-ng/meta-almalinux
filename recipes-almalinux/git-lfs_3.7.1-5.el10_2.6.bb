# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "git-lfs"
PV = "3.7.1"
PR = "5.el10_2.6"
PACKAGES = " \
 git-lfs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/git-lfs-3.7.1-5.el10_2.6.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "adc8c528475ea4f50bf1770cf87138ab503d401de1a81f0875bb1996f118084c"

URI_x86_64_v2_git-lfs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/git-lfs-3.7.1-5.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_git-lfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-lfs}"
SRC_URI[x86_64_v2_git-lfs.sha256sum] = "e1cc99c6df527b7ca90d7c1ca3856051e578026b22ddbff8a9e90673f0ba640e"

URI_aarch64_git-lfs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/git-lfs-3.7.1-5.el10_2.6.aarch64.rpm;name=aarch64_git-lfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-lfs}"
SRC_URI[aarch64_git-lfs.sha256sum] = "d876207b382904315589d19e82ee98b164575c9320e3b52ac9ca2a028541501a"

RDEPENDS:git-lfs = " \
 bash \
 git-core \
 glibc \
 "
