# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pie"
PV = "1.4.8"
PR = "1.el10_3"
PACKAGES = " \
 pie \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pie-1.4.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de6778870e6fadd257c4f3bfc8990658781ba579c8c2e4fa0434313cb7708a9a"

URI_x86_64_v2_pie = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pie-1.4.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_pie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pie}"
SRC_URI[x86_64_v2_pie.sha256sum] = "0c2bd32931f20b15152bc4e4217c4cc8afd43f14b594de4c91b2030ca7503f9c"

URI_aarch64_pie = "${EPEL_MIRROR}/aarch64/Packages/p/pie-1.4.8-1.el10_3.noarch.rpm;name=aarch64_pie;unpack=0"
SRC_URI:append = " ${URI_aarch64_pie}"
SRC_URI[aarch64_pie.sha256sum] = "8619d4d1c8823bc5536a6a6a85786149f9d3f82dff8380d293d8f4f9cf835a79"

RDEPENDS:pie = " \
 bash \
 ca-certificates \
 virtual//usr/bin/php \
 virtual/php-cli \
 virtual/php-ctype \
 virtual/php-curl \
 virtual/php-dom \
 virtual/php-intl \
 virtual/php-json \
 virtual/php-mbstring \
 virtual/php-phar \
 virtual/php-posix \
 virtual/php-zip \
 virtual/php_language__ge_8.1 \
 "
