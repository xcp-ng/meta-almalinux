# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-is-wsl"
PV = "0.4.0"
PR = "5.el10_1"
PACKAGES = " \
 rust-is-wsl+default-devel \
 rust-is-wsl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-is-wsl-0.4.0-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b324ef39e2ffe2205866c9a909cb7d324ad32a6dbcb7622354c438e35c151dc2"

URI_x86_64_v2_rust-is-wsl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-is-wsl+default-devel-0.4.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-is-wsl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-is-wsl+default-devel}"
SRC_URI[x86_64_v2_rust-is-wsl+default-devel.sha256sum] = "2e7a6449df15d7203e26d4197aea040081219c75bb9adf03139141ba2849aecb"

URI_x86_64_v2_rust-is-wsl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-is-wsl-devel-0.4.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-is-wsl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-is-wsl-devel}"
SRC_URI[x86_64_v2_rust-is-wsl-devel.sha256sum] = "f6011269ae0e18d3235f745fbe4d336dd57abb87b7c89b00a1ffd290c9cdbb4a"

URI_aarch64_rust-is-wsl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-is-wsl+default-devel-0.4.0-5.el10_1.noarch.rpm;name=aarch64_rust-is-wsl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-is-wsl+default-devel}"
SRC_URI[aarch64_rust-is-wsl+default-devel.sha256sum] = "ac84754617e6109a6340456af97517a802d1c585f2057ad82c9975783288469c"

URI_aarch64_rust-is-wsl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-is-wsl-devel-0.4.0-5.el10_1.noarch.rpm;name=aarch64_rust-is-wsl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-is-wsl-devel}"
SRC_URI[aarch64_rust-is-wsl-devel.sha256sum] = "60c7a9676361b7c37e4d201ae0258227a0d2b246dbaa18a0d96056dac587f5e5"

RDEPENDS:rust-is-wsl+default-devel = " \
 cargo \
 rust-is-wsl-devel \
 "
RDEPENDS:rust-is-wsl-devel = " \
 cargo \
 rust-is-docker+default-devel \
 rust-once_cell+default-devel \
 "
