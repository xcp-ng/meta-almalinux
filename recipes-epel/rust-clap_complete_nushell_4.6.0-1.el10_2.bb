# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap_complete_nushell"
PV = "4.6.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-clap_complete_nushell+default-devel \
 rust-clap_complete_nushell-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap_complete_nushell-4.6.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c7ca95d2f8978843fae01cda600eca713c1672de992256118cdf53267a907eb"

URI_x86_64_v2_rust-clap_complete_nushell+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete_nushell+default-devel-4.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete_nushell+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete_nushell+default-devel}"
SRC_URI[x86_64_v2_rust-clap_complete_nushell+default-devel.sha256sum] = "2f44beaf2946007cc4f937baee77fd30bb8c4a10f754d2b839e8ccc24899066b"

URI_x86_64_v2_rust-clap_complete_nushell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete_nushell-devel-4.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete_nushell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete_nushell-devel}"
SRC_URI[x86_64_v2_rust-clap_complete_nushell-devel.sha256sum] = "1194a2ee26ef47b26332f89444fc01119f680175d30d3c33da6ca88b78b40c2e"

URI_aarch64_rust-clap_complete_nushell+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete_nushell+default-devel-4.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-clap_complete_nushell+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete_nushell+default-devel}"
SRC_URI[aarch64_rust-clap_complete_nushell+default-devel.sha256sum] = "6e6a80c68ddf91481b9922d7f5cfd9854fe526493c71d8c5920190e2a089487f"

URI_aarch64_rust-clap_complete_nushell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete_nushell-devel-4.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-clap_complete_nushell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete_nushell-devel}"
SRC_URI[aarch64_rust-clap_complete_nushell-devel.sha256sum] = "240397134be900d6dfa08915f079511b7293abfb4bb88eaede62ac87146eb04c"

RDEPENDS:rust-clap_complete_nushell+default-devel = " \
 cargo \
 rust-clap_complete_nushell-devel \
 "
RDEPENDS:rust-clap_complete_nushell-devel = " \
 cargo \
 rust \
 rust-clap+std-devel \
 rust-clap-devel \
 rust-clap_complete+default-devel \
 "
