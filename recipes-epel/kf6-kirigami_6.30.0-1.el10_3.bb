# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kirigami"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kirigami \
 kf6-kirigami-devel \
 kf6-kirigami-doc \
 kf6-kirigami-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kirigami-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b890aa05a54f8682eb249d62ff1aafd7e3759dfa885d410372b731d1758001c7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kirigami-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kirigami;unpack=0"
SRC_URI[x86_64_v2_kf6-kirigami.sha256sum] = "53aad0978dc8ec0624d31ca012e71cedf916f8794e3e254a119241366fb6e526"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kirigami-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kirigami-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kirigami-devel.sha256sum] = "0c11b48f60b8287e7acb6b4a3fcf53ea0a78eb4bfdf271d5ebf4b723fa7d4527"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kirigami-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kirigami-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kirigami-doc.sha256sum] = "45ef6680bb630ff089e09cd173a7dfc01fc7ba0fb50567cddd6031f352dc0bc5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kirigami-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kirigami-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kirigami-html.sha256sum] = "7d1dc033039a1ce51c6cdb9a5526a4287a422318240ffd036264694de9eff8cc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kirigami-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kirigami;unpack=0"
SRC_URI[aarch64_kf6-kirigami.sha256sum] = "949f199a1a9996a9ebcb678501c3dda058d5f76eb6733aecf5c189993384e54b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kirigami-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kirigami-devel;unpack=0"
SRC_URI[aarch64_kf6-kirigami-devel.sha256sum] = "f14cc965383e3ff3161471d5afd3d137951310be7dde6731260733e7c129a9c3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kirigami-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kirigami-doc;unpack=0"
SRC_URI[aarch64_kf6-kirigami-doc.sha256sum] = "58c380fd7b6ca1b778ecfe97ad032973796930e0be498834fc7ff8e5f0330a8b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kirigami-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kirigami-html;unpack=0"
SRC_URI[aarch64_kf6-kirigami-html.sha256sum] = "b8f40fa778d9e4af0e0c898a011ec8f872f3f87b64883c20e866e1c1538b227f"

RDEPENDS:kf6-kirigami = " \
 glibc \
 libgomp \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kirigami-devel = " \
 cmake-filesystem \
 kf6-kirigami \
 "
RDEPENDS:kf6-kirigami-doc = " \
 "
RDEPENDS:kf6-kirigami-html = " \
 "
