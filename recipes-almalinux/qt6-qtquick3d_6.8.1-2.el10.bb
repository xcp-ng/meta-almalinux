# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtquick3d"
PV = "6.8.1"
PR = "2.el10"
PACKAGES = " \
 qt6-qtquick3d \
 qt6-qtquick3d-devel \
 qt6-qtquick3d-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtquick3d-6.8.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6192118fedde3e8ab7056f674a39677427ec228eac5ff3ba4e40f0396b5bfb38"

URI_x86_64_v2_qt6-qtquick3d = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtquick3d-6.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtquick3d;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtquick3d}"
SRC_URI[x86_64_v2_qt6-qtquick3d.sha256sum] = "0603762fe5c6a37cf521c0208c5cfc4699c8f8e3c96a67fba1439aa7861728be"

URI_x86_64_v2_qt6-qtquick3d-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtquick3d-devel-6.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtquick3d-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtquick3d-devel}"
SRC_URI[x86_64_v2_qt6-qtquick3d-devel.sha256sum] = "6b5624804f23d73e2c35bb17fb972d315d133f9eb3be3e80106cc94f455f2508"

URI_x86_64_v2_qt6-qtquick3d-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtquick3d-examples-6.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtquick3d-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtquick3d-examples}"
SRC_URI[x86_64_v2_qt6-qtquick3d-examples.sha256sum] = "e33d349049264b63a75f813f9bfa7eaef77d194c05532c751ecd1a73f9e8a009"

URI_aarch64_qt6-qtquick3d = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtquick3d-6.8.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtquick3d;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtquick3d}"
SRC_URI[aarch64_qt6-qtquick3d.sha256sum] = "2ae7f1589cb13df90b1c6239b709ce997d2fbfde78c749a111480db9a9f2cbf4"

URI_aarch64_qt6-qtquick3d-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtquick3d-devel-6.8.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtquick3d-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtquick3d-devel}"
SRC_URI[aarch64_qt6-qtquick3d-devel.sha256sum] = "403509b224cfd515ac2d3529034539da19958f0e78872ed00f257cd1c0fe7621"

URI_aarch64_qt6-qtquick3d-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtquick3d-examples-6.8.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtquick3d-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtquick3d-examples}"
SRC_URI[aarch64_qt6-qtquick3d-examples.sha256sum] = "4eed98eeab4a7a2dfc54c736f1e78583ffa6d958638843dcbbc554e8f201d559"

RDEPENDS:qt6-qtquick3d = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtquicktimeline \
 qt6-qtshadertools \
 zlib-ng-compat \
 "
RDEPENDS:qt6-qtquick3d-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtdeclarative-devel \
 qt6-qtquick3d \
 qt6-qtquick3d-devel \
 qt6-qtshadertools \
 qt6-qtshadertools-devel \
 "
RDEPENDS:qt6-qtquick3d-examples = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtquick3d \
 "
