# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "intel-lpmd"
PV = "0.0.6"
PR = "2.el10"
PACKAGES:x86_64_v2 = " \
 intel-lpmd \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/intel-lpmd-0.0.6-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0f307e3418b45dfcf52c1d8eb11242eaae055ceb83e06eaa7debc7d9e1a4b03d"

URI_x86_64_v2_intel-lpmd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/intel-lpmd-0.0.6-2.el10.x86_64_v2.rpm;name=x86_64_v2_intel-lpmd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-lpmd}"
SRC_URI[x86_64_v2_intel-lpmd.sha256sum] = "619372913a64e42bafdc53d2e531491856a63226648af9e7a2b4dd048aaec923"

RDEPENDS:intel-lpmd = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libnl3 \
 libxml2 \
 systemd-libs \
 "
