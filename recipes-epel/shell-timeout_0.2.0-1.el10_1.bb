# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "shell-timeout"
PV = "0.2.0"
PR = "1.el10_1"
PACKAGES = " \
 shell-timeout \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/shell-timeout-0.2.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "49e63e2d95e7e964b0c7010053bc2398ed1e72e37a459cebe3cae854e6173691"

URI_x86_64_v2_shell-timeout = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/shell-timeout-0.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_shell-timeout;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_shell-timeout}"
SRC_URI[x86_64_v2_shell-timeout.sha256sum] = "f2b0eb0b4236bad889f71c1b65043694af06e5e068b71a06c43e00cde6a025f8"

URI_aarch64_shell-timeout = "${EPEL_MIRROR}/aarch64/Packages/s/shell-timeout-0.2.0-1.el10_1.noarch.rpm;name=aarch64_shell-timeout;unpack=0"
SRC_URI:append = " ${URI_aarch64_shell-timeout}"
SRC_URI[aarch64_shell-timeout.sha256sum] = "aa697019442528b44746b470efeab42f0529b6087eaefb970615ac488c537344"

RDEPENDS:shell-timeout = " \
 filesystem \
 sed \
 virtual/coreutils \
 "
