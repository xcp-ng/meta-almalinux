# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio-socks"
PV = "0.5.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-tokio-socks+default-devel \
 rust-tokio-socks+futures-io-devel \
 rust-tokio-socks+tokio-devel \
 rust-tokio-socks+tor-devel \
 rust-tokio-socks-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-socks-0.5.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d7e6c4091f03815dc79a89b68aeffe28c70b3708168c13009d93ea08c55bb3af"

URI_x86_64_v2_rust-tokio-socks+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-socks+default-devel-0.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-socks+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-socks+default-devel}"
SRC_URI[x86_64_v2_rust-tokio-socks+default-devel.sha256sum] = "c3c0102e781b06337a71b9ba9d1e2cd35e97d8e42bf3b94ee64c279173ae036e"

URI_x86_64_v2_rust-tokio-socks+futures-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-socks+futures-io-devel-0.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-socks+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-socks+futures-io-devel}"
SRC_URI[x86_64_v2_rust-tokio-socks+futures-io-devel.sha256sum] = "67867244b9d89dc4c1174c68d06cf93543d180f27476ee13c1edbde794f65e87"

URI_x86_64_v2_rust-tokio-socks+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-socks+tokio-devel-0.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-socks+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-socks+tokio-devel}"
SRC_URI[x86_64_v2_rust-tokio-socks+tokio-devel.sha256sum] = "5f0366bed508b459be45617045f4a553b39eb507c6eb1b0edb5ec6defc909369"

URI_x86_64_v2_rust-tokio-socks+tor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-socks+tor-devel-0.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-socks+tor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-socks+tor-devel}"
SRC_URI[x86_64_v2_rust-tokio-socks+tor-devel.sha256sum] = "f59508ed1ceff60e64dca4bdaf1ea3d881ef5434265c928d0810099405b7b7cd"

URI_x86_64_v2_rust-tokio-socks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-socks-devel-0.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-socks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-socks-devel}"
SRC_URI[x86_64_v2_rust-tokio-socks-devel.sha256sum] = "bd098bb1449a08fa3e558e65d4a6f2546545a61a091c95fc2c7330083046b458"

URI_aarch64_rust-tokio-socks+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-socks+default-devel-0.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-socks+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-socks+default-devel}"
SRC_URI[aarch64_rust-tokio-socks+default-devel.sha256sum] = "a54c31f0480d53c8b6d90944eb227859c6f9a3d38691fcbad3e0366708d02fa0"

URI_aarch64_rust-tokio-socks+futures-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-socks+futures-io-devel-0.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-socks+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-socks+futures-io-devel}"
SRC_URI[aarch64_rust-tokio-socks+futures-io-devel.sha256sum] = "0d81cd39fe5138a3e953c40ff9d5aa90fe2f3433c50760bdef7cdb120244bd26"

URI_aarch64_rust-tokio-socks+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-socks+tokio-devel-0.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-socks+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-socks+tokio-devel}"
SRC_URI[aarch64_rust-tokio-socks+tokio-devel.sha256sum] = "4c0592cb1d8aeb3fc31fdffa8f1dc47b7d7813c88339acd262bae37aee488ba3"

URI_aarch64_rust-tokio-socks+tor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-socks+tor-devel-0.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-socks+tor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-socks+tor-devel}"
SRC_URI[aarch64_rust-tokio-socks+tor-devel.sha256sum] = "e907d9c2270bc7ba5c09bfae7365b0a6d69288e16d3dbfe13cd6c5f6670136df"

URI_aarch64_rust-tokio-socks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-socks-devel-0.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-socks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-socks-devel}"
SRC_URI[aarch64_rust-tokio-socks-devel.sha256sum] = "06cbfe6841d7afa86a16b87277f5061087aa249a8e0009023144e214c9d81eae"

RDEPENDS:rust-tokio-socks+default-devel = " \
 cargo \
 rust-tokio-socks+tokio-devel \
 rust-tokio-socks-devel \
 "
RDEPENDS:rust-tokio-socks+futures-io-devel = " \
 cargo \
 rust-futures-io+default-devel \
 rust-tokio-socks-devel \
 "
RDEPENDS:rust-tokio-socks+tokio-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio+net-devel \
 rust-tokio-socks-devel \
 "
RDEPENDS:rust-tokio-socks+tor-devel = " \
 cargo \
 rust-tokio-socks-devel \
 "
RDEPENDS:rust-tokio-socks-devel = " \
 bash \
 cargo \
 rust-either+default-devel \
 rust-futures-util-devel \
 rust-thiserror1+default-devel \
 "
