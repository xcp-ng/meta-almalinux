# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aurorae"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 aurorae \
 aurorae-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aurorae-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f5c83e19bcd59f7da58b8fb3f90b0f5945b738ccd89298786071d0a9b2c8c63b"

URI_x86_64_v2_aurorae = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aurorae-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aurorae;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aurorae}"
SRC_URI[x86_64_v2_aurorae.sha256sum] = "e70b37ef938aa426bf8617269c9fec581caca9f9574b68757a77cbee3f59d365"

URI_x86_64_v2_aurorae-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aurorae-devel-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aurorae-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aurorae-devel}"
SRC_URI[x86_64_v2_aurorae-devel.sha256sum] = "7a309c71dd84a844ea1a896ccfd8345572afa9df1a363d77ac5b6b27cd85ddbf"

URI_aarch64_aurorae = "${EPEL_MIRROR}/aarch64/Packages/a/aurorae-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_aurorae;unpack=0"
SRC_URI:append = " ${URI_aarch64_aurorae}"
SRC_URI[aarch64_aurorae.sha256sum] = "32ef31f518a055c567ece2853ed2e1693c5feaa48d68bcd450e254a723e14435"

URI_aarch64_aurorae-devel = "${EPEL_MIRROR}/aarch64/Packages/a/aurorae-devel-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_aurorae-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_aurorae-devel}"
SRC_URI[aarch64_aurorae-devel.sha256sum] = "0290edb90da08aaee13ae70af27b733c5635a883087116d1f5f3a07e49f48850"

RDEPENDS:aurorae = " \
 bash \
 glibc \
 kdecoration \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kpackage \
 kf6-ksvg \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qttools \
 "
RDEPENDS:aurorae-devel = " \
 aurorae \
 cmake-filesystem \
 "
