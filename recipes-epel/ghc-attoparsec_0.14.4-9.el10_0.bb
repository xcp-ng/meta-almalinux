# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-attoparsec"
PV = "0.14.4"
PR = "9.el10_0"
PACKAGES = " \
 ghc-attoparsec \
 ghc-attoparsec-devel \
 ghc-attoparsec-doc \
 ghc-attoparsec-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-attoparsec-0.14.4-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55ca67daad0e4ef7627388fd0db7f64944313a8419e4457d445fcc717fd6ce3c"

URI_x86_64_v2_ghc-attoparsec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-attoparsec-0.14.4-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-attoparsec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-attoparsec}"
SRC_URI[x86_64_v2_ghc-attoparsec.sha256sum] = "4adef9fd399e2ba045fa8f97f637196b0edc5da3476974002b61d4e8a34d9dce"

URI_x86_64_v2_ghc-attoparsec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-attoparsec-devel-0.14.4-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-attoparsec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-attoparsec-devel}"
SRC_URI[x86_64_v2_ghc-attoparsec-devel.sha256sum] = "79bd005eb196a66bf459811561e8484e33e8559de7ff27a94af4f4d25bb52956"

URI_x86_64_v2_ghc-attoparsec-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-attoparsec-doc-0.14.4-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-attoparsec-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-attoparsec-doc}"
SRC_URI[x86_64_v2_ghc-attoparsec-doc.sha256sum] = "0af885e0a7d244d4cd6c8cd1d090ed371cb8f81eefed612166fc0b4068e0e438"

URI_x86_64_v2_ghc-attoparsec-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-attoparsec-prof-0.14.4-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-attoparsec-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-attoparsec-prof}"
SRC_URI[x86_64_v2_ghc-attoparsec-prof.sha256sum] = "68974a7ee18c7e99484d1c86b299421977f1d25f9478b26997f064457981805a"

URI_aarch64_ghc-attoparsec = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-attoparsec-0.14.4-9.el10_0.aarch64.rpm;name=aarch64_ghc-attoparsec;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-attoparsec}"
SRC_URI[aarch64_ghc-attoparsec.sha256sum] = "95a20ac3e40fcc23cb6756a93e5cb19c90a6f5e6d3f0f699fe9ac4ca371dce9a"

URI_aarch64_ghc-attoparsec-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-attoparsec-devel-0.14.4-9.el10_0.aarch64.rpm;name=aarch64_ghc-attoparsec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-attoparsec-devel}"
SRC_URI[aarch64_ghc-attoparsec-devel.sha256sum] = "ca87b5dd2c0d87d83deba9c60d39c884b0c0d82046213dcad3753b46701c6019"

URI_aarch64_ghc-attoparsec-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-attoparsec-doc-0.14.4-9.el10_0.noarch.rpm;name=aarch64_ghc-attoparsec-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-attoparsec-doc}"
SRC_URI[aarch64_ghc-attoparsec-doc.sha256sum] = "a7f2d0b54dda33ec0c4864ea62268d9fc3c90b7d4695aaf6def8bed3e124a7d7"

URI_aarch64_ghc-attoparsec-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-attoparsec-prof-0.14.4-9.el10_0.aarch64.rpm;name=aarch64_ghc-attoparsec-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-attoparsec-prof}"
SRC_URI[aarch64_ghc-attoparsec-prof.sha256sum] = "6eed9ec0bf9fc7c541c5121e183bbd5f38eaac8f57779d59431747f3f1c623e9"

RDEPENDS:ghc-attoparsec = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-integer-logarithms \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-scientific \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-attoparsec-devel = " \
 ghc-array-devel \
 ghc-attoparsec \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-deepseq-devel \
 ghc-scientific-devel \
 ghc-text-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-attoparsec-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-attoparsec-prof = " \
 ghc-array-prof \
 ghc-attoparsec-devel \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-deepseq-prof \
 ghc-scientific-prof \
 ghc-text-prof \
 ghc-transformers-prof \
 "
