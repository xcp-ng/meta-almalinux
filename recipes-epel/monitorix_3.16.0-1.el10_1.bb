# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "monitorix"
PV = "3.16.0"
PR = "1.el10_1"
PACKAGES = " \
 monitorix \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/monitorix-3.16.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52097c99ca0074bbf3e6ac8d0d0542e419a815ebbd0ae7c1e7bffc513cdcfd46"

URI_x86_64_v2_monitorix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/monitorix-3.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_monitorix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_monitorix}"
SRC_URI[x86_64_v2_monitorix.sha256sum] = "ebfa3df28de238dfa09d3e35ddf9dc20751a6f5dd52fdecc634de2827086724f"

URI_aarch64_monitorix = "${EPEL_MIRROR}/aarch64/Packages/m/monitorix-3.16.0-1.el10_1.noarch.rpm;name=aarch64_monitorix;unpack=0"
SRC_URI:append = " ${URI_aarch64_monitorix}"
SRC_URI[aarch64_monitorix.sha256sum] = "ddfb1f3dbfd4640a5ae129b8d5b7f9d4b5c33861f04a195cc8e8e9db395d1b51"

RDEPENDS:monitorix = " \
 bash \
 logrotate \
 perl-DBD-MySQL \
 perl-DBD-Pg \
 perl-IO-Socket-SSL \
 perl-Time-HiRes \
 perl-interpreter \
 perl-libs \
 systemd \
 "
