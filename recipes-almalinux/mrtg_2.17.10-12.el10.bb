# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mrtg"
PV = "2.17.10"
PR = "12.el10"
PACKAGES = " \
 mrtg \
 mrtg-selinux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mrtg-2.17.10-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "06a3cfb0e9d56bbabffeed4a13cab891ea980b7a3f89cbaf2ea64e32b3df1171"

URI_x86_64_v2_mrtg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mrtg-2.17.10-12.el10.x86_64_v2.rpm;name=x86_64_v2_mrtg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mrtg}"
SRC_URI[x86_64_v2_mrtg.sha256sum] = "75bfcdc66f8fa146dc3466883077098ac991e5b268cb3c5ae417cc1734857177"

URI_x86_64_v2_mrtg-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mrtg-selinux-2.17.10-12.el10.noarch.rpm;name=x86_64_v2_mrtg-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mrtg-selinux}"
SRC_URI[x86_64_v2_mrtg-selinux.sha256sum] = "80d69cca270cfb5c8f6d286c6a21d6442a49378c45988b6fa7fd9d76fdd1caf7"

URI_aarch64_mrtg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mrtg-2.17.10-12.el10.aarch64.rpm;name=aarch64_mrtg;unpack=0"
SRC_URI:append = " ${URI_aarch64_mrtg}"
SRC_URI[aarch64_mrtg.sha256sum] = "90fb8aa24a70639a49461ef8fd57b9a2df4f2fc37678b07af2817dc28ec0bdca"

URI_aarch64_mrtg-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mrtg-selinux-2.17.10-12.el10.noarch.rpm;name=aarch64_mrtg-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_mrtg-selinux}"
SRC_URI[aarch64_mrtg-selinux.sha256sum] = "80d69cca270cfb5c8f6d286c6a21d6442a49378c45988b6fa7fd9d76fdd1caf7"

RDEPENDS:mrtg = " \
 bash \
 gd \
 glibc \
 mrtg \
 mrtg-selinux \
 perl-CGI \
 perl-Carp \
 perl-Exporter \
 perl-FindBin \
 perl-Getopt-Long \
 perl-IO \
 perl-IO-Socket-INET6 \
 perl-Math-BigInt \
 perl-POSIX \
 perl-Pod-Usage \
 perl-SNMP_Session \
 perl-Socket \
 perl-Socket6 \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-locale \
 perl-vars \
 systemd \
 "
RDEPENDS:mrtg-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
