# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocs"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 rocs \
 rocs-devel \
 rocs-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocs-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f52c111ffde520a05d62e5bf405e3aeac2e40b176846a3f813636bf73b04aaf1"

URI_x86_64_v2_rocs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocs-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocs}"
SRC_URI[x86_64_v2_rocs.sha256sum] = "f05aa452a5071d8e0663afeb581454a2d38efaeab8051b70f49edda903eeb64d"

URI_x86_64_v2_rocs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocs-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocs-devel}"
SRC_URI[x86_64_v2_rocs-devel.sha256sum] = "02c577a68b6241671e4b6168764c054f5c4c7f8945bb8fd3db8da1028ad37b49"

URI_x86_64_v2_rocs-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocs-libs-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocs-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocs-libs}"
SRC_URI[x86_64_v2_rocs-libs.sha256sum] = "63cfe02097e186fbda0e505106a459bc96e8062249915f9fdb3c978d46f16a00"

URI_aarch64_rocs = "${EPEL_MIRROR}/aarch64/Packages/r/rocs-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_rocs;unpack=0"
SRC_URI:append = " ${URI_aarch64_rocs}"
SRC_URI[aarch64_rocs.sha256sum] = "6c5f72690b8c3853fb7d20f02b36bf293797e88be9d9f01afb87a966ccfb6364"

URI_aarch64_rocs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rocs-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_rocs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rocs-devel}"
SRC_URI[aarch64_rocs-devel.sha256sum] = "7fe94424a431dee3cb13a852ea918d449d6788cb64d72e8b6a6da25acba22354"

URI_aarch64_rocs-libs = "${EPEL_MIRROR}/aarch64/Packages/r/rocs-libs-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_rocs-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_rocs-libs}"
SRC_URI[aarch64_rocs-libs.sha256sum] = "33ed45a2c518a8ba05a96b8e4650fdc5d80c34fa0437cb5a1f79720950b0c3a7"

RDEPENDS:rocs = " \
 glibc \
 kf6-karchive \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kitemviews \
 kf6-kparts \
 kf6-ktexteditor \
 kf6-ktexttemplate \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 rocs-libs \
 "
RDEPENDS:rocs-devel = " \
 rocs-libs \
 "
RDEPENDS:rocs-libs = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kitemviews \
 kf6-kwidgetsaddons \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 rocs \
 "
