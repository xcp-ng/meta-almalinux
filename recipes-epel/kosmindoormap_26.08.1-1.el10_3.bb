# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kosmindoormap"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kosmindoormap \
 kosmindoormap-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kosmindoormap-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "09c7bdd3df163d940fffb9e541ec773964eb8989a7f418e12442c7d5146684ca"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kosmindoormap-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kosmindoormap;unpack=0"
SRC_URI[x86_64_v2_kosmindoormap.sha256sum] = "fe69c7a8a7905099fbeb27cb8db0c9d2e4e39199fe25e5e209fdd87e6f69bc30"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kosmindoormap-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kosmindoormap-devel;unpack=0"
SRC_URI[x86_64_v2_kosmindoormap-devel.sha256sum] = "90036849ef4b62b1c008e26ec572b08bce9010f46d5900a0da618d05d7ebeaa3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kosmindoormap-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kosmindoormap;unpack=0"
SRC_URI[aarch64_kosmindoormap.sha256sum] = "50d19ba778a9e93d4eaee6875852d736053dd2f4681b55fd7e1036bd3374e0da"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kosmindoormap-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kosmindoormap-devel;unpack=0"
SRC_URI[aarch64_kosmindoormap-devel.sha256sum] = "2fc0a67b3008d1a0169d6c664068f2c563ec7c3b97dc7491169d51f3b4be540f"

RDEPENDS:kosmindoormap = " \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kservice \
 kopeninghours \
 kpublictransport \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kosmindoormap-devel = " \
 cmake-filesystem \
 kosmindoormap \
 "
