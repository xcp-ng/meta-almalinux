# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerocopy"
PV = "0.8.31"
PR = "1.el10_1"
PACKAGES = " \
 rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel \
 rust-zerocopy+alloc-devel \
 rust-zerocopy+default-devel \
 rust-zerocopy+derive-devel \
 rust-zerocopy+float-nightly-devel \
 rust-zerocopy+simd-devel \
 rust-zerocopy+simd-nightly-devel \
 rust-zerocopy+std-devel \
 rust-zerocopy+zerocopy-derive-devel \
 rust-zerocopy-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zerocopy-0.8.31-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ad46d96ab4d0c952a810579a88826f43277e21a00d996d6bebaadacfebf7b22"

URI_x86_64_v2_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel-0.8.31-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel.sha256sum] = "78e9a851e0888b8f8563ad50a88c79ab50f3c37f8e18ad5ae390fecf937a31bf"

URI_x86_64_v2_rust-zerocopy+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+alloc-devel-0.8.31-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+alloc-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+alloc-devel.sha256sum] = "cb0cebe117018866c49c38c2414051421cee761f92bc2ba189b4196e733e93ec"

URI_x86_64_v2_rust-zerocopy+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+default-devel-0.8.31-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+default-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+default-devel.sha256sum] = "b7159d33192f816d10cf3a747927342ab4d841d346872f76f18ddd7a2f6a1b08"

URI_x86_64_v2_rust-zerocopy+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+derive-devel-0.8.31-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+derive-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+derive-devel.sha256sum] = "f979247eb34ef2dfa5d2acf4d75994a672c98e4f287c6d116bd8341f6cc67e2f"

URI_x86_64_v2_rust-zerocopy+float-nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+float-nightly-devel-0.8.31-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+float-nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+float-nightly-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+float-nightly-devel.sha256sum] = "8eca8127786f3d2e2dc2943b26b02be9da243f42eb8d6274a8da12b0d6618eb6"

URI_x86_64_v2_rust-zerocopy+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+simd-devel-0.8.31-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+simd-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+simd-devel.sha256sum] = "4e59d4a3385db4d06c8c3c64312eb4a426dab15a44d5452708201f6f6679598f"

URI_x86_64_v2_rust-zerocopy+simd-nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+simd-nightly-devel-0.8.31-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+simd-nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+simd-nightly-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+simd-nightly-devel.sha256sum] = "c768ed5bbbb04ee93f8b26a661442903b67541115718998e5f76c10ea3258cf0"

URI_x86_64_v2_rust-zerocopy+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+std-devel-0.8.31-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+std-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+std-devel.sha256sum] = "5cdc5cab459afe4caf3b8ac705780c1dec2b80b2adcdf5f4cb5d63b374229afd"

URI_x86_64_v2_rust-zerocopy+zerocopy-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+zerocopy-derive-devel-0.8.31-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+zerocopy-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy+zerocopy-derive-devel}"
SRC_URI[x86_64_v2_rust-zerocopy+zerocopy-derive-devel.sha256sum] = "c4e578f19fceb096f7e5b4792e3b62c1ed912ffa8c7968b00c66f1b4e0788ddd"

URI_x86_64_v2_rust-zerocopy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy-devel-0.8.31-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy-devel}"
SRC_URI[x86_64_v2_rust-zerocopy-devel.sha256sum] = "7e4c966c100da520d9314ee7db02eae6536b46985aa69c4d37ecba2a14491175"

URI_aarch64_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel-0.8.31-1.el10_1.noarch.rpm;name=aarch64_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel}"
SRC_URI[aarch64_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel.sha256sum] = "89a70dd2df3852e2bce35ad75ab1046a3138b62cea25d4b6ec20a3301b8ee08b"

URI_aarch64_rust-zerocopy+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+alloc-devel-0.8.31-1.el10_1.noarch.rpm;name=aarch64_rust-zerocopy+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+alloc-devel}"
SRC_URI[aarch64_rust-zerocopy+alloc-devel.sha256sum] = "4577dfa649b789575c8b16da95d9452ac21e7d33152aa82bdfbf02051169451b"

URI_aarch64_rust-zerocopy+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+default-devel-0.8.31-1.el10_1.noarch.rpm;name=aarch64_rust-zerocopy+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+default-devel}"
SRC_URI[aarch64_rust-zerocopy+default-devel.sha256sum] = "fb8a949bc1af837d778b4446304f408a4c355d5ee1637c0fdaa0f4e2a6c217f7"

URI_aarch64_rust-zerocopy+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+derive-devel-0.8.31-1.el10_1.noarch.rpm;name=aarch64_rust-zerocopy+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+derive-devel}"
SRC_URI[aarch64_rust-zerocopy+derive-devel.sha256sum] = "c2d4892a515a41a98cde3ff39b1b4880300610b010ae772733c755f5770153d8"

URI_aarch64_rust-zerocopy+float-nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+float-nightly-devel-0.8.31-1.el10_1.noarch.rpm;name=aarch64_rust-zerocopy+float-nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+float-nightly-devel}"
SRC_URI[aarch64_rust-zerocopy+float-nightly-devel.sha256sum] = "861022a7cb0a199a72b695b1b68e93f3573c866f4f772b57ff3380ee63217ace"

URI_aarch64_rust-zerocopy+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+simd-devel-0.8.31-1.el10_1.noarch.rpm;name=aarch64_rust-zerocopy+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+simd-devel}"
SRC_URI[aarch64_rust-zerocopy+simd-devel.sha256sum] = "5323032c43f6970093344c0ada4634e2fb1ecc62aa41f995a7fbcfd6c07992bf"

URI_aarch64_rust-zerocopy+simd-nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+simd-nightly-devel-0.8.31-1.el10_1.noarch.rpm;name=aarch64_rust-zerocopy+simd-nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+simd-nightly-devel}"
SRC_URI[aarch64_rust-zerocopy+simd-nightly-devel.sha256sum] = "27635594dfa479ec82654db56c6544a57ea15c71083c17af00df701b5d1d93e3"

URI_aarch64_rust-zerocopy+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+std-devel-0.8.31-1.el10_1.noarch.rpm;name=aarch64_rust-zerocopy+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+std-devel}"
SRC_URI[aarch64_rust-zerocopy+std-devel.sha256sum] = "6a898ea81de52e06ecbe9a19025db25f96f8eeadddf082818fbd0f6278f151d9"

URI_aarch64_rust-zerocopy+zerocopy-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+zerocopy-derive-devel-0.8.31-1.el10_1.noarch.rpm;name=aarch64_rust-zerocopy+zerocopy-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy+zerocopy-derive-devel}"
SRC_URI[aarch64_rust-zerocopy+zerocopy-derive-devel.sha256sum] = "b30bb68b847b7ab46cbab3b036a16824e52d6612ac72a82b3fcc06105865608b"

URI_aarch64_rust-zerocopy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy-devel-0.8.31-1.el10_1.noarch.rpm;name=aarch64_rust-zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy-devel}"
SRC_URI[aarch64_rust-zerocopy-devel.sha256sum] = "7d6e8b54c06bf17cceb6a91f7ec1c10d3ce933458c37c3ae555651d764d8fd1d"

RDEPENDS:rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel = " \
 cargo \
 rust-zerocopy+alloc-devel \
 rust-zerocopy+derive-devel \
 rust-zerocopy+simd-devel \
 rust-zerocopy+std-devel \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+alloc-devel = " \
 cargo \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+default-devel = " \
 cargo \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+derive-devel = " \
 cargo \
 rust-zerocopy+zerocopy-derive-devel \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+float-nightly-devel = " \
 cargo \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+simd-devel = " \
 cargo \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+simd-nightly-devel = " \
 cargo \
 rust-zerocopy+simd-devel \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+std-devel = " \
 cargo \
 rust-zerocopy+alloc-devel \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+zerocopy-derive-devel = " \
 cargo \
 rust-zerocopy-derive+default-devel \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy-devel = " \
 cargo \
 rust \
 rust-zerocopy-derive+default-devel \
 "
