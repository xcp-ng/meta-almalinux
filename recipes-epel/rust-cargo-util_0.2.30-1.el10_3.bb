# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-util"
PV = "0.2.30"
PR = "1.el10_3"
PACKAGES = " \
 rust-cargo-util+default-devel \
 rust-cargo-util-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-util-0.2.30-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8b31a87ed35eba1cd312447da8afba86c08234a1db9922f9fd1fd17d99df44bd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-util+default-devel-0.2.30-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-util+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cargo-util+default-devel.sha256sum] = "41fd03d3830443de25c785e72094c5fe28cc755f53d65850fc6222541c46330f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-util-devel-0.2.30-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-util-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cargo-util-devel.sha256sum] = "9371934ae75337dcb1fdebb0b263a7e7e98bb2b6d46be3fb97ed573778ca7ef6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-util+default-devel-0.2.30-1.el10_3.noarch.rpm;name=aarch64_rust-cargo-util+default-devel;unpack=0"
SRC_URI[aarch64_rust-cargo-util+default-devel.sha256sum] = "00ce77373da24fc8412bce8a89aeec5150b60d17e2f3438728bf4bfe8f2f5c98"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-util-devel-0.2.30-1.el10_3.noarch.rpm;name=aarch64_rust-cargo-util-devel;unpack=0"
SRC_URI[aarch64_rust-cargo-util-devel.sha256sum] = "ba52afa53cf10152ae265c7867834d93fd1e2b49d60859b06ff7ee4b85fd7125"

RDEPENDS:rust-cargo-util+default-devel = " \
 cargo \
 rust-cargo-util-devel \
 "
RDEPENDS:rust-cargo-util-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-filetime+default-devel \
 rust-hex+default-devel \
 rust-ignore+default-devel \
 rust-jobserver+default-devel \
 rust-libc+default-devel \
 rust-portable-atomic+default-devel \
 rust-same-file+default-devel \
 rust-sha2+default-devel \
 rust-shell-escape+default-devel \
 rust-tempfile+default-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 rust-walkdir+default-devel \
 "
