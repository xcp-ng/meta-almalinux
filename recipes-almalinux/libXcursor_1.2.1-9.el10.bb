# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libXcursor"
PV = "1.2.1"
PR = "9.el10"
PACKAGES = " \
 libXcursor \
 libXcursor-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libXcursor-1.2.1-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "540ffbaed103d14e5f06f2fe5d1d2c55209a0214b171986cfdacae04ea00a253"

URI_x86_64_v2_libXcursor = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libXcursor-1.2.1-9.el10.x86_64_v2.rpm;name=x86_64_v2_libXcursor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXcursor}"
SRC_URI[x86_64_v2_libXcursor.sha256sum] = "f32cbd3132ef75aa9946e6defb42e98f3340a6b13a23b4811b57550f6714c642"

URI_x86_64_v2_libXcursor-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libXcursor-devel-1.2.1-9.el10.x86_64_v2.rpm;name=x86_64_v2_libXcursor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXcursor-devel}"
SRC_URI[x86_64_v2_libXcursor-devel.sha256sum] = "a930d37d300cec27a174ba12a8b3682ae22523d5c9b6ea6192c7a5549843cb02"

URI_aarch64_libXcursor = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libXcursor-1.2.1-9.el10.aarch64.rpm;name=aarch64_libXcursor;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXcursor}"
SRC_URI[aarch64_libXcursor.sha256sum] = "0faba1f6fcc801cd6f52299d136c1f0b28c78300cb8c2ea9e503374029d7a9f2"

URI_aarch64_libXcursor-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libXcursor-devel-1.2.1-9.el10.aarch64.rpm;name=aarch64_libXcursor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXcursor-devel}"
SRC_URI[aarch64_libXcursor-devel.sha256sum] = "b7d77cb6a42ea483ebf4b4afb801acae9b3705c9d8c95eb06a171d1aa2ac0057"

RDEPENDS:libXcursor = " \
 glibc \
 libX11 \
 libXfixes \
 libXrender \
 "
RDEPENDS:libXcursor-devel = " \
 libX11-devel \
 libXcursor \
 libXfixes-devel \
 libXrender-devel \
 pkgconf-pkg-config \
 xorg-x11-proto-devel \
 "
