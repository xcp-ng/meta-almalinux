# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libfullock"
PV = "1.0.62"
PR = "1.el10_0"
PACKAGES = " \
 libfullock \
 libfullock-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libfullock-1.0.62-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "176355feec5fe3490676b282186409f1c36fff38845d29a4a590e634010b83ea"

URI_x86_64_v2_libfullock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libfullock-1.0.62-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libfullock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfullock}"
SRC_URI[x86_64_v2_libfullock.sha256sum] = "9c4803486e0ada33b96f42363477b2772eb0a3c065c63f8e980f6b0ada04d380"

URI_x86_64_v2_libfullock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libfullock-devel-1.0.62-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libfullock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfullock-devel}"
SRC_URI[x86_64_v2_libfullock-devel.sha256sum] = "d77b9918e63e3f32987a4203d5a751c4d3a44e7f41c6a741090b985e4086fac6"

URI_aarch64_libfullock = "${EPEL_MIRROR}/aarch64/Packages/l/libfullock-1.0.62-1.el10_0.aarch64.rpm;name=aarch64_libfullock;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfullock}"
SRC_URI[aarch64_libfullock.sha256sum] = "d594c499001d804a390da89dff4ba2737f32942cc8d55f5ed1a3a9aef879ed2b"

URI_aarch64_libfullock-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libfullock-devel-1.0.62-1.el10_0.aarch64.rpm;name=aarch64_libfullock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfullock-devel}"
SRC_URI[aarch64_libfullock-devel.sha256sum] = "369067cac21c04064d1fae964a9b640c1cb26fecafb4d9528f1d55b36201b7a0"

RDEPENDS:libfullock = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libfullock-devel = " \
 libfullock \
 pkgconf-pkg-config \
 "
