# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "flatpak-builder"
PV = "1.4.4"
PR = "1.el10"
PACKAGES = " \
 flatpak-builder \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/flatpak-builder-1.4.4-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a79784feb10caf13a434f6125a253541334ee52a23301f9169f887e1c29ddfc6"

URI_x86_64_v2_flatpak-builder = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/flatpak-builder-1.4.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_flatpak-builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flatpak-builder}"
SRC_URI[x86_64_v2_flatpak-builder.sha256sum] = "57d6e800e64be1e951194e66f9f02983bff6f152f705dbca31bf29e9a32c2629"

URI_aarch64_flatpak-builder = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/flatpak-builder-1.4.4-1.el10.aarch64.rpm;name=aarch64_flatpak-builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_flatpak-builder}"
SRC_URI[aarch64_flatpak-builder.sha256sum] = "2f42f93ec1cec11bca4f1ac159e0bea9460424920f3c6a7d51e20f1fb254c04b"

RDEPENDS:flatpak-builder = " \
 appstream-compose \
 debugedit \
 elfutils-libelf \
 flatpak \
 glib2 \
 glibc \
 json-glib \
 libgcc \
 libxml2 \
 libyaml \
 ostree \
 ostree-libs \
 virtual/libcurl.so.4___64bit_ \
 "
