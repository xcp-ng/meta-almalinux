# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Data-Uniqid"
PV = "0.12"
PR = "39.el10_3"
PACKAGES = " \
 perl-Data-Uniqid \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Data-Uniqid-0.12-39.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4cf1878a44cf6941c6a02f0e91c8540db6a5ea11768cf784abdba3529f7b82fb"

URI_x86_64_v2_perl-Data-Uniqid = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Data-Uniqid-0.12-39.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Data-Uniqid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Data-Uniqid}"
SRC_URI[x86_64_v2_perl-Data-Uniqid.sha256sum] = "fc73fab72dc0e8e0027656ec758a2fac1eefeb40a99873e7f9af9f84b2e5298c"

URI_aarch64_perl-Data-Uniqid = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Data-Uniqid-0.12-39.el10_3.noarch.rpm;name=aarch64_perl-Data-Uniqid;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Data-Uniqid}"
SRC_URI[aarch64_perl-Data-Uniqid.sha256sum] = "cd0d0c2a00d44b4b31a9546ef2cbc0fe575773b35b8f339e7ef40fec64e93b3f"

RDEPENDS:perl-Data-Uniqid = " \
 perl-AutoLoader \
 perl-Exporter \
 perl-Math-BigInt \
 perl-Sys-Hostname \
 perl-Time-HiRes \
 perl-libs \
 "
