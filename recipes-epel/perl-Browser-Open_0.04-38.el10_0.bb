# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Browser-Open"
PV = "0.04"
PR = "38.el10_0"
PACKAGES = " \
 perl-Browser-Open \
 perl-Browser-Open-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Browser-Open-0.04-38.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "357341e9a98e00e8df6b6839e2e547e7369d3d65e5b92f91af7fd2ccb64a94c1"

URI_x86_64_v2_perl-Browser-Open = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Browser-Open-0.04-38.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Browser-Open;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Browser-Open}"
SRC_URI[x86_64_v2_perl-Browser-Open.sha256sum] = "e1fd01863c06f298e11bf07548da6b326158a9e810b6f8677f38c3d1f3999734"

URI_x86_64_v2_perl-Browser-Open-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Browser-Open-tests-0.04-38.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Browser-Open-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Browser-Open-tests}"
SRC_URI[x86_64_v2_perl-Browser-Open-tests.sha256sum] = "0ec42a3d2e16e96afd88055ec82f3658e3f0b7cd687396fdf5ba682c5cb5430d"

URI_aarch64_perl-Browser-Open = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Browser-Open-0.04-38.el10_0.noarch.rpm;name=aarch64_perl-Browser-Open;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Browser-Open}"
SRC_URI[aarch64_perl-Browser-Open.sha256sum] = "0974cbfff478aa209aa11c2bd590e51ae541d1d9ee6121450b19449b93b6aaaa"

URI_aarch64_perl-Browser-Open-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Browser-Open-tests-0.04-38.el10_0.noarch.rpm;name=aarch64_perl-Browser-Open-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Browser-Open-tests}"
SRC_URI[aarch64_perl-Browser-Open-tests.sha256sum] = "3bd24664e14e06d03e8c8b0e4fc88df7eeeeb9d301865d6fa21be94192f1ac30"

RDEPENDS:perl-Browser-Open = " \
 perl-Carp \
 perl-Exporter \
 perl-PathTools \
 perl-libs \
 perl-parent \
 "
RDEPENDS:perl-Browser-Open-tests = " \
 bash \
 lynx \
 perl-Browser-Open \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
