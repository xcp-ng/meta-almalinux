# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wsmancli"
PV = "2.6.2"
PR = "5.el10"
PACKAGES = " \
 wsmancli \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/wsmancli-2.6.2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "350d56c1ec816bf31bcea9cbb87424733dc8815abe86a43af05d852353520921"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/wsmancli-2.6.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_wsmancli;unpack=0"
SRC_URI[x86_64_v2_wsmancli.sha256sum] = "e46083ac63071ac64fc527b6ab22ae1f795dd94f828384d95bc7d1fdb9987f4b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/wsmancli-2.6.2-5.el10.aarch64.rpm;name=aarch64_wsmancli;unpack=0"
SRC_URI[aarch64_wsmancli.sha256sum] = "282de2789d86d1adff5fd1712e8dcb4ededda59e39e40e6721b46c30dd314742"

RDEPENDS:wsmancli = " \
 curl \
 glibc \
 libwsman1 \
 "
