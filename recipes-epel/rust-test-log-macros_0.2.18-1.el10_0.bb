# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-test-log-macros"
PV = "0.2.18"
PR = "1.el10_0"
PACKAGES = " \
 rust-test-log-macros+default-devel \
 rust-test-log-macros+log-devel \
 rust-test-log-macros+trace-devel \
 rust-test-log-macros+unstable-devel \
 rust-test-log-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-test-log-macros-0.2.18-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f23c1f6d0d96bfbab33021320a8b584535016b3cf042fa399f0a127f9c13e74e"

URI_x86_64_v2_rust-test-log-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-log-macros+default-devel-0.2.18-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-log-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-log-macros+default-devel}"
SRC_URI[x86_64_v2_rust-test-log-macros+default-devel.sha256sum] = "e1b3fb0f936ac2eadd2f6b5f2aa123d15aff26e12aff0b28c402de743c8a7174"

URI_x86_64_v2_rust-test-log-macros+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-log-macros+log-devel-0.2.18-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-log-macros+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-log-macros+log-devel}"
SRC_URI[x86_64_v2_rust-test-log-macros+log-devel.sha256sum] = "a64a450fbe45f0b45b0de9b391c0e06f89640ddc7fd124eaf273be67859619e7"

URI_x86_64_v2_rust-test-log-macros+trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-log-macros+trace-devel-0.2.18-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-log-macros+trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-log-macros+trace-devel}"
SRC_URI[x86_64_v2_rust-test-log-macros+trace-devel.sha256sum] = "e1043a648e4531655728c8f833d730be7fb234d8b14b78fbed35f4b1cc8028be"

URI_x86_64_v2_rust-test-log-macros+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-log-macros+unstable-devel-0.2.18-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-log-macros+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-log-macros+unstable-devel}"
SRC_URI[x86_64_v2_rust-test-log-macros+unstable-devel.sha256sum] = "e4a060426820b670ce5f67109ab297789c9b62b8bd0825bec838c9f83d694b19"

URI_x86_64_v2_rust-test-log-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-log-macros-devel-0.2.18-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-log-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-log-macros-devel}"
SRC_URI[x86_64_v2_rust-test-log-macros-devel.sha256sum] = "757bc4e9852b62f8a27d875b2886a212a5b7cc233b47ede58bb86adf6c67d37f"

URI_aarch64_rust-test-log-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-log-macros+default-devel-0.2.18-1.el10_0.noarch.rpm;name=aarch64_rust-test-log-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-log-macros+default-devel}"
SRC_URI[aarch64_rust-test-log-macros+default-devel.sha256sum] = "bc4cc1b0779cf1a8d22e92dacdfb3e19ce2d6dcfe289177a5fdd18cef4635a28"

URI_aarch64_rust-test-log-macros+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-log-macros+log-devel-0.2.18-1.el10_0.noarch.rpm;name=aarch64_rust-test-log-macros+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-log-macros+log-devel}"
SRC_URI[aarch64_rust-test-log-macros+log-devel.sha256sum] = "0ba2e2e39e0e175795fa69c96f47465e544e3ed718bc1d5af1f7dab5687cfab3"

URI_aarch64_rust-test-log-macros+trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-log-macros+trace-devel-0.2.18-1.el10_0.noarch.rpm;name=aarch64_rust-test-log-macros+trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-log-macros+trace-devel}"
SRC_URI[aarch64_rust-test-log-macros+trace-devel.sha256sum] = "ad83123bca85a111c594eadd28ddbe45b409c1145cc85f79d71e4a7fa82548e2"

URI_aarch64_rust-test-log-macros+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-log-macros+unstable-devel-0.2.18-1.el10_0.noarch.rpm;name=aarch64_rust-test-log-macros+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-log-macros+unstable-devel}"
SRC_URI[aarch64_rust-test-log-macros+unstable-devel.sha256sum] = "696186201963f400514e0873b81737c3fd94662e8018b9825b41dbf469b59433"

URI_aarch64_rust-test-log-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-log-macros-devel-0.2.18-1.el10_0.noarch.rpm;name=aarch64_rust-test-log-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-log-macros-devel}"
SRC_URI[aarch64_rust-test-log-macros-devel.sha256sum] = "8094db5b242bede982d3d45b145887ed82390337ac9b01763d8cc97ca916ce76"

RDEPENDS:rust-test-log-macros+default-devel = " \
 cargo \
 rust-test-log-macros-devel \
 "
RDEPENDS:rust-test-log-macros+log-devel = " \
 cargo \
 rust-test-log-macros-devel \
 "
RDEPENDS:rust-test-log-macros+trace-devel = " \
 cargo \
 rust-test-log-macros-devel \
 "
RDEPENDS:rust-test-log-macros+unstable-devel = " \
 cargo \
 rust-test-log-macros-devel \
 "
RDEPENDS:rust-test-log-macros-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
