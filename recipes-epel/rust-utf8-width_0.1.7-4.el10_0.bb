# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-utf8-width"
PV = "0.1.7"
PR = "4.el10_0"
PACKAGES = " \
 rust-utf8-width+default-devel \
 rust-utf8-width-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-utf8-width-0.1.7-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9933538c64e52403bf04741839d4303f4bcedd2f65aabe2f702404c7aa12a6f9"

URI_x86_64_v2_rust-utf8-width+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-utf8-width+default-devel-0.1.7-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-utf8-width+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-utf8-width+default-devel}"
SRC_URI[x86_64_v2_rust-utf8-width+default-devel.sha256sum] = "3350e450fa3f5de209cb26f695e3837d2bc2e0a406c2af529e9c14471ff6fa74"

URI_x86_64_v2_rust-utf8-width-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-utf8-width-devel-0.1.7-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-utf8-width-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-utf8-width-devel}"
SRC_URI[x86_64_v2_rust-utf8-width-devel.sha256sum] = "ac85b634dd3928fc5ea948d2b06f7a7594d5b3a572e3ba8994dc760fee377fa7"

URI_aarch64_rust-utf8-width+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-utf8-width+default-devel-0.1.7-4.el10_0.noarch.rpm;name=aarch64_rust-utf8-width+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-utf8-width+default-devel}"
SRC_URI[aarch64_rust-utf8-width+default-devel.sha256sum] = "c4689b8ae6a9422d9dc27c7193572d8f488fe5415fdb6b4923ee1f0791f7110b"

URI_aarch64_rust-utf8-width-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-utf8-width-devel-0.1.7-4.el10_0.noarch.rpm;name=aarch64_rust-utf8-width-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-utf8-width-devel}"
SRC_URI[aarch64_rust-utf8-width-devel.sha256sum] = "770edb66d5830b61637d2b9a3ed026267e45e376beaa4f2ef5eae3a05b9b1c7f"

RDEPENDS:rust-utf8-width+default-devel = " \
 cargo \
 rust-utf8-width-devel \
 "
RDEPENDS:rust-utf8-width-devel = " \
 cargo \
 rust \
 "
