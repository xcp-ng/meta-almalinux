# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-object"
PV = "0.36.7"
PR = "1.el10_0"
PACKAGES = " \
 rust-object+all-devel \
 rust-object+archive-devel \
 rust-object+build-devel \
 rust-object+build_core-devel \
 rust-object+cargo-all-devel \
 rust-object+coff-devel \
 rust-object+compression-devel \
 rust-object+default-devel \
 rust-object+doc-devel \
 rust-object+elf-devel \
 rust-object+macho-devel \
 rust-object+pe-devel \
 rust-object+read-devel \
 rust-object+read_core-devel \
 rust-object+std-devel \
 rust-object+unaligned-devel \
 rust-object+unstable-all-devel \
 rust-object+unstable-devel \
 rust-object+write-devel \
 rust-object+write_core-devel \
 rust-object+write_std-devel \
 rust-object+xcoff-devel \
 rust-object-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-object-0.36.7-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1db6ed7befabc7fdd733c5ff0395d45c5dfb0aa8fe802c62d476953c4007648d"

URI_x86_64_v2_rust-object+all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+all-devel-0.36.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+all-devel}"
SRC_URI[x86_64_v2_rust-object+all-devel.sha256sum] = "ce0a615935b4b545fce779bb4fc1b5f67e63500aeaec2347e746a1d5e67e823b"

URI_x86_64_v2_rust-object+archive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+archive-devel-0.36.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+archive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+archive-devel}"
SRC_URI[x86_64_v2_rust-object+archive-devel.sha256sum] = "e61b740cf8ebc69d585d46ccef4d5bbbb1a33668c9be977e4b3bc435262d6df3"

URI_x86_64_v2_rust-object+build-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+build-devel-0.36.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+build-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+build-devel}"
SRC_URI[x86_64_v2_rust-object+build-devel.sha256sum] = "d8f7e64865a5d99c1905d33d6305e24fd718935c286d0e18051a8df4f9b6c607"

URI_x86_64_v2_rust-object+build_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+build_core-devel-0.36.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+build_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+build_core-devel}"
SRC_URI[x86_64_v2_rust-object+build_core-devel.sha256sum] = "30f9dc16d4eb32d60f6c487188a4b4c9bed061a58019ffd15d547f7f933c5a10"

URI_x86_64_v2_rust-object+cargo-all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+cargo-all-devel-0.36.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+cargo-all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+cargo-all-devel}"
SRC_URI[x86_64_v2_rust-object+cargo-all-devel.sha256sum] = "bb30bfcc51ff93f9c5e9547210cce12b43da9090dcfbb928f20db2ce2214fe7e"

URI_x86_64_v2_rust-object+coff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+coff-devel-0.36.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+coff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+coff-devel}"
SRC_URI[x86_64_v2_rust-object+coff-devel.sha256sum] = "839106b36ab1185deb8d2a36211929e1a10b4eaffb9c13dbbd0a05712df4f343"

URI_x86_64_v2_rust-object+compression-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+compression-devel-0.36.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+compression-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+compression-devel}"
SRC_URI[x86_64_v2_rust-object+compression-devel.sha256sum] = "14ef621662d7b81f81aed5e89ab5bee35d9bc13f0fb7966cef0acfa08f8446c7"

URI_x86_64_v2_rust-object+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+default-devel-0.36.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+default-devel}"
SRC_URI[x86_64_v2_rust-object+default-devel.sha256sum] = "85c513da216cdfc0e36047c5e308b80945eb40fcfe9c5ddbaf45ec65642cfe74"

URI_x86_64_v2_rust-object+doc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+doc-devel-0.36.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+doc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+doc-devel}"
SRC_URI[x86_64_v2_rust-object+doc-devel.sha256sum] = "7c7f641f4a78e386935b00a216d72e2f33b1832694d9fe20d0cf294efbc50483"

URI_x86_64_v2_rust-object+elf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+elf-devel-0.36.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+elf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+elf-devel}"
SRC_URI[x86_64_v2_rust-object+elf-devel.sha256sum] = "d20035625dc90eb0136f6865e87da136b04491072a76f658999d3cfe05866c77"

URI_x86_64_v2_rust-object+macho-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+macho-devel-0.36.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+macho-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+macho-devel}"
SRC_URI[x86_64_v2_rust-object+macho-devel.sha256sum] = "00b58a7515971a8b818f5240ac06f999695e79db8fa749695ce021295c62f7be"

URI_x86_64_v2_rust-object+pe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+pe-devel-0.36.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+pe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+pe-devel}"
SRC_URI[x86_64_v2_rust-object+pe-devel.sha256sum] = "10513380554b9857ded3e354bd2a6eda4c04ae879827ea698c4724144c91dfc3"

URI_x86_64_v2_rust-object+read-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+read-devel-0.36.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+read-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+read-devel}"
SRC_URI[x86_64_v2_rust-object+read-devel.sha256sum] = "ba73c5c594f969d0b7422e8d26c01e4b92da520a7fc84d6b63db8874e25a69b8"

URI_x86_64_v2_rust-object+read_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+read_core-devel-0.36.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+read_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+read_core-devel}"
SRC_URI[x86_64_v2_rust-object+read_core-devel.sha256sum] = "4ee8b030386b6fc4608f4dac3c8071b9cf6ca1ee55830ee191b3f8afd18065bc"

URI_x86_64_v2_rust-object+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+std-devel-0.36.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+std-devel}"
SRC_URI[x86_64_v2_rust-object+std-devel.sha256sum] = "8ad83ba24ceac46ca8ad1646adc9ea87b1971d8adaf2c6a35a675c54fd8188dd"

URI_x86_64_v2_rust-object+unaligned-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+unaligned-devel-0.36.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+unaligned-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+unaligned-devel}"
SRC_URI[x86_64_v2_rust-object+unaligned-devel.sha256sum] = "2ee735f038d31e39ef3279f4cd6c4e15ca9224c5a2888f2653bb87d74ee2b331"

URI_x86_64_v2_rust-object+unstable-all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+unstable-all-devel-0.36.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+unstable-all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+unstable-all-devel}"
SRC_URI[x86_64_v2_rust-object+unstable-all-devel.sha256sum] = "07351ae2cd897d7ba586520761f6e59ddd3a16dd56d20d9124742e60cbdf0147"

URI_x86_64_v2_rust-object+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+unstable-devel-0.36.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+unstable-devel}"
SRC_URI[x86_64_v2_rust-object+unstable-devel.sha256sum] = "1a02a0ff6512620ce8a8402af76227ce63c7442a15b85d08b77e4314d5436004"

URI_x86_64_v2_rust-object+write-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+write-devel-0.36.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+write-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+write-devel}"
SRC_URI[x86_64_v2_rust-object+write-devel.sha256sum] = "0378b68e4dda43b0df8c9786fa615135304acf625b0542c01ebc54523e5d9150"

URI_x86_64_v2_rust-object+write_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+write_core-devel-0.36.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+write_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+write_core-devel}"
SRC_URI[x86_64_v2_rust-object+write_core-devel.sha256sum] = "fa669cdfc2d8968c8443fda645f102104a4393635787341c6d774aac6c8a3f50"

URI_x86_64_v2_rust-object+write_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+write_std-devel-0.36.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+write_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+write_std-devel}"
SRC_URI[x86_64_v2_rust-object+write_std-devel.sha256sum] = "80237f7b431ce91d55e461d7bee647f0558f034e1b09786121c06fac44b9bc3e"

URI_x86_64_v2_rust-object+xcoff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+xcoff-devel-0.36.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+xcoff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+xcoff-devel}"
SRC_URI[x86_64_v2_rust-object+xcoff-devel.sha256sum] = "81f2113a1c8b7ee1bf70555dfce317afe2e49d514f16ac5a98990848f4349ae8"

URI_x86_64_v2_rust-object-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object-devel-0.36.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object-devel}"
SRC_URI[x86_64_v2_rust-object-devel.sha256sum] = "71edc972298ef60967797ec9c2744088ebd3d68617337ef95fe444706f5a1a98"

URI_aarch64_rust-object+all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+all-devel-0.36.7-1.el10_0.noarch.rpm;name=aarch64_rust-object+all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+all-devel}"
SRC_URI[aarch64_rust-object+all-devel.sha256sum] = "3a95898bf6df7be132f2eaee26927188bf89157fa80fb6b55e626158ccb333fd"

URI_aarch64_rust-object+archive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+archive-devel-0.36.7-1.el10_0.noarch.rpm;name=aarch64_rust-object+archive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+archive-devel}"
SRC_URI[aarch64_rust-object+archive-devel.sha256sum] = "aa818aa6778ea3adbf9f675c0d0c23d2f418ef93b96d98258763f2cc6eeeac11"

URI_aarch64_rust-object+build-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+build-devel-0.36.7-1.el10_0.noarch.rpm;name=aarch64_rust-object+build-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+build-devel}"
SRC_URI[aarch64_rust-object+build-devel.sha256sum] = "d9074cf3be0175662bd38b72b250ba2a68f28dc61f9954999a78a33578a0f467"

URI_aarch64_rust-object+build_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+build_core-devel-0.36.7-1.el10_0.noarch.rpm;name=aarch64_rust-object+build_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+build_core-devel}"
SRC_URI[aarch64_rust-object+build_core-devel.sha256sum] = "6a085dff6a53276155cb7da239f106202495baf59b3b8a86acc473b2b228ff6d"

URI_aarch64_rust-object+cargo-all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+cargo-all-devel-0.36.7-1.el10_0.noarch.rpm;name=aarch64_rust-object+cargo-all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+cargo-all-devel}"
SRC_URI[aarch64_rust-object+cargo-all-devel.sha256sum] = "760fdd496f3bd0f87628c422388e0a424b7f41088214d09772c1925c3edb0c26"

URI_aarch64_rust-object+coff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+coff-devel-0.36.7-1.el10_0.noarch.rpm;name=aarch64_rust-object+coff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+coff-devel}"
SRC_URI[aarch64_rust-object+coff-devel.sha256sum] = "0c39fa35f78b4ea712a5e2fe7d5dde9c0b84522a0ca4f41de2cfc35fec58660a"

URI_aarch64_rust-object+compression-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+compression-devel-0.36.7-1.el10_0.noarch.rpm;name=aarch64_rust-object+compression-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+compression-devel}"
SRC_URI[aarch64_rust-object+compression-devel.sha256sum] = "b3ce94b84b838bd6d7a3a99d801543abc1b763461229c419f436255374f67169"

URI_aarch64_rust-object+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+default-devel-0.36.7-1.el10_0.noarch.rpm;name=aarch64_rust-object+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+default-devel}"
SRC_URI[aarch64_rust-object+default-devel.sha256sum] = "0c2ef8be643626e2eedddbf22ce87d1be3ca4b06f5ba476a3e5a008e55d656b2"

URI_aarch64_rust-object+doc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+doc-devel-0.36.7-1.el10_0.noarch.rpm;name=aarch64_rust-object+doc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+doc-devel}"
SRC_URI[aarch64_rust-object+doc-devel.sha256sum] = "d667e38282ff5bbe98afd49bd9701b6a922a0669cbb4bbf52f4c32c66738d038"

URI_aarch64_rust-object+elf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+elf-devel-0.36.7-1.el10_0.noarch.rpm;name=aarch64_rust-object+elf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+elf-devel}"
SRC_URI[aarch64_rust-object+elf-devel.sha256sum] = "ee21f2045eb449ab471ed7d063dc1968e5a7c970b62f28aa5fb0af52cc3d51af"

URI_aarch64_rust-object+macho-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+macho-devel-0.36.7-1.el10_0.noarch.rpm;name=aarch64_rust-object+macho-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+macho-devel}"
SRC_URI[aarch64_rust-object+macho-devel.sha256sum] = "fc65c4c761093244888f6fad9e59e22e65c0fc2d2b5a5aedb506bf6dc0469d82"

URI_aarch64_rust-object+pe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+pe-devel-0.36.7-1.el10_0.noarch.rpm;name=aarch64_rust-object+pe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+pe-devel}"
SRC_URI[aarch64_rust-object+pe-devel.sha256sum] = "db8186bc2d84952124ad676896352e848bfc8fb66f6148f104e6439ecd066034"

URI_aarch64_rust-object+read-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+read-devel-0.36.7-1.el10_0.noarch.rpm;name=aarch64_rust-object+read-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+read-devel}"
SRC_URI[aarch64_rust-object+read-devel.sha256sum] = "1bff715e7841b8ae670ea18b048f410ef84c52ffae5fba458a8c03b672869ec5"

URI_aarch64_rust-object+read_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+read_core-devel-0.36.7-1.el10_0.noarch.rpm;name=aarch64_rust-object+read_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+read_core-devel}"
SRC_URI[aarch64_rust-object+read_core-devel.sha256sum] = "3ed9af8a4088286cb97bcd6bdfeeffa21c66b3ea5911be56c30b043ca7944ed8"

URI_aarch64_rust-object+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+std-devel-0.36.7-1.el10_0.noarch.rpm;name=aarch64_rust-object+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+std-devel}"
SRC_URI[aarch64_rust-object+std-devel.sha256sum] = "6b06bbe40598969e9a020f7993440304e21dd1428ec60777aaf61ecc5e4f46c1"

URI_aarch64_rust-object+unaligned-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+unaligned-devel-0.36.7-1.el10_0.noarch.rpm;name=aarch64_rust-object+unaligned-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+unaligned-devel}"
SRC_URI[aarch64_rust-object+unaligned-devel.sha256sum] = "7eef62ce042ec090dff951b1f2a6c7c858a436ece8c499e630b51b054c2708b6"

URI_aarch64_rust-object+unstable-all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+unstable-all-devel-0.36.7-1.el10_0.noarch.rpm;name=aarch64_rust-object+unstable-all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+unstable-all-devel}"
SRC_URI[aarch64_rust-object+unstable-all-devel.sha256sum] = "4f211986702b578fcbf9777d1d45ce0a2c70a6c3db95eaedf0610303f9c0f6d0"

URI_aarch64_rust-object+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+unstable-devel-0.36.7-1.el10_0.noarch.rpm;name=aarch64_rust-object+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+unstable-devel}"
SRC_URI[aarch64_rust-object+unstable-devel.sha256sum] = "5067c2c2525639b8e4f6ff0ab5b8c6dc751d400768b19d1b85df913f0124cefb"

URI_aarch64_rust-object+write-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+write-devel-0.36.7-1.el10_0.noarch.rpm;name=aarch64_rust-object+write-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+write-devel}"
SRC_URI[aarch64_rust-object+write-devel.sha256sum] = "f84533f424ab2c08ee7b1bdec0671bcc34623140713d30fd407685d97b8da1fb"

URI_aarch64_rust-object+write_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+write_core-devel-0.36.7-1.el10_0.noarch.rpm;name=aarch64_rust-object+write_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+write_core-devel}"
SRC_URI[aarch64_rust-object+write_core-devel.sha256sum] = "18aa3156e7b6c65f647f7110b04aed4f7bf7a83d3d1afcbaae99bdba6a4b5493"

URI_aarch64_rust-object+write_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+write_std-devel-0.36.7-1.el10_0.noarch.rpm;name=aarch64_rust-object+write_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+write_std-devel}"
SRC_URI[aarch64_rust-object+write_std-devel.sha256sum] = "60c49e9528cb167fbe1cd802df22d73adcb20ab746fc1c00f317d8ec9e53c3bf"

URI_aarch64_rust-object+xcoff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+xcoff-devel-0.36.7-1.el10_0.noarch.rpm;name=aarch64_rust-object+xcoff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+xcoff-devel}"
SRC_URI[aarch64_rust-object+xcoff-devel.sha256sum] = "cc38bb26b0e048eb788580944e927a8b1a8b1b706108016b26c65e63bf012ade"

URI_aarch64_rust-object-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object-devel-0.36.7-1.el10_0.noarch.rpm;name=aarch64_rust-object-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object-devel}"
SRC_URI[aarch64_rust-object-devel.sha256sum] = "995070f650fdb6b9dc31386999bb7f3ee070502d2ba493931f5ee9c610dbb22b"

RDEPENDS:rust-object+all-devel = " \
 cargo \
 rust-object+build-devel \
 rust-object+compression-devel \
 rust-object+read-devel \
 rust-object+std-devel \
 rust-object+write-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+archive-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object+build-devel = " \
 cargo \
 rust-object+build_core-devel \
 rust-object+elf-devel \
 rust-object+write_std-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+build_core-devel = " \
 cargo \
 rust-object+read_core-devel \
 rust-object+write_core-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+cargo-all-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object+coff-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object+compression-devel = " \
 cargo \
 rust-flate2+default-devel \
 rust-object+std-devel \
 rust-object-devel \
 rust-ruzstd+default-devel \
 "
RDEPENDS:rust-object+default-devel = " \
 cargo \
 rust-object+compression-devel \
 rust-object+read-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+doc-devel = " \
 cargo \
 rust-object+archive-devel \
 rust-object+build_core-devel \
 rust-object+coff-devel \
 rust-object+compression-devel \
 rust-object+elf-devel \
 rust-object+macho-devel \
 rust-object+pe-devel \
 rust-object+read_core-devel \
 rust-object+std-devel \
 rust-object+write_std-devel \
 rust-object+xcoff-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+elf-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object+macho-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object+pe-devel = " \
 cargo \
 rust-object+coff-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+read-devel = " \
 cargo \
 rust-object+archive-devel \
 rust-object+coff-devel \
 rust-object+elf-devel \
 rust-object+macho-devel \
 rust-object+pe-devel \
 rust-object+read_core-devel \
 rust-object+unaligned-devel \
 rust-object+xcoff-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+read_core-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object+std-devel = " \
 cargo \
 rust-memchr+std-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+unaligned-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object+unstable-all-devel = " \
 cargo \
 rust-object+all-devel \
 rust-object+unstable-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+unstable-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object+write-devel = " \
 cargo \
 rust-object+coff-devel \
 rust-object+elf-devel \
 rust-object+macho-devel \
 rust-object+pe-devel \
 rust-object+write_std-devel \
 rust-object+xcoff-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+write_core-devel = " \
 cargo \
 rust-crc32fast-devel \
 rust-hashbrown+default-hasher-devel \
 rust-hashbrown-devel \
 rust-indexmap-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+write_std-devel = " \
 cargo \
 rust-crc32fast+std-devel \
 rust-crc32fast-devel \
 rust-indexmap+std-devel \
 rust-indexmap-devel \
 rust-object+std-devel \
 rust-object+write_core-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+xcoff-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object-devel = " \
 cargo \
 rust \
 rust-memchr-devel \
 "
