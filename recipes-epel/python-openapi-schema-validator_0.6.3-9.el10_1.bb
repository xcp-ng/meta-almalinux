# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-openapi-schema-validator"
PV = "0.6.3"
PR = "9.el10_1"
PACKAGES = " \
 python3-openapi-schema-validator \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-openapi-schema-validator-0.6.3-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "238d4ecac4f10ae349fd57130c3bde8e28e22254ff0dfc8aeb5ecadce62ffe10"

URI_x86_64_v2_python3-openapi-schema-validator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-openapi-schema-validator-0.6.3-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-openapi-schema-validator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-openapi-schema-validator}"
SRC_URI[x86_64_v2_python3-openapi-schema-validator.sha256sum] = "ab5f0e75620b5a325542b33d554d996b4a090b61b4b39455050b3825c88c34a7"

URI_aarch64_python3-openapi-schema-validator = "${EPEL_MIRROR}/aarch64/Packages/p/python3-openapi-schema-validator-0.6.3-9.el10_1.noarch.rpm;name=aarch64_python3-openapi-schema-validator;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-openapi-schema-validator}"
SRC_URI[aarch64_python3-openapi-schema-validator.sha256sum] = "06a858ad84f3b44a84ecba02d81595efbb4335dbe742202bfc33a55d63db6a45"

RDEPENDS:python3-openapi-schema-validator = " \
 python3 \
 python3-jsonschema \
 python3-jsonschema-specifications \
 python3-rfc3339-validator \
 "
