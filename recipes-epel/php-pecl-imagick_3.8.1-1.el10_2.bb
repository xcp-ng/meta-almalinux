# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-imagick"
PV = "3.8.1"
PR = "1.el10_2"
PACKAGES = " \
 php-pecl-imagick \
 php-pecl-imagick-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-imagick-3.8.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da8d29d8df04a53879aad9bf1bd7ccb5c676231690b64a4eab6640f844246799"

URI_x86_64_v2_php-pecl-imagick = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-imagick-3.8.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-imagick;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-imagick}"
SRC_URI[x86_64_v2_php-pecl-imagick.sha256sum] = "d85fb58d5994276587825cc6e22fbef019ce7a3e3d0086c1dd855871e893fd09"

URI_x86_64_v2_php-pecl-imagick-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-imagick-devel-3.8.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-imagick-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-imagick-devel}"
SRC_URI[x86_64_v2_php-pecl-imagick-devel.sha256sum] = "97805ded0715a149af8e71651c9128ce1329a8dc1b23f00ddbc90378b107b7b5"

URI_aarch64_php-pecl-imagick = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-imagick-3.8.1-1.el10_2.aarch64.rpm;name=aarch64_php-pecl-imagick;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-imagick}"
SRC_URI[aarch64_php-pecl-imagick.sha256sum] = "65f96aa5cb743f0e07306aac900f9015f886e442b08582a80ef6b81102fc491b"

URI_aarch64_php-pecl-imagick-devel = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-imagick-devel-3.8.1-1.el10_2.aarch64.rpm;name=aarch64_php-pecl-imagick-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-imagick-devel}"
SRC_URI[aarch64_php-pecl-imagick-devel.sha256sum] = "f820e0ca8367095fd041af541298a65f499e3f6f9ffd23b2a72e84dbf80cf297"

RDEPENDS:php-pecl-imagick:x86_64_v2 = " \
 ImageMagick-libs \
 glibc \
 libgomp \
 php8.4-common \
"
RDEPENDS:php-pecl-imagick:aarch64 = " \
 ImageMagick-libs \
 glibc \
 libgomp \
 php-common \
"
RDEPENDS:php-pecl-imagick-devel = " \
 php-devel \
 php-pecl-imagick \
 "
