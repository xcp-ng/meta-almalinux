# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadiconsole"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 akonadiconsole \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akonadiconsole-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dcf7b5ac9117aa1b23416c3db28b3f6dc4872de4377611153feef0b356ad5ff4"

URI_x86_64_v2_akonadiconsole = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadiconsole-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadiconsole;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadiconsole}"
SRC_URI[x86_64_v2_akonadiconsole.sha256sum] = "bf89abc89b3adf8799a7c88a26042d854659b5e94fe920202266efa084588ea5"

URI_aarch64_akonadiconsole = "${EPEL_MIRROR}/aarch64/Packages/a/akonadiconsole-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_akonadiconsole;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadiconsole}"
SRC_URI[aarch64_akonadiconsole.sha256sum] = "e282fe6625591f1e151f7deea395e77652ccfca58ee9f90c521bb0921b56d994"

RDEPENDS:akonadiconsole = " \
 akonadi-calendar-tools \
 akonadi-contacts \
 akonadi-search \
 akonadi-server \
 calendarsupport \
 glibc \
 kf6-kcalendarcore \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kitemmodels \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kmime \
 libgcc \
 libkdepim \
 libstdc++ \
 messagelib \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 xapian-core-libs \
 "
