# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gfal2"
PV = "2.23.5"
PR = "2.el10_2"
PACKAGES = " \
 gfal2 \
 gfal2-all \
 gfal2-devel \
 gfal2-doc \
 gfal2-plugin-file \
 gfal2-plugin-http \
 gfal2-plugin-mock \
 gfal2-plugin-srm \
 gfal2-plugin-xrootd \
 gfal2-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gfal2-2.23.5-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0130f596a254312e8d1aa2d2d73ece8bcbc5fbd7267b52a6cc79e65ba180697"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - gfal2-plugin-xrootd: libXrdCl.so.6()(64bit)
# - gfal2-plugin-xrootd: libXrdPosix.so.6()(64bit)

URI_x86_64_v2_gfal2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-2.23.5-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2}"
SRC_URI[x86_64_v2_gfal2.sha256sum] = "4270adf07814571fff44340abff7fa5942be31d251bcb7c43d19b2567be540be"

URI_x86_64_v2_gfal2-all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-all-2.23.5-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2-all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-all}"
SRC_URI[x86_64_v2_gfal2-all.sha256sum] = "890a82e0590a959f30ea12596af97891ffe23a544c47ab78333cc695b29567ed"

URI_x86_64_v2_gfal2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-devel-2.23.5-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-devel}"
SRC_URI[x86_64_v2_gfal2-devel.sha256sum] = "d9bcdfab6ec022a5da667ba670e22821734248eb415ebea95ce46650484f8dd9"

URI_x86_64_v2_gfal2-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-doc-2.23.5-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_gfal2-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-doc}"
SRC_URI[x86_64_v2_gfal2-doc.sha256sum] = "2fe49b07c51e53115d877ba00f29c0143a327d54f7fa545ee9e36a13f32965be"

URI_x86_64_v2_gfal2-plugin-file = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-plugin-file-2.23.5-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2-plugin-file;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-plugin-file}"
SRC_URI[x86_64_v2_gfal2-plugin-file.sha256sum] = "f14f55110d3f89ab6cd443424438a4da90c67ae513df9864f90d5a9d52d170e3"

URI_x86_64_v2_gfal2-plugin-http = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-plugin-http-2.23.5-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2-plugin-http;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-plugin-http}"
SRC_URI[x86_64_v2_gfal2-plugin-http.sha256sum] = "b96479ec1c847628aaf07dc9fd005b7cafeba3ffed62d42e72988fca9aaf5dc6"

URI_x86_64_v2_gfal2-plugin-mock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-plugin-mock-2.23.5-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2-plugin-mock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-plugin-mock}"
SRC_URI[x86_64_v2_gfal2-plugin-mock.sha256sum] = "a3e799a13ab5ebdf7c62c21b12dbf138c7a7382f945988f547a51180baa53476"

URI_x86_64_v2_gfal2-plugin-srm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-plugin-srm-2.23.5-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2-plugin-srm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-plugin-srm}"
SRC_URI[x86_64_v2_gfal2-plugin-srm.sha256sum] = "ad61d2cf8f06424964cd156cb7a789d6ccfc7ad43b580043267788024f2aa7ff"

URI_x86_64_v2_gfal2-plugin-xrootd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-plugin-xrootd-2.23.5-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2-plugin-xrootd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-plugin-xrootd}"
SRC_URI[x86_64_v2_gfal2-plugin-xrootd.sha256sum] = "4539dd6f3b8d7fca90b624b863ea5a964180e11b4fe84f72dfbc1deaf6ddbca8"

URI_x86_64_v2_gfal2-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-tests-2.23.5-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gfal2-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-tests}"
SRC_URI[x86_64_v2_gfal2-tests.sha256sum] = "a5faa90df035c44e9b2a4424b5f3be0afb1f96313961883c9f44b50971381f12"

URI_aarch64_gfal2 = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-2.23.5-2.el10_2.aarch64.rpm;name=aarch64_gfal2;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2}"
SRC_URI[aarch64_gfal2.sha256sum] = "a863494c1372497ecff84de8c54a15850854e45e54db34b8c00a1a4ab5bea597"

URI_aarch64_gfal2-all = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-all-2.23.5-2.el10_2.aarch64.rpm;name=aarch64_gfal2-all;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-all}"
SRC_URI[aarch64_gfal2-all.sha256sum] = "3e8312cf462c732a5fac83577a74bcd2b4356688583ebac39238ce257ebdf3be"

URI_aarch64_gfal2-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-devel-2.23.5-2.el10_2.aarch64.rpm;name=aarch64_gfal2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-devel}"
SRC_URI[aarch64_gfal2-devel.sha256sum] = "58402b731bc0e002165576ab5e064770dec5e4dee70014a309f167e556b7484d"

URI_aarch64_gfal2-doc = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-doc-2.23.5-2.el10_2.noarch.rpm;name=aarch64_gfal2-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-doc}"
SRC_URI[aarch64_gfal2-doc.sha256sum] = "7ea2d5684db0e5d52a7cc015f64358f9e7e23b3e14a4e92b7411a092875f1d86"

URI_aarch64_gfal2-plugin-file = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-plugin-file-2.23.5-2.el10_2.aarch64.rpm;name=aarch64_gfal2-plugin-file;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-plugin-file}"
SRC_URI[aarch64_gfal2-plugin-file.sha256sum] = "3d8984848e5e79487ce40c472b72471e4e96a4a3d020ac32c0472b826039a2f3"

URI_aarch64_gfal2-plugin-http = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-plugin-http-2.23.5-2.el10_2.aarch64.rpm;name=aarch64_gfal2-plugin-http;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-plugin-http}"
SRC_URI[aarch64_gfal2-plugin-http.sha256sum] = "70491ba45757d82640b12f2598c3f223723145004cdf8cdc7fa13d32e8db8328"

URI_aarch64_gfal2-plugin-mock = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-plugin-mock-2.23.5-2.el10_2.aarch64.rpm;name=aarch64_gfal2-plugin-mock;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-plugin-mock}"
SRC_URI[aarch64_gfal2-plugin-mock.sha256sum] = "50c726f4c8886f253c3454857fae06e58c6cbeadb00ce3234b929261d0edf9ea"

URI_aarch64_gfal2-plugin-srm = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-plugin-srm-2.23.5-2.el10_2.aarch64.rpm;name=aarch64_gfal2-plugin-srm;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-plugin-srm}"
SRC_URI[aarch64_gfal2-plugin-srm.sha256sum] = "2d1ca0a129a594766e4ad3baffad89ed66912674645a7f775faab87c6a1577b0"

URI_aarch64_gfal2-plugin-xrootd = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-plugin-xrootd-2.23.5-2.el10_2.aarch64.rpm;name=aarch64_gfal2-plugin-xrootd;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-plugin-xrootd}"
SRC_URI[aarch64_gfal2-plugin-xrootd.sha256sum] = "4d509d22164bb9249b9138e6a4229e72c63efae6e0f79cf7946766a0e98dc338"

URI_aarch64_gfal2-tests = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-tests-2.23.5-2.el10_2.aarch64.rpm;name=aarch64_gfal2-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-tests}"
SRC_URI[aarch64_gfal2-tests.sha256sum] = "8ec82200e1b6ee12b54f7226015312a485986b476f2117a1c510e4aebc972128"

RDEPENDS:gfal2 = " \
 glib2 \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 openldap \
 pugixml \
 "
RDEPENDS:gfal2-all = " \
 gfal2 \
 gfal2-plugin-file \
 gfal2-plugin-http \
 gfal2-plugin-srm \
 gfal2-plugin-xrootd \
 "
RDEPENDS:gfal2-devel = " \
 gfal2 \
 gfal2-devel \
 glib2-devel \
 libattr-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:gfal2-doc = " \
 "
RDEPENDS:gfal2-plugin-file = " \
 gfal2 \
 glib2 \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:gfal2-plugin-http = " \
 cryptopp \
 davix-libs \
 gfal2 \
 glib2 \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 "
RDEPENDS:gfal2-plugin-mock = " \
 gfal2 \
 glib2 \
 glibc \
 libuuid \
 "
RDEPENDS:gfal2-plugin-srm = " \
 gfal2 \
 glib2 \
 glibc \
 globus-common \
 globus-gss-assist \
 globus-gssapi-gsi \
 srm-ifce \
 "
RDEPENDS:gfal2-plugin-xrootd:x86_64_v2 = " \
 gfal2 \
 glib2 \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
"
RDEPENDS:gfal2-plugin-xrootd:aarch64 = " \
 gfal2 \
 glib2 \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 xrootd-client-libs \
"
RDEPENDS:gfal2-tests = " \
 cryptopp \
 davix-libs \
 gfal2 \
 gfal2-all \
 gfal2-plugin-mock \
 glib2 \
 glibc \
 gtest \
 json-c \
 libgcc \
 libstdc++ \
 "
