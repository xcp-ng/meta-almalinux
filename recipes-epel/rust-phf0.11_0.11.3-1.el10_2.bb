# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-phf0.11"
PV = "0.11.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-phf0.11+default-devel \
 rust-phf0.11+macros-devel \
 rust-phf0.11+phf_macros-devel \
 rust-phf0.11+serde-devel \
 rust-phf0.11+std-devel \
 rust-phf0.11+uncased-devel \
 rust-phf0.11+unicase-devel \
 rust-phf0.11-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-phf0.11-0.11.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e983cb8166038e32a91321fef5d1320b3d16fbd00b01a145a6d2066742de93d7"

URI_x86_64_v2_rust-phf0.11+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf0.11+default-devel-0.11.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf0.11+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf0.11+default-devel}"
SRC_URI[x86_64_v2_rust-phf0.11+default-devel.sha256sum] = "9f3f877b89f9ffa2302d9a5847e30b4d714b61e176f587a5f9e38c681d04a408"

URI_x86_64_v2_rust-phf0.11+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf0.11+macros-devel-0.11.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf0.11+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf0.11+macros-devel}"
SRC_URI[x86_64_v2_rust-phf0.11+macros-devel.sha256sum] = "f3e1c2af7f1d2376e0552f62c8da194332bf59a684f9aa3745c1256438c1f7e0"

URI_x86_64_v2_rust-phf0.11+phf_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf0.11+phf_macros-devel-0.11.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf0.11+phf_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf0.11+phf_macros-devel}"
SRC_URI[x86_64_v2_rust-phf0.11+phf_macros-devel.sha256sum] = "f07b26bba746457c31bd73f567fd0a0c79e1798ec64b6fd7e654e6e1f295ae34"

URI_x86_64_v2_rust-phf0.11+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf0.11+serde-devel-0.11.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf0.11+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf0.11+serde-devel}"
SRC_URI[x86_64_v2_rust-phf0.11+serde-devel.sha256sum] = "ee975079d1c0688002770e09464cf8e5363b23dfc90875e7899290225bbdbd1d"

URI_x86_64_v2_rust-phf0.11+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf0.11+std-devel-0.11.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf0.11+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf0.11+std-devel}"
SRC_URI[x86_64_v2_rust-phf0.11+std-devel.sha256sum] = "7d47bdae9bcc7ba5d2a46209cf92809a1c1f5c988a67d9037bce3abe6fe0a44f"

URI_x86_64_v2_rust-phf0.11+uncased-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf0.11+uncased-devel-0.11.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf0.11+uncased-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf0.11+uncased-devel}"
SRC_URI[x86_64_v2_rust-phf0.11+uncased-devel.sha256sum] = "086736bfe220f070e4dd2cfb9553eef36bb31bca94957385df3e513270b650ed"

URI_x86_64_v2_rust-phf0.11+unicase-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf0.11+unicase-devel-0.11.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf0.11+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf0.11+unicase-devel}"
SRC_URI[x86_64_v2_rust-phf0.11+unicase-devel.sha256sum] = "e11f31de040928a759524ea03074ed3bd8d29f86d98aa31fa4fd2b60195d2096"

URI_x86_64_v2_rust-phf0.11-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf0.11-devel-0.11.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf0.11-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf0.11-devel}"
SRC_URI[x86_64_v2_rust-phf0.11-devel.sha256sum] = "4b5fc708959e171147d9ad3d8f93518d068cadd37765a9c5015da43212a97b55"

URI_aarch64_rust-phf0.11+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf0.11+default-devel-0.11.3-1.el10_2.noarch.rpm;name=aarch64_rust-phf0.11+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf0.11+default-devel}"
SRC_URI[aarch64_rust-phf0.11+default-devel.sha256sum] = "fad84807b938cc540928a696066c39d671f716744a3041262aca643f8daa40a9"

URI_aarch64_rust-phf0.11+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf0.11+macros-devel-0.11.3-1.el10_2.noarch.rpm;name=aarch64_rust-phf0.11+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf0.11+macros-devel}"
SRC_URI[aarch64_rust-phf0.11+macros-devel.sha256sum] = "cdf054c36db98d94380ac1e0428359f83e61f7bb326265f0ac5049d1c667d92a"

URI_aarch64_rust-phf0.11+phf_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf0.11+phf_macros-devel-0.11.3-1.el10_2.noarch.rpm;name=aarch64_rust-phf0.11+phf_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf0.11+phf_macros-devel}"
SRC_URI[aarch64_rust-phf0.11+phf_macros-devel.sha256sum] = "562fcbc93ffabba95bddec1ccea4ddf9bfc67f57618ab9c8ec421dd1844537fa"

URI_aarch64_rust-phf0.11+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf0.11+serde-devel-0.11.3-1.el10_2.noarch.rpm;name=aarch64_rust-phf0.11+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf0.11+serde-devel}"
SRC_URI[aarch64_rust-phf0.11+serde-devel.sha256sum] = "32c4405903ccd65c217a72c79a394b7deb9275e4ec69a614fc80151f029fd945"

URI_aarch64_rust-phf0.11+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf0.11+std-devel-0.11.3-1.el10_2.noarch.rpm;name=aarch64_rust-phf0.11+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf0.11+std-devel}"
SRC_URI[aarch64_rust-phf0.11+std-devel.sha256sum] = "6d8c5e8acdc76ae079425492ed3659f4cf9f04c372d73eeef88675fda607601b"

URI_aarch64_rust-phf0.11+uncased-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf0.11+uncased-devel-0.11.3-1.el10_2.noarch.rpm;name=aarch64_rust-phf0.11+uncased-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf0.11+uncased-devel}"
SRC_URI[aarch64_rust-phf0.11+uncased-devel.sha256sum] = "9bd568ad02ef4bbc8554895ec9871c8fe313d11ed0ce0c63f49e9b05134f6062"

URI_aarch64_rust-phf0.11+unicase-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf0.11+unicase-devel-0.11.3-1.el10_2.noarch.rpm;name=aarch64_rust-phf0.11+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf0.11+unicase-devel}"
SRC_URI[aarch64_rust-phf0.11+unicase-devel.sha256sum] = "b189f3408eb3e9131ebf5c0d36a4ced1240848f01dbf7af79f16870c297c12c6"

URI_aarch64_rust-phf0.11-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf0.11-devel-0.11.3-1.el10_2.noarch.rpm;name=aarch64_rust-phf0.11-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf0.11-devel}"
SRC_URI[aarch64_rust-phf0.11-devel.sha256sum] = "9a4408d3892f9c3f887281f11df4042e9915f920cff574a2cceea4771a2d3906"

RDEPENDS:rust-phf0.11+default-devel = " \
 cargo \
 rust-phf0.11+std-devel \
 rust-phf0.11-devel \
 "
RDEPENDS:rust-phf0.11+macros-devel = " \
 cargo \
 rust-phf0.11+phf_macros-devel \
 rust-phf0.11-devel \
 "
RDEPENDS:rust-phf0.11+phf_macros-devel = " \
 cargo \
 rust-phf0.11-devel \
 rust-phf_macros0.11+default-devel \
 "
RDEPENDS:rust-phf0.11+serde-devel = " \
 cargo \
 rust-phf0.11-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-phf0.11+std-devel = " \
 cargo \
 rust-phf0.11-devel \
 rust-phf_shared0.11+std-devel \
 "
RDEPENDS:rust-phf0.11+uncased-devel = " \
 cargo \
 rust-phf0.11-devel \
 rust-phf_shared0.11+uncased-devel \
 "
RDEPENDS:rust-phf0.11+unicase-devel = " \
 cargo \
 rust-phf0.11-devel \
 rust-phf_macros0.11+default-devel \
 rust-phf_macros0.11+unicase-devel \
 rust-phf_shared0.11+unicase-devel \
 "
RDEPENDS:rust-phf0.11-devel = " \
 cargo \
 rust \
 rust-phf_shared0.11-devel \
 "
