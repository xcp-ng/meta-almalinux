# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hyper"
PV = "1.11.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-hyper+capi-devel \
 rust-hyper+client-devel \
 rust-hyper+default-devel \
 rust-hyper+ffi-devel \
 rust-hyper+full-devel \
 rust-hyper+http1-devel \
 rust-hyper+http2-devel \
 rust-hyper+server-devel \
 rust-hyper+tracing-devel \
 rust-hyper-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-hyper-1.11.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "96509b57c4140d1b9c45243f1af68758da0efcfe307477cf62637a337d046460"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+capi-devel-1.11.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+capi-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper+capi-devel.sha256sum] = "c7b1e6f2ffc3b3a4953e5eff6db12d42f00127bea4415e05a9b4652442fe5e71"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+client-devel-1.11.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+client-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper+client-devel.sha256sum] = "52c16e76336d746bc35e0c52bfa55c880df792e5565535ec2fadd243435e6106"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+default-devel-1.11.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper+default-devel.sha256sum] = "2292caf7cce81cd5d156e61c03eba5ab6280cad26c726912b6c13235acbbb118"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+ffi-devel-1.11.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+ffi-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper+ffi-devel.sha256sum] = "ddd043e5e14e7d6050729184d8a416756fffbf5c498bf2b12bb28574020bf7f0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+full-devel-1.11.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+full-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper+full-devel.sha256sum] = "8303e2706b4a57962ffb821cdd9a1f77b500c890f37d515c53c947681701324c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+http1-devel-1.11.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+http1-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper+http1-devel.sha256sum] = "13e3818ddcc70f253f3e706dde217e814dcbeb4281af880bbeabceacb46d425b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+http2-devel-1.11.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+http2-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper+http2-devel.sha256sum] = "0b23076bbc430e16461a2d0a28827eed8a441e318593fd18edd97483ec60f293"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+server-devel-1.11.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+server-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper+server-devel.sha256sum] = "cdec31e6041dcfe62b61cb1ee124839ca9a1cf7e7e5aac200a22e9263ab55d6a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+tracing-devel-1.11.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+tracing-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper+tracing-devel.sha256sum] = "bbfb7d9b861950ca97cd8c0de94562f17a042a5661022a195d68a3c50f9d007c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-devel-1.11.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper-devel.sha256sum] = "a43100579972d83bdf64d8abaff890a0b7fb323ddd558616be3fb5e1a728306a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+capi-devel-1.11.1-1.el10_2.noarch.rpm;name=aarch64_rust-hyper+capi-devel;unpack=0"
SRC_URI[aarch64_rust-hyper+capi-devel.sha256sum] = "33f6ebdd8337df20a3b0f0e24e791c5c7bd198e29ff0199c536e84727f3efcb3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+client-devel-1.11.1-1.el10_2.noarch.rpm;name=aarch64_rust-hyper+client-devel;unpack=0"
SRC_URI[aarch64_rust-hyper+client-devel.sha256sum] = "3745bbef45705abc132f07f5c304ede6b2d6ca6a9d33b8c25030553c18ac6ce6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+default-devel-1.11.1-1.el10_2.noarch.rpm;name=aarch64_rust-hyper+default-devel;unpack=0"
SRC_URI[aarch64_rust-hyper+default-devel.sha256sum] = "b0fa794e9a1b0b5340dc1a874079a0ecf0cf96e55a1b1b91ca9a854c50e6709d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+ffi-devel-1.11.1-1.el10_2.noarch.rpm;name=aarch64_rust-hyper+ffi-devel;unpack=0"
SRC_URI[aarch64_rust-hyper+ffi-devel.sha256sum] = "7299f61d78dd4e5399c1c1ef1305192a733076aaec550e5419e71f39199b3b52"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+full-devel-1.11.1-1.el10_2.noarch.rpm;name=aarch64_rust-hyper+full-devel;unpack=0"
SRC_URI[aarch64_rust-hyper+full-devel.sha256sum] = "2b376e7cea64471ef7b578927a1fb7cb9c0ad6836f4f358405c90ada29b80dc5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+http1-devel-1.11.1-1.el10_2.noarch.rpm;name=aarch64_rust-hyper+http1-devel;unpack=0"
SRC_URI[aarch64_rust-hyper+http1-devel.sha256sum] = "9942170accf139f5d425bc414a0dafe3071542c69677da4c2db81767969301b2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+http2-devel-1.11.1-1.el10_2.noarch.rpm;name=aarch64_rust-hyper+http2-devel;unpack=0"
SRC_URI[aarch64_rust-hyper+http2-devel.sha256sum] = "049b83499414157fac3c2963d9c0764f2e802cb23bc3a02739af9cc12e44262b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+server-devel-1.11.1-1.el10_2.noarch.rpm;name=aarch64_rust-hyper+server-devel;unpack=0"
SRC_URI[aarch64_rust-hyper+server-devel.sha256sum] = "4facfccbc3ee2e8e6a558ad46570c42be5d5f5b71291b96aed39459dbc52c472"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+tracing-devel-1.11.1-1.el10_2.noarch.rpm;name=aarch64_rust-hyper+tracing-devel;unpack=0"
SRC_URI[aarch64_rust-hyper+tracing-devel.sha256sum] = "510d53e8bbc82e394b01965084af86b4146c66c75321c7a1fadf878b609b704b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-devel-1.11.1-1.el10_2.noarch.rpm;name=aarch64_rust-hyper-devel;unpack=0"
SRC_URI[aarch64_rust-hyper-devel.sha256sum] = "7155f757eb52ecfb4fcacc3fb3a4c63c31e3a4f24040ba30f81ea7d430adc3f5"

RDEPENDS:rust-hyper+capi-devel = " \
 cargo \
 rust-hyper-devel \
 "
RDEPENDS:rust-hyper+client-devel = " \
 cargo \
 rust-hyper-devel \
 rust-pin-project-lite+default-devel \
 rust-smallvec+const_generics-devel \
 rust-smallvec+const_new-devel \
 rust-smallvec+default-devel \
 rust-want+default-devel \
 "
RDEPENDS:rust-hyper+default-devel = " \
 cargo \
 rust-hyper-devel \
 "
RDEPENDS:rust-hyper+ffi-devel = " \
 cargo \
 rust-futures-util+alloc-devel \
 rust-futures-util-devel \
 rust-http-body-util+default-devel \
 rust-hyper-devel \
 "
RDEPENDS:rust-hyper+full-devel = " \
 cargo \
 rust-hyper+client-devel \
 rust-hyper+http1-devel \
 rust-hyper+http2-devel \
 rust-hyper+server-devel \
 rust-hyper-devel \
 "
RDEPENDS:rust-hyper+http1-devel = " \
 cargo \
 rust-atomic-waker+default-devel \
 rust-futures-channel+default-devel \
 rust-futures-core+default-devel \
 rust-httparse+default-devel \
 rust-hyper-devel \
 rust-itoa+default-devel \
 "
RDEPENDS:rust-hyper+http2-devel = " \
 cargo \
 rust-atomic-waker+default-devel \
 rust-futures-channel+default-devel \
 rust-futures-core+default-devel \
 rust-h2+default-devel \
 rust-hyper-devel \
 "
RDEPENDS:rust-hyper+server-devel = " \
 cargo \
 rust-httpdate+default-devel \
 rust-hyper-devel \
 rust-pin-project-lite+default-devel \
 rust-smallvec+const_generics-devel \
 rust-smallvec+const_new-devel \
 rust-smallvec+default-devel \
 "
RDEPENDS:rust-hyper+tracing-devel = " \
 cargo \
 rust-hyper-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-hyper-devel = " \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-http+default-devel \
 rust-http-body+default-devel \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 "
