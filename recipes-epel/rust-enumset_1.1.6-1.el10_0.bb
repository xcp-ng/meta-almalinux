# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-enumset"
PV = "1.1.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-enumset+alloc-devel \
 rust-enumset+default-devel \
 rust-enumset+proc-macro-crate-devel \
 rust-enumset+serde-devel \
 rust-enumset+serde2-devel \
 rust-enumset+std-devel \
 rust-enumset-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-enumset-1.1.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "025c71828b90444af011b81eb56aca6f38f8f74a450a8c98093a8bad1ac4b326"

URI_x86_64_v2_rust-enumset+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enumset+alloc-devel-1.1.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enumset+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enumset+alloc-devel}"
SRC_URI[x86_64_v2_rust-enumset+alloc-devel.sha256sum] = "8c79c1c3dd39e8aa00a4144e72fc0065b29158364eca8ebbe42ec95cb5db90f7"

URI_x86_64_v2_rust-enumset+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enumset+default-devel-1.1.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enumset+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enumset+default-devel}"
SRC_URI[x86_64_v2_rust-enumset+default-devel.sha256sum] = "10e4862f61c21d15cdaca50abe5ddaf7c9c6ca1112c702dfe19405c07d451991"

URI_x86_64_v2_rust-enumset+proc-macro-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enumset+proc-macro-crate-devel-1.1.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enumset+proc-macro-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enumset+proc-macro-crate-devel}"
SRC_URI[x86_64_v2_rust-enumset+proc-macro-crate-devel.sha256sum] = "378e1183cc7ddc0357f2191e4c20d76199cecc47e8f9f24cfc38a8c15c12e5f7"

URI_x86_64_v2_rust-enumset+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enumset+serde-devel-1.1.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enumset+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enumset+serde-devel}"
SRC_URI[x86_64_v2_rust-enumset+serde-devel.sha256sum] = "b8bc5f21af3448c9298ba3f1c70c2b9305109f6cfadb3955284bd5add6aa2891"

URI_x86_64_v2_rust-enumset+serde2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enumset+serde2-devel-1.1.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enumset+serde2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enumset+serde2-devel}"
SRC_URI[x86_64_v2_rust-enumset+serde2-devel.sha256sum] = "c84fe6fc779e2da9d32bea69fca3840f658037a0bb5185d5998def87e1e22be1"

URI_x86_64_v2_rust-enumset+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enumset+std-devel-1.1.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enumset+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enumset+std-devel}"
SRC_URI[x86_64_v2_rust-enumset+std-devel.sha256sum] = "b788be9f5d38436781661f6ed8631f5e93d5ee902983dd795e22c803efbc09d9"

URI_x86_64_v2_rust-enumset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enumset-devel-1.1.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enumset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enumset-devel}"
SRC_URI[x86_64_v2_rust-enumset-devel.sha256sum] = "483420c5af509a47f33a6f5b61f0ba03b19eed2beabc7d45e20bfa19300bcb52"

URI_aarch64_rust-enumset+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enumset+alloc-devel-1.1.6-1.el10_0.noarch.rpm;name=aarch64_rust-enumset+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enumset+alloc-devel}"
SRC_URI[aarch64_rust-enumset+alloc-devel.sha256sum] = "c2bfcaadd59821b643af0859592d4f1e9bb4785cc5f5948339cf66cfcccdf032"

URI_aarch64_rust-enumset+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enumset+default-devel-1.1.6-1.el10_0.noarch.rpm;name=aarch64_rust-enumset+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enumset+default-devel}"
SRC_URI[aarch64_rust-enumset+default-devel.sha256sum] = "7be206cdc4085bf0da8115ee2d7e7bb3bd07d30e6b21078fe41f2483fe8ff340"

URI_aarch64_rust-enumset+proc-macro-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enumset+proc-macro-crate-devel-1.1.6-1.el10_0.noarch.rpm;name=aarch64_rust-enumset+proc-macro-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enumset+proc-macro-crate-devel}"
SRC_URI[aarch64_rust-enumset+proc-macro-crate-devel.sha256sum] = "c3454065347b04701ae2385c045411d0ec593a1aa7cf0eadea2d5152fe9248f5"

URI_aarch64_rust-enumset+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enumset+serde-devel-1.1.6-1.el10_0.noarch.rpm;name=aarch64_rust-enumset+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enumset+serde-devel}"
SRC_URI[aarch64_rust-enumset+serde-devel.sha256sum] = "456aed6eb0c0b673a793e2163d2f10ebdb5ca67132872be8e60e3b1781cd6332"

URI_aarch64_rust-enumset+serde2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enumset+serde2-devel-1.1.6-1.el10_0.noarch.rpm;name=aarch64_rust-enumset+serde2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enumset+serde2-devel}"
SRC_URI[aarch64_rust-enumset+serde2-devel.sha256sum] = "ebc1bd1147963ab1400ba45d7dfd18459c107bd2bd85c9d45b238f681a0a6f79"

URI_aarch64_rust-enumset+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enumset+std-devel-1.1.6-1.el10_0.noarch.rpm;name=aarch64_rust-enumset+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enumset+std-devel}"
SRC_URI[aarch64_rust-enumset+std-devel.sha256sum] = "a297625ef05e6eae39d28394259fac2edd5806f3b4ec423f13bf764897f0c92d"

URI_aarch64_rust-enumset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enumset-devel-1.1.6-1.el10_0.noarch.rpm;name=aarch64_rust-enumset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enumset-devel}"
SRC_URI[aarch64_rust-enumset-devel.sha256sum] = "4a32a535ee9df9d67137c7171058c64c28db2c750872b5b24d2ca6b6d0e9d41e"

RDEPENDS:rust-enumset+alloc-devel = " \
 cargo \
 rust-enumset-devel \
 "
RDEPENDS:rust-enumset+default-devel = " \
 cargo \
 rust-enumset-devel \
 "
RDEPENDS:rust-enumset+proc-macro-crate-devel = " \
 cargo \
 rust-enumset-devel \
 rust-enumset_derive+proc-macro-crate-devel \
 "
RDEPENDS:rust-enumset+serde-devel = " \
 cargo \
 rust-enumset+serde2-devel \
 rust-enumset-devel \
 rust-enumset_derive+serde-devel \
 "
RDEPENDS:rust-enumset+serde2-devel = " \
 cargo \
 rust-enumset-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-enumset+std-devel = " \
 cargo \
 rust-enumset+alloc-devel \
 rust-enumset-devel \
 rust-enumset_derive+proc-macro-crate-devel \
 rust-enumset_derive+std_deprecation_warning-devel \
 "
RDEPENDS:rust-enumset-devel = " \
 cargo \
 rust \
 rust-enumset_derive+default-devel \
 "
