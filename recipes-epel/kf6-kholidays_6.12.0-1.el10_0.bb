# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kholidays"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kholidays \
 kf6-kholidays-devel \
 kf6-kholidays-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kholidays-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "342c432f0401211638d58091872fd7424d2194877d0f9cce9f397b5d95a875ad"

URI_x86_64_v2_kf6-kholidays = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kholidays-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kholidays;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kholidays}"
SRC_URI[x86_64_v2_kf6-kholidays.sha256sum] = "4dd8669695ab8a3eae7302f9523255673d46df50b9a41ce1c74aa30897ab7892"

URI_x86_64_v2_kf6-kholidays-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kholidays-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kholidays-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kholidays-devel}"
SRC_URI[x86_64_v2_kf6-kholidays-devel.sha256sum] = "580f75002173f2f3fa56fcd9a10564eac1ee07e597803d66829ec8324ad2809d"

URI_x86_64_v2_kf6-kholidays-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kholidays-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kholidays-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kholidays-doc}"
SRC_URI[x86_64_v2_kf6-kholidays-doc.sha256sum] = "9c7e1877a18482bcf3cde564949db9d2eeb62dd659f2694f716552e2bab26cc1"

URI_aarch64_kf6-kholidays = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kholidays-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kholidays;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kholidays}"
SRC_URI[aarch64_kf6-kholidays.sha256sum] = "0e9612dffb14b011b2bbf03303d0e3de132ea8e3ffa5be9b664b170509499d2e"

URI_aarch64_kf6-kholidays-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kholidays-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kholidays-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kholidays-devel}"
SRC_URI[aarch64_kf6-kholidays-devel.sha256sum] = "c03c099880949b3459bc875485bcb04454ba7a2bebaa216435555864b7498668"

URI_aarch64_kf6-kholidays-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kholidays-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kholidays-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kholidays-doc}"
SRC_URI[aarch64_kf6-kholidays-doc.sha256sum] = "2d52827c7e351806f7ac9bac48f0c9360c56a2dc5d9667d057157448cef14f7c"

RDEPENDS:kf6-kholidays = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kholidays-devel = " \
 cmake-filesystem \
 kf6-kholidays \
 "
RDEPENDS:kf6-kholidays-doc = " \
 "
