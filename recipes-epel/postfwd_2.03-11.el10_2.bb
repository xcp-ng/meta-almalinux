# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "postfwd"
PV = "2.03"
PR = "11.el10_2"
PACKAGES = " \
 postfwd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/postfwd-2.03-11.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d5c47f1ce18410ee221bf52f3931a1a8d308b5bde12829748f471d6d47740b15"

URI_x86_64_v2_postfwd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/postfwd-2.03-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_postfwd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postfwd}"
SRC_URI[x86_64_v2_postfwd.sha256sum] = "ae2563bccf20b2b15b32e833d6db907e1588f639f39df1c62b26f869897919c0"

URI_aarch64_postfwd = "${EPEL_MIRROR}/aarch64/Packages/p/postfwd-2.03-11.el10_2.noarch.rpm;name=aarch64_postfwd;unpack=0"
SRC_URI:append = " ${URI_aarch64_postfwd}"
SRC_URI[aarch64_postfwd.sha256sum] = "e41e6bcaec02907e84624d7303dce57acfd62761e4002dc722f27c4409a5516f"

RDEPENDS:postfwd = " \
 bash \
 perl-Data-Dumper \
 perl-Digest-MD5 \
 perl-Exporter \
 perl-Getopt-Long \
 perl-IO \
 perl-Net-CIDR-Lite \
 perl-Net-DNS \
 perl-Net-Server \
 perl-NetAddr-IP \
 perl-POSIX \
 perl-Pod-Usage \
 perl-Storable \
 perl-Sys-Syslog \
 perl-Time-HiRes \
 perl-base \
 perl-interpreter \
 perl-libs \
 perl-podlators \
 perl-vars \
 shadow-utils \
 systemd \
 util-linux-core \
 "
