# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-networkmanager-qt"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-networkmanager-qt \
 kf6-networkmanager-qt-devel \
 kf6-networkmanager-qt-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-networkmanager-qt-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6bb4665d4812b3ad9d16108097bc89b4c5d01c784ed56be1b96c5b54716c774"

URI_x86_64_v2_kf6-networkmanager-qt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-networkmanager-qt-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-networkmanager-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-networkmanager-qt}"
SRC_URI[x86_64_v2_kf6-networkmanager-qt.sha256sum] = "ff447a98f16f881d735d895ad054cd0ada85b583391806846434b42cc5548eaf"

URI_x86_64_v2_kf6-networkmanager-qt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-networkmanager-qt-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-networkmanager-qt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-networkmanager-qt-devel}"
SRC_URI[x86_64_v2_kf6-networkmanager-qt-devel.sha256sum] = "08a433a869c91c99d0d210e24f1a49913382be5b197043ceb4d6ee0b48e2d04e"

URI_x86_64_v2_kf6-networkmanager-qt-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-networkmanager-qt-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-networkmanager-qt-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-networkmanager-qt-doc}"
SRC_URI[x86_64_v2_kf6-networkmanager-qt-doc.sha256sum] = "537376d8c5b2dd6ad31e82d08242540d99b7b5adb4e0b3ca570fc246c858a607"

URI_aarch64_kf6-networkmanager-qt = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-networkmanager-qt-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-networkmanager-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-networkmanager-qt}"
SRC_URI[aarch64_kf6-networkmanager-qt.sha256sum] = "fe0aef07b1c1806690dba6d8fbd7ddeb1368c9446371312a86295040ee985ac4"

URI_aarch64_kf6-networkmanager-qt-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-networkmanager-qt-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-networkmanager-qt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-networkmanager-qt-devel}"
SRC_URI[aarch64_kf6-networkmanager-qt-devel.sha256sum] = "213391efa664b1eddbeb31eb72aa521cf4ddb2a893127e75a1b6c49ce9fbaebf"

URI_aarch64_kf6-networkmanager-qt-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-networkmanager-qt-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-networkmanager-qt-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-networkmanager-qt-doc}"
SRC_URI[aarch64_kf6-networkmanager-qt-doc.sha256sum] = "16e1e720d2f3b15acdcfee78d8f570d720fe1874b3797a6355ac40b60fb569de"

RDEPENDS:kf6-networkmanager-qt = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-networkmanager-qt-devel = " \
 NetworkManager-libnm-devel \
 cmake-filesystem \
 kf6-networkmanager-qt \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-networkmanager-qt-doc = " \
 "
