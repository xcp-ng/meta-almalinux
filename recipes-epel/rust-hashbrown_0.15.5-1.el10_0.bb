# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hashbrown"
PV = "0.15.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-hashbrown+allocator-api2-devel \
 rust-hashbrown+default-devel \
 rust-hashbrown+default-hasher-devel \
 rust-hashbrown+equivalent-devel \
 rust-hashbrown+inline-more-devel \
 rust-hashbrown+raw-entry-devel \
 rust-hashbrown+rayon-devel \
 rust-hashbrown+serde-devel \
 rust-hashbrown-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hashbrown-0.15.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cabec07f5b8411b48bcca0b7f58e0c91be82f9560a09cb5ab93571d3a95bec50"

URI_x86_64_v2_rust-hashbrown+allocator-api2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+allocator-api2-devel-0.15.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+allocator-api2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown+allocator-api2-devel}"
SRC_URI[x86_64_v2_rust-hashbrown+allocator-api2-devel.sha256sum] = "a016758ac5b598d7d5adeac33740850b5afa7249dc3df03e01f7978327546928"

URI_x86_64_v2_rust-hashbrown+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+default-devel-0.15.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown+default-devel}"
SRC_URI[x86_64_v2_rust-hashbrown+default-devel.sha256sum] = "fb207b324e06beb7451740a29caa129d62e9727aa0dd751c67fcd1bdc0ea5dbe"
RPROVIDES:rust-hashbrown+default-devel:x86_64_v2 = "virtual/crate_hashbrown/default__ge_0.14.5_with_crate_hashbrown/default__lt_0.16.0~"

URI_x86_64_v2_rust-hashbrown+default-hasher-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+default-hasher-devel-0.15.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+default-hasher-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown+default-hasher-devel}"
SRC_URI[x86_64_v2_rust-hashbrown+default-hasher-devel.sha256sum] = "fee0b5544c7f5111d4dcd4308ab1a5fe68330208428b15a94643d23a03bce337"

URI_x86_64_v2_rust-hashbrown+equivalent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+equivalent-devel-0.15.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+equivalent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown+equivalent-devel}"
SRC_URI[x86_64_v2_rust-hashbrown+equivalent-devel.sha256sum] = "91e502ddc178d4b9f29b5f4ce6236e488f92a3d701d1d521d23ceafd3060df13"

URI_x86_64_v2_rust-hashbrown+inline-more-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+inline-more-devel-0.15.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+inline-more-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown+inline-more-devel}"
SRC_URI[x86_64_v2_rust-hashbrown+inline-more-devel.sha256sum] = "30b194cabe7248da21f0b2e4ec0bf696b7110cbe77d52f37d6a42003a45e9f63"

URI_x86_64_v2_rust-hashbrown+raw-entry-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+raw-entry-devel-0.15.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+raw-entry-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown+raw-entry-devel}"
SRC_URI[x86_64_v2_rust-hashbrown+raw-entry-devel.sha256sum] = "97f84d2955e9edb478fa35fc1d70118e704ad6c22cd674414219011a79a4d308"

URI_x86_64_v2_rust-hashbrown+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+rayon-devel-0.15.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown+rayon-devel}"
SRC_URI[x86_64_v2_rust-hashbrown+rayon-devel.sha256sum] = "5b3b8e984c17f43e40502e7ec800425ea65cbebe0f885a55c1c3563de1b01956"

URI_x86_64_v2_rust-hashbrown+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+serde-devel-0.15.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown+serde-devel}"
SRC_URI[x86_64_v2_rust-hashbrown+serde-devel.sha256sum] = "08da0b4fb20d702065ff1853a3039f0e863a63c2cda0a2bc18c8c491aad3e1d2"

URI_x86_64_v2_rust-hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown-devel-0.15.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown-devel}"
SRC_URI[x86_64_v2_rust-hashbrown-devel.sha256sum] = "92e8fc6f3664da8af72687393274f994597f2597ef380af8600e9aec893a9df0"

URI_aarch64_rust-hashbrown+allocator-api2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+allocator-api2-devel-0.15.5-1.el10_0.noarch.rpm;name=aarch64_rust-hashbrown+allocator-api2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown+allocator-api2-devel}"
SRC_URI[aarch64_rust-hashbrown+allocator-api2-devel.sha256sum] = "03df710780f2e892cd28d0a9eb4d4b6f12ba96554e7fe1c002c949d6b364bd46"

URI_aarch64_rust-hashbrown+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+default-devel-0.15.5-1.el10_0.noarch.rpm;name=aarch64_rust-hashbrown+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown+default-devel}"
SRC_URI[aarch64_rust-hashbrown+default-devel.sha256sum] = "4d54c3a1b7311205c296a064692b48ec00ce9f45ff8c83d8b87bd9837043c124"
RPROVIDES:rust-hashbrown+default-devel:aarch64 = "virtual/crate_hashbrown/default__ge_0.14.5_with_crate_hashbrown/default__lt_0.16.0~"

URI_aarch64_rust-hashbrown+default-hasher-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+default-hasher-devel-0.15.5-1.el10_0.noarch.rpm;name=aarch64_rust-hashbrown+default-hasher-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown+default-hasher-devel}"
SRC_URI[aarch64_rust-hashbrown+default-hasher-devel.sha256sum] = "f433ff1c937d6127074347e1a8571da5b12c1105debbe74bc8d612e32e894cdd"

URI_aarch64_rust-hashbrown+equivalent-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+equivalent-devel-0.15.5-1.el10_0.noarch.rpm;name=aarch64_rust-hashbrown+equivalent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown+equivalent-devel}"
SRC_URI[aarch64_rust-hashbrown+equivalent-devel.sha256sum] = "9262d48c4681a62a9bd83b92013db1572bec13e54767f31632580af4493de1d5"

URI_aarch64_rust-hashbrown+inline-more-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+inline-more-devel-0.15.5-1.el10_0.noarch.rpm;name=aarch64_rust-hashbrown+inline-more-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown+inline-more-devel}"
SRC_URI[aarch64_rust-hashbrown+inline-more-devel.sha256sum] = "48bcea5f9ded4d4c0d717e24054b812b0762ce8092870657ca6d86ea44d2023b"

URI_aarch64_rust-hashbrown+raw-entry-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+raw-entry-devel-0.15.5-1.el10_0.noarch.rpm;name=aarch64_rust-hashbrown+raw-entry-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown+raw-entry-devel}"
SRC_URI[aarch64_rust-hashbrown+raw-entry-devel.sha256sum] = "fd036ff629206f23192695906cf5791d94f7e9ebf5941236773f125d93fb3779"

URI_aarch64_rust-hashbrown+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+rayon-devel-0.15.5-1.el10_0.noarch.rpm;name=aarch64_rust-hashbrown+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown+rayon-devel}"
SRC_URI[aarch64_rust-hashbrown+rayon-devel.sha256sum] = "baa584f7eba91ef753ee6941ba53f20ca7768636163050c8e5c256be2551b626"

URI_aarch64_rust-hashbrown+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+serde-devel-0.15.5-1.el10_0.noarch.rpm;name=aarch64_rust-hashbrown+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown+serde-devel}"
SRC_URI[aarch64_rust-hashbrown+serde-devel.sha256sum] = "77b77d7db428f49b9bb52f9965d5990245ec34589d59b8edca8f87395e63bc00"

URI_aarch64_rust-hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown-devel-0.15.5-1.el10_0.noarch.rpm;name=aarch64_rust-hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown-devel}"
SRC_URI[aarch64_rust-hashbrown-devel.sha256sum] = "93398d5a7d34b7694b8cffddcda33d4bc084a4cc3ca8c17699bc632c60fb9494"

RDEPENDS:rust-hashbrown+allocator-api2-devel = " \
 cargo \
 rust-allocator-api2+alloc-devel \
 rust-allocator-api2-devel \
 rust-hashbrown-devel \
 "
RDEPENDS:rust-hashbrown+default-devel = " \
 cargo \
 rust-hashbrown+allocator-api2-devel \
 rust-hashbrown+default-hasher-devel \
 rust-hashbrown+equivalent-devel \
 rust-hashbrown+inline-more-devel \
 rust-hashbrown+raw-entry-devel \
 rust-hashbrown-devel \
 "
RDEPENDS:rust-hashbrown+default-hasher-devel = " \
 cargo \
 rust-foldhash-devel \
 rust-hashbrown-devel \
 "
RDEPENDS:rust-hashbrown+equivalent-devel = " \
 cargo \
 rust-equivalent-devel \
 rust-hashbrown-devel \
 "
RDEPENDS:rust-hashbrown+inline-more-devel = " \
 cargo \
 rust-hashbrown-devel \
 "
RDEPENDS:rust-hashbrown+raw-entry-devel = " \
 cargo \
 rust-hashbrown-devel \
 "
RDEPENDS:rust-hashbrown+rayon-devel = " \
 cargo \
 rust-hashbrown-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-hashbrown+serde-devel = " \
 cargo \
 rust-hashbrown-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-hashbrown-devel = " \
 cargo \
 rust \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_hashbrown/default__ge_0.14.5_with_crate_hashbrown/default__lt_0.16.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_hashbrown/default__ge_0.14.5_with_crate_hashbrown/default__lt_0.16.0~"
