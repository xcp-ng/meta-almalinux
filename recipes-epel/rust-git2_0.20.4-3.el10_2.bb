# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-git2"
PV = "0.20.4"
PR = "3.el10_2"
PACKAGES = " \
 rust-git2+default-devel \
 rust-git2+https-devel \
 rust-git2+openssl-probe-devel \
 rust-git2+openssl-sys-devel \
 rust-git2+ssh-devel \
 rust-git2+unstable-devel \
 rust-git2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-git2-0.20.4-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28c7716b53c373e5db1eea5b2f987328e93770fc2a0bf09f86112819206ab6a8"

URI_x86_64_v2_rust-git2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2+default-devel-0.20.4-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2+default-devel}"
SRC_URI[x86_64_v2_rust-git2+default-devel.sha256sum] = "18d616851a2f9ad325c1e4bde1a240c77ae56e5a2ce82d752248241911a1da9a"

URI_x86_64_v2_rust-git2+https-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2+https-devel-0.20.4-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2+https-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2+https-devel}"
SRC_URI[x86_64_v2_rust-git2+https-devel.sha256sum] = "8ff32d960e4d46a31abd66f77db691c4b7389370ba4622bbffe901925f88b886"

URI_x86_64_v2_rust-git2+openssl-probe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2+openssl-probe-devel-0.20.4-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2+openssl-probe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2+openssl-probe-devel}"
SRC_URI[x86_64_v2_rust-git2+openssl-probe-devel.sha256sum] = "504af336fde052e37df96bc99f257d9c1d31b424c0365becdff302c32a106dee"

URI_x86_64_v2_rust-git2+openssl-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2+openssl-sys-devel-0.20.4-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2+openssl-sys-devel}"
SRC_URI[x86_64_v2_rust-git2+openssl-sys-devel.sha256sum] = "58794cc2a2bae8d5527380ecd4c0c9f316e434354529ed11ea89eea594ba7344"

URI_x86_64_v2_rust-git2+ssh-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2+ssh-devel-0.20.4-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2+ssh-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2+ssh-devel}"
SRC_URI[x86_64_v2_rust-git2+ssh-devel.sha256sum] = "6c85e26b96924ee2d91d9c0f9539e8e5398678a7c096d325dd87357bba8b0bb7"

URI_x86_64_v2_rust-git2+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2+unstable-devel-0.20.4-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2+unstable-devel}"
SRC_URI[x86_64_v2_rust-git2+unstable-devel.sha256sum] = "a4819e39e58e306725f7112627f05f41b59dd20173a8cdde0fbc7635be2da332"

URI_x86_64_v2_rust-git2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2-devel-0.20.4-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2-devel}"
SRC_URI[x86_64_v2_rust-git2-devel.sha256sum] = "69b0e7c1076e23e845e1904a34608f39d6f17910eecd68b8d6c2e11e23f3f63d"

URI_aarch64_rust-git2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2+default-devel-0.20.4-3.el10_2.noarch.rpm;name=aarch64_rust-git2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2+default-devel}"
SRC_URI[aarch64_rust-git2+default-devel.sha256sum] = "95f81ee11d6c883dd0ecf54502aea869750738f64e1e807ca87528cf810b7184"

URI_aarch64_rust-git2+https-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2+https-devel-0.20.4-3.el10_2.noarch.rpm;name=aarch64_rust-git2+https-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2+https-devel}"
SRC_URI[aarch64_rust-git2+https-devel.sha256sum] = "b93a1163565882cf60152c2da437f2a635b50e293ee36813f62f16f9aa80d2ed"

URI_aarch64_rust-git2+openssl-probe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2+openssl-probe-devel-0.20.4-3.el10_2.noarch.rpm;name=aarch64_rust-git2+openssl-probe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2+openssl-probe-devel}"
SRC_URI[aarch64_rust-git2+openssl-probe-devel.sha256sum] = "4f0cafd26e1c0379daafa5128dcd18e261a1cc80a7d27dc89300ceffd456f26e"

URI_aarch64_rust-git2+openssl-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2+openssl-sys-devel-0.20.4-3.el10_2.noarch.rpm;name=aarch64_rust-git2+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2+openssl-sys-devel}"
SRC_URI[aarch64_rust-git2+openssl-sys-devel.sha256sum] = "c336b27c6591b1bff8c2c4459b0534ef834c7e139b55c9c7fcb03211b3693b9b"

URI_aarch64_rust-git2+ssh-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2+ssh-devel-0.20.4-3.el10_2.noarch.rpm;name=aarch64_rust-git2+ssh-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2+ssh-devel}"
SRC_URI[aarch64_rust-git2+ssh-devel.sha256sum] = "a9fc72619de81851955d0ee249ef2fb8d4bb6ff1254a8e2732e8a45fe780d228"

URI_aarch64_rust-git2+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2+unstable-devel-0.20.4-3.el10_2.noarch.rpm;name=aarch64_rust-git2+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2+unstable-devel}"
SRC_URI[aarch64_rust-git2+unstable-devel.sha256sum] = "fc481589358b105b0c99b34381fa95689bcf937ea87e4f84290969b02c564527"

URI_aarch64_rust-git2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2-devel-0.20.4-3.el10_2.noarch.rpm;name=aarch64_rust-git2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2-devel}"
SRC_URI[aarch64_rust-git2-devel.sha256sum] = "491fe18eefbae2f9af4d7a5f1c7abc102c0bcd06cfd7455ab1d3cc45ef82c37c"

RDEPENDS:rust-git2+default-devel = " \
 cargo \
 rust-git2+https-devel \
 rust-git2+ssh-devel \
 rust-git2-devel \
 "
RDEPENDS:rust-git2+https-devel = " \
 cargo \
 rust-git2+openssl-probe-devel \
 rust-git2+openssl-sys-devel \
 rust-git2-devel \
 rust-libgit2-sys+https-devel \
 "
RDEPENDS:rust-git2+openssl-probe-devel = " \
 cargo \
 rust-git2-devel \
 rust-openssl-probe+default-devel \
 "
RDEPENDS:rust-git2+openssl-sys-devel = " \
 cargo \
 rust-git2-devel \
 rust-openssl-sys+default-devel \
 "
RDEPENDS:rust-git2+ssh-devel = " \
 cargo \
 rust-git2-devel \
 rust-libgit2-sys+ssh-devel \
 "
RDEPENDS:rust-git2+unstable-devel = " \
 cargo \
 rust-git2-devel \
 "
RDEPENDS:rust-git2-devel = " \
 bash \
 cargo \
 rust-bitflags+default-devel \
 rust-libc+default-devel \
 rust-libgit2-sys+default-devel \
 rust-log+default-devel \
 rust-url+default-devel \
 "
