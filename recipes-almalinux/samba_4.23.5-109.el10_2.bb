# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "samba"
PV = "4.23.5"
PR = "109.el10_2"
PACKAGES:x86_64_v2 = " \
 ldb-tools \
 libldb \
 libldb-devel \
 libnetapi \
 libnetapi-devel \
 libsmbclient \
 libsmbclient-devel \
 libwbclient \
 libwbclient-devel \
 python3-ldb \
 python3-samba \
 python3-samba-dc \
 python3-samba-test \
 samba \
 samba-client \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 samba-common-tools \
 samba-dc-libs \
 samba-dcerpc \
 samba-devel \
 samba-gpupdate \
 samba-krb5-printing \
 samba-ldb-ldap-modules \
 samba-libs \
 samba-pidl \
 samba-test \
 samba-test-libs \
 samba-tools \
 samba-usershares \
 samba-vfs-iouring \
 samba-winbind \
 samba-winbind-clients \
 samba-winbind-krb5-locator \
 samba-winbind-modules \
 samba-winexe \
"
PACKAGES:aarch64 = " \
 ldb-tools \
 libldb \
 libldb-devel \
 libnetapi \
 libnetapi-devel \
 libsmbclient \
 libsmbclient-devel \
 libwbclient \
 libwbclient-devel \
 python3-ldb \
 python3-samba \
 python3-samba-dc \
 python3-samba-test \
 samba \
 samba-client \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 samba-common-tools \
 samba-dc-libs \
 samba-dcerpc \
 samba-devel \
 samba-gpupdate \
 samba-krb5-printing \
 samba-ldb-ldap-modules \
 samba-libs \
 samba-pidl \
 samba-test \
 samba-test-libs \
 samba-tools \
 samba-usershares \
 samba-vfs-iouring \
 samba-winbind \
 samba-winbind-clients \
 samba-winbind-krb5-locator \
 samba-winbind-modules \
"

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/samba-4.23.5-109.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "424668955f3089daf869282cd0b3418b8df5b811c8608aa09100ee4281efde1a"

URI_x86_64_v2_ldb-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ldb-tools-4.23.5-109.el10_2.x86_64_v2.rpm;name=x86_64_v2_ldb-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ldb-tools}"
SRC_URI[x86_64_v2_ldb-tools.sha256sum] = "09fa8e0220bd2289376c756d7b332626a66d66a3295a2e0fab02e5dfbf466da5"

URI_x86_64_v2_libldb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libldb-4.23.5-109.el10_2.x86_64_v2.rpm;name=x86_64_v2_libldb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libldb}"
SRC_URI[x86_64_v2_libldb.sha256sum] = "427776bc6973c79d04f9786c42130518310b6e179475c3251148c0b004191179"

URI_x86_64_v2_libldb-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libldb-devel-4.23.5-109.el10_2.x86_64_v2.rpm;name=x86_64_v2_libldb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libldb-devel}"
SRC_URI[x86_64_v2_libldb-devel.sha256sum] = "91b63feff18c30b8dba6e1bc57c7d5d3970fe94ed6adc70c84c2fb4eb86555ff"

URI_x86_64_v2_libnetapi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libnetapi-4.23.5-109.el10_2.x86_64_v2.rpm;name=x86_64_v2_libnetapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnetapi}"
SRC_URI[x86_64_v2_libnetapi.sha256sum] = "ec4dd2e7b09fd9c4aa0bcd8ba20685a74f686cf86b9b5bf4d4bd52876856f7cc"

URI_x86_64_v2_libnetapi-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libnetapi-devel-4.23.5-109.el10_2.x86_64_v2.rpm;name=x86_64_v2_libnetapi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnetapi-devel}"
SRC_URI[x86_64_v2_libnetapi-devel.sha256sum] = "6ed68c481b2f93652bbdc69568fe4889682e2ece84d1f3e99689736ce14d9071"

URI_x86_64_v2_libsmbclient = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsmbclient-4.23.5-109.el10_2.x86_64_v2.rpm;name=x86_64_v2_libsmbclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsmbclient}"
SRC_URI[x86_64_v2_libsmbclient.sha256sum] = "a2521f8bdabb29869c71766ede67fdabf344313320dd5da61e966d1a86252130"

URI_x86_64_v2_libsmbclient-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsmbclient-devel-4.23.5-109.el10_2.x86_64_v2.rpm;name=x86_64_v2_libsmbclient-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsmbclient-devel}"
SRC_URI[x86_64_v2_libsmbclient-devel.sha256sum] = "fe8d9c75dea4bb7df79a0309b04ae551e5534cb0e14aeddad1ca7d0c56f04013"

URI_x86_64_v2_libwbclient = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libwbclient-4.23.5-109.el10_2.x86_64_v2.rpm;name=x86_64_v2_libwbclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwbclient}"
SRC_URI[x86_64_v2_libwbclient.sha256sum] = "a1ac069d8b677e13fba8a55ee74592384e16b29b9bde51f4a039c2c8873d65f4"

URI_x86_64_v2_libwbclient-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libwbclient-devel-4.23.5-109.el10_2.x86_64_v2.rpm;name=x86_64_v2_libwbclient-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwbclient-devel}"
SRC_URI[x86_64_v2_libwbclient-devel.sha256sum] = "dff146bc2cb71a1ba52f70cb06c70b42f74ea4b439822b7152755c44f6515146"

URI_x86_64_v2_python3-ldb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-ldb-4.23.5-109.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3-ldb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ldb}"
SRC_URI[x86_64_v2_python3-ldb.sha256sum] = "88170b4f98e9bb57f8165ed2d282c1b7d91682e88f38aa24069efcde21aae5ea"

URI_x86_64_v2_python3-samba = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-samba-4.23.5-109.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3-samba;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-samba}"
SRC_URI[x86_64_v2_python3-samba.sha256sum] = "3590b79ad8e4c0fe32c0982bb9a69732918a77804070b6880b1db2302a222d92"

URI_x86_64_v2_python3-samba-dc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-samba-dc-4.23.5-109.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3-samba-dc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-samba-dc}"
SRC_URI[x86_64_v2_python3-samba-dc.sha256sum] = "3f761eba6899a063ab162bdea7d7e4a670433bef336412e86cd20d387e4dc587"

URI_x86_64_v2_python3-samba-test = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-samba-test-4.23.5-109.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3-samba-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-samba-test}"
SRC_URI[x86_64_v2_python3-samba-test.sha256sum] = "6f2fbf50a611727ebd961f84305177559dc3c27ebc66b57dc749afd65a0b997a"

URI_x86_64_v2_samba = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-4.23.5-109.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba}"
SRC_URI[x86_64_v2_samba.sha256sum] = "4fcbfaff662fa3762b95f388bd410d44f06e14ea7b8ea2ebc7c14215f1dd6799"

URI_x86_64_v2_samba-client = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-client-4.23.5-109.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-client}"
SRC_URI[x86_64_v2_samba-client.sha256sum] = "9d19fd4dd415ff1f6cf1c54b266780bf7397808f760243e3c35c760cc5193ba3"

URI_x86_64_v2_samba-client-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-client-libs-4.23.5-109.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-client-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-client-libs}"
SRC_URI[x86_64_v2_samba-client-libs.sha256sum] = "5717df831fc116d4f6c5d3f276e6b936d04de5f673d5ed8b83dcee33e04fc5c3"

URI_x86_64_v2_samba-common = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-common-4.23.5-109.el10_2.noarch.rpm;name=x86_64_v2_samba-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-common}"
SRC_URI[x86_64_v2_samba-common.sha256sum] = "a932b9dfd687d67c598700086effd079ee4257097061d0e29b1a209e96fce056"

URI_x86_64_v2_samba-common-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-common-libs-4.23.5-109.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-common-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-common-libs}"
SRC_URI[x86_64_v2_samba-common-libs.sha256sum] = "b3433be14f7bed0f37930d4c44de4c4e0546930188d9a71a763509cbcea52a82"

URI_x86_64_v2_samba-common-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-common-tools-4.23.5-109.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-common-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-common-tools}"
SRC_URI[x86_64_v2_samba-common-tools.sha256sum] = "1478545d7f16d1e3b25d2e685aabb31297e122997676282175b3c238a6452727"

URI_x86_64_v2_samba-dc-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-dc-libs-4.23.5-109.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-dc-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-dc-libs}"
SRC_URI[x86_64_v2_samba-dc-libs.sha256sum] = "4d54883cea2ecf23482880aacaa1752c38fe6ace1b77cb7dcd46c9ab14dd4f5b"

URI_x86_64_v2_samba-dcerpc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-dcerpc-4.23.5-109.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-dcerpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-dcerpc}"
SRC_URI[x86_64_v2_samba-dcerpc.sha256sum] = "b180a641f90c4976bf3a319c621c1054465d6d10f27cd9d8cf617bf304ab65fd"

URI_x86_64_v2_samba-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/samba-devel-4.23.5-109.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-devel}"
SRC_URI[x86_64_v2_samba-devel.sha256sum] = "1b62bb6fb860bacd25441a2fd41f52c96b7909a09b3f964ef00b617c462c4024"

URI_x86_64_v2_samba-gpupdate = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-gpupdate-4.23.5-109.el10_2.noarch.rpm;name=x86_64_v2_samba-gpupdate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-gpupdate}"
SRC_URI[x86_64_v2_samba-gpupdate.sha256sum] = "02ab33c4186fb468d4de6cffac56cd285836279fe4e2d03245fef1dcf26dd611"

URI_x86_64_v2_samba-krb5-printing = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-krb5-printing-4.23.5-109.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-krb5-printing;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-krb5-printing}"
SRC_URI[x86_64_v2_samba-krb5-printing.sha256sum] = "2e58971c2e83cbe479e19c8940b29b2e0d0e4b11c9563dd4a4d73e2e90cfb7dd"

URI_x86_64_v2_samba-ldb-ldap-modules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-ldb-ldap-modules-4.23.5-109.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-ldb-ldap-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-ldb-ldap-modules}"
SRC_URI[x86_64_v2_samba-ldb-ldap-modules.sha256sum] = "b5d162c9735a11ef2e1bf16141dee21e681f0dd89aa879600bd2d057fcf699e2"

URI_x86_64_v2_samba-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-libs-4.23.5-109.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-libs}"
SRC_URI[x86_64_v2_samba-libs.sha256sum] = "820b83aef00665c9c66d490213fc3de60e17f393ceba490b5f87ea775aa61cbf"

URI_x86_64_v2_samba-pidl = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/samba-pidl-4.23.5-109.el10_2.noarch.rpm;name=x86_64_v2_samba-pidl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-pidl}"
SRC_URI[x86_64_v2_samba-pidl.sha256sum] = "4180231d6fcb81a083d7db024760d87997779989ac8643e34d7af50f5873ba01"

URI_x86_64_v2_samba-test = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/samba-test-4.23.5-109.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-test}"
SRC_URI[x86_64_v2_samba-test.sha256sum] = "d03f0e3a8ebe604fcc8466e71eecb16168fbf8c4079e01ae87ce782b51dc80fa"

URI_x86_64_v2_samba-test-libs = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/samba-test-libs-4.23.5-109.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-test-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-test-libs}"
SRC_URI[x86_64_v2_samba-test-libs.sha256sum] = "3b97261388485852bbb291ce976204d6ca4a5bcabf2e7a68d99fa91a7db90242"

URI_x86_64_v2_samba-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-tools-4.23.5-109.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-tools}"
SRC_URI[x86_64_v2_samba-tools.sha256sum] = "70fc3e437b442e6870eb4e6fa1943d5f29fd94dee05aa5f72d15d06924e932d4"

URI_x86_64_v2_samba-usershares = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-usershares-4.23.5-109.el10_2.noarch.rpm;name=x86_64_v2_samba-usershares;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-usershares}"
SRC_URI[x86_64_v2_samba-usershares.sha256sum] = "7071b9e2f3d456f670a123eb7226d5f33ac66ce2cdb480cee56be8f912647c18"

URI_x86_64_v2_samba-vfs-iouring = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-vfs-iouring-4.23.5-109.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-vfs-iouring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-vfs-iouring}"
SRC_URI[x86_64_v2_samba-vfs-iouring.sha256sum] = "a10fbec54d17c3e55eac2ef7662bc5fd6684bb49f21418384c9ba7859b59ab5b"

URI_x86_64_v2_samba-winbind = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-winbind-4.23.5-109.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-winbind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-winbind}"
SRC_URI[x86_64_v2_samba-winbind.sha256sum] = "fc9c8e37d28eefd426c71dd534d4f79631c489660a0851a20574b1623a0e42c9"

URI_x86_64_v2_samba-winbind-clients = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-winbind-clients-4.23.5-109.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-winbind-clients;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-winbind-clients}"
SRC_URI[x86_64_v2_samba-winbind-clients.sha256sum] = "ce7d3939a370b0008c391f13acf76c56778e43d8af9a730a256afafc51d46f6c"

URI_x86_64_v2_samba-winbind-krb5-locator = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-winbind-krb5-locator-4.23.5-109.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-winbind-krb5-locator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-winbind-krb5-locator}"
SRC_URI[x86_64_v2_samba-winbind-krb5-locator.sha256sum] = "5402b5a523b52de9cec1adaf22d37ee23bf60ecf89419b6f8819ab1f7ce7040a"

URI_x86_64_v2_samba-winbind-modules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-winbind-modules-4.23.5-109.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-winbind-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-winbind-modules}"
SRC_URI[x86_64_v2_samba-winbind-modules.sha256sum] = "9750ef53e031713e7734f281ee3450ed31eedfbbde394e108a5b76713b2dd40e"

URI_x86_64_v2_samba-winexe = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-winexe-4.23.5-109.el10_2.x86_64_v2.rpm;name=x86_64_v2_samba-winexe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-winexe}"
SRC_URI[x86_64_v2_samba-winexe.sha256sum] = "152c243a8e438b6ae46e6b4c1c6dafaaa5473f2ae0f03d8681974ddfba424edd"

URI_aarch64_ldb-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ldb-tools-4.23.5-109.el10_2.aarch64.rpm;name=aarch64_ldb-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_ldb-tools}"
SRC_URI[aarch64_ldb-tools.sha256sum] = "a74e1bd5b0c7536cb22e3fc349e5060836bb689012bd87ac91b9de3073dc9c1d"

URI_aarch64_libldb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libldb-4.23.5-109.el10_2.aarch64.rpm;name=aarch64_libldb;unpack=0"
SRC_URI:append = " ${URI_aarch64_libldb}"
SRC_URI[aarch64_libldb.sha256sum] = "e067c85968d94e566f6d85cde54b1b6457fce7e616f81dc808949758a66d8b94"

URI_aarch64_libldb-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libldb-devel-4.23.5-109.el10_2.aarch64.rpm;name=aarch64_libldb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libldb-devel}"
SRC_URI[aarch64_libldb-devel.sha256sum] = "74328e784a8937407e6e0d8a57401f3361999134b974413625ee2daf0f0eb1a0"

URI_aarch64_libnetapi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libnetapi-4.23.5-109.el10_2.aarch64.rpm;name=aarch64_libnetapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnetapi}"
SRC_URI[aarch64_libnetapi.sha256sum] = "f8317ae72014ad9d9c313cafc3010c0a7f0655fd5b684126f47fa1cf3903e49e"

URI_aarch64_libnetapi-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libnetapi-devel-4.23.5-109.el10_2.aarch64.rpm;name=aarch64_libnetapi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnetapi-devel}"
SRC_URI[aarch64_libnetapi-devel.sha256sum] = "f3afaceec81689d28257e173ac571e6b676c04c1956a1e85ab29615163c4519b"

URI_aarch64_libsmbclient = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsmbclient-4.23.5-109.el10_2.aarch64.rpm;name=aarch64_libsmbclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsmbclient}"
SRC_URI[aarch64_libsmbclient.sha256sum] = "6d0838b2d0ee8aae57148ccc5979c6741b1d7839832128affd3479be56edeb77"

URI_aarch64_libsmbclient-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsmbclient-devel-4.23.5-109.el10_2.aarch64.rpm;name=aarch64_libsmbclient-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsmbclient-devel}"
SRC_URI[aarch64_libsmbclient-devel.sha256sum] = "7b8c9b783f5a821140f8b965cb442b9940af288abc9c5eb96c24f36b23997b5d"

URI_aarch64_libwbclient = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libwbclient-4.23.5-109.el10_2.aarch64.rpm;name=aarch64_libwbclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwbclient}"
SRC_URI[aarch64_libwbclient.sha256sum] = "9c67312e14d4c0326c8d1042510840c0c00dca035708e78e07c3dea480f9a0b6"

URI_aarch64_libwbclient-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libwbclient-devel-4.23.5-109.el10_2.aarch64.rpm;name=aarch64_libwbclient-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwbclient-devel}"
SRC_URI[aarch64_libwbclient-devel.sha256sum] = "145b24f380b509b37ff750f235e0cb9107c0e398771318233abd56d2a38ba2b1"

URI_aarch64_python3-ldb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-ldb-4.23.5-109.el10_2.aarch64.rpm;name=aarch64_python3-ldb;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ldb}"
SRC_URI[aarch64_python3-ldb.sha256sum] = "32b163000d0ba3b8553d0311a5f4592d42816ec41792766090995b4de17ad8c8"

URI_aarch64_python3-samba = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-samba-4.23.5-109.el10_2.aarch64.rpm;name=aarch64_python3-samba;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-samba}"
SRC_URI[aarch64_python3-samba.sha256sum] = "9997b1d7f08518a7441e9118451e3ec6c07ea75825e2f9558603f6b1cf3262bb"

URI_aarch64_python3-samba-dc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-samba-dc-4.23.5-109.el10_2.aarch64.rpm;name=aarch64_python3-samba-dc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-samba-dc}"
SRC_URI[aarch64_python3-samba-dc.sha256sum] = "ceeef7207f776ad81f62ad84d0702a91659e9e24a2d56f760cec124f4a0e2966"

URI_aarch64_python3-samba-test = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-samba-test-4.23.5-109.el10_2.aarch64.rpm;name=aarch64_python3-samba-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-samba-test}"
SRC_URI[aarch64_python3-samba-test.sha256sum] = "d66fcc80283c3652ea1808ca2c6e9d1357319eabd269fea9b06aac27dcc2939e"

URI_aarch64_samba = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-4.23.5-109.el10_2.aarch64.rpm;name=aarch64_samba;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba}"
SRC_URI[aarch64_samba.sha256sum] = "d0ae0fd076984f087a24c6d2fc969a5c2f71c71f00129fba70105367c9d474b1"

URI_aarch64_samba-client = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-client-4.23.5-109.el10_2.aarch64.rpm;name=aarch64_samba-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-client}"
SRC_URI[aarch64_samba-client.sha256sum] = "27caf7fa9c3ba93da63abac5e9976f2246bc092b5ee53c2cab9a70d01d154642"

URI_aarch64_samba-client-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-client-libs-4.23.5-109.el10_2.aarch64.rpm;name=aarch64_samba-client-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-client-libs}"
SRC_URI[aarch64_samba-client-libs.sha256sum] = "8cd012a15c8996148db8bd0951722cd223870428647b79b0e560d45ffc5ff6e8"

URI_aarch64_samba-common = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-common-4.23.5-109.el10_2.noarch.rpm;name=aarch64_samba-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-common}"
SRC_URI[aarch64_samba-common.sha256sum] = "a932b9dfd687d67c598700086effd079ee4257097061d0e29b1a209e96fce056"

URI_aarch64_samba-common-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-common-libs-4.23.5-109.el10_2.aarch64.rpm;name=aarch64_samba-common-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-common-libs}"
SRC_URI[aarch64_samba-common-libs.sha256sum] = "f9412776fc3504d55c0594f41db5dcdfb06dfd05af47f0ae810c72ca29aab798"

URI_aarch64_samba-common-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-common-tools-4.23.5-109.el10_2.aarch64.rpm;name=aarch64_samba-common-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-common-tools}"
SRC_URI[aarch64_samba-common-tools.sha256sum] = "e8e1dddd9abb23c90ad67b789be1e86a33a7cf8b6c8c050a80e0a4e3c38d0568"

URI_aarch64_samba-dc-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-dc-libs-4.23.5-109.el10_2.aarch64.rpm;name=aarch64_samba-dc-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-dc-libs}"
SRC_URI[aarch64_samba-dc-libs.sha256sum] = "01e05be1bb0b8f7a2877655e619102706a8bed2907322ac86e183f720df6e9ad"

URI_aarch64_samba-dcerpc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-dcerpc-4.23.5-109.el10_2.aarch64.rpm;name=aarch64_samba-dcerpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-dcerpc}"
SRC_URI[aarch64_samba-dcerpc.sha256sum] = "e1e6c749ba8f845393f42bccab63fc7caaabb558d6036d72e8922e71587d9755"

URI_aarch64_samba-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/samba-devel-4.23.5-109.el10_2.aarch64.rpm;name=aarch64_samba-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-devel}"
SRC_URI[aarch64_samba-devel.sha256sum] = "900dc6f9ef726efde943c3d1bf1ee1b0739204c642e594f39ee08abe1f913c7b"

URI_aarch64_samba-gpupdate = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-gpupdate-4.23.5-109.el10_2.noarch.rpm;name=aarch64_samba-gpupdate;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-gpupdate}"
SRC_URI[aarch64_samba-gpupdate.sha256sum] = "02ab33c4186fb468d4de6cffac56cd285836279fe4e2d03245fef1dcf26dd611"

URI_aarch64_samba-krb5-printing = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-krb5-printing-4.23.5-109.el10_2.aarch64.rpm;name=aarch64_samba-krb5-printing;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-krb5-printing}"
SRC_URI[aarch64_samba-krb5-printing.sha256sum] = "f9809e33207cec4e0a4875717b9efb2842b5425724a14eb04bb00aeb12150a56"

URI_aarch64_samba-ldb-ldap-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-ldb-ldap-modules-4.23.5-109.el10_2.aarch64.rpm;name=aarch64_samba-ldb-ldap-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-ldb-ldap-modules}"
SRC_URI[aarch64_samba-ldb-ldap-modules.sha256sum] = "3c552c7d5e0b35c1ff23d79253f9b6ead5f30a72fc6709db88bd832a87e2483c"

URI_aarch64_samba-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-libs-4.23.5-109.el10_2.aarch64.rpm;name=aarch64_samba-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-libs}"
SRC_URI[aarch64_samba-libs.sha256sum] = "24b4b1332eefe292e33699886728b50b79b2441e3443598cefb74faae7028b3d"

URI_aarch64_samba-pidl = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/samba-pidl-4.23.5-109.el10_2.noarch.rpm;name=aarch64_samba-pidl;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-pidl}"
SRC_URI[aarch64_samba-pidl.sha256sum] = "4180231d6fcb81a083d7db024760d87997779989ac8643e34d7af50f5873ba01"

URI_aarch64_samba-test = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/samba-test-4.23.5-109.el10_2.aarch64.rpm;name=aarch64_samba-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-test}"
SRC_URI[aarch64_samba-test.sha256sum] = "82737f68a5d27d6f329bee01a17c7dc0304a6a99ab2908ce1d1eb3379448afbc"

URI_aarch64_samba-test-libs = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/samba-test-libs-4.23.5-109.el10_2.aarch64.rpm;name=aarch64_samba-test-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-test-libs}"
SRC_URI[aarch64_samba-test-libs.sha256sum] = "ace0280089e5c10cf1a213194e301868e0e6220a30cbdf86da96a364e2677fd9"

URI_aarch64_samba-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-tools-4.23.5-109.el10_2.aarch64.rpm;name=aarch64_samba-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-tools}"
SRC_URI[aarch64_samba-tools.sha256sum] = "14e51ab2812e57f9174df548d968657d91ba07a94d667f82772eaa00b59a6bfb"

URI_aarch64_samba-usershares = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-usershares-4.23.5-109.el10_2.noarch.rpm;name=aarch64_samba-usershares;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-usershares}"
SRC_URI[aarch64_samba-usershares.sha256sum] = "7071b9e2f3d456f670a123eb7226d5f33ac66ce2cdb480cee56be8f912647c18"

URI_aarch64_samba-vfs-iouring = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-vfs-iouring-4.23.5-109.el10_2.aarch64.rpm;name=aarch64_samba-vfs-iouring;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-vfs-iouring}"
SRC_URI[aarch64_samba-vfs-iouring.sha256sum] = "8baec8ed3bdde3611157e06ab4623679c2e0d7bf34add8011ba70feab4cd4880"

URI_aarch64_samba-winbind = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-winbind-4.23.5-109.el10_2.aarch64.rpm;name=aarch64_samba-winbind;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-winbind}"
SRC_URI[aarch64_samba-winbind.sha256sum] = "0ab434a800343ea847b31597387f382f324a1f95bd02b7efdc2bf3d9fc194367"

URI_aarch64_samba-winbind-clients = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-winbind-clients-4.23.5-109.el10_2.aarch64.rpm;name=aarch64_samba-winbind-clients;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-winbind-clients}"
SRC_URI[aarch64_samba-winbind-clients.sha256sum] = "a5e613af0e69819967ecab9250662e65fc09f8bc71139384e3871858dd9d3183"

URI_aarch64_samba-winbind-krb5-locator = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-winbind-krb5-locator-4.23.5-109.el10_2.aarch64.rpm;name=aarch64_samba-winbind-krb5-locator;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-winbind-krb5-locator}"
SRC_URI[aarch64_samba-winbind-krb5-locator.sha256sum] = "6958a38a27a62042a986adaa9fc00423d0940d3f37669537f33cd19d4b28d5f4"

URI_aarch64_samba-winbind-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-winbind-modules-4.23.5-109.el10_2.aarch64.rpm;name=aarch64_samba-winbind-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-winbind-modules}"
SRC_URI[aarch64_samba-winbind-modules.sha256sum] = "f174a74bcf15983a7eb0defada4fc66caa90e40b9224ff18910fe40a41d8f921"

RDEPENDS:ldb-tools = " \
 glibc \
 libldb \
 libtalloc \
 popt \
 "
RDEPENDS:libldb = " \
 glibc \
 libtalloc \
 libtdb \
 libtevent \
 lmdb-libs \
 "
RDEPENDS:libldb-devel = " \
 libldb \
 libtalloc-devel \
 libtdb-devel \
 libtevent-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libnetapi = " \
 glibc \
 gnutls \
 libgcc \
 libldb \
 libtalloc \
 libwbclient \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 "
RDEPENDS:libnetapi-devel = " \
 libnetapi \
 pkgconf-pkg-config \
 "
RDEPENDS:libsmbclient = " \
 glibc \
 libldb \
 libtalloc \
 libtevent \
 libwbclient \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 "
RDEPENDS:libsmbclient-devel = " \
 libsmbclient \
 pkgconf-pkg-config \
 "
RDEPENDS:libwbclient = " \
 bash \
 glibc \
 samba-client-libs \
 "
RDEPENDS:libwbclient-devel = " \
 libwbclient \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-ldb = " \
 glibc \
 libldb \
 libtalloc \
 python3 \
 python3-libs \
 python3-tdb \
 samba-client-libs \
 samba-common-libs \
 "
RDEPENDS:python3-samba = " \
 glibc \
 gnutls \
 krb5-libs \
 libgcc \
 libldb \
 libsmbclient \
 libtalloc \
 libtevent \
 libwbclient \
 python3 \
 python3-cryptography \
 python3-dns \
 python3-ldb \
 python3-libs \
 python3-requests \
 python3-talloc \
 python3-tdb \
 python3-tevent \
 samba-client-libs \
 samba-common-libs \
 samba-dc-libs \
 samba-libs \
 "
RDEPENDS:python3-samba-dc = " \
 glibc \
 libldb \
 libtalloc \
 libwbclient \
 python3 \
 python3-libs \
 python3-markdown \
 python3-samba \
 python3-talloc \
 samba-client-libs \
 samba-dc-libs \
 "
RDEPENDS:python3-samba-test = " \
 python3 \
 python3-samba \
 samba-client-libs \
 samba-libs \
 "
RDEPENDS:samba = " \
 bash \
 cups-libs \
 dbus-libs \
 glibc \
 gnutls \
 libldb \
 libnetapi \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 openldap \
 pam \
 popt \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 samba-common-tools \
 samba-dcerpc \
 samba-libs \
 "
RDEPENDS:samba-client = " \
 alternatives \
 bash \
 glibc \
 gnutls \
 krb5-libs \
 libarchive \
 libcom_err \
 libldb \
 libsmbclient \
 libtalloc \
 libtevent \
 libwbclient \
 ncurses-libs \
 popt \
 readline \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 "
RDEPENDS:samba-client-libs = " \
 avahi-libs \
 glibc \
 glibc-gconv-extra \
 gnutls \
 jansson \
 krb5-libs \
 libacl \
 libcap \
 libcom_err \
 libgcc \
 libicu \
 libldb \
 libtalloc \
 libtasn1 \
 libtdb \
 libtevent \
 libtirpc \
 libwbclient \
 libxcrypt \
 openldap \
 pam-libs \
 popt \
 samba-common \
 samba-common-libs \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:samba-common = " \
 bash \
 systemd \
 "
RDEPENDS:samba-common-libs = " \
 glibc \
 libldb \
 libtalloc \
 libtdb \
 libwbclient \
 openldap \
 popt \
 samba-client-libs \
 samba-common \
 "
RDEPENDS:samba-common-tools = " \
 glibc \
 gnutls \
 jansson \
 krb5-libs \
 libcom_err \
 libldb \
 libnetapi \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 openldap \
 popt \
 python3 \
 readline \
 samba-client-libs \
 samba-common-libs \
 samba-ldb-ldap-modules \
 samba-libs \
 "
RDEPENDS:samba-dc-libs = " \
 glibc \
 gnutls \
 libldb \
 libtalloc \
 libtevent \
 libwbclient \
 samba-client-libs \
 samba-common-libs \
 samba-libs \
 "
RDEPENDS:samba-dcerpc = " \
 cups-libs \
 glibc \
 gnutls \
 jansson \
 libldb \
 libnetapi \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 openldap \
 popt \
 samba-client-libs \
 samba-common-libs \
 samba-libs \
 "
RDEPENDS:samba-devel = " \
 libldb-devel \
 libnetapi \
 libtalloc-devel \
 libtevent-devel \
 pkgconf-pkg-config \
 samba-client-libs \
 samba-dc-libs \
 samba-devel \
 samba-libs \
 "
RDEPENDS:samba-gpupdate = " \
 cepces-certmonger \
 certmonger \
 python3 \
 python3-samba \
 python3-samba-dc \
 samba-ldb-ldap-modules \
 "
RDEPENDS:samba-krb5-printing = " \
 alternatives \
 bash \
 glibc \
 krb5-libs \
 samba-client \
 samba-client-libs \
 "
RDEPENDS:samba-ldb-ldap-modules = " \
 glibc \
 libldb \
 libtalloc \
 libtevent \
 libwbclient \
 openldap \
 samba-client-libs \
 samba-common-libs \
 "
RDEPENDS:samba-libs = " \
 glibc \
 libldb \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 popt \
 samba-client-libs \
 samba-common-libs \
 "
RDEPENDS:samba-pidl = " \
 perl-Exporter \
 perl-File-Basename \
 perl-FindBin \
 perl-Getopt-Long \
 perl-Parse-Yapp \
 perl-base \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-parent \
 perl-vars \
 samba-pidl \
 "
RDEPENDS:samba-test = " \
 glibc \
 gnutls \
 krb5-libs \
 libcom_err \
 libldb \
 libnetapi \
 libsmbclient \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 perl-Archive-Tar \
 popt \
 python3-samba \
 readline \
 samba \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 samba-dc-libs \
 samba-libs \
 samba-test-libs \
 samba-winbind \
 "
RDEPENDS:samba-test-libs = " \
 glibc \
 libldb \
 libtalloc \
 libwbclient \
 samba-client-libs \
 samba-common-libs \
 samba-libs \
 "
RDEPENDS:samba-tools = " \
 python3 \
 python3-samba \
 python3-samba-dc \
 "
RDEPENDS:samba-usershares = " \
 bash \
 samba \
 samba-common-tools \
 "
RDEPENDS:samba-vfs-iouring = " \
 glibc \
 libldb \
 libtalloc \
 libtevent \
 liburing \
 libwbclient \
 samba \
 samba-client-libs \
 samba-libs \
 "
RDEPENDS:samba-winbind = " \
 bash \
 glibc \
 gnutls \
 krb5-libs \
 libcom_err \
 libldb \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 openldap \
 popt \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 samba-common-tools \
 samba-dcerpc \
 samba-libs \
 samba-winbind-modules \
 "
RDEPENDS:samba-winbind-clients = " \
 glibc \
 gnutls \
 krb5-libs \
 libcom_err \
 libldb \
 libtalloc \
 libtevent \
 libwbclient \
 popt \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 samba-libs \
 samba-winbind \
 "
RDEPENDS:samba-winbind-krb5-locator = " \
 alternatives \
 bash \
 glibc \
 libldb \
 libtalloc \
 libwbclient \
 samba-client-libs \
 samba-winbind \
 "
RDEPENDS:samba-winbind-modules = " \
 glibc \
 libtalloc \
 libwbclient \
 pam \
 pam-libs \
 samba-client-libs \
 samba-libs \
 "
RDEPENDS:samba-winexe = " \
 glibc \
 libldb \
 libtalloc \
 libtevent \
 libwbclient \
 popt \
 samba-client-libs \
 samba-common-libs \
 "
