# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-human-panic"
PV = "2.0.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-human-panic+color-devel \
 rust-human-panic+default-devel \
 rust-human-panic-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-human-panic-2.0.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e2b4aa3f9be1d163cb0ebceb3f1b7815189326fbee5db0877cf15a4752730b0"

URI_x86_64_v2_rust-human-panic+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-human-panic+color-devel-2.0.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-human-panic+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-human-panic+color-devel}"
SRC_URI[x86_64_v2_rust-human-panic+color-devel.sha256sum] = "8e75fe749310172a7a1f97c43a1503a58d14008626bc4f2bb47efbb25f826ade"

URI_x86_64_v2_rust-human-panic+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-human-panic+default-devel-2.0.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-human-panic+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-human-panic+default-devel}"
SRC_URI[x86_64_v2_rust-human-panic+default-devel.sha256sum] = "fbcb7cd0c587d29b4cece8823c6d18c61ce0bf57ff0498604b481aa3d7286563"

URI_x86_64_v2_rust-human-panic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-human-panic-devel-2.0.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-human-panic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-human-panic-devel}"
SRC_URI[x86_64_v2_rust-human-panic-devel.sha256sum] = "867bb553d50a0f975c396b87d52643da0e5c4694c54171a4dbd8b9085cd2f3c1"

URI_aarch64_rust-human-panic+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-human-panic+color-devel-2.0.4-1.el10_1.noarch.rpm;name=aarch64_rust-human-panic+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-human-panic+color-devel}"
SRC_URI[aarch64_rust-human-panic+color-devel.sha256sum] = "094a894944b8476d615ca512ea04b31314b39ee0c96b4d024095c8b65404ba66"

URI_aarch64_rust-human-panic+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-human-panic+default-devel-2.0.4-1.el10_1.noarch.rpm;name=aarch64_rust-human-panic+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-human-panic+default-devel}"
SRC_URI[aarch64_rust-human-panic+default-devel.sha256sum] = "1881daf867a2e928ecabca802e143be3055445277ec76f37a3d22333a7c89330"

URI_aarch64_rust-human-panic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-human-panic-devel-2.0.4-1.el10_1.noarch.rpm;name=aarch64_rust-human-panic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-human-panic-devel}"
SRC_URI[aarch64_rust-human-panic-devel.sha256sum] = "7351984ff21f5e1cab32bd0869154bf39d11571b77f6d23fe6e645f0623ee123"

RDEPENDS:rust-human-panic+color-devel = " \
 cargo \
 rust-anstream+default-devel \
 rust-anstyle+default-devel \
 rust-human-panic-devel \
 "
RDEPENDS:rust-human-panic+default-devel = " \
 cargo \
 rust-human-panic+color-devel \
 rust-human-panic-devel \
 "
RDEPENDS:rust-human-panic-devel = " \
 cargo \
 rust \
 rust-backtrace+default-devel \
 rust-os_info+default-devel \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 rust-toml+display-devel \
 rust-toml+serde-devel \
 rust-toml-devel \
 rust-uuid+v4-devel \
 rust-uuid-devel \
 "
