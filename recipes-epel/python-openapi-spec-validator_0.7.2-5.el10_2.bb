# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-openapi-spec-validator"
PV = "0.7.2"
PR = "5.el10_2"
PACKAGES = " \
 python3-openapi-spec-validator \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-openapi-spec-validator-0.7.2-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f443f388addbbb2d65ded74ca7c74628182fc515734c3a2f06a4a07d99eed2e6"

URI_x86_64_v2_python3-openapi-spec-validator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-openapi-spec-validator-0.7.2-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-openapi-spec-validator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-openapi-spec-validator}"
SRC_URI[x86_64_v2_python3-openapi-spec-validator.sha256sum] = "df78e28927b72d2618234daa63519eecd92da49673066c1d4c31eba6bf630d22"

URI_aarch64_python3-openapi-spec-validator = "${EPEL_MIRROR}/aarch64/Packages/p/python3-openapi-spec-validator-0.7.2-5.el10_2.noarch.rpm;name=aarch64_python3-openapi-spec-validator;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-openapi-spec-validator}"
SRC_URI[aarch64_python3-openapi-spec-validator.sha256sum] = "981f031dc4780b51a1437e2bc83132deb382fe1d4ed8927f6526687c7263ad88"

RDEPENDS:python3-openapi-spec-validator = " \
 python3 \
 python3-jsonschema \
 python3-jsonschema-path \
 python3-lazy-object-proxy \
 python3-openapi-schema-validator \
 "
