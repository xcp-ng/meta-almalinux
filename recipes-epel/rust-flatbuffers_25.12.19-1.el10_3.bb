# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-flatbuffers"
PV = "25.12.19"
PR = "1.el10_3"
PACKAGES = " \
 rust-flatbuffers+default-devel \
 rust-flatbuffers+serde-devel \
 rust-flatbuffers+serialize-devel \
 rust-flatbuffers+std-devel \
 rust-flatbuffers-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-flatbuffers-25.12.19-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec99dcfdd1a99d279e0ba8cdee22a6b836f71eba132e3833ea902e83d703147f"

URI_x86_64_v2_rust-flatbuffers+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flatbuffers+default-devel-25.12.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flatbuffers+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flatbuffers+default-devel}"
SRC_URI[x86_64_v2_rust-flatbuffers+default-devel.sha256sum] = "ddbc6b9ff94d1a26ccf0d24d27cfe4646840107a32bbf880cf156487fa336562"

URI_x86_64_v2_rust-flatbuffers+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flatbuffers+serde-devel-25.12.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flatbuffers+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flatbuffers+serde-devel}"
SRC_URI[x86_64_v2_rust-flatbuffers+serde-devel.sha256sum] = "ca625b272b43d0599a29735740f68620a455373b15eb00805c3e51abe0adbba9"

URI_x86_64_v2_rust-flatbuffers+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flatbuffers+serialize-devel-25.12.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flatbuffers+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flatbuffers+serialize-devel}"
SRC_URI[x86_64_v2_rust-flatbuffers+serialize-devel.sha256sum] = "8162a8d1cf5479b90e03a2253010766456bb72cdd0b2f646148030b765f346c5"

URI_x86_64_v2_rust-flatbuffers+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flatbuffers+std-devel-25.12.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flatbuffers+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flatbuffers+std-devel}"
SRC_URI[x86_64_v2_rust-flatbuffers+std-devel.sha256sum] = "ba7c8cc3cf7e1ca6be2c0cb2a69b398225271272a54437fb957762424c8d5a8f"

URI_x86_64_v2_rust-flatbuffers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flatbuffers-devel-25.12.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flatbuffers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flatbuffers-devel}"
SRC_URI[x86_64_v2_rust-flatbuffers-devel.sha256sum] = "8cce416ac6af9083e4b004f54151d1b6a6c2005a0f5ef707d9e2b8f7dc74de99"

URI_aarch64_rust-flatbuffers+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flatbuffers+default-devel-25.12.19-1.el10_3.noarch.rpm;name=aarch64_rust-flatbuffers+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flatbuffers+default-devel}"
SRC_URI[aarch64_rust-flatbuffers+default-devel.sha256sum] = "1c99ae12998fbdda63b4bf37a1998e9237802975b5da8445398b3074d6058b43"

URI_aarch64_rust-flatbuffers+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flatbuffers+serde-devel-25.12.19-1.el10_3.noarch.rpm;name=aarch64_rust-flatbuffers+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flatbuffers+serde-devel}"
SRC_URI[aarch64_rust-flatbuffers+serde-devel.sha256sum] = "5a506f80bce18a6f3e3c3a2e76dabff0519cf1a54fbecab6031d4a07b8eb3608"

URI_aarch64_rust-flatbuffers+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flatbuffers+serialize-devel-25.12.19-1.el10_3.noarch.rpm;name=aarch64_rust-flatbuffers+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flatbuffers+serialize-devel}"
SRC_URI[aarch64_rust-flatbuffers+serialize-devel.sha256sum] = "1dec6c26717087836f7171231559200609cab8145c7b1b3b1e64504c5ec08bf8"

URI_aarch64_rust-flatbuffers+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flatbuffers+std-devel-25.12.19-1.el10_3.noarch.rpm;name=aarch64_rust-flatbuffers+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flatbuffers+std-devel}"
SRC_URI[aarch64_rust-flatbuffers+std-devel.sha256sum] = "2b3dbda3bf7273f1791d2852a82da253313988484f8e8bf3647eff278d80a0c4"

URI_aarch64_rust-flatbuffers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flatbuffers-devel-25.12.19-1.el10_3.noarch.rpm;name=aarch64_rust-flatbuffers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flatbuffers-devel}"
SRC_URI[aarch64_rust-flatbuffers-devel.sha256sum] = "18fac9ddd5a0bc376bbb849679d4e614cce22fe006cd49d0a12539fc216ef093"

RDEPENDS:rust-flatbuffers+default-devel = " \
 cargo \
 rust-flatbuffers+std-devel \
 rust-flatbuffers-devel \
 "
RDEPENDS:rust-flatbuffers+serde-devel = " \
 cargo \
 rust-flatbuffers-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-flatbuffers+serialize-devel = " \
 cargo \
 rust-flatbuffers+serde-devel \
 rust-flatbuffers-devel \
 "
RDEPENDS:rust-flatbuffers+std-devel = " \
 cargo \
 rust-flatbuffers-devel \
 "
RDEPENDS:rust-flatbuffers-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-rustc_version+default-devel \
 "
