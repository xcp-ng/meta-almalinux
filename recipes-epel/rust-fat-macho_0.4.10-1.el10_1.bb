# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fat-macho"
PV = "0.4.10"
PR = "1.el10_1"
PACKAGES = " \
 rust-fat-macho+bitcode-devel \
 rust-fat-macho+default-devel \
 rust-fat-macho+llvm-bitcode-devel \
 rust-fat-macho-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fat-macho-0.4.10-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "61fb27ddd0ee6edd3aee60e594dd902ce46ab7c2303d3c377065efad7e8b4cae"

URI_x86_64_v2_rust-fat-macho+bitcode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fat-macho+bitcode-devel-0.4.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fat-macho+bitcode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fat-macho+bitcode-devel}"
SRC_URI[x86_64_v2_rust-fat-macho+bitcode-devel.sha256sum] = "7048c1e75345a3cf82521c65c380b63d589f27982e4d8a07569d912bdb8ceba8"

URI_x86_64_v2_rust-fat-macho+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fat-macho+default-devel-0.4.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fat-macho+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fat-macho+default-devel}"
SRC_URI[x86_64_v2_rust-fat-macho+default-devel.sha256sum] = "9eaf075b597f3c3d6a1044086beff91e29b1f4ea41492534b25991d55e18b374"

URI_x86_64_v2_rust-fat-macho+llvm-bitcode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fat-macho+llvm-bitcode-devel-0.4.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fat-macho+llvm-bitcode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fat-macho+llvm-bitcode-devel}"
SRC_URI[x86_64_v2_rust-fat-macho+llvm-bitcode-devel.sha256sum] = "2e77b6941eb490b21547ed5ab1c16935c074928270eb8b1b78b14cad852fee04"

URI_x86_64_v2_rust-fat-macho-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fat-macho-devel-0.4.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fat-macho-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fat-macho-devel}"
SRC_URI[x86_64_v2_rust-fat-macho-devel.sha256sum] = "f2052ba1bd719bf4868a25baff7505d4b9f3f5928b4ad6d524c7e538581b740c"

URI_aarch64_rust-fat-macho+bitcode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fat-macho+bitcode-devel-0.4.10-1.el10_1.noarch.rpm;name=aarch64_rust-fat-macho+bitcode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fat-macho+bitcode-devel}"
SRC_URI[aarch64_rust-fat-macho+bitcode-devel.sha256sum] = "d12403a5f3a547986f45b4f291fda33b0565d25d1604e1436a70cac926eec262"

URI_aarch64_rust-fat-macho+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fat-macho+default-devel-0.4.10-1.el10_1.noarch.rpm;name=aarch64_rust-fat-macho+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fat-macho+default-devel}"
SRC_URI[aarch64_rust-fat-macho+default-devel.sha256sum] = "4cea66e6eead43bd217fe04273921fdcee6fe268952446bc374b3f5c33a41600"

URI_aarch64_rust-fat-macho+llvm-bitcode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fat-macho+llvm-bitcode-devel-0.4.10-1.el10_1.noarch.rpm;name=aarch64_rust-fat-macho+llvm-bitcode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fat-macho+llvm-bitcode-devel}"
SRC_URI[aarch64_rust-fat-macho+llvm-bitcode-devel.sha256sum] = "9a03ee7075b04780685f820e2a87400e79190ffaa5a0a0e230139d0f48be1267"

URI_aarch64_rust-fat-macho-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fat-macho-devel-0.4.10-1.el10_1.noarch.rpm;name=aarch64_rust-fat-macho-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fat-macho-devel}"
SRC_URI[aarch64_rust-fat-macho-devel.sha256sum] = "272c4d08b9acf31882d9caa9311fe859889983b57652a7d649871a6ecd27bc77"

RDEPENDS:rust-fat-macho+bitcode-devel = " \
 cargo \
 rust-fat-macho+llvm-bitcode-devel \
 rust-fat-macho-devel \
 "
RDEPENDS:rust-fat-macho+default-devel = " \
 cargo \
 rust-fat-macho+bitcode-devel \
 rust-fat-macho-devel \
 "
RDEPENDS:rust-fat-macho+llvm-bitcode-devel = " \
 cargo \
 rust-fat-macho-devel \
 rust-llvm-bitcode+default-devel \
 "
RDEPENDS:rust-fat-macho-devel = " \
 cargo \
 rust-goblin+default-devel \
 "
