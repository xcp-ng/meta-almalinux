# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dashmap"
PV = "6.1.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-dashmap+arbitrary-devel \
 rust-dashmap+default-devel \
 rust-dashmap+inline-devel \
 rust-dashmap+raw-api-devel \
 rust-dashmap+rayon-devel \
 rust-dashmap+serde-devel \
 rust-dashmap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dashmap-6.1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8619d28d717be3211fa3cac3c273ee2570b75058c9b2db4d43d9c00560e6a00"

URI_x86_64_v2_rust-dashmap+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dashmap+arbitrary-devel-6.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dashmap+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dashmap+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-dashmap+arbitrary-devel.sha256sum] = "3a200497f5fb20e693feee06815dddb96964319c1b057685a2198e17c74843ae"

URI_x86_64_v2_rust-dashmap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dashmap+default-devel-6.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dashmap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dashmap+default-devel}"
SRC_URI[x86_64_v2_rust-dashmap+default-devel.sha256sum] = "0ff5c7637a472f83a1e2dd195293f87384d4ab8425c4c6090576b4e4042303b0"

URI_x86_64_v2_rust-dashmap+inline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dashmap+inline-devel-6.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dashmap+inline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dashmap+inline-devel}"
SRC_URI[x86_64_v2_rust-dashmap+inline-devel.sha256sum] = "0a732f35ce8938ce2663e8dfe3fad969d43b5174952b2d5f25e8c8530357e100"

URI_x86_64_v2_rust-dashmap+raw-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dashmap+raw-api-devel-6.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dashmap+raw-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dashmap+raw-api-devel}"
SRC_URI[x86_64_v2_rust-dashmap+raw-api-devel.sha256sum] = "e989d7be34de8260f9fd356b2fb9578169e3d0a5571a4d4bd5dbfab7331db35a"

URI_x86_64_v2_rust-dashmap+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dashmap+rayon-devel-6.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dashmap+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dashmap+rayon-devel}"
SRC_URI[x86_64_v2_rust-dashmap+rayon-devel.sha256sum] = "3d7cca88e53a013c671b56a02ae475d1349aaefb120341432b75b9371022033c"

URI_x86_64_v2_rust-dashmap+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dashmap+serde-devel-6.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dashmap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dashmap+serde-devel}"
SRC_URI[x86_64_v2_rust-dashmap+serde-devel.sha256sum] = "3638aaf3fcf9200ef1a30ca19872503f0011612291039fec433fcc9aeef24397"

URI_x86_64_v2_rust-dashmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dashmap-devel-6.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dashmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dashmap-devel}"
SRC_URI[x86_64_v2_rust-dashmap-devel.sha256sum] = "2c61a781293aec03b9952e01ce082ed5afd4754315895850e7b727bd9c241b62"

URI_aarch64_rust-dashmap+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dashmap+arbitrary-devel-6.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-dashmap+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dashmap+arbitrary-devel}"
SRC_URI[aarch64_rust-dashmap+arbitrary-devel.sha256sum] = "0cfe9240a99f8b5e1c4d6d95cbba38165c0810e4d0707bc716804054957f5de6"

URI_aarch64_rust-dashmap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dashmap+default-devel-6.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-dashmap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dashmap+default-devel}"
SRC_URI[aarch64_rust-dashmap+default-devel.sha256sum] = "c79a23b98d9a21f5700dd338eade3e3897548b82402d199782d59fb5b3e76f68"

URI_aarch64_rust-dashmap+inline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dashmap+inline-devel-6.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-dashmap+inline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dashmap+inline-devel}"
SRC_URI[aarch64_rust-dashmap+inline-devel.sha256sum] = "32af0707debce9abb9e5e3de9bab61086ae82c68ceb550804fa2b6d8d362d487"

URI_aarch64_rust-dashmap+raw-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dashmap+raw-api-devel-6.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-dashmap+raw-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dashmap+raw-api-devel}"
SRC_URI[aarch64_rust-dashmap+raw-api-devel.sha256sum] = "a373ac6b155160cabfb0e8487bf9796efb13cd8d5796f8f5431527b9c1ea362c"

URI_aarch64_rust-dashmap+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dashmap+rayon-devel-6.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-dashmap+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dashmap+rayon-devel}"
SRC_URI[aarch64_rust-dashmap+rayon-devel.sha256sum] = "9b60df2cecea764fa0acea2925439c920603c1f0df99bb7fa8e13d0a673ec84f"

URI_aarch64_rust-dashmap+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dashmap+serde-devel-6.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-dashmap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dashmap+serde-devel}"
SRC_URI[aarch64_rust-dashmap+serde-devel.sha256sum] = "af02a55209ad3a50504b5ea00829cadee28ccd7e8d8a23262268ba0ca812db29"

URI_aarch64_rust-dashmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dashmap-devel-6.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-dashmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dashmap-devel}"
SRC_URI[aarch64_rust-dashmap-devel.sha256sum] = "3d563c95996ed7bfe1a9352339408c7d469f4a7556358c4753ffe75080a856ac"

RDEPENDS:rust-dashmap+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-dashmap-devel \
 "
RDEPENDS:rust-dashmap+default-devel = " \
 cargo \
 rust-dashmap-devel \
 "
RDEPENDS:rust-dashmap+inline-devel = " \
 cargo \
 rust-dashmap-devel \
 rust-hashbrown0.14+inline-more-devel \
 "
RDEPENDS:rust-dashmap+raw-api-devel = " \
 cargo \
 rust-dashmap-devel \
 "
RDEPENDS:rust-dashmap+rayon-devel = " \
 cargo \
 rust-dashmap-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-dashmap+serde-devel = " \
 cargo \
 rust-dashmap-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-dashmap-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-crossbeam-utils+default-devel \
 rust-hashbrown0.14+raw-devel \
 rust-hashbrown0.14-devel \
 rust-lock_api+default-devel \
 rust-once_cell+default-devel \
 rust-parking_lot_core+default-devel \
 "
