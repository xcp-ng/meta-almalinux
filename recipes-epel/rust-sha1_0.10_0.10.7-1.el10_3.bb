# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sha1_0.10"
PV = "0.10.7"
PR = "1.el10_3"
PACKAGES = " \
 rust-sha1_0.10+asm-devel \
 rust-sha1_0.10+compress-devel \
 rust-sha1_0.10+default-devel \
 rust-sha1_0.10+force-soft-devel \
 rust-sha1_0.10+loongarch64_asm-devel \
 rust-sha1_0.10+oid-devel \
 rust-sha1_0.10+std-devel \
 rust-sha1_0.10-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sha1_0.10-0.10.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3837b10eec0941a95e26b5adac89cb1adb98dc17dfb6ce3f453992bb236543d3"

URI_x86_64_v2_rust-sha1_0.10+asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1_0.10+asm-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1_0.10+asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1_0.10+asm-devel}"
SRC_URI[x86_64_v2_rust-sha1_0.10+asm-devel.sha256sum] = "164578d6df5ede95b51b5c9319a5c4e99198d014f5b0fd23c7116d3ea0ac9fd4"

URI_x86_64_v2_rust-sha1_0.10+compress-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1_0.10+compress-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1_0.10+compress-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1_0.10+compress-devel}"
SRC_URI[x86_64_v2_rust-sha1_0.10+compress-devel.sha256sum] = "68a49138a394d5eca58f7993af78915aa5aff595eb23584db61f1c915d9442fe"

URI_x86_64_v2_rust-sha1_0.10+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1_0.10+default-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1_0.10+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1_0.10+default-devel}"
SRC_URI[x86_64_v2_rust-sha1_0.10+default-devel.sha256sum] = "f25bfc0422e8d960c253461b934d4b51d464e90645d4f2360446e89af2fe346c"

URI_x86_64_v2_rust-sha1_0.10+force-soft-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1_0.10+force-soft-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1_0.10+force-soft-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1_0.10+force-soft-devel}"
SRC_URI[x86_64_v2_rust-sha1_0.10+force-soft-devel.sha256sum] = "88c0da22858e18980c900f7275da5b6db7257070fcd562476036ca26fd8c1f35"

URI_x86_64_v2_rust-sha1_0.10+loongarch64_asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1_0.10+loongarch64_asm-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1_0.10+loongarch64_asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1_0.10+loongarch64_asm-devel}"
SRC_URI[x86_64_v2_rust-sha1_0.10+loongarch64_asm-devel.sha256sum] = "ee72a34440b17b92d3dac3cd8f7ef5b40e8fbd2c0acd0f5d0723fa2ea07f7a96"

URI_x86_64_v2_rust-sha1_0.10+oid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1_0.10+oid-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1_0.10+oid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1_0.10+oid-devel}"
SRC_URI[x86_64_v2_rust-sha1_0.10+oid-devel.sha256sum] = "20aef661a559b877d9e85638160b2e38d9dee66333cbac40bd66988b3bd44a92"

URI_x86_64_v2_rust-sha1_0.10+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1_0.10+std-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1_0.10+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1_0.10+std-devel}"
SRC_URI[x86_64_v2_rust-sha1_0.10+std-devel.sha256sum] = "16dd290347ca6cf0872da72860234a3cf3555131a43edf724ba4506f5dc012c8"

URI_x86_64_v2_rust-sha1_0.10-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1_0.10-devel-0.10.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1_0.10-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1_0.10-devel}"
SRC_URI[x86_64_v2_rust-sha1_0.10-devel.sha256sum] = "a1646e00e5c8d0d56d387380e76680c3803ddab6afb43a96437cd210bd5de1e4"

URI_aarch64_rust-sha1_0.10+asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1_0.10+asm-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-sha1_0.10+asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1_0.10+asm-devel}"
SRC_URI[aarch64_rust-sha1_0.10+asm-devel.sha256sum] = "a4c7e04a1beeee9782d607608b337d285047f9f884d16e15c1099c758751d926"

URI_aarch64_rust-sha1_0.10+compress-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1_0.10+compress-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-sha1_0.10+compress-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1_0.10+compress-devel}"
SRC_URI[aarch64_rust-sha1_0.10+compress-devel.sha256sum] = "11fc847c329bdc689ff98acf97c5e88e77f9bb5acd23b4d341e64f2e3699de4c"

URI_aarch64_rust-sha1_0.10+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1_0.10+default-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-sha1_0.10+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1_0.10+default-devel}"
SRC_URI[aarch64_rust-sha1_0.10+default-devel.sha256sum] = "a164afac87cf719b5af59911ad6cc8b9b7d40e4d24a51463ff73ac9ef3d1ef06"

URI_aarch64_rust-sha1_0.10+force-soft-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1_0.10+force-soft-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-sha1_0.10+force-soft-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1_0.10+force-soft-devel}"
SRC_URI[aarch64_rust-sha1_0.10+force-soft-devel.sha256sum] = "c311682e0847b2d3635194fa80e8625de728e411ce05ceb6fd27efcfebf5321e"

URI_aarch64_rust-sha1_0.10+loongarch64_asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1_0.10+loongarch64_asm-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-sha1_0.10+loongarch64_asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1_0.10+loongarch64_asm-devel}"
SRC_URI[aarch64_rust-sha1_0.10+loongarch64_asm-devel.sha256sum] = "cedc99b561d74e0e2c7a65d523d72b4c13c1cfa0025395a85344691d772d5ab5"

URI_aarch64_rust-sha1_0.10+oid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1_0.10+oid-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-sha1_0.10+oid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1_0.10+oid-devel}"
SRC_URI[aarch64_rust-sha1_0.10+oid-devel.sha256sum] = "a4fbc7dc4df986ebedc844ecba822d7341d81efa639c57afcb4be10b551bb5be"

URI_aarch64_rust-sha1_0.10+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1_0.10+std-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-sha1_0.10+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1_0.10+std-devel}"
SRC_URI[aarch64_rust-sha1_0.10+std-devel.sha256sum] = "531c033baa6c8aaa53bebe80f6f01356a692748ca691f0e12d04f717f3fc8bed"

URI_aarch64_rust-sha1_0.10-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1_0.10-devel-0.10.7-1.el10_3.noarch.rpm;name=aarch64_rust-sha1_0.10-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1_0.10-devel}"
SRC_URI[aarch64_rust-sha1_0.10-devel.sha256sum] = "41b17e6ef115773bc656dc0d75956f81d70c1aa8b00cd202710249d69e9a0c1d"

RDEPENDS:rust-sha1_0.10+asm-devel = " \
 cargo \
 rust-sha1_0.10-devel \
 "
RDEPENDS:rust-sha1_0.10+compress-devel = " \
 cargo \
 rust-sha1_0.10-devel \
 "
RDEPENDS:rust-sha1_0.10+default-devel = " \
 cargo \
 rust-sha1_0.10+std-devel \
 rust-sha1_0.10-devel \
 "
RDEPENDS:rust-sha1_0.10+force-soft-devel = " \
 cargo \
 rust-sha1_0.10-devel \
 "
RDEPENDS:rust-sha1_0.10+loongarch64_asm-devel = " \
 cargo \
 rust-sha1_0.10-devel \
 "
RDEPENDS:rust-sha1_0.10+oid-devel = " \
 cargo \
 rust-digest0.10+oid-devel \
 rust-sha1_0.10-devel \
 "
RDEPENDS:rust-sha1_0.10+std-devel = " \
 cargo \
 rust-digest0.10+std-devel \
 rust-sha1_0.10-devel \
 "
RDEPENDS:rust-sha1_0.10-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 rust-cpufeatures0.2+default-devel \
 rust-digest0.10+default-devel \
 "
