# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-snapbox-macros"
PV = "0.3.10"
PR = "1.el10_0"
PACKAGES = " \
 rust-snapbox-macros+color-devel \
 rust-snapbox-macros+debug-devel \
 rust-snapbox-macros+default-devel \
 rust-snapbox-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-snapbox-macros-0.3.10-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "22e994586e8df04ee272a2e527a5d47f9abe7fa6aa0ca2e29f185c65200581c1"

URI_x86_64_v2_rust-snapbox-macros+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox-macros+color-devel-0.3.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox-macros+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox-macros+color-devel}"
SRC_URI[x86_64_v2_rust-snapbox-macros+color-devel.sha256sum] = "d83b46c87824be16b97955277537c913fd46078d4a2396f5969e693baa7586ce"

URI_x86_64_v2_rust-snapbox-macros+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox-macros+debug-devel-0.3.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox-macros+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox-macros+debug-devel}"
SRC_URI[x86_64_v2_rust-snapbox-macros+debug-devel.sha256sum] = "5fac83b8d4829980109a0407c3f273139934ad3ebd62c04c9bb831369beda432"

URI_x86_64_v2_rust-snapbox-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox-macros+default-devel-0.3.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox-macros+default-devel}"
SRC_URI[x86_64_v2_rust-snapbox-macros+default-devel.sha256sum] = "713b0db99a54c2a20380828bdbe62c65a829e81f8c30a8e9a23a99ccd6cbc482"

URI_x86_64_v2_rust-snapbox-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox-macros-devel-0.3.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox-macros-devel}"
SRC_URI[x86_64_v2_rust-snapbox-macros-devel.sha256sum] = "594fab770556de11ad4ff03ce5a64021e5deeac689e19398dbdd22663ec8b84e"

URI_aarch64_rust-snapbox-macros+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox-macros+color-devel-0.3.10-1.el10_0.noarch.rpm;name=aarch64_rust-snapbox-macros+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox-macros+color-devel}"
SRC_URI[aarch64_rust-snapbox-macros+color-devel.sha256sum] = "c13270ce742982fdcd78c5206565551c44027c6da8c39b97aa349b4b749caa24"

URI_aarch64_rust-snapbox-macros+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox-macros+debug-devel-0.3.10-1.el10_0.noarch.rpm;name=aarch64_rust-snapbox-macros+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox-macros+debug-devel}"
SRC_URI[aarch64_rust-snapbox-macros+debug-devel.sha256sum] = "163fd8e0461228ea9c2503ad99df32a5121456bd8943e74ac105c6a031c868fe"

URI_aarch64_rust-snapbox-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox-macros+default-devel-0.3.10-1.el10_0.noarch.rpm;name=aarch64_rust-snapbox-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox-macros+default-devel}"
SRC_URI[aarch64_rust-snapbox-macros+default-devel.sha256sum] = "474202b41a69bf61970173abdd619c8674b2145d65d1ce79119239850f940975"

URI_aarch64_rust-snapbox-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox-macros-devel-0.3.10-1.el10_0.noarch.rpm;name=aarch64_rust-snapbox-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox-macros-devel}"
SRC_URI[aarch64_rust-snapbox-macros-devel.sha256sum] = "96ca44bfb7c1e341bcb443c89e57f303172abcaf4d3b79fc8b6c0acdc1657387"

RDEPENDS:rust-snapbox-macros+color-devel = " \
 cargo \
 rust-anstream+default-devel \
 rust-snapbox-macros-devel \
 "
RDEPENDS:rust-snapbox-macros+debug-devel = " \
 cargo \
 rust-snapbox-macros-devel \
 "
RDEPENDS:rust-snapbox-macros+default-devel = " \
 cargo \
 rust-snapbox-macros-devel \
 "
RDEPENDS:rust-snapbox-macros-devel = " \
 cargo \
 rust \
 "
