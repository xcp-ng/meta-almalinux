# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "isoimagewriter"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 isoimagewriter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/isoimagewriter-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8061bbc85d7fb2dc62df74ca0778b74f9fc946b8e7953fd5c87f168c2190e28f"

URI_x86_64_v2_isoimagewriter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/isoimagewriter-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_isoimagewriter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_isoimagewriter}"
SRC_URI[x86_64_v2_isoimagewriter.sha256sum] = "06d4635825a7a4d67103d3257123cb87e86479837f4f6a99fa0967a47fba0f8a"

URI_aarch64_isoimagewriter = "${EPEL_MIRROR}/aarch64/Packages/i/isoimagewriter-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_isoimagewriter;unpack=0"
SRC_URI:append = " ${URI_aarch64_isoimagewriter}"
SRC_URI[aarch64_isoimagewriter.sha256sum] = "561ceadd49b1c361066b87b3deaa15103b299d217d2db6e317e1c199bae390ee"

RDEPENDS:isoimagewriter = " \
 glibc \
 gpgmepp \
 kf6-karchive \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-solid \
 libgcc \
 libstdc++ \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
