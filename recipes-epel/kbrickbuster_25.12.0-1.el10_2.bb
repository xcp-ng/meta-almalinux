# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kbrickbuster"
PV = "25.12.0"
PR = "1.el10_2"
PACKAGES = " \
 kbrickbuster \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kbrickbuster-25.12.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc805053c11ea0a31c60af5c1fdcaf0d1bd4ec73c1928548973df6ede65ae1f5"

URI_x86_64_v2_kbrickbuster = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kbrickbuster-25.12.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kbrickbuster;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kbrickbuster}"
SRC_URI[x86_64_v2_kbrickbuster.sha256sum] = "226527f7cad305271d827ae43b84bdb56acda7d9dd145a848f9081cbdf5fe6a4"

URI_aarch64_kbrickbuster = "${EPEL_MIRROR}/aarch64/Packages/k/kbrickbuster-25.12.0-1.el10_2.aarch64.rpm;name=aarch64_kbrickbuster;unpack=0"
SRC_URI:append = " ${URI_aarch64_kbrickbuster}"
SRC_URI[aarch64_kbrickbuster.sha256sum] = "c717af4f6a7249d664c452c1c31c260419c1140b07b6564408b9203886a7168e"

RDEPENDS:kbrickbuster = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
