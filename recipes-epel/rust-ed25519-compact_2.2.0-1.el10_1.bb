# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ed25519-compact"
PV = "2.2.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-ed25519-compact+blind-keys-devel \
 rust-ed25519-compact+ct-codecs-devel \
 rust-ed25519-compact+default-devel \
 rust-ed25519-compact+disable-signatures-devel \
 rust-ed25519-compact+ed25519-devel \
 rust-ed25519-compact+getrandom-devel \
 rust-ed25519-compact+opt_size-devel \
 rust-ed25519-compact+pem-devel \
 rust-ed25519-compact+random-devel \
 rust-ed25519-compact+self-verify-devel \
 rust-ed25519-compact+std-devel \
 rust-ed25519-compact+traits-devel \
 rust-ed25519-compact+x25519-devel \
 rust-ed25519-compact-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ed25519-compact-2.2.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "218bb20e37c7918aa501892d2d018e988389dbac1c3f35eefde2d704270cb8f4"

URI_x86_64_v2_rust-ed25519-compact+blind-keys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+blind-keys-devel-2.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+blind-keys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+blind-keys-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+blind-keys-devel.sha256sum] = "4a0fe4461004cf327700673bc9cead6bb2ea669f268c4c05cdbbdaa4c01035b7"

URI_x86_64_v2_rust-ed25519-compact+ct-codecs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+ct-codecs-devel-2.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+ct-codecs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+ct-codecs-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+ct-codecs-devel.sha256sum] = "deb13abc2dcf6d6d97d8518918a936e59cb78c99aeb0e142b0e468d4af66859c"

URI_x86_64_v2_rust-ed25519-compact+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+default-devel-2.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+default-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+default-devel.sha256sum] = "e47c5227c72e8d25454532cd5c0ece13126f50285dce028dd98e17644fe9a633"

URI_x86_64_v2_rust-ed25519-compact+disable-signatures-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+disable-signatures-devel-2.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+disable-signatures-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+disable-signatures-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+disable-signatures-devel.sha256sum] = "f9f2007551106ae224c836b3547bdd5d838a1b81c3fe08632bfeca5572f8f077"

URI_x86_64_v2_rust-ed25519-compact+ed25519-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+ed25519-devel-2.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+ed25519-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+ed25519-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+ed25519-devel.sha256sum] = "44172db7556a28113b1f020e297b7294443949199c813272bfa1be414f62a8c9"

URI_x86_64_v2_rust-ed25519-compact+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+getrandom-devel-2.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+getrandom-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+getrandom-devel.sha256sum] = "b6a7f413099b5119a78df544b45479438e59e8a3036fc992b83c0e96d2fc2f4b"

URI_x86_64_v2_rust-ed25519-compact+opt_size-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+opt_size-devel-2.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+opt_size-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+opt_size-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+opt_size-devel.sha256sum] = "88296a8ffc4f320392c1b9844c53bd09830c4100039a434ba586cb83404503d0"

URI_x86_64_v2_rust-ed25519-compact+pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+pem-devel-2.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+pem-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+pem-devel.sha256sum] = "3606c4007f7d6bc27875abd5fcca8065ed24723ab00ea0c29ec08d5fad26ede6"

URI_x86_64_v2_rust-ed25519-compact+random-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+random-devel-2.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+random-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+random-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+random-devel.sha256sum] = "256e05f2962bf5a671ee8a630469c28968439367bf911f40b762c11bb6604bab"

URI_x86_64_v2_rust-ed25519-compact+self-verify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+self-verify-devel-2.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+self-verify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+self-verify-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+self-verify-devel.sha256sum] = "9642b305ea5e19fa259bc3a8e31a52d2f4203741e25496db51a3cb1fa2306c13"

URI_x86_64_v2_rust-ed25519-compact+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+std-devel-2.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+std-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+std-devel.sha256sum] = "18887775224d450fa921cc6d8f29880f5400e2c87179084962b014029f1d37ec"

URI_x86_64_v2_rust-ed25519-compact+traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+traits-devel-2.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+traits-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+traits-devel.sha256sum] = "6a30271a49a909fbd3ab54680ff64080e29c04409dc88b345a053d5377724913"

URI_x86_64_v2_rust-ed25519-compact+x25519-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+x25519-devel-2.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+x25519-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+x25519-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+x25519-devel.sha256sum] = "e03d49791070f75b6836c9f258f119420997be283630f829114a291f9aa01855"

URI_x86_64_v2_rust-ed25519-compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact-devel-2.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact-devel.sha256sum] = "90360c4797d973b27ecbdfbd87df2aa706d2a6c698b43591059d3d681dd1a010"

URI_aarch64_rust-ed25519-compact+blind-keys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+blind-keys-devel-2.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-ed25519-compact+blind-keys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+blind-keys-devel}"
SRC_URI[aarch64_rust-ed25519-compact+blind-keys-devel.sha256sum] = "00de2bf69bc71ebf1707f79d2f7783e086b657422fb32cb2fac4806234c1854d"

URI_aarch64_rust-ed25519-compact+ct-codecs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+ct-codecs-devel-2.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-ed25519-compact+ct-codecs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+ct-codecs-devel}"
SRC_URI[aarch64_rust-ed25519-compact+ct-codecs-devel.sha256sum] = "8eb1c85ee37042705f298da9bfce2c5598c88e8d864a177e12c8e838f57292d2"

URI_aarch64_rust-ed25519-compact+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+default-devel-2.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-ed25519-compact+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+default-devel}"
SRC_URI[aarch64_rust-ed25519-compact+default-devel.sha256sum] = "4bbcad0a293d5fc3307bc4069662b8d207dbf7f0825c832d5d206267b365ffe0"

URI_aarch64_rust-ed25519-compact+disable-signatures-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+disable-signatures-devel-2.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-ed25519-compact+disable-signatures-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+disable-signatures-devel}"
SRC_URI[aarch64_rust-ed25519-compact+disable-signatures-devel.sha256sum] = "fcdd45d0411b7594d62b04c1aeff57d6abd6511fb701770577f1bfee934d64e3"

URI_aarch64_rust-ed25519-compact+ed25519-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+ed25519-devel-2.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-ed25519-compact+ed25519-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+ed25519-devel}"
SRC_URI[aarch64_rust-ed25519-compact+ed25519-devel.sha256sum] = "905743c1a239053ae21a755aff2d1c8986b951d017933f3c35b76409f7106831"

URI_aarch64_rust-ed25519-compact+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+getrandom-devel-2.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-ed25519-compact+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+getrandom-devel}"
SRC_URI[aarch64_rust-ed25519-compact+getrandom-devel.sha256sum] = "74d7177bea02e4825dae97905d7ffc8924cb4cdd587abc841d5e194a7e2a334e"

URI_aarch64_rust-ed25519-compact+opt_size-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+opt_size-devel-2.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-ed25519-compact+opt_size-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+opt_size-devel}"
SRC_URI[aarch64_rust-ed25519-compact+opt_size-devel.sha256sum] = "d3b450d39fca304ff047a91a4958357437dad9d45bdfebedd4795c4cafff2f2f"

URI_aarch64_rust-ed25519-compact+pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+pem-devel-2.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-ed25519-compact+pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+pem-devel}"
SRC_URI[aarch64_rust-ed25519-compact+pem-devel.sha256sum] = "b56b11142cd7c99b7055d8f934e391d61f46c0179a8085650e531e1782168523"

URI_aarch64_rust-ed25519-compact+random-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+random-devel-2.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-ed25519-compact+random-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+random-devel}"
SRC_URI[aarch64_rust-ed25519-compact+random-devel.sha256sum] = "ade6126a0ed8202fb9cc69bc630c7d0bfe95ef5fa5fe1b6c38373a0dac964c0c"

URI_aarch64_rust-ed25519-compact+self-verify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+self-verify-devel-2.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-ed25519-compact+self-verify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+self-verify-devel}"
SRC_URI[aarch64_rust-ed25519-compact+self-verify-devel.sha256sum] = "f963d01de6fc904f130b1bacebaba44ee8227764e757f47e8273a6d73943aa53"

URI_aarch64_rust-ed25519-compact+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+std-devel-2.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-ed25519-compact+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+std-devel}"
SRC_URI[aarch64_rust-ed25519-compact+std-devel.sha256sum] = "0bdefdca7c9ff8db6fbb340ce024a91ee0de6fea5e55b65cd3b387ea0edfc11c"

URI_aarch64_rust-ed25519-compact+traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+traits-devel-2.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-ed25519-compact+traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+traits-devel}"
SRC_URI[aarch64_rust-ed25519-compact+traits-devel.sha256sum] = "dacf2cf6535f24f06ebd01133e546d5e37acc60f8e85a40c456bf378b01b16ef"

URI_aarch64_rust-ed25519-compact+x25519-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+x25519-devel-2.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-ed25519-compact+x25519-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+x25519-devel}"
SRC_URI[aarch64_rust-ed25519-compact+x25519-devel.sha256sum] = "f8b4ef3690f0cf5795c15652236a5f6a441b03a1e68c45c8383905a8f365878c"

URI_aarch64_rust-ed25519-compact-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact-devel-2.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-ed25519-compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact-devel}"
SRC_URI[aarch64_rust-ed25519-compact-devel.sha256sum] = "338e14bca98066bb702f3b40e585509f1815754afc1cc2ed0a277cc71190ecf5"

RDEPENDS:rust-ed25519-compact+blind-keys-devel = " \
 cargo \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact+ct-codecs-devel = " \
 cargo \
 rust-ct-codecs+default-devel \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact+default-devel = " \
 cargo \
 rust-ed25519-compact+pem-devel \
 rust-ed25519-compact+random-devel \
 rust-ed25519-compact+std-devel \
 rust-ed25519-compact+x25519-devel \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact+disable-signatures-devel = " \
 cargo \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact+ed25519-devel = " \
 cargo \
 rust-ed25519+default-devel \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact+getrandom-devel = " \
 cargo \
 rust-ed25519-compact-devel \
 rust-getrandom+default-devel \
 "
RDEPENDS:rust-ed25519-compact+opt_size-devel = " \
 cargo \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact+pem-devel = " \
 cargo \
 rust-ed25519-compact+ct-codecs-devel \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact+random-devel = " \
 cargo \
 rust-ed25519-compact+getrandom-devel \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact+self-verify-devel = " \
 cargo \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact+std-devel = " \
 cargo \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact+traits-devel = " \
 cargo \
 rust-ed25519-compact+ed25519-devel \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact+x25519-devel = " \
 cargo \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact-devel = " \
 cargo \
 "
