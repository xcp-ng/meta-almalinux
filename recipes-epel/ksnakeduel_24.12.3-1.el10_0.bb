# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksnakeduel"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 ksnakeduel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ksnakeduel-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1a8ab2e3e80bab344e9afe46671293a7cfc6d4de61d0465b9b0946c6c1d96dbc"

URI_x86_64_v2_ksnakeduel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksnakeduel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksnakeduel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksnakeduel}"
SRC_URI[x86_64_v2_ksnakeduel.sha256sum] = "0c12215f40cde9aa50d76beecf83b3019653a45e970dacc0a11bd662fe3be080"

URI_aarch64_ksnakeduel = "${EPEL_MIRROR}/aarch64/Packages/k/ksnakeduel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_ksnakeduel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksnakeduel}"
SRC_URI[aarch64_ksnakeduel.sha256sum] = "9e59dd8b91b039e947941743e3d21e2110576f939da4e09916209f7ceac42c20"

RDEPENDS:ksnakeduel = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
