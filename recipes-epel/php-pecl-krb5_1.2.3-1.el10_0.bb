# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-krb5"
PV = "1.2.3"
PR = "1.el10_0"
PACKAGES = " \
 php-pecl-krb5 \
 php-pecl-krb5-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-krb5-1.2.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc9a11b3c96d66247d27540bd20a09238147006df561991839d383052f182d31"

URI_x86_64_v2_php-pecl-krb5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-krb5-1.2.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-krb5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-krb5}"
SRC_URI[x86_64_v2_php-pecl-krb5.sha256sum] = "dfc99d65aef1630e71a0e0a26aadadfbd6e2ec068f275a3714496eb28945c310"

URI_x86_64_v2_php-pecl-krb5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-krb5-devel-1.2.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-krb5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-krb5-devel}"
SRC_URI[x86_64_v2_php-pecl-krb5-devel.sha256sum] = "307f03c1053a71e598707a23651c6316957228860dcc127bdc3d50b665dadb5c"

URI_aarch64_php-pecl-krb5 = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-krb5-1.2.3-1.el10_0.aarch64.rpm;name=aarch64_php-pecl-krb5;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-krb5}"
SRC_URI[aarch64_php-pecl-krb5.sha256sum] = "3345905bf7f069038ae7eedf63f452779c49cf026fa7190d11d7eb0e496edba2"

URI_aarch64_php-pecl-krb5-devel = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-krb5-devel-1.2.3-1.el10_0.aarch64.rpm;name=aarch64_php-pecl-krb5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-krb5-devel}"
SRC_URI[aarch64_php-pecl-krb5-devel.sha256sum] = "b8b075847c6411dde05623740f64b8a711c16a1eef10499c1f4ffa6aa9db7661"

RDEPENDS:php-pecl-krb5 = " \
 glibc \
 krb5-libs \
 libcom_err \
 libkadm5 \
 php-common \
 "
RDEPENDS:php-pecl-krb5-devel = " \
 php-devel \
 php-pecl-krb5 \
 "
