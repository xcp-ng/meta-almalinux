# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fax"
PV = "0.2.7"
PR = "1.el10_3"
PACKAGES = " \
 rust-fax+debug-devel \
 rust-fax+default-devel \
 rust-fax+generate_bitmaps-devel \
 rust-fax-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fax-0.2.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96ff2df02e32be8765ab02b10daed90c9bdbd0222ec11ffbe347e49f819e72e1"

URI_x86_64_v2_rust-fax+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fax+debug-devel-0.2.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fax+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fax+debug-devel}"
SRC_URI[x86_64_v2_rust-fax+debug-devel.sha256sum] = "723a3ea1ed45e55e068b4dc5de43b409c56d31c0c6471bcc62efdd92f2f9d8c6"

URI_x86_64_v2_rust-fax+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fax+default-devel-0.2.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fax+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fax+default-devel}"
SRC_URI[x86_64_v2_rust-fax+default-devel.sha256sum] = "1d0f08574e1ea3146e8e48300f0ff940d5bd44bb8fc9d9e88992ca79bd24fbc4"

URI_x86_64_v2_rust-fax+generate_bitmaps-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fax+generate_bitmaps-devel-0.2.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fax+generate_bitmaps-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fax+generate_bitmaps-devel}"
SRC_URI[x86_64_v2_rust-fax+generate_bitmaps-devel.sha256sum] = "0199800aba273efd783ecd5a5c4b31f59a81307fb2b476e72e6d097872574d2a"

URI_x86_64_v2_rust-fax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fax-devel-0.2.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fax-devel}"
SRC_URI[x86_64_v2_rust-fax-devel.sha256sum] = "63a4bc5ccbeff4b34841a8ba26539017ffe89ceaac8e49d6df6498cef0285539"

URI_aarch64_rust-fax+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fax+debug-devel-0.2.7-1.el10_3.noarch.rpm;name=aarch64_rust-fax+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fax+debug-devel}"
SRC_URI[aarch64_rust-fax+debug-devel.sha256sum] = "6d472eebacbeada14c6db238effd2a77d2e7159e905db5dccbf803225662ac06"

URI_aarch64_rust-fax+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fax+default-devel-0.2.7-1.el10_3.noarch.rpm;name=aarch64_rust-fax+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fax+default-devel}"
SRC_URI[aarch64_rust-fax+default-devel.sha256sum] = "74aa2ef91fa3a2702f28ce8d7e2acd8c025b4cbbedb019279dd9ff7f85594740"

URI_aarch64_rust-fax+generate_bitmaps-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fax+generate_bitmaps-devel-0.2.7-1.el10_3.noarch.rpm;name=aarch64_rust-fax+generate_bitmaps-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fax+generate_bitmaps-devel}"
SRC_URI[aarch64_rust-fax+generate_bitmaps-devel.sha256sum] = "c987fefa97e94649e6e1c67b65aa24d5d17fabded56dbb27aeb84d0853582bbe"

URI_aarch64_rust-fax-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fax-devel-0.2.7-1.el10_3.noarch.rpm;name=aarch64_rust-fax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fax-devel}"
SRC_URI[aarch64_rust-fax-devel.sha256sum] = "2f2f23b20e6f85987ccf5f76c28c65ebd4cba07a9d851a0d49d48ac6d058a190"

RDEPENDS:rust-fax+debug-devel = " \
 cargo \
 rust-fax-devel \
 "
RDEPENDS:rust-fax+default-devel = " \
 cargo \
 rust-fax-devel \
 "
RDEPENDS:rust-fax+generate_bitmaps-devel = " \
 cargo \
 rust-fax-devel \
 rust-fax_derive+default-devel \
 "
RDEPENDS:rust-fax-devel = " \
 cargo \
 rust \
 "
