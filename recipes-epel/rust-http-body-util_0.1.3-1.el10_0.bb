# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-http-body-util"
PV = "0.1.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-http-body-util+channel-devel \
 rust-http-body-util+default-devel \
 rust-http-body-util+full-devel \
 rust-http-body-util-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-http-body-util-0.1.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ff50aa09a87c6e50aef524862b4bd98298d8b4027451efae7a10000073b1148"

URI_x86_64_v2_rust-http-body-util+channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-body-util+channel-devel-0.1.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-body-util+channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-body-util+channel-devel}"
SRC_URI[x86_64_v2_rust-http-body-util+channel-devel.sha256sum] = "20330e52665d3f28994b44d0fc02b2481ce621b5aefd1bac10753b1bc42f541e"

URI_x86_64_v2_rust-http-body-util+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-body-util+default-devel-0.1.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-body-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-body-util+default-devel}"
SRC_URI[x86_64_v2_rust-http-body-util+default-devel.sha256sum] = "03742e26a9406bec80162f0a8b6f7091faf59d338436e1f18c28264282149baa"

URI_x86_64_v2_rust-http-body-util+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-body-util+full-devel-0.1.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-body-util+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-body-util+full-devel}"
SRC_URI[x86_64_v2_rust-http-body-util+full-devel.sha256sum] = "13cff39e9fcbeb7a448355ebb7a10240d8a913e92512a3c40ea78325337b688d"

URI_x86_64_v2_rust-http-body-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-body-util-devel-0.1.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-body-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-body-util-devel}"
SRC_URI[x86_64_v2_rust-http-body-util-devel.sha256sum] = "5ade3a7e0abbdec1eba1e197aa9db0cedda49a7222208dde785d07de1bfeb5ce"

URI_aarch64_rust-http-body-util+channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-body-util+channel-devel-0.1.3-1.el10_0.noarch.rpm;name=aarch64_rust-http-body-util+channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-body-util+channel-devel}"
SRC_URI[aarch64_rust-http-body-util+channel-devel.sha256sum] = "c9ee007cac1e2da87b5aaf7d26307aeed9050afc9ca854f8585a65ac55ec4932"

URI_aarch64_rust-http-body-util+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-body-util+default-devel-0.1.3-1.el10_0.noarch.rpm;name=aarch64_rust-http-body-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-body-util+default-devel}"
SRC_URI[aarch64_rust-http-body-util+default-devel.sha256sum] = "4948cf20c95fb579212ee841d21ac6ee9a145359e2e43cc21b9124a88d595e22"

URI_aarch64_rust-http-body-util+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-body-util+full-devel-0.1.3-1.el10_0.noarch.rpm;name=aarch64_rust-http-body-util+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-body-util+full-devel}"
SRC_URI[aarch64_rust-http-body-util+full-devel.sha256sum] = "7e1c80024d5f84a7c5323b46bd605d7fb108c710bd898680ecb046ef118e4792"

URI_aarch64_rust-http-body-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-body-util-devel-0.1.3-1.el10_0.noarch.rpm;name=aarch64_rust-http-body-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-body-util-devel}"
SRC_URI[aarch64_rust-http-body-util-devel.sha256sum] = "1f78915190cf1d65e52c8d8c599540acd60b9562f16dcd55754c678fe8741db1"

RDEPENDS:rust-http-body-util+channel-devel = " \
 cargo \
 rust-http-body-util-devel \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 "
RDEPENDS:rust-http-body-util+default-devel = " \
 cargo \
 rust-http-body-util-devel \
 "
RDEPENDS:rust-http-body-util+full-devel = " \
 cargo \
 rust-http-body-util+channel-devel \
 rust-http-body-util-devel \
 "
RDEPENDS:rust-http-body-util-devel = " \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-futures-core-devel \
 rust-http+default-devel \
 rust-http-body+default-devel \
 rust-pin-project-lite+default-devel \
 "
