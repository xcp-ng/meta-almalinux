# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-pierrec-cmdflag"
PV = "0.0.2"
PR = "16.el10_0"
PACKAGES = " \
 golang-github-pierrec-cmdflag-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-pierrec-cmdflag-0.0.2-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6180d1e7d65f7881fe6dd48a7c80a42044bcd575cd89d6cac294639f016d759d"

URI_x86_64_v2_golang-github-pierrec-cmdflag-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-pierrec-cmdflag-devel-0.0.2-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-pierrec-cmdflag-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-pierrec-cmdflag-devel}"
SRC_URI[x86_64_v2_golang-github-pierrec-cmdflag-devel.sha256sum] = "eb47a304e37b2baa9183d549913058c97608b47ee9742e28dfa719e79af90463"

URI_aarch64_golang-github-pierrec-cmdflag-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-pierrec-cmdflag-devel-0.0.2-16.el10_0.noarch.rpm;name=aarch64_golang-github-pierrec-cmdflag-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-pierrec-cmdflag-devel}"
SRC_URI[aarch64_golang-github-pierrec-cmdflag-devel.sha256sum] = "66efd40bf1d235bb5c4da11f586d74f8933c34ebc07a443f6e188d5a93639a35"

RDEPENDS:golang-github-pierrec-cmdflag-devel = " \
 go-filesystem \
 "
