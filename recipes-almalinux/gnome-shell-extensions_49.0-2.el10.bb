# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-shell-extensions"
PV = "49.0"
PR = "2.el10"
PACKAGES = " \
 gnome-classic-session \
 gnome-shell-extension-apps-menu \
 gnome-shell-extension-auto-move-windows \
 gnome-shell-extension-classification-banner \
 gnome-shell-extension-common \
 gnome-shell-extension-custom-menu \
 gnome-shell-extension-desktop-icons \
 gnome-shell-extension-drive-menu \
 gnome-shell-extension-gesture-inhibitor \
 gnome-shell-extension-heads-up-display \
 gnome-shell-extension-launch-new-instance \
 gnome-shell-extension-light-style \
 gnome-shell-extension-native-window-placement \
 gnome-shell-extension-places-menu \
 gnome-shell-extension-screenshot-window-sizer \
 gnome-shell-extension-status-icons \
 gnome-shell-extension-system-monitor \
 gnome-shell-extension-user-theme \
 gnome-shell-extension-window-list \
 gnome-shell-extension-windowsNavigator \
 gnome-shell-extension-workspace-indicator \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-shell-extensions-49.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f5826e53499e4111e6f337500825713a086a01308e0db3680ce03eca48a56982"

URI_x86_64_v2_gnome-classic-session = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-classic-session-49.0-2.el10.noarch.rpm;name=x86_64_v2_gnome-classic-session;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-classic-session}"
SRC_URI[x86_64_v2_gnome-classic-session.sha256sum] = "bf415551af94369ab8e867e3aa5e1a4da10f68ea337a2426e8d8a0df7ff1c310"

URI_x86_64_v2_gnome-shell-extension-apps-menu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-apps-menu-49.0-2.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-apps-menu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-apps-menu}"
SRC_URI[x86_64_v2_gnome-shell-extension-apps-menu.sha256sum] = "faf1029b0d75c3ec3b422f297a240f548bcce861f53a2c92c811fe58a0020911"

URI_x86_64_v2_gnome-shell-extension-auto-move-windows = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-auto-move-windows-49.0-2.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-auto-move-windows;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-auto-move-windows}"
SRC_URI[x86_64_v2_gnome-shell-extension-auto-move-windows.sha256sum] = "da9eb80b86bfc8c3511b4bcba977f1e32dfde8e86979fddf67cd50f70eec9f4b"

URI_x86_64_v2_gnome-shell-extension-classification-banner = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-classification-banner-49.0-2.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-classification-banner;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-classification-banner}"
SRC_URI[x86_64_v2_gnome-shell-extension-classification-banner.sha256sum] = "0903d199d1fc9fe4bd71fefd074fd219d837300caeeabf581840a0509f5ac0de"

URI_x86_64_v2_gnome-shell-extension-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-common-49.0-2.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-common}"
SRC_URI[x86_64_v2_gnome-shell-extension-common.sha256sum] = "e60d3adf1a33b2b2f26bd40b4b3aa896617950205dacaed9875566b9391118f7"

URI_x86_64_v2_gnome-shell-extension-custom-menu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-custom-menu-49.0-2.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-custom-menu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-custom-menu}"
SRC_URI[x86_64_v2_gnome-shell-extension-custom-menu.sha256sum] = "fd06802b06ecb50470d016b26d220cbb013939a992ef240d6ee1654b686707b9"

URI_x86_64_v2_gnome-shell-extension-desktop-icons = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-desktop-icons-49.0-2.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-desktop-icons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-desktop-icons}"
SRC_URI[x86_64_v2_gnome-shell-extension-desktop-icons.sha256sum] = "c602ed4e32ca878c0cf0d3b8732b498601962feff6fc10714914e2db3b7f1dce"

URI_x86_64_v2_gnome-shell-extension-drive-menu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-drive-menu-49.0-2.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-drive-menu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-drive-menu}"
SRC_URI[x86_64_v2_gnome-shell-extension-drive-menu.sha256sum] = "10ef9bd3f396c37e568f68b61de25a0876dd0c4cf467d03d6b423b23ba47dc9d"

URI_x86_64_v2_gnome-shell-extension-gesture-inhibitor = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-gesture-inhibitor-49.0-2.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-gesture-inhibitor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-gesture-inhibitor}"
SRC_URI[x86_64_v2_gnome-shell-extension-gesture-inhibitor.sha256sum] = "b9401c19f459e5289755535299b03814d319be4c9b3a068a40ddefc04d7acc75"

URI_x86_64_v2_gnome-shell-extension-heads-up-display = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-heads-up-display-49.0-2.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-heads-up-display;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-heads-up-display}"
SRC_URI[x86_64_v2_gnome-shell-extension-heads-up-display.sha256sum] = "deb6caed20b9d1de638007557bfde0b68d9c945e28330925b22699f70e870f80"

URI_x86_64_v2_gnome-shell-extension-launch-new-instance = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-launch-new-instance-49.0-2.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-launch-new-instance;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-launch-new-instance}"
SRC_URI[x86_64_v2_gnome-shell-extension-launch-new-instance.sha256sum] = "f88f2bec4cd88f18f7656b4bf3d5f71a7436b4004ea2db6a4fea34149d58eb7a"

URI_x86_64_v2_gnome-shell-extension-light-style = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-light-style-49.0-2.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-light-style;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-light-style}"
SRC_URI[x86_64_v2_gnome-shell-extension-light-style.sha256sum] = "e0d6c8451ea5244c795188201e27a59746bf0e2706c33fb5489b907bef724050"

URI_x86_64_v2_gnome-shell-extension-native-window-placement = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-native-window-placement-49.0-2.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-native-window-placement;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-native-window-placement}"
SRC_URI[x86_64_v2_gnome-shell-extension-native-window-placement.sha256sum] = "dbaaab023916656ee44cd549d17e9f183e4d43584b697306bfa117ba744c3b66"

URI_x86_64_v2_gnome-shell-extension-places-menu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-places-menu-49.0-2.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-places-menu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-places-menu}"
SRC_URI[x86_64_v2_gnome-shell-extension-places-menu.sha256sum] = "447daa1b234e177d4905703afcf23cab27ecf4eb92f23333677ba6b334cf12c6"

URI_x86_64_v2_gnome-shell-extension-screenshot-window-sizer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-screenshot-window-sizer-49.0-2.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-screenshot-window-sizer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-screenshot-window-sizer}"
SRC_URI[x86_64_v2_gnome-shell-extension-screenshot-window-sizer.sha256sum] = "820b91da1f59c5738f92ecdee7d8b42d937227532c77f3874ebe04fb1090ce82"

URI_x86_64_v2_gnome-shell-extension-status-icons = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-status-icons-49.0-2.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-status-icons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-status-icons}"
SRC_URI[x86_64_v2_gnome-shell-extension-status-icons.sha256sum] = "d1cd8087994914fc111d69634ce5d1a6eaa2733c7b03ec4d45c7318f938adbda"

URI_x86_64_v2_gnome-shell-extension-system-monitor = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-system-monitor-49.0-2.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-system-monitor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-system-monitor}"
SRC_URI[x86_64_v2_gnome-shell-extension-system-monitor.sha256sum] = "953750673a9af85ef376072fb72bf70c4b02d6a507fc84c3fa45a3618ba75daf"

URI_x86_64_v2_gnome-shell-extension-user-theme = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-user-theme-49.0-2.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-user-theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-user-theme}"
SRC_URI[x86_64_v2_gnome-shell-extension-user-theme.sha256sum] = "254a3de98094a549b63d5f898eebe7dbaa3c431d5b18b96c4e98752f74531163"

URI_x86_64_v2_gnome-shell-extension-window-list = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-window-list-49.0-2.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-window-list;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-window-list}"
SRC_URI[x86_64_v2_gnome-shell-extension-window-list.sha256sum] = "30e57ce7addafa45922838983c85e470aeb70310c8aeb688c1674be6a39c7579"

URI_x86_64_v2_gnome-shell-extension-windowsNavigator = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-windowsNavigator-49.0-2.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-windowsNavigator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-windowsNavigator}"
SRC_URI[x86_64_v2_gnome-shell-extension-windowsNavigator.sha256sum] = "383f837242d7668ffd0fa6d83a06eb3e81748efeaf47bc2bedc0a90e12faaa81"

URI_x86_64_v2_gnome-shell-extension-workspace-indicator = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-workspace-indicator-49.0-2.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-workspace-indicator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-workspace-indicator}"
SRC_URI[x86_64_v2_gnome-shell-extension-workspace-indicator.sha256sum] = "e81e2064663c6b6f54436e7d98f12b32ce6c94988fd4171bda5621e6f6fae930"

URI_aarch64_gnome-classic-session = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-classic-session-49.0-2.el10.noarch.rpm;name=aarch64_gnome-classic-session;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-classic-session}"
SRC_URI[aarch64_gnome-classic-session.sha256sum] = "bf415551af94369ab8e867e3aa5e1a4da10f68ea337a2426e8d8a0df7ff1c310"

URI_aarch64_gnome-shell-extension-apps-menu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-apps-menu-49.0-2.el10.noarch.rpm;name=aarch64_gnome-shell-extension-apps-menu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-apps-menu}"
SRC_URI[aarch64_gnome-shell-extension-apps-menu.sha256sum] = "faf1029b0d75c3ec3b422f297a240f548bcce861f53a2c92c811fe58a0020911"

URI_aarch64_gnome-shell-extension-auto-move-windows = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-auto-move-windows-49.0-2.el10.noarch.rpm;name=aarch64_gnome-shell-extension-auto-move-windows;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-auto-move-windows}"
SRC_URI[aarch64_gnome-shell-extension-auto-move-windows.sha256sum] = "da9eb80b86bfc8c3511b4bcba977f1e32dfde8e86979fddf67cd50f70eec9f4b"

URI_aarch64_gnome-shell-extension-classification-banner = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-classification-banner-49.0-2.el10.noarch.rpm;name=aarch64_gnome-shell-extension-classification-banner;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-classification-banner}"
SRC_URI[aarch64_gnome-shell-extension-classification-banner.sha256sum] = "0903d199d1fc9fe4bd71fefd074fd219d837300caeeabf581840a0509f5ac0de"

URI_aarch64_gnome-shell-extension-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-common-49.0-2.el10.noarch.rpm;name=aarch64_gnome-shell-extension-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-common}"
SRC_URI[aarch64_gnome-shell-extension-common.sha256sum] = "e60d3adf1a33b2b2f26bd40b4b3aa896617950205dacaed9875566b9391118f7"

URI_aarch64_gnome-shell-extension-custom-menu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-custom-menu-49.0-2.el10.noarch.rpm;name=aarch64_gnome-shell-extension-custom-menu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-custom-menu}"
SRC_URI[aarch64_gnome-shell-extension-custom-menu.sha256sum] = "fd06802b06ecb50470d016b26d220cbb013939a992ef240d6ee1654b686707b9"

URI_aarch64_gnome-shell-extension-desktop-icons = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-desktop-icons-49.0-2.el10.noarch.rpm;name=aarch64_gnome-shell-extension-desktop-icons;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-desktop-icons}"
SRC_URI[aarch64_gnome-shell-extension-desktop-icons.sha256sum] = "c602ed4e32ca878c0cf0d3b8732b498601962feff6fc10714914e2db3b7f1dce"

URI_aarch64_gnome-shell-extension-drive-menu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-drive-menu-49.0-2.el10.noarch.rpm;name=aarch64_gnome-shell-extension-drive-menu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-drive-menu}"
SRC_URI[aarch64_gnome-shell-extension-drive-menu.sha256sum] = "10ef9bd3f396c37e568f68b61de25a0876dd0c4cf467d03d6b423b23ba47dc9d"

URI_aarch64_gnome-shell-extension-gesture-inhibitor = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-gesture-inhibitor-49.0-2.el10.noarch.rpm;name=aarch64_gnome-shell-extension-gesture-inhibitor;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-gesture-inhibitor}"
SRC_URI[aarch64_gnome-shell-extension-gesture-inhibitor.sha256sum] = "b9401c19f459e5289755535299b03814d319be4c9b3a068a40ddefc04d7acc75"

URI_aarch64_gnome-shell-extension-heads-up-display = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-heads-up-display-49.0-2.el10.noarch.rpm;name=aarch64_gnome-shell-extension-heads-up-display;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-heads-up-display}"
SRC_URI[aarch64_gnome-shell-extension-heads-up-display.sha256sum] = "deb6caed20b9d1de638007557bfde0b68d9c945e28330925b22699f70e870f80"

URI_aarch64_gnome-shell-extension-launch-new-instance = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-launch-new-instance-49.0-2.el10.noarch.rpm;name=aarch64_gnome-shell-extension-launch-new-instance;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-launch-new-instance}"
SRC_URI[aarch64_gnome-shell-extension-launch-new-instance.sha256sum] = "f88f2bec4cd88f18f7656b4bf3d5f71a7436b4004ea2db6a4fea34149d58eb7a"

URI_aarch64_gnome-shell-extension-light-style = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-light-style-49.0-2.el10.noarch.rpm;name=aarch64_gnome-shell-extension-light-style;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-light-style}"
SRC_URI[aarch64_gnome-shell-extension-light-style.sha256sum] = "e0d6c8451ea5244c795188201e27a59746bf0e2706c33fb5489b907bef724050"

URI_aarch64_gnome-shell-extension-native-window-placement = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-native-window-placement-49.0-2.el10.noarch.rpm;name=aarch64_gnome-shell-extension-native-window-placement;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-native-window-placement}"
SRC_URI[aarch64_gnome-shell-extension-native-window-placement.sha256sum] = "dbaaab023916656ee44cd549d17e9f183e4d43584b697306bfa117ba744c3b66"

URI_aarch64_gnome-shell-extension-places-menu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-places-menu-49.0-2.el10.noarch.rpm;name=aarch64_gnome-shell-extension-places-menu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-places-menu}"
SRC_URI[aarch64_gnome-shell-extension-places-menu.sha256sum] = "447daa1b234e177d4905703afcf23cab27ecf4eb92f23333677ba6b334cf12c6"

URI_aarch64_gnome-shell-extension-screenshot-window-sizer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-screenshot-window-sizer-49.0-2.el10.noarch.rpm;name=aarch64_gnome-shell-extension-screenshot-window-sizer;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-screenshot-window-sizer}"
SRC_URI[aarch64_gnome-shell-extension-screenshot-window-sizer.sha256sum] = "820b91da1f59c5738f92ecdee7d8b42d937227532c77f3874ebe04fb1090ce82"

URI_aarch64_gnome-shell-extension-status-icons = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-status-icons-49.0-2.el10.noarch.rpm;name=aarch64_gnome-shell-extension-status-icons;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-status-icons}"
SRC_URI[aarch64_gnome-shell-extension-status-icons.sha256sum] = "d1cd8087994914fc111d69634ce5d1a6eaa2733c7b03ec4d45c7318f938adbda"

URI_aarch64_gnome-shell-extension-system-monitor = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-system-monitor-49.0-2.el10.noarch.rpm;name=aarch64_gnome-shell-extension-system-monitor;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-system-monitor}"
SRC_URI[aarch64_gnome-shell-extension-system-monitor.sha256sum] = "953750673a9af85ef376072fb72bf70c4b02d6a507fc84c3fa45a3618ba75daf"

URI_aarch64_gnome-shell-extension-user-theme = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-user-theme-49.0-2.el10.noarch.rpm;name=aarch64_gnome-shell-extension-user-theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-user-theme}"
SRC_URI[aarch64_gnome-shell-extension-user-theme.sha256sum] = "254a3de98094a549b63d5f898eebe7dbaa3c431d5b18b96c4e98752f74531163"

URI_aarch64_gnome-shell-extension-window-list = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-window-list-49.0-2.el10.noarch.rpm;name=aarch64_gnome-shell-extension-window-list;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-window-list}"
SRC_URI[aarch64_gnome-shell-extension-window-list.sha256sum] = "30e57ce7addafa45922838983c85e470aeb70310c8aeb688c1674be6a39c7579"

URI_aarch64_gnome-shell-extension-windowsNavigator = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-windowsNavigator-49.0-2.el10.noarch.rpm;name=aarch64_gnome-shell-extension-windowsNavigator;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-windowsNavigator}"
SRC_URI[aarch64_gnome-shell-extension-windowsNavigator.sha256sum] = "383f837242d7668ffd0fa6d83a06eb3e81748efeaf47bc2bedc0a90e12faaa81"

URI_aarch64_gnome-shell-extension-workspace-indicator = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-workspace-indicator-49.0-2.el10.noarch.rpm;name=aarch64_gnome-shell-extension-workspace-indicator;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-workspace-indicator}"
SRC_URI[aarch64_gnome-shell-extension-workspace-indicator.sha256sum] = "e81e2064663c6b6f54436e7d98f12b32ce6c94988fd4171bda5621e6f6fae930"

RDEPENDS:gnome-classic-session = " \
 gnome-shell-extension-apps-menu \
 gnome-shell-extension-launch-new-instance \
 gnome-shell-extension-places-menu \
 gnome-shell-extension-window-list \
 nautilus \
 "
RDEPENDS:gnome-shell-extension-apps-menu = " \
 gnome-menus \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-auto-move-windows = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-classification-banner = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-common = " \
 gnome-shell \
 "
RDEPENDS:gnome-shell-extension-custom-menu = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-desktop-icons = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-drive-menu = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-gesture-inhibitor = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-heads-up-display = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-launch-new-instance = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-light-style = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-native-window-placement = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-places-menu = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-screenshot-window-sizer = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-status-icons = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-system-monitor = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-user-theme = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-window-list = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-windowsNavigator = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-workspace-indicator = " \
 gnome-shell-extension-common \
 "
