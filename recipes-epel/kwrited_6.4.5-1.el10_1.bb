# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kwrited"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 kwrited \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kwrited-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a60063824ed3ee822396d49da453443a405395d747de4b00d61774fb64220e9c"

URI_x86_64_v2_kwrited = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwrited-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwrited;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwrited}"
SRC_URI[x86_64_v2_kwrited.sha256sum] = "f80e3b9afc6c2af32bce6678a35c5974bc7f058f507a0eb45a5bfabe0a112eef"

URI_aarch64_kwrited = "${EPEL_MIRROR}/aarch64/Packages/k/kwrited-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_kwrited;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwrited}"
SRC_URI[aarch64_kwrited.sha256sum] = "653670ab6e09e0b6dd70e9cbd2090760ee79ea8180648c74f754f1fcd331f3b2"

RDEPENDS:kwrited = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-knotifications \
 kf6-kpty \
 libstdc++ \
 qt6-qtbase \
 "
