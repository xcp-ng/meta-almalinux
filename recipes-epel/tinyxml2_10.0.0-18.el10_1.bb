# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tinyxml2"
PV = "10.0.0"
PR = "18.el10_1"
PACKAGES = " \
 tinyxml2 \
 tinyxml2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tinyxml2-10.0.0-18.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb3b0ed0c2a2d89e2f323efd64e3c77e0d72f66497f894833fed1794cd87f7f9"

URI_x86_64_v2_tinyxml2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tinyxml2-10.0.0-18.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tinyxml2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tinyxml2}"
SRC_URI[x86_64_v2_tinyxml2.sha256sum] = "b1abf583ac3bd7fefc4c547d86b24ae0c16bac72c6f3a51374cc94718f9aee10"

URI_x86_64_v2_tinyxml2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tinyxml2-devel-10.0.0-18.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tinyxml2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tinyxml2-devel}"
SRC_URI[x86_64_v2_tinyxml2-devel.sha256sum] = "4e5d6fb9a7f368e9fe25a3e939edad3f44ff7ce037687e362d127604ac04d037"

URI_aarch64_tinyxml2 = "${EPEL_MIRROR}/aarch64/Packages/t/tinyxml2-10.0.0-18.el10_1.aarch64.rpm;name=aarch64_tinyxml2;unpack=0"
SRC_URI:append = " ${URI_aarch64_tinyxml2}"
SRC_URI[aarch64_tinyxml2.sha256sum] = "2cf68677807ce0a4d094da7d1886b641f2302e2a8415548f69f2c2f4fc9565de"

URI_aarch64_tinyxml2-devel = "${EPEL_MIRROR}/aarch64/Packages/t/tinyxml2-devel-10.0.0-18.el10_1.aarch64.rpm;name=aarch64_tinyxml2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_tinyxml2-devel}"
SRC_URI[aarch64_tinyxml2-devel.sha256sum] = "223cd9b92be847cc58b89dc703c3f23ddab14100db4d6f24e866552bd05df2a5"

RDEPENDS:tinyxml2 = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:tinyxml2-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 tinyxml2 \
 "
