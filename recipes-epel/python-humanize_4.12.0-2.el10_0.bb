# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-humanize"
PV = "4.12.0"
PR = "2.el10_0"
PACKAGES = " \
 python3-humanize \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-humanize-4.12.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6019a04e0f8433b65d2fd8d2c62b927919165a0e3afb2c7109d9c82fd3e7fb00"

URI_x86_64_v2_python3-humanize = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-humanize-4.12.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-humanize;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-humanize}"
SRC_URI[x86_64_v2_python3-humanize.sha256sum] = "66e874ba0124b98198a4446ed568e2c77d8d668b07fa4828061a154d9a852e2f"

URI_aarch64_python3-humanize = "${EPEL_MIRROR}/aarch64/Packages/p/python3-humanize-4.12.0-2.el10_0.noarch.rpm;name=aarch64_python3-humanize;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-humanize}"
SRC_URI[aarch64_python3-humanize.sha256sum] = "ba19f21e34af84fc87a4799214cc424930e8ba0525a29b67fe5ff3a6def380f9"

RDEPENDS:python3-humanize = " \
 python3 \
 "
