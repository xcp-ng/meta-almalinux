# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zlib-rs"
PV = "0.6.8"
PR = "1.el10_3"
PACKAGES = " \
 rust-zlib-rs+__internal-api-devel \
 rust-zlib-rs+avx512-devel \
 rust-zlib-rs+c-allocator-devel \
 rust-zlib-rs+default-devel \
 rust-zlib-rs+lsx-devel \
 rust-zlib-rs+rust-allocator-devel \
 rust-zlib-rs+std-devel \
 rust-zlib-rs+vpclmulqdq-devel \
 rust-zlib-rs-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-zlib-rs-0.6.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c0d56908ecde5a1ce8da701f640bb09d05853bbfdeef6c8f38df26f07f330bb8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+__internal-api-devel-0.6.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+__internal-api-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zlib-rs+__internal-api-devel.sha256sum] = "9e7463bee43e330ca37c8233c907db8f924b5586b31867ca12a099a5ee5e6254"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+avx512-devel-0.6.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+avx512-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zlib-rs+avx512-devel.sha256sum] = "11947c0fffd8b6f5fb26ba563c322277e305a989ecd77f90b430456a0a52e8bf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+c-allocator-devel-0.6.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+c-allocator-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zlib-rs+c-allocator-devel.sha256sum] = "d28a07672c1ffce44659d4fe6e38bc1ee3d22d136fdf0344dc290c66d0f32dc8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+default-devel-0.6.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zlib-rs+default-devel.sha256sum] = "a4c1f5b75dfc0db1268181136d2d054e0a2e167667beee2066ec6f570e34e4fa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+lsx-devel-0.6.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+lsx-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zlib-rs+lsx-devel.sha256sum] = "99d895e5b115ebbdb0865af8f5b9fbda0a7de67d581c4df79a74bded810dc5f5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+rust-allocator-devel-0.6.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+rust-allocator-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zlib-rs+rust-allocator-devel.sha256sum] = "c45425a9ec24d18073819cd9d608bc4d4b72fb6e3aef2698256cb97b60675835"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+std-devel-0.6.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zlib-rs+std-devel.sha256sum] = "e05721371e851d3ca82e1edc3ea7e63c06ff7aa6509489d355fabadbd7b7defc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs+vpclmulqdq-devel-0.6.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs+vpclmulqdq-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zlib-rs+vpclmulqdq-devel.sha256sum] = "c683e2119d12bbe75c478283b044b91e8a5a03b68b8095061f305c644edb217d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zlib-rs-devel-0.6.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zlib-rs-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zlib-rs-devel.sha256sum] = "4b360731c2d92c5b3a6a03709e05fd27fee2b7d3df546e51cf5ebae98eb59d56"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+__internal-api-devel-0.6.8-1.el10_3.noarch.rpm;name=aarch64_rust-zlib-rs+__internal-api-devel;unpack=0"
SRC_URI[aarch64_rust-zlib-rs+__internal-api-devel.sha256sum] = "52ab10c8d8edbdee510b908dba56096702a3f34443f16204f020570cbae2178a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+avx512-devel-0.6.8-1.el10_3.noarch.rpm;name=aarch64_rust-zlib-rs+avx512-devel;unpack=0"
SRC_URI[aarch64_rust-zlib-rs+avx512-devel.sha256sum] = "03721d214a5334495b0911a5fdfb83ed48e01f4c356d26d31017f79e0811a250"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+c-allocator-devel-0.6.8-1.el10_3.noarch.rpm;name=aarch64_rust-zlib-rs+c-allocator-devel;unpack=0"
SRC_URI[aarch64_rust-zlib-rs+c-allocator-devel.sha256sum] = "b479fa9cd8427f9442002f088323d464ffc1c6eb06cf5ea01ccb173d19ac39aa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+default-devel-0.6.8-1.el10_3.noarch.rpm;name=aarch64_rust-zlib-rs+default-devel;unpack=0"
SRC_URI[aarch64_rust-zlib-rs+default-devel.sha256sum] = "4aac2d72e4355cd9693939f3aa32c2962873fc8d86978e334be2fa4f7d7fb200"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+lsx-devel-0.6.8-1.el10_3.noarch.rpm;name=aarch64_rust-zlib-rs+lsx-devel;unpack=0"
SRC_URI[aarch64_rust-zlib-rs+lsx-devel.sha256sum] = "ed43b7ddc2914eb27add7376d3d4f4cbc9ea3c0f9a69f3de38c567e0b8ffd377"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+rust-allocator-devel-0.6.8-1.el10_3.noarch.rpm;name=aarch64_rust-zlib-rs+rust-allocator-devel;unpack=0"
SRC_URI[aarch64_rust-zlib-rs+rust-allocator-devel.sha256sum] = "46bf63a491291e77d39d6df40bf0a1d912fd27812b67a5f85166d4b547cbc50e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+std-devel-0.6.8-1.el10_3.noarch.rpm;name=aarch64_rust-zlib-rs+std-devel;unpack=0"
SRC_URI[aarch64_rust-zlib-rs+std-devel.sha256sum] = "cc801624b5a00c34dccc4ecfbbc797721298879487aa3f3a83ba8e72107ae112"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs+vpclmulqdq-devel-0.6.8-1.el10_3.noarch.rpm;name=aarch64_rust-zlib-rs+vpclmulqdq-devel;unpack=0"
SRC_URI[aarch64_rust-zlib-rs+vpclmulqdq-devel.sha256sum] = "38cb2a71c64b7839da74920ff85b145b48bde6f09b57adc68a73caec901a3a91"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zlib-rs-devel-0.6.8-1.el10_3.noarch.rpm;name=aarch64_rust-zlib-rs-devel;unpack=0"
SRC_URI[aarch64_rust-zlib-rs-devel.sha256sum] = "3324f5c9bc8d43f1279f4b18e3fa531386996e817c24a51599998bc91e9e32a0"

RDEPENDS:rust-zlib-rs+__internal-api-devel = " \
 cargo \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs+avx512-devel = " \
 cargo \
 rust-zlib-rs+vpclmulqdq-devel \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs+c-allocator-devel = " \
 cargo \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs+default-devel = " \
 cargo \
 rust-zlib-rs+c-allocator-devel \
 rust-zlib-rs+std-devel \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs+lsx-devel = " \
 cargo \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs+rust-allocator-devel = " \
 cargo \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs+std-devel = " \
 cargo \
 rust-zlib-rs+rust-allocator-devel \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs+vpclmulqdq-devel = " \
 cargo \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-zlib-rs-devel = " \
 cargo \
 rust \
 "
