# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "coturn"
PV = "4.18.0"
PR = "1.el10_3"
PACKAGES = " \
 coturn \
 coturn-client-devel \
 coturn-client-libs \
 coturn-utils \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/coturn-4.18.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c3f8dd7fd53fea2cff0d5c6117ec0b2090b1c778dff8c2e94a281933790bf36e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/coturn-4.18.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_coturn;unpack=0"
SRC_URI[x86_64_v2_coturn.sha256sum] = "65164a32c902410f1903a8030fd87c5d80a3e7f3c7dcbc212687ba27de94ffd8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/coturn-client-devel-4.18.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_coturn-client-devel;unpack=0"
SRC_URI[x86_64_v2_coturn-client-devel.sha256sum] = "68eb73b5ece0685b2a27c272d392d6a4a7f5ce4e8a3b4d3be977b31ad7d46fb9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/coturn-client-libs-4.18.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_coturn-client-libs;unpack=0"
SRC_URI[x86_64_v2_coturn-client-libs.sha256sum] = "e4222395116ce426dc40f8dff0b769605e60100aab8e86ef6d9c33a2e775f0ab"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/coturn-utils-4.18.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_coturn-utils;unpack=0"
SRC_URI[x86_64_v2_coturn-utils.sha256sum] = "27174259298278df8b6c14ef395f2a9ba9824aaea3310eef01fa1fec9664e232"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/coturn-4.18.0-1.el10_3.aarch64.rpm;name=aarch64_coturn;unpack=0"
SRC_URI[aarch64_coturn.sha256sum] = "48e95bf8a696578204b3d69adcad5502a1870c77c55941257edfefaf9d7d676d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/coturn-client-devel-4.18.0-1.el10_3.aarch64.rpm;name=aarch64_coturn-client-devel;unpack=0"
SRC_URI[aarch64_coturn-client-devel.sha256sum] = "0c6f00f9cfcf8b1bc5486d54f2e272d0e4476062d91c2a953a7d85ae0b8c7191"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/coturn-client-libs-4.18.0-1.el10_3.aarch64.rpm;name=aarch64_coturn-client-libs;unpack=0"
SRC_URI[aarch64_coturn-client-libs.sha256sum] = "fa23877a0fa6d4b035089983c118aa9395d366be849712fe527f8c9294f69614"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/coturn-utils-4.18.0-1.el10_3.aarch64.rpm;name=aarch64_coturn-utils;unpack=0"
SRC_URI[aarch64_coturn-utils.sha256sum] = "62cfcb90ceb35d2478745efeb313b5f98d2af38b5f733dffc0760bfacee83a97"

RDEPENDS:coturn = " \
 bash \
 glibc \
 hiredis \
 libevent \
 libmicrohttpd \
 libpq \
 mariadb-connector-c \
 openssl-libs \
 shadow-utils \
 sqlite-libs \
 systemd \
 systemd-libs \
 "
RDEPENDS:coturn-client-devel = " \
 "
RDEPENDS:coturn-client-libs = " \
 "
RDEPENDS:coturn-utils = " \
 glibc \
 libevent \
 openssl-libs \
 "
