# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-jinzhu-inflection"
PV = "1.0.0"
PR = "12.el10_0"
PACKAGES = " \
 golang-github-jinzhu-inflection-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-jinzhu-inflection-1.0.0-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a5a1129371afa5392d9e11281ad7d7aa58ba97eebd1202fdf59969db146ddfc"

URI_x86_64_v2_golang-github-jinzhu-inflection-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-jinzhu-inflection-devel-1.0.0-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-jinzhu-inflection-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-jinzhu-inflection-devel}"
SRC_URI[x86_64_v2_golang-github-jinzhu-inflection-devel.sha256sum] = "48cb9751882ba8c8b225aa4d6de80ba3540d7c8b5e66811a7a66dbd59b1ecbd5"

URI_aarch64_golang-github-jinzhu-inflection-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-jinzhu-inflection-devel-1.0.0-12.el10_0.noarch.rpm;name=aarch64_golang-github-jinzhu-inflection-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-jinzhu-inflection-devel}"
SRC_URI[aarch64_golang-github-jinzhu-inflection-devel.sha256sum] = "e79012af77b352bfcb5b821507c5dbb0170bc11ad9a9783471ecbd5fa6542079"

RDEPENDS:golang-github-jinzhu-inflection-devel = " \
 go-filesystem \
 "
