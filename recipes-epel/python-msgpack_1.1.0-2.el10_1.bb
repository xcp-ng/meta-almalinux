# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-msgpack"
PV = "1.1.0"
PR = "2.el10_1"
PACKAGES = " \
 python3-msgpack \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-msgpack-1.1.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dbfc2ceace1aab0de66f7d9446acd27066713025ca58a52b51b55a4126f9cb19"

URI_x86_64_v2_python3-msgpack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-msgpack-1.1.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-msgpack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-msgpack}"
SRC_URI[x86_64_v2_python3-msgpack.sha256sum] = "b4214655dd4fb4795207d31405ab01ca087fdebdd495c2dd787e463634a07fdb"

URI_aarch64_python3-msgpack = "${EPEL_MIRROR}/aarch64/Packages/p/python3-msgpack-1.1.0-2.el10_1.aarch64.rpm;name=aarch64_python3-msgpack;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-msgpack}"
SRC_URI[aarch64_python3-msgpack.sha256sum] = "1143dd626e8d37a9a02a73ca87f94547de117683d424d1918cc2d1ca147c3b01"

RDEPENDS:python3-msgpack = " \
 glibc \
 python3 \
 "
