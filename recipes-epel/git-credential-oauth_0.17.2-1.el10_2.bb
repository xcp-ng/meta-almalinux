# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "git-credential-oauth"
PV = "0.17.2"
PR = "1.el10_2"
PACKAGES = " \
 git-credential-oauth \
 golang-github-hickford-git-credential-oauth-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/git-credential-oauth-0.17.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6c36cf34aba8d5e938f3ea1ad45302a6113593de11ae70c202e6f6d3ac6d532"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - golang-github-hickford-git-credential-oauth-devel: golang(rsc.io/qr)

URI_x86_64_v2_git-credential-oauth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/git-credential-oauth-0.17.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_git-credential-oauth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-credential-oauth}"
SRC_URI[x86_64_v2_git-credential-oauth.sha256sum] = "4598f2d10892c1b4c75dc52dbd97a6599f515410b705d9bb7f9830492cac7f78"

URI_x86_64_v2_golang-github-hickford-git-credential-oauth-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-hickford-git-credential-oauth-devel-0.17.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-hickford-git-credential-oauth-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-hickford-git-credential-oauth-devel}"
SRC_URI[x86_64_v2_golang-github-hickford-git-credential-oauth-devel.sha256sum] = "9b50f573e64d0d8ba31321a26370a5d3181756f1c15ec55807ce01894a9552f7"

URI_aarch64_git-credential-oauth = "${EPEL_MIRROR}/aarch64/Packages/g/git-credential-oauth-0.17.2-1.el10_2.aarch64.rpm;name=aarch64_git-credential-oauth;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-credential-oauth}"
SRC_URI[aarch64_git-credential-oauth.sha256sum] = "bdb228b9cbdc26083bc091638dbf06ed7c1533eeea476e2db03d7cd57bf74ab2"

URI_aarch64_golang-github-hickford-git-credential-oauth-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-hickford-git-credential-oauth-devel-0.17.2-1.el10_2.noarch.rpm;name=aarch64_golang-github-hickford-git-credential-oauth-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-hickford-git-credential-oauth-devel}"
SRC_URI[aarch64_golang-github-hickford-git-credential-oauth-devel.sha256sum] = "d548cf4dfea4d8c9ee01fbfb857bb2d9304db7fd988e1439db9fd018f7b333ec"

RDEPENDS:git-credential-oauth = " \
 glibc \
 "
RDEPENDS:golang-github-hickford-git-credential-oauth-devel:x86_64_v2 = " \
 go-filesystem \
 golang-x-oauth2-devel \
"
RDEPENDS:golang-github-hickford-git-credential-oauth-devel:aarch64 = " \
 go-filesystem \
 golang-rsc-qr-devel \
 golang-x-oauth2-devel \
"
