# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_ignored"
PV = "0.1.14"
PR = "1.el10_2"
PACKAGES = " \
 rust-serde_ignored+default-devel \
 rust-serde_ignored-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_ignored-0.1.14-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a897b8cab7494f028fd1e81d289db2914480da03e3eebec6f206a13b0da8352"

URI_x86_64_v2_rust-serde_ignored+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_ignored+default-devel-0.1.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_ignored+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_ignored+default-devel}"
SRC_URI[x86_64_v2_rust-serde_ignored+default-devel.sha256sum] = "170febd9f52fbfa4a2454180c757272dde3863738819e4fd484aaa9da1a8958b"

URI_x86_64_v2_rust-serde_ignored-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_ignored-devel-0.1.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_ignored-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_ignored-devel}"
SRC_URI[x86_64_v2_rust-serde_ignored-devel.sha256sum] = "081c5924e0c45300b84c4d5e4d725ba553f03fe6a3a33085dcffc56c86dd1f20"

URI_aarch64_rust-serde_ignored+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_ignored+default-devel-0.1.14-1.el10_2.noarch.rpm;name=aarch64_rust-serde_ignored+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_ignored+default-devel}"
SRC_URI[aarch64_rust-serde_ignored+default-devel.sha256sum] = "04992ada8510eb0584e0b3ae2298341db43f5459d2d44b22a6e55c7ded947e6c"

URI_aarch64_rust-serde_ignored-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_ignored-devel-0.1.14-1.el10_2.noarch.rpm;name=aarch64_rust-serde_ignored-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_ignored-devel}"
SRC_URI[aarch64_rust-serde_ignored-devel.sha256sum] = "7ac6518926f9266096f3b0dcbc4b81b88949bc3d72b4e9f4b9d1d7d3c15ba208"

RDEPENDS:rust-serde_ignored+default-devel = " \
 cargo \
 rust-serde_ignored-devel \
 "
RDEPENDS:rust-serde_ignored-devel = " \
 cargo \
 rust \
 rust-serde-devel \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 "
