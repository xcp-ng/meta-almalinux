# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "granatier"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 granatier \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/granatier-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "29fbe9b031c8f964821d59e2da48c0330d3b2f3fbe51ac65cbc9682a7074fdde"

URI_x86_64_v2_granatier = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/granatier-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_granatier;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_granatier}"
SRC_URI[x86_64_v2_granatier.sha256sum] = "5b9bd89074ecc44762eaeea467329101176102335dc452186636950722c70947"

URI_aarch64_granatier = "${EPEL_MIRROR}/aarch64/Packages/g/granatier-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_granatier;unpack=0"
SRC_URI:append = " ${URI_aarch64_granatier}"
SRC_URI[aarch64_granatier.sha256sum] = "95eba93f7aaa4c970558cb232419181cfa5b5fbe88164dd7025b52d788732ee7"

RDEPENDS:granatier = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
