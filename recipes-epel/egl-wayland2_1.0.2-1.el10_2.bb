# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "egl-wayland2"
PV = "1.0.2"
PR = "1.el10_2"
PACKAGES = " \
 egl-wayland2 \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/e/egl-wayland2-1.0.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3f143f4482fb72de69c26397a5605c755e04ed78dade293b67719eade68c82fe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/egl-wayland2-1.0.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_egl-wayland2;unpack=0"
SRC_URI[x86_64_v2_egl-wayland2.sha256sum] = "8d4903df5da1164c956b390b4c8d8ac491582cf3d4dde071b7b616baf6d76135"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/e/egl-wayland2-1.0.2-1.el10_2.aarch64.rpm;name=aarch64_egl-wayland2;unpack=0"
SRC_URI[aarch64_egl-wayland2.sha256sum] = "3182c15a4e66cb58e4becc0461cd04788ffb0af022c109102f9a15f1f6a1904f"

RDEPENDS:egl-wayland2 = " \
 glibc \
 libdrm \
 libglvnd-egl \
 libwayland-client \
 mesa-libgbm \
 "
