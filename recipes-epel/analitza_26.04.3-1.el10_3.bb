# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "analitza"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 analitza \
 analitza-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/analitza-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe558295702ac4ba442f53af21925d73a8149de7c3ae3f717df2c3b2b57bb033"

URI_x86_64_v2_analitza = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/analitza-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_analitza;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_analitza}"
SRC_URI[x86_64_v2_analitza.sha256sum] = "ba01c9f23cd7258f2a8691a0aeadc21c6aba5b03c135c63b749a8cd9560c620c"

URI_x86_64_v2_analitza-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/analitza-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_analitza-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_analitza-devel}"
SRC_URI[x86_64_v2_analitza-devel.sha256sum] = "401e92a1cf2207c12ed155f53a84916d068baaed258420e58b41ce11fdb80fab"

URI_aarch64_analitza = "${EPEL_MIRROR}/aarch64/Packages/a/analitza-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_analitza;unpack=0"
SRC_URI:append = " ${URI_aarch64_analitza}"
SRC_URI[aarch64_analitza.sha256sum] = "ef39f9203433652c296c230ec3060f66667acccdfa935d3883ec28b4441abe69"

URI_aarch64_analitza-devel = "${EPEL_MIRROR}/aarch64/Packages/a/analitza-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_analitza-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_analitza-devel}"
SRC_URI[aarch64_analitza-devel.sha256sum] = "7ba0d6ddda3002d9d915257feb627dbbd80b6432c5a36eb2d5c01c39e12fa712"

RDEPENDS:analitza = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 "
RDEPENDS:analitza-devel = " \
 analitza \
 cmake-filesystem \
 "
