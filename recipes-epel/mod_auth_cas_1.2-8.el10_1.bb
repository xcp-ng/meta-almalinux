# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mod_auth_cas"
PV = "1.2"
PR = "8.el10_1"
PACKAGES = " \
 mod_auth_cas \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mod_auth_cas-1.2-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f6e09485bbe2d8540dc5d2c936f0a503246e09eae04fa08b11c33b05cdb829e"

URI_x86_64_v2_mod_auth_cas = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mod_auth_cas-1.2-8.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mod_auth_cas;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_auth_cas}"
SRC_URI[x86_64_v2_mod_auth_cas.sha256sum] = "46626b46561ac652eaae569fa3c1578c9f90807967386c794c0a35edff7ed868"

URI_aarch64_mod_auth_cas = "${EPEL_MIRROR}/aarch64/Packages/m/mod_auth_cas-1.2-8.el10_1.aarch64.rpm;name=aarch64_mod_auth_cas;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_auth_cas}"
SRC_URI[aarch64_mod_auth_cas.sha256sum] = "2cc52bdeae4e437640ff1ecf3b8e33e4133dac17b5c8e69688282827bd72596f"

RDEPENDS:mod_auth_cas = " \
 glibc \
 httpd-core \
 mod_ssl \
 openssl-libs \
 pcre2 \
 virtual/libcurl.so.4___64bit_ \
 "
