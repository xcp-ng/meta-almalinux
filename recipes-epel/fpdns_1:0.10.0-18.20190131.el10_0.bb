# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fpdns"
PE = "1"
PV = "0.10.0"
PR = "18.20190131.el10_0"
PACKAGES = " \
 fpdns \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fpdns-0.10.0-18.20190131.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ba081137c12126bd0bd17957b1ae33aa4d03f64b48b5f57af3e383f6c47516bb"

URI_x86_64_v2_fpdns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fpdns-0.10.0-18.20190131.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fpdns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fpdns}"
SRC_URI[x86_64_v2_fpdns.sha256sum] = "0786670e8216cf0295aaeae9f6249ca877c6170eeb61b55233ae2d2bf09afba4"

URI_aarch64_fpdns = "${EPEL_MIRROR}/aarch64/Packages/f/fpdns-0.10.0-18.20190131.el10_0.noarch.rpm;name=aarch64_fpdns;unpack=0"
SRC_URI:append = " ${URI_aarch64_fpdns}"
SRC_URI[aarch64_fpdns.sha256sum] = "94552e41808fb2491fdc5a351537fb7caaf8a281dcfab788fd73e25ee68cd019"

RDEPENDS:fpdns = " \
 fpdns \
 perl-Getopt-Std \
 perl-Net-DNS \
 perl-POSIX \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
