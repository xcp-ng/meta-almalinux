# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-pack"
PV = "0.60.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-pack+default-devel \
 rust-gix-pack+document-features-devel \
 rust-gix-pack+generate-devel \
 rust-gix-pack+object-cache-dynamic-devel \
 rust-gix-pack+pack-cache-lru-dynamic-devel \
 rust-gix-pack+pack-cache-lru-static-devel \
 rust-gix-pack+serde-devel \
 rust-gix-pack+streaming-input-devel \
 rust-gix-pack-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-pack-0.60.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe04a28b3bd254c2d6faa0404a3fec71cde6eb8e85ecd152de46f00bb4f771f4"

URI_x86_64_v2_rust-gix-pack+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+default-devel-0.60.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+default-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+default-devel.sha256sum] = "8eb4e4725a58bf0b3343af4d622768628f8a932ca3961bc53cb56a8d29712c0f"

URI_x86_64_v2_rust-gix-pack+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+document-features-devel-0.60.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+document-features-devel.sha256sum] = "fabe8c3ddc75bc87e2480203daca0be138b600a7a3baa1ab38cb7f10626c4889"

URI_x86_64_v2_rust-gix-pack+generate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+generate-devel-0.60.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+generate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+generate-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+generate-devel.sha256sum] = "a464ef10ea6b9ee01d20ab598021c2d83f7860eaa41127837312089db8a169cc"

URI_x86_64_v2_rust-gix-pack+object-cache-dynamic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+object-cache-dynamic-devel-0.60.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+object-cache-dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+object-cache-dynamic-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+object-cache-dynamic-devel.sha256sum] = "b5030c962da7d5b09300c6ab3654e0cb1b653c3f0bb980ae418e0302bf819060"

URI_x86_64_v2_rust-gix-pack+pack-cache-lru-dynamic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+pack-cache-lru-dynamic-devel-0.60.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+pack-cache-lru-dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+pack-cache-lru-dynamic-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+pack-cache-lru-dynamic-devel.sha256sum] = "84d53e51e5095e1a43d13ce4334c17f7140f97b7184d0d316d57cbe9096b5e92"

URI_x86_64_v2_rust-gix-pack+pack-cache-lru-static-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+pack-cache-lru-static-devel-0.60.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+pack-cache-lru-static-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+pack-cache-lru-static-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+pack-cache-lru-static-devel.sha256sum] = "a78cbcb749362b819a90c5092f794053acd1f1a117ba0ab73156406370bab2b7"

URI_x86_64_v2_rust-gix-pack+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+serde-devel-0.60.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+serde-devel.sha256sum] = "63e3b9d73ad66bc333405193547c7aa5070c4ddd7f6e43ebb149b4d8a2054ac9"

URI_x86_64_v2_rust-gix-pack+streaming-input-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+streaming-input-devel-0.60.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+streaming-input-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+streaming-input-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+streaming-input-devel.sha256sum] = "df6bda6ac3caf0067c1c52c4cd14908333b6e38d9889f18c1f1894cf5acf62ee"

URI_x86_64_v2_rust-gix-pack-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack-devel-0.60.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack-devel}"
SRC_URI[x86_64_v2_rust-gix-pack-devel.sha256sum] = "cc2572a15371480f06e98ed13fd4f6a3c5830dd439dad83c556e5bd5d4fdb9df"

URI_aarch64_rust-gix-pack+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+default-devel-0.60.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-pack+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+default-devel}"
SRC_URI[aarch64_rust-gix-pack+default-devel.sha256sum] = "5d848909fcdd512b91e17ba84f1ce2d9133dc3a0059ba396b1d18ed63d1b2a06"

URI_aarch64_rust-gix-pack+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+document-features-devel-0.60.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-pack+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+document-features-devel}"
SRC_URI[aarch64_rust-gix-pack+document-features-devel.sha256sum] = "809f0f279f9def8cf938ce89e050d51ec54155d93a64d231d619483f7e89800f"

URI_aarch64_rust-gix-pack+generate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+generate-devel-0.60.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-pack+generate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+generate-devel}"
SRC_URI[aarch64_rust-gix-pack+generate-devel.sha256sum] = "5c8477fbd81b3bcfab5b3b29f8672801f785e9254f2fe00e4153806996cfa414"

URI_aarch64_rust-gix-pack+object-cache-dynamic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+object-cache-dynamic-devel-0.60.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-pack+object-cache-dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+object-cache-dynamic-devel}"
SRC_URI[aarch64_rust-gix-pack+object-cache-dynamic-devel.sha256sum] = "681b24d18601807533d67b0a4eba040a5f1eff8d14fc6dd2593b92b0771d43a7"

URI_aarch64_rust-gix-pack+pack-cache-lru-dynamic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+pack-cache-lru-dynamic-devel-0.60.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-pack+pack-cache-lru-dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+pack-cache-lru-dynamic-devel}"
SRC_URI[aarch64_rust-gix-pack+pack-cache-lru-dynamic-devel.sha256sum] = "cddc9939a32dadc8cc4234132e4db12fd6d3e5d5e2b43ddde7644a9d435dd1b6"

URI_aarch64_rust-gix-pack+pack-cache-lru-static-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+pack-cache-lru-static-devel-0.60.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-pack+pack-cache-lru-static-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+pack-cache-lru-static-devel}"
SRC_URI[aarch64_rust-gix-pack+pack-cache-lru-static-devel.sha256sum] = "c7948553b80fb6614089d0b56499b212c84be97787aae53a412e957f6224bbbd"

URI_aarch64_rust-gix-pack+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+serde-devel-0.60.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-pack+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+serde-devel}"
SRC_URI[aarch64_rust-gix-pack+serde-devel.sha256sum] = "4fb96c7341fc6479fd96731b11eccdb2263d2484da385bd48cc6f0febb51ed68"

URI_aarch64_rust-gix-pack+streaming-input-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+streaming-input-devel-0.60.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-pack+streaming-input-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+streaming-input-devel}"
SRC_URI[aarch64_rust-gix-pack+streaming-input-devel.sha256sum] = "c2493c98ac4740f24786d0befe86b25804a078b619bfad881fefb84810fd1870"

URI_aarch64_rust-gix-pack-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack-devel-0.60.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-pack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack-devel}"
SRC_URI[aarch64_rust-gix-pack-devel.sha256sum] = "9eef13cd8e1a72f2ea04093fb875fc4a72e9d1d794341f0e9d94ed2ee8328548"

RDEPENDS:rust-gix-pack+default-devel = " \
 cargo \
 rust-gix-pack+generate-devel \
 rust-gix-pack+streaming-input-devel \
 rust-gix-pack-devel \
 "
RDEPENDS:rust-gix-pack+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-pack-devel \
 "
RDEPENDS:rust-gix-pack+generate-devel = " \
 cargo \
 rust-gix-diff-devel \
 rust-gix-hashtable+default-devel \
 rust-gix-pack-devel \
 rust-gix-traverse+default-devel \
 rust-parking_lot-devel \
 "
RDEPENDS:rust-gix-pack+object-cache-dynamic-devel = " \
 cargo \
 rust-clru+default-devel \
 rust-gix-hashtable+default-devel \
 rust-gix-pack-devel \
 "
RDEPENDS:rust-gix-pack+pack-cache-lru-dynamic-devel = " \
 cargo \
 rust-clru+default-devel \
 rust-gix-pack-devel \
 "
RDEPENDS:rust-gix-pack+pack-cache-lru-static-devel = " \
 cargo \
 rust-gix-pack-devel \
 rust-uluru+default-devel \
 "
RDEPENDS:rust-gix-pack+serde-devel = " \
 cargo \
 rust-gix-object+serde-devel \
 rust-gix-pack-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-pack+streaming-input-devel = " \
 cargo \
 rust-gix-pack-devel \
 rust-gix-tempfile-devel \
 rust-parking_lot-devel \
 "
RDEPENDS:rust-gix-pack-devel = " \
 cargo \
 rust \
 rust-gix-chunk+default-devel \
 rust-gix-features+crc32-devel \
 rust-gix-features+default-devel \
 rust-gix-features+progress-devel \
 rust-gix-features+zlib-devel \
 rust-gix-hash+default-devel \
 rust-gix-object+default-devel \
 rust-gix-path+default-devel \
 rust-memmap2+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 "
