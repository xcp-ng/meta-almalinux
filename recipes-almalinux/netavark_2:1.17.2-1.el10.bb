# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "netavark"
PE = "2"
PV = "1.17.2"
PR = "1.el10"
PACKAGES = " \
 netavark \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/netavark-1.17.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19d3c91c4693d24fc463f0ff00b4f20f8e02e93acfd45ef4869a99ec3a39e9c0"

URI_x86_64_v2_netavark = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/netavark-1.17.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_netavark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netavark}"
SRC_URI[x86_64_v2_netavark.sha256sum] = "eb7e81103172e96ec3135d3544b97928e61f970f68e57abd816afd253dbcc0b1"

URI_aarch64_netavark = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/netavark-1.17.2-1.el10.aarch64.rpm;name=aarch64_netavark;unpack=0"
SRC_URI:append = " ${URI_aarch64_netavark}"
SRC_URI[aarch64_netavark.sha256sum] = "f0a190dff8795c9c7ae9d9819c63f09733ff0f62d09c8e6beb7871edef060add"

RDEPENDS:netavark = " \
 aardvark-dns \
 bash \
 glibc \
 libgcc \
 nftables \
 "
