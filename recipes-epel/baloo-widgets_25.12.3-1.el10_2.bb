# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "baloo-widgets"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 baloo-widgets \
 baloo-widgets-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/baloo-widgets-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d6746a4ed373a93d67f6462b3b506c4f59e87bc02cd52c4e4c13f7e631165dd"

URI_x86_64_v2_baloo-widgets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baloo-widgets-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baloo-widgets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baloo-widgets}"
SRC_URI[x86_64_v2_baloo-widgets.sha256sum] = "c82458f8449401516d19146bc690e51339d07fa613ff498d664763fab17d435f"

URI_x86_64_v2_baloo-widgets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baloo-widgets-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baloo-widgets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baloo-widgets-devel}"
SRC_URI[x86_64_v2_baloo-widgets-devel.sha256sum] = "90d2f3b7069f1eba4d142cda2915f782b0f5f4ca5564efc0bdb05b57d35c6643"

URI_aarch64_baloo-widgets = "${EPEL_MIRROR}/aarch64/Packages/b/baloo-widgets-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_baloo-widgets;unpack=0"
SRC_URI:append = " ${URI_aarch64_baloo-widgets}"
SRC_URI[aarch64_baloo-widgets.sha256sum] = "972cdb7bbfe86c422b61b8f91022e49d4e7284ceb5e3ef2c7faeabd48e128091"

URI_aarch64_baloo-widgets-devel = "${EPEL_MIRROR}/aarch64/Packages/b/baloo-widgets-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_baloo-widgets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_baloo-widgets-devel}"
SRC_URI[aarch64_baloo-widgets-devel.sha256sum] = "65408838e0d1adba02c6e966d5e300612c5e69e5f703a72c08d057d67511dd5d"

RDEPENDS:baloo-widgets = " \
 glibc \
 kf6-baloo-libs \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kservice \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:baloo-widgets-devel = " \
 baloo-widgets \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kf6-kio-devel \
 qt6-qtbase-devel \
 "
