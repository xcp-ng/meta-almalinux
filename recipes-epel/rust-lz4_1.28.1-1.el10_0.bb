# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lz4"
PV = "1.28.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-lz4+default-devel \
 rust-lz4-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lz4-1.28.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3853e5a6f0201111a2a1c55c7897350b14abd5a6bcfaa9eef350643feb5a7436"

URI_x86_64_v2_rust-lz4+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lz4+default-devel-1.28.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lz4+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lz4+default-devel}"
SRC_URI[x86_64_v2_rust-lz4+default-devel.sha256sum] = "99f8b77df79fb9e4dbdc0c8ba20f1f70182bb181cd15c6286e1dbdd86220e3b9"

URI_x86_64_v2_rust-lz4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lz4-devel-1.28.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lz4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lz4-devel}"
SRC_URI[x86_64_v2_rust-lz4-devel.sha256sum] = "2f0842581eb5358fbff0a9e09507c5b7418d211aecc8fb8e5bb3b84844ffdf9a"

URI_aarch64_rust-lz4+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lz4+default-devel-1.28.1-1.el10_0.noarch.rpm;name=aarch64_rust-lz4+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lz4+default-devel}"
SRC_URI[aarch64_rust-lz4+default-devel.sha256sum] = "184814762688d1f39c62a5823dd8f5b13cb51c40b1c21a6cc38326770fe0a5c3"

URI_aarch64_rust-lz4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lz4-devel-1.28.1-1.el10_0.noarch.rpm;name=aarch64_rust-lz4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lz4-devel}"
SRC_URI[aarch64_rust-lz4-devel.sha256sum] = "7792776c834672320e6a8678a39d662fcd73c3091e8d4ed3514f708ff107a149"

RDEPENDS:rust-lz4+default-devel = " \
 cargo \
 rust-lz4-devel \
 "
RDEPENDS:rust-lz4-devel = " \
 cargo \
 rust-lz4-sys+default-devel \
 "
