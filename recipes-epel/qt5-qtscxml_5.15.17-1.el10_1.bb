# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtscxml"
PV = "5.15.17"
PR = "1.el10_1"
PACKAGES = " \
 qt5-qtscxml \
 qt5-qtscxml-devel \
 qt5-qtscxml-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtscxml-5.15.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55510f06f0554ee73bc6936cac4d2380b8a16eac94eb278109c197233cf9f296"

URI_x86_64_v2_qt5-qtscxml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtscxml-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtscxml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtscxml}"
SRC_URI[x86_64_v2_qt5-qtscxml.sha256sum] = "604f24890116d50063188559893eb3d56a6813bd9d8057bb661434d3c6f0c8cb"

URI_x86_64_v2_qt5-qtscxml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtscxml-devel-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtscxml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtscxml-devel}"
SRC_URI[x86_64_v2_qt5-qtscxml-devel.sha256sum] = "7887f7aee31d9f8814b3efa4536dd1acca2989ff42b3939330130e76e30a068f"

URI_x86_64_v2_qt5-qtscxml-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtscxml-examples-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtscxml-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtscxml-examples}"
SRC_URI[x86_64_v2_qt5-qtscxml-examples.sha256sum] = "1cfd6e525b79b8dcb3d914bbcc8ea84abcc1c045eebd8d93228ee968ae3b0a74"

URI_aarch64_qt5-qtscxml = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtscxml-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtscxml;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtscxml}"
SRC_URI[aarch64_qt5-qtscxml.sha256sum] = "e420d86efc8ca0f18942ff6fcf93ab295f1e66fcc2ac22eeab92e3f1798f225c"

URI_aarch64_qt5-qtscxml-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtscxml-devel-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtscxml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtscxml-devel}"
SRC_URI[aarch64_qt5-qtscxml-devel.sha256sum] = "60d5bc07da053ac3d105d73d1f8e80e2d4663efac30926895a349e7750cc8752"

URI_aarch64_qt5-qtscxml-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtscxml-examples-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtscxml-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtscxml-examples}"
SRC_URI[aarch64_qt5-qtscxml-examples.sha256sum] = "ffc27b3500939156f22f7dfd994c7a4355669102ad595493f511e04ec6df06cc"

RDEPENDS:qt5-qtscxml = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtscxml-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtdeclarative-devel \
 qt5-qtscxml \
 "
RDEPENDS:qt5-qtscxml-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtscxml \
 "
