# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openldap-epel"
PV = "2.6.9"
PR = "1.el10_1"
PACKAGES = " \
 openldap-servers \
 openldap-slapi \
 openldap-slapi-compat \
 openldap-slapi-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/openldap-epel-2.6.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d1c95e7eabd4ead3c797f75ee220da6babb04465df5ec421f54560f8b5d0585"

URI_x86_64_v2_openldap-servers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openldap-servers-2.6.9-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openldap-servers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openldap-servers}"
SRC_URI[x86_64_v2_openldap-servers.sha256sum] = "dcf367def8be077323e10810308248af58f6a972a6d9a62b4fee7767cc9af2d7"

URI_x86_64_v2_openldap-slapi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openldap-slapi-2.6.9-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openldap-slapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openldap-slapi}"
SRC_URI[x86_64_v2_openldap-slapi.sha256sum] = "efdb36431ee623099b153a727d7d1eed3a7f5f771d6900c178d60854ae29b8ff"

URI_x86_64_v2_openldap-slapi-compat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openldap-slapi-compat-2.6.9-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openldap-slapi-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openldap-slapi-compat}"
SRC_URI[x86_64_v2_openldap-slapi-compat.sha256sum] = "82ce522679ab472df9fee75d1a5eb76506221916d6ed8bed7576828760765253"

URI_x86_64_v2_openldap-slapi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openldap-slapi-devel-2.6.9-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openldap-slapi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openldap-slapi-devel}"
SRC_URI[x86_64_v2_openldap-slapi-devel.sha256sum] = "cca4e5dbd94ee0d4c888466f14c1bf7848a7ba44fd95cda10d73c58074a2ecfc"

URI_aarch64_openldap-servers = "${EPEL_MIRROR}/aarch64/Packages/o/openldap-servers-2.6.9-1.el10_1.aarch64.rpm;name=aarch64_openldap-servers;unpack=0"
SRC_URI:append = " ${URI_aarch64_openldap-servers}"
SRC_URI[aarch64_openldap-servers.sha256sum] = "ec5f78c2baa34a20997e8a4a7231e0364a778e999e56e969ab198d3950ea4c43"

URI_aarch64_openldap-slapi = "${EPEL_MIRROR}/aarch64/Packages/o/openldap-slapi-2.6.9-1.el10_1.aarch64.rpm;name=aarch64_openldap-slapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_openldap-slapi}"
SRC_URI[aarch64_openldap-slapi.sha256sum] = "8fbb77c176e525cc455f59fe95452f2bde94c8a3456400ba7720c490b8ccf3ed"

URI_aarch64_openldap-slapi-compat = "${EPEL_MIRROR}/aarch64/Packages/o/openldap-slapi-compat-2.6.9-1.el10_1.aarch64.rpm;name=aarch64_openldap-slapi-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_openldap-slapi-compat}"
SRC_URI[aarch64_openldap-slapi-compat.sha256sum] = "28bd0dfa33b231e952dc3649966cdc4c03d935a2cb185a32acb299be5476dd60"

URI_aarch64_openldap-slapi-devel = "${EPEL_MIRROR}/aarch64/Packages/o/openldap-slapi-devel-2.6.9-1.el10_1.aarch64.rpm;name=aarch64_openldap-slapi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openldap-slapi-devel}"
SRC_URI[aarch64_openldap-slapi-devel.sha256sum] = "f1705513e23a3a4d1bac0d175dd86c34fc6b93e589b8f96adb1a5f0c621db213"

RDEPENDS:openldap-servers = " \
 bash \
 cracklib \
 cyrus-sasl-lib \
 glibc \
 libevent \
 libgcc \
 libtool-ltdl \
 libxcrypt \
 openldap \
 openldap-slapi \
 openssl-libs \
 perl-libs \
 shadow-utils \
 systemd \
 "
RDEPENDS:openldap-slapi = " \
 glibc \
 libtool-ltdl \
 "
RDEPENDS:openldap-slapi-compat = " \
 glibc \
 openldap-slapi \
 "
RDEPENDS:openldap-slapi-devel = " \
 openldap-devel \
 openldap-slapi \
 "
