# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libvpl"
PE = "1"
PV = "2.17.0"
PR = "1.el10_3"
PACKAGES:x86_64_v2 = " \
 libvpl \
 libvpl-devel \
 libvpl-samples \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/l/libvpl-2.17.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e4f8b5064c6944fca2b28b11145d8d5b5b3b20e6add7a6ed6b082e930545e19"

URI_x86_64_v2_libvpl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvpl-2.17.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvpl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvpl}"
SRC_URI[x86_64_v2_libvpl.sha256sum] = "b4cbd746d767b6b3f46d86d3f90bd469b9ec057a88a53c5ab6bdc44e34577c2e"

URI_x86_64_v2_libvpl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvpl-devel-2.17.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvpl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvpl-devel}"
SRC_URI[x86_64_v2_libvpl-devel.sha256sum] = "627700c1078876888ef5355cb21118e5f4771580bbe91d5d0eab151f25479889"

URI_x86_64_v2_libvpl-samples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvpl-samples-2.17.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvpl-samples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvpl-samples}"
SRC_URI[x86_64_v2_libvpl-samples.sha256sum] = "b07d855c03e03f968e71f99ba06201639ebd0b6bd6afe72965bb06e58d382efe"

RDEPENDS:libvpl = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libvpl-devel = " \
 cmake-filesystem \
 libvpl \
 pkgconf-pkg-config \
 "
RDEPENDS:libvpl-samples = " \
 libvpl-devel \
 "
