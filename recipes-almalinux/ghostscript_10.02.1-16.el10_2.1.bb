# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghostscript"
PV = "10.02.1"
PR = "16.el10_2.1"
PACKAGES = " \
 ghostscript \
 ghostscript-doc \
 ghostscript-tools-dvipdf \
 ghostscript-tools-fonts \
 ghostscript-tools-printing \
 libgs \
 libgs-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ghostscript-10.02.1-16.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "46b8de125351656514dadf8bdf152de8722b2a599297c282ba94661a3ebc0baf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ghostscript-10.02.1-16.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_ghostscript;unpack=0"
SRC_URI[x86_64_v2_ghostscript.sha256sum] = "bb69b5ae0cdcab758be89385f35e3cd89b7b18b2ad6bbc6b5f74c91429779388"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ghostscript-doc-10.02.1-16.el10_2.1.noarch.rpm;name=x86_64_v2_ghostscript-doc;unpack=0"
SRC_URI[x86_64_v2_ghostscript-doc.sha256sum] = "617175f855bb442ae2b330cea4f12398f5b091a7d462994c072769221b20c59e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ghostscript-tools-dvipdf-10.02.1-16.el10_2.1.noarch.rpm;name=x86_64_v2_ghostscript-tools-dvipdf;unpack=0"
SRC_URI[x86_64_v2_ghostscript-tools-dvipdf.sha256sum] = "1139d94a4afa32b10bc8f970a77e35eb935151274b7492b03b3a62efdee0048d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ghostscript-tools-fonts-10.02.1-16.el10_2.1.noarch.rpm;name=x86_64_v2_ghostscript-tools-fonts;unpack=0"
SRC_URI[x86_64_v2_ghostscript-tools-fonts.sha256sum] = "afeee0186e3b8fc2a1465593bc73b907e5983363ee869023e04bdc397fa74493"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ghostscript-tools-printing-10.02.1-16.el10_2.1.noarch.rpm;name=x86_64_v2_ghostscript-tools-printing;unpack=0"
SRC_URI[x86_64_v2_ghostscript-tools-printing.sha256sum] = "c49fc8445ae5065659355a423f7eff2b5067e08b45ae02b7062620618b3b5cb2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgs-10.02.1-16.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_libgs;unpack=0"
SRC_URI[x86_64_v2_libgs.sha256sum] = "39033d2536635db2dfdbc13c03f03c23f17b448c83328636c9ae784bf0824934"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libgs-devel-10.02.1-16.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_libgs-devel;unpack=0"
SRC_URI[x86_64_v2_libgs-devel.sha256sum] = "085ff0d3591e90b2cea3c60c7178d1ea5835640549d2129ff5a03a11c7c7f6bf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ghostscript-10.02.1-16.el10_2.1.aarch64.rpm;name=aarch64_ghostscript;unpack=0"
SRC_URI[aarch64_ghostscript.sha256sum] = "5802ac306430c40ceb9add2dfd4b9e139dba5423438d957bf9a0f34bc9a99d4d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ghostscript-doc-10.02.1-16.el10_2.1.noarch.rpm;name=aarch64_ghostscript-doc;unpack=0"
SRC_URI[aarch64_ghostscript-doc.sha256sum] = "617175f855bb442ae2b330cea4f12398f5b091a7d462994c072769221b20c59e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ghostscript-tools-dvipdf-10.02.1-16.el10_2.1.noarch.rpm;name=aarch64_ghostscript-tools-dvipdf;unpack=0"
SRC_URI[aarch64_ghostscript-tools-dvipdf.sha256sum] = "1139d94a4afa32b10bc8f970a77e35eb935151274b7492b03b3a62efdee0048d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ghostscript-tools-fonts-10.02.1-16.el10_2.1.noarch.rpm;name=aarch64_ghostscript-tools-fonts;unpack=0"
SRC_URI[aarch64_ghostscript-tools-fonts.sha256sum] = "afeee0186e3b8fc2a1465593bc73b907e5983363ee869023e04bdc397fa74493"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ghostscript-tools-printing-10.02.1-16.el10_2.1.noarch.rpm;name=aarch64_ghostscript-tools-printing;unpack=0"
SRC_URI[aarch64_ghostscript-tools-printing.sha256sum] = "c49fc8445ae5065659355a423f7eff2b5067e08b45ae02b7062620618b3b5cb2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libgs-10.02.1-16.el10_2.1.aarch64.rpm;name=aarch64_libgs;unpack=0"
SRC_URI[aarch64_libgs.sha256sum] = "e1ed48fa891859ddb1303432af862db96c500e5c56a310235a1ff9d813fb140d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libgs-devel-10.02.1-16.el10_2.1.aarch64.rpm;name=aarch64_libgs-devel;unpack=0"
SRC_URI[aarch64_libgs-devel.sha256sum] = "bb1bb7681c4bb0ecb0c617f56d50b29f3d36040e939b84c9a929838eef04cb92"

RDEPENDS:ghostscript = " \
 bash \
 ghostscript-tools-fonts \
 ghostscript-tools-printing \
 glibc \
 jbig2dec-libs \
 libgs \
 "
RDEPENDS:ghostscript-doc = " \
 ghostscript \
 "
RDEPENDS:ghostscript-tools-dvipdf = " \
 bash \
 ghostscript \
 texlive-dvips \
 "
RDEPENDS:ghostscript-tools-fonts = " \
 bash \
 ghostscript \
 "
RDEPENDS:ghostscript-tools-printing = " \
 bash \
 ghostscript \
 "
RDEPENDS:libgs = " \
 adobe-mappings-cmap \
 adobe-mappings-cmap-deprecated \
 adobe-mappings-pdf \
 cups-libs \
 fontconfig \
 freetype \
 glibc \
 google-droid-sans-fonts \
 jbig2dec-libs \
 lcms2 \
 libijs \
 libjpeg-turbo \
 libpaper \
 libpng \
 libtiff \
 openjpeg2 \
 urw-base35-fonts \
 zlib-ng-compat \
 "
RDEPENDS:libgs-devel = " \
 libgs \
 "
