# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "knetwalk"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 knetwalk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/knetwalk-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6ba9552de3d98d7112bd3b279f73474f6509f18b0efc27c06dc3b941f3dc6196"

URI_x86_64_v2_knetwalk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knetwalk-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knetwalk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knetwalk}"
SRC_URI[x86_64_v2_knetwalk.sha256sum] = "ece3f5581a120cf01127d9ae063b8a35019a44722d864e42b59e2641462eb0e5"

URI_aarch64_knetwalk = "${EPEL_MIRROR}/aarch64/Packages/k/knetwalk-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_knetwalk;unpack=0"
SRC_URI:append = " ${URI_aarch64_knetwalk}"
SRC_URI[aarch64_knetwalk.sha256sum] = "a4939bfb5896e308288135717aa988431ced7228e5ca249d4394c73ee6b33c84"

RDEPENDS:knetwalk = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
