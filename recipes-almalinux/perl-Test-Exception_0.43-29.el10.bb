# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-Exception"
PV = "0.43"
PR = "29.el10"
PACKAGES = " \
 perl-Test-Exception \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Test-Exception-0.43-29.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "544ebe14afb64ef41bf9fd18609f781dfda3a828294647ffb63f2a72496a4fc1"

URI_x86_64_v2_perl-Test-Exception = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Test-Exception-0.43-29.el10.noarch.rpm;name=x86_64_v2_perl-Test-Exception;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-Exception}"
SRC_URI[x86_64_v2_perl-Test-Exception.sha256sum] = "f4ef982f6a310b086caa1f251d6c493ae1af219aa2b6974cf611867f1d6271bb"

URI_aarch64_perl-Test-Exception = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Test-Exception-0.43-29.el10.noarch.rpm;name=aarch64_perl-Test-Exception;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-Exception}"
SRC_URI[aarch64_perl-Test-Exception.sha256sum] = "f4ef982f6a310b086caa1f251d6c493ae1af219aa2b6974cf611867f1d6271bb"

RDEPENDS:perl-Test-Exception = " \
 perl-Carp \
 perl-Exporter \
 perl-Sub-Uplevel \
 perl-Test-Simple \
 perl-base \
 perl-libs \
 "
