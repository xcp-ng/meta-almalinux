# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "redhat-rpm-config"
PV = "296"
PR = "1.el10.alma.2"
PACKAGES = " \
 redhat-rpm-config \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/redhat-rpm-config-296-1.el10.alma.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "068e571950295c7dee7c2a7cb7346ed18aa7c90c4d070e3602b3cebfbc3f5bb2"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - redhat-rpm-config: ocaml-srpm-macros

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - redhat-rpm-config: ocaml-srpm-macros

URI_x86_64_v2_redhat-rpm-config = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/redhat-rpm-config-296-1.el10.alma.2.noarch.rpm;name=x86_64_v2_redhat-rpm-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_redhat-rpm-config}"
SRC_URI[x86_64_v2_redhat-rpm-config.sha256sum] = "d8a082597eedfb402afa11285fc1f765a77baa237e968d7ca97bb89091b1cef2"

URI_aarch64_redhat-rpm-config = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/redhat-rpm-config-296-1.el10.alma.2.noarch.rpm;name=aarch64_redhat-rpm-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_redhat-rpm-config}"
SRC_URI[aarch64_redhat-rpm-config.sha256sum] = "d8a082597eedfb402afa11285fc1f765a77baa237e968d7ca97bb89091b1cef2"

RDEPENDS:redhat-rpm-config = " \
 annobin-plugin-gcc \
 bash \
 dwz \
 efi-srpm-macros \
 file \
 findutils \
 fonts-srpm-macros \
 forge-srpm-macros \
 gcc-plugin-annobin \
 go-srpm-macros \
 grep \
 kernel-srpm-macros \
 lua-srpm-macros \
 openblas-srpm-macros \
 package-notes-srpm-macros \
 perl-srpm-macros \
 pyproject-srpm-macros \
 python-srpm-macros \
 qt6-srpm-macros \
 rpm \
 rust-toolset-srpm-macros \
 sed \
 virtual/coreutils \
 zip \
 "
