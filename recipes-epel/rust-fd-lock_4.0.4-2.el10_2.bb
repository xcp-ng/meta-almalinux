# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fd-lock"
PV = "4.0.4"
PR = "2.el10_2"
PACKAGES = " \
 rust-fd-lock+default-devel \
 rust-fd-lock-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fd-lock-4.0.4-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d7ee1457e1425d1390a5b5a075c0fe62fe6437601036a427892268d68a97aa2b"

URI_x86_64_v2_rust-fd-lock+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fd-lock+default-devel-4.0.4-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fd-lock+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fd-lock+default-devel}"
SRC_URI[x86_64_v2_rust-fd-lock+default-devel.sha256sum] = "133c856f3666c9869161a44dbecc1ecc14b2999394639d31be8daccc237bca8e"

URI_x86_64_v2_rust-fd-lock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fd-lock-devel-4.0.4-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fd-lock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fd-lock-devel}"
SRC_URI[x86_64_v2_rust-fd-lock-devel.sha256sum] = "0da6e21d99c75c1f881107591dcd662aa0b939e45d3b3a74020ad5b79c3256e4"

URI_aarch64_rust-fd-lock+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fd-lock+default-devel-4.0.4-2.el10_2.noarch.rpm;name=aarch64_rust-fd-lock+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fd-lock+default-devel}"
SRC_URI[aarch64_rust-fd-lock+default-devel.sha256sum] = "f770d74253acc725ca2477245574e8fe1d461275f97c6afb50e19c03548dec0c"

URI_aarch64_rust-fd-lock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fd-lock-devel-4.0.4-2.el10_2.noarch.rpm;name=aarch64_rust-fd-lock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fd-lock-devel}"
SRC_URI[aarch64_rust-fd-lock-devel.sha256sum] = "8b89066af21dda8e8aec185fb471cea21d67f869e8741c87df9805c4025d74f7"

RDEPENDS:rust-fd-lock+default-devel = " \
 cargo \
 rust-fd-lock-devel \
 "
RDEPENDS:rust-fd-lock-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 rust-rustix+default-devel \
 rust-rustix+fs-devel \
 "
