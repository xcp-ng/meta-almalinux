# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fetchmail"
PV = "6.4.38"
PR = "3.el10"
PACKAGES = " \
 fetchmail \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/fetchmail-6.4.38-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63e7cf0c2cff8fa871ede7086984f11f6ae3f69a251e37c8019351ba88fd0ce8"

URI_x86_64_v2_fetchmail = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fetchmail-6.4.38-3.el10.x86_64_v2.rpm;name=x86_64_v2_fetchmail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fetchmail}"
SRC_URI[x86_64_v2_fetchmail.sha256sum] = "d1182771e4d5cc181048f7ce9bcaa144580c46f45e737f911fb14fe42dde9b3b"

URI_aarch64_fetchmail = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fetchmail-6.4.38-3.el10.aarch64.rpm;name=aarch64_fetchmail;unpack=0"
SRC_URI:append = " ${URI_aarch64_fetchmail}"
SRC_URI[aarch64_fetchmail.sha256sum] = "2b8498da5d25ea9926428da3bc0e5ce9ee630e1d7ebdf88870cffe8e46164446"

RDEPENDS:fetchmail = " \
 glibc \
 krb5-libs \
 libcom_err \
 openssl-libs \
 "
