# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ebook-tools"
PV = "0.2.2"
PR = "28.el10_0"
PACKAGES = " \
 ebook-tools \
 ebook-tools-devel \
 ebook-tools-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/ebook-tools-0.2.2-28.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8728c4bbeb9f68f3b2dc526528fdbef1bc294ecf4e6efe08fd945b142996bd0a"

URI_x86_64_v2_ebook-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ebook-tools-0.2.2-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ebook-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ebook-tools}"
SRC_URI[x86_64_v2_ebook-tools.sha256sum] = "fc3a4890fd168bab608143c3036b7aa5059980eb4aa3ed63cf530128c0401248"

URI_x86_64_v2_ebook-tools-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ebook-tools-devel-0.2.2-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ebook-tools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ebook-tools-devel}"
SRC_URI[x86_64_v2_ebook-tools-devel.sha256sum] = "3f1c05101b822c094c57c98de2f52aef00e88b3a5e56be51cf28f061eaf81502"

URI_x86_64_v2_ebook-tools-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ebook-tools-libs-0.2.2-28.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ebook-tools-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ebook-tools-libs}"
SRC_URI[x86_64_v2_ebook-tools-libs.sha256sum] = "813894eae1cd012242bd1e662ea7ce245118964fac7cfb27407b2c091a3f87a5"

URI_aarch64_ebook-tools = "${EPEL_MIRROR}/aarch64/Packages/e/ebook-tools-0.2.2-28.el10_0.aarch64.rpm;name=aarch64_ebook-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_ebook-tools}"
SRC_URI[aarch64_ebook-tools.sha256sum] = "9212feb50c0aa9d89e8112cdffe0b3ac2d8d24d58462b786f0739d3fcc44fb34"

URI_aarch64_ebook-tools-devel = "${EPEL_MIRROR}/aarch64/Packages/e/ebook-tools-devel-0.2.2-28.el10_0.aarch64.rpm;name=aarch64_ebook-tools-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ebook-tools-devel}"
SRC_URI[aarch64_ebook-tools-devel.sha256sum] = "30ab505f93d9607f9859a147f328bbfc7bfbe9365a40e8e2e33214dfada438b4"

URI_aarch64_ebook-tools-libs = "${EPEL_MIRROR}/aarch64/Packages/e/ebook-tools-libs-0.2.2-28.el10_0.aarch64.rpm;name=aarch64_ebook-tools-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ebook-tools-libs}"
SRC_URI[aarch64_ebook-tools-libs.sha256sum] = "ce1900d543c87587a1a561833a870932c902c0b6eec2c7b411dfa703052534b0"

RDEPENDS:ebook-tools = " \
 ebook-tools-libs \
 glibc \
 "
RDEPENDS:ebook-tools-devel = " \
 ebook-tools-libs \
 "
RDEPENDS:ebook-tools-libs = " \
 glibc \
 libxml2 \
 libzip \
 "
