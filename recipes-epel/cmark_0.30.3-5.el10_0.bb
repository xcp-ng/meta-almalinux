# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cmark"
PV = "0.30.3"
PR = "5.el10_0"
PACKAGES = " \
 cmark \
 cmark-devel \
 cmark-lib \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cmark-0.30.3-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f16bf4f2f34601f5ca0be7a9869c50eb1ef6cad7780c976f947aee58d2a5dc29"

URI_x86_64_v2_cmark = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cmark-0.30.3-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cmark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cmark}"
SRC_URI[x86_64_v2_cmark.sha256sum] = "2ee879938241e955d68f2c38d52acff10c19625bd59cef6c40a0444cdcb6bc81"

URI_x86_64_v2_cmark-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cmark-devel-0.30.3-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cmark-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cmark-devel}"
SRC_URI[x86_64_v2_cmark-devel.sha256sum] = "20541eac2514d1f6aef21d77df34cafcf4a3d0ce2781f578169b74ef118e575a"

URI_x86_64_v2_cmark-lib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cmark-lib-0.30.3-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cmark-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cmark-lib}"
SRC_URI[x86_64_v2_cmark-lib.sha256sum] = "8dc8ecbab73bdb40488e6640e0865dfe4ba5c0477944786b1f944a68e552fcf0"

URI_aarch64_cmark = "${EPEL_MIRROR}/aarch64/Packages/c/cmark-0.30.3-5.el10_0.aarch64.rpm;name=aarch64_cmark;unpack=0"
SRC_URI:append = " ${URI_aarch64_cmark}"
SRC_URI[aarch64_cmark.sha256sum] = "7df60b37c14cf9edce8315f5b75cfd982c993bb1ad0bce454097a05947a848c5"

URI_aarch64_cmark-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cmark-devel-0.30.3-5.el10_0.aarch64.rpm;name=aarch64_cmark-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cmark-devel}"
SRC_URI[aarch64_cmark-devel.sha256sum] = "c441fa2ecece6de1456015527abb17505acaef1cbb4aef7a27fd1e4f73377d0d"

URI_aarch64_cmark-lib = "${EPEL_MIRROR}/aarch64/Packages/c/cmark-lib-0.30.3-5.el10_0.aarch64.rpm;name=aarch64_cmark-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_cmark-lib}"
SRC_URI[aarch64_cmark-lib.sha256sum] = "06231896274ee25bc505015b17bdcfa32113bb5e58c2e0f69503c39b9d66159b"

RDEPENDS:cmark = " \
 cmark-lib \
 glibc \
 "
RDEPENDS:cmark-devel = " \
 cmake-filesystem \
 cmark \
 cmark-lib \
 pkgconf-pkg-config \
 "
RDEPENDS:cmark-lib = " \
 glibc \
 "
