# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zork"
PV = "1.1.0"
PR = "1.el10_3"
PACKAGES = " \
 zork \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/z/zork-1.1.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "188c89e10b5e8c42cdbbf1a53033bff1022cfa807fed2b5810c0110e51c6aa8e"

URI_x86_64_v2_zork = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zork-1.1.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zork;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zork}"
SRC_URI[x86_64_v2_zork.sha256sum] = "94c43e28d21430ad75d2d768a252b1723271bc5ec52d27bec359bb91b659133c"

URI_aarch64_zork = "${EPEL_MIRROR}/aarch64/Packages/z/zork-1.1.0-1.el10_3.aarch64.rpm;name=aarch64_zork;unpack=0"
SRC_URI:append = " ${URI_aarch64_zork}"
SRC_URI[aarch64_zork.sha256sum] = "c1c5d731a85d5e14a8b706aa8f212f3948ace97fe1830e70331f93c89641dd3e"

RDEPENDS:zork = " \
 glibc \
 "
