# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksh"
PE = "3"
PV = "1.0.10"
PR = "8.el10"
PACKAGES = " \
 ksh \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ksh-1.0.10-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a3d5f30979dc8b662a3e12b480ef15041aefa1c0de3c91d305d40eca9e031598"

URI_x86_64_v2_ksh = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ksh-1.0.10-8.el10.x86_64_v2.rpm;name=x86_64_v2_ksh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksh}"
SRC_URI[x86_64_v2_ksh.sha256sum] = "b3517b6c793c214bef88e6a04e47c60a5ccc7ed104ab52ddf11d5f2599cb7867"

URI_aarch64_ksh = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ksh-1.0.10-8.el10.aarch64.rpm;name=aarch64_ksh;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksh}"
SRC_URI[aarch64_ksh.sha256sum] = "c0b7671800121c24715668c0fc0e524244b7ea4e4f582b85832cd254b18d18d7"

RDEPENDS:ksh = " \
 bash \
 diffutils \
 glibc \
 grep \
 sed \
 systemd \
 virtual/coreutils \
 "
