# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libetpan"
PV = "1.9.4"
PR = "19.el10_2"
PACKAGES = " \
 libetpan \
 libetpan-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libetpan-1.9.4-19.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "66624e7b7de81496b6dc39e9540fb179093c1eaaa380a40f6d367f134d532219"

URI_x86_64_v2_libetpan = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libetpan-1.9.4-19.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libetpan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libetpan}"
SRC_URI[x86_64_v2_libetpan.sha256sum] = "50003dc67fbf25dc88824c708ec4160ae4d711236c4545cfa9d89cd2c8864edf"

URI_x86_64_v2_libetpan-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libetpan-devel-1.9.4-19.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libetpan-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libetpan-devel}"
SRC_URI[x86_64_v2_libetpan-devel.sha256sum] = "ec13b06319e186b8bd195a4bc85331799f76c55e2441f4d85e0b19e10c69987e"

URI_aarch64_libetpan = "${EPEL_MIRROR}/aarch64/Packages/l/libetpan-1.9.4-19.el10_2.aarch64.rpm;name=aarch64_libetpan;unpack=0"
SRC_URI:append = " ${URI_aarch64_libetpan}"
SRC_URI[aarch64_libetpan.sha256sum] = "44d77c60964cd0655c8a9ff36fa4f2ac1eab3552e58cc16d0868e2f206e37ccd"

URI_aarch64_libetpan-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libetpan-devel-1.9.4-19.el10_2.aarch64.rpm;name=aarch64_libetpan-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libetpan-devel}"
SRC_URI[aarch64_libetpan-devel.sha256sum] = "051eb732aae52ee6479a8a7602ae1b2fd109c4f3882e6c03d27af5569de53c2c"

RDEPENDS:libetpan = " \
 cyrus-sasl-lib \
 glibc \
 gnutls \
 libdb \
 libgcc \
 liblockfile \
 libstdc++ \
 zlib-ng-compat \
 "
RDEPENDS:libetpan-devel = " \
 libetpan \
 pkgconf-pkg-config \
 "
