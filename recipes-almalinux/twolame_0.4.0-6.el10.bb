# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "twolame"
PV = "0.4.0"
PR = "6.el10"
PACKAGES = " \
 twolame \
 twolame-devel \
 twolame-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/twolame-0.4.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d6ab385342eebcd50588555678aa2a978b949656f98587f7aa946a9488003815"

URI_x86_64_v2_twolame = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/twolame-0.4.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_twolame;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_twolame}"
SRC_URI[x86_64_v2_twolame.sha256sum] = "fd15a332c3fb9b642653f0c7f09c4ea366dffdd179c00811c767501f777cabdc"

URI_x86_64_v2_twolame-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/twolame-devel-0.4.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_twolame-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_twolame-devel}"
SRC_URI[x86_64_v2_twolame-devel.sha256sum] = "2cf81a9df155e3ec509064cb3cc112f371f2805bd4d18e4f8da3b9fe46e1d395"

URI_x86_64_v2_twolame-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/twolame-libs-0.4.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_twolame-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_twolame-libs}"
SRC_URI[x86_64_v2_twolame-libs.sha256sum] = "fe4ce0254d0d6b7d60faa590db9f0558d16a4c3c22e0b060d25ab21470da20fe"

URI_aarch64_twolame = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/twolame-0.4.0-6.el10.aarch64.rpm;name=aarch64_twolame;unpack=0"
SRC_URI:append = " ${URI_aarch64_twolame}"
SRC_URI[aarch64_twolame.sha256sum] = "c73428ded9d3c5d1744d36d184fdcad09ad72c2378f25689065077864e17abcb"

URI_aarch64_twolame-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/twolame-devel-0.4.0-6.el10.aarch64.rpm;name=aarch64_twolame-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_twolame-devel}"
SRC_URI[aarch64_twolame-devel.sha256sum] = "48f1f5e26a6ffe386e6312d0ca3d21dbdc40b1e5be89822557d60ace45969829"

URI_aarch64_twolame-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/twolame-libs-0.4.0-6.el10.aarch64.rpm;name=aarch64_twolame-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_twolame-libs}"
SRC_URI[aarch64_twolame-libs.sha256sum] = "004e111f76ec97c8ab1160262543e6320deec52db8ae67ebc7b15fe27dd7c512"

RDEPENDS:twolame = " \
 glibc \
 libsndfile \
 twolame-libs \
 "
RDEPENDS:twolame-devel = " \
 pkgconf-pkg-config \
 twolame-libs \
 "
RDEPENDS:twolame-libs = " \
 glibc \
 "
