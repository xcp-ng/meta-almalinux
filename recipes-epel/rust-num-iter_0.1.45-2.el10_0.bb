# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num-iter"
PV = "0.1.45"
PR = "2.el10_0"
PACKAGES = " \
 rust-num-iter+default-devel \
 rust-num-iter+i128-devel \
 rust-num-iter+std-devel \
 rust-num-iter-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-num-iter-0.1.45-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "592b29afbb15c0b0abf081a989fb6148f249653d2a5be46b2c3005bbf424cefa"

URI_x86_64_v2_rust-num-iter+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-iter+default-devel-0.1.45-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-iter+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-iter+default-devel}"
SRC_URI[x86_64_v2_rust-num-iter+default-devel.sha256sum] = "ec0126b7ad27e38c5a8f132c9b4bcab383452b73bf3b31e2c2c56915c13ffe52"

URI_x86_64_v2_rust-num-iter+i128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-iter+i128-devel-0.1.45-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-iter+i128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-iter+i128-devel}"
SRC_URI[x86_64_v2_rust-num-iter+i128-devel.sha256sum] = "5535aa3c2b0c1440e54fd798749a20f21852f9330037dc14d4f9bbdb28fac97a"

URI_x86_64_v2_rust-num-iter+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-iter+std-devel-0.1.45-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-iter+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-iter+std-devel}"
SRC_URI[x86_64_v2_rust-num-iter+std-devel.sha256sum] = "17ea4c5126f893e48baf1986f719ecf3f5536a934fa8875d74050bc3657844f8"

URI_x86_64_v2_rust-num-iter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-iter-devel-0.1.45-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-iter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-iter-devel}"
SRC_URI[x86_64_v2_rust-num-iter-devel.sha256sum] = "6c2f207f1e55186e7ba5d566ec9a585eae922a740ac55c2909cdfc41010607b6"

URI_aarch64_rust-num-iter+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-iter+default-devel-0.1.45-2.el10_0.noarch.rpm;name=aarch64_rust-num-iter+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-iter+default-devel}"
SRC_URI[aarch64_rust-num-iter+default-devel.sha256sum] = "e82c0505a2573f4f04c048b33dacb62229d28c9a5bd700b72886c5403fc7606c"

URI_aarch64_rust-num-iter+i128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-iter+i128-devel-0.1.45-2.el10_0.noarch.rpm;name=aarch64_rust-num-iter+i128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-iter+i128-devel}"
SRC_URI[aarch64_rust-num-iter+i128-devel.sha256sum] = "d631f7c928b71d99ea89a20936f24b858687262482adf07cf8f5e6ca952eff02"

URI_aarch64_rust-num-iter+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-iter+std-devel-0.1.45-2.el10_0.noarch.rpm;name=aarch64_rust-num-iter+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-iter+std-devel}"
SRC_URI[aarch64_rust-num-iter+std-devel.sha256sum] = "13335ccaef15d76b31d081af9d384f26b08643485faa68f586af87a9cba9a752"

URI_aarch64_rust-num-iter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-iter-devel-0.1.45-2.el10_0.noarch.rpm;name=aarch64_rust-num-iter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-iter-devel}"
SRC_URI[aarch64_rust-num-iter-devel.sha256sum] = "57594a876a6b182e5b77557f08f90b6198044ea6eb5c45ef08b838bcab7f69c3"

RDEPENDS:rust-num-iter+default-devel = " \
 cargo \
 rust-num-iter+std-devel \
 rust-num-iter-devel \
 "
RDEPENDS:rust-num-iter+i128-devel = " \
 cargo \
 rust-num-iter-devel \
 "
RDEPENDS:rust-num-iter+std-devel = " \
 cargo \
 rust-num-integer+std-devel \
 rust-num-iter-devel \
 rust-num-traits+std-devel \
 "
RDEPENDS:rust-num-iter-devel = " \
 cargo \
 rust \
 rust-autocfg+default-devel \
 rust-num-integer+i128-devel \
 rust-num-integer-devel \
 rust-num-traits+i128-devel \
 rust-num-traits-devel \
 "
