# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-curl-sys"
PV = "0.4.82"
PR = "1.el10_0"
PACKAGES = " \
 rust-curl-sys+default-devel \
 rust-curl-sys+http2-devel \
 rust-curl-sys+ntlm-devel \
 rust-curl-sys+openssl-sys-devel \
 rust-curl-sys+poll_7_68_0-devel \
 rust-curl-sys+protocol-ftp-devel \
 rust-curl-sys+spnego-devel \
 rust-curl-sys+ssl-devel \
 rust-curl-sys+upkeep_7_62_0-devel \
 rust-curl-sys-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-curl-sys-0.4.82-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "72aca5fd929c22af894b769b7a31a4a6ca57dc39d7eafb3c136ef64dca2005b0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+default-devel-0.4.82-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-curl-sys+default-devel.sha256sum] = "1aef4d2fdac300155b0d6f4e41181f91562564cafb4ecca8bb6109dc76ad490f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+http2-devel-0.4.82-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+http2-devel;unpack=0"
SRC_URI[x86_64_v2_rust-curl-sys+http2-devel.sha256sum] = "f32828f2d3828e5d1ce66ea7bf3cfa5f8b2a282749b683f3eeac02729717eda5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+ntlm-devel-0.4.82-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+ntlm-devel;unpack=0"
SRC_URI[x86_64_v2_rust-curl-sys+ntlm-devel.sha256sum] = "f14f1b206fbf820e00ff96d671c24eae6701f2ebbc5a7bf6db6b5d55f0ea407c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+openssl-sys-devel-0.4.82-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+openssl-sys-devel;unpack=0"
SRC_URI[x86_64_v2_rust-curl-sys+openssl-sys-devel.sha256sum] = "4cac9486e1533fdae658e0105242d55a927f39a8cf9a34b574dd7f78dc376e1a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+poll_7_68_0-devel-0.4.82-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+poll_7_68_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-curl-sys+poll_7_68_0-devel.sha256sum] = "d26e93706b07fdd63a08fff27029ba461e7bf36912a328f9ca548604fc5e82db"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+protocol-ftp-devel-0.4.82-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+protocol-ftp-devel;unpack=0"
SRC_URI[x86_64_v2_rust-curl-sys+protocol-ftp-devel.sha256sum] = "7d4befc66b51bc30082262f8d809546ee1c290b73f2ab9b000ab4ff81463d4f4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+spnego-devel-0.4.82-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+spnego-devel;unpack=0"
SRC_URI[x86_64_v2_rust-curl-sys+spnego-devel.sha256sum] = "d417345ddd5ae8e408c32c133c487a5771713355b21b020f00b814d678b5874a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+ssl-devel-0.4.82-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+ssl-devel;unpack=0"
SRC_URI[x86_64_v2_rust-curl-sys+ssl-devel.sha256sum] = "1245a40596540a7740550efa28ec941c088b6403a17e8275648c624ea3ced107"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+upkeep_7_62_0-devel-0.4.82-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+upkeep_7_62_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-curl-sys+upkeep_7_62_0-devel.sha256sum] = "dfef0a65ee496064b89a7a35d90e6387c67c943f27423b58ca18edce4f40596d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys-devel-0.4.82-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys-devel;unpack=0"
SRC_URI[x86_64_v2_rust-curl-sys-devel.sha256sum] = "a66f4ed3b5fc040ceea0483d067fe992d4a4973576bb60715b4b4403b25c474b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+default-devel-0.4.82-1.el10_0.noarch.rpm;name=aarch64_rust-curl-sys+default-devel;unpack=0"
SRC_URI[aarch64_rust-curl-sys+default-devel.sha256sum] = "ced25fc71a8023659e66e506c38f98400ad04753ee92374c57771b314af0fcc6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+http2-devel-0.4.82-1.el10_0.noarch.rpm;name=aarch64_rust-curl-sys+http2-devel;unpack=0"
SRC_URI[aarch64_rust-curl-sys+http2-devel.sha256sum] = "18e58479371329cd71fc1f43441b0eea38139754c9c73d03040f4145024c2239"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+ntlm-devel-0.4.82-1.el10_0.noarch.rpm;name=aarch64_rust-curl-sys+ntlm-devel;unpack=0"
SRC_URI[aarch64_rust-curl-sys+ntlm-devel.sha256sum] = "6140f2aa09a4221c2f9aba142d5c75c8c61f23dc31393317fe7b9eecaaee7a06"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+openssl-sys-devel-0.4.82-1.el10_0.noarch.rpm;name=aarch64_rust-curl-sys+openssl-sys-devel;unpack=0"
SRC_URI[aarch64_rust-curl-sys+openssl-sys-devel.sha256sum] = "1f30d188b37b16fda5bd86a21e6e84ad94d6b48b34723e6284dfa1473d26afed"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+poll_7_68_0-devel-0.4.82-1.el10_0.noarch.rpm;name=aarch64_rust-curl-sys+poll_7_68_0-devel;unpack=0"
SRC_URI[aarch64_rust-curl-sys+poll_7_68_0-devel.sha256sum] = "e2e962e12273b340d0e8345b8b26ad85844fa6d545279d8b40cdbb2378335044"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+protocol-ftp-devel-0.4.82-1.el10_0.noarch.rpm;name=aarch64_rust-curl-sys+protocol-ftp-devel;unpack=0"
SRC_URI[aarch64_rust-curl-sys+protocol-ftp-devel.sha256sum] = "e4d13ff30d13615b50408cd26211790f1cf7a8188a974069bfdbf54e77e2a3b4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+spnego-devel-0.4.82-1.el10_0.noarch.rpm;name=aarch64_rust-curl-sys+spnego-devel;unpack=0"
SRC_URI[aarch64_rust-curl-sys+spnego-devel.sha256sum] = "a70cc12893c92007baf1c7a161f6a2c85f7a889cc7afe077cd0078bdd1e326a9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+ssl-devel-0.4.82-1.el10_0.noarch.rpm;name=aarch64_rust-curl-sys+ssl-devel;unpack=0"
SRC_URI[aarch64_rust-curl-sys+ssl-devel.sha256sum] = "188c31995dee84b50dbc442d8472a9866937e51505b8d38cdfb042871d1c3118"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+upkeep_7_62_0-devel-0.4.82-1.el10_0.noarch.rpm;name=aarch64_rust-curl-sys+upkeep_7_62_0-devel;unpack=0"
SRC_URI[aarch64_rust-curl-sys+upkeep_7_62_0-devel.sha256sum] = "12a15628be6a1af8efec48893a927eca98e0de0d49589950ae15b358d859838d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys-devel-0.4.82-1.el10_0.noarch.rpm;name=aarch64_rust-curl-sys-devel;unpack=0"
SRC_URI[aarch64_rust-curl-sys-devel.sha256sum] = "6a93629dfd9ad6f50a8cc85155c479be8a24cd2c14fca72b7ff90d5d2fc2330f"

RDEPENDS:rust-curl-sys+default-devel = " \
 cargo \
 rust-curl-sys+ssl-devel \
 rust-curl-sys-devel \
 "
RDEPENDS:rust-curl-sys+http2-devel = " \
 cargo \
 rust-curl-sys-devel \
 "
RDEPENDS:rust-curl-sys+ntlm-devel = " \
 cargo \
 rust-curl-sys-devel \
 "
RDEPENDS:rust-curl-sys+openssl-sys-devel = " \
 cargo \
 rust-curl-sys-devel \
 rust-openssl-sys+default-devel \
 "
RDEPENDS:rust-curl-sys+poll_7_68_0-devel = " \
 cargo \
 rust-curl-sys-devel \
 "
RDEPENDS:rust-curl-sys+protocol-ftp-devel = " \
 cargo \
 rust-curl-sys-devel \
 "
RDEPENDS:rust-curl-sys+spnego-devel = " \
 cargo \
 rust-curl-sys-devel \
 "
RDEPENDS:rust-curl-sys+ssl-devel = " \
 cargo \
 rust-curl-sys+openssl-sys-devel \
 rust-curl-sys-devel \
 "
RDEPENDS:rust-curl-sys+upkeep_7_62_0-devel = " \
 cargo \
 rust-curl-sys-devel \
 "
RDEPENDS:rust-curl-sys-devel = " \
 cargo \
 libcurl-devel \
 rust-cc+default-devel \
 rust-libc+default-devel \
 rust-pkg-config+default-devel \
 "
