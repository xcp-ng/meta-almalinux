# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gc"
PV = "8.2.6"
PR = "4.el10_0"
PACKAGES = " \
 gc \
 gc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gc-8.2.6-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6b47c66226cfd43ea8a7322d12916f7545bc6780ebe8e23746ab336bd539794"

URI_x86_64_v2_gc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gc-8.2.6-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gc}"
SRC_URI[x86_64_v2_gc.sha256sum] = "0f185503c6f08693346486729486d53994d815754a831c4887f0cbf47d42a769"

URI_x86_64_v2_gc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gc-devel-8.2.6-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gc-devel}"
SRC_URI[x86_64_v2_gc-devel.sha256sum] = "56b7bc7ec766467d501158ae4696997ccc2772a1ff86f4bb1a555c0404881d84"

URI_aarch64_gc = "${EPEL_MIRROR}/aarch64/Packages/g/gc-8.2.6-4.el10_0.aarch64.rpm;name=aarch64_gc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gc}"
SRC_URI[aarch64_gc.sha256sum] = "8ee403e57543d346717eb87269475c99fbf1b6a46cab5c7770c21413dac923b9"

URI_aarch64_gc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gc-devel-8.2.6-4.el10_0.aarch64.rpm;name=aarch64_gc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gc-devel}"
SRC_URI[aarch64_gc-devel.sha256sum] = "4a9fb9891e1b6dea1d5a8e6ba58d3f465dd416920e97b4b0239fb1b60176175d"

RDEPENDS:gc = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:gc-devel = " \
 gc \
 pkgconf-pkg-config \
 "
