# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-indenter"
PV = "0.3.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-indenter+default-devel \
 rust-indenter+std-devel \
 rust-indenter-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-indenter-0.3.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f5492d7994c0fbfb4c8682c56ed6e74717f0abe14a328ffb6ea9756ede0121fa"

URI_x86_64_v2_rust-indenter+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indenter+default-devel-0.3.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indenter+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indenter+default-devel}"
SRC_URI[x86_64_v2_rust-indenter+default-devel.sha256sum] = "f84322f9c8f1415e092b6ca5fa77198a1b55366c9f6df00ed4970d01b3f15b60"

URI_x86_64_v2_rust-indenter+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indenter+std-devel-0.3.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indenter+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indenter+std-devel}"
SRC_URI[x86_64_v2_rust-indenter+std-devel.sha256sum] = "44fb3c2214f95ef4464809c7cc266432f508b0d29a76713271ca9ad0ecacc707"

URI_x86_64_v2_rust-indenter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indenter-devel-0.3.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indenter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indenter-devel}"
SRC_URI[x86_64_v2_rust-indenter-devel.sha256sum] = "b9ffc3924d55ceeb349a88dc2115e759def4db760140a49be7027a3b504cdf87"

URI_aarch64_rust-indenter+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indenter+default-devel-0.3.4-1.el10_0.noarch.rpm;name=aarch64_rust-indenter+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indenter+default-devel}"
SRC_URI[aarch64_rust-indenter+default-devel.sha256sum] = "f0d5fcf9182d6492cb3da5e91de23db9539ad6f0beb8e8cabdd67597a62b5a0a"

URI_aarch64_rust-indenter+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indenter+std-devel-0.3.4-1.el10_0.noarch.rpm;name=aarch64_rust-indenter+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indenter+std-devel}"
SRC_URI[aarch64_rust-indenter+std-devel.sha256sum] = "6e74c88177f51a35ca0e6330ce2481313473f8bcddc25125e9e44eb5175e0a04"

URI_aarch64_rust-indenter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indenter-devel-0.3.4-1.el10_0.noarch.rpm;name=aarch64_rust-indenter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indenter-devel}"
SRC_URI[aarch64_rust-indenter-devel.sha256sum] = "949978d2005bb2f37000086af241461e60fdaa7550e5f51406720b7b7aaddbda"

RDEPENDS:rust-indenter+default-devel = " \
 cargo \
 rust-indenter-devel \
 "
RDEPENDS:rust-indenter+std-devel = " \
 cargo \
 rust-indenter-devel \
 "
RDEPENDS:rust-indenter-devel = " \
 cargo \
 rust \
 "
