# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_fold"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_fold+default-devel \
 rust-uu_fold-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_fold-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c285b0d4944b32eb0ad4bbca6f9e3205ae030f19aa218a75088f597254be06dd"

URI_x86_64_v2_rust-uu_fold+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_fold+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_fold+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_fold+default-devel}"
SRC_URI[x86_64_v2_rust-uu_fold+default-devel.sha256sum] = "b13e571c5162f2bdf5aba2ef55d9ccba9852626c2d1d7078510b63a9b52c0842"

URI_x86_64_v2_rust-uu_fold-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_fold-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_fold-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_fold-devel}"
SRC_URI[x86_64_v2_rust-uu_fold-devel.sha256sum] = "d283597b71363fd53765fbdfec1d800632b4e2294076a3ea68d055ebdecc2d38"

URI_aarch64_rust-uu_fold+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_fold+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_fold+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_fold+default-devel}"
SRC_URI[aarch64_rust-uu_fold+default-devel.sha256sum] = "0a0cfa6c04cc73db2cf5cae27e1fe44ac13b10c819d5c61897619e915b93fe0d"

URI_aarch64_rust-uu_fold-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_fold-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_fold-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_fold-devel}"
SRC_URI[aarch64_rust-uu_fold-devel.sha256sum] = "0f74de07fc1b3cc36fd04be7c6eaa1d4a479dea9d602cdab16c9e571822532b0"

RDEPENDS:rust-uu_fold+default-devel = " \
 cargo \
 rust-uu_fold-devel \
 "
RDEPENDS:rust-uu_fold-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-unicode-width+default-devel \
 rust-uucore+default-devel \
 "
