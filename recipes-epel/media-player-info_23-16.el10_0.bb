# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "media-player-info"
PV = "23"
PR = "16.el10_0"
PACKAGES = " \
 media-player-info \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/media-player-info-23-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c12cfc45732b9a84926d2f08d63c1da78bac45d6d321b91918c15ecaa1d64f19"

URI_x86_64_v2_media-player-info = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/media-player-info-23-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_media-player-info;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_media-player-info}"
SRC_URI[x86_64_v2_media-player-info.sha256sum] = "9e1c9083f1a4d0ef77b1ff2f30aefbc9ac2f73ed1829988b4c23994bdb2e8036"

URI_aarch64_media-player-info = "${EPEL_MIRROR}/aarch64/Packages/m/media-player-info-23-16.el10_0.noarch.rpm;name=aarch64_media-player-info;unpack=0"
SRC_URI:append = " ${URI_aarch64_media-player-info}"
SRC_URI[aarch64_media-player-info.sha256sum] = "247a0d6b43f0967057e1ee2443aa258ddcf48c9e2384e13bfc37d2b2202adaa8"

RDEPENDS:media-player-info = " \
 systemd-udev \
 "
