# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-schemars0.8"
PV = "0.8.22"
PR = "1.el10_1"
PACKAGES = " \
 rust-schemars0.8+arrayvec07-devel \
 rust-schemars0.8+bigdecimal04-devel \
 rust-schemars0.8+bytes-devel \
 rust-schemars0.8+chrono-devel \
 rust-schemars0.8+default-devel \
 rust-schemars0.8+derive-devel \
 rust-schemars0.8+derive_json_schema-devel \
 rust-schemars0.8+either-devel \
 rust-schemars0.8+enumset-devel \
 rust-schemars0.8+impl_json_schema-devel \
 rust-schemars0.8+indexmap-devel \
 rust-schemars0.8+indexmap1-devel \
 rust-schemars0.8+indexmap2-devel \
 rust-schemars0.8+preserve_order-devel \
 rust-schemars0.8+raw_value-devel \
 rust-schemars0.8+rust_decimal-devel \
 rust-schemars0.8+schemars_derive-devel \
 rust-schemars0.8+semver-devel \
 rust-schemars0.8+smallvec-devel \
 rust-schemars0.8+smol_str-devel \
 rust-schemars0.8+ui_test-devel \
 rust-schemars0.8+url-devel \
 rust-schemars0.8+uuid1-devel \
 rust-schemars0.8-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-schemars0.8-0.8.22-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "51c07e21ded8d883c6805c4d9adae5fb5abbee53ec8c611cccad3d02475b3358"

URI_x86_64_v2_rust-schemars0.8+arrayvec07-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars0.8+arrayvec07-devel-0.8.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars0.8+arrayvec07-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars0.8+arrayvec07-devel}"
SRC_URI[x86_64_v2_rust-schemars0.8+arrayvec07-devel.sha256sum] = "d9d8759593e971dab65fb56b2f9a54914a79e3bfdd34c343bdc36bf2b117c22f"

URI_x86_64_v2_rust-schemars0.8+bigdecimal04-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars0.8+bigdecimal04-devel-0.8.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars0.8+bigdecimal04-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars0.8+bigdecimal04-devel}"
SRC_URI[x86_64_v2_rust-schemars0.8+bigdecimal04-devel.sha256sum] = "3060d20ded986884ede635e15abb3cf379c0fe9ce614a2b90739cfe8c49ab411"

URI_x86_64_v2_rust-schemars0.8+bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars0.8+bytes-devel-0.8.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars0.8+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars0.8+bytes-devel}"
SRC_URI[x86_64_v2_rust-schemars0.8+bytes-devel.sha256sum] = "a36996e361a88fe53a29b1f1a638c80f8856c927f571c5f3e5ad2137ee47020f"

URI_x86_64_v2_rust-schemars0.8+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars0.8+chrono-devel-0.8.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars0.8+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars0.8+chrono-devel}"
SRC_URI[x86_64_v2_rust-schemars0.8+chrono-devel.sha256sum] = "24a379e3ac50547f158f24bcd57f81665dc6e2e358d5e53a49938044d597533e"

URI_x86_64_v2_rust-schemars0.8+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars0.8+default-devel-0.8.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars0.8+default-devel}"
SRC_URI[x86_64_v2_rust-schemars0.8+default-devel.sha256sum] = "a7f82d4383bd65bc879a666a082ac093b82c9d7204ca591f9b80511f4cbe7771"

URI_x86_64_v2_rust-schemars0.8+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars0.8+derive-devel-0.8.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars0.8+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars0.8+derive-devel}"
SRC_URI[x86_64_v2_rust-schemars0.8+derive-devel.sha256sum] = "3d3202443520b9f5f1fe9c5a4a21b4c844d8233759f813a5efbe24fa2175d3ea"

URI_x86_64_v2_rust-schemars0.8+derive_json_schema-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars0.8+derive_json_schema-devel-0.8.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars0.8+derive_json_schema-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars0.8+derive_json_schema-devel}"
SRC_URI[x86_64_v2_rust-schemars0.8+derive_json_schema-devel.sha256sum] = "6698128977f0f5cfdb4bcd82cb19b42eb74b6737348beca9d6a9633d896fd225"

URI_x86_64_v2_rust-schemars0.8+either-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars0.8+either-devel-0.8.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars0.8+either-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars0.8+either-devel}"
SRC_URI[x86_64_v2_rust-schemars0.8+either-devel.sha256sum] = "2d06b55bc5342369e9d9211b7ace6f94b02f4e57ef37847dfbbfcf0a1aa37e52"

URI_x86_64_v2_rust-schemars0.8+enumset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars0.8+enumset-devel-0.8.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars0.8+enumset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars0.8+enumset-devel}"
SRC_URI[x86_64_v2_rust-schemars0.8+enumset-devel.sha256sum] = "7fd49c6fb6122312ecaaf53f80c9e4898537320611e20c5ec26131c98fd26152"

URI_x86_64_v2_rust-schemars0.8+impl_json_schema-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars0.8+impl_json_schema-devel-0.8.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars0.8+impl_json_schema-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars0.8+impl_json_schema-devel}"
SRC_URI[x86_64_v2_rust-schemars0.8+impl_json_schema-devel.sha256sum] = "44d88e3a9a134a4b5961470c5968eeba4993b323da20f902a81a0b68c9cebf5f"

URI_x86_64_v2_rust-schemars0.8+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars0.8+indexmap-devel-0.8.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars0.8+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars0.8+indexmap-devel}"
SRC_URI[x86_64_v2_rust-schemars0.8+indexmap-devel.sha256sum] = "fd37c2cbb0695af9126afbfd7fc2503bb948959e5afa79051e338fe7432deaf7"

URI_x86_64_v2_rust-schemars0.8+indexmap1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars0.8+indexmap1-devel-0.8.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars0.8+indexmap1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars0.8+indexmap1-devel}"
SRC_URI[x86_64_v2_rust-schemars0.8+indexmap1-devel.sha256sum] = "03f36eb909fb023bb8831bf4c3ca558ae9d4284c2e600a2e64c9744fb78ac15a"

URI_x86_64_v2_rust-schemars0.8+indexmap2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars0.8+indexmap2-devel-0.8.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars0.8+indexmap2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars0.8+indexmap2-devel}"
SRC_URI[x86_64_v2_rust-schemars0.8+indexmap2-devel.sha256sum] = "cba4e01b6b95dead6aa61987f12f5fb71bf0fba58d6c146c9321755b12860e5e"

URI_x86_64_v2_rust-schemars0.8+preserve_order-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars0.8+preserve_order-devel-0.8.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars0.8+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars0.8+preserve_order-devel}"
SRC_URI[x86_64_v2_rust-schemars0.8+preserve_order-devel.sha256sum] = "8dd69b6a905abfcbc97033bdb5a20bcf4a996f38b7ce70a3e5f1f398c765a9b1"

URI_x86_64_v2_rust-schemars0.8+raw_value-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars0.8+raw_value-devel-0.8.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars0.8+raw_value-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars0.8+raw_value-devel}"
SRC_URI[x86_64_v2_rust-schemars0.8+raw_value-devel.sha256sum] = "64b0f00a042c9a2a22d9769f4bcae0c5a8c45b43a471f0f44612cdaadc952269"

URI_x86_64_v2_rust-schemars0.8+rust_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars0.8+rust_decimal-devel-0.8.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars0.8+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars0.8+rust_decimal-devel}"
SRC_URI[x86_64_v2_rust-schemars0.8+rust_decimal-devel.sha256sum] = "e1bbc2327ff4c6aff6623a0751aa831138cca0e4cc7fcb87ea1ec84484f7ea0a"

URI_x86_64_v2_rust-schemars0.8+schemars_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars0.8+schemars_derive-devel-0.8.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars0.8+schemars_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars0.8+schemars_derive-devel}"
SRC_URI[x86_64_v2_rust-schemars0.8+schemars_derive-devel.sha256sum] = "525d89658446a7ffd14a9567a422d8694f4cb4a31adc06a676e2a8e3e4aa1787"

URI_x86_64_v2_rust-schemars0.8+semver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars0.8+semver-devel-0.8.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars0.8+semver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars0.8+semver-devel}"
SRC_URI[x86_64_v2_rust-schemars0.8+semver-devel.sha256sum] = "84c5a5d5dc1e154989923d285c80895feaeaeb285db9b517a6b49e430741f5a5"

URI_x86_64_v2_rust-schemars0.8+smallvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars0.8+smallvec-devel-0.8.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars0.8+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars0.8+smallvec-devel}"
SRC_URI[x86_64_v2_rust-schemars0.8+smallvec-devel.sha256sum] = "445efe24f14c8324eb6b4e8bba5830850352f5fc682ae3f069c940dbe883089b"

URI_x86_64_v2_rust-schemars0.8+smol_str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars0.8+smol_str-devel-0.8.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars0.8+smol_str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars0.8+smol_str-devel}"
SRC_URI[x86_64_v2_rust-schemars0.8+smol_str-devel.sha256sum] = "b6d1f3091d496d2f86586b8db50bc0b6aef3c4f52a0688d7981297c66b839eeb"

URI_x86_64_v2_rust-schemars0.8+ui_test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars0.8+ui_test-devel-0.8.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars0.8+ui_test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars0.8+ui_test-devel}"
SRC_URI[x86_64_v2_rust-schemars0.8+ui_test-devel.sha256sum] = "753199cdeaa1d2ac8beca2532956809624a685e1031a6ff16156cd2c7cdb5d5a"

URI_x86_64_v2_rust-schemars0.8+url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars0.8+url-devel-0.8.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars0.8+url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars0.8+url-devel}"
SRC_URI[x86_64_v2_rust-schemars0.8+url-devel.sha256sum] = "9fa5cd85229728f502220038c8a7b9a2f783a2f3e9e04fdd9b0c51a024061894"

URI_x86_64_v2_rust-schemars0.8+uuid1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars0.8+uuid1-devel-0.8.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars0.8+uuid1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars0.8+uuid1-devel}"
SRC_URI[x86_64_v2_rust-schemars0.8+uuid1-devel.sha256sum] = "8109bd01027949cd93cb9ed5513dba0c0cbc9a4b930197b28b9ebb22899c42c0"

URI_x86_64_v2_rust-schemars0.8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars0.8-devel-0.8.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars0.8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars0.8-devel}"
SRC_URI[x86_64_v2_rust-schemars0.8-devel.sha256sum] = "8b1d6599685c4111e6126b474d690bdb2d4bac3a9960affcb395bfb6104a5bbd"

URI_aarch64_rust-schemars0.8+arrayvec07-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars0.8+arrayvec07-devel-0.8.22-1.el10_1.noarch.rpm;name=aarch64_rust-schemars0.8+arrayvec07-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars0.8+arrayvec07-devel}"
SRC_URI[aarch64_rust-schemars0.8+arrayvec07-devel.sha256sum] = "9052a25f4ec82b7dce91c9a200c8daa813861f9a7699b6e2c420b050fb172cae"

URI_aarch64_rust-schemars0.8+bigdecimal04-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars0.8+bigdecimal04-devel-0.8.22-1.el10_1.noarch.rpm;name=aarch64_rust-schemars0.8+bigdecimal04-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars0.8+bigdecimal04-devel}"
SRC_URI[aarch64_rust-schemars0.8+bigdecimal04-devel.sha256sum] = "ed99638120f18a9cf72966ededc6330f641bc3db1d0cd5e607664d66df464888"

URI_aarch64_rust-schemars0.8+bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars0.8+bytes-devel-0.8.22-1.el10_1.noarch.rpm;name=aarch64_rust-schemars0.8+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars0.8+bytes-devel}"
SRC_URI[aarch64_rust-schemars0.8+bytes-devel.sha256sum] = "ed3bd3e3d1fdbf9de12d12c43abdf14ac494f9e5093bc6ac8cf2bb4e81333cb6"

URI_aarch64_rust-schemars0.8+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars0.8+chrono-devel-0.8.22-1.el10_1.noarch.rpm;name=aarch64_rust-schemars0.8+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars0.8+chrono-devel}"
SRC_URI[aarch64_rust-schemars0.8+chrono-devel.sha256sum] = "01769c01a7812849f298b21f3178080472dcdd3825c3ad41662ed1871168f28b"

URI_aarch64_rust-schemars0.8+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars0.8+default-devel-0.8.22-1.el10_1.noarch.rpm;name=aarch64_rust-schemars0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars0.8+default-devel}"
SRC_URI[aarch64_rust-schemars0.8+default-devel.sha256sum] = "e577f3a59cfacea74f5f845904fb3ad8ae50fc5992927f36406c6a3fddde4383"

URI_aarch64_rust-schemars0.8+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars0.8+derive-devel-0.8.22-1.el10_1.noarch.rpm;name=aarch64_rust-schemars0.8+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars0.8+derive-devel}"
SRC_URI[aarch64_rust-schemars0.8+derive-devel.sha256sum] = "74c7e4e6cd94809e3774f9c959179e0e4eba3515aab6c5d09e8a00160e022685"

URI_aarch64_rust-schemars0.8+derive_json_schema-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars0.8+derive_json_schema-devel-0.8.22-1.el10_1.noarch.rpm;name=aarch64_rust-schemars0.8+derive_json_schema-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars0.8+derive_json_schema-devel}"
SRC_URI[aarch64_rust-schemars0.8+derive_json_schema-devel.sha256sum] = "31b8e7e6e9ea48d3ea5c020eb7af46f9c1e047cddb6f3b000add4baa09defcd2"

URI_aarch64_rust-schemars0.8+either-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars0.8+either-devel-0.8.22-1.el10_1.noarch.rpm;name=aarch64_rust-schemars0.8+either-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars0.8+either-devel}"
SRC_URI[aarch64_rust-schemars0.8+either-devel.sha256sum] = "04ed8867adf378894d859dc21a7ea53fd7379b9be2773e4d865dc3eeeb01f7b8"

URI_aarch64_rust-schemars0.8+enumset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars0.8+enumset-devel-0.8.22-1.el10_1.noarch.rpm;name=aarch64_rust-schemars0.8+enumset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars0.8+enumset-devel}"
SRC_URI[aarch64_rust-schemars0.8+enumset-devel.sha256sum] = "04a03922c7d41ed5629309af1509a47627c0e2be21bcc4cc187991bcba708286"

URI_aarch64_rust-schemars0.8+impl_json_schema-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars0.8+impl_json_schema-devel-0.8.22-1.el10_1.noarch.rpm;name=aarch64_rust-schemars0.8+impl_json_schema-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars0.8+impl_json_schema-devel}"
SRC_URI[aarch64_rust-schemars0.8+impl_json_schema-devel.sha256sum] = "1b89a733b3d143637fed66a42b7907409f1f6dc2831204f3b40fc61ba2011eba"

URI_aarch64_rust-schemars0.8+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars0.8+indexmap-devel-0.8.22-1.el10_1.noarch.rpm;name=aarch64_rust-schemars0.8+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars0.8+indexmap-devel}"
SRC_URI[aarch64_rust-schemars0.8+indexmap-devel.sha256sum] = "c93403c5dd7b7b7bed56551f4b7cd0dc8c47b2a5f92d2ee6c59ae23e039a174f"

URI_aarch64_rust-schemars0.8+indexmap1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars0.8+indexmap1-devel-0.8.22-1.el10_1.noarch.rpm;name=aarch64_rust-schemars0.8+indexmap1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars0.8+indexmap1-devel}"
SRC_URI[aarch64_rust-schemars0.8+indexmap1-devel.sha256sum] = "c73a2b8c6619f90df3993bc89b06b0f2ef790cd4d2fce1a17e502e2bede209dc"

URI_aarch64_rust-schemars0.8+indexmap2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars0.8+indexmap2-devel-0.8.22-1.el10_1.noarch.rpm;name=aarch64_rust-schemars0.8+indexmap2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars0.8+indexmap2-devel}"
SRC_URI[aarch64_rust-schemars0.8+indexmap2-devel.sha256sum] = "d9777b73dd0dd444795bd0c74c09343500b2f53ae1a25ed9a0f7fc76ad9f9e9c"

URI_aarch64_rust-schemars0.8+preserve_order-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars0.8+preserve_order-devel-0.8.22-1.el10_1.noarch.rpm;name=aarch64_rust-schemars0.8+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars0.8+preserve_order-devel}"
SRC_URI[aarch64_rust-schemars0.8+preserve_order-devel.sha256sum] = "2d61d6a185f40ee79b7ce632dee2b0206fef88fc1526c020ba72610122cdadd7"

URI_aarch64_rust-schemars0.8+raw_value-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars0.8+raw_value-devel-0.8.22-1.el10_1.noarch.rpm;name=aarch64_rust-schemars0.8+raw_value-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars0.8+raw_value-devel}"
SRC_URI[aarch64_rust-schemars0.8+raw_value-devel.sha256sum] = "6b6d8810b62d6d9d9657d4d6be470c6382bb87704ce435c2dd4caefbd6d5ee63"

URI_aarch64_rust-schemars0.8+rust_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars0.8+rust_decimal-devel-0.8.22-1.el10_1.noarch.rpm;name=aarch64_rust-schemars0.8+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars0.8+rust_decimal-devel}"
SRC_URI[aarch64_rust-schemars0.8+rust_decimal-devel.sha256sum] = "bced8761b13bc05edd6b43d3cc8d755038119aeb26c1a115dc57a1fa379f6368"

URI_aarch64_rust-schemars0.8+schemars_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars0.8+schemars_derive-devel-0.8.22-1.el10_1.noarch.rpm;name=aarch64_rust-schemars0.8+schemars_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars0.8+schemars_derive-devel}"
SRC_URI[aarch64_rust-schemars0.8+schemars_derive-devel.sha256sum] = "68ff235f4c39bb8153c6d353c131d8c8565c3f1f8a62dcaa1b8654b294cb627d"

URI_aarch64_rust-schemars0.8+semver-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars0.8+semver-devel-0.8.22-1.el10_1.noarch.rpm;name=aarch64_rust-schemars0.8+semver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars0.8+semver-devel}"
SRC_URI[aarch64_rust-schemars0.8+semver-devel.sha256sum] = "18f589e47cf5ef6b50ebb70284b0d3b9bab7be432e03b6f5dac5a7a12986df2f"

URI_aarch64_rust-schemars0.8+smallvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars0.8+smallvec-devel-0.8.22-1.el10_1.noarch.rpm;name=aarch64_rust-schemars0.8+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars0.8+smallvec-devel}"
SRC_URI[aarch64_rust-schemars0.8+smallvec-devel.sha256sum] = "c6a76977a323d7f1fed94984dbc14963336203880d2d205c5be7b2a3055403c9"

URI_aarch64_rust-schemars0.8+smol_str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars0.8+smol_str-devel-0.8.22-1.el10_1.noarch.rpm;name=aarch64_rust-schemars0.8+smol_str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars0.8+smol_str-devel}"
SRC_URI[aarch64_rust-schemars0.8+smol_str-devel.sha256sum] = "a74fda6897be0294502ea72d2c6b9837b5c9b78b0c6daf80883a0f26c6b712ec"

URI_aarch64_rust-schemars0.8+ui_test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars0.8+ui_test-devel-0.8.22-1.el10_1.noarch.rpm;name=aarch64_rust-schemars0.8+ui_test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars0.8+ui_test-devel}"
SRC_URI[aarch64_rust-schemars0.8+ui_test-devel.sha256sum] = "2d2baa980c47375399321cbb30e3dbf860d5033bd3925736581486cbf3735fdb"

URI_aarch64_rust-schemars0.8+url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars0.8+url-devel-0.8.22-1.el10_1.noarch.rpm;name=aarch64_rust-schemars0.8+url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars0.8+url-devel}"
SRC_URI[aarch64_rust-schemars0.8+url-devel.sha256sum] = "5d145272fd1176353444265fc9142082b39c9d13c3de8dd8866550fb13eed248"

URI_aarch64_rust-schemars0.8+uuid1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars0.8+uuid1-devel-0.8.22-1.el10_1.noarch.rpm;name=aarch64_rust-schemars0.8+uuid1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars0.8+uuid1-devel}"
SRC_URI[aarch64_rust-schemars0.8+uuid1-devel.sha256sum] = "5451390566610cd4284d26d485e58168624388393cb87b3fd0107f5e111c62cc"

URI_aarch64_rust-schemars0.8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars0.8-devel-0.8.22-1.el10_1.noarch.rpm;name=aarch64_rust-schemars0.8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars0.8-devel}"
SRC_URI[aarch64_rust-schemars0.8-devel.sha256sum] = "a58f9a8078defc195a5e74ea0b5aa732ab9734db88b381feb44369e53fea42a1"

RDEPENDS:rust-schemars0.8+arrayvec07-devel = " \
 cargo \
 rust-arrayvec-devel \
 rust-schemars0.8-devel \
 "
RDEPENDS:rust-schemars0.8+bigdecimal04-devel = " \
 cargo \
 rust-bigdecimal-devel \
 rust-schemars0.8-devel \
 "
RDEPENDS:rust-schemars0.8+bytes-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-schemars0.8-devel \
 "
RDEPENDS:rust-schemars0.8+chrono-devel = " \
 cargo \
 rust-chrono-devel \
 rust-schemars0.8-devel \
 "
RDEPENDS:rust-schemars0.8+default-devel = " \
 cargo \
 rust-schemars0.8+derive-devel \
 rust-schemars0.8-devel \
 "
RDEPENDS:rust-schemars0.8+derive-devel = " \
 cargo \
 rust-schemars0.8+schemars_derive-devel \
 rust-schemars0.8-devel \
 "
RDEPENDS:rust-schemars0.8+derive_json_schema-devel = " \
 cargo \
 rust-schemars0.8+impl_json_schema-devel \
 rust-schemars0.8-devel \
 "
RDEPENDS:rust-schemars0.8+either-devel = " \
 cargo \
 rust-either-devel \
 rust-schemars0.8-devel \
 "
RDEPENDS:rust-schemars0.8+enumset-devel = " \
 cargo \
 rust-enumset+default-devel \
 rust-schemars0.8-devel \
 "
RDEPENDS:rust-schemars0.8+impl_json_schema-devel = " \
 cargo \
 rust-schemars0.8+derive-devel \
 rust-schemars0.8-devel \
 "
RDEPENDS:rust-schemars0.8+indexmap-devel = " \
 cargo \
 rust-indexmap1+default-devel \
 rust-indexmap1+serde-1-devel \
 rust-schemars0.8-devel \
 "
RDEPENDS:rust-schemars0.8+indexmap1-devel = " \
 cargo \
 rust-schemars0.8+indexmap-devel \
 rust-schemars0.8-devel \
 "
RDEPENDS:rust-schemars0.8+indexmap2-devel = " \
 cargo \
 rust-indexmap+default-devel \
 rust-indexmap+serde-devel \
 rust-schemars0.8-devel \
 "
RDEPENDS:rust-schemars0.8+preserve_order-devel = " \
 cargo \
 rust-schemars0.8+indexmap-devel \
 rust-schemars0.8-devel \
 "
RDEPENDS:rust-schemars0.8+raw_value-devel = " \
 cargo \
 rust-schemars0.8-devel \
 rust-serde_json+raw_value-devel \
 "
RDEPENDS:rust-schemars0.8+rust_decimal-devel = " \
 cargo \
 rust-rust_decimal-devel \
 rust-schemars0.8-devel \
 "
RDEPENDS:rust-schemars0.8+schemars_derive-devel = " \
 cargo \
 rust-schemars0.8-devel \
 rust-schemars_derive0.8+default-devel \
 "
RDEPENDS:rust-schemars0.8+semver-devel = " \
 cargo \
 rust-schemars0.8-devel \
 rust-semver+default-devel \
 rust-semver+serde-devel \
 "
RDEPENDS:rust-schemars0.8+smallvec-devel = " \
 cargo \
 rust-schemars0.8-devel \
 rust-smallvec+default-devel \
 "
RDEPENDS:rust-schemars0.8+smol_str-devel = " \
 cargo \
 rust-schemars0.8-devel \
 rust-smol_str0.1+default-devel \
 "
RDEPENDS:rust-schemars0.8+ui_test-devel = " \
 cargo \
 rust-schemars0.8-devel \
 "
RDEPENDS:rust-schemars0.8+url-devel = " \
 cargo \
 rust-schemars0.8-devel \
 rust-url-devel \
 "
RDEPENDS:rust-schemars0.8+uuid1-devel = " \
 cargo \
 rust-schemars0.8-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-schemars0.8-devel = " \
 cargo \
 rust \
 rust-dyn-clone+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 "
