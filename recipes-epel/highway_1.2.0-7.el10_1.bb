# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "highway"
PV = "1.2.0"
PR = "7.el10_1"
PACKAGES = " \
 highway \
 highway-devel \
 highway-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/highway-1.2.0-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0842d49721de4339d5ccdcdfd6efd4de10f9cc4bf39535c2cdbfac8d8df8941e"

URI_x86_64_v2_highway = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/highway-1.2.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_highway;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_highway}"
SRC_URI[x86_64_v2_highway.sha256sum] = "0882684e961000548d04d603b34c67315d881e354e129bffdef618533ce935a5"

URI_x86_64_v2_highway-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/highway-devel-1.2.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_highway-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_highway-devel}"
SRC_URI[x86_64_v2_highway-devel.sha256sum] = "c8939fe8652019d2064d6999accaa8665adddaafd2a6bc6f192fdec03376d65b"

URI_x86_64_v2_highway-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/highway-doc-1.2.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_highway-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_highway-doc}"
SRC_URI[x86_64_v2_highway-doc.sha256sum] = "0aa2da4e5803ea100419c4db76e63d30f675a52fb91c8b7fddec692cba9c2522"

URI_aarch64_highway = "${EPEL_MIRROR}/aarch64/Packages/h/highway-1.2.0-7.el10_1.aarch64.rpm;name=aarch64_highway;unpack=0"
SRC_URI:append = " ${URI_aarch64_highway}"
SRC_URI[aarch64_highway.sha256sum] = "6f6250d4ba3ba873903c95390c11fe12fd9ab9314b4aa2c12ab55a1dd68725b6"

URI_aarch64_highway-devel = "${EPEL_MIRROR}/aarch64/Packages/h/highway-devel-1.2.0-7.el10_1.aarch64.rpm;name=aarch64_highway-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_highway-devel}"
SRC_URI[aarch64_highway-devel.sha256sum] = "a5574a8056ba2e1939c1091d9b605f25a896770492303582faa562ea0b5c832d"

URI_aarch64_highway-doc = "${EPEL_MIRROR}/aarch64/Packages/h/highway-doc-1.2.0-7.el10_1.noarch.rpm;name=aarch64_highway-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_highway-doc}"
SRC_URI[aarch64_highway-doc.sha256sum] = "ed0965997f3dc6e80a97034cebe63c512f076e506a11abf556a584324d93aeeb"

RDEPENDS:highway:x86_64_v2 = " \
 glibc \
 libgcc \
 libstdc++ \
"
RDEPENDS:highway:aarch64 = " \
 glibc \
 libstdc++ \
"
RDEPENDS:highway-devel = " \
 cmake-filesystem \
 gtest-devel \
 highway \
 pkgconf-pkg-config \
 "
RDEPENDS:highway-doc = " \
 "
