# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aardvark-dns"
PE = "2"
PV = "1.17.1"
PR = "1.el10_2"
PACKAGES = " \
 aardvark-dns \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/aardvark-dns-1.17.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52f3b3b1ced800a2a565ab4680e0fc16badf466c9ac19625843bbb25dbb7e919"

URI_x86_64_v2_aardvark-dns = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aardvark-dns-1.17.1-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_aardvark-dns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aardvark-dns}"
SRC_URI[x86_64_v2_aardvark-dns.sha256sum] = "7cdd16314ee1d93f8d8a71d36b831533ee2cf3a78fc8bfc7aa229b9f9e209a5b"

URI_aarch64_aardvark-dns = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aardvark-dns-1.17.1-1.el10_2.aarch64.rpm;name=aarch64_aardvark-dns;unpack=0"
SRC_URI:append = " ${URI_aarch64_aardvark-dns}"
SRC_URI[aarch64_aardvark-dns.sha256sum] = "1a40e6b6c641e4ff2e9f3758f03d945575abbd70e0b645b4eed12bc481155a54"

RDEPENDS:aardvark-dns = " \
 glibc \
 libgcc \
 "
