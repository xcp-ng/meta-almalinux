# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-bluez-qt"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-bluez-qt \
 kf6-bluez-qt-devel \
 kf6-bluez-qt-doc \
 kf6-bluez-qt-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-bluez-qt-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "40300fe8af2067d02834c07da4e941a3650f16c4a90cdfc3713d65832ddacaa1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-bluez-qt-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-bluez-qt;unpack=0"
SRC_URI[x86_64_v2_kf6-bluez-qt.sha256sum] = "6d3ad1e341dceb4467625cec71f43c2b06dc649d638fe39f3fd107411b1dc50f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-bluez-qt-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-bluez-qt-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-bluez-qt-devel.sha256sum] = "32a4b33dbe619528eb4a39f43f3c1316b1756a55f045c4375cd33f7f6ba5f9a6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-bluez-qt-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-bluez-qt-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-bluez-qt-doc.sha256sum] = "dc163b0b12e938f1a59cd440245b3b9b363f9ec7cfcba604afdf68ada0f86620"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-bluez-qt-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-bluez-qt-html;unpack=0"
SRC_URI[x86_64_v2_kf6-bluez-qt-html.sha256sum] = "f751303a01cf82237ca34f27bb0a53cf62c8bd2343515212432a6004267871c7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-bluez-qt-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-bluez-qt;unpack=0"
SRC_URI[aarch64_kf6-bluez-qt.sha256sum] = "fddfe7621c04debfa0af7de64acad81082090d790fce83fe817c20a3c88ac9f6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-bluez-qt-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-bluez-qt-devel;unpack=0"
SRC_URI[aarch64_kf6-bluez-qt-devel.sha256sum] = "ebe44a9beafb0bae8f258a4dee37b4346e5036166f7c70e8c0be5283c799cede"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-bluez-qt-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-bluez-qt-doc;unpack=0"
SRC_URI[aarch64_kf6-bluez-qt-doc.sha256sum] = "95feab6356a25430c777d4cecec2843d9d7e49ee6988445c858b7708a257fcd7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-bluez-qt-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-bluez-qt-html;unpack=0"
SRC_URI[aarch64_kf6-bluez-qt-html.sha256sum] = "79e81c3789f670dc049f35657af58742d8c3a927f635bea96860c24d5c200c66"

RDEPENDS:kf6-bluez-qt = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-bluez-qt-devel = " \
 cmake-filesystem \
 kf6-bluez-qt \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-bluez-qt-doc = " \
 "
RDEPENDS:kf6-bluez-qt-html = " \
 "
