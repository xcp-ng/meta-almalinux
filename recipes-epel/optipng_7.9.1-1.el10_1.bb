# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "optipng"
PV = "7.9.1"
PR = "1.el10_1"
PACKAGES = " \
 optipng \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/optipng-7.9.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de09f5023c7ef256101594b789e7af17880b0e7f44a009f20bf257c68eca3003"

URI_x86_64_v2_optipng = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/optipng-7.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_optipng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_optipng}"
SRC_URI[x86_64_v2_optipng.sha256sum] = "954280b5a2a44c211377a75fb67ba3b2e5ebbd52611af82e519d83443e7aed31"

URI_aarch64_optipng = "${EPEL_MIRROR}/aarch64/Packages/o/optipng-7.9.1-1.el10_1.aarch64.rpm;name=aarch64_optipng;unpack=0"
SRC_URI:append = " ${URI_aarch64_optipng}"
SRC_URI[aarch64_optipng.sha256sum] = "3feba52b3a262e0e40e95046f8af9d8f9a3d8269b1fd30b8897c47741449fcb8"

RDEPENDS:optipng = " \
 glibc \
 libpng \
 zlib-ng-compat \
 "
