# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "filelight"
PE = "1"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 filelight \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/filelight-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "301795b52bb9e48cba826e381ea6e8b577593941c5c208c5180483cd19ae785f"

URI_x86_64_v2_filelight = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/filelight-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_filelight;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_filelight}"
SRC_URI[x86_64_v2_filelight.sha256sum] = "78af3fc567c3d33112299e92dffaa6cf3c8cc7722ba8651691eb86d4efa5dcb8"

URI_aarch64_filelight = "${EPEL_MIRROR}/aarch64/Packages/f/filelight-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_filelight;unpack=0"
SRC_URI:append = " ${URI_aarch64_filelight}"
SRC_URI[aarch64_filelight.sha256sum] = "bae1d58b317b06eb6e5c597ebe89d2bf491ae19ddee6419461628f1faa3ae75e"

RDEPENDS:filelight = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kquickcharts \
 kf6-kwidgetsaddons \
 kf6-qqc2-desktop-style \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
