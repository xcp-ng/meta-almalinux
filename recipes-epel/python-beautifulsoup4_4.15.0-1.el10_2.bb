# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-beautifulsoup4"
PV = "4.15.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-beautifulsoup4 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-beautifulsoup4-4.15.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0c3207f9fca07b617edf038a80585c24613c8b095ec18bd0e10de06ea4def14"

URI_x86_64_v2_python3-beautifulsoup4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-beautifulsoup4-4.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-beautifulsoup4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-beautifulsoup4}"
SRC_URI[x86_64_v2_python3-beautifulsoup4.sha256sum] = "b0b00aedc1770adae15f1c495f2941da161c5f58edee8bacfb09a56fa3397352"

URI_aarch64_python3-beautifulsoup4 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-beautifulsoup4-4.15.0-1.el10_2.noarch.rpm;name=aarch64_python3-beautifulsoup4;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-beautifulsoup4}"
SRC_URI[aarch64_python3-beautifulsoup4.sha256sum] = "8ea53e30ed689a401269681b25b2eee2575b23b0baad223c82e8a8353bc13079"

RDEPENDS:python3-beautifulsoup4 = " \
 python3 \
 python3-lxml \
 python3-soupsieve \
 python3-typing-extensions \
 "
