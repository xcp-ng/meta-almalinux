# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-config-value"
PV = "0.14.11"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-config-value+default-devel \
 rust-gix-config-value+document-features-devel \
 rust-gix-config-value+serde-devel \
 rust-gix-config-value-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-config-value-0.14.11-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "914a38b0a84d2f05abae174e6c6c666983b1f453768ac52ddcf2962d07543dfd"

URI_x86_64_v2_rust-gix-config-value+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config-value+default-devel-0.14.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config-value+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config-value+default-devel}"
SRC_URI[x86_64_v2_rust-gix-config-value+default-devel.sha256sum] = "2c21a8fe51ad36080afc411933edf58160d0a1f337a3ab0ff9cb25a16c40bd07"

URI_x86_64_v2_rust-gix-config-value+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config-value+document-features-devel-0.14.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config-value+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config-value+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-config-value+document-features-devel.sha256sum] = "d34a9a608ab6d737ab01cf7a069d5a7e36794710a0b260ac2518c5a5fab5adce"

URI_x86_64_v2_rust-gix-config-value+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config-value+serde-devel-0.14.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config-value+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config-value+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-config-value+serde-devel.sha256sum] = "d12b2cc75a6ea609be37999215e9594c3d384348655d8b8d2cc3267a51f4e22f"

URI_x86_64_v2_rust-gix-config-value-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config-value-devel-0.14.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config-value-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config-value-devel}"
SRC_URI[x86_64_v2_rust-gix-config-value-devel.sha256sum] = "3c806e2a404d1413f4763a813b4c973b002ea3234984ca51e2fc9f4348f93f37"

URI_aarch64_rust-gix-config-value+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config-value+default-devel-0.14.11-1.el10_0.noarch.rpm;name=aarch64_rust-gix-config-value+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config-value+default-devel}"
SRC_URI[aarch64_rust-gix-config-value+default-devel.sha256sum] = "d24aa698f4ae3812f8a3f7fc4fa48e0404162d613faf6e1e7edba69936022129"

URI_aarch64_rust-gix-config-value+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config-value+document-features-devel-0.14.11-1.el10_0.noarch.rpm;name=aarch64_rust-gix-config-value+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config-value+document-features-devel}"
SRC_URI[aarch64_rust-gix-config-value+document-features-devel.sha256sum] = "ce03bb2ff294f3c7298fafeb4abcd156a263f0e8b1b92986fad3fce0683e73d2"

URI_aarch64_rust-gix-config-value+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config-value+serde-devel-0.14.11-1.el10_0.noarch.rpm;name=aarch64_rust-gix-config-value+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config-value+serde-devel}"
SRC_URI[aarch64_rust-gix-config-value+serde-devel.sha256sum] = "c06504feb3470535b57a2a5714b3dcca2b53e19f25458179fc9447c36fc83d48"

URI_aarch64_rust-gix-config-value-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config-value-devel-0.14.11-1.el10_0.noarch.rpm;name=aarch64_rust-gix-config-value-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config-value-devel}"
SRC_URI[aarch64_rust-gix-config-value-devel.sha256sum] = "6982f03d57a2fc3bb06af342f628a116443a64b2df61da67d8738a62db4478a6"

RDEPENDS:rust-gix-config-value+default-devel = " \
 cargo \
 rust-gix-config-value-devel \
 "
RDEPENDS:rust-gix-config-value+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-config-value-devel \
 "
RDEPENDS:rust-gix-config-value+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-config-value-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-config-value-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-path+default-devel \
 rust-libc+default-devel \
 rust-thiserror+default-devel \
 "
