# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "reproc"
PV = "14.2.4"
PR = "1.20230609git1c07bdb.el10_1"
PACKAGES = " \
 reproc \
 reproc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/reproc-14.2.4-1.20230609git1c07bdb.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8744099bef22601f9ff00be8843d1375ec3e2ace40cc3925dcd1b227fbad6f42"

URI_x86_64_v2_reproc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/reproc-14.2.4-1.20230609git1c07bdb.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_reproc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_reproc}"
SRC_URI[x86_64_v2_reproc.sha256sum] = "db6ad698a845d11ee3b81cf7061c02bb1277a90f3093d2923d14ec2bff4c77e8"

URI_x86_64_v2_reproc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/reproc-devel-14.2.4-1.20230609git1c07bdb.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_reproc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_reproc-devel}"
SRC_URI[x86_64_v2_reproc-devel.sha256sum] = "e7265a994c906143b6dd002dabcf41456d656c7a2dc082985bfeeb18f2ea14a9"

URI_aarch64_reproc = "${EPEL_MIRROR}/aarch64/Packages/r/reproc-14.2.4-1.20230609git1c07bdb.el10_1.aarch64.rpm;name=aarch64_reproc;unpack=0"
SRC_URI:append = " ${URI_aarch64_reproc}"
SRC_URI[aarch64_reproc.sha256sum] = "cbcb0389655575b2961b6a0f364e1e74bc4ec9d01f20d6ae720ab29505a961b3"

URI_aarch64_reproc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/reproc-devel-14.2.4-1.20230609git1c07bdb.el10_1.aarch64.rpm;name=aarch64_reproc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_reproc-devel}"
SRC_URI[aarch64_reproc-devel.sha256sum] = "28039d240d5fc612228131c12ce705e0b55e0230d55c31ef0f75984787df3b56"

RDEPENDS:reproc = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:reproc-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 reproc \
 "
