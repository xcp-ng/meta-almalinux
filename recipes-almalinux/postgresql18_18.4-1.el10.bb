# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "postgresql18"
PV = "18.4"
PR = "1.el10"
PACKAGES = " \
 postgresql18 \
 postgresql18-contrib \
 postgresql18-docs \
 postgresql18-plperl \
 postgresql18-plpython3 \
 postgresql18-pltcl \
 postgresql18-private-devel \
 postgresql18-private-libs \
 postgresql18-server \
 postgresql18-server-devel \
 postgresql18-static \
 postgresql18-test \
 postgresql18-test-rpm-macros \
 postgresql18-upgrade \
 postgresql18-upgrade-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/postgresql18-18.4-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7646673466e209b626c32234038c32ed71eda6da16165cbff9a3b927b2e4c22d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-18.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql18;unpack=0"
SRC_URI[x86_64_v2_postgresql18.sha256sum] = "6bd71478d8108bedb23aa4e13711717984ef7d0120a114cdad6d02eb3d75f0b4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-contrib-18.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql18-contrib;unpack=0"
SRC_URI[x86_64_v2_postgresql18-contrib.sha256sum] = "362fb4c38df8ce8a668cc4d8c262a10398dd2f3782d65f056269f32f2d4940c6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-docs-18.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql18-docs;unpack=0"
SRC_URI[x86_64_v2_postgresql18-docs.sha256sum] = "076365ea58aa77c740a696c85f74d5627d46b62d124da8836e6d67fec779818b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-plperl-18.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql18-plperl;unpack=0"
SRC_URI[x86_64_v2_postgresql18-plperl.sha256sum] = "192418585ced54f5875fcc97b8bb2616eac191bebfcbe89dcce805fd05288213"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-plpython3-18.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql18-plpython3;unpack=0"
SRC_URI[x86_64_v2_postgresql18-plpython3.sha256sum] = "48388dcbffd31579e9618c4fff0ecada1a47c6975634336723c0133a7388fb34"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-pltcl-18.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql18-pltcl;unpack=0"
SRC_URI[x86_64_v2_postgresql18-pltcl.sha256sum] = "3be4d790308938962b18baa9235be16db3981fb8b4f86e08a87afdaa7d585d2e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-private-devel-18.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql18-private-devel;unpack=0"
SRC_URI[x86_64_v2_postgresql18-private-devel.sha256sum] = "7f2392bcb35c15383edc62b8b08e8fc50d06419bc721898e080c15eb9c8dfcbe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-private-libs-18.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql18-private-libs;unpack=0"
SRC_URI[x86_64_v2_postgresql18-private-libs.sha256sum] = "739f9fee3b47842b2448441b6caa48c5d8a4b629439713938a8a45048fbfb04a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-server-18.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql18-server;unpack=0"
SRC_URI[x86_64_v2_postgresql18-server.sha256sum] = "a3173e995c0f5f29d165cae4ba24c916d5164b1c554aece3f765926179439da3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-server-devel-18.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql18-server-devel;unpack=0"
SRC_URI[x86_64_v2_postgresql18-server-devel.sha256sum] = "98a9506ec64e6c3a30979f44fe4c68fecbab3592cb52c3698df1198921a79a1d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-static-18.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql18-static;unpack=0"
SRC_URI[x86_64_v2_postgresql18-static.sha256sum] = "c43e54ed25be9036befc25cbc2b131f719aed2dd51486269a0a32ef78f73771a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-test-18.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql18-test;unpack=0"
SRC_URI[x86_64_v2_postgresql18-test.sha256sum] = "03d36250bc9615595056491898e9bc22af7f997c7ba2432c4e19dcedb0cb5821"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/postgresql18-test-rpm-macros-18.4-1.el10.noarch.rpm;name=x86_64_v2_postgresql18-test-rpm-macros;unpack=0"
SRC_URI[x86_64_v2_postgresql18-test-rpm-macros.sha256sum] = "c992f21c569aff7448862a23bc1368ca7ecb69d08045a0fffd40c43339b6a65d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-upgrade-18.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql18-upgrade;unpack=0"
SRC_URI[x86_64_v2_postgresql18-upgrade.sha256sum] = "9af9cee795a9f9299cf012997d259a306f709572276bb881e20caa366cee2509"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-upgrade-devel-18.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_postgresql18-upgrade-devel;unpack=0"
SRC_URI[x86_64_v2_postgresql18-upgrade-devel.sha256sum] = "00ef48b266b31015d44033c18284e50d20ddc367c1c8bbb9555224bd6377a918"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-18.4-1.el10.aarch64.rpm;name=aarch64_postgresql18;unpack=0"
SRC_URI[aarch64_postgresql18.sha256sum] = "a2e57e314ae6f199e4551ac9c7f5e9b791f5a522082ae96e7e6b783b5f2c6784"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-contrib-18.4-1.el10.aarch64.rpm;name=aarch64_postgresql18-contrib;unpack=0"
SRC_URI[aarch64_postgresql18-contrib.sha256sum] = "ce357e5f01eb4c434c5a00cda793ce78d7c1e46228bad3d892b8a1731ab7942e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-docs-18.4-1.el10.aarch64.rpm;name=aarch64_postgresql18-docs;unpack=0"
SRC_URI[aarch64_postgresql18-docs.sha256sum] = "3df5fc7c9523663b6e69c60a66f26fe89d91dacff3ed32296726c46919ad1024"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-plperl-18.4-1.el10.aarch64.rpm;name=aarch64_postgresql18-plperl;unpack=0"
SRC_URI[aarch64_postgresql18-plperl.sha256sum] = "f01209ae4fe6f61b05d06a67b7d9818b02b493b3bc85fc238405e42d37dee9aa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-plpython3-18.4-1.el10.aarch64.rpm;name=aarch64_postgresql18-plpython3;unpack=0"
SRC_URI[aarch64_postgresql18-plpython3.sha256sum] = "842bed40a348c5e452bff38d4a2587037a7cbef3877745a6fbf61881a19ceb1f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-pltcl-18.4-1.el10.aarch64.rpm;name=aarch64_postgresql18-pltcl;unpack=0"
SRC_URI[aarch64_postgresql18-pltcl.sha256sum] = "951c7566dd18bc3092d7905890738afa39fefb02eea0a126d8dd2b4defa1f612"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-private-devel-18.4-1.el10.aarch64.rpm;name=aarch64_postgresql18-private-devel;unpack=0"
SRC_URI[aarch64_postgresql18-private-devel.sha256sum] = "2bef524fbe3e7f1ffe10054f1fed4068b02ff06d315bef8e1ebd4be4d730f187"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-private-libs-18.4-1.el10.aarch64.rpm;name=aarch64_postgresql18-private-libs;unpack=0"
SRC_URI[aarch64_postgresql18-private-libs.sha256sum] = "fdaddb7b9141c87efed46c8a7e0fe1b9e57fc8fb78086fce9254d2f9cedc3114"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-server-18.4-1.el10.aarch64.rpm;name=aarch64_postgresql18-server;unpack=0"
SRC_URI[aarch64_postgresql18-server.sha256sum] = "ec2187ae70c8a5f21615d559268a08ca7bdadcee1abedd2550637ab390363fcf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-server-devel-18.4-1.el10.aarch64.rpm;name=aarch64_postgresql18-server-devel;unpack=0"
SRC_URI[aarch64_postgresql18-server-devel.sha256sum] = "3901640a61454a70bc1a3a32aa7adc9b80dc49a18c8180faf1e30f4a8b1ac59c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-static-18.4-1.el10.aarch64.rpm;name=aarch64_postgresql18-static;unpack=0"
SRC_URI[aarch64_postgresql18-static.sha256sum] = "0ef92a11872ab6feebac55e386b3c66e9585c36c34172d3117aba48c160a7c03"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-test-18.4-1.el10.aarch64.rpm;name=aarch64_postgresql18-test;unpack=0"
SRC_URI[aarch64_postgresql18-test.sha256sum] = "20f061f215c9a957dac42b4e4886e3383ffc72edf0ec85d1ef5cb28e998ad7a7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/postgresql18-test-rpm-macros-18.4-1.el10.noarch.rpm;name=aarch64_postgresql18-test-rpm-macros;unpack=0"
SRC_URI[aarch64_postgresql18-test-rpm-macros.sha256sum] = "c992f21c569aff7448862a23bc1368ca7ecb69d08045a0fffd40c43339b6a65d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-upgrade-18.4-1.el10.aarch64.rpm;name=aarch64_postgresql18-upgrade;unpack=0"
SRC_URI[aarch64_postgresql18-upgrade.sha256sum] = "5a0d46cbd87b84c0217a20a9360bbb53f90a2fbb6ee234936f34f667178f31ee"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-upgrade-devel-18.4-1.el10.aarch64.rpm;name=aarch64_postgresql18-upgrade-devel;unpack=0"
SRC_URI[aarch64_postgresql18-upgrade-devel.sha256sum] = "3ac8ec2cc3024cdf933e4d8af3b3238b87f95bb206ec6f0dd3a34e0fc6058a3e"

RDEPENDS:postgresql18 = " \
 glibc \
 libzstd \
 lz4-libs \
 openssl-libs \
 postgresql18-private-libs \
 readline \
 zlib-ng-compat \
 "
RDEPENDS:postgresql18-contrib = " \
 glibc \
 libselinux \
 libxml2 \
 libxslt \
 libzstd \
 lz4-libs \
 openssl-libs \
 perl-libs \
 postgresql18 \
 postgresql18-private-libs \
 python3-libs \
 uuid \
 zlib-ng-compat \
 "
RDEPENDS:postgresql18-docs = " \
 glibc \
 postgresql18 \
 "
RDEPENDS:postgresql18-plperl = " \
 glibc \
 perl-libs \
 postgresql18-server \
 "
RDEPENDS:postgresql18-plpython3 = " \
 glibc \
 postgresql18-server \
 python3-libs \
 "
RDEPENDS:postgresql18-pltcl = " \
 glibc \
 postgresql18-server \
 tcl \
 "
RDEPENDS:postgresql18-private-devel = " \
 openssl-devel \
 pkgconf-pkg-config \
 postgresql18-private-libs \
 "
RDEPENDS:postgresql18-private-libs = " \
 glibc \
 krb5-libs \
 openldap \
 openssl-libs \
 "
RDEPENDS:postgresql18-server = " \
 bash \
 glibc \
 krb5-libs \
 libicu \
 libxml2 \
 libzstd \
 lz4-libs \
 openldap \
 openssl-libs \
 pam-libs \
 postgresql18 \
 postgresql18-private-libs \
 systemd \
 systemd-libs \
 util-linux \
 zlib-ng-compat \
 "
RDEPENDS:postgresql18-server-devel = " \
 bash \
 glibc \
 krb5-devel \
 libicu-devel \
 postgresql18-private-devel \
 postgresql18-private-libs \
 "
RDEPENDS:postgresql18-static = " \
 postgresql18-server-devel \
 "
RDEPENDS:postgresql18-test = " \
 bash \
 glibc \
 postgresql18-contrib \
 postgresql18-server \
 postgresql18-server-devel \
 "
RDEPENDS:postgresql18-test-rpm-macros = " \
 postgresql18-server \
 "
RDEPENDS:postgresql18-upgrade = " \
 glibc \
 krb5-libs \
 libicu \
 libselinux \
 libxml2 \
 libxslt \
 libzstd \
 lz4-libs \
 openldap \
 openssl-libs \
 pam-libs \
 perl-libs \
 postgresql18-private-libs \
 postgresql18-server \
 python3-libs \
 tcl \
 uuid \
 zlib-ng-compat \
 "
RDEPENDS:postgresql18-upgrade-devel = " \
 bash \
 glibc \
 postgresql18-private-libs \
 postgresql18-upgrade \
 "
