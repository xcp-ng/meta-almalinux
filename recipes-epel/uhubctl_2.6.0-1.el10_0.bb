# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "uhubctl"
PV = "2.6.0"
PR = "1.el10_0"
PACKAGES = " \
 uhubctl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/uhubctl-2.6.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "068ff14956a5decb48da960538f6b2cb23e5327026506857ca4cbbf4eb4a020a"

URI_x86_64_v2_uhubctl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uhubctl-2.6.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uhubctl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uhubctl}"
SRC_URI[x86_64_v2_uhubctl.sha256sum] = "2f6372d70f53baf25e1b072dc6d39fcdb22c82dee9003389392afc7dc24aa5fe"

URI_aarch64_uhubctl = "${EPEL_MIRROR}/aarch64/Packages/u/uhubctl-2.6.0-1.el10_0.aarch64.rpm;name=aarch64_uhubctl;unpack=0"
SRC_URI:append = " ${URI_aarch64_uhubctl}"
SRC_URI[aarch64_uhubctl.sha256sum] = "fc8000054868d617eac639260c18ac95f402c30eedba2c299bb828aa6820268a"

RDEPENDS:uhubctl = " \
 glibc \
 libusb1 \
 "
