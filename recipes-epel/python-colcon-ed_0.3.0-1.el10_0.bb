# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-ed"
PV = "0.3.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-colcon-ed \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-colcon-ed-0.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "88aae9dfe2623953533d475344af519c1b5d32a5a41ef61d0ecd4156c78e5a8c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-ed-0.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-ed;unpack=0"
SRC_URI[x86_64_v2_python3-colcon-ed.sha256sum] = "65a24b5fb5e1c9a6a4f4bf04f71a0c51838f52e67dfcf3af8b992b29c6392ba1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-ed-0.3.0-1.el10_0.noarch.rpm;name=aarch64_python3-colcon-ed;unpack=0"
SRC_URI[aarch64_python3-colcon-ed.sha256sum] = "f3f0c12e3470d7b90d56e0308bd7a1032fa19a62422a1879c25d7b9300abae3d"

RDEPENDS:python3-colcon-ed = " \
 python3 \
 python3-colcon-core \
 "
