# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "PackageKit"
PV = "1.2.8"
PR = "8.el10_2"
PACKAGES = " \
 PackageKit \
 PackageKit-command-not-found \
 PackageKit-glib \
 PackageKit-glib-devel \
 PackageKit-gstreamer-plugin \
 PackageKit-gtk3-module \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/PackageKit-1.2.8-8.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cd01f21a10925407e987316deaf4d75a3efaf669307e8bd2690d1c05cb4fde19"

URI_x86_64_v2_PackageKit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/PackageKit-1.2.8-8.el10_2.x86_64_v2.rpm;name=x86_64_v2_PackageKit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_PackageKit}"
SRC_URI[x86_64_v2_PackageKit.sha256sum] = "161f3e2cf9ebc73aae69ef5254a2d3d65f0401a6c4ed872e22a40e888da74f6b"

URI_x86_64_v2_PackageKit-command-not-found = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/PackageKit-command-not-found-1.2.8-8.el10_2.x86_64_v2.rpm;name=x86_64_v2_PackageKit-command-not-found;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_PackageKit-command-not-found}"
SRC_URI[x86_64_v2_PackageKit-command-not-found.sha256sum] = "1c382fd1d22ab7791a2c059670d787a71921fb102e478f1187193544fdaf14cb"

URI_x86_64_v2_PackageKit-glib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/PackageKit-glib-1.2.8-8.el10_2.x86_64_v2.rpm;name=x86_64_v2_PackageKit-glib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_PackageKit-glib}"
SRC_URI[x86_64_v2_PackageKit-glib.sha256sum] = "5b452912b1feb48d85e8c48d7f65a84c2023c1e9386132068249a5279e28f70c"

URI_x86_64_v2_PackageKit-glib-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/PackageKit-glib-devel-1.2.8-8.el10_2.x86_64_v2.rpm;name=x86_64_v2_PackageKit-glib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_PackageKit-glib-devel}"
SRC_URI[x86_64_v2_PackageKit-glib-devel.sha256sum] = "5573d88df43d6b2c810d9484040f8b53a76b341f7af924142a999300bd6846a0"

URI_x86_64_v2_PackageKit-gstreamer-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/PackageKit-gstreamer-plugin-1.2.8-8.el10_2.x86_64_v2.rpm;name=x86_64_v2_PackageKit-gstreamer-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_PackageKit-gstreamer-plugin}"
SRC_URI[x86_64_v2_PackageKit-gstreamer-plugin.sha256sum] = "089c70ff772f35e73a5da2414a5fba96bd1cac68b488d9272dcf5beb43f2345d"

URI_x86_64_v2_PackageKit-gtk3-module = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/PackageKit-gtk3-module-1.2.8-8.el10_2.x86_64_v2.rpm;name=x86_64_v2_PackageKit-gtk3-module;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_PackageKit-gtk3-module}"
SRC_URI[x86_64_v2_PackageKit-gtk3-module.sha256sum] = "bd2cafb29dc93095bda855f8f0d5482e0ea62617fde534061283086f014a3080"

URI_aarch64_PackageKit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/PackageKit-1.2.8-8.el10_2.aarch64.rpm;name=aarch64_PackageKit;unpack=0"
SRC_URI:append = " ${URI_aarch64_PackageKit}"
SRC_URI[aarch64_PackageKit.sha256sum] = "44953839ad0f43174ea381f7c5dcf6563977a446254d3d76b3a35440db486c58"

URI_aarch64_PackageKit-command-not-found = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/PackageKit-command-not-found-1.2.8-8.el10_2.aarch64.rpm;name=aarch64_PackageKit-command-not-found;unpack=0"
SRC_URI:append = " ${URI_aarch64_PackageKit-command-not-found}"
SRC_URI[aarch64_PackageKit-command-not-found.sha256sum] = "722234620a375b34637f38b7b67ff4ebd6e354e304a7a19d7bc1a01271580016"

URI_aarch64_PackageKit-glib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/PackageKit-glib-1.2.8-8.el10_2.aarch64.rpm;name=aarch64_PackageKit-glib;unpack=0"
SRC_URI:append = " ${URI_aarch64_PackageKit-glib}"
SRC_URI[aarch64_PackageKit-glib.sha256sum] = "8c09fcc9c39f0a96dde5c653c37b8e16c1b3bd63283c02490fe94cae7d081941"

URI_aarch64_PackageKit-glib-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/PackageKit-glib-devel-1.2.8-8.el10_2.aarch64.rpm;name=aarch64_PackageKit-glib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_PackageKit-glib-devel}"
SRC_URI[aarch64_PackageKit-glib-devel.sha256sum] = "6654990c9cddc1e14788c7e389558527ba9dd2a7f0545a60f8418d42d6a39741"

URI_aarch64_PackageKit-gstreamer-plugin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/PackageKit-gstreamer-plugin-1.2.8-8.el10_2.aarch64.rpm;name=aarch64_PackageKit-gstreamer-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_PackageKit-gstreamer-plugin}"
SRC_URI[aarch64_PackageKit-gstreamer-plugin.sha256sum] = "9967bcb1d3c9e3a6dfe0f8cbcd2a6f2329f6289b2e1a8c5fd54314af6b0ac0c1"

URI_aarch64_PackageKit-gtk3-module = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/PackageKit-gtk3-module-1.2.8-8.el10_2.aarch64.rpm;name=aarch64_PackageKit-gtk3-module;unpack=0"
SRC_URI:append = " ${URI_aarch64_PackageKit-gtk3-module}"
SRC_URI[aarch64_PackageKit-gtk3-module.sha256sum] = "3935e84f01f16ecc5b470f00abed750421ea6d7b9e594d1747da2877ead894ff"

RDEPENDS:PackageKit = " \
 PackageKit-glib \
 appstream \
 bash \
 glib2 \
 glibc \
 libdnf \
 libgcc \
 polkit-libs \
 python3 \
 rpm-libs \
 shared-mime-info \
 sqlite-libs \
 systemd \
 systemd-libs \
 "
RDEPENDS:PackageKit-command-not-found = " \
 PackageKit \
 PackageKit-glib \
 bash \
 glib2 \
 glibc \
 libgcc \
 "
RDEPENDS:PackageKit-glib = " \
 dbus \
 glib2 \
 glibc \
 gobject-introspection \
 libgcc \
 "
RDEPENDS:PackageKit-glib-devel = " \
 PackageKit-glib \
 dbus-devel \
 glib2-devel \
 pkgconf-pkg-config \
 sqlite-devel \
 "
RDEPENDS:PackageKit-gstreamer-plugin = " \
 PackageKit-glib \
 glib2 \
 glibc \
 gstreamer1 \
 libgcc \
 "
RDEPENDS:PackageKit-gtk3-module = " \
 PackageKit-glib \
 fontconfig \
 glib2 \
 glibc \
 libgcc \
 pango \
 "
