# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-tls-session-manager"
PV = "0.0.4"
PR = "22.el10_0"
PACKAGES = " \
 ghc-tls-session-manager \
 ghc-tls-session-manager-devel \
 ghc-tls-session-manager-doc \
 ghc-tls-session-manager-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-tls-session-manager-0.0.4-22.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f2944e8fc45a6928d665e62a2a2b123342f4e4144145b398ca3cd7cfdc5c846d"

URI_x86_64_v2_ghc-tls-session-manager = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tls-session-manager-0.0.4-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tls-session-manager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tls-session-manager}"
SRC_URI[x86_64_v2_ghc-tls-session-manager.sha256sum] = "80fea0b90839b322cf9681732eecd813c56cace2431a7df1e13b26f581ff2b6c"

URI_x86_64_v2_ghc-tls-session-manager-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tls-session-manager-devel-0.0.4-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tls-session-manager-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tls-session-manager-devel}"
SRC_URI[x86_64_v2_ghc-tls-session-manager-devel.sha256sum] = "c7c27403cb0df6fe88ba6d4ae814d50d8df75e0cce471c9714f316233f9cc750"

URI_x86_64_v2_ghc-tls-session-manager-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tls-session-manager-doc-0.0.4-22.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-tls-session-manager-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tls-session-manager-doc}"
SRC_URI[x86_64_v2_ghc-tls-session-manager-doc.sha256sum] = "8fe44747a9c1c21b97e680422471b79d9baa9f455e315cb8ad570aeaf1a659b7"

URI_x86_64_v2_ghc-tls-session-manager-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tls-session-manager-prof-0.0.4-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tls-session-manager-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tls-session-manager-prof}"
SRC_URI[x86_64_v2_ghc-tls-session-manager-prof.sha256sum] = "2b612ea0be4392481b82ca0a2bd30607d9fae647791c3ab6d6a8179d936c8c77"

URI_aarch64_ghc-tls-session-manager = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tls-session-manager-0.0.4-22.el10_0.aarch64.rpm;name=aarch64_ghc-tls-session-manager;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tls-session-manager}"
SRC_URI[aarch64_ghc-tls-session-manager.sha256sum] = "9ea38410e5ee3beb2adf5576ede886dac3b2238628545a776fcbc5974b045b6f"

URI_aarch64_ghc-tls-session-manager-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tls-session-manager-devel-0.0.4-22.el10_0.aarch64.rpm;name=aarch64_ghc-tls-session-manager-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tls-session-manager-devel}"
SRC_URI[aarch64_ghc-tls-session-manager-devel.sha256sum] = "bcb382e2023f11504288f8838c380f1cb6b3b12181c7434a85476ad7f70e6ac6"

URI_aarch64_ghc-tls-session-manager-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tls-session-manager-doc-0.0.4-22.el10_0.noarch.rpm;name=aarch64_ghc-tls-session-manager-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tls-session-manager-doc}"
SRC_URI[aarch64_ghc-tls-session-manager-doc.sha256sum] = "b3347f781d4348ee6a420ebd70c7738e77c32ca74d9bb937d72a89990b4b3d69"

URI_aarch64_ghc-tls-session-manager-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tls-session-manager-prof-0.0.4-22.el10_0.aarch64.rpm;name=aarch64_ghc-tls-session-manager-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tls-session-manager-prof}"
SRC_URI[aarch64_ghc-tls-session-manager-prof.sha256sum] = "0ad1115a31876e49f55133d56690d78ac9ccd3228802096c72dc72feb0ab60ee"

RDEPENDS:ghc-tls-session-manager = " \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-async \
 ghc-auto-update \
 ghc-base \
 ghc-basement \
 ghc-binary \
 ghc-bytestring \
 ghc-cereal \
 ghc-clock \
 ghc-containers \
 ghc-crypton \
 ghc-crypton-x509 \
 ghc-crypton-x509-store \
 ghc-crypton-x509-validation \
 ghc-data-default-class \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hourglass \
 ghc-memory \
 ghc-mtl \
 ghc-network \
 ghc-old-locale \
 ghc-old-time \
 ghc-os-string \
 ghc-pem \
 ghc-pretty \
 ghc-psqueues \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-tls \
 ghc-transformers \
 ghc-unix \
 ghc-unix-time \
 glibc \
 gmp \
 "
RDEPENDS:ghc-tls-session-manager-devel = " \
 ghc-auto-update-devel \
 ghc-base-devel \
 ghc-basement-devel \
 ghc-bytestring-devel \
 ghc-clock-devel \
 ghc-compiler \
 ghc-memory-devel \
 ghc-psqueues-devel \
 ghc-tls-devel \
 ghc-tls-session-manager \
 "
RDEPENDS:ghc-tls-session-manager-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-tls-session-manager-prof = " \
 ghc-auto-update-prof \
 ghc-base-prof \
 ghc-basement-prof \
 ghc-bytestring-prof \
 ghc-clock-prof \
 ghc-memory-prof \
 ghc-psqueues-prof \
 ghc-tls-prof \
 ghc-tls-session-manager-devel \
 "
