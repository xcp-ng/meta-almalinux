# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pyproject-rpm-macros"
PV = "1.16.2"
PR = "1.el10"
PACKAGES = " \
 pyproject-rpm-macros \
 pyproject-srpm-macros \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pyproject-rpm-macros-1.16.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ed84b98c5a7d3edfd4cf6fcf073834aee303b31d47b50e74b9948087c29b2ee"

URI_x86_64_v2_pyproject-rpm-macros = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/pyproject-rpm-macros-1.16.2-1.el10.noarch.rpm;name=x86_64_v2_pyproject-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pyproject-rpm-macros}"
SRC_URI[x86_64_v2_pyproject-rpm-macros.sha256sum] = "9746adffd96a99139f6a21d1f6cff7ee1099d32498cf8e39ac70ef5713fd41ed"

URI_x86_64_v2_pyproject-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pyproject-srpm-macros-1.16.2-1.el10.noarch.rpm;name=x86_64_v2_pyproject-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pyproject-srpm-macros}"
SRC_URI[x86_64_v2_pyproject-srpm-macros.sha256sum] = "21a9d616192ee3486d7101534402caf72972790236bf0eb0e6f043e27f65187c"

URI_aarch64_pyproject-rpm-macros = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/pyproject-rpm-macros-1.16.2-1.el10.noarch.rpm;name=aarch64_pyproject-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_pyproject-rpm-macros}"
SRC_URI[aarch64_pyproject-rpm-macros.sha256sum] = "9746adffd96a99139f6a21d1f6cff7ee1099d32498cf8e39ac70ef5713fd41ed"

URI_aarch64_pyproject-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pyproject-srpm-macros-1.16.2-1.el10.noarch.rpm;name=aarch64_pyproject-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_pyproject-srpm-macros}"
SRC_URI[aarch64_pyproject-srpm-macros.sha256sum] = "21a9d616192ee3486d7101534402caf72972790236bf0eb0e6f043e27f65187c"

RDEPENDS:pyproject-rpm-macros = " \
 findutils \
 pyproject-srpm-macros \
 python-rpm-macros \
 python-srpm-macros \
 python3-rpm-macros \
 rpm-build \
 sed \
 "
RDEPENDS:pyproject-srpm-macros = " \
 pyproject-rpm-macros \
 rpm-build \
 "
