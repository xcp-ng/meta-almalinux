# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grafana-pcp"
PV = "6.1.0"
PR = "1.el10"
PACKAGES = " \
 grafana-pcp \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/grafana-pcp-6.1.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "73158921c4406866b165a50cf084e00e085a898ebdc2a7aac1917aa8fe2a39fc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/grafana-pcp-6.1.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_grafana-pcp;unpack=0"
SRC_URI[x86_64_v2_grafana-pcp.sha256sum] = "a8981ec4b43fa2f98507818ad88c3ee1c713983dff82979e1d2f0e57515b7616"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/grafana-pcp-6.1.0-1.el10.aarch64.rpm;name=aarch64_grafana-pcp;unpack=0"
SRC_URI[aarch64_grafana-pcp.sha256sum] = "167f986203a2c384a0fe34d7c113ce4edbd7b4cc963919d2d7c563318cbbfc6e"

RDEPENDS:grafana-pcp = " \
 bash \
 glibc \
 grafana \
 systemd \
 "
