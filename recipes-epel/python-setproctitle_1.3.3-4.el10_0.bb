# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-setproctitle"
PV = "1.3.3"
PR = "4.el10_0"
PACKAGES = " \
 python3-setproctitle \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-setproctitle-1.3.3-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5b92bf529ad3a59b217477942f7cbf3cfb1c2df613f3c53a4232fbc2533333b2"

URI_x86_64_v2_python3-setproctitle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-setproctitle-1.3.3-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-setproctitle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-setproctitle}"
SRC_URI[x86_64_v2_python3-setproctitle.sha256sum] = "df84073467e5bb707f7eff688b068767bf65b445fc8e0fb141ca18028e5f6a12"

URI_aarch64_python3-setproctitle = "${EPEL_MIRROR}/aarch64/Packages/p/python3-setproctitle-1.3.3-4.el10_0.aarch64.rpm;name=aarch64_python3-setproctitle;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-setproctitle}"
SRC_URI[aarch64_python3-setproctitle.sha256sum] = "675be5ad19e79dbbdfcbc70883ac6ba9775638e6b3eee8b6d07803f18bba5557"

RDEPENDS:python3-setproctitle = " \
 glibc \
 python3 \
 "
