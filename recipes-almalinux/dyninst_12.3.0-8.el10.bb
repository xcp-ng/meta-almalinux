# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dyninst"
PV = "12.3.0"
PR = "8.el10"
PACKAGES = " \
 dyninst \
 dyninst-devel \
 dyninst-doc \
 dyninst-testsuite \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dyninst-12.3.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55903fbf78683bc66de91aecf6dbd4add750fc9f49dede11074a0115697760ba"

URI_x86_64_v2_dyninst = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dyninst-12.3.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_dyninst;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dyninst}"
SRC_URI[x86_64_v2_dyninst.sha256sum] = "08a925c007b939950250588bff253284f38c5c4fecfe71bbe031a48a40ccac85"

URI_x86_64_v2_dyninst-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dyninst-devel-12.3.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_dyninst-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dyninst-devel}"
SRC_URI[x86_64_v2_dyninst-devel.sha256sum] = "445b6b131da8f3025d33ad9d04b5e88edcaf7277f25f0a394aa8102a11999368"

URI_x86_64_v2_dyninst-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dyninst-doc-12.3.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_dyninst-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dyninst-doc}"
SRC_URI[x86_64_v2_dyninst-doc.sha256sum] = "d3206997843dbdc3737fe2ee8c8e5c10b0bd2a471657c2415b26c4169b65364b"

URI_x86_64_v2_dyninst-testsuite = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dyninst-testsuite-12.3.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_dyninst-testsuite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dyninst-testsuite}"
SRC_URI[x86_64_v2_dyninst-testsuite.sha256sum] = "b6c9192333c62ce05cd52cc528eb3215b9f5e786f635e7a464d5f8f32cdc7a60"

URI_aarch64_dyninst = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dyninst-12.3.0-8.el10.aarch64.rpm;name=aarch64_dyninst;unpack=0"
SRC_URI:append = " ${URI_aarch64_dyninst}"
SRC_URI[aarch64_dyninst.sha256sum] = "cf4c8c4d11ad83d2899cecfbbafabd7ec289984efabd1dfa1600faa4ef068f46"

URI_aarch64_dyninst-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dyninst-devel-12.3.0-8.el10.aarch64.rpm;name=aarch64_dyninst-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dyninst-devel}"
SRC_URI[aarch64_dyninst-devel.sha256sum] = "2911484402e066442fd5706407b7504ee9b4fa532651e80672f34b1aecc588df"

URI_aarch64_dyninst-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dyninst-doc-12.3.0-8.el10.aarch64.rpm;name=aarch64_dyninst-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_dyninst-doc}"
SRC_URI[aarch64_dyninst-doc.sha256sum] = "283d21e9b3fbcecfef8f2837fb6b7a70b6d9c475b29df27ad375384946d39aa4"

URI_aarch64_dyninst-testsuite = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dyninst-testsuite-12.3.0-8.el10.aarch64.rpm;name=aarch64_dyninst-testsuite;unpack=0"
SRC_URI:append = " ${URI_aarch64_dyninst-testsuite}"
SRC_URI[aarch64_dyninst-testsuite.sha256sum] = "59177688937305bd6f1d0ee9b3408af2e766475e2418c2f5b70424859fc66223"

RDEPENDS:dyninst = " \
 boost-filesystem \
 boost-thread \
 elfutils-debuginfod-client \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 tbb \
 "
RDEPENDS:dyninst-devel = " \
 boost-devel \
 cmake-filesystem \
 dyninst \
 tbb-devel \
 "
RDEPENDS:dyninst-doc = " \
 "
RDEPENDS:dyninst-testsuite = " \
 dyninst \
 dyninst-devel \
 glibc \
 libgcc \
 libstdc++ \
 tbb \
 "
