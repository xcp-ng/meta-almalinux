# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-toml0.5"
PV = "0.5.11"
PR = "4.el10_0"
PACKAGES = " \
 rust-toml0.5+default-devel \
 rust-toml0.5+indexmap-devel \
 rust-toml0.5+preserve_order-devel \
 rust-toml0.5-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-toml0.5-0.5.11-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c59dc3a76f1158a2fb66d78fcc25ceebfd9405d17daf3b96597019adb3b3e22"

URI_x86_64_v2_rust-toml0.5+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml0.5+default-devel-0.5.11-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml0.5+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml0.5+default-devel}"
SRC_URI[x86_64_v2_rust-toml0.5+default-devel.sha256sum] = "4c988efbb55978f723334adb3ab28aa65414b7feeeeb9059b3fc779785630f31"

URI_x86_64_v2_rust-toml0.5+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml0.5+indexmap-devel-0.5.11-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml0.5+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml0.5+indexmap-devel}"
SRC_URI[x86_64_v2_rust-toml0.5+indexmap-devel.sha256sum] = "5f1867e552aff87e7049ea8a6ce2ebb7bd1d160cd97262e802198bd31222dd9a"

URI_x86_64_v2_rust-toml0.5+preserve_order-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml0.5+preserve_order-devel-0.5.11-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml0.5+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml0.5+preserve_order-devel}"
SRC_URI[x86_64_v2_rust-toml0.5+preserve_order-devel.sha256sum] = "0716efbdc138d10a0b96d962d6f04713191bb10428fa2bb0a1224bde566b7d2a"

URI_x86_64_v2_rust-toml0.5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml0.5-devel-0.5.11-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml0.5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml0.5-devel}"
SRC_URI[x86_64_v2_rust-toml0.5-devel.sha256sum] = "3bfe2225e9e4c6905a0cc75827e0faaf6e8a974f9b9f16839138d6570992c5ad"

URI_aarch64_rust-toml0.5+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml0.5+default-devel-0.5.11-4.el10_0.noarch.rpm;name=aarch64_rust-toml0.5+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml0.5+default-devel}"
SRC_URI[aarch64_rust-toml0.5+default-devel.sha256sum] = "a4e1cf0926ffd064d4168f7f952cbcb2296b8805a685282d5a847d38927e12b3"

URI_aarch64_rust-toml0.5+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml0.5+indexmap-devel-0.5.11-4.el10_0.noarch.rpm;name=aarch64_rust-toml0.5+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml0.5+indexmap-devel}"
SRC_URI[aarch64_rust-toml0.5+indexmap-devel.sha256sum] = "63043e0fadc39f544cfb56f0826154e45414859ecbc6af9e218979f65701192f"

URI_aarch64_rust-toml0.5+preserve_order-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml0.5+preserve_order-devel-0.5.11-4.el10_0.noarch.rpm;name=aarch64_rust-toml0.5+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml0.5+preserve_order-devel}"
SRC_URI[aarch64_rust-toml0.5+preserve_order-devel.sha256sum] = "5698a2e0d7fb4570cb16047c870f951cd734011c7377df3dfe54c0e1e83ed351"

URI_aarch64_rust-toml0.5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml0.5-devel-0.5.11-4.el10_0.noarch.rpm;name=aarch64_rust-toml0.5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml0.5-devel}"
SRC_URI[aarch64_rust-toml0.5-devel.sha256sum] = "356fe313c9e3b115936c0d38bf56f76f026cc44eee8b2069f1839470b5943120"

RDEPENDS:rust-toml0.5+default-devel = " \
 cargo \
 rust-toml0.5-devel \
 "
RDEPENDS:rust-toml0.5+indexmap-devel = " \
 cargo \
 rust-indexmap1+default-devel \
 rust-toml0.5-devel \
 "
RDEPENDS:rust-toml0.5+preserve_order-devel = " \
 cargo \
 rust-toml0.5+indexmap-devel \
 rust-toml0.5-devel \
 "
RDEPENDS:rust-toml0.5-devel = " \
 cargo \
 rust \
 rust-serde+default-devel \
 "
