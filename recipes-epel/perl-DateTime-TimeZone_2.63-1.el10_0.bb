# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-DateTime-TimeZone"
PV = "2.63"
PR = "1.el10_0"
PACKAGES = " \
 perl-DateTime-TimeZone \
 perl-DateTime-TimeZone-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-DateTime-TimeZone-2.63-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e162259eb9466ee97bf66199c84bd47fb67896a1222a26fac1fde6f4ca0468a"

URI_x86_64_v2_perl-DateTime-TimeZone = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DateTime-TimeZone-2.63-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-DateTime-TimeZone;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-DateTime-TimeZone}"
SRC_URI[x86_64_v2_perl-DateTime-TimeZone.sha256sum] = "8ab1540bd138b3ff409ac3231ceb2ca37d6932c4f03656b8b19a1375c5ae073f"

URI_x86_64_v2_perl-DateTime-TimeZone-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DateTime-TimeZone-tests-2.63-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-DateTime-TimeZone-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-DateTime-TimeZone-tests}"
SRC_URI[x86_64_v2_perl-DateTime-TimeZone-tests.sha256sum] = "1fa93fbc2b7c87dc59eb8b08125655600b3d00cbd12180d2d0e76e6ce32f32e8"

URI_aarch64_perl-DateTime-TimeZone = "${EPEL_MIRROR}/aarch64/Packages/p/perl-DateTime-TimeZone-2.63-1.el10_0.noarch.rpm;name=aarch64_perl-DateTime-TimeZone;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-DateTime-TimeZone}"
SRC_URI[aarch64_perl-DateTime-TimeZone.sha256sum] = "2486b414651046f5c7d7910c1c11cc4fa5daefe26fb9f4e7085f45dbab57ee51"

URI_aarch64_perl-DateTime-TimeZone-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-DateTime-TimeZone-tests-2.63-1.el10_0.noarch.rpm;name=aarch64_perl-DateTime-TimeZone-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-DateTime-TimeZone-tests}"
SRC_URI[aarch64_perl-DateTime-TimeZone-tests.sha256sum] = "505d838cf598d76005c75410e6554d33d9e4468d488458923872ce4ad3269fb4"

RDEPENDS:perl-DateTime-TimeZone = " \
 perl-Class-Singleton \
 perl-DateTime \
 perl-DateTime-TimeZone \
 perl-DateTime-TimeZone-Tzfile \
 perl-File-Basename \
 perl-File-Compare \
 perl-File-Find \
 perl-Module-Runtime \
 perl-Params-ValidationCompiler \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Specio \
 perl-Try-Tiny \
 perl-constant \
 perl-libs \
 perl-namespace-autoclean \
 perl-parent \
 "
RDEPENDS:perl-DateTime-TimeZone-tests = " \
 bash \
 perl-DateTime \
 perl-DateTime-TimeZone \
 perl-ExtUtils-MakeMaker \
 perl-File-Basename \
 perl-File-Path \
 perl-File-Temp \
 perl-PathTools \
 perl-Storable \
 perl-Sys-Hostname \
 perl-Test-Fatal \
 perl-Test-Harness \
 perl-Test-Output \
 perl-Test-Requires \
 perl-Test-Simple \
 perl-Test-Taint \
 perl-Try-Tiny \
 perl-base \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-overload \
 "
