# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo"
PV = "0.93.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-cargo+default-devel \
 rust-cargo+http-transport-curl-devel \
 rust-cargo+http-transport-reqwest-devel \
 rust-cargo+openssl-devel \
 rust-cargo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-0.93.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7cc2e4e22643a0a7642fb45ebece2e2ce8da9ea8ee10b44c34e79e9c6811b4d4"

URI_x86_64_v2_rust-cargo+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo+default-devel-0.93.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo+default-devel}"
SRC_URI[x86_64_v2_rust-cargo+default-devel.sha256sum] = "9ee2ca02863decf6dfbb6999531ac168bb1b0d392212f956d68ae69f2bc5ea6f"

URI_x86_64_v2_rust-cargo+http-transport-curl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo+http-transport-curl-devel-0.93.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo+http-transport-curl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo+http-transport-curl-devel}"
SRC_URI[x86_64_v2_rust-cargo+http-transport-curl-devel.sha256sum] = "06fd2096a6adc615c1c8d98148aeaef92a62c5148afc1faa18f688cd12c41228"

URI_x86_64_v2_rust-cargo+http-transport-reqwest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo+http-transport-reqwest-devel-0.93.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo+http-transport-reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo+http-transport-reqwest-devel}"
SRC_URI[x86_64_v2_rust-cargo+http-transport-reqwest-devel.sha256sum] = "3190b087da4009862bc81819c0722afb445f03be2a0eab97838752d031e5b839"

URI_x86_64_v2_rust-cargo+openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo+openssl-devel-0.93.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo+openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo+openssl-devel}"
SRC_URI[x86_64_v2_rust-cargo+openssl-devel.sha256sum] = "fd91d6f8b2be13d9caa82da60fae049dfd19a2431e5279bdd4026c29eaf02291"

URI_x86_64_v2_rust-cargo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-devel-0.93.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-devel}"
SRC_URI[x86_64_v2_rust-cargo-devel.sha256sum] = "04ae06f1a67bfd0615b00af749398c18e0b14f36617d7711e39f95170f6fc128"

URI_aarch64_rust-cargo+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo+default-devel-0.93.0-1.el10_2.noarch.rpm;name=aarch64_rust-cargo+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo+default-devel}"
SRC_URI[aarch64_rust-cargo+default-devel.sha256sum] = "73984fa9b64191fe0e3e01a01859b0e9dd331630fabac2d2fc933e99d50bb949"

URI_aarch64_rust-cargo+http-transport-curl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo+http-transport-curl-devel-0.93.0-1.el10_2.noarch.rpm;name=aarch64_rust-cargo+http-transport-curl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo+http-transport-curl-devel}"
SRC_URI[aarch64_rust-cargo+http-transport-curl-devel.sha256sum] = "c3f47e14b58f35f032c3e0294ece685656bbd0b33deeae95b4c65329067bf736"

URI_aarch64_rust-cargo+http-transport-reqwest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo+http-transport-reqwest-devel-0.93.0-1.el10_2.noarch.rpm;name=aarch64_rust-cargo+http-transport-reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo+http-transport-reqwest-devel}"
SRC_URI[aarch64_rust-cargo+http-transport-reqwest-devel.sha256sum] = "db11217cc014c381e0ab44acf3859d560924d6c50042786fbd512aadec6d1a19"

URI_aarch64_rust-cargo+openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo+openssl-devel-0.93.0-1.el10_2.noarch.rpm;name=aarch64_rust-cargo+openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo+openssl-devel}"
SRC_URI[aarch64_rust-cargo+openssl-devel.sha256sum] = "864a8b25da8c4d90a8b3482776e3372ed400358f8958b920780e5aef0754167f"

URI_aarch64_rust-cargo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-devel-0.93.0-1.el10_2.noarch.rpm;name=aarch64_rust-cargo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-devel}"
SRC_URI[aarch64_rust-cargo-devel.sha256sum] = "3e14cdea03505cb682fcd1745dfe3b718ff9e7181b62e3b69c346a485677c853"

RDEPENDS:rust-cargo+default-devel = " \
 cargo \
 rust-cargo+http-transport-curl-devel \
 rust-cargo-devel \
 "
RDEPENDS:rust-cargo+http-transport-curl-devel = " \
 cargo \
 rust-cargo-devel \
 rust-gix+blocking-http-transport-curl-devel \
 "
RDEPENDS:rust-cargo+http-transport-reqwest-devel = " \
 cargo \
 rust-cargo-devel \
 rust-gix+blocking-http-transport-reqwest-devel \
 "
RDEPENDS:rust-cargo+openssl-devel = " \
 cargo \
 rust-cargo-devel \
 rust-openssl+default-devel \
 "
RDEPENDS:rust-cargo-devel = " \
 cargo \
 rust \
 rust-annotate-snippets+default-devel \
 rust-annotate-snippets+simd-devel \
 rust-anstream0.6+default-devel \
 rust-anstyle+default-devel \
 rust-anyhow+default-devel \
 rust-base64+default-devel \
 rust-blake3+default-devel \
 rust-cargo-credential+default-devel \
 rust-cargo-credential-libsecret+default-devel \
 rust-cargo-platform+default-devel \
 rust-cargo-util+default-devel \
 rust-cargo-util-schemas+default-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-clap_complete+default-devel \
 rust-clap_complete+unstable-dynamic-devel \
 rust-color-print+default-devel \
 rust-crates-io+default-devel \
 rust-curl+default-devel \
 rust-curl+http2-devel \
 rust-curl-sys+default-devel \
 rust-filetime+default-devel \
 rust-flate2+zlib-rs-devel \
 rust-flate2-devel \
 rust-git2+default-devel \
 rust-git2-curl+default-devel \
 rust-gix+dirwalk-devel \
 rust-gix+parallel-devel \
 rust-gix+progress-tree-devel \
 rust-gix+status-devel \
 rust-gix-devel \
 rust-glob+default-devel \
 rust-hex+default-devel \
 rust-hmac+default-devel \
 rust-home+default-devel \
 rust-http-auth-devel \
 rust-ignore+default-devel \
 rust-im-rc+default-devel \
 rust-indexmap+default-devel \
 rust-itertools+default-devel \
 rust-jiff+std-devel \
 rust-jiff-devel \
 rust-jobserver+default-devel \
 rust-lazycell+default-devel \
 rust-libc+default-devel \
 rust-libgit2-sys+default-devel \
 rust-memchr+default-devel \
 rust-opener+default-devel \
 rust-os_info-devel \
 rust-pasetors+default-devel \
 rust-pasetors+paserk-devel \
 rust-pasetors+serde-devel \
 rust-pasetors+std-devel \
 rust-pasetors+v3-devel \
 rust-pathdiff+default-devel \
 rust-rand0.9+default-devel \
 rust-regex+default-devel \
 rust-rusqlite0.31+default-devel \
 rust-rustc-hash+default-devel \
 rust-rustc-stable-hash+default-devel \
 rust-rustfix+default-devel \
 rust-same-file+default-devel \
 rust-semver+default-devel \
 rust-semver+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde-untagged+default-devel \
 rust-serde_ignored+default-devel \
 rust-serde_json+default-devel \
 rust-serde_json+raw_value-devel \
 rust-sha1+default-devel \
 rust-shell-escape+default-devel \
 rust-supports-hyperlinks+default-devel \
 rust-supports-unicode+default-devel \
 rust-tar-devel \
 rust-tempfile+default-devel \
 rust-thiserror+default-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+parsing-devel \
 rust-time+serde-devel \
 rust-toml0.9+display-devel \
 rust-toml0.9+parse-devel \
 rust-toml0.9+preserve_order-devel \
 rust-toml0.9+serde-devel \
 rust-toml0.9+std-devel \
 rust-toml0.9-devel \
 rust-toml_edit0.23+default-devel \
 rust-toml_edit0.23+serde-devel \
 rust-tracing+attributes-devel \
 rust-tracing+std-devel \
 rust-tracing-chrome+default-devel \
 rust-tracing-devel \
 rust-tracing-subscriber+default-devel \
 rust-tracing-subscriber+env-filter-devel \
 rust-unicase+default-devel \
 rust-unicode-width+default-devel \
 rust-unicode-xid+default-devel \
 rust-url+default-devel \
 rust-walkdir+default-devel \
 rust-winnow+default-devel \
 "
