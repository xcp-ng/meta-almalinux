# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qatengine"
PV = "2.2.0"
PR = "1.el10"
PACKAGES:x86_64_v2 = " \
 qatengine \
"
PACKAGES:aarch64 = " \
  \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qatengine-2.2.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3c4b3b1814628fff3cfc3280b206f8651f0ab0004e777aac46fa96aefa81132f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qatengine-2.2.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_qatengine;unpack=0"
SRC_URI[x86_64_v2_qatengine.sha256sum] = "3b55421204e99ff33ec7db755e989ed98f45fee6263c86b5c786870edc0c74bf"

RDEPENDS:qatengine = " \
 glibc \
 qatlib \
 "
