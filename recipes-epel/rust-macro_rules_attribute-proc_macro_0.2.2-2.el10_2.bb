# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-macro_rules_attribute-proc_macro"
PV = "0.2.2"
PR = "2.el10_2"
PACKAGES = " \
 rust-macro_rules_attribute-proc_macro+default-devel \
 rust-macro_rules_attribute-proc_macro+verbose-expansions-devel \
 rust-macro_rules_attribute-proc_macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-macro_rules_attribute-proc_macro-0.2.2-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4afdd15e5dee1a50a28fad17c2e34b8ca941f7e21a424374cb2552a31d0a724c"

URI_x86_64_v2_rust-macro_rules_attribute-proc_macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-macro_rules_attribute-proc_macro+default-devel-0.2.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-macro_rules_attribute-proc_macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-macro_rules_attribute-proc_macro+default-devel}"
SRC_URI[x86_64_v2_rust-macro_rules_attribute-proc_macro+default-devel.sha256sum] = "8ba3c21a1db6a79ab767eb5d888239e2cfb65ed1b7576f5a9d2d770fbd045b64"

URI_x86_64_v2_rust-macro_rules_attribute-proc_macro+verbose-expansions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-macro_rules_attribute-proc_macro+verbose-expansions-devel-0.2.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-macro_rules_attribute-proc_macro+verbose-expansions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-macro_rules_attribute-proc_macro+verbose-expansions-devel}"
SRC_URI[x86_64_v2_rust-macro_rules_attribute-proc_macro+verbose-expansions-devel.sha256sum] = "374dcf7bdf6a02cced37826e6a3ac151e59ee50a97ba0a9eae7f9ca59485badf"

URI_x86_64_v2_rust-macro_rules_attribute-proc_macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-macro_rules_attribute-proc_macro-devel-0.2.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-macro_rules_attribute-proc_macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-macro_rules_attribute-proc_macro-devel}"
SRC_URI[x86_64_v2_rust-macro_rules_attribute-proc_macro-devel.sha256sum] = "8f3744e33d0e5d2919e0fb73e8bd84a855e4b981b0a2aed5ab8568b73c70ce1f"

URI_aarch64_rust-macro_rules_attribute-proc_macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-macro_rules_attribute-proc_macro+default-devel-0.2.2-2.el10_2.noarch.rpm;name=aarch64_rust-macro_rules_attribute-proc_macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-macro_rules_attribute-proc_macro+default-devel}"
SRC_URI[aarch64_rust-macro_rules_attribute-proc_macro+default-devel.sha256sum] = "bb6a79b10ce244056b984ec7af7e8146bdd2fea64b936fa819d1e1a6b0d33ed0"

URI_aarch64_rust-macro_rules_attribute-proc_macro+verbose-expansions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-macro_rules_attribute-proc_macro+verbose-expansions-devel-0.2.2-2.el10_2.noarch.rpm;name=aarch64_rust-macro_rules_attribute-proc_macro+verbose-expansions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-macro_rules_attribute-proc_macro+verbose-expansions-devel}"
SRC_URI[aarch64_rust-macro_rules_attribute-proc_macro+verbose-expansions-devel.sha256sum] = "49a5bbe1c97f86a84c6e9572e643ddee13abd192494b7db0073a1f134ce1d2de"

URI_aarch64_rust-macro_rules_attribute-proc_macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-macro_rules_attribute-proc_macro-devel-0.2.2-2.el10_2.noarch.rpm;name=aarch64_rust-macro_rules_attribute-proc_macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-macro_rules_attribute-proc_macro-devel}"
SRC_URI[aarch64_rust-macro_rules_attribute-proc_macro-devel.sha256sum] = "8c46d4433f5922910d6fb7340d90fa95f3474325f8c5ee744c92592bb4222337"

RDEPENDS:rust-macro_rules_attribute-proc_macro+default-devel = " \
 cargo \
 rust-macro_rules_attribute-proc_macro-devel \
 "
RDEPENDS:rust-macro_rules_attribute-proc_macro+verbose-expansions-devel = " \
 cargo \
 rust-macro_rules_attribute-proc_macro-devel \
 "
RDEPENDS:rust-macro_rules_attribute-proc_macro-devel = " \
 cargo \
 "
