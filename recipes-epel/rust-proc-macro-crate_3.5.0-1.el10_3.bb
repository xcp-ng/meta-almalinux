# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-proc-macro-crate"
PV = "3.5.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-proc-macro-crate+default-devel \
 rust-proc-macro-crate-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-proc-macro-crate-3.5.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a2e3c0722f69b78ac3ea58d0e0d2cadf1b6bc0e69bbefa0016be582cbd06dd81"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-crate+default-devel-3.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-crate+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-proc-macro-crate+default-devel.sha256sum] = "a346a3760ac81036141dcdab7a96afe419f29771cdc38b5cf0f9dbe674a3ea4f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-crate-devel-3.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-crate-devel;unpack=0"
SRC_URI[x86_64_v2_rust-proc-macro-crate-devel.sha256sum] = "1d7c8bd8bcc823e5bc75cd672f8a633314e89c8626f753aea889df9cb8d617eb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-crate+default-devel-3.5.0-1.el10_3.noarch.rpm;name=aarch64_rust-proc-macro-crate+default-devel;unpack=0"
SRC_URI[aarch64_rust-proc-macro-crate+default-devel.sha256sum] = "f6bf4785c9f03fedf9f8b0f0b3ec5333f4ff865f3d9df9d65b54d0a19f928c66"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-crate-devel-3.5.0-1.el10_3.noarch.rpm;name=aarch64_rust-proc-macro-crate-devel;unpack=0"
SRC_URI[aarch64_rust-proc-macro-crate-devel.sha256sum] = "521ab3b997c3abc12ad5d5e05305bf80700878c3122845a6b22b7fc313fe93fc"

RDEPENDS:rust-proc-macro-crate+default-devel = " \
 cargo \
 rust-proc-macro-crate-devel \
 "
RDEPENDS:rust-proc-macro-crate-devel = " \
 cargo \
 rust \
 rust-toml_edit+parse-devel \
 rust-toml_edit-devel \
 "
