# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tar"
PV = "0.4.45"
PR = "1.el10_1"
PACKAGES = " \
 rust-tar+default-devel \
 rust-tar+xattr-devel \
 rust-tar-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tar-0.4.45-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "294845c18f02213cba7b7872aa3b2611146e7ae1d2610a6203161ce309f21f57"

URI_x86_64_v2_rust-tar+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tar+default-devel-0.4.45-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tar+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tar+default-devel}"
SRC_URI[x86_64_v2_rust-tar+default-devel.sha256sum] = "6a2bbc3b6d59b5cb192fa044b5ec32c0f652b82a5a82f54946d46764a4d4ff06"

URI_x86_64_v2_rust-tar+xattr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tar+xattr-devel-0.4.45-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tar+xattr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tar+xattr-devel}"
SRC_URI[x86_64_v2_rust-tar+xattr-devel.sha256sum] = "6a9452644055c088385b0cb9e7352222f6e038ee88aef88a26512375dd57c721"

URI_x86_64_v2_rust-tar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tar-devel-0.4.45-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tar-devel}"
SRC_URI[x86_64_v2_rust-tar-devel.sha256sum] = "6c98e0ad09904de8288303eb627e37c5177a7543c9ce7dfb15ea381889898d7d"

URI_aarch64_rust-tar+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tar+default-devel-0.4.45-1.el10_1.noarch.rpm;name=aarch64_rust-tar+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tar+default-devel}"
SRC_URI[aarch64_rust-tar+default-devel.sha256sum] = "dbcb95dc766a11c87dd1e751ad78a28b2ea470698cf368ac53a176fabe799d2b"

URI_aarch64_rust-tar+xattr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tar+xattr-devel-0.4.45-1.el10_1.noarch.rpm;name=aarch64_rust-tar+xattr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tar+xattr-devel}"
SRC_URI[aarch64_rust-tar+xattr-devel.sha256sum] = "0326f4a5d540318819d10d406f193f49439e9b5f18ee0a9370fa761583e90a3c"

URI_aarch64_rust-tar-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tar-devel-0.4.45-1.el10_1.noarch.rpm;name=aarch64_rust-tar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tar-devel}"
SRC_URI[aarch64_rust-tar-devel.sha256sum] = "2f11d7071e143b7701658c192908c44c7307d16604ee4b226516956f2152968d"

RDEPENDS:rust-tar+default-devel = " \
 cargo \
 rust-tar+xattr-devel \
 rust-tar-devel \
 "
RDEPENDS:rust-tar+xattr-devel = " \
 cargo \
 rust-tar-devel \
 rust-xattr+default-devel \
 "
RDEPENDS:rust-tar-devel = " \
 cargo \
 rust \
 rust-filetime+default-devel \
 rust-libc+default-devel \
 "
