# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "CUnit"
PV = "2.1.3"
PR = "34.el10"
PACKAGES = " \
 CUnit \
 CUnit-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/CUnit-2.1.3-34.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b46bd70f5dbfac638280f9fbc83a418225d1477dab4fa9dc1305d703df9422a"

URI_x86_64_v2_CUnit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/CUnit-2.1.3-34.el10.x86_64_v2.rpm;name=x86_64_v2_CUnit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_CUnit}"
SRC_URI[x86_64_v2_CUnit.sha256sum] = "7a2fa3f54979bc649887403ccf4aa853468f1d1a95e46bb20aaf7a73de610ad6"

URI_x86_64_v2_CUnit-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/CUnit-devel-2.1.3-34.el10.x86_64_v2.rpm;name=x86_64_v2_CUnit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_CUnit-devel}"
SRC_URI[x86_64_v2_CUnit-devel.sha256sum] = "4d58d752b933dab2a9247b7ff8c66557628e5eefa82c61f56d3914bc2b4cc7c1"

URI_aarch64_CUnit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/CUnit-2.1.3-34.el10.aarch64.rpm;name=aarch64_CUnit;unpack=0"
SRC_URI:append = " ${URI_aarch64_CUnit}"
SRC_URI[aarch64_CUnit.sha256sum] = "193fc98d95ed83df00d9f56679173b0ce8c5b67698ccdf9cbd2f3b525b0e92c6"

URI_aarch64_CUnit-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/CUnit-devel-2.1.3-34.el10.aarch64.rpm;name=aarch64_CUnit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_CUnit-devel}"
SRC_URI[aarch64_CUnit-devel.sha256sum] = "e31876e052396390dcedb75ba53c53476652ae405b7d5693545d7724efc08e04"

RDEPENDS:CUnit = " \
 glibc \
 "
RDEPENDS:CUnit-devel = " \
 CUnit \
 pkgconf-pkg-config \
 "
