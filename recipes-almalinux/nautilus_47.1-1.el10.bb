# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nautilus"
PV = "47.1"
PR = "1.el10"
PACKAGES = " \
 nautilus \
 nautilus-devel \
 nautilus-extensions \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nautilus-47.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a1e1b27116de5e5576a3830081b19217ea4c758ae00a45411abf340157c0052"

URI_x86_64_v2_nautilus = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nautilus-47.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_nautilus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nautilus}"
SRC_URI[x86_64_v2_nautilus.sha256sum] = "f9b364a73ed434495f45ace5c1c5306e0e0c877bf4170e195d35c6e468c083f6"

URI_x86_64_v2_nautilus-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nautilus-devel-47.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_nautilus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nautilus-devel}"
SRC_URI[x86_64_v2_nautilus-devel.sha256sum] = "75bb578766d739d3e4de755ccfdfdea51a248a70d0fd111f5cc699c562a21263"

URI_x86_64_v2_nautilus-extensions = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nautilus-extensions-47.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_nautilus-extensions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nautilus-extensions}"
SRC_URI[x86_64_v2_nautilus-extensions.sha256sum] = "6606dbd2b3298482764fbf020b91447200fdabe226dc91a8021bac10292abd6a"

URI_aarch64_nautilus = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nautilus-47.1-1.el10.aarch64.rpm;name=aarch64_nautilus;unpack=0"
SRC_URI:append = " ${URI_aarch64_nautilus}"
SRC_URI[aarch64_nautilus.sha256sum] = "5e414fffa6cd5a7460c0b50019a5ddce6327b5023328a04f6a9a91fe351b8b5c"

URI_aarch64_nautilus-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nautilus-devel-47.1-1.el10.aarch64.rpm;name=aarch64_nautilus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nautilus-devel}"
SRC_URI[aarch64_nautilus-devel.sha256sum] = "c602c5cba6f8520473a5113acaaceb97ee769205d309b8c1d24553dabdd1a74a"

URI_aarch64_nautilus-extensions = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nautilus-extensions-47.1-1.el10.aarch64.rpm;name=aarch64_nautilus-extensions;unpack=0"
SRC_URI:append = " ${URI_aarch64_nautilus-extensions}"
SRC_URI[aarch64_nautilus-extensions.sha256sum] = "51e5d60f18bfca37ccc7b308dad056e776513a44eff041b999d87908dce4128a"

RDEPENDS:nautilus = " \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gnome-autoar \
 gnome-desktop4 \
 graphene \
 gsettings-desktop-schemas \
 gstreamer1 \
 gstreamer1-plugins-base \
 gtk4 \
 gvfs \
 libX11 \
 libadwaita \
 libgcc \
 libgexiv2 \
 libportal \
 libportal-gtk4 \
 libselinux \
 libtracker-sparql \
 libwayland-client \
 nautilus-extensions \
 pango \
 tracker-miners \
 "
RDEPENDS:nautilus-devel = " \
 glib2-devel \
 nautilus \
 nautilus-extensions \
 pkgconf-pkg-config \
 "
RDEPENDS:nautilus-extensions = " \
 glib2 \
 glibc \
 libgcc \
 "
