# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "powerdevil"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 powerdevil \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/powerdevil-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90327f85b1feb769146b5878cc69e6e69516ac2b9fada50f92a4033befade5f5"

URI_x86_64_v2_powerdevil = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/powerdevil-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_powerdevil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_powerdevil}"
SRC_URI[x86_64_v2_powerdevil.sha256sum] = "74f4d1cdbefd8cfcbbc150daca458be67e6e8d1c696c441f0fb4b2531f1d15bd"

URI_aarch64_powerdevil = "${EPEL_MIRROR}/aarch64/Packages/p/powerdevil-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_powerdevil;unpack=0"
SRC_URI:append = " ${URI_aarch64_powerdevil}"
SRC_URI[aarch64_powerdevil.sha256sum] = "35153dd41d66e354074f5a41084449b32f438b7ea44042ab2b41fc2ad9923301"

RDEPENDS:powerdevil = " \
 ddcutil \
 glibc \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kidletime \
 kf6-kirigami \
 kf6-knotifications \
 kf6-krunner \
 kf6-kservice \
 kf6-kxmlgui \
 kf6-solid \
 libddcutil \
 libkscreen \
 libkworkspace6 \
 libstdc++ \
 libwayland-client \
 libxcb \
 plasma-activities \
 qcoro-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwayland \
 systemd-libs \
 "
