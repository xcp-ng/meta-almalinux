# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libisofs"
PV = "1.5.6"
PR = "6.el10"
PACKAGES = " \
 libisofs \
 libisofs-devel \
 libisofs-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libisofs-1.5.6-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b252b937d9a740f785ad603855a75e2570df55c1bf2c55815b34698c8b06f670"

URI_x86_64_v2_libisofs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libisofs-1.5.6-6.el10.x86_64_v2.rpm;name=x86_64_v2_libisofs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libisofs}"
SRC_URI[x86_64_v2_libisofs.sha256sum] = "e5dfbbab0d28911ec85d2c7cc976db8285a219213a9cc76e7ba9420748acc37d"

URI_x86_64_v2_libisofs-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libisofs-devel-1.5.6-6.el10.x86_64_v2.rpm;name=x86_64_v2_libisofs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libisofs-devel}"
SRC_URI[x86_64_v2_libisofs-devel.sha256sum] = "8a0f04e1b2fb0dd3278e25b303312ff4cb343390b3bd6618aa772fbda320941f"

URI_x86_64_v2_libisofs-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libisofs-doc-1.5.6-6.el10.noarch.rpm;name=x86_64_v2_libisofs-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libisofs-doc}"
SRC_URI[x86_64_v2_libisofs-doc.sha256sum] = "e2c4082c959ce6cd709876bd9c1e65f4cae5fbeab296628a94c9579b55942cb0"

URI_aarch64_libisofs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libisofs-1.5.6-6.el10.aarch64.rpm;name=aarch64_libisofs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libisofs}"
SRC_URI[aarch64_libisofs.sha256sum] = "c486e2f171b0f9859e39051df663e6c061fdb293aaa1ac58b2ccc6fce82f3102"

URI_aarch64_libisofs-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libisofs-devel-1.5.6-6.el10.aarch64.rpm;name=aarch64_libisofs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libisofs-devel}"
SRC_URI[aarch64_libisofs-devel.sha256sum] = "e0a30fd409b2af1ff254a069cd18a9f29fadc108c0877f8d76adfaaa20db4cf2"

URI_aarch64_libisofs-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libisofs-doc-1.5.6-6.el10.noarch.rpm;name=aarch64_libisofs-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libisofs-doc}"
SRC_URI[aarch64_libisofs-doc.sha256sum] = "e2c4082c959ce6cd709876bd9c1e65f4cae5fbeab296628a94c9579b55942cb0"

RDEPENDS:libisofs = " \
 glibc \
 libacl \
 zlib-ng-compat \
 "
RDEPENDS:libisofs-devel = " \
 libisofs \
 pkgconf-pkg-config \
 "
RDEPENDS:libisofs-doc = " \
 "
