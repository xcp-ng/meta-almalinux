# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kontactinterface"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kontactinterface \
 kontactinterface-devel \
 kontactinterface-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kontactinterface-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f1913b8f6591a213f56e4d958c8a1103129a7537f0c220f38c4ef32fbc17a488"

URI_x86_64_v2_kontactinterface = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kontactinterface-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kontactinterface;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kontactinterface}"
SRC_URI[x86_64_v2_kontactinterface.sha256sum] = "fbab6f3717185c1e5fbbd260266231747a62d5c360837e2bbed4fe2619fbed7a"

URI_x86_64_v2_kontactinterface-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kontactinterface-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kontactinterface-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kontactinterface-devel}"
SRC_URI[x86_64_v2_kontactinterface-devel.sha256sum] = "a42ad158b15cb47c10ecfdbc5b75f5c7d43ac8bb81f9b0da618f8773f10e83ba"

URI_x86_64_v2_kontactinterface-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kontactinterface-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kontactinterface-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kontactinterface-doc}"
SRC_URI[x86_64_v2_kontactinterface-doc.sha256sum] = "ad25330e7ffe906861e493c6948726f8aac97fd24781a5c3439b3be0b3549f42"

URI_aarch64_kontactinterface = "${EPEL_MIRROR}/aarch64/Packages/k/kontactinterface-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kontactinterface;unpack=0"
SRC_URI:append = " ${URI_aarch64_kontactinterface}"
SRC_URI[aarch64_kontactinterface.sha256sum] = "856e629573f403e5295e2e3084acf00025425372851d0df10012d38820e5c7ba"

URI_aarch64_kontactinterface-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kontactinterface-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kontactinterface-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kontactinterface-devel}"
SRC_URI[aarch64_kontactinterface-devel.sha256sum] = "96689b1aeed599e9db05aa6a5e9b42481e3c5c6901ace13f0f8c711dcc4f58f5"

URI_aarch64_kontactinterface-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kontactinterface-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_kontactinterface-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kontactinterface-doc}"
SRC_URI[aarch64_kontactinterface-doc.sha256sum] = "88fc57200c5337b241f74d4174ced0cc105782e4ec4ce9044a079de8a10cd656"

RDEPENDS:kontactinterface = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kio-gui \
 kf6-kparts \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kontactinterface-devel = " \
 cmake-filesystem \
 kf6-kparts-devel \
 kontactinterface \
 "
RDEPENDS:kontactinterface-doc = " \
 "
