# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-treq"
PV = "25.5.0"
PR = "1.el10_3"
PACKAGES = " \
 python-treq-doc \
 python3-treq \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-treq-25.5.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "71549e29517c7d064eeb2fb73d8ad2c0ae9ca722d2f15090fbb2cd3943fc18bd"

URI_x86_64_v2_python-treq-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-treq-doc-25.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-treq-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-treq-doc}"
SRC_URI[x86_64_v2_python-treq-doc.sha256sum] = "47ab1491cf919ded25bdd30b33cd66a61e52fc0a29aa99cd23b0ef7f075eff75"

URI_x86_64_v2_python3-treq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-treq-25.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-treq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-treq}"
SRC_URI[x86_64_v2_python3-treq.sha256sum] = "bc61b25a7a8e6bb6a533506c0479668810e3df672b0194386a407694aea0b926"

URI_aarch64_python-treq-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-treq-doc-25.5.0-1.el10_3.noarch.rpm;name=aarch64_python-treq-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-treq-doc}"
SRC_URI[aarch64_python-treq-doc.sha256sum] = "1d660f3ead21c6127518f6ed411f0b52af8d15b4358a369bbe2e89e5ecb41f14"

URI_aarch64_python3-treq = "${EPEL_MIRROR}/aarch64/Packages/p/python3-treq-25.5.0-1.el10_3.noarch.rpm;name=aarch64_python3-treq;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-treq}"
SRC_URI[aarch64_python3-treq.sha256sum] = "e369214e3291f1cf938561f2affbab08efa596632b35720d05f6b17d7b149de3"

RDEPENDS:python-treq-doc = " \
 "
RDEPENDS:python3-treq = " \
 python3 \
 python3-attrs \
 python3-hyperlink \
 python3-incremental \
 python3-multipart \
 python3-requests \
 python3-twisted \
 python3-twisted+tls \
 python3-typing-extensions \
 "
