# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-house"
PV = "0.3.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-tree-house+default-devel \
 rust-tree-house+fixtures-devel \
 rust-tree-house-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-house-0.3.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0dfd2d443e704399c01614b3c4254e07ac34eadd27233cbf11c2b701d368f6de"

URI_x86_64_v2_rust-tree-house+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-house+default-devel-0.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-house+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-house+default-devel}"
SRC_URI[x86_64_v2_rust-tree-house+default-devel.sha256sum] = "773fa823081a6629f024036674355e4f5480d9344aebc978c187de2fd764e0ea"

URI_x86_64_v2_rust-tree-house+fixtures-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-house+fixtures-devel-0.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-house+fixtures-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-house+fixtures-devel}"
SRC_URI[x86_64_v2_rust-tree-house+fixtures-devel.sha256sum] = "74060b731be6f9a29f436b4af8707c8d925428301a2003d494f25262286728ce"

URI_x86_64_v2_rust-tree-house-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-house-devel-0.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-house-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-house-devel}"
SRC_URI[x86_64_v2_rust-tree-house-devel.sha256sum] = "f265d4dccba74ea42e16972c13cab426db9fc97790219a6f62083f64b4b41656"

URI_aarch64_rust-tree-house+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-house+default-devel-0.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-tree-house+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-house+default-devel}"
SRC_URI[aarch64_rust-tree-house+default-devel.sha256sum] = "b3944dfeb422abd35e99b54be39f1e28dffccefcb9a27c954a55a67179a404bc"

URI_aarch64_rust-tree-house+fixtures-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-house+fixtures-devel-0.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-tree-house+fixtures-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-house+fixtures-devel}"
SRC_URI[aarch64_rust-tree-house+fixtures-devel.sha256sum] = "b58a517532d0bbc7f6ec96c775584e01fff10eef6e0ab612acecc97d4c5e1121"

URI_aarch64_rust-tree-house-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-house-devel-0.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-tree-house-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-house-devel}"
SRC_URI[aarch64_rust-tree-house-devel.sha256sum] = "4790dbf6bce9695e0eb86217debe2afd076d63ec82ae7d1dd963db382a21ef73"

RDEPENDS:rust-tree-house+default-devel = " \
 cargo \
 rust-tree-house+fixtures-devel \
 rust-tree-house-devel \
 "
RDEPENDS:rust-tree-house+fixtures-devel = " \
 cargo \
 rust-pretty_assertions+default-devel \
 rust-tree-house-devel \
 rust-unicode-width0.1+default-devel \
 "
RDEPENDS:rust-tree-house-devel = " \
 cargo \
 rust \
 rust-arc-swap+default-devel \
 rust-hashbrown0.15+default-devel \
 rust-kstring+default-devel \
 rust-once_cell+alloc-devel \
 rust-once_cell+std-devel \
 rust-once_cell-devel \
 rust-regex+default-devel \
 rust-regex-cursor+default-devel \
 rust-ropey-devel \
 rust-slab+default-devel \
 rust-tree-house-bindings+default-devel \
 rust-tree-house-bindings+ropey-devel \
 "
