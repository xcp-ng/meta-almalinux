# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "soundtouch"
PV = "2.3.1"
PR = "8.el10"
PACKAGES = " \
 soundtouch \
 soundtouch-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/soundtouch-2.3.1-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "204ccbeeda9421e227c92ca764a5e0d9ff93a662bffca450c6f286946031adf2"

URI_x86_64_v2_soundtouch = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/soundtouch-2.3.1-8.el10.x86_64_v2.rpm;name=x86_64_v2_soundtouch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_soundtouch}"
SRC_URI[x86_64_v2_soundtouch.sha256sum] = "2225d0f262ac05065b36b06879bfddaaef8da620f7cb91c32ff54d3c246a33d0"

URI_x86_64_v2_soundtouch-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/soundtouch-devel-2.3.1-8.el10.x86_64_v2.rpm;name=x86_64_v2_soundtouch-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_soundtouch-devel}"
SRC_URI[x86_64_v2_soundtouch-devel.sha256sum] = "5a85a0d06a49db14101e998d298a8edb7230e104791fde70c517728bc6469067"

URI_aarch64_soundtouch = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/soundtouch-2.3.1-8.el10.aarch64.rpm;name=aarch64_soundtouch;unpack=0"
SRC_URI:append = " ${URI_aarch64_soundtouch}"
SRC_URI[aarch64_soundtouch.sha256sum] = "7b6090790d334116812f83b0dc8bdcd120d3c7cc35ca5723757a63b9a0b47aa2"

URI_aarch64_soundtouch-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/soundtouch-devel-2.3.1-8.el10.aarch64.rpm;name=aarch64_soundtouch-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_soundtouch-devel}"
SRC_URI[aarch64_soundtouch-devel.sha256sum] = "9c2aef601b3acede6b9915f18d7f24c580c5c548932b7e6012d94901e10adad1"

RDEPENDS:soundtouch = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:soundtouch-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 soundtouch \
 "
