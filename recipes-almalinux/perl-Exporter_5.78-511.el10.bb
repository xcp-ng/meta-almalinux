# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Exporter"
PV = "5.78"
PR = "511.el10"
PACKAGES = " \
 perl-Exporter \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Exporter-5.78-511.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8ad1b80844b4f41496987e879594a1049c0dacf94bfba69dfee5ae7f356ea5b3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Exporter-5.78-511.el10.noarch.rpm;name=x86_64_v2_perl-Exporter;unpack=0"
SRC_URI[x86_64_v2_perl-Exporter.sha256sum] = "3c23ebc3c23a498244aabebf0f6ca0257daf33423885f615b3602700823e6c7b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Exporter-5.78-511.el10.noarch.rpm;name=aarch64_perl-Exporter;unpack=0"
SRC_URI[aarch64_perl-Exporter.sha256sum] = "3c23ebc3c23a498244aabebf0f6ca0257daf33423885f615b3602700823e6c7b"

RDEPENDS:perl-Exporter = " \
 perl-Carp \
 perl-libs \
 "
