# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtserialbus"
PV = "6.9.1"
PR = "2.el10"
PACKAGES = " \
 qt6-qtserialbus \
 qt6-qtserialbus-devel \
 qt6-qtserialbus-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtserialbus-6.9.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "82901c2b84ab58190a132bc53db9b4988526f001c2e0e3e6e47e7cf57c7bc3ef"

URI_x86_64_v2_qt6-qtserialbus = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtserialbus-6.9.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtserialbus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtserialbus}"
SRC_URI[x86_64_v2_qt6-qtserialbus.sha256sum] = "3f9c2bf152c51ebc115d1fbb1543d1413d3341ed7e435e37813d55cacd90bcca"

URI_x86_64_v2_qt6-qtserialbus-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtserialbus-devel-6.9.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtserialbus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtserialbus-devel}"
SRC_URI[x86_64_v2_qt6-qtserialbus-devel.sha256sum] = "b8013fc3e59ae6985302a94f72dad663663f8a6e6c23947840fcd0acb2d6a994"

URI_x86_64_v2_qt6-qtserialbus-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtserialbus-examples-6.9.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtserialbus-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtserialbus-examples}"
SRC_URI[x86_64_v2_qt6-qtserialbus-examples.sha256sum] = "1e19899d3e77f2b416c3900d3840d99dec9b74682716814ba437a7f79fab2daf"

URI_aarch64_qt6-qtserialbus = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtserialbus-6.9.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtserialbus;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtserialbus}"
SRC_URI[aarch64_qt6-qtserialbus.sha256sum] = "0c99ee6dfef3d90c58c03d60b0f8af2b5f6766516ad7db500289efe1b600db92"

URI_aarch64_qt6-qtserialbus-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtserialbus-devel-6.9.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtserialbus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtserialbus-devel}"
SRC_URI[aarch64_qt6-qtserialbus-devel.sha256sum] = "cdb0ee791cbf9af7a87446947064d377bfd5b6a7a67ee88da6eb14ce00ebc3a3"

URI_aarch64_qt6-qtserialbus-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtserialbus-examples-6.9.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtserialbus-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtserialbus-examples}"
SRC_URI[aarch64_qt6-qtserialbus-examples.sha256sum] = "8b82f6a97ce7b525cc77205c564f3749a3ceff50b5308e9aea6f47eeb87c8cc9"

RDEPENDS:qt6-qtserialbus = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtserialport \
 "
RDEPENDS:qt6-qtserialbus-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtserialbus \
 qt6-qtserialport-devel \
 "
RDEPENDS:qt6-qtserialbus-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtserialbus \
 qt6-qtserialport \
 "
