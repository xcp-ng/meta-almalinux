# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-phf_codegen"
PV = "0.11.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-phf_codegen+default-devel \
 rust-phf_codegen-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-phf_codegen-0.11.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "29fa784b07f76025de0cafce1496136458755d802914a33e92c47be0c0e020b6"

URI_x86_64_v2_rust-phf_codegen+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_codegen+default-devel-0.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_codegen+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_codegen+default-devel}"
SRC_URI[x86_64_v2_rust-phf_codegen+default-devel.sha256sum] = "a428bb1735f053acdcb9cd268089ac72b0441d5f04a9b77facdfc57060f14754"

URI_x86_64_v2_rust-phf_codegen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_codegen-devel-0.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_codegen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_codegen-devel}"
SRC_URI[x86_64_v2_rust-phf_codegen-devel.sha256sum] = "801d3210462e1b8ef50ba6c95710a313240a5560edb486f6da0cb5cfd0f177ac"

URI_aarch64_rust-phf_codegen+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_codegen+default-devel-0.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-phf_codegen+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_codegen+default-devel}"
SRC_URI[aarch64_rust-phf_codegen+default-devel.sha256sum] = "4ab4cb3125a4a6602f7ab4f043ed7e6b9130bdb75ec51fd5fea474dbd48158a9"

URI_aarch64_rust-phf_codegen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_codegen-devel-0.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-phf_codegen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_codegen-devel}"
SRC_URI[aarch64_rust-phf_codegen-devel.sha256sum] = "519cb5a1845ea45583553215cc1682840983214b1caf5979ca1858a314fb5557"

RDEPENDS:rust-phf_codegen+default-devel = " \
 cargo \
 rust-phf_codegen-devel \
 "
RDEPENDS:rust-phf_codegen-devel = " \
 cargo \
 rust \
 rust-phf_generator+default-devel \
 rust-phf_shared+default-devel \
 "
