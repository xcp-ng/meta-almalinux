# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qrca"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 qrca \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qrca-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0dacb5bd698cb8038a7c11559758288fc6cd6d455e09c7a3e2836b011ffadf87"

URI_x86_64_v2_qrca = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qrca-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qrca;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qrca}"
SRC_URI[x86_64_v2_qrca.sha256sum] = "5747c180368d7a8ca4c44c07582dba89094dd76f5c6dbc1c906d71a32310caf5"

URI_aarch64_qrca = "${EPEL_MIRROR}/aarch64/Packages/q/qrca-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_qrca;unpack=0"
SRC_URI:append = " ${URI_aarch64_qrca}"
SRC_URI[aarch64_qrca.sha256sum] = "385f28bbb1882d3251820f86fb6670904a8f94dacfabfb8e5b12e768aa2b222b"

RDEPENDS:qrca = " \
 glibc \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-knotifications \
 kf6-kservice \
 kf6-networkmanager-qt \
 kf6-prison \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 xdg-utils \
 "
