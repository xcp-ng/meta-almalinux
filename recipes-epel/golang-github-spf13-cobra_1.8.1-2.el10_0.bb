# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-spf13-cobra"
PV = "1.8.1"
PR = "2.el10_0"
PACKAGES = " \
 golang-github-spf13-cobra-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-spf13-cobra-1.8.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b6a2ee2df07ee2a190db8735677433d9985c88202f3ce99cf6c2363fef95c825"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - golang-github-spf13-cobra-devel: golang(github.com/spf13/pflag)

URI_x86_64_v2_golang-github-spf13-cobra-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-spf13-cobra-devel-1.8.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-spf13-cobra-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-spf13-cobra-devel}"
SRC_URI[x86_64_v2_golang-github-spf13-cobra-devel.sha256sum] = "ed4c5dba28b5214f30a5ad4f19fa0e376ea437a9157804f7a4e7d2355294ac01"

URI_aarch64_golang-github-spf13-cobra-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-spf13-cobra-devel-1.8.1-2.el10_0.noarch.rpm;name=aarch64_golang-github-spf13-cobra-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-spf13-cobra-devel}"
SRC_URI[aarch64_golang-github-spf13-cobra-devel.sha256sum] = "af4456ebb983a65574c84262d2caa22135460ed0ad9c09a411b7e97d13843d08"

RDEPENDS:golang-github-spf13-cobra-devel:x86_64_v2 = " \
 compat-golang-github-cpuguy83-md2man2-devel \
 go-filesystem \
 golang-gopkg-yaml-3-devel \
"
RDEPENDS:golang-github-spf13-cobra-devel:aarch64 = " \
 compat-golang-github-cpuguy83-md2man2-devel \
 go-filesystem \
 golang-github-spf13-pflag-devel \
 golang-gopkg-yaml-3-devel \
"
