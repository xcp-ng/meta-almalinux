# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-powerfmt-macros"
PV = "0.1.0"
PR = "3.el10_0"
PACKAGES = " \
 rust-powerfmt-macros+default-devel \
 rust-powerfmt-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-powerfmt-macros-0.1.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63f364a10007e96f94b29c8da17cea2646adea11dd07cca38e201f6e44f34f20"

URI_x86_64_v2_rust-powerfmt-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-powerfmt-macros+default-devel-0.1.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-powerfmt-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-powerfmt-macros+default-devel}"
SRC_URI[x86_64_v2_rust-powerfmt-macros+default-devel.sha256sum] = "68d1e7bd0808727db92eeec1ac823e0d47482930017aa729be75414e4c5f9d50"

URI_x86_64_v2_rust-powerfmt-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-powerfmt-macros-devel-0.1.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-powerfmt-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-powerfmt-macros-devel}"
SRC_URI[x86_64_v2_rust-powerfmt-macros-devel.sha256sum] = "61b2d010d81d8b3c04e92f4315224edd300103fd3ed99577f0025d67c60a6442"

URI_aarch64_rust-powerfmt-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-powerfmt-macros+default-devel-0.1.0-3.el10_0.noarch.rpm;name=aarch64_rust-powerfmt-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-powerfmt-macros+default-devel}"
SRC_URI[aarch64_rust-powerfmt-macros+default-devel.sha256sum] = "1fdf31c17eb2b0cfb5e7db6733565f617ef788010f01a4340b5550d1ab255a0b"

URI_aarch64_rust-powerfmt-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-powerfmt-macros-devel-0.1.0-3.el10_0.noarch.rpm;name=aarch64_rust-powerfmt-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-powerfmt-macros-devel}"
SRC_URI[aarch64_rust-powerfmt-macros-devel.sha256sum] = "d74bad6876f887b7dea3348bd72849c00bac24d9c59e7123017cd8fa878c4389"

RDEPENDS:rust-powerfmt-macros+default-devel = " \
 cargo \
 rust-powerfmt-macros-devel \
 "
RDEPENDS:rust-powerfmt-macros-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+full-devel \
 "
