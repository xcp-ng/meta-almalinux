# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wireless-regdb"
PV = "2025.10.07"
PR = "1.el10"
PACKAGES = " \
 wireless-regdb \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/wireless-regdb-2025.10.07-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "05265089e7d5526e5fa2e5333ca4d41e082ce6af732bc79fe93bfe0e8f542ce5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/wireless-regdb-2025.10.07-1.el10.noarch.rpm;name=x86_64_v2_wireless-regdb;unpack=0"
SRC_URI[x86_64_v2_wireless-regdb.sha256sum] = "2d2031830d47e3e8b3eacba2e5e6a023c8dfd9b952aa9c65bd94369658ed74bd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/wireless-regdb-2025.10.07-1.el10.noarch.rpm;name=aarch64_wireless-regdb;unpack=0"
SRC_URI[aarch64_wireless-regdb.sha256sum] = "2d2031830d47e3e8b3eacba2e5e6a023c8dfd9b952aa9c65bd94369658ed74bd"

RDEPENDS:wireless-regdb = " \
 bash \
 iw \
 systemd \
 systemd-udev \
 "
