# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fennel"
PV = "1.5.3"
PR = "2.el10_1"
PACKAGES = " \
 fennel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fennel-1.5.3-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c27b434a9133a9efc88e2b6e947ee79bedf02553925b38e4db29b9a71f144182"

URI_x86_64_v2_fennel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fennel-1.5.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_fennel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fennel}"
SRC_URI[x86_64_v2_fennel.sha256sum] = "3b1cae5c27cd00f737668b5ed5bee6779d3674dc9f062122d97370421f375f10"

URI_aarch64_fennel = "${EPEL_MIRROR}/aarch64/Packages/f/fennel-1.5.3-2.el10_1.noarch.rpm;name=aarch64_fennel;unpack=0"
SRC_URI:append = " ${URI_aarch64_fennel}"
SRC_URI[aarch64_fennel.sha256sum] = "4bc69af5593387d7d3bf9e0347f7cf77434e352d4f47f7e9632a28462c0701be"

RDEPENDS:fennel = " \
 lua \
 lua-libs \
 "
