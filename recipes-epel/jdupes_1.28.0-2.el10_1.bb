# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jdupes"
PV = "1.28.0"
PR = "2.el10_1"
PACKAGES = " \
 jdupes \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/jdupes-1.28.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f66d38a66abf88d8b37619767fe15b309ee41f479d4f786d9f924864b4bdab7"

URI_x86_64_v2_jdupes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jdupes-1.28.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_jdupes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jdupes}"
SRC_URI[x86_64_v2_jdupes.sha256sum] = "2089b9c3e961a72c1430d84d9cea97854e9c773bcbc19c0051e29ad936bc404a"

URI_aarch64_jdupes = "${EPEL_MIRROR}/aarch64/Packages/j/jdupes-1.28.0-2.el10_1.aarch64.rpm;name=aarch64_jdupes;unpack=0"
SRC_URI:append = " ${URI_aarch64_jdupes}"
SRC_URI[aarch64_jdupes.sha256sum] = "63210a2d0ef5a6c93c6dc38ad246ad6481e266eb7c188c5de3d91839bf53edd2"

RDEPENDS:jdupes = " \
 glibc \
 libjodycode \
 "
