# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mingw-binutils"
PV = "2.44"
PR = "1.el10"
PACKAGES = " \
 mingw-binutils-generic \
 mingw32-binutils \
 mingw64-binutils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/mingw-binutils-2.44-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f99e125126da3931a2e9b1dddc33ffa83be42f6d262e7b792f0e065e5362878"

URI_x86_64_v2_mingw-binutils-generic = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw-binutils-generic-2.44-1.el10.x86_64_v2.rpm;name=x86_64_v2_mingw-binutils-generic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw-binutils-generic}"
SRC_URI[x86_64_v2_mingw-binutils-generic.sha256sum] = "7a47dadbfe1841531865d32131767d26159eb3998f607f99c2c9f520102186ff"

URI_x86_64_v2_mingw32-binutils = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw32-binutils-2.44-1.el10.x86_64_v2.rpm;name=x86_64_v2_mingw32-binutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-binutils}"
SRC_URI[x86_64_v2_mingw32-binutils.sha256sum] = "fe48f3186efc0749c49621edb7414b6601eefe9387c446527714dfff494090dc"

URI_x86_64_v2_mingw64-binutils = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw64-binutils-2.44-1.el10.x86_64_v2.rpm;name=x86_64_v2_mingw64-binutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-binutils}"
SRC_URI[x86_64_v2_mingw64-binutils.sha256sum] = "de93db2c46b57bcc789302ca4b49aa6f0e2b1977640a961cadfa7b42b047cc63"

URI_aarch64_mingw-binutils-generic = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw-binutils-generic-2.44-1.el10.aarch64.rpm;name=aarch64_mingw-binutils-generic;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw-binutils-generic}"
SRC_URI[aarch64_mingw-binutils-generic.sha256sum] = "2a4fd92b4cae408921c49812f417876387fddbcd5e1f5e7c63b3be3cc2cac669"

URI_aarch64_mingw32-binutils = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw32-binutils-2.44-1.el10.aarch64.rpm;name=aarch64_mingw32-binutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw32-binutils}"
SRC_URI[aarch64_mingw32-binutils.sha256sum] = "40e0b767d9b19757e47485c2f4832941b81746dc5e138efa16a4356d247f192a"

URI_aarch64_mingw64-binutils = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw64-binutils-2.44-1.el10.aarch64.rpm;name=aarch64_mingw64-binutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw64-binutils}"
SRC_URI[aarch64_mingw64-binutils.sha256sum] = "0c8092d745e9caa28c22b6d106659e5fbf6438339b1f79fc3f07f1c00775aecd"

RDEPENDS:mingw-binutils-generic = " \
 glibc \
 "
RDEPENDS:mingw32-binutils = " \
 glibc \
 mingw-binutils-generic \
 mingw32-filesystem \
 "
RDEPENDS:mingw64-binutils = " \
 glibc \
 mingw-binutils-generic \
 mingw64-filesystem \
 "
