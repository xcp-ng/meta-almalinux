# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-shell"
PV = "49.5"
PR = "7.el10.alma.7"
PACKAGES = " \
 gnome-shell \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-shell-49.5-7.el10.alma.7.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5304cb030a1ec3b618c86654923a5a87a992395663d08699edaf59be76e25abd"

URI_x86_64_v2_gnome-shell = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-49.5-7.el10.alma.7.x86_64_v2.rpm;name=x86_64_v2_gnome-shell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell}"
SRC_URI[x86_64_v2_gnome-shell.sha256sum] = "2d2c809349af3299c0e0d2529a7cb49c263f8d3bef419ef93fa339586f2876e1"
RPROVIDES:gnome-shell:x86_64_v2 = "virtual/PolicyKit-authentication-agent"

URI_aarch64_gnome-shell = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-49.5-7.el10.alma.7.aarch64.rpm;name=aarch64_gnome-shell;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell}"
SRC_URI[aarch64_gnome-shell.sha256sum] = "76c51588251f6abdfd6a17f607ada535b8a9ee01bf4a02f6bafd146ca1c4b0cd"
RPROVIDES:gnome-shell:aarch64 = "virtual/PolicyKit-authentication-agent"

RDEPENDS:gnome-shell = " \
 NetworkManager-libnm \
 accountsservice-libs \
 at-spi2-atk \
 atk \
 cairo \
 evolution-data-server \
 gcr \
 gcr-libs \
 gdk-pixbuf2 \
 gdm \
 geoclue2-libs \
 gettext \
 gjs \
 glib2 \
 glibc \
 gnome-autoar \
 gnome-control-center \
 gnome-desktop4 \
 gnome-settings-daemon \
 gobject-introspection \
 graphene \
 gsettings-desktop-schemas \
 gstreamer1 \
 gstreamer1-plugins-good \
 gtk4 \
 ibus-libs \
 json-glib \
 libX11 \
 libXext \
 libXfixes \
 libadwaita \
 libgcc \
 libglvnd-gles \
 libgweather \
 libical-glib \
 libnma-gtk4 \
 librsvg2 \
 libsecret \
 libsoup3 \
 mutter \
 pango \
 pipewire-gstreamer \
 pipewire-libs \
 polkit \
 polkit-libs \
 pulseaudio-libs \
 pulseaudio-libs-glib2 \
 python3 \
 python3-argcomplete \
 switcheroo-control \
 systemd-libs \
 tecla \
 upower \
 xdg-desktop-portal-gnome \
 xdg-desktop-portal-gtk \
 xdg-user-dirs-gtk \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/PolicyKit-authentication-agent"

PROVIDES:append:aarch64 = " rpm/virtual/PolicyKit-authentication-agent"
