# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-v_frame"
PV = "0.5.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-v_frame+default-devel \
 rust-v_frame+padding_api-devel \
 rust-v_frame-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-v_frame-0.5.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d469072691f8ff6436f3f61fc2d479c759c26cafc106389a9cd992d3d87c84b5"

URI_x86_64_v2_rust-v_frame+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-v_frame+default-devel-0.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-v_frame+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-v_frame+default-devel}"
SRC_URI[x86_64_v2_rust-v_frame+default-devel.sha256sum] = "f2bab2b6b3e01ce472447064cf31e8d2b9408ab4a944eb2948922e72b79399e1"

URI_x86_64_v2_rust-v_frame+padding_api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-v_frame+padding_api-devel-0.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-v_frame+padding_api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-v_frame+padding_api-devel}"
SRC_URI[x86_64_v2_rust-v_frame+padding_api-devel.sha256sum] = "23ccba1e2cb531b800d6b96f1a42287a24db9904402a6428968b8a6ca1961640"

URI_x86_64_v2_rust-v_frame-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-v_frame-devel-0.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-v_frame-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-v_frame-devel}"
SRC_URI[x86_64_v2_rust-v_frame-devel.sha256sum] = "7aa548f8083526fd6e92a309302300e0f6116dfa28d74f26c6007a3085225f4c"

URI_aarch64_rust-v_frame+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-v_frame+default-devel-0.5.0-1.el10_2.noarch.rpm;name=aarch64_rust-v_frame+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-v_frame+default-devel}"
SRC_URI[aarch64_rust-v_frame+default-devel.sha256sum] = "80aafdbc8cac33dae45d15457edc80cd2af85706345a32ffc801381964cb8368"

URI_aarch64_rust-v_frame+padding_api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-v_frame+padding_api-devel-0.5.0-1.el10_2.noarch.rpm;name=aarch64_rust-v_frame+padding_api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-v_frame+padding_api-devel}"
SRC_URI[aarch64_rust-v_frame+padding_api-devel.sha256sum] = "6c76cab178aa94fb7cd1d880fc163bb8ca64207038c499d191e990c964e8e10e"

URI_aarch64_rust-v_frame-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-v_frame-devel-0.5.0-1.el10_2.noarch.rpm;name=aarch64_rust-v_frame-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-v_frame-devel}"
SRC_URI[aarch64_rust-v_frame-devel.sha256sum] = "fd0ad958209b2a0e45ff200908ff3f35bb7e768bd154f2c9bcaca0e8ca074c7a"

RDEPENDS:rust-v_frame+default-devel = " \
 cargo \
 rust-v_frame-devel \
 "
RDEPENDS:rust-v_frame+padding_api-devel = " \
 cargo \
 rust-v_frame-devel \
 "
RDEPENDS:rust-v_frame-devel = " \
 cargo \
 rust \
 rust-aligned-vec+default-devel \
 rust-num-traits+default-devel \
 rust-thiserror+default-devel \
 "
