# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kpublictransport"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kpublictransport \
 kpublictransport-devel \
 kpublictransport-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kpublictransport-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4bd46c84bfa4b509368f055c6ccffcae2c027175950dd1872a31684857c6aeb8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpublictransport-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpublictransport;unpack=0"
SRC_URI[x86_64_v2_kpublictransport.sha256sum] = "083e1f6198b742b1d99162b716f6e45c02efaf2b41d8aa86b1093b5344f8b3bd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpublictransport-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpublictransport-devel;unpack=0"
SRC_URI[x86_64_v2_kpublictransport-devel.sha256sum] = "97481b2411b46a9080e5187805fe445a728a886a6c96833da47e8e7d54d26825"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpublictransport-doc-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kpublictransport-doc;unpack=0"
SRC_URI[x86_64_v2_kpublictransport-doc.sha256sum] = "53fb0ceeb5e71917f805f1d848152a032791d3c0dd79e8b01c0cb3dbb3429b79"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kpublictransport-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kpublictransport;unpack=0"
SRC_URI[aarch64_kpublictransport.sha256sum] = "313fe4c2e3a6c51b1209e0a01e1024d7808e21430763cfd0587fa29e38c3958b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kpublictransport-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kpublictransport-devel;unpack=0"
SRC_URI[aarch64_kpublictransport-devel.sha256sum] = "1af8788cc6529d4b4b3cbd18adc1daf91d41b9e833d791f342917262ec6c2de9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kpublictransport-doc-26.08.1-1.el10_3.noarch.rpm;name=aarch64_kpublictransport-doc;unpack=0"
SRC_URI[aarch64_kpublictransport-doc.sha256sum] = "46306d09c473f37a87b7c432daaad9e0d0abfb36e88b74a48ea37597679a7f3c"

RDEPENDS:kpublictransport = " \
 glibc \
 kf6-ki18n \
 kf6-kitemmodels \
 kf6-networkmanager-qt \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 zlib-ng-compat \
 "
RDEPENDS:kpublictransport-devel = " \
 cmake-filesystem \
 kpublictransport \
 "
RDEPENDS:kpublictransport-doc = " \
 "
