# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossbeam-epoch"
PV = "0.9.18"
PR = "3.el10_0"
PACKAGES = " \
 rust-crossbeam-epoch+alloc-devel \
 rust-crossbeam-epoch+default-devel \
 rust-crossbeam-epoch+nightly-devel \
 rust-crossbeam-epoch+std-devel \
 rust-crossbeam-epoch-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crossbeam-epoch-0.9.18-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b25d66d024d37ef2d5f9df935dbe7238b2ddf712c33b9911b28d09164df70e0b"

URI_x86_64_v2_rust-crossbeam-epoch+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-epoch+alloc-devel-0.9.18-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-epoch+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-epoch+alloc-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-epoch+alloc-devel.sha256sum] = "d9b189fe333b90f86137fd46e1d011e3262430afb7c4c8a3e26df1a696302f63"

URI_x86_64_v2_rust-crossbeam-epoch+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-epoch+default-devel-0.9.18-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-epoch+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-epoch+default-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-epoch+default-devel.sha256sum] = "65587e32dd1e0e3e79b2b0d76e61965fd14a26db5c06cb1b26f2e889480f85a4"

URI_x86_64_v2_rust-crossbeam-epoch+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-epoch+nightly-devel-0.9.18-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-epoch+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-epoch+nightly-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-epoch+nightly-devel.sha256sum] = "71945d5df76c6bf8a82dbbd9d67f31b590d302dabd93441e2a39b2ed011ee636"

URI_x86_64_v2_rust-crossbeam-epoch+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-epoch+std-devel-0.9.18-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-epoch+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-epoch+std-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-epoch+std-devel.sha256sum] = "d524a3b455f8a8c590ba1c5c2df32799134fb3d1cb39b02002b9c3bec219a460"

URI_x86_64_v2_rust-crossbeam-epoch-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-epoch-devel-0.9.18-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-epoch-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-epoch-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-epoch-devel.sha256sum] = "8d8581d1c4333129e7a3fca7443407760fe1fd0afee85c22996b1b347fc05670"

URI_aarch64_rust-crossbeam-epoch+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-epoch+alloc-devel-0.9.18-3.el10_0.noarch.rpm;name=aarch64_rust-crossbeam-epoch+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-epoch+alloc-devel}"
SRC_URI[aarch64_rust-crossbeam-epoch+alloc-devel.sha256sum] = "100349417325b1756247d8682ac81fe42c968cd3b17fa370c96a6f2ea35328ab"

URI_aarch64_rust-crossbeam-epoch+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-epoch+default-devel-0.9.18-3.el10_0.noarch.rpm;name=aarch64_rust-crossbeam-epoch+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-epoch+default-devel}"
SRC_URI[aarch64_rust-crossbeam-epoch+default-devel.sha256sum] = "5b974c2d88cf509f2adee577d9efd827e473ab9ab0eeb77ba59642ca2546d2d4"

URI_aarch64_rust-crossbeam-epoch+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-epoch+nightly-devel-0.9.18-3.el10_0.noarch.rpm;name=aarch64_rust-crossbeam-epoch+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-epoch+nightly-devel}"
SRC_URI[aarch64_rust-crossbeam-epoch+nightly-devel.sha256sum] = "ee4ee67c6253470aec4e11af3888e23552e37dbd4d52b72d93175ce523592963"

URI_aarch64_rust-crossbeam-epoch+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-epoch+std-devel-0.9.18-3.el10_0.noarch.rpm;name=aarch64_rust-crossbeam-epoch+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-epoch+std-devel}"
SRC_URI[aarch64_rust-crossbeam-epoch+std-devel.sha256sum] = "877ff1fef991810046d9bca17ade7d21d6a8597b0240ad56580b274bab420658"

URI_aarch64_rust-crossbeam-epoch-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-epoch-devel-0.9.18-3.el10_0.noarch.rpm;name=aarch64_rust-crossbeam-epoch-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-epoch-devel}"
SRC_URI[aarch64_rust-crossbeam-epoch-devel.sha256sum] = "cb1e6a5fb66ce40657054002359d027dc269666dcba82c1924a14eaa97c3db01"

RDEPENDS:rust-crossbeam-epoch+alloc-devel = " \
 cargo \
 rust-crossbeam-epoch-devel \
 "
RDEPENDS:rust-crossbeam-epoch+default-devel = " \
 cargo \
 rust-crossbeam-epoch+std-devel \
 rust-crossbeam-epoch-devel \
 "
RDEPENDS:rust-crossbeam-epoch+nightly-devel = " \
 cargo \
 rust-crossbeam-epoch-devel \
 rust-crossbeam-utils+nightly-devel \
 "
RDEPENDS:rust-crossbeam-epoch+std-devel = " \
 cargo \
 rust-crossbeam-epoch+alloc-devel \
 rust-crossbeam-epoch-devel \
 rust-crossbeam-utils+std-devel \
 "
RDEPENDS:rust-crossbeam-epoch-devel = " \
 cargo \
 rust \
 rust-crossbeam-utils-devel \
 "
