# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kdoctools"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kdoctools \
 kf6-kdoctools-devel \
 kf6-kdoctools-doc \
 kf6-kdoctools-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kdoctools-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "dcb6722523d305872f8d7d45b9a8e46e87ea9045e484302ce112605198540638"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdoctools-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdoctools;unpack=0"
SRC_URI[x86_64_v2_kf6-kdoctools.sha256sum] = "a75fad36ff43469c378d9475c97278801d47ef45069071e872e2f6094302ecfb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdoctools-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdoctools-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kdoctools-devel.sha256sum] = "12a7cb11c5e003ee2980ffb1f80b455691bb8201228f75460816820b5f23437d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdoctools-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdoctools-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kdoctools-doc.sha256sum] = "43d4487de50145609676c7b27082ac56a96cac5151d9f8c735793d0d58b7c886"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdoctools-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdoctools-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kdoctools-html.sha256sum] = "e45573c2857fd13df6219a369571963a6804606741eea5d4d4c8ed9c3ca36a2c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdoctools-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kdoctools;unpack=0"
SRC_URI[aarch64_kf6-kdoctools.sha256sum] = "0309d3dfddfd1cf8f7764af3e6719721782c83e7aa188dfc17ad03a31373d101"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdoctools-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kdoctools-devel;unpack=0"
SRC_URI[aarch64_kf6-kdoctools-devel.sha256sum] = "e95af033148f18ba3cddfc83529df87d289591307bb92f7661689a2f9ed3d58b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdoctools-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kdoctools-doc;unpack=0"
SRC_URI[aarch64_kf6-kdoctools-doc.sha256sum] = "e82d60cbcedee53b648b11842b53c6f5ccbd6151e2bfa7023608dae4110acc9a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdoctools-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kdoctools-html;unpack=0"
SRC_URI[aarch64_kf6-kdoctools-html.sha256sum] = "f2d9b2e9099f98538854bd33b866be05aff15c71654e1ab8837b64499b3ea613"

RDEPENDS:kf6-kdoctools = " \
 docbook-dtds \
 docbook-style-xsl \
 glibc \
 kf6-karchive \
 libstdc++ \
 libxml2 \
 libxslt \
 qt6-qtbase \
 "
RDEPENDS:kf6-kdoctools-devel = " \
 cmake-filesystem \
 kf6-kdoctools \
 perl-Any-URI-Escape \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kdoctools-doc = " \
 "
RDEPENDS:kf6-kdoctools-html = " \
 "
