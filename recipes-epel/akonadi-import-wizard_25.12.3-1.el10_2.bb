# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-import-wizard"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 akonadi-import-wizard \
 akonadi-import-wizard-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akonadi-import-wizard-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e59249e0151584dabfaa19a8f2407edf54c54bc8da360a7f7065ff7ceaa4332"

URI_x86_64_v2_akonadi-import-wizard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-import-wizard-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-import-wizard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-import-wizard}"
SRC_URI[x86_64_v2_akonadi-import-wizard.sha256sum] = "51689859f8347587b8455357409988e952d370a9627c52e7ffc4204c3a82f667"

URI_x86_64_v2_akonadi-import-wizard-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-import-wizard-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-import-wizard-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-import-wizard-devel}"
SRC_URI[x86_64_v2_akonadi-import-wizard-devel.sha256sum] = "a8b1a19b7829e258735c14f10abeb1097ae6a1b037c144b2ba4390729628adc2"

URI_aarch64_akonadi-import-wizard = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-import-wizard-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_akonadi-import-wizard;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-import-wizard}"
SRC_URI[aarch64_akonadi-import-wizard.sha256sum] = "70c3eaabb3f19529049f97876f696d0c4230d3f0d04c4d38fc4361c3671bc923"

URI_aarch64_akonadi-import-wizard-devel = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-import-wizard-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_akonadi-import-wizard-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-import-wizard-devel}"
SRC_URI[aarch64_akonadi-import-wizard-devel.sha256sum] = "baa615b72ef65c693b84bb1a6f01db52e550b2065cd3ac9760a3928fc33290af"

RDEPENDS:akonadi-import-wizard = " \
 akonadi-server \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kidentitymanagement \
 kmailtransport \
 libgcc \
 libstdc++ \
 mailcommon \
 mailimporter \
 mailimporter-akonadi \
 messagelib \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
RDEPENDS:akonadi-import-wizard-devel = " \
 akonadi-import-wizard \
 cmake-filesystem \
 kmailtransport-devel \
 "
