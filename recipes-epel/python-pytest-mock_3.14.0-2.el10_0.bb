# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-mock"
PV = "3.14.0"
PR = "2.el10_0"
PACKAGES = " \
 python3-pytest-mock \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-mock-3.14.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b05764fbe7c5e40fab04c7b043f0075938612551a0ff4741e1472726214e31aa"

URI_x86_64_v2_python3-pytest-mock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-mock-3.14.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-mock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-mock}"
SRC_URI[x86_64_v2_python3-pytest-mock.sha256sum] = "ff947b5cacf0e589b89fb41f55eef8c70f7280ea9364fc602459131fd9af31e9"

URI_aarch64_python3-pytest-mock = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-mock-3.14.0-2.el10_0.noarch.rpm;name=aarch64_python3-pytest-mock;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-mock}"
SRC_URI[aarch64_python3-pytest-mock.sha256sum] = "5ca1be0939020be8f8e399f45841cb1dfd56d50e20ea4aa093656a61b4feaf2d"

RDEPENDS:python3-pytest-mock = " \
 python3 \
 python3-pytest \
 "
