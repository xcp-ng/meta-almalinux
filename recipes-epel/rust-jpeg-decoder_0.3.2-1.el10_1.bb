# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-jpeg-decoder"
PV = "0.3.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-jpeg-decoder+default-devel \
 rust-jpeg-decoder+nightly_aarch64_neon-devel \
 rust-jpeg-decoder+platform_independent-devel \
 rust-jpeg-decoder+rayon-devel \
 rust-jpeg-decoder-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-jpeg-decoder-0.3.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "58479bdb4bd20edbb3908025faeac91a633070e997102e9dd2138ebb225a668f"

URI_x86_64_v2_rust-jpeg-decoder+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jpeg-decoder+default-devel-0.3.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jpeg-decoder+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jpeg-decoder+default-devel}"
SRC_URI[x86_64_v2_rust-jpeg-decoder+default-devel.sha256sum] = "863cb35ce9c8924b03c1295fe98c40e4bfec02573848c8362ad43c140f429b64"

URI_x86_64_v2_rust-jpeg-decoder+nightly_aarch64_neon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jpeg-decoder+nightly_aarch64_neon-devel-0.3.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jpeg-decoder+nightly_aarch64_neon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jpeg-decoder+nightly_aarch64_neon-devel}"
SRC_URI[x86_64_v2_rust-jpeg-decoder+nightly_aarch64_neon-devel.sha256sum] = "4ad6ef1d2129facc9782229e51672538753038ff119d99b1f0057b2aed93436d"

URI_x86_64_v2_rust-jpeg-decoder+platform_independent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jpeg-decoder+platform_independent-devel-0.3.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jpeg-decoder+platform_independent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jpeg-decoder+platform_independent-devel}"
SRC_URI[x86_64_v2_rust-jpeg-decoder+platform_independent-devel.sha256sum] = "5d43eb6d701c052673a5a7e60ff25f55085e14b44a20bae0fb83ba9913ac2569"

URI_x86_64_v2_rust-jpeg-decoder+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jpeg-decoder+rayon-devel-0.3.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jpeg-decoder+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jpeg-decoder+rayon-devel}"
SRC_URI[x86_64_v2_rust-jpeg-decoder+rayon-devel.sha256sum] = "46c2f8e2e411418d59ec00bf790c42e16503d4b8f2f1ef726a0f13b96066f457"

URI_x86_64_v2_rust-jpeg-decoder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jpeg-decoder-devel-0.3.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jpeg-decoder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jpeg-decoder-devel}"
SRC_URI[x86_64_v2_rust-jpeg-decoder-devel.sha256sum] = "b33e8ece38dc303b215606de622dd357290a96488893ae1af4eb7cd7728fa9a5"

URI_aarch64_rust-jpeg-decoder+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jpeg-decoder+default-devel-0.3.2-1.el10_1.noarch.rpm;name=aarch64_rust-jpeg-decoder+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jpeg-decoder+default-devel}"
SRC_URI[aarch64_rust-jpeg-decoder+default-devel.sha256sum] = "f8206cef281ca0b9ea462a5b60300203fb9ad2f6f4d705c0878984b7c5e84b98"

URI_aarch64_rust-jpeg-decoder+nightly_aarch64_neon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jpeg-decoder+nightly_aarch64_neon-devel-0.3.2-1.el10_1.noarch.rpm;name=aarch64_rust-jpeg-decoder+nightly_aarch64_neon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jpeg-decoder+nightly_aarch64_neon-devel}"
SRC_URI[aarch64_rust-jpeg-decoder+nightly_aarch64_neon-devel.sha256sum] = "4499212fbd597f6a09ae186d7e44fea72b978c784a67a2651f3f00267a8cd21b"

URI_aarch64_rust-jpeg-decoder+platform_independent-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jpeg-decoder+platform_independent-devel-0.3.2-1.el10_1.noarch.rpm;name=aarch64_rust-jpeg-decoder+platform_independent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jpeg-decoder+platform_independent-devel}"
SRC_URI[aarch64_rust-jpeg-decoder+platform_independent-devel.sha256sum] = "eb98ff10502119359d79c11c28a0084d410fb6a306bf40b0d6f1458fd67d81ce"

URI_aarch64_rust-jpeg-decoder+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jpeg-decoder+rayon-devel-0.3.2-1.el10_1.noarch.rpm;name=aarch64_rust-jpeg-decoder+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jpeg-decoder+rayon-devel}"
SRC_URI[aarch64_rust-jpeg-decoder+rayon-devel.sha256sum] = "1f18bd0264b46d2561b20e97cb60de88e56c39b98031873eef9a575f14247034"

URI_aarch64_rust-jpeg-decoder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jpeg-decoder-devel-0.3.2-1.el10_1.noarch.rpm;name=aarch64_rust-jpeg-decoder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jpeg-decoder-devel}"
SRC_URI[aarch64_rust-jpeg-decoder-devel.sha256sum] = "0174a32187307238624a52e42d66cbae8cd0ef8adbd27634f299f2ea5d4cddd3"

RDEPENDS:rust-jpeg-decoder+default-devel = " \
 cargo \
 rust-jpeg-decoder+rayon-devel \
 rust-jpeg-decoder-devel \
 "
RDEPENDS:rust-jpeg-decoder+nightly_aarch64_neon-devel = " \
 cargo \
 rust-jpeg-decoder-devel \
 "
RDEPENDS:rust-jpeg-decoder+platform_independent-devel = " \
 cargo \
 rust-jpeg-decoder-devel \
 "
RDEPENDS:rust-jpeg-decoder+rayon-devel = " \
 cargo \
 rust-jpeg-decoder-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-jpeg-decoder-devel = " \
 cargo \
 rust \
 "
