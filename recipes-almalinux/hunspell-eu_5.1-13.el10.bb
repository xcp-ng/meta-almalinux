# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-eu"
PV = "5.1"
PR = "13.el10"
PACKAGES = " \
 hunspell-eu \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-eu-5.1-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a807e95218496c8ecbee92ca6c33516d235b79f5af764e1304ccaa81f9973408"

URI_x86_64_v2_hunspell-eu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-eu-5.1-13.el10.noarch.rpm;name=x86_64_v2_hunspell-eu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-eu}"
SRC_URI[x86_64_v2_hunspell-eu.sha256sum] = "18b0845e067ec7efa97ab1798b8150ff82ab68b2d509d6a5890194e7d9380334"

URI_aarch64_hunspell-eu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-eu-5.1-13.el10.noarch.rpm;name=aarch64_hunspell-eu;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-eu}"
SRC_URI[aarch64_hunspell-eu.sha256sum] = "18b0845e067ec7efa97ab1798b8150ff82ab68b2d509d6a5890194e7d9380334"

RDEPENDS:hunspell-eu = " \
 hunspell-filesystem \
 "
