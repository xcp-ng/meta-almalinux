# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-crochet"
PV = "2.1.1"
PR = "7.el10_1"
PACKAGES = " \
 python-crochet-doc \
 python3-crochet \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-crochet-2.1.1-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c45744a768765f23f09db3a1ee561f4380e79edcb191964864b5f18f91dd4d2"

URI_x86_64_v2_python-crochet-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-crochet-doc-2.1.1-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-crochet-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-crochet-doc}"
SRC_URI[x86_64_v2_python-crochet-doc.sha256sum] = "8a2df6d5eba7b38215656b976a0d88a53f2d05ac48d62efedda572db946d4270"

URI_x86_64_v2_python3-crochet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-crochet-2.1.1-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-crochet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-crochet}"
SRC_URI[x86_64_v2_python3-crochet.sha256sum] = "2832081f3e413ed06075d7dd108f20fec97fb6c60aa9a48f970fb09644819076"

URI_aarch64_python-crochet-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-crochet-doc-2.1.1-7.el10_1.noarch.rpm;name=aarch64_python-crochet-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-crochet-doc}"
SRC_URI[aarch64_python-crochet-doc.sha256sum] = "124856ceff35d1a99eb87ae7bc0f4af0052296966b25b34638e3449d9827801a"

URI_aarch64_python3-crochet = "${EPEL_MIRROR}/aarch64/Packages/p/python3-crochet-2.1.1-7.el10_1.noarch.rpm;name=aarch64_python3-crochet;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-crochet}"
SRC_URI[aarch64_python3-crochet.sha256sum] = "0c3798138af6d39f0ab8a3e60926b472a08898a81414880c5db60f5558506111"

RDEPENDS:python-crochet-doc = " \
 "
RDEPENDS:python3-crochet = " \
 python3 \
 python3-twisted \
 python3-wrapt \
 "
