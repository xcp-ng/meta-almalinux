# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tracing"
PV = "0.1.41"
PR = "1.el10_0"
PACKAGES = " \
 rust-tracing+async-await-devel \
 rust-tracing+attributes-devel \
 rust-tracing+default-devel \
 rust-tracing+log-always-devel \
 rust-tracing+log-devel \
 rust-tracing+max_level_debug-devel \
 rust-tracing+max_level_error-devel \
 rust-tracing+max_level_info-devel \
 rust-tracing+max_level_off-devel \
 rust-tracing+max_level_trace-devel \
 rust-tracing+max_level_warn-devel \
 rust-tracing+release_max_level_debug-devel \
 rust-tracing+release_max_level_error-devel \
 rust-tracing+release_max_level_info-devel \
 rust-tracing+release_max_level_off-devel \
 rust-tracing+release_max_level_trace-devel \
 rust-tracing+release_max_level_warn-devel \
 rust-tracing+std-devel \
 rust-tracing+tracing-attributes-devel \
 rust-tracing-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tracing-0.1.41-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2002f4b45e783e40e90fd44d8501828bd342825eef6e49780c8f58e9c6e190ff"

URI_x86_64_v2_rust-tracing+async-await-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+async-await-devel-0.1.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+async-await-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+async-await-devel}"
SRC_URI[x86_64_v2_rust-tracing+async-await-devel.sha256sum] = "1dbe29a33f4d56b494fa469800bb79f6628c72e72e14928e2384463a1abbf61a"

URI_x86_64_v2_rust-tracing+attributes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+attributes-devel-0.1.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+attributes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+attributes-devel}"
SRC_URI[x86_64_v2_rust-tracing+attributes-devel.sha256sum] = "0e5a9d39e8a0ddfcfa5d02e2213d71a8f53fbd934072043716c9c425b380b57c"

URI_x86_64_v2_rust-tracing+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+default-devel-0.1.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+default-devel}"
SRC_URI[x86_64_v2_rust-tracing+default-devel.sha256sum] = "708b0c3b89a3c382f626cec0cfc3cca279574909eaf3938441beb02b8f33e99a"

URI_x86_64_v2_rust-tracing+log-always-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+log-always-devel-0.1.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+log-always-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+log-always-devel}"
SRC_URI[x86_64_v2_rust-tracing+log-always-devel.sha256sum] = "a03d94773f4d61294cc55f8c51291534bef8774db7e8eaaea3cc308db4eda28f"

URI_x86_64_v2_rust-tracing+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+log-devel-0.1.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+log-devel}"
SRC_URI[x86_64_v2_rust-tracing+log-devel.sha256sum] = "b09f08185be85b9fcadaba07a00caef41149c53b0bb2df6536ee0d6dc54fc2f0"

URI_x86_64_v2_rust-tracing+max_level_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+max_level_debug-devel-0.1.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+max_level_debug-devel}"
SRC_URI[x86_64_v2_rust-tracing+max_level_debug-devel.sha256sum] = "7f7221763c593b87ec803c6c7998e8dba31ec09b30ce2b41b06cb5b9ded13094"

URI_x86_64_v2_rust-tracing+max_level_error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+max_level_error-devel-0.1.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+max_level_error-devel}"
SRC_URI[x86_64_v2_rust-tracing+max_level_error-devel.sha256sum] = "e44d8bc14027bb743a24e1df73d9be4064f4b8ede468b42fc0b83b3cf33ec5d8"

URI_x86_64_v2_rust-tracing+max_level_info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+max_level_info-devel-0.1.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+max_level_info-devel}"
SRC_URI[x86_64_v2_rust-tracing+max_level_info-devel.sha256sum] = "0718915d21bd0019c62cf0c3a0d303c3c1a8ec387327645c0482ced50cd277c2"

URI_x86_64_v2_rust-tracing+max_level_off-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+max_level_off-devel-0.1.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+max_level_off-devel}"
SRC_URI[x86_64_v2_rust-tracing+max_level_off-devel.sha256sum] = "8a146f598561b46297786487ee2ef94f66d3e6e7df80d331ed5c57a1df173b85"

URI_x86_64_v2_rust-tracing+max_level_trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+max_level_trace-devel-0.1.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+max_level_trace-devel}"
SRC_URI[x86_64_v2_rust-tracing+max_level_trace-devel.sha256sum] = "df0ea1d6c37938f443c0577c5225e7fa364977c6b7a5616ae12aebeb035fd417"

URI_x86_64_v2_rust-tracing+max_level_warn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+max_level_warn-devel-0.1.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+max_level_warn-devel}"
SRC_URI[x86_64_v2_rust-tracing+max_level_warn-devel.sha256sum] = "06e28c68bbd8b67df0b64d51592a1520c589454c0c1a36f0845bb18f2748d884"

URI_x86_64_v2_rust-tracing+release_max_level_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+release_max_level_debug-devel-0.1.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+release_max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+release_max_level_debug-devel}"
SRC_URI[x86_64_v2_rust-tracing+release_max_level_debug-devel.sha256sum] = "152704d3dc852b1a74eb540601b7d3f3006951c7ed2be5196627896065cbbbfa"

URI_x86_64_v2_rust-tracing+release_max_level_error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+release_max_level_error-devel-0.1.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+release_max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+release_max_level_error-devel}"
SRC_URI[x86_64_v2_rust-tracing+release_max_level_error-devel.sha256sum] = "ff369aadb65ed1e126934f2af9d8a1bbc6f677925dac81d8140b3a8b3fc9fc90"

URI_x86_64_v2_rust-tracing+release_max_level_info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+release_max_level_info-devel-0.1.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+release_max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+release_max_level_info-devel}"
SRC_URI[x86_64_v2_rust-tracing+release_max_level_info-devel.sha256sum] = "1c8677f908eb5e11a1530c9441a158060fab89c0c54f56f0c5e98f1a67c488d4"

URI_x86_64_v2_rust-tracing+release_max_level_off-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+release_max_level_off-devel-0.1.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+release_max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+release_max_level_off-devel}"
SRC_URI[x86_64_v2_rust-tracing+release_max_level_off-devel.sha256sum] = "604cca253a3f58e20b41ee72b626900763cc0e80b9291870e0385955d43ceade"

URI_x86_64_v2_rust-tracing+release_max_level_trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+release_max_level_trace-devel-0.1.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+release_max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+release_max_level_trace-devel}"
SRC_URI[x86_64_v2_rust-tracing+release_max_level_trace-devel.sha256sum] = "2ef06699f0fcc81b17100d4e5826d429b423388b65e5476f2d3884f69b157c75"

URI_x86_64_v2_rust-tracing+release_max_level_warn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+release_max_level_warn-devel-0.1.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+release_max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+release_max_level_warn-devel}"
SRC_URI[x86_64_v2_rust-tracing+release_max_level_warn-devel.sha256sum] = "1620f60a156fa58cd49864a9dad1b2ebe5abe8d3fe8164481262e046d657f71a"

URI_x86_64_v2_rust-tracing+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+std-devel-0.1.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+std-devel}"
SRC_URI[x86_64_v2_rust-tracing+std-devel.sha256sum] = "080edfe4fd5b1b207577cfb85e4ae60b6d6f4c1b966c6e2e65a4bcfff1ec04cd"

URI_x86_64_v2_rust-tracing+tracing-attributes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+tracing-attributes-devel-0.1.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+tracing-attributes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+tracing-attributes-devel}"
SRC_URI[x86_64_v2_rust-tracing+tracing-attributes-devel.sha256sum] = "29613dca716ad6f49c4cdce5373df03943422a7f53398915e271a2e94201e17f"

URI_x86_64_v2_rust-tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-devel-0.1.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-devel}"
SRC_URI[x86_64_v2_rust-tracing-devel.sha256sum] = "fa06f962326203ee6aac474688890b29173d8e269b825572682466cfe851da49"

URI_aarch64_rust-tracing+async-await-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+async-await-devel-0.1.41-1.el10_0.noarch.rpm;name=aarch64_rust-tracing+async-await-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+async-await-devel}"
SRC_URI[aarch64_rust-tracing+async-await-devel.sha256sum] = "1c3b79f6c117cba257f9f6d95b201f1aca39c019a952283e69230a6b29d44405"

URI_aarch64_rust-tracing+attributes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+attributes-devel-0.1.41-1.el10_0.noarch.rpm;name=aarch64_rust-tracing+attributes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+attributes-devel}"
SRC_URI[aarch64_rust-tracing+attributes-devel.sha256sum] = "43b9aa5de9f1d8c4ff61b8def000c012adeccfe5ba70ef813782b664d242f052"

URI_aarch64_rust-tracing+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+default-devel-0.1.41-1.el10_0.noarch.rpm;name=aarch64_rust-tracing+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+default-devel}"
SRC_URI[aarch64_rust-tracing+default-devel.sha256sum] = "6cc4be73983dfb377ac555cfeac63d7911baef0209f99756b49241ec86dd1f05"

URI_aarch64_rust-tracing+log-always-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+log-always-devel-0.1.41-1.el10_0.noarch.rpm;name=aarch64_rust-tracing+log-always-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+log-always-devel}"
SRC_URI[aarch64_rust-tracing+log-always-devel.sha256sum] = "c3519ab50ae5e9eb44b75a412d1b24862a4c3d6dec057748a7cd9507ac9d7e4d"

URI_aarch64_rust-tracing+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+log-devel-0.1.41-1.el10_0.noarch.rpm;name=aarch64_rust-tracing+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+log-devel}"
SRC_URI[aarch64_rust-tracing+log-devel.sha256sum] = "6dcba81b5b4a13091cf2d76c1a86465d72569974d2a5b55f5e58d058617c78f3"

URI_aarch64_rust-tracing+max_level_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+max_level_debug-devel-0.1.41-1.el10_0.noarch.rpm;name=aarch64_rust-tracing+max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+max_level_debug-devel}"
SRC_URI[aarch64_rust-tracing+max_level_debug-devel.sha256sum] = "6e92e83932bbcd39963050a479d1a2c427b9507cb7024cfe7c3a93aaeaec6620"

URI_aarch64_rust-tracing+max_level_error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+max_level_error-devel-0.1.41-1.el10_0.noarch.rpm;name=aarch64_rust-tracing+max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+max_level_error-devel}"
SRC_URI[aarch64_rust-tracing+max_level_error-devel.sha256sum] = "956825f64255268b9c585631a326780a1f4832794c274966554013c0388279f2"

URI_aarch64_rust-tracing+max_level_info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+max_level_info-devel-0.1.41-1.el10_0.noarch.rpm;name=aarch64_rust-tracing+max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+max_level_info-devel}"
SRC_URI[aarch64_rust-tracing+max_level_info-devel.sha256sum] = "8b02819274546ee5c6623396f52d1036c0ca0f7d1ce67b1c98f25e4cf93a512f"

URI_aarch64_rust-tracing+max_level_off-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+max_level_off-devel-0.1.41-1.el10_0.noarch.rpm;name=aarch64_rust-tracing+max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+max_level_off-devel}"
SRC_URI[aarch64_rust-tracing+max_level_off-devel.sha256sum] = "63f7fc4f3bb1cfca9c5f1bc92831444804e94fbf42df6f825ae958d7dccb02ea"

URI_aarch64_rust-tracing+max_level_trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+max_level_trace-devel-0.1.41-1.el10_0.noarch.rpm;name=aarch64_rust-tracing+max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+max_level_trace-devel}"
SRC_URI[aarch64_rust-tracing+max_level_trace-devel.sha256sum] = "7f44c37f324c30e00b2c19c8aa65da28dc7df56d36e6943b412aaa8aac049da2"

URI_aarch64_rust-tracing+max_level_warn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+max_level_warn-devel-0.1.41-1.el10_0.noarch.rpm;name=aarch64_rust-tracing+max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+max_level_warn-devel}"
SRC_URI[aarch64_rust-tracing+max_level_warn-devel.sha256sum] = "9bcfce7113c2b1baf3b4407dedce1749cda9e3ad7c0852b9adbe13300918d0f5"

URI_aarch64_rust-tracing+release_max_level_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+release_max_level_debug-devel-0.1.41-1.el10_0.noarch.rpm;name=aarch64_rust-tracing+release_max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+release_max_level_debug-devel}"
SRC_URI[aarch64_rust-tracing+release_max_level_debug-devel.sha256sum] = "2cd2b90280d7f037771b40e686122d28d48801200895e6c19fba14b8f5b25923"

URI_aarch64_rust-tracing+release_max_level_error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+release_max_level_error-devel-0.1.41-1.el10_0.noarch.rpm;name=aarch64_rust-tracing+release_max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+release_max_level_error-devel}"
SRC_URI[aarch64_rust-tracing+release_max_level_error-devel.sha256sum] = "9149a25443abb9d4b663bb65843bec10fdffaa2a5bfda3a5cae73fa2ed749def"

URI_aarch64_rust-tracing+release_max_level_info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+release_max_level_info-devel-0.1.41-1.el10_0.noarch.rpm;name=aarch64_rust-tracing+release_max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+release_max_level_info-devel}"
SRC_URI[aarch64_rust-tracing+release_max_level_info-devel.sha256sum] = "eed15687e1edff820d2abf8f9f18307ae618eb21dfc8c7b44cda0af8966d2b8a"

URI_aarch64_rust-tracing+release_max_level_off-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+release_max_level_off-devel-0.1.41-1.el10_0.noarch.rpm;name=aarch64_rust-tracing+release_max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+release_max_level_off-devel}"
SRC_URI[aarch64_rust-tracing+release_max_level_off-devel.sha256sum] = "6f6df441d0c36210a5f216f6e65b8e1c4f4cfd3b7dced25350d30ffa33876886"

URI_aarch64_rust-tracing+release_max_level_trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+release_max_level_trace-devel-0.1.41-1.el10_0.noarch.rpm;name=aarch64_rust-tracing+release_max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+release_max_level_trace-devel}"
SRC_URI[aarch64_rust-tracing+release_max_level_trace-devel.sha256sum] = "6d102ae93831d8ffd583693ce3265638974667ac6e15e9a6584bd2bdc6a81679"

URI_aarch64_rust-tracing+release_max_level_warn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+release_max_level_warn-devel-0.1.41-1.el10_0.noarch.rpm;name=aarch64_rust-tracing+release_max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+release_max_level_warn-devel}"
SRC_URI[aarch64_rust-tracing+release_max_level_warn-devel.sha256sum] = "e3172c6c51044d2add5dc0b616873fe97d28b73e51b4f6c3ec899254b4c10b22"

URI_aarch64_rust-tracing+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+std-devel-0.1.41-1.el10_0.noarch.rpm;name=aarch64_rust-tracing+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+std-devel}"
SRC_URI[aarch64_rust-tracing+std-devel.sha256sum] = "0d5024ede77aeb9f64955bbed25e7850f4bc9bdd0b110ba0798145cc04985923"

URI_aarch64_rust-tracing+tracing-attributes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+tracing-attributes-devel-0.1.41-1.el10_0.noarch.rpm;name=aarch64_rust-tracing+tracing-attributes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+tracing-attributes-devel}"
SRC_URI[aarch64_rust-tracing+tracing-attributes-devel.sha256sum] = "eb44ee150842f6ba3ef337ec4c59efde2b889afff8b528c19b86795d69b63b86"

URI_aarch64_rust-tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-devel-0.1.41-1.el10_0.noarch.rpm;name=aarch64_rust-tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-devel}"
SRC_URI[aarch64_rust-tracing-devel.sha256sum] = "a2bd253acc32e1869cd40ac1d7860da970a67ee3ecc16f44ed2dde1ffdeb6fd0"

RDEPENDS:rust-tracing+async-await-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+attributes-devel = " \
 cargo \
 rust-tracing+tracing-attributes-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+default-devel = " \
 cargo \
 rust-tracing+attributes-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+log-always-devel = " \
 cargo \
 rust-tracing+log-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+max_level_debug-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+max_level_error-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+max_level_info-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+max_level_off-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+max_level_trace-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+max_level_warn-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+release_max_level_debug-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+release_max_level_error-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+release_max_level_info-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+release_max_level_off-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+release_max_level_trace-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+release_max_level_warn-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+std-devel = " \
 cargo \
 rust-tracing-core+std-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+tracing-attributes-devel = " \
 cargo \
 rust-tracing-attributes+default-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing-devel = " \
 cargo \
 rust \
 rust-pin-project-lite+default-devel \
 rust-tracing-core-devel \
 "
