# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yakuake"
PV = "25.12.3"
PR = "1.el10_3"
PACKAGES = " \
 yakuake \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/y/yakuake-25.12.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "16745b37c3118f45fa38b0db7810dd1f38eb3a6a34d5dc03d59dbfac20d70ac3"

URI_x86_64_v2_yakuake = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yakuake-25.12.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yakuake;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yakuake}"
SRC_URI[x86_64_v2_yakuake.sha256sum] = "b3b3ff2b3ba817271461e2d91445104d15ec67d55b5ddab9ccb06fb20abe73a1"

URI_aarch64_yakuake = "${EPEL_MIRROR}/aarch64/Packages/y/yakuake-25.12.3-1.el10_3.aarch64.rpm;name=aarch64_yakuake;unpack=0"
SRC_URI:append = " ${URI_aarch64_yakuake}"
SRC_URI[aarch64_yakuake.sha256sum] = "669d42b86e0e00d0c3391a20e947a5658ddb6326e252493b29fd0c81e2d54577"

RDEPENDS:yakuake = " \
 glibc \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kparts \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 konsole-part \
 kwayland \
 libX11 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
