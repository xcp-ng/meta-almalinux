# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-sonnet"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-sonnet \
 kf6-sonnet-aspell \
 kf6-sonnet-devel \
 kf6-sonnet-doc \
 kf6-sonnet-hspell \
 kf6-sonnet-html \
 kf6-sonnet-hunspell \
 kf6-sonnet-voikko \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-sonnet-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e3eb3acf6636d11cfa9824a6ce5d0e803cc44398fc4417275a7acf502527e8a"

URI_x86_64_v2_kf6-sonnet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-sonnet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-sonnet}"
SRC_URI[x86_64_v2_kf6-sonnet.sha256sum] = "404baad61e6acb2678639a13be9b9454b1d6d552d6a8de2987d1830f1d5f4e1a"

URI_x86_64_v2_kf6-sonnet-aspell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-aspell-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-sonnet-aspell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-sonnet-aspell}"
SRC_URI[x86_64_v2_kf6-sonnet-aspell.sha256sum] = "1d5e6b832b628f31999a16d4900bcab68e5199786e3ad1e0424638a7db8c1d3d"

URI_x86_64_v2_kf6-sonnet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-sonnet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-sonnet-devel}"
SRC_URI[x86_64_v2_kf6-sonnet-devel.sha256sum] = "7504dbafeb7a86f1cc69e92279b4a48a02ba918f6cdd633c08fb58b644392a54"

URI_x86_64_v2_kf6-sonnet-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-sonnet-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-sonnet-doc}"
SRC_URI[x86_64_v2_kf6-sonnet-doc.sha256sum] = "5a8ce92fda3b12ffc3efa2cb7b8854825d766827c377b0c74c3e72d3e65201f5"

URI_x86_64_v2_kf6-sonnet-hspell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-hspell-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-sonnet-hspell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-sonnet-hspell}"
SRC_URI[x86_64_v2_kf6-sonnet-hspell.sha256sum] = "53346e21e6e70c351bf472a274303a301d145b5aa07a816e66f4d6154dc1e9ac"

URI_x86_64_v2_kf6-sonnet-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-sonnet-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-sonnet-html}"
SRC_URI[x86_64_v2_kf6-sonnet-html.sha256sum] = "f991e7cad2dec7f5d928df316ded6dce943b14249ef1596241844686afafc021"

URI_x86_64_v2_kf6-sonnet-hunspell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-hunspell-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-sonnet-hunspell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-sonnet-hunspell}"
SRC_URI[x86_64_v2_kf6-sonnet-hunspell.sha256sum] = "884e4c7fee88ed6643cc9deb55ea5a9da80d757761c5e68a95d1851c95317b39"

URI_x86_64_v2_kf6-sonnet-voikko = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-voikko-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-sonnet-voikko;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-sonnet-voikko}"
SRC_URI[x86_64_v2_kf6-sonnet-voikko.sha256sum] = "d8e1eecb5e7b334c9e08427762e82ac625028789b4dfe3a5dde307b8eb49e063"

URI_aarch64_kf6-sonnet = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-sonnet;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-sonnet}"
SRC_URI[aarch64_kf6-sonnet.sha256sum] = "578f655eaa5c1a5ea9ca0190d544c663334eeca51d8a0b1c8d0ca52ccf0bddf3"

URI_aarch64_kf6-sonnet-aspell = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-aspell-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-sonnet-aspell;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-sonnet-aspell}"
SRC_URI[aarch64_kf6-sonnet-aspell.sha256sum] = "d3db98459b9e863a53885829b730d1b9cc30b16f349cce28e2e0555aee83c31d"

URI_aarch64_kf6-sonnet-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-sonnet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-sonnet-devel}"
SRC_URI[aarch64_kf6-sonnet-devel.sha256sum] = "842c87aa87c1501e714c9da79dd7700cf0c66fd8efc300a6cb2b4545c0fbbaa0"

URI_aarch64_kf6-sonnet-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-sonnet-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-sonnet-doc}"
SRC_URI[aarch64_kf6-sonnet-doc.sha256sum] = "ecf668625110610a882aba3bb4341c39fdc36b09e815b5d69e5151e88b2c13bc"

URI_aarch64_kf6-sonnet-hspell = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-hspell-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-sonnet-hspell;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-sonnet-hspell}"
SRC_URI[aarch64_kf6-sonnet-hspell.sha256sum] = "c9d2b7a1b89dd6110a60b000389b0214dea14b6e784a1957c5bb4e4fed1f9407"

URI_aarch64_kf6-sonnet-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-sonnet-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-sonnet-html}"
SRC_URI[aarch64_kf6-sonnet-html.sha256sum] = "c19914d646be95000d7997a622da0e59b24f7def8291cf8231ac1f7ef3bce196"

URI_aarch64_kf6-sonnet-hunspell = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-hunspell-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-sonnet-hunspell;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-sonnet-hunspell}"
SRC_URI[aarch64_kf6-sonnet-hunspell.sha256sum] = "ae1d75036c35eb89e7332564594528bc819bad8aba6616fba37bd72d197189c1"

URI_aarch64_kf6-sonnet-voikko = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-voikko-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-sonnet-voikko;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-sonnet-voikko}"
SRC_URI[aarch64_kf6-sonnet-voikko.sha256sum] = "414685a63323404f86a51c814fc06ceac7e823dc1ef122af741473d4120a36f5"

RDEPENDS:kf6-sonnet = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-sonnet-aspell = " \
 aspell \
 glibc \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-sonnet-devel = " \
 cmake-filesystem \
 glibc \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-sonnet-doc = " \
 "
RDEPENDS:kf6-sonnet-hspell = " \
 glibc \
 hspell \
 hunspell-he \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-sonnet-html = " \
 "
RDEPENDS:kf6-sonnet-hunspell = " \
 glibc \
 hunspell \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-sonnet-voikko = " \
 glibc \
 kf6-sonnet \
 libstdc++ \
 libvoikko \
 qt6-qtbase \
 "
