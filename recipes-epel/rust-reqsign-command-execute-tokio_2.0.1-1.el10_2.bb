# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-command-execute-tokio"
PV = "2.0.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-reqsign-command-execute-tokio+default-devel \
 rust-reqsign-command-execute-tokio-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-command-execute-tokio-2.0.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f2e421f3d7b91709a12f0954a1af6730dc1dad77d57073b70a68386fcf077657"

URI_x86_64_v2_rust-reqsign-command-execute-tokio+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-command-execute-tokio+default-devel-2.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-command-execute-tokio+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-command-execute-tokio+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign-command-execute-tokio+default-devel.sha256sum] = "d25d164c27af1215a0278a79cb330aaa4d8f31b00abbcd18ace32e862707bd59"

URI_x86_64_v2_rust-reqsign-command-execute-tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-command-execute-tokio-devel-2.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-command-execute-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-command-execute-tokio-devel}"
SRC_URI[x86_64_v2_rust-reqsign-command-execute-tokio-devel.sha256sum] = "8310250a6a0f66389741d46576cfeed1418ce3f33a6ecae8571d3d63bb7aacbf"

URI_aarch64_rust-reqsign-command-execute-tokio+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-command-execute-tokio+default-devel-2.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-reqsign-command-execute-tokio+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-command-execute-tokio+default-devel}"
SRC_URI[aarch64_rust-reqsign-command-execute-tokio+default-devel.sha256sum] = "07c9392130ad4da149a958383d8fa9c55b99461b8810349ec6365942d52c1363"

URI_aarch64_rust-reqsign-command-execute-tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-command-execute-tokio-devel-2.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-reqsign-command-execute-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-command-execute-tokio-devel}"
SRC_URI[aarch64_rust-reqsign-command-execute-tokio-devel.sha256sum] = "414df1ef3b63740ac1e0e2554c6af188082c0ec6853ec9e0f45ad0f082b93818"

RDEPENDS:rust-reqsign-command-execute-tokio+default-devel = " \
 cargo \
 rust-reqsign-command-execute-tokio-devel \
 "
RDEPENDS:rust-reqsign-command-execute-tokio-devel = " \
 cargo \
 rust \
 rust-async-trait+default-devel \
 rust-reqsign-core+default-devel \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio+process-devel \
 "
