# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-path-absolutize"
PV = "3.1.1"
PR = "4.el10_0"
PACKAGES = " \
 rust-path-absolutize+default-devel \
 rust-path-absolutize+lazy_static_cache-devel \
 rust-path-absolutize+once_cell_cache-devel \
 rust-path-absolutize+unsafe_cache-devel \
 rust-path-absolutize+use_unix_paths_on_wasm-devel \
 rust-path-absolutize-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-path-absolutize-3.1.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2cd949247b0e4f436efd65f6ad664ca0c5f436e60f1bbd780baa27f41171664e"

URI_x86_64_v2_rust-path-absolutize+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-path-absolutize+default-devel-3.1.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-path-absolutize+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-path-absolutize+default-devel}"
SRC_URI[x86_64_v2_rust-path-absolutize+default-devel.sha256sum] = "b56dbc530a4ee4f7f51b38251bd8bf01cfa83bf0776b6faae9c8955a3156d58d"

URI_x86_64_v2_rust-path-absolutize+lazy_static_cache-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-path-absolutize+lazy_static_cache-devel-3.1.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-path-absolutize+lazy_static_cache-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-path-absolutize+lazy_static_cache-devel}"
SRC_URI[x86_64_v2_rust-path-absolutize+lazy_static_cache-devel.sha256sum] = "2234773d342c1770266d6cbc4bae927965b591abddbb273794028031c26ba29e"

URI_x86_64_v2_rust-path-absolutize+once_cell_cache-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-path-absolutize+once_cell_cache-devel-3.1.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-path-absolutize+once_cell_cache-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-path-absolutize+once_cell_cache-devel}"
SRC_URI[x86_64_v2_rust-path-absolutize+once_cell_cache-devel.sha256sum] = "32017af15cda2d6ae7534a5fc6f162ccedf87b022be72dd49246bcbdaf765356"

URI_x86_64_v2_rust-path-absolutize+unsafe_cache-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-path-absolutize+unsafe_cache-devel-3.1.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-path-absolutize+unsafe_cache-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-path-absolutize+unsafe_cache-devel}"
SRC_URI[x86_64_v2_rust-path-absolutize+unsafe_cache-devel.sha256sum] = "699c178f2653aa75f503b063df262e4d8dcf978c1c928e82340b2da38fa5ce7f"

URI_x86_64_v2_rust-path-absolutize+use_unix_paths_on_wasm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-path-absolutize+use_unix_paths_on_wasm-devel-3.1.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-path-absolutize+use_unix_paths_on_wasm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-path-absolutize+use_unix_paths_on_wasm-devel}"
SRC_URI[x86_64_v2_rust-path-absolutize+use_unix_paths_on_wasm-devel.sha256sum] = "6f2c64e6b7480c5d311f234d6ca3970a7589ce8e1f28690fecdb727e4349c557"

URI_x86_64_v2_rust-path-absolutize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-path-absolutize-devel-3.1.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-path-absolutize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-path-absolutize-devel}"
SRC_URI[x86_64_v2_rust-path-absolutize-devel.sha256sum] = "79eeb64355de955dda4c25354464b549ace0abdecb765b82239d16fb8b5acac4"

URI_aarch64_rust-path-absolutize+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-path-absolutize+default-devel-3.1.1-4.el10_0.noarch.rpm;name=aarch64_rust-path-absolutize+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-path-absolutize+default-devel}"
SRC_URI[aarch64_rust-path-absolutize+default-devel.sha256sum] = "c258c28bba1845a90b92c0ec6527f8e55519cf82b4ad3723f51133ce50f62a92"

URI_aarch64_rust-path-absolutize+lazy_static_cache-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-path-absolutize+lazy_static_cache-devel-3.1.1-4.el10_0.noarch.rpm;name=aarch64_rust-path-absolutize+lazy_static_cache-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-path-absolutize+lazy_static_cache-devel}"
SRC_URI[aarch64_rust-path-absolutize+lazy_static_cache-devel.sha256sum] = "04d2c54b57ce0f81bbec8afa0fb4c1912fd3fffe1defa88b6f7d2ad894976a23"

URI_aarch64_rust-path-absolutize+once_cell_cache-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-path-absolutize+once_cell_cache-devel-3.1.1-4.el10_0.noarch.rpm;name=aarch64_rust-path-absolutize+once_cell_cache-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-path-absolutize+once_cell_cache-devel}"
SRC_URI[aarch64_rust-path-absolutize+once_cell_cache-devel.sha256sum] = "d573d3bff2dacc52ccc859c463e7955c69f1b50cf79ef9bfa916eb8dec041551"

URI_aarch64_rust-path-absolutize+unsafe_cache-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-path-absolutize+unsafe_cache-devel-3.1.1-4.el10_0.noarch.rpm;name=aarch64_rust-path-absolutize+unsafe_cache-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-path-absolutize+unsafe_cache-devel}"
SRC_URI[aarch64_rust-path-absolutize+unsafe_cache-devel.sha256sum] = "e9342952c8269d811b53d141b0dccf225784b4754a90c68955b09b628ab29708"

URI_aarch64_rust-path-absolutize+use_unix_paths_on_wasm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-path-absolutize+use_unix_paths_on_wasm-devel-3.1.1-4.el10_0.noarch.rpm;name=aarch64_rust-path-absolutize+use_unix_paths_on_wasm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-path-absolutize+use_unix_paths_on_wasm-devel}"
SRC_URI[aarch64_rust-path-absolutize+use_unix_paths_on_wasm-devel.sha256sum] = "ba101ba16e1324fcf7e118407c400ef280d6ef6edeacb2305f330d747e0144a1"

URI_aarch64_rust-path-absolutize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-path-absolutize-devel-3.1.1-4.el10_0.noarch.rpm;name=aarch64_rust-path-absolutize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-path-absolutize-devel}"
SRC_URI[aarch64_rust-path-absolutize-devel.sha256sum] = "9572f836850d81b058740a48d2050ec4df8167553864ad7180275c054ae3929f"

RDEPENDS:rust-path-absolutize+default-devel = " \
 cargo \
 rust-path-absolutize-devel \
 "
RDEPENDS:rust-path-absolutize+lazy_static_cache-devel = " \
 cargo \
 rust-path-absolutize-devel \
 rust-path-dedot+lazy_static_cache-devel \
 "
RDEPENDS:rust-path-absolutize+once_cell_cache-devel = " \
 cargo \
 rust-path-absolutize-devel \
 rust-path-dedot+once_cell_cache-devel \
 "
RDEPENDS:rust-path-absolutize+unsafe_cache-devel = " \
 cargo \
 rust-path-absolutize-devel \
 rust-path-dedot+unsafe_cache-devel \
 "
RDEPENDS:rust-path-absolutize+use_unix_paths_on_wasm-devel = " \
 cargo \
 rust-path-absolutize-devel \
 rust-path-dedot+use_unix_paths_on_wasm-devel \
 "
RDEPENDS:rust-path-absolutize-devel = " \
 cargo \
 rust \
 rust-path-dedot+default-devel \
 "
