# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-wayland-protocols"
PV = "1.20.0"
PR = "1.el10_2"
PACKAGES = " \
 plasma-wayland-protocols \
 plasma-wayland-protocols-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma-wayland-protocols-1.20.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "eea4286faf77311edb712aebe793c92ac3123de4fd827e47607e52d4a3428b16"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-wayland-protocols-1.20.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-wayland-protocols;unpack=0"
SRC_URI[x86_64_v2_plasma-wayland-protocols.sha256sum] = "4820b75f2a35b0c828b73009dd68e70823ab76db24246227d722c27826af794d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-wayland-protocols-devel-1.20.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-wayland-protocols-devel;unpack=0"
SRC_URI[x86_64_v2_plasma-wayland-protocols-devel.sha256sum] = "01b344a87c382348a1d79acca798f79c932931b5d7ea95af345d2d4e5f80391b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-wayland-protocols-1.20.0-1.el10_2.aarch64.rpm;name=aarch64_plasma-wayland-protocols;unpack=0"
SRC_URI[aarch64_plasma-wayland-protocols.sha256sum] = "edde9546ed9980ce8fba53bf4229f75712114013c03b8bee4b2f06273e18cdc6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-wayland-protocols-devel-1.20.0-1.el10_2.aarch64.rpm;name=aarch64_plasma-wayland-protocols-devel;unpack=0"
SRC_URI[aarch64_plasma-wayland-protocols-devel.sha256sum] = "f00e8ab52913af88d74e63cfa0a7e25b95bdf370fb8c6e2b71a868e8d5f3aa9f"

RDEPENDS:plasma-wayland-protocols = " \
 "
RDEPENDS:plasma-wayland-protocols-devel = " \
 cmake-filesystem \
 plasma-wayland-protocols \
 "
