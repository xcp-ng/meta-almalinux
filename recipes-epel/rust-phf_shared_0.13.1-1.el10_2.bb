# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-phf_shared"
PV = "0.13.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-phf_shared+default-devel \
 rust-phf_shared+std-devel \
 rust-phf_shared+uncased-devel \
 rust-phf_shared+unicase-devel \
 rust-phf_shared-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-phf_shared-0.13.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "35085fe47bef4307dbf31c61dec94265f5f7f0735a303f0efe84be3e7a20291c"

URI_x86_64_v2_rust-phf_shared+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_shared+default-devel-0.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_shared+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_shared+default-devel}"
SRC_URI[x86_64_v2_rust-phf_shared+default-devel.sha256sum] = "ca3469cab9e8ad02b9086cb3042594e9107a4231e7db7209a0cc9dad5647905c"

URI_x86_64_v2_rust-phf_shared+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_shared+std-devel-0.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_shared+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_shared+std-devel}"
SRC_URI[x86_64_v2_rust-phf_shared+std-devel.sha256sum] = "f7e7fa1717f1b67956cc1a8bec1504919120fa4b88b20b3646a1fcaf129c5db3"

URI_x86_64_v2_rust-phf_shared+uncased-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_shared+uncased-devel-0.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_shared+uncased-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_shared+uncased-devel}"
SRC_URI[x86_64_v2_rust-phf_shared+uncased-devel.sha256sum] = "8a4c712749aedd7df03903c90398b48f2a3052ffaecca3fcc5970ce57e455312"

URI_x86_64_v2_rust-phf_shared+unicase-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_shared+unicase-devel-0.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_shared+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_shared+unicase-devel}"
SRC_URI[x86_64_v2_rust-phf_shared+unicase-devel.sha256sum] = "9ed4efb025d709a792559155204a904efd87c22bbba40c4a3994ff408974a749"

URI_x86_64_v2_rust-phf_shared-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_shared-devel-0.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_shared-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_shared-devel}"
SRC_URI[x86_64_v2_rust-phf_shared-devel.sha256sum] = "8dd7eecdd2039fa984b455c57ab653a6eb727cb5ec5fb1c0a3aa08027e794dc0"

URI_aarch64_rust-phf_shared+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_shared+default-devel-0.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-phf_shared+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_shared+default-devel}"
SRC_URI[aarch64_rust-phf_shared+default-devel.sha256sum] = "a2eafa61dfaa0c8eb6d92cf6789f72f623a3ca0f1a3a95c1ad63480587991a70"

URI_aarch64_rust-phf_shared+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_shared+std-devel-0.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-phf_shared+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_shared+std-devel}"
SRC_URI[aarch64_rust-phf_shared+std-devel.sha256sum] = "bb9cf312afe91aceee559a2ad9046ea6ce7c802f598bd4389f750f6a726a6341"

URI_aarch64_rust-phf_shared+uncased-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_shared+uncased-devel-0.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-phf_shared+uncased-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_shared+uncased-devel}"
SRC_URI[aarch64_rust-phf_shared+uncased-devel.sha256sum] = "ffe3aaab194eb3c3e3ba37a6fb2aac87a50b054e4012721e52e9cebb019ba611"

URI_aarch64_rust-phf_shared+unicase-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_shared+unicase-devel-0.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-phf_shared+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_shared+unicase-devel}"
SRC_URI[aarch64_rust-phf_shared+unicase-devel.sha256sum] = "b8b3d4e8e747480ef7607216d19793518987407367c05c96e1599aea77bf7913"

URI_aarch64_rust-phf_shared-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_shared-devel-0.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-phf_shared-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_shared-devel}"
SRC_URI[aarch64_rust-phf_shared-devel.sha256sum] = "46f600c936483395ab11581448194b0230c2116d4c950444ac59ed3d74c4338d"

RDEPENDS:rust-phf_shared+default-devel = " \
 cargo \
 rust-phf_shared+std-devel \
 rust-phf_shared-devel \
 "
RDEPENDS:rust-phf_shared+std-devel = " \
 cargo \
 rust-phf_shared-devel \
 "
RDEPENDS:rust-phf_shared+uncased-devel = " \
 cargo \
 rust-phf_shared-devel \
 rust-uncased-devel \
 "
RDEPENDS:rust-phf_shared+unicase-devel = " \
 cargo \
 rust-phf_shared-devel \
 rust-unicase+default-devel \
 "
RDEPENDS:rust-phf_shared-devel = " \
 cargo \
 rust \
 rust-siphasher+default-devel \
 "
