# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gif2png"
PV = "2.5.14"
PR = "18.el10_0"
PACKAGES = " \
 gif2png \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gif2png-2.5.14-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a3b524cb71876300fe757366fbb5c0d5d2615a54595afbdcb49ab91da8c01a07"

URI_x86_64_v2_gif2png = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gif2png-2.5.14-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gif2png;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gif2png}"
SRC_URI[x86_64_v2_gif2png.sha256sum] = "55b789fc0fced436b68aa6b4e58df6753523ac134cb55a2f0a7f7c88111a559c"

URI_aarch64_gif2png = "${EPEL_MIRROR}/aarch64/Packages/g/gif2png-2.5.14-18.el10_0.aarch64.rpm;name=aarch64_gif2png;unpack=0"
SRC_URI:append = " ${URI_aarch64_gif2png}"
SRC_URI[aarch64_gif2png.sha256sum] = "b91102339a4c49b4a89476b4f3d8d8cfd2c5c19c245b8da0e3dc15ea5c053cfd"

RDEPENDS:gif2png = " \
 glibc \
 libpng \
 zlib-ng-compat \
 "
