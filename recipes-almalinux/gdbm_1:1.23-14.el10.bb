# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gdbm"
PE = "1"
PV = "1.23"
PR = "14.el10"
PACKAGES = " \
 gdbm \
 gdbm-devel \
 gdbm-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/gdbm-1.23-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85a59e52777e79a3dedb9f4a39cea42ad8d13fd02cfd2fb3e03c411bf36ef498"

URI_x86_64_v2_gdbm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/gdbm-1.23-14.el10.x86_64_v2.rpm;name=x86_64_v2_gdbm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdbm}"
SRC_URI[x86_64_v2_gdbm.sha256sum] = "38a293a805ff1a782334ac32591ec5263e0877f133585508171676ffae143853"

URI_x86_64_v2_gdbm-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gdbm-devel-1.23-14.el10.x86_64_v2.rpm;name=x86_64_v2_gdbm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdbm-devel}"
SRC_URI[x86_64_v2_gdbm-devel.sha256sum] = "10ac3fb4266152a29ed0c840cbbd62fe0205293af502838af8127ce29b3155d7"

URI_x86_64_v2_gdbm-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/gdbm-libs-1.23-14.el10.x86_64_v2.rpm;name=x86_64_v2_gdbm-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdbm-libs}"
SRC_URI[x86_64_v2_gdbm-libs.sha256sum] = "cafb3be84996bd0d1c4a61a83b941405af0516c9ab9d4cea748567af42731eaa"

URI_aarch64_gdbm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/gdbm-1.23-14.el10.aarch64.rpm;name=aarch64_gdbm;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdbm}"
SRC_URI[aarch64_gdbm.sha256sum] = "f654f2f94cae0af634b8883e3976d944ada9595f7e92e9ad88cf273af7b9e8f2"

URI_aarch64_gdbm-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gdbm-devel-1.23-14.el10.aarch64.rpm;name=aarch64_gdbm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdbm-devel}"
SRC_URI[aarch64_gdbm-devel.sha256sum] = "a0e6dbdb1436a201de092490b594bfa20f3239853455966e06aff9b87f0a7b02"

URI_aarch64_gdbm-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/gdbm-libs-1.23-14.el10.aarch64.rpm;name=aarch64_gdbm-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdbm-libs}"
SRC_URI[aarch64_gdbm-libs.sha256sum] = "ea90f9b9d544f9278c439f89c76ad3e2c85afb365d1c0048ec1d9adc6f7e0ca6"

RDEPENDS:gdbm = " \
 gdbm-libs \
 glibc \
 readline \
 "
RDEPENDS:gdbm-devel = " \
 gdbm \
 gdbm-libs \
 info \
 "
RDEPENDS:gdbm-libs = " \
 glibc \
 "
