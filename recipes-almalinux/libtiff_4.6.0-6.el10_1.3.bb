# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libtiff"
PV = "4.6.0"
PR = "6.el10_1.3"
PACKAGES = " \
 libtiff \
 libtiff-devel \
 libtiff-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libtiff-4.6.0-6.el10_1.3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f071cbd1d655a7bec205ef8c61a891eb02abae94c4f2df2f032d077876db326"

URI_x86_64_v2_libtiff = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libtiff-4.6.0-6.el10_1.3.x86_64_v2.rpm;name=x86_64_v2_libtiff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtiff}"
SRC_URI[x86_64_v2_libtiff.sha256sum] = "81d2d28e9b10e16f70510d84e3ff38e7cedc80ec6bbe5d421f5f122b69272126"
RPROVIDES:libtiff:append:x86_64_v2 = " virtual/libtiffxx.so.6___64bit_"

URI_x86_64_v2_libtiff-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libtiff-devel-4.6.0-6.el10_1.3.x86_64_v2.rpm;name=x86_64_v2_libtiff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtiff-devel}"
SRC_URI[x86_64_v2_libtiff-devel.sha256sum] = "7fab7fe1a6a085dfa2f6a22c908ec64c7ab0c761b4938d9c82be3e4f9523a20b"

URI_x86_64_v2_libtiff-tools = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libtiff-tools-4.6.0-6.el10_1.3.x86_64_v2.rpm;name=x86_64_v2_libtiff-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtiff-tools}"
SRC_URI[x86_64_v2_libtiff-tools.sha256sum] = "a88fac24349e644c43514852e1583a1e633f2461ca7b3fd4ce414ac833867b93"

URI_aarch64_libtiff = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libtiff-4.6.0-6.el10_1.3.aarch64.rpm;name=aarch64_libtiff;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtiff}"
SRC_URI[aarch64_libtiff.sha256sum] = "1ba90473b40b22af30c72ae25847b400eb5bc631d4192b530c6c0ae461291d8d"
RPROVIDES:libtiff:append:aarch64 = " virtual/libtiffxx.so.6___64bit_"

URI_aarch64_libtiff-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libtiff-devel-4.6.0-6.el10_1.3.aarch64.rpm;name=aarch64_libtiff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtiff-devel}"
SRC_URI[aarch64_libtiff-devel.sha256sum] = "a6bff9d6eac55806d5f02b7a582ef22330872d9b3a52819c3d7371ba7ea0a251"

URI_aarch64_libtiff-tools = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libtiff-tools-4.6.0-6.el10_1.3.aarch64.rpm;name=aarch64_libtiff-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtiff-tools}"
SRC_URI[aarch64_libtiff-tools.sha256sum] = "e6d5a0d9dce3d257225778da206a9bbc3f41507a969ccee3c299189d1ba863c9"

RDEPENDS:libtiff = " \
 glibc \
 jbigkit-libs \
 libgcc \
 libjpeg-turbo \
 liblerc \
 libstdc++ \
 libwebp \
 libzstd \
 zlib-ng-compat \
 "
RDEPENDS:libtiff-devel = " \
 libjpeg-turbo-devel \
 libtiff \
 libwebp-devel \
 libzstd-devel \
 pkgconf-pkg-config \
 virtual/libtiffxx.so.6___64bit_ \
 zlib-ng-compat-devel \
 "
RDEPENDS:libtiff-tools = " \
 glibc \
 libtiff \
 "
