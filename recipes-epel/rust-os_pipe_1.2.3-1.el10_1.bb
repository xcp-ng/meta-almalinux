# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-os_pipe"
PV = "1.2.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-os_pipe+default-devel \
 rust-os_pipe+io_safety-devel \
 rust-os_pipe-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-os_pipe-1.2.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9f54f3332d31a8526b2d7ab54bf6eef54566d5b6f0033bc88d76e4f66ec0438"

URI_x86_64_v2_rust-os_pipe+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_pipe+default-devel-1.2.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_pipe+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_pipe+default-devel}"
SRC_URI[x86_64_v2_rust-os_pipe+default-devel.sha256sum] = "b7f6a2ad874718d5a314594a76c8a27e22a4164fbc288187951c39e2983ed36e"

URI_x86_64_v2_rust-os_pipe+io_safety-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_pipe+io_safety-devel-1.2.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_pipe+io_safety-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_pipe+io_safety-devel}"
SRC_URI[x86_64_v2_rust-os_pipe+io_safety-devel.sha256sum] = "7a3038769761bffd6d0b6f519f3de097cfa42f1550cebc499a51b8d7a3c7a3d2"

URI_x86_64_v2_rust-os_pipe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_pipe-devel-1.2.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_pipe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_pipe-devel}"
SRC_URI[x86_64_v2_rust-os_pipe-devel.sha256sum] = "ab80fcee4d9c3038738daa224829c5e99160aa61bf7c5770e358414472c3d903"

URI_aarch64_rust-os_pipe+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_pipe+default-devel-1.2.3-1.el10_1.noarch.rpm;name=aarch64_rust-os_pipe+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_pipe+default-devel}"
SRC_URI[aarch64_rust-os_pipe+default-devel.sha256sum] = "fe1f964054945226f4c838c5107d92dba4173dbd17bb16e25c144cbef2d58121"

URI_aarch64_rust-os_pipe+io_safety-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_pipe+io_safety-devel-1.2.3-1.el10_1.noarch.rpm;name=aarch64_rust-os_pipe+io_safety-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_pipe+io_safety-devel}"
SRC_URI[aarch64_rust-os_pipe+io_safety-devel.sha256sum] = "c0e4b34568e9bae44f687e4e76d253896bb0f76d07e875ba9b9ca741b530ba1d"

URI_aarch64_rust-os_pipe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_pipe-devel-1.2.3-1.el10_1.noarch.rpm;name=aarch64_rust-os_pipe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_pipe-devel}"
SRC_URI[aarch64_rust-os_pipe-devel.sha256sum] = "0f7cb278e779175f9b2daeafa229e1c4dcf4f1ff08926851c8fd22df85e716b9"

RDEPENDS:rust-os_pipe+default-devel = " \
 cargo \
 rust-os_pipe-devel \
 "
RDEPENDS:rust-os_pipe+io_safety-devel = " \
 cargo \
 rust-os_pipe-devel \
 "
RDEPENDS:rust-os_pipe-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
