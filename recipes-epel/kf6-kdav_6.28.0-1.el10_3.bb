# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kdav"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kdav \
 kf6-kdav-devel \
 kf6-kdav-doc \
 kf6-kdav-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kdav-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1be8769361dd0bac7f210964867a0094b6bdbb94c05cfdc7d302a1821262c3b4"

URI_x86_64_v2_kf6-kdav = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdav-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdav;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdav}"
SRC_URI[x86_64_v2_kf6-kdav.sha256sum] = "1415012af22167c47f2277b056b3e929310b78b077d8f9c9974973017d1c43ac"

URI_x86_64_v2_kf6-kdav-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdav-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdav-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdav-devel}"
SRC_URI[x86_64_v2_kf6-kdav-devel.sha256sum] = "7a61b51c498292f8d2265e1f683ac6b6a2cff2244f56640ab8516cfb4981a012"

URI_x86_64_v2_kf6-kdav-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdav-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdav-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdav-doc}"
SRC_URI[x86_64_v2_kf6-kdav-doc.sha256sum] = "bd79f50471eb450ea334c17c30de96a8b39e3599d4cdc4ef519b910f7d270747"

URI_x86_64_v2_kf6-kdav-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdav-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdav-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdav-html}"
SRC_URI[x86_64_v2_kf6-kdav-html.sha256sum] = "2511e934a93bbbfa7780af921fd7ec762b254a31cb767694acd22f701c62bbde"

URI_aarch64_kf6-kdav = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdav-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kdav;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdav}"
SRC_URI[aarch64_kf6-kdav.sha256sum] = "6105b88c935f4ddae7c6047b0ae7bab2c48f2575a6ba4df66222e7beb82506e0"

URI_aarch64_kf6-kdav-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdav-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kdav-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdav-devel}"
SRC_URI[aarch64_kf6-kdav-devel.sha256sum] = "d0a79b3832f8a6c9580b9159bcbbc9224e874ca7020de65b4a4934ac422fc7db"

URI_aarch64_kf6-kdav-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdav-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kdav-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdav-doc}"
SRC_URI[aarch64_kf6-kdav-doc.sha256sum] = "104b51c3ee85b9c455aa8abf66e12db393a1e8ab1973abf836b6f64780211740"

URI_aarch64_kf6-kdav-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdav-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kdav-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdav-html}"
SRC_URI[aarch64_kf6-kdav-html.sha256sum] = "f87be979518f0ad5dca5c522f3e46623b8c6260f9912427d539417a82975cac0"

RDEPENDS:kf6-kdav = " \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kdav-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kf6-kdav \
 "
RDEPENDS:kf6-kdav-doc = " \
 "
RDEPENDS:kf6-kdav-html = " \
 "
