# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-IO-Compress-Zstd"
PV = "2.212"
PR = "2.el10_0"
PACKAGES = " \
 perl-IO-Compress-Zstd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-IO-Compress-Zstd-2.212-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "daa253749351277e6243ce02b62a9204e9838b21d2d1f5dd941b7d9721c0667e"

URI_x86_64_v2_perl-IO-Compress-Zstd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-IO-Compress-Zstd-2.212-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-IO-Compress-Zstd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-IO-Compress-Zstd}"
SRC_URI[x86_64_v2_perl-IO-Compress-Zstd.sha256sum] = "e44d72e557fcbf7d509bd1cdf25ab66b6bc66fd2b639cc616d15a3477a1c933c"

URI_aarch64_perl-IO-Compress-Zstd = "${EPEL_MIRROR}/aarch64/Packages/p/perl-IO-Compress-Zstd-2.212-2.el10_0.noarch.rpm;name=aarch64_perl-IO-Compress-Zstd;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-IO-Compress-Zstd}"
SRC_URI[aarch64_perl-IO-Compress-Zstd.sha256sum] = "a76ea9cc953282785c6e2e01c9414861f89bcdb605170a4dff5d7e2f3b2deae4"

RDEPENDS:perl-IO-Compress-Zstd = " \
 perl-Compress-Stream-Zstd \
 perl-Exporter \
 perl-IO-Compress \
 perl-IO-Compress-Zstd \
 perl-constant \
 perl-libs \
 "
