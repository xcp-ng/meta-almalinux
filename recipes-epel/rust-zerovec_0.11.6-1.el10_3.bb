# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerovec"
PV = "0.11.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-zerovec+alloc-devel \
 rust-zerovec+databake-devel \
 rust-zerovec+default-devel \
 rust-zerovec+derive-devel \
 rust-zerovec+hashmap-devel \
 rust-zerovec+schemars-devel \
 rust-zerovec+serde-devel \
 rust-zerovec+std-devel \
 rust-zerovec+yoke-devel \
 rust-zerovec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zerovec-0.11.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9916f258f2c0d9c32665493982b4adf52e520c4470b9e7d22e6677b598c3d38b"

URI_x86_64_v2_rust-zerovec+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+alloc-devel-0.11.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec+alloc-devel}"
SRC_URI[x86_64_v2_rust-zerovec+alloc-devel.sha256sum] = "a51c03da4b6860f2a16a2cc54fce98fe37c9028a82d02e47cb126c07eebea64c"

URI_x86_64_v2_rust-zerovec+databake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+databake-devel-0.11.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+databake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec+databake-devel}"
SRC_URI[x86_64_v2_rust-zerovec+databake-devel.sha256sum] = "8359fe8cb768b5105cab54131ce75c206a854713033d64b4bd53912789b9cb9c"

URI_x86_64_v2_rust-zerovec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+default-devel-0.11.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec+default-devel}"
SRC_URI[x86_64_v2_rust-zerovec+default-devel.sha256sum] = "ff45cdf79981c91dc139571c071824136f60efcca72eeb8f1f7df3baebda5749"

URI_x86_64_v2_rust-zerovec+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+derive-devel-0.11.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec+derive-devel}"
SRC_URI[x86_64_v2_rust-zerovec+derive-devel.sha256sum] = "ec7b543a92cd93c257573fc1b0744750eb2bfc2839333b640d7d565252b09687"

URI_x86_64_v2_rust-zerovec+hashmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+hashmap-devel-0.11.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+hashmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec+hashmap-devel}"
SRC_URI[x86_64_v2_rust-zerovec+hashmap-devel.sha256sum] = "b8a4c608c10faef2fcd74abf4d23b5322359e42668dc0271e7186e5acd31af8a"

URI_x86_64_v2_rust-zerovec+schemars-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+schemars-devel-0.11.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+schemars-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec+schemars-devel}"
SRC_URI[x86_64_v2_rust-zerovec+schemars-devel.sha256sum] = "982e4b0fb1415728778c13aa0e246b091efcf731ad0900792be6da6e98a882a9"

URI_x86_64_v2_rust-zerovec+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+serde-devel-0.11.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec+serde-devel}"
SRC_URI[x86_64_v2_rust-zerovec+serde-devel.sha256sum] = "3b3c674b16b81a792b7a1e854a1f6d4aef113888e0298e5a0e51f1fc97fab690"

URI_x86_64_v2_rust-zerovec+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+std-devel-0.11.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec+std-devel}"
SRC_URI[x86_64_v2_rust-zerovec+std-devel.sha256sum] = "2e900136e3918fd8d4b557fa1580205bd16cb4005be05dc21e231acaf7befdb2"

URI_x86_64_v2_rust-zerovec+yoke-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+yoke-devel-0.11.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+yoke-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec+yoke-devel}"
SRC_URI[x86_64_v2_rust-zerovec+yoke-devel.sha256sum] = "0f64601ffc139a5022befe219283784e1c6c7549b222192d7406ab57e25354f7"

URI_x86_64_v2_rust-zerovec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec-devel-0.11.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec-devel}"
SRC_URI[x86_64_v2_rust-zerovec-devel.sha256sum] = "c1dbf5502fee73aed178a1cfdeead0cc82b77827d226e5afc4d7024d57d0493f"

URI_aarch64_rust-zerovec+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+alloc-devel-0.11.6-1.el10_3.noarch.rpm;name=aarch64_rust-zerovec+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec+alloc-devel}"
SRC_URI[aarch64_rust-zerovec+alloc-devel.sha256sum] = "7424f8fd142bfd97e492bb1a5e48bc373d051fe9297babd619f1efa41accacbe"

URI_aarch64_rust-zerovec+databake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+databake-devel-0.11.6-1.el10_3.noarch.rpm;name=aarch64_rust-zerovec+databake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec+databake-devel}"
SRC_URI[aarch64_rust-zerovec+databake-devel.sha256sum] = "a72040ec1b751a739023ea7903966ff1c09bc2a862ad92de84dc29d3e8da2c00"

URI_aarch64_rust-zerovec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+default-devel-0.11.6-1.el10_3.noarch.rpm;name=aarch64_rust-zerovec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec+default-devel}"
SRC_URI[aarch64_rust-zerovec+default-devel.sha256sum] = "766a6a8a689e1dc1a330aac765541ebec1767387e343129f93eef89fdc17e360"

URI_aarch64_rust-zerovec+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+derive-devel-0.11.6-1.el10_3.noarch.rpm;name=aarch64_rust-zerovec+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec+derive-devel}"
SRC_URI[aarch64_rust-zerovec+derive-devel.sha256sum] = "9749c7d5f56bb76b4b4e53e6789fc0c26e4b11896074e75a2b334e481b69fbd2"

URI_aarch64_rust-zerovec+hashmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+hashmap-devel-0.11.6-1.el10_3.noarch.rpm;name=aarch64_rust-zerovec+hashmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec+hashmap-devel}"
SRC_URI[aarch64_rust-zerovec+hashmap-devel.sha256sum] = "b441dbbb1dac6d532990aedb858a04dc032fe089b5399b4a6001e79a1e3acae1"

URI_aarch64_rust-zerovec+schemars-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+schemars-devel-0.11.6-1.el10_3.noarch.rpm;name=aarch64_rust-zerovec+schemars-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec+schemars-devel}"
SRC_URI[aarch64_rust-zerovec+schemars-devel.sha256sum] = "1a8d75a486aafc2095a19498d8d3ae99e7d3ce8bf08bf5787a167c66e1be6c15"

URI_aarch64_rust-zerovec+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+serde-devel-0.11.6-1.el10_3.noarch.rpm;name=aarch64_rust-zerovec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec+serde-devel}"
SRC_URI[aarch64_rust-zerovec+serde-devel.sha256sum] = "34219df622ceb63c480120ba2bf6adb3d29f3d6eb963ee9e003add8472d73755"

URI_aarch64_rust-zerovec+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+std-devel-0.11.6-1.el10_3.noarch.rpm;name=aarch64_rust-zerovec+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec+std-devel}"
SRC_URI[aarch64_rust-zerovec+std-devel.sha256sum] = "d333eb61112aaa55238b582551b6b5456c804c19dfe9754b091f6d0894df2ac4"

URI_aarch64_rust-zerovec+yoke-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+yoke-devel-0.11.6-1.el10_3.noarch.rpm;name=aarch64_rust-zerovec+yoke-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec+yoke-devel}"
SRC_URI[aarch64_rust-zerovec+yoke-devel.sha256sum] = "9aca7024086565d65c61a9cb5620c9efde2d94c98e0413a7bc598b496d214ea2"

URI_aarch64_rust-zerovec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec-devel-0.11.6-1.el10_3.noarch.rpm;name=aarch64_rust-zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec-devel}"
SRC_URI[aarch64_rust-zerovec-devel.sha256sum] = "dab9d6c0d8333194452e7c7d0b4a3316148e126b2457a4027906055dd07064e1"

RDEPENDS:rust-zerovec+alloc-devel = " \
 cargo \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+databake-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+default-devel = " \
 cargo \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+derive-devel = " \
 cargo \
 rust-zerovec-derive-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+hashmap-devel = " \
 cargo \
 rust-twox-hash+xxhash64-devel \
 rust-twox-hash-devel \
 rust-zerovec+alloc-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+schemars-devel = " \
 cargo \
 rust-schemars-devel \
 rust-zerovec+alloc-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+serde-devel = " \
 cargo \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+std-devel = " \
 cargo \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+yoke-devel = " \
 cargo \
 rust-yoke-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec-devel = " \
 cargo \
 rust \
 rust-zerofrom-devel \
 "
