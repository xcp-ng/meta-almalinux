# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rdma-core"
PV = "62.0"
PR = "2.el10"
PACKAGES = " \
 ibacm \
 infiniband-diags \
 iwpmd \
 libibumad \
 libibverbs \
 libibverbs-utils \
 librdmacm \
 librdmacm-utils \
 python3-pyverbs \
 rdma-core \
 rdma-core-devel \
 srp_daemon \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/rdma-core-62.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e86d2bdbbaf55c5b80b70e4ac63fa48ea7db3585b95f4a63fa7fb12773d4a133"

URI_x86_64_v2_ibacm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ibacm-62.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_ibacm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibacm}"
SRC_URI[x86_64_v2_ibacm.sha256sum] = "a816d105133bf7d9cd626ce96c6d446c5ba050a3f85c527173dc5ff0cd6226e5"

URI_x86_64_v2_infiniband-diags = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/infiniband-diags-62.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_infiniband-diags;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_infiniband-diags}"
SRC_URI[x86_64_v2_infiniband-diags.sha256sum] = "0807d514860fbfb7464e40077b0d9a3f99de8e6a82f15ce9b86a9ab96e54bfb8"

URI_x86_64_v2_iwpmd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iwpmd-62.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_iwpmd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iwpmd}"
SRC_URI[x86_64_v2_iwpmd.sha256sum] = "0914979aaabaf6bdf9cec3d68ec622eb563ad6da441b5717cc53ea70fc2bda90"

URI_x86_64_v2_libibumad = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libibumad-62.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libibumad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libibumad}"
SRC_URI[x86_64_v2_libibumad.sha256sum] = "44b77d709fe0124f8b6ade49b4025810b0a2cde71486c3c0ad434e110ee89e54"

URI_x86_64_v2_libibverbs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libibverbs-62.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libibverbs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libibverbs}"
SRC_URI[x86_64_v2_libibverbs.sha256sum] = "10c0e3244b34fba34e9b95a6c43cce532c04fa36c16660a1e79213b4609bacfd"

URI_x86_64_v2_libibverbs-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libibverbs-utils-62.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libibverbs-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libibverbs-utils}"
SRC_URI[x86_64_v2_libibverbs-utils.sha256sum] = "db231434457cc61622a0ca38ec3d86578f9975492f681b7e9cea6886e8f1cf82"

URI_x86_64_v2_librdmacm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/librdmacm-62.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_librdmacm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librdmacm}"
SRC_URI[x86_64_v2_librdmacm.sha256sum] = "1f636c08cd242950d2b4e2ab2ea99995e9624aa289b8f3a18522c625b77eec55"

URI_x86_64_v2_librdmacm-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/librdmacm-utils-62.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_librdmacm-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librdmacm-utils}"
SRC_URI[x86_64_v2_librdmacm-utils.sha256sum] = "124a9fb46d275c9f987a68d338f92cd21bc7bddc4028f571861a8d396c67de14"

URI_x86_64_v2_python3-pyverbs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pyverbs-62.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3-pyverbs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyverbs}"
SRC_URI[x86_64_v2_python3-pyverbs.sha256sum] = "f05277ab6a6a734ea99a7f9ddd2062332d4a3f0d73098b1c831d2a0e20182083"

URI_x86_64_v2_rdma-core = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rdma-core-62.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_rdma-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rdma-core}"
SRC_URI[x86_64_v2_rdma-core.sha256sum] = "f36534de6d449a3f3e04ccbc8a208a5b1b75eff6333d56faa1bf84bab8801893"

URI_x86_64_v2_rdma-core-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rdma-core-devel-62.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_rdma-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rdma-core-devel}"
SRC_URI[x86_64_v2_rdma-core-devel.sha256sum] = "d70dab5cd0bf6df0bfb7b320701f60001cbfa2a49f5c1e5c8d8a92f5a59e05ab"

URI_x86_64_v2_srp_daemon = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/srp_daemon-62.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_srp_daemon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_srp_daemon}"
SRC_URI[x86_64_v2_srp_daemon.sha256sum] = "0ca2d3d94e72d31c448a0b9886bc4e8d02deb0b7c9211e450dc04b032bba2601"

URI_aarch64_ibacm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ibacm-62.0-2.el10.aarch64.rpm;name=aarch64_ibacm;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibacm}"
SRC_URI[aarch64_ibacm.sha256sum] = "0ae26cd71266bc6afc1b496aa20cfd19e61c9de559b0a34d65689139aedc09d7"

URI_aarch64_infiniband-diags = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/infiniband-diags-62.0-2.el10.aarch64.rpm;name=aarch64_infiniband-diags;unpack=0"
SRC_URI:append = " ${URI_aarch64_infiniband-diags}"
SRC_URI[aarch64_infiniband-diags.sha256sum] = "b1b9a6b9536457e502890621f1de21b05b9b8a60ba9bf48914e4ae9f66670387"

URI_aarch64_iwpmd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iwpmd-62.0-2.el10.aarch64.rpm;name=aarch64_iwpmd;unpack=0"
SRC_URI:append = " ${URI_aarch64_iwpmd}"
SRC_URI[aarch64_iwpmd.sha256sum] = "c38d7c9bc05d7449ca8beb44bafc8d13c73f89e7dcaec8e805f61307ed619f84"

URI_aarch64_libibumad = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libibumad-62.0-2.el10.aarch64.rpm;name=aarch64_libibumad;unpack=0"
SRC_URI:append = " ${URI_aarch64_libibumad}"
SRC_URI[aarch64_libibumad.sha256sum] = "e8c79667a171d5f79ccc369b145f80264b9e011a623fe3dc35fbc4f9466004ba"

URI_aarch64_libibverbs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libibverbs-62.0-2.el10.aarch64.rpm;name=aarch64_libibverbs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libibverbs}"
SRC_URI[aarch64_libibverbs.sha256sum] = "7da1d9c948bbdd2959db3470c4124bec07e488a8be494167668b038016769555"

URI_aarch64_libibverbs-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libibverbs-utils-62.0-2.el10.aarch64.rpm;name=aarch64_libibverbs-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libibverbs-utils}"
SRC_URI[aarch64_libibverbs-utils.sha256sum] = "dc7eaf795563abc62b9b53082fd1cd9a1d0b7a7784d02b4d17f7f5b9be77e063"

URI_aarch64_librdmacm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/librdmacm-62.0-2.el10.aarch64.rpm;name=aarch64_librdmacm;unpack=0"
SRC_URI:append = " ${URI_aarch64_librdmacm}"
SRC_URI[aarch64_librdmacm.sha256sum] = "1737b2436ebfdffffeb084487d9dda22f7dec2d56a815058db62d9b3ade387ea"

URI_aarch64_librdmacm-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/librdmacm-utils-62.0-2.el10.aarch64.rpm;name=aarch64_librdmacm-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_librdmacm-utils}"
SRC_URI[aarch64_librdmacm-utils.sha256sum] = "edeee1efad42f8f09cc51f1b87952fadf815a4ac546c37bd612ecb17e7e0c23e"

URI_aarch64_python3-pyverbs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pyverbs-62.0-2.el10.aarch64.rpm;name=aarch64_python3-pyverbs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyverbs}"
SRC_URI[aarch64_python3-pyverbs.sha256sum] = "593415ea7c80c1dd4c18ff322543fe41c3c9588ee40cb71990b9a8915229c4a7"

URI_aarch64_rdma-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rdma-core-62.0-2.el10.aarch64.rpm;name=aarch64_rdma-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_rdma-core}"
SRC_URI[aarch64_rdma-core.sha256sum] = "2c885380229bae444b9c134b55bbbd207c08b485ab7c656e9616a009c104bbd3"

URI_aarch64_rdma-core-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rdma-core-devel-62.0-2.el10.aarch64.rpm;name=aarch64_rdma-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rdma-core-devel}"
SRC_URI[aarch64_rdma-core-devel.sha256sum] = "35ac5e214f9d048ba8b42028f069c6c0f5fe62a871e2dae1282f3cbc26da8535"

URI_aarch64_srp_daemon = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/srp_daemon-62.0-2.el10.aarch64.rpm;name=aarch64_srp_daemon;unpack=0"
SRC_URI:append = " ${URI_aarch64_srp_daemon}"
SRC_URI[aarch64_srp_daemon.sha256sum] = "95ceafe3a454b04c301110bf1b8fecbf901a045f6a4e19734b82e879b561f192"

RDEPENDS:ibacm = " \
 bash \
 glibc \
 libibumad \
 libibverbs \
 libnl3 \
 systemd \
 systemd-libs \
 "
RDEPENDS:infiniband-diags = " \
 bash \
 glibc \
 libibumad \
 perl-Getopt-Std \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:iwpmd = " \
 bash \
 glibc \
 libnl3 \
 systemd \
 systemd-libs \
 "
RDEPENDS:libibumad = " \
 glibc \
 "
RDEPENDS:libibverbs = " \
 glibc \
 libnl3 \
 "
RDEPENDS:libibverbs-utils = " \
 glibc \
 libibverbs \
 "
RDEPENDS:librdmacm = " \
 glibc \
 libibverbs \
 libnl3 \
 "
RDEPENDS:librdmacm-utils = " \
 glibc \
 libibverbs \
 librdmacm \
 "
RDEPENDS:python3-pyverbs = " \
 glibc \
 libibverbs \
 librdmacm \
 python3 \
 python3-libs \
 "
RDEPENDS:rdma-core = " \
 bash \
 glibc \
 libnl3 \
 pciutils \
 python3 \
 systemd-libs \
 "
RDEPENDS:rdma-core-devel = " \
 infiniband-diags \
 libibumad \
 libibverbs \
 librdmacm \
 pkgconf-pkg-config \
 rdma-core-devel \
 "
RDEPENDS:srp_daemon = " \
 bash \
 glibc \
 libibumad \
 libibverbs \
 systemd \
 "
