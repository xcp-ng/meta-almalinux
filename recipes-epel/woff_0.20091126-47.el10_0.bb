# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "woff"
PV = "0.20091126"
PR = "47.el10_0"
PACKAGES = " \
 woff \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/woff-0.20091126-47.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e3bf45972625e78b8ef5f18d823e3b7cdcbd0537bc4cd984c32856226f490833"

URI_x86_64_v2_woff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/woff-0.20091126-47.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_woff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_woff}"
SRC_URI[x86_64_v2_woff.sha256sum] = "0bfe46fccbafa15032b5194756d9d9a4be14a3abeee2fab409cd0d44a3c45e4b"

URI_aarch64_woff = "${EPEL_MIRROR}/aarch64/Packages/w/woff-0.20091126-47.el10_0.aarch64.rpm;name=aarch64_woff;unpack=0"
SRC_URI:append = " ${URI_aarch64_woff}"
SRC_URI[aarch64_woff.sha256sum] = "6f5a87aa34c8da06fdc56c761b87b0e8ed9f7b00b0f77008983e2b46b1e1db35"

RDEPENDS:woff = " \
 glibc \
 zlib-ng-compat \
 "
