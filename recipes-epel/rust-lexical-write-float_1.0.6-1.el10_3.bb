# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lexical-write-float"
PV = "1.0.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-lexical-write-float+compact-devel \
 rust-lexical-write-float+default-devel \
 rust-lexical-write-float+f128-devel \
 rust-lexical-write-float+f16-devel \
 rust-lexical-write-float+format-devel \
 rust-lexical-write-float+lint-devel \
 rust-lexical-write-float+power-of-two-devel \
 rust-lexical-write-float+radix-devel \
 rust-lexical-write-float+std-devel \
 rust-lexical-write-float-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lexical-write-float-1.0.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50f08c54faa8cad07e4886a1527dd6ed8761d164196603524f93f40e1328fbc1"

URI_x86_64_v2_rust-lexical-write-float+compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-write-float+compact-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-write-float+compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-write-float+compact-devel}"
SRC_URI[x86_64_v2_rust-lexical-write-float+compact-devel.sha256sum] = "82ee934dda3330420d9bcfc7a4854f3c53737089206347ebdc14f8fd2e863856"

URI_x86_64_v2_rust-lexical-write-float+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-write-float+default-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-write-float+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-write-float+default-devel}"
SRC_URI[x86_64_v2_rust-lexical-write-float+default-devel.sha256sum] = "bc4071c12b1ed28f492727ae2b88f6054950061fd171de1a8052931547e150b6"

URI_x86_64_v2_rust-lexical-write-float+f128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-write-float+f128-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-write-float+f128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-write-float+f128-devel}"
SRC_URI[x86_64_v2_rust-lexical-write-float+f128-devel.sha256sum] = "59205234e54b9a6deb76179039e9d8202a6364574544b5659cce361bc79b3583"

URI_x86_64_v2_rust-lexical-write-float+f16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-write-float+f16-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-write-float+f16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-write-float+f16-devel}"
SRC_URI[x86_64_v2_rust-lexical-write-float+f16-devel.sha256sum] = "f8d8cca2a1dee12020390f1e3ee2cb87e78f367e7085a9313f8340e1beebd77f"

URI_x86_64_v2_rust-lexical-write-float+format-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-write-float+format-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-write-float+format-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-write-float+format-devel}"
SRC_URI[x86_64_v2_rust-lexical-write-float+format-devel.sha256sum] = "4d9bf0ebbfd3a5bb1ce55fb128700aab57136b04119514ec4224da9088a0e5c0"

URI_x86_64_v2_rust-lexical-write-float+lint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-write-float+lint-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-write-float+lint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-write-float+lint-devel}"
SRC_URI[x86_64_v2_rust-lexical-write-float+lint-devel.sha256sum] = "2b6ee421a4adbd420cd5984514c53b7ab999c688a896c9ea41dfdf04db8bfacd"

URI_x86_64_v2_rust-lexical-write-float+power-of-two-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-write-float+power-of-two-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-write-float+power-of-two-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-write-float+power-of-two-devel}"
SRC_URI[x86_64_v2_rust-lexical-write-float+power-of-two-devel.sha256sum] = "c442d97dffd9ef12d55411d1141cd50ef924f1b4de63bc81a70ffb172b68accc"

URI_x86_64_v2_rust-lexical-write-float+radix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-write-float+radix-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-write-float+radix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-write-float+radix-devel}"
SRC_URI[x86_64_v2_rust-lexical-write-float+radix-devel.sha256sum] = "ab863f166889a271cea8d59faaef1457aba2d97b9909727688e541ef7aac87b4"

URI_x86_64_v2_rust-lexical-write-float+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-write-float+std-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-write-float+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-write-float+std-devel}"
SRC_URI[x86_64_v2_rust-lexical-write-float+std-devel.sha256sum] = "83b748e4b14beb4d8b09a9975eb4b0c948758b72562e9a6ed0003f5dea8437c3"

URI_x86_64_v2_rust-lexical-write-float-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-write-float-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-write-float-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-write-float-devel}"
SRC_URI[x86_64_v2_rust-lexical-write-float-devel.sha256sum] = "97d3920412b0b6acd2347f76d61cb5823f2be7e125038639c63f19fe1a992cc9"

URI_aarch64_rust-lexical-write-float+compact-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-write-float+compact-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-write-float+compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-write-float+compact-devel}"
SRC_URI[aarch64_rust-lexical-write-float+compact-devel.sha256sum] = "913f5c3b29a5c8e76ca8713dc22cb70386c205f63bf5bd8833ffb6628c13272c"

URI_aarch64_rust-lexical-write-float+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-write-float+default-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-write-float+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-write-float+default-devel}"
SRC_URI[aarch64_rust-lexical-write-float+default-devel.sha256sum] = "32ff764a8d7a7d80eae5a84a55ab3f9281b237c800870a5bd3e366ad57052b8e"

URI_aarch64_rust-lexical-write-float+f128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-write-float+f128-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-write-float+f128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-write-float+f128-devel}"
SRC_URI[aarch64_rust-lexical-write-float+f128-devel.sha256sum] = "dbac3e3d8de92d8bf25987854a46d9b080059987d0e0a8360bc36fd9feda588a"

URI_aarch64_rust-lexical-write-float+f16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-write-float+f16-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-write-float+f16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-write-float+f16-devel}"
SRC_URI[aarch64_rust-lexical-write-float+f16-devel.sha256sum] = "773b9226e8851e3339ef923afe9ec2468a9cd41fc78973ad0cf358d8cb4864c3"

URI_aarch64_rust-lexical-write-float+format-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-write-float+format-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-write-float+format-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-write-float+format-devel}"
SRC_URI[aarch64_rust-lexical-write-float+format-devel.sha256sum] = "b0a64ae2e7fd0710d5a082f0ec0bc0c8b6b7f755279d0fd7989e5fdd7a5aaa03"

URI_aarch64_rust-lexical-write-float+lint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-write-float+lint-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-write-float+lint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-write-float+lint-devel}"
SRC_URI[aarch64_rust-lexical-write-float+lint-devel.sha256sum] = "80f8843a175bc6e3463564b9a85f4f2d3984494369f4a73802d6f8743e2c4c2d"

URI_aarch64_rust-lexical-write-float+power-of-two-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-write-float+power-of-two-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-write-float+power-of-two-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-write-float+power-of-two-devel}"
SRC_URI[aarch64_rust-lexical-write-float+power-of-two-devel.sha256sum] = "62d8ba393d0330ba6f95b3dbbb62910a928289634a61f23431a6a966f53d971b"

URI_aarch64_rust-lexical-write-float+radix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-write-float+radix-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-write-float+radix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-write-float+radix-devel}"
SRC_URI[aarch64_rust-lexical-write-float+radix-devel.sha256sum] = "9ab08851fd2fb4c791e9080a766068aad5321c39d66ee12dd2686a39854c7e78"

URI_aarch64_rust-lexical-write-float+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-write-float+std-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-write-float+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-write-float+std-devel}"
SRC_URI[aarch64_rust-lexical-write-float+std-devel.sha256sum] = "21d8eaa05d4464a9499f6d1b5d4901b0bb7b0f8acba40fa1ae59d1f1c6f8b38b"

URI_aarch64_rust-lexical-write-float-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-write-float-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-write-float-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-write-float-devel}"
SRC_URI[aarch64_rust-lexical-write-float-devel.sha256sum] = "eaa8c0cff89be686201caeafb03978d43d29417e839514f9702592231e638e4d"

RDEPENDS:rust-lexical-write-float+compact-devel = " \
 cargo \
 rust-lexical-util+compact-devel \
 rust-lexical-write-float-devel \
 rust-lexical-write-integer+compact-devel \
 "
RDEPENDS:rust-lexical-write-float+default-devel = " \
 cargo \
 rust-lexical-write-float+std-devel \
 rust-lexical-write-float-devel \
 "
RDEPENDS:rust-lexical-write-float+f128-devel = " \
 cargo \
 rust-lexical-util+f128-devel \
 rust-lexical-write-float-devel \
 "
RDEPENDS:rust-lexical-write-float+f16-devel = " \
 cargo \
 rust-lexical-util+f16-devel \
 rust-lexical-write-float-devel \
 "
RDEPENDS:rust-lexical-write-float+format-devel = " \
 cargo \
 rust-lexical-util+format-devel \
 rust-lexical-write-float-devel \
 "
RDEPENDS:rust-lexical-write-float+lint-devel = " \
 cargo \
 rust-lexical-util+lint-devel \
 rust-lexical-write-float-devel \
 rust-lexical-write-integer+lint-devel \
 "
RDEPENDS:rust-lexical-write-float+power-of-two-devel = " \
 cargo \
 rust-lexical-util+power-of-two-devel \
 rust-lexical-write-float-devel \
 rust-lexical-write-integer+power-of-two-devel \
 "
RDEPENDS:rust-lexical-write-float+radix-devel = " \
 cargo \
 rust-lexical-util+radix-devel \
 rust-lexical-write-float+power-of-two-devel \
 rust-lexical-write-float-devel \
 rust-lexical-write-integer+radix-devel \
 "
RDEPENDS:rust-lexical-write-float+std-devel = " \
 cargo \
 rust-lexical-util+std-devel \
 rust-lexical-write-float-devel \
 rust-lexical-write-integer+std-devel \
 "
RDEPENDS:rust-lexical-write-float-devel = " \
 cargo \
 rust \
 rust-lexical-util+write-floats-devel \
 rust-lexical-util-devel \
 rust-lexical-write-integer-devel \
 "
