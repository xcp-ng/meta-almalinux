# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "weechat"
PV = "4.10.1"
PR = "2.el10_2"
PACKAGES = " \
 weechat \
 weechat-devel \
 weechat-php \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/w/weechat-4.10.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8d35d2babdec00d094e17e3d52b2a3703dd5fe250033f0b77a8fed8950ed07c1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/weechat-4.10.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_weechat;unpack=0"
SRC_URI[x86_64_v2_weechat.sha256sum] = "ee378f82e145f36e111b5e8f6792682807238147d965e9a8a09c4394b1d9af0e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/weechat-devel-4.10.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_weechat-devel;unpack=0"
SRC_URI[x86_64_v2_weechat-devel.sha256sum] = "5cf53015590f68a1f82412eb2da4d0da47985b6bc6f3284537f5575a8469fda2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/weechat-php-4.10.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_weechat-php;unpack=0"
SRC_URI[x86_64_v2_weechat-php.sha256sum] = "8981576f6a15fa0a5f0e139496a3ba0ce8579f5d8df9c66cf26bdf26598ece91"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/weechat-4.10.1-2.el10_2.aarch64.rpm;name=aarch64_weechat;unpack=0"
SRC_URI[aarch64_weechat.sha256sum] = "6a2d310c932d6cad672084280878371b51cd226a51d167d64fc995497a7c37ef"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/weechat-devel-4.10.1-2.el10_2.aarch64.rpm;name=aarch64_weechat-devel;unpack=0"
SRC_URI[aarch64_weechat-devel.sha256sum] = "c86f02f90a0d671a7be264584e2c731356eaa91d5dea249cf4a49f029129b8bc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/weechat-php-4.10.1-2.el10_2.aarch64.rpm;name=aarch64_weechat-php;unpack=0"
SRC_URI[aarch64_weechat-php.sha256sum] = "e9b9d194fb30e8420af0043a050fafc587e928c1dcfafa0fd2d49c6e70955d73"

RDEPENDS:weechat = " \
 cjson \
 enchant2 \
 glibc \
 gnutls \
 guile30 \
 hicolor-icon-theme \
 libgcc \
 libgcrypt \
 libzstd \
 lua-libs \
 ncurses-libs \
 perl-libs \
 python3-libs \
 ruby-libs \
 tcl \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:weechat-devel = " \
 pkgconf-pkg-config \
 weechat \
 "
RDEPENDS:weechat-php = " \
 glibc \
 php8.4-embedded \
 weechat \
 "
