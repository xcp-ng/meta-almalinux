# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iptables"
PV = "1.8.11"
PR = "9.el10_0"
PACKAGES = " \
 iptables-devel \
 iptables-libs \
 iptables-nft \
 iptables-nft-services \
 iptables-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/iptables-1.8.11-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0c26c5182661dc23ae15a8245a470207d38707e7374a729e9c3b7438dac2b54"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - iptables-nft: (kernel-64k-debug-modules-extra if kernel-64k-debug-core)
# - iptables-nft: (kernel-64k-modules-extra if kernel-64k-core)
# - iptables-nft: (kernel-rt-64k-debug-modules-extra if kernel-rt-64k-debug-core)
# - iptables-nft: (kernel-rt-64k-modules-extra if kernel-rt-64k-core)
# - iptables-nft: (kernel-rt-debug-modules-extra if kernel-rt-debug-core)
# - iptables-nft: (kernel-rt-modules-extra if kernel-rt-core)

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - iptables-nft: (kernel-rt-64k-debug-modules-extra if kernel-rt-64k-debug-core)
# - iptables-nft: (kernel-rt-64k-modules-extra if kernel-rt-64k-core)
# - iptables-nft: (kernel-rt-debug-modules-extra if kernel-rt-debug-core)
# - iptables-nft: (kernel-rt-modules-extra if kernel-rt-core)

URI_x86_64_v2_iptables-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/iptables-devel-1.8.11-9.el10_0.x86_64_v2.rpm;name=x86_64_v2_iptables-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iptables-devel}"
SRC_URI[x86_64_v2_iptables-devel.sha256sum] = "efd3fe827cd22e3ebed19264e883e132fa1c5518aa89c9a4950c71f8fb011477"

URI_x86_64_v2_iptables-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iptables-libs-1.8.11-9.el10_0.x86_64_v2.rpm;name=x86_64_v2_iptables-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iptables-libs}"
SRC_URI[x86_64_v2_iptables-libs.sha256sum] = "4b9e8ac45495cdb384ef91af039831c0ad9cf697bc0c5f9c54f7b9c7666c5d43"

URI_x86_64_v2_iptables-nft = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/iptables-nft-1.8.11-9.el10_0.x86_64_v2.rpm;name=x86_64_v2_iptables-nft;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iptables-nft}"
SRC_URI[x86_64_v2_iptables-nft.sha256sum] = "cf61b58d9834df1eaa747a75ac049a91c209b5fdef71b57710b775a20c8304b9"

URI_x86_64_v2_iptables-nft-services = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/iptables-nft-services-1.8.11-9.el10_0.noarch.rpm;name=x86_64_v2_iptables-nft-services;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iptables-nft-services}"
SRC_URI[x86_64_v2_iptables-nft-services.sha256sum] = "62aeae4ca5c5f61344e36f87c095abf28ca3a08c9d5ab4e4e9ea09c8739b4558"

URI_x86_64_v2_iptables-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/iptables-utils-1.8.11-9.el10_0.x86_64_v2.rpm;name=x86_64_v2_iptables-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iptables-utils}"
SRC_URI[x86_64_v2_iptables-utils.sha256sum] = "283a69a6135a8cc7f7222013d97c8616943bda127767a2d895ba31e95e643c7e"

URI_aarch64_iptables-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/iptables-devel-1.8.11-9.el10_0.aarch64.rpm;name=aarch64_iptables-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_iptables-devel}"
SRC_URI[aarch64_iptables-devel.sha256sum] = "c5fbc4db2c95a6282de2e010985f3896d128dbd290d63fa866d4afd3fb0ec2de"

URI_aarch64_iptables-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iptables-libs-1.8.11-9.el10_0.aarch64.rpm;name=aarch64_iptables-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_iptables-libs}"
SRC_URI[aarch64_iptables-libs.sha256sum] = "cccdc363a455f4fc3582bbe7c52755d412033763cb18ce8bc5b53a22e2603a3c"

URI_aarch64_iptables-nft = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/iptables-nft-1.8.11-9.el10_0.aarch64.rpm;name=aarch64_iptables-nft;unpack=0"
SRC_URI:append = " ${URI_aarch64_iptables-nft}"
SRC_URI[aarch64_iptables-nft.sha256sum] = "7603321728c2dade098d45a3e52bbbf5ac40315f88c4396e9fd23f7418f3f6a5"

URI_aarch64_iptables-nft-services = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/iptables-nft-services-1.8.11-9.el10_0.noarch.rpm;name=aarch64_iptables-nft-services;unpack=0"
SRC_URI:append = " ${URI_aarch64_iptables-nft-services}"
SRC_URI[aarch64_iptables-nft-services.sha256sum] = "62aeae4ca5c5f61344e36f87c095abf28ca3a08c9d5ab4e4e9ea09c8739b4558"

URI_aarch64_iptables-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/iptables-utils-1.8.11-9.el10_0.aarch64.rpm;name=aarch64_iptables-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_iptables-utils}"
SRC_URI[aarch64_iptables-utils.sha256sum] = "1c44db77e8d61b97bf0b4800fa4276045a7df7b8e4ab803ad75308f101b3ff1d"

RDEPENDS:iptables-devel = " \
 iptables-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:iptables-libs = " \
 glibc \
 libnetfilter_conntrack \
 "
RDEPENDS:iptables-nft:x86_64_v2 = " \
 alternatives \
 bash \
 glibc \
 iptables-libs \
 kernel-debug-modules-extra \
 kernel-modules-extra \
 libmnl \
 libnftnl \
 virtual//usr/bin/readlink \
"
RDEPENDS:iptables-nft:aarch64 = " \
 alternatives \
 bash \
 glibc \
 iptables-libs \
 kernel-64k-debug-modules-extra \
 kernel-64k-modules-extra \
 kernel-debug-modules-extra \
 kernel-modules-extra \
 libmnl \
 libnftnl \
 virtual//usr/bin/readlink \
"
RDEPENDS:iptables-nft-services = " \
 bash \
 iptables-nft \
 "
RDEPENDS:iptables-utils = " \
 bash \
 glibc \
 iptables-nft \
 libnfnetlink \
 libpcap \
 "
