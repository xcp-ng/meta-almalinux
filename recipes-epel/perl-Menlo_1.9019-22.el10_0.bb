# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Menlo"
PV = "1.9019"
PR = "22.el10_0"
PACKAGES = " \
 perl-Menlo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Menlo-1.9019-22.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a24a7d55e8b3a9a1d0dee6d58445c84c9844f15f6dddcdcb58e9a6bfdf3ae83f"

URI_x86_64_v2_perl-Menlo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Menlo-1.9019-22.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Menlo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Menlo}"
SRC_URI[x86_64_v2_perl-Menlo.sha256sum] = "057c11ce5c8427cd5a18d5193c3666a36135998a321d63360f758b31a9ca8264"

URI_aarch64_perl-Menlo = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Menlo-1.9019-22.el10_0.noarch.rpm;name=aarch64_perl-Menlo;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Menlo}"
SRC_URI[aarch64_perl-Menlo.sha256sum] = "ad27bfe5e94fd90ada6e2e3a2e2b0c940335dd6f92caf561c0a6b7a6e54c98e7"

RDEPENDS:perl-Menlo = " \
 git \
 perl-CPAN-Common-Index \
 perl-CPAN-Meta \
 perl-CPAN-Meta-Requirements \
 perl-CPAN-Meta-YAML \
 perl-Carp \
 perl-Class-Tiny \
 perl-Exporter \
 perl-ExtUtils-Config \
 perl-ExtUtils-Helpers \
 perl-ExtUtils-Install \
 perl-ExtUtils-InstallPaths \
 perl-File-Basename \
 perl-File-Find \
 perl-File-Path \
 perl-File-pushd \
 perl-Getopt-Long \
 perl-HTTP-Tiny \
 perl-HTTP-Tinyish \
 perl-JSON-PP \
 perl-PathTools \
 perl-String-ShellQuote \
 perl-Test-Harness \
 perl-Time-Local \
 perl-URI \
 perl-constant \
 perl-libs \
 perl-parent \
 perl-podlators \
 "
