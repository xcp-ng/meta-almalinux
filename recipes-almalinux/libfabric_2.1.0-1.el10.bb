# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libfabric"
PV = "2.1.0"
PR = "1.el10"
PACKAGES = " \
 libfabric \
 libfabric-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libfabric-2.1.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5fa60ff0421e23875569093c7f9250b93e3a1ed1e4563e0558e9dee02f7f7792"

URI_x86_64_v2_libfabric = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libfabric-2.1.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libfabric;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfabric}"
SRC_URI[x86_64_v2_libfabric.sha256sum] = "4c85b984c20872a86bc3e727997726d3b77bf0f285ee128c14a353cd2eb5bb89"

URI_x86_64_v2_libfabric-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libfabric-devel-2.1.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libfabric-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfabric-devel}"
SRC_URI[x86_64_v2_libfabric-devel.sha256sum] = "fa930fdfb1dcab2d5eeb06b1ace78fd1137cd99bce40427471cf87e034da39a5"

URI_aarch64_libfabric = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libfabric-2.1.0-1.el10.aarch64.rpm;name=aarch64_libfabric;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfabric}"
SRC_URI[aarch64_libfabric.sha256sum] = "e68a0fea43d26a7619de88d328734da39853ed2c0f62eaf44934d82e4db9b5d9"

URI_aarch64_libfabric-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libfabric-devel-2.1.0-1.el10.aarch64.rpm;name=aarch64_libfabric-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfabric-devel}"
SRC_URI[aarch64_libfabric-devel.sha256sum] = "b8748843fe03e860a9834e9c75f64d212a746f20dd2922f67d4c4f09621427e5"

RDEPENDS:libfabric:x86_64_v2 = " \
 glibc \
 libibverbs \
 libnl3 \
 librdmacm \
"
RDEPENDS:libfabric:aarch64 = " \
 glibc \
 libatomic \
 libibverbs \
 libnl3 \
 librdmacm \
"
RDEPENDS:libfabric-devel = " \
 libfabric \
 pkgconf-pkg-config \
 "
