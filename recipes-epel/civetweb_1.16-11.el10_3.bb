# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "civetweb"
PV = "1.16"
PR = "11.el10_3"
PACKAGES = " \
 civetweb \
 civetweb-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/civetweb-1.16-11.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ae61db254ff8c8e321da2980e8e68668b882c605ff59cfc6dedbc25c9f1078d"

URI_x86_64_v2_civetweb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/civetweb-1.16-11.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_civetweb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_civetweb}"
SRC_URI[x86_64_v2_civetweb.sha256sum] = "aed67160264773b452d23cf38b319c0c9a46dedcd045bd4244b1c8dac88d49f5"

URI_x86_64_v2_civetweb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/civetweb-devel-1.16-11.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_civetweb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_civetweb-devel}"
SRC_URI[x86_64_v2_civetweb-devel.sha256sum] = "9c7283525a81e781cb8b75a24fb27caf9d5399e05f6e0140a2c1f1d3810cbadd"

URI_aarch64_civetweb = "${EPEL_MIRROR}/aarch64/Packages/c/civetweb-1.16-11.el10_3.aarch64.rpm;name=aarch64_civetweb;unpack=0"
SRC_URI:append = " ${URI_aarch64_civetweb}"
SRC_URI[aarch64_civetweb.sha256sum] = "c6285915519b16ca54282383fde42980203b08190a04df79d9d63de8d6f7e70f"

URI_aarch64_civetweb-devel = "${EPEL_MIRROR}/aarch64/Packages/c/civetweb-devel-1.16-11.el10_3.aarch64.rpm;name=aarch64_civetweb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_civetweb-devel}"
SRC_URI[aarch64_civetweb-devel.sha256sum] = "f3c1440222332003a0810a626ddc903ab222ec7ecb44dcce673ad84482eb24e0"

RDEPENDS:civetweb = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:civetweb-devel = " \
 civetweb \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
