# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-activities"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 plasma-activities \
 plasma-activities-devel \
 plasma-activities-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma-activities-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ddee3cbe13a0a02210665d2560fc72f5c772d1e8c263c828333528833c14eeba"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-activities-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-activities;unpack=0"
SRC_URI[x86_64_v2_plasma-activities.sha256sum] = "5b52818e1d8ad725d935531aaeb8122bdd719bf4314f5b14abc569219efc8e63"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-activities-devel-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-activities-devel;unpack=0"
SRC_URI[x86_64_v2_plasma-activities-devel.sha256sum] = "a1c8ff805b4f9e7e532649111e098a10c7f06195a292f1cf483dd9dfd66900d4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-activities-doc-6.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-activities-doc;unpack=0"
SRC_URI[x86_64_v2_plasma-activities-doc.sha256sum] = "5ab31e9a57fd0d786c755c60b83078fcd7697636e9c8190b1fac493326bf92ba"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-activities-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-activities;unpack=0"
SRC_URI[aarch64_plasma-activities.sha256sum] = "0c4258004d7b3e455f8129bd69642a8c916d27ee05e503a2ec1b14ed4a59b193"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-activities-devel-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-activities-devel;unpack=0"
SRC_URI[aarch64_plasma-activities-devel.sha256sum] = "fcb2457fd8d5cb9a9df713e42d4ce290efb46dc9b39ed15dcd3b43c9c7e2e695"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-activities-doc-6.7.5-1.el10_3.noarch.rpm;name=aarch64_plasma-activities-doc;unpack=0"
SRC_URI[aarch64_plasma-activities-doc.sha256sum] = "7a049acc298ebea01f19c76a913870300aba62bdc7a562ad0d6f4e6431820c2e"

RDEPENDS:plasma-activities = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:plasma-activities-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 plasma-activities \
 qt6-qtbase-devel \
 "
RDEPENDS:plasma-activities-doc = " \
 "
