# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "boom-boot"
PV = "1.6.8"
PR = "2.el10"
PACKAGES = " \
 boom-boot \
 boom-boot-conf \
 python3-boom \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/boom-boot-1.6.8-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "782f4016b97f3119bfe118a70936f4fea377c356311d0b2ad90b4972e20fd4e8"

URI_x86_64_v2_boom-boot = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boom-boot-1.6.8-2.el10.noarch.rpm;name=x86_64_v2_boom-boot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boom-boot}"
SRC_URI[x86_64_v2_boom-boot.sha256sum] = "20ae6cc24222a434f50e7cb1434ac80454894c18f9bd75b14a39f8526b001c2e"

URI_x86_64_v2_boom-boot-conf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boom-boot-conf-1.6.8-2.el10.noarch.rpm;name=x86_64_v2_boom-boot-conf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boom-boot-conf}"
SRC_URI[x86_64_v2_boom-boot-conf.sha256sum] = "3b7db309c442ac4a2e09ef67ab718691fa6ca0d4352ff506921c343e27015919"

URI_x86_64_v2_python3-boom = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-boom-1.6.8-2.el10.noarch.rpm;name=x86_64_v2_python3-boom;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-boom}"
SRC_URI[x86_64_v2_python3-boom.sha256sum] = "0146e11bbd8469e5875d160bf1f65e127ff1b6d9d9d34703324918913b4034be"

URI_aarch64_boom-boot = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boom-boot-1.6.8-2.el10.noarch.rpm;name=aarch64_boom-boot;unpack=0"
SRC_URI:append = " ${URI_aarch64_boom-boot}"
SRC_URI[aarch64_boom-boot.sha256sum] = "20ae6cc24222a434f50e7cb1434ac80454894c18f9bd75b14a39f8526b001c2e"

URI_aarch64_boom-boot-conf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boom-boot-conf-1.6.8-2.el10.noarch.rpm;name=aarch64_boom-boot-conf;unpack=0"
SRC_URI:append = " ${URI_aarch64_boom-boot-conf}"
SRC_URI[aarch64_boom-boot-conf.sha256sum] = "3b7db309c442ac4a2e09ef67ab718691fa6ca0d4352ff506921c343e27015919"

URI_aarch64_python3-boom = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-boom-1.6.8-2.el10.noarch.rpm;name=aarch64_python3-boom;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-boom}"
SRC_URI[aarch64_python3-boom.sha256sum] = "0146e11bbd8469e5875d160bf1f65e127ff1b6d9d9d34703324918913b4034be"

RDEPENDS:boom-boot = " \
 boom-boot-conf \
 python3 \
 python3-boom \
 python3-dbus \
 systemd \
 "
RDEPENDS:boom-boot-conf = " \
 "
RDEPENDS:python3-boom = " \
 python3 \
 python3-dbus \
 "
