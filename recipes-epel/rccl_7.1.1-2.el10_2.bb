# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rccl"
PV = "7.1.1"
PR = "2.el10_2"
PACKAGES:x86_64_v2 = " \
 rccl \
 rccl-data \
 rccl-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rccl-7.1.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86cb7b2034136416852bd7236a1202ac9f45634727894fd11b6f95c58c247e28"

URI_x86_64_v2_rccl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rccl-7.1.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rccl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rccl}"
SRC_URI[x86_64_v2_rccl.sha256sum] = "3dd38c3c72fbdeb3df9267d9fc78aa35864fa1816d0cdc1791411e65b004258e"

URI_x86_64_v2_rccl-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rccl-data-7.1.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rccl-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rccl-data}"
SRC_URI[x86_64_v2_rccl-data.sha256sum] = "05ca7310f33abeb7140f823a737928b3be2481f30c89b8b6a45896820dadb883"

URI_x86_64_v2_rccl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rccl-devel-7.1.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rccl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rccl-devel}"
SRC_URI[x86_64_v2_rccl-devel.sha256sum] = "063fcc87b11390f3edda2a24824f47b6957fde2b7f0dad088f396c8a06d26f87"

RDEPENDS:rccl = " \
 glibc \
 libgcc \
 libstdc++ \
 rccl-data \
 rocm-hip \
 rocm-smi \
 "
RDEPENDS:rccl-data = " \
 "
RDEPENDS:rccl-devel = " \
 cmake-filesystem \
 rccl \
 "
