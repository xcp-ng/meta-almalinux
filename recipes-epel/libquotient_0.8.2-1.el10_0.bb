# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libquotient"
PV = "0.8.2"
PR = "1.el10_0"
PACKAGES = " \
 libquotient-qt5 \
 libquotient-qt5-devel \
 libquotient-qt6 \
 libquotient-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libquotient-0.8.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1f5e8c6e596308ec30681a7a565da299873eb43046426e9f04f36199cad0c32"

URI_x86_64_v2_libquotient-qt5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libquotient-qt5-0.8.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libquotient-qt5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libquotient-qt5}"
SRC_URI[x86_64_v2_libquotient-qt5.sha256sum] = "a323bc8fdfc6fb387a8c537b0889ed98f083ada18eeb30f62bb3b20e844eb3f2"

URI_x86_64_v2_libquotient-qt5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libquotient-qt5-devel-0.8.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libquotient-qt5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libquotient-qt5-devel}"
SRC_URI[x86_64_v2_libquotient-qt5-devel.sha256sum] = "cf962b05529c9875ba5cfc925a5f4062ad9d2ecbc247c95f5b42abe1ec0c0f3a"

URI_x86_64_v2_libquotient-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libquotient-qt6-0.8.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libquotient-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libquotient-qt6}"
SRC_URI[x86_64_v2_libquotient-qt6.sha256sum] = "b298d9308e6525977402f2939a2b6affbb56a8b0108f648a610a65925d15a742"

URI_x86_64_v2_libquotient-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libquotient-qt6-devel-0.8.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libquotient-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libquotient-qt6-devel}"
SRC_URI[x86_64_v2_libquotient-qt6-devel.sha256sum] = "42c4c533929f6a6ffd89fec4dfd4bfd48f68934175385a27fcdf2e1cb8bd86e9"

URI_aarch64_libquotient-qt5 = "${EPEL_MIRROR}/aarch64/Packages/l/libquotient-qt5-0.8.2-1.el10_0.aarch64.rpm;name=aarch64_libquotient-qt5;unpack=0"
SRC_URI:append = " ${URI_aarch64_libquotient-qt5}"
SRC_URI[aarch64_libquotient-qt5.sha256sum] = "9d15b927316ecb84dcadae08a585b8c704c147d7153eab67d4657383ba537bf2"

URI_aarch64_libquotient-qt5-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libquotient-qt5-devel-0.8.2-1.el10_0.aarch64.rpm;name=aarch64_libquotient-qt5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libquotient-qt5-devel}"
SRC_URI[aarch64_libquotient-qt5-devel.sha256sum] = "8f50625faef83ad34c46ece469b572b4084382090a582483a6e630a42ca8d73c"

URI_aarch64_libquotient-qt6 = "${EPEL_MIRROR}/aarch64/Packages/l/libquotient-qt6-0.8.2-1.el10_0.aarch64.rpm;name=aarch64_libquotient-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_libquotient-qt6}"
SRC_URI[aarch64_libquotient-qt6.sha256sum] = "a0e53e07db3cf083d7cecc11b43181e35e323528fee1f76e370140ae50602896"

URI_aarch64_libquotient-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libquotient-qt6-devel-0.8.2-1.el10_0.aarch64.rpm;name=aarch64_libquotient-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libquotient-qt6-devel}"
SRC_URI[aarch64_libquotient-qt6-devel.sha256sum] = "95345bc0cf5921b4b255fc2aa9a31e3e5aa9c2c235ffd177b853b4c6edf9ee64"

RDEPENDS:libquotient-qt5 = " \
 glibc \
 libolm \
 libstdc++ \
 openssl-libs \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtmultimedia \
 qtkeychain-qt5 \
 "
RDEPENDS:libquotient-qt5-devel = " \
 cmake-filesystem \
 libolm-devel \
 libquotient-qt5 \
 openssl-devel \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qtkeychain-qt5-devel \
 "
RDEPENDS:libquotient-qt6 = " \
 glibc \
 libolm \
 libstdc++ \
 openssl-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
RDEPENDS:libquotient-qt6-devel = " \
 cmake-filesystem \
 libolm-devel \
 libquotient-qt6 \
 openssl-devel \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qtkeychain-qt6-devel \
 "
