# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dlv-list"
PV = "0.5.2"
PR = "2.el10_1"
PACKAGES = " \
 rust-dlv-list+default-devel \
 rust-dlv-list+serde-devel \
 rust-dlv-list+std-devel \
 rust-dlv-list-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dlv-list-0.5.2-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b3cb9a77decb18fccf86e0fc6d61139d6fe9ca22e13156836dd48866f6445309"

URI_x86_64_v2_rust-dlv-list+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dlv-list+default-devel-0.5.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dlv-list+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dlv-list+default-devel}"
SRC_URI[x86_64_v2_rust-dlv-list+default-devel.sha256sum] = "00a47aa5468452c9f469a708db8ab61d07303812a71c400f2ab1998957480658"

URI_x86_64_v2_rust-dlv-list+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dlv-list+serde-devel-0.5.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dlv-list+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dlv-list+serde-devel}"
SRC_URI[x86_64_v2_rust-dlv-list+serde-devel.sha256sum] = "252d8474189afa5387f3f56479f63762ea58cab7b179b65db458d9c60003fa00"

URI_x86_64_v2_rust-dlv-list+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dlv-list+std-devel-0.5.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dlv-list+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dlv-list+std-devel}"
SRC_URI[x86_64_v2_rust-dlv-list+std-devel.sha256sum] = "d5283f36d4083183029d384313321ffe2850b255f0348f66997f9df53de35989"

URI_x86_64_v2_rust-dlv-list-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dlv-list-devel-0.5.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dlv-list-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dlv-list-devel}"
SRC_URI[x86_64_v2_rust-dlv-list-devel.sha256sum] = "a6a7ebc195a47465f81e042b8f10aab9ac9a80810a9c5a746b7bb5cd141c164e"

URI_aarch64_rust-dlv-list+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dlv-list+default-devel-0.5.2-2.el10_1.noarch.rpm;name=aarch64_rust-dlv-list+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dlv-list+default-devel}"
SRC_URI[aarch64_rust-dlv-list+default-devel.sha256sum] = "85831435a2416d0a5cc57a6b3454f6eaf3749b412a0774d913dca704c23dfd0f"

URI_aarch64_rust-dlv-list+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dlv-list+serde-devel-0.5.2-2.el10_1.noarch.rpm;name=aarch64_rust-dlv-list+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dlv-list+serde-devel}"
SRC_URI[aarch64_rust-dlv-list+serde-devel.sha256sum] = "f0e663c008f4688b9ebd5736c2fac95eccb5251d55bcdf7f4808932d966e5fad"

URI_aarch64_rust-dlv-list+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dlv-list+std-devel-0.5.2-2.el10_1.noarch.rpm;name=aarch64_rust-dlv-list+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dlv-list+std-devel}"
SRC_URI[aarch64_rust-dlv-list+std-devel.sha256sum] = "944f30082ed9b6e673fdbe449951472f387b33277c2ff3e32ab9fdc8639414c4"

URI_aarch64_rust-dlv-list-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dlv-list-devel-0.5.2-2.el10_1.noarch.rpm;name=aarch64_rust-dlv-list-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dlv-list-devel}"
SRC_URI[aarch64_rust-dlv-list-devel.sha256sum] = "f4a0872ad62af61773124f661ba579621dcb2945d31bf6942b38901d8b21a54c"

RDEPENDS:rust-dlv-list+default-devel = " \
 cargo \
 rust-dlv-list+std-devel \
 rust-dlv-list-devel \
 "
RDEPENDS:rust-dlv-list+serde-devel = " \
 cargo \
 rust-dlv-list-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-dlv-list+std-devel = " \
 cargo \
 rust-dlv-list-devel \
 "
RDEPENDS:rust-dlv-list-devel = " \
 cargo \
 rust-const-random+default-devel \
 "
