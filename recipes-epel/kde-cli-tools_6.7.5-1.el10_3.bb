# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-cli-tools"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 kde-cli-tools \
 kdesu \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kde-cli-tools-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b0df6b288a6d53761aeb5fe50e4f2dbe7996bfeaf7d6345949204f787f63b8da"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-cli-tools-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-cli-tools;unpack=0"
SRC_URI[x86_64_v2_kde-cli-tools.sha256sum] = "a01ddb4d97b427f19ac2cd8e3d799b3cbf9f98f175b43097b41ffd1de8f149e2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdesu-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdesu;unpack=0"
SRC_URI[x86_64_v2_kdesu.sha256sum] = "34a4fb68d443b12c7ef79d0bbe3081e75979c1e5fb2107dedda66845f6335460"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kde-cli-tools-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_kde-cli-tools;unpack=0"
SRC_URI[aarch64_kde-cli-tools.sha256sum] = "93273480212d532166fa752fcd9663f11e99aab802d7fc27baa658c56f739c56"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kdesu-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_kdesu;unpack=0"
SRC_URI[aarch64_kdesu.sha256sum] = "069b8a1fb208c8003c533e557f88ee0fbab199fbb57f9d105306c08116291ece"

RDEPENDS:kde-cli-tools = " \
 bash \
 glibc \
 kdesu \
 kf6-kcmutils \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kparts \
 kf6-kservice \
 kf6-kwindowsystem \
 libkworkspace6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
RDEPENDS:kdesu = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdesu \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
