# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-networkmanager-qt"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-networkmanager-qt \
 kf6-networkmanager-qt-devel \
 kf6-networkmanager-qt-doc \
 kf6-networkmanager-qt-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-networkmanager-qt-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19317807a03a1f1bfb382e8454af1747137c15b932efd30484b1f4daa049c237"

URI_x86_64_v2_kf6-networkmanager-qt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-networkmanager-qt-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-networkmanager-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-networkmanager-qt}"
SRC_URI[x86_64_v2_kf6-networkmanager-qt.sha256sum] = "d8fb3d83d1574ee9d493ce19ff40768de3b88c7a79b1b4618b4e71d66a7f299e"

URI_x86_64_v2_kf6-networkmanager-qt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-networkmanager-qt-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-networkmanager-qt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-networkmanager-qt-devel}"
SRC_URI[x86_64_v2_kf6-networkmanager-qt-devel.sha256sum] = "9595bf541af56560d66a3738eea8f1fc6639b4050620ed0d0a9401b6b5352de4"

URI_x86_64_v2_kf6-networkmanager-qt-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-networkmanager-qt-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-networkmanager-qt-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-networkmanager-qt-doc}"
SRC_URI[x86_64_v2_kf6-networkmanager-qt-doc.sha256sum] = "5d679a5c6403891a420e38b94cc92415cae5d2596ca964da7d906c52da8f57ec"

URI_x86_64_v2_kf6-networkmanager-qt-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-networkmanager-qt-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-networkmanager-qt-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-networkmanager-qt-html}"
SRC_URI[x86_64_v2_kf6-networkmanager-qt-html.sha256sum] = "0b41d6c9056e13ae9d8f0c8add3fb487e4caa7cf7ff7d7c18628d4c31242aa00"

URI_aarch64_kf6-networkmanager-qt = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-networkmanager-qt-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-networkmanager-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-networkmanager-qt}"
SRC_URI[aarch64_kf6-networkmanager-qt.sha256sum] = "757c09b12bd2bb6cb6cfd5d02224048b9535ad2c8b22f6e4ce11bf5af38fb828"

URI_aarch64_kf6-networkmanager-qt-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-networkmanager-qt-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-networkmanager-qt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-networkmanager-qt-devel}"
SRC_URI[aarch64_kf6-networkmanager-qt-devel.sha256sum] = "0f7b15c049d15de4755b17766dfdc167eb3986a217d6f492c5cf0297095e52dc"

URI_aarch64_kf6-networkmanager-qt-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-networkmanager-qt-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-networkmanager-qt-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-networkmanager-qt-doc}"
SRC_URI[aarch64_kf6-networkmanager-qt-doc.sha256sum] = "234cc530c3548f5221894f9dec6c1944379177a441f45b1014ff9fd41ca42e97"

URI_aarch64_kf6-networkmanager-qt-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-networkmanager-qt-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-networkmanager-qt-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-networkmanager-qt-html}"
SRC_URI[aarch64_kf6-networkmanager-qt-html.sha256sum] = "c1e6ee16e6d0709000b193d4f3fce7a8f3e491b9290c2854eebcbb65bc384d7e"

RDEPENDS:kf6-networkmanager-qt = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-networkmanager-qt-devel = " \
 NetworkManager-libnm-devel \
 cmake-filesystem \
 kf6-networkmanager-qt \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-networkmanager-qt-doc = " \
 "
RDEPENDS:kf6-networkmanager-qt-html = " \
 "
