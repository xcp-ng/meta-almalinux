# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rsyslog"
PV = "8.2412.0"
PR = "1.el10"
PACKAGES = " \
 rsyslog \
 rsyslog-crypto \
 rsyslog-doc \
 rsyslog-elasticsearch \
 rsyslog-gnutls \
 rsyslog-gssapi \
 rsyslog-kafka \
 rsyslog-mmaudit \
 rsyslog-mmfields \
 rsyslog-mmjsonparse \
 rsyslog-mmkubernetes \
 rsyslog-mmnormalize \
 rsyslog-mmsnmptrapd \
 rsyslog-mysql \
 rsyslog-omamqp1 \
 rsyslog-openssl \
 rsyslog-pgsql \
 rsyslog-relp \
 rsyslog-snmp \
 rsyslog-udpspoof \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rsyslog-8.2412.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c2bcb6ce82b178c5ba5633f3957863c130c444a3e4d2cb915070b4bd5d460c1"

URI_x86_64_v2_rsyslog = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-8.2412.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog}"
SRC_URI[x86_64_v2_rsyslog.sha256sum] = "aa0fa56452f08034a56f92d428f32331cb46331342a70f22cf1c45ba5931b9f7"
RPROVIDES:rsyslog:x86_64_v2 = "virtual/syslog"

URI_x86_64_v2_rsyslog-crypto = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-crypto-8.2412.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-crypto;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-crypto}"
SRC_URI[x86_64_v2_rsyslog-crypto.sha256sum] = "6cc699800a0d8d0bc6f940bb59a77ed66493343510c7b044d2fc5a227c4f073d"

URI_x86_64_v2_rsyslog-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-doc-8.2412.0-1.el10.noarch.rpm;name=x86_64_v2_rsyslog-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-doc}"
SRC_URI[x86_64_v2_rsyslog-doc.sha256sum] = "612f89202cf3354f8c2b2adfeafeb7b7bf6021f49d42cf7af4c13658f05dfa0f"

URI_x86_64_v2_rsyslog-elasticsearch = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-elasticsearch-8.2412.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-elasticsearch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-elasticsearch}"
SRC_URI[x86_64_v2_rsyslog-elasticsearch.sha256sum] = "b0777791392156d2eee596d482b0dc0cd4669e0023eba5d1b299e9a2856db901"

URI_x86_64_v2_rsyslog-gnutls = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-gnutls-8.2412.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-gnutls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-gnutls}"
SRC_URI[x86_64_v2_rsyslog-gnutls.sha256sum] = "c7d8092fa496ced4267c64a56e26a4face6c8c4d48197cc6e834c36c639b1462"

URI_x86_64_v2_rsyslog-gssapi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-gssapi-8.2412.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-gssapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-gssapi}"
SRC_URI[x86_64_v2_rsyslog-gssapi.sha256sum] = "c57beba4888955e298bde37b0f0afc336d53edefd66ac6459cc6ecc133b61a8c"

URI_x86_64_v2_rsyslog-kafka = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-kafka-8.2412.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-kafka;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-kafka}"
SRC_URI[x86_64_v2_rsyslog-kafka.sha256sum] = "c12c44459227bfcc4d4c558c133865a6aeee2c07fc0fefeba9e7d099d37092bd"

URI_x86_64_v2_rsyslog-mmaudit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmaudit-8.2412.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmaudit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-mmaudit}"
SRC_URI[x86_64_v2_rsyslog-mmaudit.sha256sum] = "c001bbaa70387818b309bd3492540f3462415e9ccd609b16218767d8e0453472"

URI_x86_64_v2_rsyslog-mmfields = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmfields-8.2412.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmfields;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-mmfields}"
SRC_URI[x86_64_v2_rsyslog-mmfields.sha256sum] = "9acdc0ce040844b7810216b4046a3f93e54cb207f1b61a880e557d3df89f5f11"

URI_x86_64_v2_rsyslog-mmjsonparse = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmjsonparse-8.2412.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmjsonparse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-mmjsonparse}"
SRC_URI[x86_64_v2_rsyslog-mmjsonparse.sha256sum] = "45b250a4035431092417392f89ca1ff01584e0400883ee45ae2a3d38b997ee90"

URI_x86_64_v2_rsyslog-mmkubernetes = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmkubernetes-8.2412.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmkubernetes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-mmkubernetes}"
SRC_URI[x86_64_v2_rsyslog-mmkubernetes.sha256sum] = "abef12692ea066a6ba9926a8ba1a573a7231fc4cdc4621a3d58b3308e6003bf7"

URI_x86_64_v2_rsyslog-mmnormalize = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmnormalize-8.2412.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmnormalize;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-mmnormalize}"
SRC_URI[x86_64_v2_rsyslog-mmnormalize.sha256sum] = "8454f09b1c1dc62d58507e3e961199967fb651ca7c9d8faa33e7ad2dd4d09790"

URI_x86_64_v2_rsyslog-mmsnmptrapd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmsnmptrapd-8.2412.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmsnmptrapd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-mmsnmptrapd}"
SRC_URI[x86_64_v2_rsyslog-mmsnmptrapd.sha256sum] = "af986e80341898bdf5e9dccb25c62a9006920b2c39d6eedda00f995d75015619"

URI_x86_64_v2_rsyslog-mysql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mysql-8.2412.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-mysql}"
SRC_URI[x86_64_v2_rsyslog-mysql.sha256sum] = "7a817923124f8400905474e357a0b90e0d7b60143172463901dcc7cee48f41ab"

URI_x86_64_v2_rsyslog-omamqp1 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-omamqp1-8.2412.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-omamqp1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-omamqp1}"
SRC_URI[x86_64_v2_rsyslog-omamqp1.sha256sum] = "ce8381a4c50c3b0def24e8a78bf240ea3237212729ed3a1d54c2bc103c3a141e"

URI_x86_64_v2_rsyslog-openssl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-openssl-8.2412.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-openssl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-openssl}"
SRC_URI[x86_64_v2_rsyslog-openssl.sha256sum] = "cb654362bd39b8af2a885a408589f2ed2a046bb884b258e738a49b69d506b3ea"

URI_x86_64_v2_rsyslog-pgsql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-pgsql-8.2412.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-pgsql}"
SRC_URI[x86_64_v2_rsyslog-pgsql.sha256sum] = "7e84c1e46a530e3383737e28c37f3d67afdfd754ec1ade58510c6a2bccc6b460"

URI_x86_64_v2_rsyslog-relp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-relp-8.2412.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-relp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-relp}"
SRC_URI[x86_64_v2_rsyslog-relp.sha256sum] = "4b913872e5643744c471b046ea56601d0a0ed6ad89b7a957e8d02c48759402c2"

URI_x86_64_v2_rsyslog-snmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-snmp-8.2412.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-snmp}"
SRC_URI[x86_64_v2_rsyslog-snmp.sha256sum] = "abd316e287fbfdd14e1ae9fc56839dd480e7eb5a48e2be5e3ad83cc2e866f87f"

URI_x86_64_v2_rsyslog-udpspoof = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-udpspoof-8.2412.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-udpspoof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-udpspoof}"
SRC_URI[x86_64_v2_rsyslog-udpspoof.sha256sum] = "a93f07e43abbe28fd75b61c56304033dd6cc6d4b9115517c8d6cda5cdb5015b7"

URI_aarch64_rsyslog = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-8.2412.0-1.el10.aarch64.rpm;name=aarch64_rsyslog;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog}"
SRC_URI[aarch64_rsyslog.sha256sum] = "4b254d64135ccb8c803fb7d3828bb17a7fe9f87977f970d6103ae0d97a554d1a"
RPROVIDES:rsyslog:aarch64 = "virtual/syslog"

URI_aarch64_rsyslog-crypto = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-crypto-8.2412.0-1.el10.aarch64.rpm;name=aarch64_rsyslog-crypto;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-crypto}"
SRC_URI[aarch64_rsyslog-crypto.sha256sum] = "87b7ba2a85ab4c4131ca3984fd306b4c79475b86c7136f521f771dd0e15f1914"

URI_aarch64_rsyslog-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-doc-8.2412.0-1.el10.noarch.rpm;name=aarch64_rsyslog-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-doc}"
SRC_URI[aarch64_rsyslog-doc.sha256sum] = "612f89202cf3354f8c2b2adfeafeb7b7bf6021f49d42cf7af4c13658f05dfa0f"

URI_aarch64_rsyslog-elasticsearch = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-elasticsearch-8.2412.0-1.el10.aarch64.rpm;name=aarch64_rsyslog-elasticsearch;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-elasticsearch}"
SRC_URI[aarch64_rsyslog-elasticsearch.sha256sum] = "24b9aebff4452eff648e584ab288e28bdf13a721a51441635703075e3c290ea7"

URI_aarch64_rsyslog-gnutls = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-gnutls-8.2412.0-1.el10.aarch64.rpm;name=aarch64_rsyslog-gnutls;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-gnutls}"
SRC_URI[aarch64_rsyslog-gnutls.sha256sum] = "b8586b83f0b4259f74a1bb75ce100c0d9a60bcf78a98f4e4c5aed0cfa12dc010"

URI_aarch64_rsyslog-gssapi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-gssapi-8.2412.0-1.el10.aarch64.rpm;name=aarch64_rsyslog-gssapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-gssapi}"
SRC_URI[aarch64_rsyslog-gssapi.sha256sum] = "02d00041f92358b8b3f81a73ab5d9a8d7e6bc1a4b03c264ffadd9b13a5fb460f"

URI_aarch64_rsyslog-kafka = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-kafka-8.2412.0-1.el10.aarch64.rpm;name=aarch64_rsyslog-kafka;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-kafka}"
SRC_URI[aarch64_rsyslog-kafka.sha256sum] = "b68b1336b649a8dbecb55b9106c175f8ca511dbf0863a1a516c1952ddea62d9a"

URI_aarch64_rsyslog-mmaudit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmaudit-8.2412.0-1.el10.aarch64.rpm;name=aarch64_rsyslog-mmaudit;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-mmaudit}"
SRC_URI[aarch64_rsyslog-mmaudit.sha256sum] = "cd01c97c81a8a88bf89ba8c654a88e823cc4071ab20292f5b07cfab34d0156c0"

URI_aarch64_rsyslog-mmfields = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmfields-8.2412.0-1.el10.aarch64.rpm;name=aarch64_rsyslog-mmfields;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-mmfields}"
SRC_URI[aarch64_rsyslog-mmfields.sha256sum] = "945e4a4ab3c9e53b4308bdd7a05f623295fe69d7b439b608f2a6f1baf12eaa0c"

URI_aarch64_rsyslog-mmjsonparse = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmjsonparse-8.2412.0-1.el10.aarch64.rpm;name=aarch64_rsyslog-mmjsonparse;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-mmjsonparse}"
SRC_URI[aarch64_rsyslog-mmjsonparse.sha256sum] = "2e89f7e49b3cdf767ed7da3f567d51cc0d4b78f622b6af522bff05cc6954e2b4"

URI_aarch64_rsyslog-mmkubernetes = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmkubernetes-8.2412.0-1.el10.aarch64.rpm;name=aarch64_rsyslog-mmkubernetes;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-mmkubernetes}"
SRC_URI[aarch64_rsyslog-mmkubernetes.sha256sum] = "68e73db1f2c5466e6c5ce08b779fb791cc8f935f5837a2ad14dbd5daece001af"

URI_aarch64_rsyslog-mmnormalize = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmnormalize-8.2412.0-1.el10.aarch64.rpm;name=aarch64_rsyslog-mmnormalize;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-mmnormalize}"
SRC_URI[aarch64_rsyslog-mmnormalize.sha256sum] = "3741283a7f13395b5eab5fdb2ef37f1cc0667df9ab1a2bc0d441d67ef4dafe51"

URI_aarch64_rsyslog-mmsnmptrapd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmsnmptrapd-8.2412.0-1.el10.aarch64.rpm;name=aarch64_rsyslog-mmsnmptrapd;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-mmsnmptrapd}"
SRC_URI[aarch64_rsyslog-mmsnmptrapd.sha256sum] = "eb70938d438376ee81ef6c0bed1e07c2279476a77f6734affe41481762c779a9"

URI_aarch64_rsyslog-mysql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mysql-8.2412.0-1.el10.aarch64.rpm;name=aarch64_rsyslog-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-mysql}"
SRC_URI[aarch64_rsyslog-mysql.sha256sum] = "5ca8921e9ee11cb2c0c7d3ded87c56e83674f72d3d87b7cdfbe9e50ee60c50f5"

URI_aarch64_rsyslog-omamqp1 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-omamqp1-8.2412.0-1.el10.aarch64.rpm;name=aarch64_rsyslog-omamqp1;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-omamqp1}"
SRC_URI[aarch64_rsyslog-omamqp1.sha256sum] = "c70bda6335b3b89a7843780be329ffa6ce11f5fc3f9ae7fd46968d1f9ffccfe4"

URI_aarch64_rsyslog-openssl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-openssl-8.2412.0-1.el10.aarch64.rpm;name=aarch64_rsyslog-openssl;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-openssl}"
SRC_URI[aarch64_rsyslog-openssl.sha256sum] = "4a8d970c87d87cc9ca64aa3f02e46abbb6b06ff52923f6ef554f99a364ba517e"

URI_aarch64_rsyslog-pgsql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-pgsql-8.2412.0-1.el10.aarch64.rpm;name=aarch64_rsyslog-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-pgsql}"
SRC_URI[aarch64_rsyslog-pgsql.sha256sum] = "8193c529d68e7bf5ec4f8c61f467109b0cf362b1a5b091bc19707b022b162d4d"

URI_aarch64_rsyslog-relp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-relp-8.2412.0-1.el10.aarch64.rpm;name=aarch64_rsyslog-relp;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-relp}"
SRC_URI[aarch64_rsyslog-relp.sha256sum] = "572d8b9cf57538a9ef523e88c3e5c61c8c333aee066b70fb502ecc5069eee946"

URI_aarch64_rsyslog-snmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-snmp-8.2412.0-1.el10.aarch64.rpm;name=aarch64_rsyslog-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-snmp}"
SRC_URI[aarch64_rsyslog-snmp.sha256sum] = "06ad01d64cef9a5250aa9a024f74f43019998ee6d1c0654a437eab58971ba7d8"

URI_aarch64_rsyslog-udpspoof = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-udpspoof-8.2412.0-1.el10.aarch64.rpm;name=aarch64_rsyslog-udpspoof;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-udpspoof}"
SRC_URI[aarch64_rsyslog-udpspoof.sha256sum] = "885d9266a2c336a5bb9f13afbb4c3ee90a3d82172b10dfbb1abc4a9428b3c2c4"

RDEPENDS:rsyslog = " \
 bash \
 glibc \
 libcap-ng \
 libestr \
 libfastjson \
 libgcc \
 libuuid \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:rsyslog-crypto = " \
 glibc \
 libcap-ng \
 openssl-libs \
 rsyslog \
 "
RDEPENDS:rsyslog-doc = " \
 "
RDEPENDS:rsyslog-elasticsearch = " \
 glibc \
 libcap-ng \
 rsyslog \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:rsyslog-gnutls = " \
 glibc \
 gnutls \
 libcap-ng \
 rsyslog \
 "
RDEPENDS:rsyslog-gssapi = " \
 glibc \
 krb5-libs \
 libcap-ng \
 rsyslog \
 "
RDEPENDS:rsyslog-kafka = " \
 glibc \
 libcap-ng \
 librdkafka \
 rsyslog \
 "
RDEPENDS:rsyslog-mmaudit = " \
 glibc \
 libcap-ng \
 rsyslog \
 "
RDEPENDS:rsyslog-mmfields = " \
 glibc \
 libcap-ng \
 rsyslog \
 "
RDEPENDS:rsyslog-mmjsonparse = " \
 glibc \
 libcap-ng \
 libfastjson \
 rsyslog \
 "
RDEPENDS:rsyslog-mmkubernetes = " \
 glibc \
 libcap-ng \
 libfastjson \
 liblognorm \
 rsyslog \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:rsyslog-mmnormalize = " \
 glibc \
 libcap-ng \
 libfastjson \
 liblognorm \
 rsyslog \
 "
RDEPENDS:rsyslog-mmsnmptrapd = " \
 glibc \
 libcap-ng \
 rsyslog \
 "
RDEPENDS:rsyslog-mysql = " \
 glibc \
 mariadb-connector-c \
 rsyslog \
 "
RDEPENDS:rsyslog-omamqp1 = " \
 cyrus-sasl-lib \
 glibc \
 libcap-ng \
 openssl-libs \
 rsyslog \
 "
RDEPENDS:rsyslog-openssl = " \
 glibc \
 libcap-ng \
 openssl-libs \
 rsyslog \
 "
RDEPENDS:rsyslog-pgsql = " \
 glibc \
 libcap-ng \
 libpq \
 rsyslog \
 "
RDEPENDS:rsyslog-relp = " \
 glibc \
 libcap-ng \
 librelp \
 rsyslog \
 "
RDEPENDS:rsyslog-snmp = " \
 glibc \
 libcap-ng \
 net-snmp-libs \
 rsyslog \
 "
RDEPENDS:rsyslog-udpspoof = " \
 glibc \
 libcap-ng \
 libnet \
 rsyslog \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/syslog"

PROVIDES:append:aarch64 = " rpm/virtual/syslog"
