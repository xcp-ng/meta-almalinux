# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libwebsockets"
PV = "4.3.3"
PR = "1.el10_0"
PACKAGES = " \
 libwebsockets \
 libwebsockets-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libwebsockets-4.3.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c563c7ad7a15bbdfff56719b0df25366998a942ca37eb17be2120434d406af35"

URI_x86_64_v2_libwebsockets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libwebsockets-4.3.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libwebsockets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwebsockets}"
SRC_URI[x86_64_v2_libwebsockets.sha256sum] = "dd308c69db57e7c445d9a2ec6960bc306ed87f89a9d5eec38d3efa1aaf22b9ed"

URI_x86_64_v2_libwebsockets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libwebsockets-devel-4.3.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libwebsockets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwebsockets-devel}"
SRC_URI[x86_64_v2_libwebsockets-devel.sha256sum] = "2ed76a31a2e2ef41a6100605b90a083a4f961810718d8770aea68623741fb964"

URI_aarch64_libwebsockets = "${EPEL_MIRROR}/aarch64/Packages/l/libwebsockets-4.3.3-1.el10_0.aarch64.rpm;name=aarch64_libwebsockets;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwebsockets}"
SRC_URI[aarch64_libwebsockets.sha256sum] = "cfb36d661008c7d3e5da71b6ac8080df3fa54519830a7a6c4b0a0c4634ff40ea"

URI_aarch64_libwebsockets-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libwebsockets-devel-4.3.3-1.el10_0.aarch64.rpm;name=aarch64_libwebsockets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwebsockets-devel}"
SRC_URI[aarch64_libwebsockets-devel.sha256sum] = "c7929bae2702f9db6894926405cfee5e6bbcdf8cf72e9f8fd0e191bccc4775b8"

RDEPENDS:libwebsockets = " \
 glibc \
 libev \
 libuv \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:libwebsockets-devel = " \
 libev-devel \
 libuv-devel \
 libwebsockets \
 openssl-devel \
 pkgconf-pkg-config \
 "
