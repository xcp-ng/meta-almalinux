# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_json"
PV = "1.0.151"
PR = "1.el10_3"
PACKAGES = " \
 rust-serde_json+alloc-devel \
 rust-serde_json+arbitrary_precision-devel \
 rust-serde_json+default-devel \
 rust-serde_json+float_roundtrip-devel \
 rust-serde_json+indexmap-devel \
 rust-serde_json+preserve_order-devel \
 rust-serde_json+raw_value-devel \
 rust-serde_json+std-devel \
 rust-serde_json+unbounded_depth-devel \
 rust-serde_json-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_json-1.0.151-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "66802cf5b8a2ee8a26bfaa792556bb12ab2a9cc2fe421d52039bd36c086fbe5e"

URI_x86_64_v2_rust-serde_json+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_json+alloc-devel-1.0.151-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_json+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_json+alloc-devel}"
SRC_URI[x86_64_v2_rust-serde_json+alloc-devel.sha256sum] = "af0c5201a2a0ab75fb63be5c9e1e45634e70d34bdec25923f037ecf5f3aea936"

URI_x86_64_v2_rust-serde_json+arbitrary_precision-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_json+arbitrary_precision-devel-1.0.151-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_json+arbitrary_precision-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_json+arbitrary_precision-devel}"
SRC_URI[x86_64_v2_rust-serde_json+arbitrary_precision-devel.sha256sum] = "ca186d490d57e09eb11a5039db5a233ef56405832681cf0f5ec79e466b9c8ea0"

URI_x86_64_v2_rust-serde_json+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_json+default-devel-1.0.151-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_json+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_json+default-devel}"
SRC_URI[x86_64_v2_rust-serde_json+default-devel.sha256sum] = "3f70e681b1635364b999040e2960c4d24682257cb878ccf78c3f9d3547a08e62"

URI_x86_64_v2_rust-serde_json+float_roundtrip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_json+float_roundtrip-devel-1.0.151-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_json+float_roundtrip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_json+float_roundtrip-devel}"
SRC_URI[x86_64_v2_rust-serde_json+float_roundtrip-devel.sha256sum] = "ac171242bddbdfb9a1be43adbcfc10e2250a00e3a7a02073a529574d7cdcb826"

URI_x86_64_v2_rust-serde_json+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_json+indexmap-devel-1.0.151-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_json+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_json+indexmap-devel}"
SRC_URI[x86_64_v2_rust-serde_json+indexmap-devel.sha256sum] = "7e7b344595f05af81e7beac60382be1f9f411354e165cc67fe0661cb85eeb491"

URI_x86_64_v2_rust-serde_json+preserve_order-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_json+preserve_order-devel-1.0.151-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_json+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_json+preserve_order-devel}"
SRC_URI[x86_64_v2_rust-serde_json+preserve_order-devel.sha256sum] = "4369c554a8dd2b7ae8261fc464adf6f024d41404f87c14e1214fd8bde13261d9"

URI_x86_64_v2_rust-serde_json+raw_value-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_json+raw_value-devel-1.0.151-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_json+raw_value-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_json+raw_value-devel}"
SRC_URI[x86_64_v2_rust-serde_json+raw_value-devel.sha256sum] = "7be5af53725c290d46952f1039e0898c975b4f899b02f16b952d9661b7bd26c6"

URI_x86_64_v2_rust-serde_json+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_json+std-devel-1.0.151-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_json+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_json+std-devel}"
SRC_URI[x86_64_v2_rust-serde_json+std-devel.sha256sum] = "80721e6e3840658f760bd20841f3f5cc6f4baac1cfe770db2113e49f667a72c5"

URI_x86_64_v2_rust-serde_json+unbounded_depth-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_json+unbounded_depth-devel-1.0.151-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_json+unbounded_depth-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_json+unbounded_depth-devel}"
SRC_URI[x86_64_v2_rust-serde_json+unbounded_depth-devel.sha256sum] = "20c5ad6633ada4ed0d72edd3ae778891b51c34cc77301d1642c5ada06817848f"

URI_x86_64_v2_rust-serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_json-devel-1.0.151-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_json-devel}"
SRC_URI[x86_64_v2_rust-serde_json-devel.sha256sum] = "410e787e8460176a27dd35994b7aeabc028a48e75e7d55fad70092c69f902d0f"

URI_aarch64_rust-serde_json+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_json+alloc-devel-1.0.151-1.el10_3.noarch.rpm;name=aarch64_rust-serde_json+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_json+alloc-devel}"
SRC_URI[aarch64_rust-serde_json+alloc-devel.sha256sum] = "27700bf3c2b470ccc87084cf3d85061ef117f5388855458172de89704bb44dfa"

URI_aarch64_rust-serde_json+arbitrary_precision-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_json+arbitrary_precision-devel-1.0.151-1.el10_3.noarch.rpm;name=aarch64_rust-serde_json+arbitrary_precision-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_json+arbitrary_precision-devel}"
SRC_URI[aarch64_rust-serde_json+arbitrary_precision-devel.sha256sum] = "876759ae7a7c5026b5ff520731aa69006010d7eb66c8096eebd7bd4ef01d1521"

URI_aarch64_rust-serde_json+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_json+default-devel-1.0.151-1.el10_3.noarch.rpm;name=aarch64_rust-serde_json+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_json+default-devel}"
SRC_URI[aarch64_rust-serde_json+default-devel.sha256sum] = "fd95e3d6149661df5a1a4367ec3dd71721a1dfc912f2a8c685b6e0c353669e66"

URI_aarch64_rust-serde_json+float_roundtrip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_json+float_roundtrip-devel-1.0.151-1.el10_3.noarch.rpm;name=aarch64_rust-serde_json+float_roundtrip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_json+float_roundtrip-devel}"
SRC_URI[aarch64_rust-serde_json+float_roundtrip-devel.sha256sum] = "c668b69b46c222af6e5374a8971744203c8b9984a1d5f4bbd7daef1a95d1fe75"

URI_aarch64_rust-serde_json+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_json+indexmap-devel-1.0.151-1.el10_3.noarch.rpm;name=aarch64_rust-serde_json+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_json+indexmap-devel}"
SRC_URI[aarch64_rust-serde_json+indexmap-devel.sha256sum] = "030f423a01b959af5c19669ad96dde590665350c962f0505c27d03b11d7a780f"

URI_aarch64_rust-serde_json+preserve_order-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_json+preserve_order-devel-1.0.151-1.el10_3.noarch.rpm;name=aarch64_rust-serde_json+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_json+preserve_order-devel}"
SRC_URI[aarch64_rust-serde_json+preserve_order-devel.sha256sum] = "b07e0d5009388cb55064bf68acc02d926d1e75dfbc748cd92ee2b8f046502696"

URI_aarch64_rust-serde_json+raw_value-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_json+raw_value-devel-1.0.151-1.el10_3.noarch.rpm;name=aarch64_rust-serde_json+raw_value-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_json+raw_value-devel}"
SRC_URI[aarch64_rust-serde_json+raw_value-devel.sha256sum] = "f87b93de036559698699b1c4d9d9ca7bffdd0d0faa12fdd390323d91f498186d"

URI_aarch64_rust-serde_json+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_json+std-devel-1.0.151-1.el10_3.noarch.rpm;name=aarch64_rust-serde_json+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_json+std-devel}"
SRC_URI[aarch64_rust-serde_json+std-devel.sha256sum] = "d3017d83d46b30a8b4b90ee8f79a3392a675aab74b0d331cb5ac2171c779f04e"

URI_aarch64_rust-serde_json+unbounded_depth-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_json+unbounded_depth-devel-1.0.151-1.el10_3.noarch.rpm;name=aarch64_rust-serde_json+unbounded_depth-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_json+unbounded_depth-devel}"
SRC_URI[aarch64_rust-serde_json+unbounded_depth-devel.sha256sum] = "71b0217f03cc16c26676d5a3e58a3ee0eefb91f0317f9bf91079912423a5c0d9"

URI_aarch64_rust-serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_json-devel-1.0.151-1.el10_3.noarch.rpm;name=aarch64_rust-serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_json-devel}"
SRC_URI[aarch64_rust-serde_json-devel.sha256sum] = "6116e662978374f212a3ee7e424b35bae0a107368a44a8da0a3441e4f2fd1f7b"

RDEPENDS:rust-serde_json+alloc-devel = " \
 cargo \
 rust-serde_core+alloc-devel \
 rust-serde_json-devel \
 "
RDEPENDS:rust-serde_json+arbitrary_precision-devel = " \
 cargo \
 rust-serde_json-devel \
 "
RDEPENDS:rust-serde_json+default-devel = " \
 cargo \
 rust-serde_json+std-devel \
 rust-serde_json-devel \
 "
RDEPENDS:rust-serde_json+float_roundtrip-devel = " \
 cargo \
 rust-serde_json-devel \
 "
RDEPENDS:rust-serde_json+indexmap-devel = " \
 cargo \
 rust-indexmap+default-devel \
 rust-serde_json-devel \
 "
RDEPENDS:rust-serde_json+preserve_order-devel = " \
 cargo \
 rust-serde_json+indexmap-devel \
 rust-serde_json+std-devel \
 rust-serde_json-devel \
 "
RDEPENDS:rust-serde_json+raw_value-devel = " \
 cargo \
 rust-serde_json-devel \
 "
RDEPENDS:rust-serde_json+std-devel = " \
 cargo \
 rust-memchr+std-devel \
 rust-serde_core+std-devel \
 rust-serde_json-devel \
 "
RDEPENDS:rust-serde_json+unbounded_depth-devel = " \
 cargo \
 rust-serde_json-devel \
 "
RDEPENDS:rust-serde_json-devel = " \
 cargo \
 rust \
 rust-itoa+default-devel \
 rust-memchr-devel \
 rust-serde-devel \
 rust-serde_core-devel \
 rust-zmij+default-devel \
 "
