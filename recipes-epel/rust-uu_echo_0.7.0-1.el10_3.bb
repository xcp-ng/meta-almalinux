# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_echo"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_echo+default-devel \
 rust-uu_echo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_echo-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65b373455c059692677cb53fcc8ad7971b98892bd12cabc14aa761353c48bfb9"

URI_x86_64_v2_rust-uu_echo+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_echo+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_echo+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_echo+default-devel}"
SRC_URI[x86_64_v2_rust-uu_echo+default-devel.sha256sum] = "d03bbee4eeaaa0cd886b5b6da0e2071c45685d4bae981bb138b8ada074bd6f9e"

URI_x86_64_v2_rust-uu_echo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_echo-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_echo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_echo-devel}"
SRC_URI[x86_64_v2_rust-uu_echo-devel.sha256sum] = "726d9608596790e0cfa4f36a937efcc1b8cea7ab1a571ac3fcb6433d9d97299a"

URI_aarch64_rust-uu_echo+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_echo+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_echo+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_echo+default-devel}"
SRC_URI[aarch64_rust-uu_echo+default-devel.sha256sum] = "dd443a68feed02059696192fae443b1c4e8359e8e52c2d87c8c8c2dd741b2ce2"

URI_aarch64_rust-uu_echo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_echo-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_echo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_echo-devel}"
SRC_URI[aarch64_rust-uu_echo-devel.sha256sum] = "632427212f3c69c7019ef31b49c266171208ac6cfe6e58f9ddf5ec621e835fdc"

RDEPENDS:rust-uu_echo+default-devel = " \
 cargo \
 rust-uu_echo-devel \
 "
RDEPENDS:rust-uu_echo-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uucore+default-devel \
 rust-uucore+format-devel \
 "
