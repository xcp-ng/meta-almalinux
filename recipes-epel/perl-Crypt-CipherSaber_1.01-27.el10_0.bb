# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-CipherSaber"
PV = "1.01"
PR = "27.el10_0"
PACKAGES = " \
 perl-Crypt-CipherSaber \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-CipherSaber-1.01-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "195e1a3eca6fd8ab17f1e63b0c68de561ba75c8d9a58a64bba8e083faae5be2f"

URI_x86_64_v2_perl-Crypt-CipherSaber = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-CipherSaber-1.01-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Crypt-CipherSaber;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-CipherSaber}"
SRC_URI[x86_64_v2_perl-Crypt-CipherSaber.sha256sum] = "1c8cc450654c9af79d49531965ba368fbd23ecc7c12e910f969eb1609efab6c5"

URI_aarch64_perl-Crypt-CipherSaber = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-CipherSaber-1.01-27.el10_0.noarch.rpm;name=aarch64_perl-Crypt-CipherSaber;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-CipherSaber}"
SRC_URI[aarch64_perl-Crypt-CipherSaber.sha256sum] = "ee368e05414e0cab1469e855ed6df31f1765140af45b7a8afdc74ea5c976434c"

RDEPENDS:perl-Crypt-CipherSaber = " \
 perl-Carp \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-vars \
 "
