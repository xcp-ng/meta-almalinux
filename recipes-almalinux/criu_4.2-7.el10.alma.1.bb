# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "criu"
PV = "4.2"
PR = "7.el10.alma.1"
PACKAGES = " \
 crit \
 criu \
 criu-devel \
 criu-libs \
 python3-criu \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/criu-4.2-7.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "84a1c9709161c5423df8aa3e57d7ae3606bea8f000f4c67c0cd60fa8519bdd9b"

URI_x86_64_v2_crit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/crit-4.2-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_crit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_crit}"
SRC_URI[x86_64_v2_crit.sha256sum] = "a79bf944ee1526fbbbcb014b3ff5ca5fdd60fd2adb6c4daf75e8d92be1eda35f"

URI_x86_64_v2_criu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/criu-4.2-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_criu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_criu}"
SRC_URI[x86_64_v2_criu.sha256sum] = "f1f6676ff103edba6dec5d6cf29e01aa6e81bdb2a4fccbf37dacc664c2c2ee06"

URI_x86_64_v2_criu-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/criu-devel-4.2-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_criu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_criu-devel}"
SRC_URI[x86_64_v2_criu-devel.sha256sum] = "210ae3dcad6675f137d40a9e9ff9adfbc87de8f65f83a996d62c009509205e07"

URI_x86_64_v2_criu-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/criu-libs-4.2-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_criu-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_criu-libs}"
SRC_URI[x86_64_v2_criu-libs.sha256sum] = "ef752f501daa54a0c565056e6193ba5dbe335e9b1e66ef45a5b9705137c9afa1"

URI_x86_64_v2_python3-criu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-criu-4.2-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-criu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-criu}"
SRC_URI[x86_64_v2_python3-criu.sha256sum] = "118c58826eceea0523bee253a2207029d5916cea930bff8de972ba10bc074158"

URI_aarch64_crit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/crit-4.2-7.el10.alma.1.aarch64.rpm;name=aarch64_crit;unpack=0"
SRC_URI:append = " ${URI_aarch64_crit}"
SRC_URI[aarch64_crit.sha256sum] = "c2148c5d162e52c8fee33fddbec075417ac1d6645fb42bde9f9e0be83a29b6bb"

URI_aarch64_criu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/criu-4.2-7.el10.alma.1.aarch64.rpm;name=aarch64_criu;unpack=0"
SRC_URI:append = " ${URI_aarch64_criu}"
SRC_URI[aarch64_criu.sha256sum] = "9be772bb831ec12266366c94e8bb665d3eadd8609d6e4e6574486675e08d3daa"

URI_aarch64_criu-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/criu-devel-4.2-7.el10.alma.1.aarch64.rpm;name=aarch64_criu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_criu-devel}"
SRC_URI[aarch64_criu-devel.sha256sum] = "b57fd0403c50526153e0a0ae24594feedb5f882cec816045c6b00fce9fd235ea"

URI_aarch64_criu-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/criu-libs-4.2-7.el10.alma.1.aarch64.rpm;name=aarch64_criu-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_criu-libs}"
SRC_URI[aarch64_criu-libs.sha256sum] = "16bea501d7b2fc0d8dd4c4a1f5dafb1b6c0f5f8c384ff3dd938f50435135c30e"

URI_aarch64_python3-criu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-criu-4.2-7.el10.alma.1.aarch64.rpm;name=aarch64_python3-criu;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-criu}"
SRC_URI[aarch64_python3-criu.sha256sum] = "3b0d726e52a27c7c5db69958a6630dca937f07db8f60d33712e57ef9df37c3d8"

RDEPENDS:crit = " \
 python3 \
 python3-criu \
 "
RDEPENDS:criu = " \
 bash \
 glibc \
 gnutls \
 libgcc \
 libnet \
 libnl3 \
 libselinux \
 libuuid \
 nftables \
 protobuf-c \
 "
RDEPENDS:criu-devel = " \
 criu \
 criu-libs \
 pkgconf-pkg-config \
 protobuf-c-devel \
 "
RDEPENDS:criu-libs = " \
 criu \
 glibc \
 protobuf-c \
 "
RDEPENDS:python3-criu = " \
 python3 \
 python3-protobuf \
 "
