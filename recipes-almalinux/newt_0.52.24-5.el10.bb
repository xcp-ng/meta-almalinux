# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "newt"
PV = "0.52.24"
PR = "5.el10"
PACKAGES = " \
 newt \
 newt-devel \
 python3-newt \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/newt-0.52.24-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eb305dadb56d55e416ae0d3ac94fb381f7017f03c2797abe5ac6db9a3b7e1d66"

URI_x86_64_v2_newt = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/newt-0.52.24-5.el10.x86_64_v2.rpm;name=x86_64_v2_newt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_newt}"
SRC_URI[x86_64_v2_newt.sha256sum] = "6b02cdd0b0a7e6b1720f88bc781aed12c0c067d686e41f764794e67aecad1bf9"

URI_x86_64_v2_newt-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/newt-devel-0.52.24-5.el10.x86_64_v2.rpm;name=x86_64_v2_newt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_newt-devel}"
SRC_URI[x86_64_v2_newt-devel.sha256sum] = "34f8cf8650b03a0fd046d6466550b8cbede63604994bc6d8e0f0a16b256b3f07"

URI_x86_64_v2_python3-newt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-newt-0.52.24-5.el10.x86_64_v2.rpm;name=x86_64_v2_python3-newt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-newt}"
SRC_URI[x86_64_v2_python3-newt.sha256sum] = "e23cf6ec6e3c681bf4b125819fcc6b13fe49474a54f711bc8fb67b73fdbc3bb6"

URI_aarch64_newt = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/newt-0.52.24-5.el10.aarch64.rpm;name=aarch64_newt;unpack=0"
SRC_URI:append = " ${URI_aarch64_newt}"
SRC_URI[aarch64_newt.sha256sum] = "ee2f04ddd05765f9d02f3da20ab082abe8da219f93d2104a4576c178ed590258"

URI_aarch64_newt-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/newt-devel-0.52.24-5.el10.aarch64.rpm;name=aarch64_newt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_newt-devel}"
SRC_URI[aarch64_newt-devel.sha256sum] = "3eb91ca3b9ccc6661af2e0c8c9d1787ccd138fbaecdcd7571cf8ac6248cbd26f"

URI_aarch64_python3-newt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-newt-0.52.24-5.el10.aarch64.rpm;name=aarch64_python3-newt;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-newt}"
SRC_URI[aarch64_python3-newt.sha256sum] = "8ca2baf18facfd18e07d381b207ac106dacc4634f14a42538c31efbb4865ff87"

RDEPENDS:newt = " \
 glibc \
 popt \
 slang \
 "
RDEPENDS:newt-devel = " \
 newt \
 pkgconf-pkg-config \
 slang-devel \
 "
RDEPENDS:python3-newt = " \
 glibc \
 newt \
 python3 \
 "
