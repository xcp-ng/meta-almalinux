# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kalgebra"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kalgebra \
 kalgebra-plasma-applet \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kalgebra-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca9ad20a57cc08a22df6c829d7b16bc258c027a3c9fc70f0c31eb2265935e0f5"

URI_x86_64_v2_kalgebra = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kalgebra-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kalgebra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kalgebra}"
SRC_URI[x86_64_v2_kalgebra.sha256sum] = "1793a605a40038efc2f1f3a53dbb4e25863b51c758e32ee538771f7cfabaf24f"

URI_x86_64_v2_kalgebra-plasma-applet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kalgebra-plasma-applet-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kalgebra-plasma-applet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kalgebra-plasma-applet}"
SRC_URI[x86_64_v2_kalgebra-plasma-applet.sha256sum] = "2093510171c6c5efa2db2886710a08ac1f1b63ee8244987824af3cd43e409613"

URI_aarch64_kalgebra = "${EPEL_MIRROR}/aarch64/Packages/k/kalgebra-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kalgebra;unpack=0"
SRC_URI:append = " ${URI_aarch64_kalgebra}"
SRC_URI[aarch64_kalgebra.sha256sum] = "44d70178c7988a185d24b4b23237758a74d75a4f93e8d99f03632bbff16ccd46"

URI_aarch64_kalgebra-plasma-applet = "${EPEL_MIRROR}/aarch64/Packages/k/kalgebra-plasma-applet-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kalgebra-plasma-applet;unpack=0"
SRC_URI:append = " ${URI_aarch64_kalgebra-plasma-applet}"
SRC_URI[aarch64_kalgebra-plasma-applet.sha256sum] = "bba769ab834b554f44c464b35681417d5f6fe33104962894f14e5b0294e6fd27"

RDEPENDS:kalgebra = " \
 analitza \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebengine \
 readline \
 "
RDEPENDS:kalgebra-plasma-applet = " \
 kalgebra \
 libplasma \
 "
