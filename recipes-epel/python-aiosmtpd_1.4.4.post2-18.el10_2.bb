# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-aiosmtpd"
PV = "1.4.4.post2"
PR = "18.el10_2"
PACKAGES = " \
 python3-aiosmtpd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-aiosmtpd-1.4.4.post2-18.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e56b7e5d0fabb6da0be0dacd0fef525ed55d9ab0e31d224cb1c2e4f56555fe4c"

URI_x86_64_v2_python3-aiosmtpd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-aiosmtpd-1.4.4.post2-18.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-aiosmtpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-aiosmtpd}"
SRC_URI[x86_64_v2_python3-aiosmtpd.sha256sum] = "e30ae8148395c6abb92b5a2b6fe08ced70c6ffe8f76551fc82262668edbb7e64"

URI_aarch64_python3-aiosmtpd = "${EPEL_MIRROR}/aarch64/Packages/p/python3-aiosmtpd-1.4.4.post2-18.el10_2.noarch.rpm;name=aarch64_python3-aiosmtpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-aiosmtpd}"
SRC_URI[aarch64_python3-aiosmtpd.sha256sum] = "11154f2b9a4b483af830a5c9918f7cda422f7347a6c8351be27626d23896952c"

RDEPENDS:python3-aiosmtpd = " \
 python3 \
 python3-atpublic \
 python3-attrs \
 "
