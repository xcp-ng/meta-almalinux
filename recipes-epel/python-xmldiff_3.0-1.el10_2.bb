# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-xmldiff"
PV = "3.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-xmldiff \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-xmldiff-3.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c3c509a88cf7d05ce8c45f8c1e1b8b20d60ed3f72a08ee7ff4230295e1d770a8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-xmldiff-3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-xmldiff;unpack=0"
SRC_URI[x86_64_v2_python3-xmldiff.sha256sum] = "3d2a24e389c0a0a23c678c00f8e7cd71ed1af48ee55994eea05668b20e13c520"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-xmldiff-3.0-1.el10_2.noarch.rpm;name=aarch64_python3-xmldiff;unpack=0"
SRC_URI[aarch64_python3-xmldiff.sha256sum] = "819900a3e5ea8c0d8c0af315de3a0a6e4126ff60fc9f53c48c3ec17075715628"

RDEPENDS:python3-xmldiff = " \
 python3 \
 python3-lxml \
 "
