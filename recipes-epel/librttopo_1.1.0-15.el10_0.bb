# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "librttopo"
PV = "1.1.0"
PR = "15.el10_0"
PACKAGES = " \
 librttopo \
 librttopo-devel \
 mingw32-librttopo \
 mingw64-librttopo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/librttopo-1.1.0-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d3d012febc144ba02f46b575795a8b079f46af227b67207895e89078891cb30"

URI_x86_64_v2_librttopo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librttopo-1.1.0-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librttopo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librttopo}"
SRC_URI[x86_64_v2_librttopo.sha256sum] = "9b9e43441d00acdaaafbbc5812334f5b27ea4172a94dfc7d9524565404d6a701"

URI_x86_64_v2_librttopo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librttopo-devel-1.1.0-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librttopo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librttopo-devel}"
SRC_URI[x86_64_v2_librttopo-devel.sha256sum] = "5e5c44e82d095be4572a09b80522131942e09a5411aae85c8bd8756e715865ad"

URI_x86_64_v2_mingw32-librttopo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw32-librttopo-1.1.0-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mingw32-librttopo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-librttopo}"
SRC_URI[x86_64_v2_mingw32-librttopo.sha256sum] = "b2000a5622cea9d18f883ceadc8a0fe1aef8e2b0f9417dc2f30b768d0eb92ffd"

URI_x86_64_v2_mingw64-librttopo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw64-librttopo-1.1.0-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mingw64-librttopo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-librttopo}"
SRC_URI[x86_64_v2_mingw64-librttopo.sha256sum] = "4f0c987552cb3819f5d8e3c1e9427a9d6adafcf67adedd44347b11be9022ffcf"

URI_aarch64_librttopo = "${EPEL_MIRROR}/aarch64/Packages/l/librttopo-1.1.0-15.el10_0.aarch64.rpm;name=aarch64_librttopo;unpack=0"
SRC_URI:append = " ${URI_aarch64_librttopo}"
SRC_URI[aarch64_librttopo.sha256sum] = "6a4d385863a06b6fb7defee018245335cbecfc8f380e5d00fd9e53d3e4638569"

URI_aarch64_librttopo-devel = "${EPEL_MIRROR}/aarch64/Packages/l/librttopo-devel-1.1.0-15.el10_0.aarch64.rpm;name=aarch64_librttopo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_librttopo-devel}"
SRC_URI[aarch64_librttopo-devel.sha256sum] = "c555736f8adbb88bf62740dd36066243db78ffe4a9f26bae504f76fd998eb88c"

URI_aarch64_mingw32-librttopo = "${EPEL_MIRROR}/aarch64/Packages/m/mingw32-librttopo-1.1.0-15.el10_0.noarch.rpm;name=aarch64_mingw32-librttopo;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw32-librttopo}"
SRC_URI[aarch64_mingw32-librttopo.sha256sum] = "a075c5252d8dec90a132800b904ab9bb3c4573db839a5bb43879996c67c7b025"

URI_aarch64_mingw64-librttopo = "${EPEL_MIRROR}/aarch64/Packages/m/mingw64-librttopo-1.1.0-15.el10_0.noarch.rpm;name=aarch64_mingw64-librttopo;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw64-librttopo}"
SRC_URI[aarch64_mingw64-librttopo.sha256sum] = "b24d15d93ff6429beb9a778b6fcee178d86e414f92a334c77181758b86d5e4d9"

RDEPENDS:librttopo = " \
 geos \
 glibc \
 "
RDEPENDS:librttopo-devel = " \
 librttopo \
 pkgconf-pkg-config \
 "
RDEPENDS:mingw32-librttopo = " \
 mingw32-crt \
 mingw32-filesystem \
 mingw32-geos \
 "
RDEPENDS:mingw64-librttopo = " \
 mingw64-crt \
 mingw64-filesystem \
 mingw64-geos \
 "
