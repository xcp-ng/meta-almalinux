# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clang18"
PV = "18.1.8"
PR = "5.el10_1"
PACKAGES = " \
 clang18 \
 clang18-analyzer \
 clang18-devel \
 clang18-libs \
 clang18-resource-filesystem \
 clang18-tools-extra \
 clang18-tools-extra-devel \
 git-clang-format18 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/clang18-18.1.8-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "733f45d1eab82f93fb1f699704caa27f6020debabfbc7be8a50d62b78128c104"

URI_x86_64_v2_clang18 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clang18-18.1.8-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clang18;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang18}"
SRC_URI[x86_64_v2_clang18.sha256sum] = "5e3d9069a904c86171f329ffc8b29bf11f78f517e8a3f06af358f76d22c0da2a"

URI_x86_64_v2_clang18-analyzer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clang18-analyzer-18.1.8-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clang18-analyzer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang18-analyzer}"
SRC_URI[x86_64_v2_clang18-analyzer.sha256sum] = "b5fb9c3d9c9a894dd3acb010c568e786a594fe3e2efef206bca63c57be89bdea"

URI_x86_64_v2_clang18-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clang18-devel-18.1.8-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clang18-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang18-devel}"
SRC_URI[x86_64_v2_clang18-devel.sha256sum] = "3622d8fc0f488898640b09273f2f867b2eb1eb26d70375136d0c080778f8860a"

URI_x86_64_v2_clang18-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clang18-libs-18.1.8-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clang18-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang18-libs}"
SRC_URI[x86_64_v2_clang18-libs.sha256sum] = "36ed5b72c855fbf71979eae071aa58a196d98e0c34b8e36e09420029a07c3582"

URI_x86_64_v2_clang18-resource-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clang18-resource-filesystem-18.1.8-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clang18-resource-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang18-resource-filesystem}"
SRC_URI[x86_64_v2_clang18-resource-filesystem.sha256sum] = "ddff1fc11e09735a6a6cc1cd7b91a1a6d1cc238b493293eb7cbb9883ee7f111f"

URI_x86_64_v2_clang18-tools-extra = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clang18-tools-extra-18.1.8-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clang18-tools-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang18-tools-extra}"
SRC_URI[x86_64_v2_clang18-tools-extra.sha256sum] = "cd4f2e164e91ff855f3180498ba0a3f13a4c862177b682486a49d8523759d567"

URI_x86_64_v2_clang18-tools-extra-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clang18-tools-extra-devel-18.1.8-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clang18-tools-extra-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang18-tools-extra-devel}"
SRC_URI[x86_64_v2_clang18-tools-extra-devel.sha256sum] = "1efb3852fd3de69431e9bde84572c072a782419c53363d1dbc7d4fbc67228958"

URI_x86_64_v2_git-clang-format18 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/git-clang-format18-18.1.8-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_git-clang-format18;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-clang-format18}"
SRC_URI[x86_64_v2_git-clang-format18.sha256sum] = "29ee4f79b3f4495b61b128f8786d91f122fae9159f71af813d6216df3383f448"

URI_aarch64_clang18 = "${EPEL_MIRROR}/aarch64/Packages/c/clang18-18.1.8-5.el10_1.aarch64.rpm;name=aarch64_clang18;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang18}"
SRC_URI[aarch64_clang18.sha256sum] = "166c68e1ba9b68b335bb4d81fa3ca4815febcddd21b720ce0f77e57b9255878d"

URI_aarch64_clang18-analyzer = "${EPEL_MIRROR}/aarch64/Packages/c/clang18-analyzer-18.1.8-5.el10_1.aarch64.rpm;name=aarch64_clang18-analyzer;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang18-analyzer}"
SRC_URI[aarch64_clang18-analyzer.sha256sum] = "b3ed9dce8d47274b28f0329edfdba894118e055c9f34cc87a034aca8a7d0f670"

URI_aarch64_clang18-devel = "${EPEL_MIRROR}/aarch64/Packages/c/clang18-devel-18.1.8-5.el10_1.aarch64.rpm;name=aarch64_clang18-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang18-devel}"
SRC_URI[aarch64_clang18-devel.sha256sum] = "82e4ba7c1a03d31160d2aae2f4f71190eb1f29d6bc98554ee108fcceeb38efd2"

URI_aarch64_clang18-libs = "${EPEL_MIRROR}/aarch64/Packages/c/clang18-libs-18.1.8-5.el10_1.aarch64.rpm;name=aarch64_clang18-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang18-libs}"
SRC_URI[aarch64_clang18-libs.sha256sum] = "3cb87485bbb9b1c4d831ad0cb054bd11bb948897511b46f43663f570a2cbfd35"

URI_aarch64_clang18-resource-filesystem = "${EPEL_MIRROR}/aarch64/Packages/c/clang18-resource-filesystem-18.1.8-5.el10_1.aarch64.rpm;name=aarch64_clang18-resource-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang18-resource-filesystem}"
SRC_URI[aarch64_clang18-resource-filesystem.sha256sum] = "0e54f2e4756116e95512e315594ec3d4e788b511db824c85977b905a324e89a1"

URI_aarch64_clang18-tools-extra = "${EPEL_MIRROR}/aarch64/Packages/c/clang18-tools-extra-18.1.8-5.el10_1.aarch64.rpm;name=aarch64_clang18-tools-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang18-tools-extra}"
SRC_URI[aarch64_clang18-tools-extra.sha256sum] = "e69feaa0c608a791a76099484bcd1a19367bd2855467f2325911cbeaf3a493ac"

URI_aarch64_clang18-tools-extra-devel = "${EPEL_MIRROR}/aarch64/Packages/c/clang18-tools-extra-devel-18.1.8-5.el10_1.aarch64.rpm;name=aarch64_clang18-tools-extra-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang18-tools-extra-devel}"
SRC_URI[aarch64_clang18-tools-extra-devel.sha256sum] = "99b470871d85cbc6cf03af17966ff2740feb182109751a34560db9c01a154f4a"

URI_aarch64_git-clang-format18 = "${EPEL_MIRROR}/aarch64/Packages/g/git-clang-format18-18.1.8-5.el10_1.aarch64.rpm;name=aarch64_git-clang-format18;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-clang-format18}"
SRC_URI[aarch64_git-clang-format18.sha256sum] = "df3bcd7ac62e0718829478adb6e94e6872b493166fd5ed2758d1d06c0c957d4e"

RDEPENDS:clang18 = " \
 clang18-libs \
 gcc-c++ \
 glibc \
 libstdc++ \
 libstdc++-devel \
 llvm18-libs \
 "
RDEPENDS:clang18-analyzer = " \
 clang18 \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-FindBin \
 perl-Hash-Util \
 perl-PathTools \
 perl-Sys-Hostname \
 perl-Term-ANSIColor \
 perl-Text-ParseWords \
 perl-interpreter \
 perl-lib \
 perl-libs \
 python3 \
 "
RDEPENDS:clang18-devel = " \
 clang18 \
 clang18-libs \
 clang18-tools-extra \
 glibc \
 libgcc \
 libstdc++ \
 ncurses-libs \
 "
RDEPENDS:clang18-libs:x86_64_v2 = " \
 clang18-resource-filesystem \
 glibc \
 libstdc++ \
 llvm18-libs \
"
RDEPENDS:clang18-libs:aarch64 = " \
 clang18-resource-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 llvm18-libs \
"
RDEPENDS:clang18-resource-filesystem = " \
 "
RDEPENDS:clang18-tools-extra = " \
 clang18-libs \
 emacs-filesystem \
 glibc \
 libstdc++ \
 libxml2 \
 llvm18-libs \
 python3 \
 "
RDEPENDS:clang18-tools-extra-devel = " \
 clang18-tools-extra \
 "
RDEPENDS:git-clang-format18 = " \
 clang18-tools-extra \
 git \
 python3 \
 "
