# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-debian"
PV = "0.1.51"
PR = "10.el10_3"
PACKAGES = " \
 python3-debian \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-debian-0.1.51-10.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c4e21c708f429e36260aed214f4f00562f45b1495817056b279b5e53c1f0adc"

URI_x86_64_v2_python3-debian = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-debian-0.1.51-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-debian;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-debian}"
SRC_URI[x86_64_v2_python3-debian.sha256sum] = "44075d60747f863e2fa7a2eacf0ff208f7925e9ac003d36c46aa3fd256da00bc"

URI_aarch64_python3-debian = "${EPEL_MIRROR}/aarch64/Packages/p/python3-debian-0.1.51-10.el10_3.noarch.rpm;name=aarch64_python3-debian;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-debian}"
SRC_URI[aarch64_python3-debian.sha256sum] = "a568f2e9ca4efd1f5283370e4e48b7ef4f5e8b155fc204fb1eb470dfc76eb247"

RDEPENDS:python3-debian = " \
 python3 \
 python3-chardet \
 python3-charset-normalizer \
 python3-six \
 xz \
 "
