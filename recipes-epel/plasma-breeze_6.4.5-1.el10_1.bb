# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-breeze"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 breeze-cursor-theme \
 plasma-breeze \
 plasma-breeze-common \
 plasma-breeze-qt6 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-breeze-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b7ec508b635d91a7ba812d4fcb5694faab10ff1354cd733a77143ef7ab7d4e0"

URI_x86_64_v2_breeze-cursor-theme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-cursor-theme-6.4.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-cursor-theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_breeze-cursor-theme}"
SRC_URI[x86_64_v2_breeze-cursor-theme.sha256sum] = "2d4041f0602867cb7e75b406dcd1016ba4a67c838da3b4790dacda7bdea83eff"

URI_x86_64_v2_plasma-breeze = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-breeze-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-breeze;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-breeze}"
SRC_URI[x86_64_v2_plasma-breeze.sha256sum] = "72e51082f509aad0a0a719939f66522acb96b0498fe054dd6564298d62d4bee2"

URI_x86_64_v2_plasma-breeze-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-breeze-common-6.4.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-breeze-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-breeze-common}"
SRC_URI[x86_64_v2_plasma-breeze-common.sha256sum] = "6c1c60b6ecb85237b7ca9956f9b6a11a7b4c036e8c608b6972a160f89cbe942e"

URI_x86_64_v2_plasma-breeze-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-breeze-qt6-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-breeze-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-breeze-qt6}"
SRC_URI[x86_64_v2_plasma-breeze-qt6.sha256sum] = "f80b4f91ed062360e6965ad82d97a5e157455b9617d76bdbf4ee520d17b93aa8"

URI_aarch64_breeze-cursor-theme = "${EPEL_MIRROR}/aarch64/Packages/b/breeze-cursor-theme-6.4.5-1.el10_1.noarch.rpm;name=aarch64_breeze-cursor-theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_breeze-cursor-theme}"
SRC_URI[aarch64_breeze-cursor-theme.sha256sum] = "d1af0b42ba3121cd08486108b4b2bdec36b141283597b760941f9cbee8613344"

URI_aarch64_plasma-breeze = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-breeze-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_plasma-breeze;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-breeze}"
SRC_URI[aarch64_plasma-breeze.sha256sum] = "5bf1a1c1216f57796b45fe7c86ef144a05708c5cad50abef82c28bfd8ae4e2e0"

URI_aarch64_plasma-breeze-common = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-breeze-common-6.4.5-1.el10_1.noarch.rpm;name=aarch64_plasma-breeze-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-breeze-common}"
SRC_URI[aarch64_plasma-breeze-common.sha256sum] = "024d8fe730e20b541a1bd8b4477c7b3f9d6de9c26e620d2405ec317a181e5450"

URI_aarch64_plasma-breeze-qt6 = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-breeze-qt6-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_plasma-breeze-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-breeze-qt6}"
SRC_URI[aarch64_plasma-breeze-qt6.sha256sum] = "567f2935478cc8de10d3fcbd44f7e0f70e4636a8f2e9126ebf50fc5bf0cb994b"

RDEPENDS:breeze-cursor-theme = " \
 "
RDEPENDS:plasma-breeze = " \
 cmake-filesystem \
 glibc \
 kdecoration \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 libstdc++ \
 plasma-breeze-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
RDEPENDS:plasma-breeze-common = " \
 "
RDEPENDS:plasma-breeze-qt6 = " \
 glibc \
 kf6-frameworkintegration-libs \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kguiaddons \
 kf6-kiconthemes \
 kf6-kirigami \
 kf6-kwindowsystem \
 libstdc++ \
 plasma-breeze-common \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
