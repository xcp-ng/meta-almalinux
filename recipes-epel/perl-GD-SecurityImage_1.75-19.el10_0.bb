# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-GD-SecurityImage"
PV = "1.75"
PR = "19.el10_0"
PACKAGES = " \
 perl-GD-SecurityImage \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-GD-SecurityImage-1.75-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cfa906f7a2473548ffb681d3a1ee26176f9f8982955f03e39dd3db2d1c56024a"

URI_x86_64_v2_perl-GD-SecurityImage = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-GD-SecurityImage-1.75-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-GD-SecurityImage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-GD-SecurityImage}"
SRC_URI[x86_64_v2_perl-GD-SecurityImage.sha256sum] = "0438c979080e5616758ae70e958e657bc5e0f3dba459cba0d2eb9b486b2b3fda"

URI_aarch64_perl-GD-SecurityImage = "${EPEL_MIRROR}/aarch64/Packages/p/perl-GD-SecurityImage-1.75-19.el10_0.noarch.rpm;name=aarch64_perl-GD-SecurityImage;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-GD-SecurityImage}"
SRC_URI[aarch64_perl-GD-SecurityImage.sha256sum] = "74682bcb30b9396c07aed51a3a53830cb12b119b3b7f103235c92e060123aa7a"

RDEPENDS:perl-GD-SecurityImage = " \
 ImageMagick-perl \
 perl-Carp \
 perl-GD \
 perl-GD-SecurityImage \
 perl-constant \
 perl-libs \
 perl-vars \
 "
