# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-minijinja"
PV = "2.24.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-minijinja+adjacent_loop_items-devel \
 rust-minijinja+builtins-devel \
 rust-minijinja+custom_syntax-devel \
 rust-minijinja+debug-devel \
 rust-minijinja+default-devel \
 rust-minijinja+deserialization-devel \
 rust-minijinja+fuel-devel \
 rust-minijinja+indexmap-devel \
 rust-minijinja+internal_debug-devel \
 rust-minijinja+internal_safe_search-devel \
 rust-minijinja+json-devel \
 rust-minijinja+key_interning-devel \
 rust-minijinja+loader-devel \
 rust-minijinja+loop_controls-devel \
 rust-minijinja+macros-devel \
 rust-minijinja+multi_template-devel \
 rust-minijinja+percent-encoding-devel \
 rust-minijinja+preserve_order-devel \
 rust-minijinja+serde-devel \
 rust-minijinja+serde_json-devel \
 rust-minijinja+speedups-devel \
 rust-minijinja+stacker-devel \
 rust-minijinja+std_collections-devel \
 rust-minijinja+unicase-devel \
 rust-minijinja+unicode-devel \
 rust-minijinja+unicode-ident-devel \
 rust-minijinja+unstable_machinery-devel \
 rust-minijinja+unstable_machinery_serde-devel \
 rust-minijinja+urlencode-devel \
 rust-minijinja+v_htmlescape-devel \
 rust-minijinja-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-minijinja-2.24.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "57c0404dbe2aff145430fc5df49964137b4d149046614f0a5ba765326c83d4c2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+adjacent_loop_items-devel-2.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+adjacent_loop_items-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+adjacent_loop_items-devel.sha256sum] = "1fe203474cf0c372e972dc33cac213897160550e3c4f2ba80170ce0792b76f84"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+builtins-devel-2.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+builtins-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+builtins-devel.sha256sum] = "2d0f4e4750e616c58e35229fe00c655cc4769eeaf18a90338a0299792f7110ad"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+custom_syntax-devel-2.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+custom_syntax-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+custom_syntax-devel.sha256sum] = "ff99cf0b988b8a0dda0a0be05ec92c07819562c4dfb5734c356590e8827e92ea"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+debug-devel-2.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+debug-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+debug-devel.sha256sum] = "98107fd2ddfd63f12f3b94181f850fb8824a763c97095228589ab21b48c75c3f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+default-devel-2.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+default-devel.sha256sum] = "e3b45570746128bfd0c283a892c741689200127f6771d67b2036f27d3882e5ca"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+deserialization-devel-2.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+deserialization-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+deserialization-devel.sha256sum] = "17ee4b35114232b92614c9e0f3a546cf5652f7606e4747e5cb5f8e524d519096"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+fuel-devel-2.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+fuel-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+fuel-devel.sha256sum] = "bd83d9c81fde1fc535e2fd1db836b9dabb82a2dcc06f5ac952e746a05c32e240"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+indexmap-devel-2.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+indexmap-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+indexmap-devel.sha256sum] = "a56fa4d716eb4eb21c6570d6583ebada6ff194f35a768203a37ecef0fee16000"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+internal_debug-devel-2.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+internal_debug-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+internal_debug-devel.sha256sum] = "63d47031c98e2a6681dc97dbc41dbee1f3fd203afd29acf1cf562848cd864254"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+internal_safe_search-devel-2.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+internal_safe_search-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+internal_safe_search-devel.sha256sum] = "dd61027471225cc9296ede31b64f2d1075ff919bd4b9e451b27b80298d8f537d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+json-devel-2.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+json-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+json-devel.sha256sum] = "c36e4b480db1469fa0bb8bc6454856e43e6af4edb39545015de78708419c4834"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+key_interning-devel-2.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+key_interning-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+key_interning-devel.sha256sum] = "de516c2b33c43609bae34de4fb509d116735e79109a21c435f10985b8436d41c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+loader-devel-2.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+loader-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+loader-devel.sha256sum] = "dbab229bb0c601dfbc919bd5a1af7a0561de6fee9e73760cfba684656f588746"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+loop_controls-devel-2.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+loop_controls-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+loop_controls-devel.sha256sum] = "cb3aa5df61c4812b67914d9d2b6bd86db8ed442b95e37ad80dd3c6fb55beaf2b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+macros-devel-2.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+macros-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+macros-devel.sha256sum] = "da3182cd9a7346a92b72eb3f5d4eb26466f65fb69ff50d4eb772b7ea0dd45d61"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+multi_template-devel-2.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+multi_template-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+multi_template-devel.sha256sum] = "bfe36bf8ec6e16008bd8b09fff34bf0d692ade678de315792137ddc8404358f9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+percent-encoding-devel-2.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+percent-encoding-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+percent-encoding-devel.sha256sum] = "795f83280499652a1cab27c6940dbd3f9b92387a09131efc79286a4194f7477d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+preserve_order-devel-2.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+preserve_order-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+preserve_order-devel.sha256sum] = "9f088cebf8fa9cd345bb259e6ae33469a7a34bbe7600e468b8463589a3bdb9ba"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+serde-devel-2.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+serde-devel.sha256sum] = "46e05cd4c8827903a87ce77e5c6ee5bea083ddb893b27ae6f2d35528c9a8b989"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+serde_json-devel-2.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+serde_json-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+serde_json-devel.sha256sum] = "1feae0badac7e00a8b4eba44e7e800b1e156d72c311c14973c924b009034d182"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+speedups-devel-2.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+speedups-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+speedups-devel.sha256sum] = "f0c65fb7ea9c3cb0d841d7cebac9f9a4a00d122aa1bc6559c97d06d001391d6f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+stacker-devel-2.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+stacker-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+stacker-devel.sha256sum] = "00464e1ddb4a1bc1bcaf267238bcb8c40674dbc0ddaade1c4c417c02bf7c4632"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+std_collections-devel-2.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+std_collections-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+std_collections-devel.sha256sum] = "4335d3a84c0d9d3301767d647bf223d020f8d420a368175139aa29304fe3af60"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+unicase-devel-2.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+unicase-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+unicase-devel.sha256sum] = "73db9199dc82e305a5d981b40f83f2f18eead4e873643c64d0f9066796ff0a54"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+unicode-devel-2.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+unicode-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+unicode-devel.sha256sum] = "0540854f096c9e1e9a9cea7fcf80a8b57a6b4404788cfaa8d1a681ce73a7485f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+unicode-ident-devel-2.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+unicode-ident-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+unicode-ident-devel.sha256sum] = "cee302fda40bd494bb835b4a1c5c85efcb7a3a181e11d0fcb10ed8ccaa774063"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+unstable_machinery-devel-2.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+unstable_machinery-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+unstable_machinery-devel.sha256sum] = "e5b7269cee6c1c08b017f787d5f54924a686342b6120ee35553a5c0e9cb651a1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+unstable_machinery_serde-devel-2.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+unstable_machinery_serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+unstable_machinery_serde-devel.sha256sum] = "ad2a3a297cd746924ab72ffe5bac2ffd8c0686536cd9a3a3b8152b74dd809cbb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+urlencode-devel-2.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+urlencode-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+urlencode-devel.sha256sum] = "dde6007ab5170ff6bfd45e8d98c4d6d3aeb358e522f2e3344c5491ee63f2fb2a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+v_htmlescape-devel-2.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+v_htmlescape-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+v_htmlescape-devel.sha256sum] = "5dd2cbbba3207afaa6e1a9a7087a9200f79bf86f08b0315611b16b0b55ef747d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja-devel-2.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja-devel.sha256sum] = "f661ef5646e888049bb7b296bf0e99e18c4298ef16f44b6ab252a4e23203c74d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+adjacent_loop_items-devel-2.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+adjacent_loop_items-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+adjacent_loop_items-devel.sha256sum] = "e335e95b14f79db74c3e368a5ca3d37d35038a77fa79948d59c9ee58dc502c6b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+builtins-devel-2.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+builtins-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+builtins-devel.sha256sum] = "78529876197ea7e2d3d06568ab776ea58676502ed7f08e38810465c1a1d20fe2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+custom_syntax-devel-2.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+custom_syntax-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+custom_syntax-devel.sha256sum] = "dd94dd7efe28df9de4e331df46e1733309071a52c601f21d698768e5b268d6fb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+debug-devel-2.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+debug-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+debug-devel.sha256sum] = "74270d8710b35abcd597397833587bd504f7c73ef03546b1455f62eef0761087"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+default-devel-2.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+default-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+default-devel.sha256sum] = "6cbbc31dbdc51cab61807d8c3cc02afe426d1d82c7686b936a18e41514dae87e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+deserialization-devel-2.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+deserialization-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+deserialization-devel.sha256sum] = "5b75745175fee0de7913d09fa68c10bf0868449556c46550621fbd714d418682"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+fuel-devel-2.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+fuel-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+fuel-devel.sha256sum] = "592ec64244e2049e93210029cec244406fb0c78a256577f55ea4b4f57c09e495"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+indexmap-devel-2.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+indexmap-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+indexmap-devel.sha256sum] = "420d55a6c66664719aa19594aac27b95eda9ba01b2d7ea7f52b2cf3d7f0546b1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+internal_debug-devel-2.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+internal_debug-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+internal_debug-devel.sha256sum] = "4052ff7abc695a95e2f47d052736a5753d7eac07e81a9185f57667e533ff51d3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+internal_safe_search-devel-2.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+internal_safe_search-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+internal_safe_search-devel.sha256sum] = "985eccf366f950f529aabd54e8835eceef56e81d8d2daf4b4b467b7ae9171172"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+json-devel-2.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+json-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+json-devel.sha256sum] = "09b2fab5fe58c0b1f9bc64ec21c824cd68b6b37a776044ae454cd21f359b52d2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+key_interning-devel-2.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+key_interning-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+key_interning-devel.sha256sum] = "4105ca37120f97570a249ebe61b81b324ce0bb0d52aa387269182893cb5db49b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+loader-devel-2.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+loader-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+loader-devel.sha256sum] = "0f9ad71d425b3eee6da5d856a020ab045aefbc1605bbfada47c7fd33675a3edc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+loop_controls-devel-2.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+loop_controls-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+loop_controls-devel.sha256sum] = "ec9a259c44e8b849d9ca176eec3ee0acb282888f448bba71ee802c27c80b578a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+macros-devel-2.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+macros-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+macros-devel.sha256sum] = "c0f3a55e3c7ff8619cfbb03b1b6e4c21b3fdd731f093190456dcb7f43ac22af2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+multi_template-devel-2.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+multi_template-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+multi_template-devel.sha256sum] = "582f782cab886f5fa1cfd59285c0b543b159fbff0c0e97454d6f387b3c0ef7f1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+percent-encoding-devel-2.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+percent-encoding-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+percent-encoding-devel.sha256sum] = "33d2c50c6c2d46318a9dbc1f9f91c627d81697a44ff27629a87d2fd57b77b043"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+preserve_order-devel-2.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+preserve_order-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+preserve_order-devel.sha256sum] = "cd2b600b07784a2d17ce2fa6287e9430363afd922296b40b337605a790a7bfeb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+serde-devel-2.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+serde-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+serde-devel.sha256sum] = "71d6574e22e72cdda3963ced12e07c31a9aa4f0b5756fea1b41e5b0c64a314d9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+serde_json-devel-2.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+serde_json-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+serde_json-devel.sha256sum] = "ae0f1232ab95568fbbaf1073947bdfb1e7758264579f1604648e28d2fce2c549"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+speedups-devel-2.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+speedups-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+speedups-devel.sha256sum] = "d143174afe88b0d87110e9a39c61d4d6cbaa99b204b6b9bcc9fd837be2245f5d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+stacker-devel-2.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+stacker-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+stacker-devel.sha256sum] = "f98654455ada43bd782381a85ffaa8fb71fa981413f0c40f55890fad72704679"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+std_collections-devel-2.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+std_collections-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+std_collections-devel.sha256sum] = "6c4e45ebc010168a2d1b59a96d5ef87e0b717b8e823ea2d0b63ba4e5a41db2af"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+unicase-devel-2.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+unicase-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+unicase-devel.sha256sum] = "8a22d0436b89a9b7382ea4cc5232bcd00bf118bf0d8b9c34e870d4bbbb60ce3a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+unicode-devel-2.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+unicode-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+unicode-devel.sha256sum] = "dc93299436c9a37a85ffcb219ecd4aa77fae483acc797541be6d95ca1fca3d7e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+unicode-ident-devel-2.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+unicode-ident-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+unicode-ident-devel.sha256sum] = "0b9b75d3b2e7bd4ceee7872c9597f6c74af55ab0c42c2cac8f494881b83cb46b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+unstable_machinery-devel-2.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+unstable_machinery-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+unstable_machinery-devel.sha256sum] = "60f9a57db781f9a962a9264c05b1d5a827d4ac5851b38057ce9e53a5829cc271"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+unstable_machinery_serde-devel-2.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+unstable_machinery_serde-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+unstable_machinery_serde-devel.sha256sum] = "0a061ef6f2791a09bf60509cff245762bd64ed62e049cef2cf337b68c440fb03"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+urlencode-devel-2.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+urlencode-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+urlencode-devel.sha256sum] = "6b69d35437a4b921e3a03b59ccf659616e21cc0de45fbaa5b443989b2e8a348d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+v_htmlescape-devel-2.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja+v_htmlescape-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+v_htmlescape-devel.sha256sum] = "b84729c5a86d6dbe11ff8f23af5105c3446d39311fadf616c0c5d01de301176b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja-devel-2.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-minijinja-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja-devel.sha256sum] = "d604423ef15e22ef6e96c94497163163fbabfa3689045a70fe4290c99388fcc5"

RDEPENDS:rust-minijinja+adjacent_loop_items-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+builtins-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+custom_syntax-devel = " \
 cargo \
 rust-aho-corasick-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+debug-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+default-devel = " \
 cargo \
 rust-minijinja+adjacent_loop_items-devel \
 rust-minijinja+builtins-devel \
 rust-minijinja+debug-devel \
 rust-minijinja+deserialization-devel \
 rust-minijinja+macros-devel \
 rust-minijinja+multi_template-devel \
 rust-minijinja+serde-devel \
 rust-minijinja+std_collections-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+deserialization-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+fuel-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+indexmap-devel = " \
 cargo \
 rust-indexmap+default-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+internal_debug-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+internal_safe_search-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+json-devel = " \
 cargo \
 rust-minijinja+serde_json-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+key_interning-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+loader-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+loop_controls-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+macros-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+multi_template-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+percent-encoding-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-percent-encoding+default-devel \
 "
RDEPENDS:rust-minijinja+preserve_order-devel = " \
 cargo \
 rust-minijinja+indexmap-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+serde-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+serde_json-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-minijinja+speedups-devel = " \
 cargo \
 rust-minijinja+v_htmlescape-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+stacker-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-stacker+default-devel \
 "
RDEPENDS:rust-minijinja+std_collections-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+unicase-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-unicase+default-devel \
 "
RDEPENDS:rust-minijinja+unicode-devel = " \
 cargo \
 rust-minijinja+unicase-devel \
 rust-minijinja+unicode-ident-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+unicode-ident-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-unicode-ident+default-devel \
 "
RDEPENDS:rust-minijinja+unstable_machinery-devel = " \
 cargo \
 rust-minijinja+internal_debug-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+unstable_machinery_serde-devel = " \
 cargo \
 rust-minijinja+unstable_machinery-devel \
 rust-minijinja-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-minijinja+urlencode-devel = " \
 cargo \
 rust-minijinja+percent-encoding-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+v_htmlescape-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-v_htmlescape+default-devel \
 "
RDEPENDS:rust-minijinja-devel = " \
 cargo \
 rust \
 rust-memo-map+default-devel \
 rust-serde+default-devel \
 "
