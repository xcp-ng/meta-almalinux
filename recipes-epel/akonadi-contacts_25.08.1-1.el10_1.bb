# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-contacts"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 akonadi-contacts \
 akonadi-contacts-devel \
 akonadi-contacts-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akonadi-contacts-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd5a59a9230f74dab7dc6b1b6e613b9e649b71649bf19026fef64ca8d5b33126"

URI_x86_64_v2_akonadi-contacts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-contacts-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-contacts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-contacts}"
SRC_URI[x86_64_v2_akonadi-contacts.sha256sum] = "63cdd556856eadededb15b6a4e466d12c27e9dd7a9a2be20d35ceb352a94a58b"

URI_x86_64_v2_akonadi-contacts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-contacts-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-contacts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-contacts-devel}"
SRC_URI[x86_64_v2_akonadi-contacts-devel.sha256sum] = "e67e9385b28b26d4c30bd860adbc29c5cfe1d9f655cf04f779392a1f9b10bd5b"

URI_x86_64_v2_akonadi-contacts-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-contacts-doc-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_akonadi-contacts-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-contacts-doc}"
SRC_URI[x86_64_v2_akonadi-contacts-doc.sha256sum] = "f113753aef78fb0a12dec362aa5b899a4108133bfb1d3f03d2df7457bee20372"

URI_aarch64_akonadi-contacts = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-contacts-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_akonadi-contacts;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-contacts}"
SRC_URI[aarch64_akonadi-contacts.sha256sum] = "63f2173b0f87b1ad9212c906573901531060f1a4c7d1cbaf5d3a3a55b2c1652b"

URI_aarch64_akonadi-contacts-devel = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-contacts-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_akonadi-contacts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-contacts-devel}"
SRC_URI[aarch64_akonadi-contacts-devel.sha256sum] = "a891c290ee1271b108567ab81a20f47b86d2feb624b2e1ac211c403f2f77d0b2"

URI_aarch64_akonadi-contacts-doc = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-contacts-doc-25.08.1-1.el10_1.noarch.rpm;name=aarch64_akonadi-contacts-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-contacts-doc}"
SRC_URI[aarch64_akonadi-contacts-doc.sha256sum] = "fc99951fa89aa576446df0e69fe5625b9f7ff91f06e571ff6c5ef7b7fa9f25eb"

RDEPENDS:akonadi-contacts = " \
 akonadi-server \
 glibc \
 grantleetheme \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-ktexttemplate \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-prison \
 kmime \
 ktextaddons-qt6 \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:akonadi-contacts-devel = " \
 akonadi-contacts \
 akonadi-server-devel \
 cmake-filesystem \
 grantleetheme-devel \
 kf6-kcontacts-devel \
 "
RDEPENDS:akonadi-contacts-doc = " \
 "
