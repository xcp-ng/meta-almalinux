# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-genshi"
PV = "0.7.11"
PR = "1.el10_2"
PACKAGES = " \
 python3-genshi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-genshi-0.7.11-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "67f3011f805dc8f3f2fa047866b1a5a7ab4825c2b76cfd64893d19690d72032a"

URI_x86_64_v2_python3-genshi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-genshi-0.7.11-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-genshi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-genshi}"
SRC_URI[x86_64_v2_python3-genshi.sha256sum] = "fdf7342b5963199bd6384d32af23a123cb1a05618c063b5270e9d305e7cc06f9"

URI_aarch64_python3-genshi = "${EPEL_MIRROR}/aarch64/Packages/p/python3-genshi-0.7.11-1.el10_2.aarch64.rpm;name=aarch64_python3-genshi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-genshi}"
SRC_URI[aarch64_python3-genshi.sha256sum] = "03aa6f3590384e26b4f3df1f9a0a920d344dec8656e2a2876b90b00a1d246b19"

RDEPENDS:python3-genshi = " \
 glibc \
 python3 \
 "
