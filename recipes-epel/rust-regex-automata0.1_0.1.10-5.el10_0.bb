# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-regex-automata0.1"
PV = "0.1.10"
PR = "5.el10_0"
PACKAGES = " \
 rust-regex-automata0.1+default-devel \
 rust-regex-automata0.1+regex-syntax-devel \
 rust-regex-automata0.1+std-devel \
 rust-regex-automata0.1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-regex-automata0.1-0.1.10-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ddaf175688d469f94d2188cab1c412b3727af80153b2fc5319488fc6180c39d"

URI_x86_64_v2_rust-regex-automata0.1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata0.1+default-devel-0.1.10-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata0.1+default-devel}"
SRC_URI[x86_64_v2_rust-regex-automata0.1+default-devel.sha256sum] = "a99cf1e91e0b3f6a1701211aba24570741ceea0243c83e9b374b15cff5df009e"

URI_x86_64_v2_rust-regex-automata0.1+regex-syntax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata0.1+regex-syntax-devel-0.1.10-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata0.1+regex-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata0.1+regex-syntax-devel}"
SRC_URI[x86_64_v2_rust-regex-automata0.1+regex-syntax-devel.sha256sum] = "3d3d84c3f11595a089666b8448ec85d035f9f746dbe6d3d890f6122b966a226e"

URI_x86_64_v2_rust-regex-automata0.1+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata0.1+std-devel-0.1.10-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata0.1+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata0.1+std-devel}"
SRC_URI[x86_64_v2_rust-regex-automata0.1+std-devel.sha256sum] = "1ebf8d6e814329901af6f02e3b795079e75e26bcc24cad4959a1fcdd7d2cc5d4"

URI_x86_64_v2_rust-regex-automata0.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata0.1-devel-0.1.10-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata0.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata0.1-devel}"
SRC_URI[x86_64_v2_rust-regex-automata0.1-devel.sha256sum] = "fed41d0d01059e5c22df7f8297fd8fe47f63b157b2613edd478d2f91c852be21"

URI_aarch64_rust-regex-automata0.1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata0.1+default-devel-0.1.10-5.el10_0.noarch.rpm;name=aarch64_rust-regex-automata0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata0.1+default-devel}"
SRC_URI[aarch64_rust-regex-automata0.1+default-devel.sha256sum] = "6bcc63bd177cb44a00708adcdcdb7b309428190dd5d4730aace8e50058c25b79"

URI_aarch64_rust-regex-automata0.1+regex-syntax-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata0.1+regex-syntax-devel-0.1.10-5.el10_0.noarch.rpm;name=aarch64_rust-regex-automata0.1+regex-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata0.1+regex-syntax-devel}"
SRC_URI[aarch64_rust-regex-automata0.1+regex-syntax-devel.sha256sum] = "8c42c4f4c3d12102f732d480b6bb4afc6931cb21de656ae50becd30108648d9f"

URI_aarch64_rust-regex-automata0.1+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata0.1+std-devel-0.1.10-5.el10_0.noarch.rpm;name=aarch64_rust-regex-automata0.1+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata0.1+std-devel}"
SRC_URI[aarch64_rust-regex-automata0.1+std-devel.sha256sum] = "90a9ddad6a4b53fb7aae7dcb5d32dcd81ba30079964eeac69b73833d613ea877"

URI_aarch64_rust-regex-automata0.1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata0.1-devel-0.1.10-5.el10_0.noarch.rpm;name=aarch64_rust-regex-automata0.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata0.1-devel}"
SRC_URI[aarch64_rust-regex-automata0.1-devel.sha256sum] = "967c905a54f2090a6f5f46db1a69cc17a77b2849ebd811fe395acd605650bd47"

RDEPENDS:rust-regex-automata0.1+default-devel = " \
 cargo \
 rust-regex-automata0.1+std-devel \
 rust-regex-automata0.1-devel \
 "
RDEPENDS:rust-regex-automata0.1+regex-syntax-devel = " \
 cargo \
 rust-regex-automata0.1-devel \
 rust-regex-syntax0.6+default-devel \
 "
RDEPENDS:rust-regex-automata0.1+std-devel = " \
 cargo \
 rust-regex-automata0.1+regex-syntax-devel \
 rust-regex-automata0.1-devel \
 "
RDEPENDS:rust-regex-automata0.1-devel = " \
 cargo \
 "
