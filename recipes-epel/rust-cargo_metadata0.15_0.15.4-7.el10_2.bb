# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo_metadata0.15"
PV = "0.15.4"
PR = "7.el10_2"
PACKAGES = " \
 rust-cargo_metadata0.15+builder-devel \
 rust-cargo_metadata0.15+default-devel \
 rust-cargo_metadata0.15+derive_builder-devel \
 rust-cargo_metadata0.15-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo_metadata0.15-0.15.4-7.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d5e01590d50fdb4d99c5951db6592976551396fa5bcecce1c79b1a49fb3fd0f"

URI_x86_64_v2_rust-cargo_metadata0.15+builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata0.15+builder-devel-0.15.4-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata0.15+builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata0.15+builder-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata0.15+builder-devel.sha256sum] = "81fb1c2ec3cb8c0b13f87a93cfc3c706f3049bce006920f2e1caa96d8546b246"

URI_x86_64_v2_rust-cargo_metadata0.15+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata0.15+default-devel-0.15.4-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata0.15+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata0.15+default-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata0.15+default-devel.sha256sum] = "d251ae94f50caa92c114b5873219ef8623d287aa0c7155350aba966b9e0a82a1"

URI_x86_64_v2_rust-cargo_metadata0.15+derive_builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata0.15+derive_builder-devel-0.15.4-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata0.15+derive_builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata0.15+derive_builder-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata0.15+derive_builder-devel.sha256sum] = "66b33e82d6927bb3ed4b40a0be49c3c43b3cfc6639cd90c91173bcc472dab245"

URI_x86_64_v2_rust-cargo_metadata0.15-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata0.15-devel-0.15.4-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata0.15-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata0.15-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata0.15-devel.sha256sum] = "c164d3131052ca100efb2f1fd8f52b16919801e99523b199b1ec3ec4c6c95842"

URI_aarch64_rust-cargo_metadata0.15+builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata0.15+builder-devel-0.15.4-7.el10_2.noarch.rpm;name=aarch64_rust-cargo_metadata0.15+builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata0.15+builder-devel}"
SRC_URI[aarch64_rust-cargo_metadata0.15+builder-devel.sha256sum] = "14e8e384e8b588a05da81939b5d48e70ae19e635f2fd21c4e966ce16ee2e3043"

URI_aarch64_rust-cargo_metadata0.15+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata0.15+default-devel-0.15.4-7.el10_2.noarch.rpm;name=aarch64_rust-cargo_metadata0.15+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata0.15+default-devel}"
SRC_URI[aarch64_rust-cargo_metadata0.15+default-devel.sha256sum] = "522e99365d141f111fa1da32be1e6f33ce8a7f5dcdb47c9684707290405af45d"

URI_aarch64_rust-cargo_metadata0.15+derive_builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata0.15+derive_builder-devel-0.15.4-7.el10_2.noarch.rpm;name=aarch64_rust-cargo_metadata0.15+derive_builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata0.15+derive_builder-devel}"
SRC_URI[aarch64_rust-cargo_metadata0.15+derive_builder-devel.sha256sum] = "c70084c0245937bc2394e3c18d00f075d37986637ae377002c280dfa55f1918d"

URI_aarch64_rust-cargo_metadata0.15-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata0.15-devel-0.15.4-7.el10_2.noarch.rpm;name=aarch64_rust-cargo_metadata0.15-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata0.15-devel}"
SRC_URI[aarch64_rust-cargo_metadata0.15-devel.sha256sum] = "11bb29a8bddec482f82942f5bb3d81c0f4e71b9770f4a927c36488bb5ed51e21"

RDEPENDS:rust-cargo_metadata0.15+builder-devel = " \
 cargo \
 rust-cargo_metadata0.15+derive_builder-devel \
 rust-cargo_metadata0.15-devel \
 "
RDEPENDS:rust-cargo_metadata0.15+default-devel = " \
 cargo \
 rust-cargo_metadata0.15-devel \
 "
RDEPENDS:rust-cargo_metadata0.15+derive_builder-devel = " \
 cargo \
 rust-cargo_metadata0.15-devel \
 rust-derive_builder+default-devel \
 "
RDEPENDS:rust-cargo_metadata0.15-devel = " \
 cargo \
 rust \
 rust-camino+default-devel \
 rust-camino+serde1-devel \
 rust-cargo-platform0.1+default-devel \
 rust-semver+default-devel \
 rust-semver+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-serde_json+unbounded_depth-devel \
 rust-thiserror1+default-devel \
 "
