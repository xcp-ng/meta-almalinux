# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "java-latest-openjdk-portable"
PE = "1"
PV = "27.0.0.0.35"
PR = "0.0.ea.rolling.el8"
PACKAGES = " \
 java-latest-openjdk-portable \
 java-latest-openjdk-portable-devel \
 java-latest-openjdk-portable-devel-fastdebug \
 java-latest-openjdk-portable-devel-slowdebug \
 java-latest-openjdk-portable-docs \
 java-latest-openjdk-portable-fastdebug \
 java-latest-openjdk-portable-misc \
 java-latest-openjdk-portable-slowdebug \
 java-latest-openjdk-portable-sources \
 java-latest-openjdk-portable-static-libs \
 java-latest-openjdk-portable-static-libs-fastdebug \
 java-latest-openjdk-portable-static-libs-slowdebug \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/j/java-latest-openjdk-portable-27.0.0.0.35-0.0.ea.rolling.el8.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8f0832d9186b7192077e9b6502d7f06cb6cb96d8b22c70624567d2d6225eec89"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-27.0.0.0.35-0.0.ea.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-portable.sha256sum] = "58ca5b7cfc048b6b33216108e05d84738ba26d89c06a08bd2a70ac8c62ae10d4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-devel-27.0.0.0.35-0.0.ea.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-devel;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-devel.sha256sum] = "7bb2f62a8b65e7f0ea8b5a58f84009aa0335107030e9400dc64f821ff43c26f1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-devel-fastdebug-27.0.0.0.35-0.0.ea.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-devel-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-devel-fastdebug.sha256sum] = "fe670947792e8e5280cc55fa1abfde75233791c979450265984f658cc7639588"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-devel-slowdebug-27.0.0.0.35-0.0.ea.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-devel-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-devel-slowdebug.sha256sum] = "94288b67b8cee29eecfebbade3f6aae879f0da222833246adac86fb3f178a0bb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-docs-27.0.0.0.35-0.0.ea.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-docs;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-docs.sha256sum] = "95050cdf1537019dfe354d7b5ae749fe32f67f12e04c372c1108f700daa88103"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-fastdebug-27.0.0.0.35-0.0.ea.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-fastdebug.sha256sum] = "4d99596fc65deb91f45ae1bfdb6c71844a0d118253f509499a32609edfaa1e64"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-misc-27.0.0.0.35-0.0.ea.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-misc;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-misc.sha256sum] = "2e3016ac3ac54fb82b02d188ec3363eb1b78fdf211dcf27c289c482cbb2da427"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-slowdebug-27.0.0.0.35-0.0.ea.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-slowdebug.sha256sum] = "8f506ce8ab4203e3290c1b4945d81e0d0e3da1bc67fdd9b1ceb0110f14afac94"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-sources-27.0.0.0.35-0.0.ea.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-sources;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-sources.sha256sum] = "b35d252693de787603f3b696f42f5ce8d8878f7ab75c60f6499beed9d49626e5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-static-libs-27.0.0.0.35-0.0.ea.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-static-libs;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-static-libs.sha256sum] = "292a3069dfece1933fc7e4e5e15795449426825d2121d44592f3368e623c5dcf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-static-libs-fastdebug-27.0.0.0.35-0.0.ea.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-static-libs-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-static-libs-fastdebug.sha256sum] = "2e6ed4c76ff3508d592a261d01d505d42d50cf1593bd381806429b6f60017542"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-static-libs-slowdebug-27.0.0.0.35-0.0.ea.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-static-libs-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-static-libs-slowdebug.sha256sum] = "4e674fbeb84019ee5da5b420e750bab79336a4527c66b11d0200171e09d2bd14"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-27.0.0.0.35-0.0.ea.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-portable.sha256sum] = "258323fe9481576ce5e39aafd43e4a5054d60566977da3ae98e3d729c285acac"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-devel-27.0.0.0.35-0.0.ea.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-devel;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-portable-devel.sha256sum] = "4bc0f07692813d942ab3f047a8d211ac07a1fae459dbe27268320fd10e997210"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-devel-fastdebug-27.0.0.0.35-0.0.ea.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-devel-fastdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-portable-devel-fastdebug.sha256sum] = "621ee48487db3fa90a5f2679ef977639717a653aa0eb71ce19d8fa010cf5e573"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-devel-slowdebug-27.0.0.0.35-0.0.ea.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-devel-slowdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-portable-devel-slowdebug.sha256sum] = "119a7fd10b918fdcfd82167644be61f7f8acbbfd29652727a7e5f8f665070026"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-docs-27.0.0.0.35-0.0.ea.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-docs;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-portable-docs.sha256sum] = "963ace459f13c57fd555caa04d6cdccee0af3f1cb7e566366951a13ee2225f0a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-fastdebug-27.0.0.0.35-0.0.ea.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-fastdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-portable-fastdebug.sha256sum] = "90af215f2ec4ad6905de618e15986544c6b8de4e21443fa9b69f9b24b3559ac1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-misc-27.0.0.0.35-0.0.ea.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-misc;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-portable-misc.sha256sum] = "e67e871e278fc5a50fc8ac3aa14a96171291b8d12d634180d232c91edd57af71"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-slowdebug-27.0.0.0.35-0.0.ea.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-slowdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-portable-slowdebug.sha256sum] = "3bee75afc6eae21d048919570fc3d551f092f604aa2408bbfe79db61f4aee2ea"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-sources-27.0.0.0.35-0.0.ea.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-sources;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-portable-sources.sha256sum] = "08d31e5f0a23168791ad32c80714e5fd3effcca2e6ddf47dfb838fbaa136735e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-static-libs-27.0.0.0.35-0.0.ea.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-static-libs;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-portable-static-libs.sha256sum] = "33e82cbf7b5abaec2b71166f0d9e2048c676c403c6e553207c9681f6e17951a5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-static-libs-fastdebug-27.0.0.0.35-0.0.ea.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-static-libs-fastdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-portable-static-libs-fastdebug.sha256sum] = "4e156d626b9abf6d851e5d4a996df72998be2667ade4070efd6990dbc8a2fbd5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-static-libs-slowdebug-27.0.0.0.35-0.0.ea.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-static-libs-slowdebug;unpack=0"
SRC_URI[aarch64_java-latest-openjdk-portable-static-libs-slowdebug.sha256sum] = "2c8bb1f12e66cfeab7f50e92ab85b55a4c2486046c7522a5f3e12c5a7b7a34df"

RDEPENDS:java-latest-openjdk-portable = " \
 "
RDEPENDS:java-latest-openjdk-portable-devel = " \
 "
RDEPENDS:java-latest-openjdk-portable-devel-fastdebug = " \
 "
RDEPENDS:java-latest-openjdk-portable-devel-slowdebug = " \
 "
RDEPENDS:java-latest-openjdk-portable-docs = " \
 "
RDEPENDS:java-latest-openjdk-portable-fastdebug = " \
 "
RDEPENDS:java-latest-openjdk-portable-misc = " \
 "
RDEPENDS:java-latest-openjdk-portable-slowdebug = " \
 "
RDEPENDS:java-latest-openjdk-portable-sources = " \
 "
RDEPENDS:java-latest-openjdk-portable-static-libs = " \
 "
RDEPENDS:java-latest-openjdk-portable-static-libs-fastdebug = " \
 "
RDEPENDS:java-latest-openjdk-portable-static-libs-slowdebug = " \
 "
