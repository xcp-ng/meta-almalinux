# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "scorep"
PV = "9.4"
PR = "2.el10_3"
PACKAGES = " \
 scorep \
 scorep-config \
 scorep-doc \
 scorep-libs \
 scorep-mpich \
 scorep-mpich-config \
 scorep-mpich-libs \
 scorep-openmpi \
 scorep-openmpi-config \
 scorep-openmpi-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/scorep-9.4-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec2036503694ddfbbc0b2080d2ebdba43c2db785ccc96ab109d897cf4863aa57"

URI_x86_64_v2_scorep = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-9.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep}"
SRC_URI[x86_64_v2_scorep.sha256sum] = "7aeff38346d8758354035fa6a08829a7a6c0a90350ea7799220ddafd683e68d3"

URI_x86_64_v2_scorep-config = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-config-9.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-config}"
SRC_URI[x86_64_v2_scorep-config.sha256sum] = "c6df55fb51e943ba46f2608ddd214356f95bdeb382407f68c8f491c15cde5799"

URI_x86_64_v2_scorep-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-doc-9.4-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_scorep-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-doc}"
SRC_URI[x86_64_v2_scorep-doc.sha256sum] = "10e468c2fe7a731326a5fe7014ae4fc7705c4eda8a0dead1178cd310f93ca7f9"

URI_x86_64_v2_scorep-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-libs-9.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-libs}"
SRC_URI[x86_64_v2_scorep-libs.sha256sum] = "dd97963b6a492dd248330e99843c0aea69063f137710653840649f9a014e1711"

URI_x86_64_v2_scorep-mpich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-mpich-9.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-mpich}"
SRC_URI[x86_64_v2_scorep-mpich.sha256sum] = "e3083cb0680a5b53c25b00800bd68f071f9c9ff90cde500cbf83c013904e7d62"

URI_x86_64_v2_scorep-mpich-config = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-mpich-config-9.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep-mpich-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-mpich-config}"
SRC_URI[x86_64_v2_scorep-mpich-config.sha256sum] = "64e4ad3140f7e9a23cf442ca1f9e0d52c861f8cece38a1be41273d0eae8dc452"

URI_x86_64_v2_scorep-mpich-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-mpich-libs-9.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep-mpich-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-mpich-libs}"
SRC_URI[x86_64_v2_scorep-mpich-libs.sha256sum] = "17921d8f739c372dd2cc4cc9aad84f68932b0687536dcb694361e10187a01a89"

URI_x86_64_v2_scorep-openmpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-openmpi-9.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-openmpi}"
SRC_URI[x86_64_v2_scorep-openmpi.sha256sum] = "235cbb94ff2b529167a2744e82f6a312e532703f41aef10def77f23b5972fe1c"

URI_x86_64_v2_scorep-openmpi-config = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-openmpi-config-9.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep-openmpi-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-openmpi-config}"
SRC_URI[x86_64_v2_scorep-openmpi-config.sha256sum] = "fe10779f40e0d8e834e3d7a5068ad933d2e8b540221025f3e81a41e065e3a40f"

URI_x86_64_v2_scorep-openmpi-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-openmpi-libs-9.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep-openmpi-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-openmpi-libs}"
SRC_URI[x86_64_v2_scorep-openmpi-libs.sha256sum] = "dbef5622d21d8a65fef3038b2bd7218a9b9af9c5b1db684be65972605d454854"

URI_aarch64_scorep = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-9.4-2.el10_3.aarch64.rpm;name=aarch64_scorep;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep}"
SRC_URI[aarch64_scorep.sha256sum] = "ec8083361ed1e72a223b1c5744977c0ccd5c646bfbf004f3f3e65c55b48f94c8"

URI_aarch64_scorep-config = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-config-9.4-2.el10_3.aarch64.rpm;name=aarch64_scorep-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-config}"
SRC_URI[aarch64_scorep-config.sha256sum] = "ca72013314e67447492cc4754b7f317378e91362cc6f40411d1144703db09d0c"

URI_aarch64_scorep-doc = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-doc-9.4-2.el10_3.noarch.rpm;name=aarch64_scorep-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-doc}"
SRC_URI[aarch64_scorep-doc.sha256sum] = "3a01899a6bd367c1fca66487f9bbc84a1783f4d923b740668644db16032f06e0"

URI_aarch64_scorep-libs = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-libs-9.4-2.el10_3.aarch64.rpm;name=aarch64_scorep-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-libs}"
SRC_URI[aarch64_scorep-libs.sha256sum] = "048325fcf9ddc48ef153c60d0042f34bea4453fa3bb69bf0875c71ff2125a9c4"

URI_aarch64_scorep-mpich = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-mpich-9.4-2.el10_3.aarch64.rpm;name=aarch64_scorep-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-mpich}"
SRC_URI[aarch64_scorep-mpich.sha256sum] = "809d9f84d00258472abe610275097a1fcccd7f3172e394754e257ed0295788f2"

URI_aarch64_scorep-mpich-config = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-mpich-config-9.4-2.el10_3.aarch64.rpm;name=aarch64_scorep-mpich-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-mpich-config}"
SRC_URI[aarch64_scorep-mpich-config.sha256sum] = "3320d64e2f0703233cc2b04544f5ffda82ecb5a23f955e5724f8b2f8761e9b55"

URI_aarch64_scorep-mpich-libs = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-mpich-libs-9.4-2.el10_3.aarch64.rpm;name=aarch64_scorep-mpich-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-mpich-libs}"
SRC_URI[aarch64_scorep-mpich-libs.sha256sum] = "15d86f08a6ca6f2a8c563412cc7aa2cb1b06f6c43f85c43cc10a5ba84978fc4b"

URI_aarch64_scorep-openmpi = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-openmpi-9.4-2.el10_3.aarch64.rpm;name=aarch64_scorep-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-openmpi}"
SRC_URI[aarch64_scorep-openmpi.sha256sum] = "e5c089b6d38790984a4613cadfbb311128ec8beaedf2c5212d9f89ede66b81d2"

URI_aarch64_scorep-openmpi-config = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-openmpi-config-9.4-2.el10_3.aarch64.rpm;name=aarch64_scorep-openmpi-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-openmpi-config}"
SRC_URI[aarch64_scorep-openmpi-config.sha256sum] = "9a900baac08874d066fbbec0a5f7bf70230ffbeb938578600803011e2ee7ab66"

URI_aarch64_scorep-openmpi-libs = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-openmpi-libs-9.4-2.el10_3.aarch64.rpm;name=aarch64_scorep-openmpi-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-openmpi-libs}"
SRC_URI[aarch64_scorep-openmpi-libs.sha256sum] = "53aa3f6d382b5684ea4f641184b93fec023e0b850769023d95c46b301729d122"

RDEPENDS:scorep:x86_64_v2 = " \
 bash \
 binutils-devel \
 clang-libs \
 cube-libs \
 cube-libs-devel \
 glibc \
 gotcha-devel \
 libgcc \
 libstdc++ \
 libunwind-devel \
 ocl-icd-devel \
 opari2 \
 otf2-devel \
 papi-devel \
 scorep-libs \
"
RDEPENDS:scorep:aarch64 = " \
 bash \
 binutils-devel \
 cube-libs \
 cube-libs-devel \
 glibc \
 gotcha-devel \
 libgcc \
 libstdc++ \
 libunwind-devel \
 ocl-icd-devel \
 opari2 \
 otf2-devel \
 papi-devel \
 scorep-libs \
 virtual/libclang.so.21.1_LLVM_13__64bit_ \
 virtual/libclang.so.21.1___64bit_ \
"
RDEPENDS:scorep-config = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:scorep-doc = " \
 "
RDEPENDS:scorep-libs = " \
 scorep-config \
 "
RDEPENDS:scorep-mpich = " \
 bash \
 cube-libs \
 cube-libs-devel \
 glibc \
 libgcc \
 libstdc++ \
 otf2-devel \
 papi-devel \
 scorep-mpich-libs \
 "
RDEPENDS:scorep-mpich-config = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:scorep-mpich-libs = " \
 scorep-mpich-config \
 "
RDEPENDS:scorep-openmpi = " \
 bash \
 cube-libs \
 cube-libs-devel \
 glibc \
 libgcc \
 libstdc++ \
 otf2-devel \
 papi-devel \
 scorep-openmpi-libs \
 "
RDEPENDS:scorep-openmpi-config = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:scorep-openmpi-libs = " \
 scorep-openmpi-config \
 "
