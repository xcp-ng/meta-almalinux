# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sblim-cmpi-base"
PV = "1.6.4"
PR = "29.el10"
PACKAGES = " \
 sblim-cmpi-base \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/sblim-cmpi-base-1.6.4-29.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9a6ded2ebb68cb3ec8bc2a8ccc03f71e4d62e6071f193293fb53a8f42425f2ad"

URI_x86_64_v2_sblim-cmpi-base = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sblim-cmpi-base-1.6.4-29.el10.x86_64_v2.rpm;name=x86_64_v2_sblim-cmpi-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sblim-cmpi-base}"
SRC_URI[x86_64_v2_sblim-cmpi-base.sha256sum] = "b6eecae46d3048f60b24b8764f53a962281c0f123aa3faf359feec5e63bd0996"

URI_aarch64_sblim-cmpi-base = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sblim-cmpi-base-1.6.4-29.el10.aarch64.rpm;name=aarch64_sblim-cmpi-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_sblim-cmpi-base}"
SRC_URI[aarch64_sblim-cmpi-base.sha256sum] = "cc3518b802da287861d49e2fcfe8285c6ac04586e1390c004e35de6f34b4a4b1"

RDEPENDS:sblim-cmpi-base = " \
 bash \
 glibc \
 sblim-indication_helper \
 virtual/cim-server \
 "
