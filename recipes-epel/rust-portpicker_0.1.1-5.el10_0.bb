# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-portpicker"
PV = "0.1.1"
PR = "5.el10_0"
PACKAGES = " \
 rust-portpicker+default-devel \
 rust-portpicker-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-portpicker-0.1.1-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8209d32e3c4f37f6d82cc3ce6ec4b58f1ac4207fb3a6d4ec6de078d17433f934"

URI_x86_64_v2_rust-portpicker+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portpicker+default-devel-0.1.1-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portpicker+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portpicker+default-devel}"
SRC_URI[x86_64_v2_rust-portpicker+default-devel.sha256sum] = "e83054e5111e99aac3aaa763bbd1ad8da95d754fdce0e3889979ca63e53eb5c2"

URI_x86_64_v2_rust-portpicker-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portpicker-devel-0.1.1-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portpicker-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portpicker-devel}"
SRC_URI[x86_64_v2_rust-portpicker-devel.sha256sum] = "03d7b9ea1fc9ea6677a32c1744b84ba11fba75990116dcf76afe68b2e12468c2"

URI_aarch64_rust-portpicker+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portpicker+default-devel-0.1.1-5.el10_0.noarch.rpm;name=aarch64_rust-portpicker+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portpicker+default-devel}"
SRC_URI[aarch64_rust-portpicker+default-devel.sha256sum] = "bfbfc643415a61a5cc9c28eca8cd1c864fed09622b6ce61921f350a3b15cdc99"

URI_aarch64_rust-portpicker-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portpicker-devel-0.1.1-5.el10_0.noarch.rpm;name=aarch64_rust-portpicker-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portpicker-devel}"
SRC_URI[aarch64_rust-portpicker-devel.sha256sum] = "180ea806571d7f1d4e53de4dbd694e0b0a1194a997a18c3ce1fd194d5075ee21"

RDEPENDS:rust-portpicker+default-devel = " \
 cargo \
 rust-portpicker-devel \
 "
RDEPENDS:rust-portpicker-devel = " \
 cargo \
 rust-rand0.8+default-devel \
 "
