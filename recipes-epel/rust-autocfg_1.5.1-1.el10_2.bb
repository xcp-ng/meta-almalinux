# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-autocfg"
PV = "1.5.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-autocfg+default-devel \
 rust-autocfg-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-autocfg-1.5.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "178d2fcdb671955aac3d5c0de3e5e935af016e57ef02654b9d2a4fe4757e73e0"

URI_x86_64_v2_rust-autocfg+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-autocfg+default-devel-1.5.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-autocfg+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-autocfg+default-devel}"
SRC_URI[x86_64_v2_rust-autocfg+default-devel.sha256sum] = "541d030e5add0279e5812e912b9dfbff156b8684f5c2c7a1cf246d570005d109"

URI_x86_64_v2_rust-autocfg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-autocfg-devel-1.5.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-autocfg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-autocfg-devel}"
SRC_URI[x86_64_v2_rust-autocfg-devel.sha256sum] = "8ff414a91056b59bad46590571b5e30f7a77585682e5234aaefe705a8ad8b047"

URI_aarch64_rust-autocfg+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-autocfg+default-devel-1.5.1-1.el10_2.noarch.rpm;name=aarch64_rust-autocfg+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-autocfg+default-devel}"
SRC_URI[aarch64_rust-autocfg+default-devel.sha256sum] = "2b1ece4d08db9a75ece056bad9f9d67fb7562505430fb99ab20bb7e43ad032dd"

URI_aarch64_rust-autocfg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-autocfg-devel-1.5.1-1.el10_2.noarch.rpm;name=aarch64_rust-autocfg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-autocfg-devel}"
SRC_URI[aarch64_rust-autocfg-devel.sha256sum] = "cdccd13812c9787300558b87ffffacfd140e962adb4894e459f45bb13767233a"

RDEPENDS:rust-autocfg+default-devel = " \
 cargo \
 rust-autocfg-devel \
 "
RDEPENDS:rust-autocfg-devel = " \
 cargo \
 rust \
 "
