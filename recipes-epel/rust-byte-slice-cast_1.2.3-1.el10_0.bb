# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-byte-slice-cast"
PV = "1.2.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-byte-slice-cast+default-devel \
 rust-byte-slice-cast+std-devel \
 rust-byte-slice-cast-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-byte-slice-cast-1.2.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7d894af8e7ed08adabe2857b0e1a2fa91d2933a8e314b7c0ce828af80bf7813e"

URI_x86_64_v2_rust-byte-slice-cast+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-slice-cast+default-devel-1.2.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-slice-cast+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-slice-cast+default-devel}"
SRC_URI[x86_64_v2_rust-byte-slice-cast+default-devel.sha256sum] = "a77d3e1f91513b635bf07c88212d9232d20178be586c351e052885f6b87ec8f0"

URI_x86_64_v2_rust-byte-slice-cast+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-slice-cast+std-devel-1.2.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-slice-cast+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-slice-cast+std-devel}"
SRC_URI[x86_64_v2_rust-byte-slice-cast+std-devel.sha256sum] = "e14bac85f209b8d771e1d58ec75c2ba4f7a4cad796dae96782ed15f00301cb33"

URI_x86_64_v2_rust-byte-slice-cast-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-slice-cast-devel-1.2.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-slice-cast-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-slice-cast-devel}"
SRC_URI[x86_64_v2_rust-byte-slice-cast-devel.sha256sum] = "dda1a9584a9e4670439beec012ee6d3586c8f8166c05d320c7bf7e32289efe20"

URI_aarch64_rust-byte-slice-cast+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-slice-cast+default-devel-1.2.3-1.el10_0.noarch.rpm;name=aarch64_rust-byte-slice-cast+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-slice-cast+default-devel}"
SRC_URI[aarch64_rust-byte-slice-cast+default-devel.sha256sum] = "a6c2834e98fb2eee722256fb5b54b5ab6ef21cad06ac2d65e08135513fd2a5e3"

URI_aarch64_rust-byte-slice-cast+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-slice-cast+std-devel-1.2.3-1.el10_0.noarch.rpm;name=aarch64_rust-byte-slice-cast+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-slice-cast+std-devel}"
SRC_URI[aarch64_rust-byte-slice-cast+std-devel.sha256sum] = "09de73675116cdecac164cc869207fc91523e190e938eefd2d09640f3b252924"

URI_aarch64_rust-byte-slice-cast-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-slice-cast-devel-1.2.3-1.el10_0.noarch.rpm;name=aarch64_rust-byte-slice-cast-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-slice-cast-devel}"
SRC_URI[aarch64_rust-byte-slice-cast-devel.sha256sum] = "0d1271de3c449d5e4d69a4bce41117e1d9517842c5d68bddbc3734defa84ab54"

RDEPENDS:rust-byte-slice-cast+default-devel = " \
 cargo \
 rust-byte-slice-cast+std-devel \
 rust-byte-slice-cast-devel \
 "
RDEPENDS:rust-byte-slice-cast+std-devel = " \
 cargo \
 rust-byte-slice-cast-devel \
 "
RDEPENDS:rust-byte-slice-cast-devel = " \
 cargo \
 rust \
 "
