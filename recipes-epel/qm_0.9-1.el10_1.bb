# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qm"
PV = "0.9"
PR = "1.el10_1"
PACKAGES = " \
 qm \
 qm-ctl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qm-0.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "738a4fbfffd9eec7e2736711c727be21df34093202c3cf0b4ba8e090b36f5ee9"

URI_x86_64_v2_qm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qm-0.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qm}"
SRC_URI[x86_64_v2_qm.sha256sum] = "61dea19289687381ab50aecc6760c67f70a8ef9ba48b85c60b8064f9b87026a6"

URI_x86_64_v2_qm-ctl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qm-ctl-0.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qm-ctl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qm-ctl}"
SRC_URI[x86_64_v2_qm-ctl.sha256sum] = "06eaf12c6ce2f77675b6f39b40b67a955ebd4ded302a3cf92db6ccf5fdf8f400"

URI_aarch64_qm = "${EPEL_MIRROR}/aarch64/Packages/q/qm-0.9-1.el10_1.noarch.rpm;name=aarch64_qm;unpack=0"
SRC_URI:append = " ${URI_aarch64_qm}"
SRC_URI[aarch64_qm.sha256sum] = "f77d6655347c1ddbd8aed9e033170561c6e3c088ca197539898081774aa031c2"

URI_aarch64_qm-ctl = "${EPEL_MIRROR}/aarch64/Packages/q/qm-ctl-0.9-1.el10_1.noarch.rpm;name=aarch64_qm-ctl;unpack=0"
SRC_URI:append = " ${URI_aarch64_qm-ctl}"
SRC_URI[aarch64_qm-ctl.sha256sum] = "730efe7252584ca70866a33a12a688996b92b660aad9dd18661508e2a2de6385"

RDEPENDS:qm:x86_64_v2 = " \
 bash \
 containers-common \
 jq \
 libselinux-utils \
 parted \
 podman \
 policycoreutils \
 selinux-policy \
 virtual/selinux-policy-any_ge_42.1.2 \
"
RDEPENDS:qm:aarch64 = " \
 bash \
 containers-common \
 jq \
 libselinux-utils \
 parted \
 podman \
 policycoreutils \
 selinux-policy \
 virtual/selinux-policy-any_ge_42.1.3 \
"
RDEPENDS:qm-ctl = " \
 python3 \
 qm \
 "
