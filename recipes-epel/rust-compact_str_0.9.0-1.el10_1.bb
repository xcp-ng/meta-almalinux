# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-compact_str"
PV = "0.9.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-compact_str+arbitrary-devel \
 rust-compact_str+bytes-devel \
 rust-compact_str+default-devel \
 rust-compact_str+proptest-devel \
 rust-compact_str+quickcheck-devel \
 rust-compact_str+rkyv-devel \
 rust-compact_str+serde-devel \
 rust-compact_str+smallvec-devel \
 rust-compact_str+std-devel \
 rust-compact_str+zeroize-devel \
 rust-compact_str-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-compact_str-0.9.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af22d7149ca002f77fcd4d4422a45ff79f61f6d401ea1919abcbe855284fb067"

URI_x86_64_v2_rust-compact_str+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+arbitrary-devel-0.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-compact_str+arbitrary-devel.sha256sum] = "cf0bfa49d0debcef4ddc19cff7df6bd4fea5f9ea8319ab8be2a59b0b62981a58"

URI_x86_64_v2_rust-compact_str+bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+bytes-devel-0.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+bytes-devel}"
SRC_URI[x86_64_v2_rust-compact_str+bytes-devel.sha256sum] = "1ef3f6436f017e08b957607f1dd078b054f75a87abacd74aef29a89ca82d03fa"

URI_x86_64_v2_rust-compact_str+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+default-devel-0.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+default-devel}"
SRC_URI[x86_64_v2_rust-compact_str+default-devel.sha256sum] = "bd4a2569d1e0a3e52cd4d7d704762a668712997e50365beb747e9599d28fab06"

URI_x86_64_v2_rust-compact_str+proptest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+proptest-devel-0.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+proptest-devel}"
SRC_URI[x86_64_v2_rust-compact_str+proptest-devel.sha256sum] = "ff71f09ab7d3de441716068af40b092360acbc0d3af41ff97a5a727ca4140851"

URI_x86_64_v2_rust-compact_str+quickcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+quickcheck-devel-0.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+quickcheck-devel}"
SRC_URI[x86_64_v2_rust-compact_str+quickcheck-devel.sha256sum] = "828bc69d5480c3528ae358143ee73c532cc192b2f34bba5437327be155002b63"

URI_x86_64_v2_rust-compact_str+rkyv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+rkyv-devel-0.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+rkyv-devel}"
SRC_URI[x86_64_v2_rust-compact_str+rkyv-devel.sha256sum] = "1ba108730630f6b675e9189baf09b35f58cde0363509123a2dffef41b7202cc2"

URI_x86_64_v2_rust-compact_str+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+serde-devel-0.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+serde-devel}"
SRC_URI[x86_64_v2_rust-compact_str+serde-devel.sha256sum] = "73b08ccad46b0fd25cabf951422be568df800c1d2083a624b50d6a4dc76cc0e8"

URI_x86_64_v2_rust-compact_str+smallvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+smallvec-devel-0.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+smallvec-devel}"
SRC_URI[x86_64_v2_rust-compact_str+smallvec-devel.sha256sum] = "2800cd9e9f603698beb3f0151d880243db765a8f0c7edd572533964912f3c8de"

URI_x86_64_v2_rust-compact_str+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+std-devel-0.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+std-devel}"
SRC_URI[x86_64_v2_rust-compact_str+std-devel.sha256sum] = "880dd4ea6bca528395ac32027b4dda1ceaa03f7b5f31adf30771e285dc80ab8e"

URI_x86_64_v2_rust-compact_str+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+zeroize-devel-0.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+zeroize-devel}"
SRC_URI[x86_64_v2_rust-compact_str+zeroize-devel.sha256sum] = "86e7db273fa5c9cd60834f06089ee74d5737777889ed02b611a76d21bf9557d8"

URI_x86_64_v2_rust-compact_str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str-devel-0.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str-devel}"
SRC_URI[x86_64_v2_rust-compact_str-devel.sha256sum] = "83807dcc18c68f7e8ddd81a6cfa0657d4347e79d5b1b76def2ea2c717b00f5a2"

URI_aarch64_rust-compact_str+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+arbitrary-devel-0.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-compact_str+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+arbitrary-devel}"
SRC_URI[aarch64_rust-compact_str+arbitrary-devel.sha256sum] = "1859fa62c338ab773ed015d657f32b406266fa94d2b13f10a21e1dba3deeef11"

URI_aarch64_rust-compact_str+bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+bytes-devel-0.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-compact_str+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+bytes-devel}"
SRC_URI[aarch64_rust-compact_str+bytes-devel.sha256sum] = "414cd387bbca77f51f39e46e11ea88803cb4286ae2f3b0bafbee374fd0bb64c6"

URI_aarch64_rust-compact_str+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+default-devel-0.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-compact_str+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+default-devel}"
SRC_URI[aarch64_rust-compact_str+default-devel.sha256sum] = "93a0426097661467bfd16c9c420fb1c0d850e2d2412422d0b0a22ea7853e820d"

URI_aarch64_rust-compact_str+proptest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+proptest-devel-0.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-compact_str+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+proptest-devel}"
SRC_URI[aarch64_rust-compact_str+proptest-devel.sha256sum] = "622d242cb54b247460e051b5056441fd6bd76422e21eef613b28cb09399350b1"

URI_aarch64_rust-compact_str+quickcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+quickcheck-devel-0.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-compact_str+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+quickcheck-devel}"
SRC_URI[aarch64_rust-compact_str+quickcheck-devel.sha256sum] = "2cdc97a00a2d41807cfd4905abb1ff5f6812babc2c3d054c20708a7b0dbf31ca"

URI_aarch64_rust-compact_str+rkyv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+rkyv-devel-0.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-compact_str+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+rkyv-devel}"
SRC_URI[aarch64_rust-compact_str+rkyv-devel.sha256sum] = "da69c57bb3e4a0c8a3ab503c670868c6e60654a9bfb55a9f21745d4b62b77d74"

URI_aarch64_rust-compact_str+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+serde-devel-0.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-compact_str+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+serde-devel}"
SRC_URI[aarch64_rust-compact_str+serde-devel.sha256sum] = "ff61dfe1a45ae690afae59d2b2e49f555409fefd905e5171700208cfb04a22d0"

URI_aarch64_rust-compact_str+smallvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+smallvec-devel-0.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-compact_str+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+smallvec-devel}"
SRC_URI[aarch64_rust-compact_str+smallvec-devel.sha256sum] = "c2c509a820a5e1bdfbf3ae67ec28f6f73c8842c51cc6308f2fbd4a2cb4c77303"

URI_aarch64_rust-compact_str+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+std-devel-0.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-compact_str+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+std-devel}"
SRC_URI[aarch64_rust-compact_str+std-devel.sha256sum] = "5c86b9e863f9ff9d9c6b525334ded78968ba4f7447bf357ba1a231463e001972"

URI_aarch64_rust-compact_str+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+zeroize-devel-0.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-compact_str+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+zeroize-devel}"
SRC_URI[aarch64_rust-compact_str+zeroize-devel.sha256sum] = "706a9f608de858f93033c98ba9cd7b7e2250377db898155965d02fa43a8965dd"

URI_aarch64_rust-compact_str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str-devel-0.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-compact_str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str-devel}"
SRC_URI[aarch64_rust-compact_str-devel.sha256sum] = "7b95627226976d90aa79a1bef92c51973c583d4fce913a6202d3f6928079fbd5"

RDEPENDS:rust-compact_str+arbitrary-devel = " \
 cargo \
 rust-arbitrary-devel \
 rust-compact_str-devel \
 "
RDEPENDS:rust-compact_str+bytes-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-compact_str-devel \
 "
RDEPENDS:rust-compact_str+default-devel = " \
 cargo \
 rust-compact_str+std-devel \
 rust-compact_str-devel \
 "
RDEPENDS:rust-compact_str+proptest-devel = " \
 cargo \
 rust-compact_str-devel \
 rust-proptest+std-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-compact_str+quickcheck-devel = " \
 cargo \
 rust-compact_str-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-compact_str+rkyv-devel = " \
 cargo \
 rust-compact_str-devel \
 rust-rkyv-devel \
 "
RDEPENDS:rust-compact_str+serde-devel = " \
 cargo \
 rust-compact_str-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-compact_str+smallvec-devel = " \
 cargo \
 rust-compact_str-devel \
 rust-smallvec+default-devel \
 rust-smallvec+union-devel \
 "
RDEPENDS:rust-compact_str+std-devel = " \
 cargo \
 rust-compact_str-devel \
 "
RDEPENDS:rust-compact_str+zeroize-devel = " \
 cargo \
 rust-compact_str-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-compact_str-devel = " \
 cargo \
 rust-castaway+alloc-devel \
 rust-castaway-devel \
 rust-cfg-if+default-devel \
 rust-itoa+default-devel \
 rust-rustversion+default-devel \
 rust-ryu+default-devel \
 rust-static_assertions+default-devel \
 "
