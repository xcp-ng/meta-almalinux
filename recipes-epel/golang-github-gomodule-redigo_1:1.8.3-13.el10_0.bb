# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-gomodule-redigo"
PE = "1"
PV = "1.8.3"
PR = "13.el10_0"
PACKAGES = " \
 compat-golang-github-garyburd-redigo-devel \
 golang-github-gomodule-redigo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-gomodule-redigo-1.8.3-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19d35ac9e0baaccdce160b316520d8d139aac6127f5e99d1bc0e07f65d79369f"

URI_x86_64_v2_compat-golang-github-garyburd-redigo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/compat-golang-github-garyburd-redigo-devel-1.8.3-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_compat-golang-github-garyburd-redigo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_compat-golang-github-garyburd-redigo-devel}"
SRC_URI[x86_64_v2_compat-golang-github-garyburd-redigo-devel.sha256sum] = "0bddb8715256065072d6bae1f2840d2738e8d449aaf86a193d84f5d4373697c8"

URI_x86_64_v2_golang-github-gomodule-redigo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-gomodule-redigo-devel-1.8.3-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-gomodule-redigo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-gomodule-redigo-devel}"
SRC_URI[x86_64_v2_golang-github-gomodule-redigo-devel.sha256sum] = "468c71693cea70e4823ac65f8d174cfc4b47a9851e61c1021f844e012b1ca3d5"

URI_aarch64_compat-golang-github-garyburd-redigo-devel = "${EPEL_MIRROR}/aarch64/Packages/c/compat-golang-github-garyburd-redigo-devel-1.8.3-13.el10_0.noarch.rpm;name=aarch64_compat-golang-github-garyburd-redigo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_compat-golang-github-garyburd-redigo-devel}"
SRC_URI[aarch64_compat-golang-github-garyburd-redigo-devel.sha256sum] = "bdd6a002fe694bc431c0f9ce6af669e7313599b3491754dcba82befc2208d941"

URI_aarch64_golang-github-gomodule-redigo-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-gomodule-redigo-devel-1.8.3-13.el10_0.noarch.rpm;name=aarch64_golang-github-gomodule-redigo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-gomodule-redigo-devel}"
SRC_URI[aarch64_golang-github-gomodule-redigo-devel.sha256sum] = "5e816cfaa5a9f56d51f1140bd2a1506bbf014c1a9dba22d7b94dc91370c3107b"

RDEPENDS:compat-golang-github-garyburd-redigo-devel = " \
 go-filesystem \
 golang-github-gomodule-redigo-devel \
 "
RDEPENDS:golang-github-gomodule-redigo-devel = " \
 go-filesystem \
 "
