# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-threadweaver"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-threadweaver \
 kf6-threadweaver-devel \
 kf6-threadweaver-doc \
 kf6-threadweaver-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-threadweaver-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a7995c0307153cce1f9bdd6f9d64d31b65c3b34b1eddc0279d71a93048f868d"

URI_x86_64_v2_kf6-threadweaver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-threadweaver-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-threadweaver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-threadweaver}"
SRC_URI[x86_64_v2_kf6-threadweaver.sha256sum] = "f4588d564b39b1d965f2fa5c89eb40f09410f53d3b9fad962ec430e7a80b33e8"

URI_x86_64_v2_kf6-threadweaver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-threadweaver-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-threadweaver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-threadweaver-devel}"
SRC_URI[x86_64_v2_kf6-threadweaver-devel.sha256sum] = "15bbfcf11c8ca5f08c776d727ccee476c6e58d22d8adcdf19e9e785e8212ab39"

URI_x86_64_v2_kf6-threadweaver-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-threadweaver-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-threadweaver-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-threadweaver-doc}"
SRC_URI[x86_64_v2_kf6-threadweaver-doc.sha256sum] = "75fd79cb36a02057f284c31b2fb1da2489ca09065a6190063795c0f15286b4e6"

URI_x86_64_v2_kf6-threadweaver-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-threadweaver-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-threadweaver-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-threadweaver-html}"
SRC_URI[x86_64_v2_kf6-threadweaver-html.sha256sum] = "1e1d3306758387733fa45e6860c3044dbee35be04bcf5d5a87a1e122aa2a9f19"

URI_aarch64_kf6-threadweaver = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-threadweaver-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-threadweaver;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-threadweaver}"
SRC_URI[aarch64_kf6-threadweaver.sha256sum] = "f10fc0663f0c83570437f588d2ac3f9643c8bafe40128f7abf509e9342875222"

URI_aarch64_kf6-threadweaver-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-threadweaver-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-threadweaver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-threadweaver-devel}"
SRC_URI[aarch64_kf6-threadweaver-devel.sha256sum] = "6db2d142029268e452bdd28adc76a2fb1565ab526aa10db8e645a91d3beb7cc6"

URI_aarch64_kf6-threadweaver-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-threadweaver-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-threadweaver-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-threadweaver-doc}"
SRC_URI[aarch64_kf6-threadweaver-doc.sha256sum] = "f482acd5e1ccc8526c7a6b08e9f54d41b160bb4dba662a0a8687e3d18d6cb875"

URI_aarch64_kf6-threadweaver-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-threadweaver-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-threadweaver-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-threadweaver-html}"
SRC_URI[aarch64_kf6-threadweaver-html.sha256sum] = "eca0b708793a7867ace03bcf2ffa06fb556d8026fef2e5ccb8d7d243b61f7240"

RDEPENDS:kf6-threadweaver = " \
 glibc \
 kf6-filesystem \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-threadweaver-devel = " \
 cmake-filesystem \
 kf6-threadweaver \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-threadweaver-doc = " \
 "
RDEPENDS:kf6-threadweaver-html = " \
 "
