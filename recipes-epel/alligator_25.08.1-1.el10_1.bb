# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "alligator"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 alligator \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/alligator-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "58d4de2c9f2d2bc672f38bdd9d0301911f99b4afd75c4e8ac962585fd9f37293"

URI_x86_64_v2_alligator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/alligator-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_alligator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_alligator}"
SRC_URI[x86_64_v2_alligator.sha256sum] = "e9c162ee0442893a2e0792ce02fe4fbce72e0f86b33041a6e96ca1612a7c8f51"

URI_aarch64_alligator = "${EPEL_MIRROR}/aarch64/Packages/a/alligator-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_alligator;unpack=0"
SRC_URI:append = " ${URI_aarch64_alligator}"
SRC_URI[aarch64_alligator.sha256sum] = "a3a541fb1edb7412dc5013dcbf7a123082dc8c51baf3928ab8f5b3523032244e"

RDEPENDS:alligator = " \
 glibc \
 hicolor-icon-theme \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-syndication \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
