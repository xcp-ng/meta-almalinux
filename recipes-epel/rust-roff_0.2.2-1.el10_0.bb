# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-roff"
PV = "0.2.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-roff+default-devel \
 rust-roff-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-roff-0.2.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e2a44376d86f5a13732954dac88679f5d4ecc36b865f39f09928e5b3672e716"

URI_x86_64_v2_rust-roff+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-roff+default-devel-0.2.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-roff+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-roff+default-devel}"
SRC_URI[x86_64_v2_rust-roff+default-devel.sha256sum] = "44301eb56757bebc1a313632bb8d77cd764713dfdc2d61fb0f2de6ebefa93e14"

URI_x86_64_v2_rust-roff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-roff-devel-0.2.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-roff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-roff-devel}"
SRC_URI[x86_64_v2_rust-roff-devel.sha256sum] = "ebf7e38a31c0675283811bb3d510ddacd34a02eb6a6f1f39f5bd065042d7a908"

URI_aarch64_rust-roff+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-roff+default-devel-0.2.2-1.el10_0.noarch.rpm;name=aarch64_rust-roff+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-roff+default-devel}"
SRC_URI[aarch64_rust-roff+default-devel.sha256sum] = "e8a9857b4ba324756f6a05b149035dc13918b8eba438ec5a2200a5258ad5bff5"

URI_aarch64_rust-roff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-roff-devel-0.2.2-1.el10_0.noarch.rpm;name=aarch64_rust-roff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-roff-devel}"
SRC_URI[aarch64_rust-roff-devel.sha256sum] = "0d05f727724a91b1418f50e7fd9e5b5075aae7b33ad8aaa6eec38b870594f178"

RDEPENDS:rust-roff+default-devel = " \
 cargo \
 rust-roff-devel \
 "
RDEPENDS:rust-roff-devel = " \
 cargo \
 rust \
 "
