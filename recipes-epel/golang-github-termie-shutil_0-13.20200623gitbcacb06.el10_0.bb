# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-termie-shutil"
PV = "0"
PR = "13.20200623gitbcacb06.el10_0"
PACKAGES = " \
 golang-github-termie-shutil-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-termie-shutil-0-13.20200623gitbcacb06.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2ade8bd04a55804636e9a7b056e1662fc3959e51fb416a158dbc16577e0471eb"

URI_aarch64_golang-github-termie-shutil-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-termie-shutil-devel-0-13.20200623gitbcacb06.el10_0.noarch.rpm;name=aarch64_golang-github-termie-shutil-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-termie-shutil-devel}"
SRC_URI[aarch64_golang-github-termie-shutil-devel.sha256sum] = "5fafc4f70c6f848a6408318d85fdb830909d149e5a70c174ee4edf2143abb22c"

RDEPENDS:golang-github-termie-shutil-devel = " \
 go-filesystem \
 "
