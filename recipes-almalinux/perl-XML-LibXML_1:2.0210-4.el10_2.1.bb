# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-XML-LibXML"
PE = "1"
PV = "2.0210"
PR = "4.el10_2.1"
PACKAGES = " \
 perl-XML-LibXML \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-XML-LibXML-2.0210-4.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e174f07c5da723004952a8e11a518da78130f25bd553316a2d20610e240c89fd"

URI_x86_64_v2_perl-XML-LibXML = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-XML-LibXML-2.0210-4.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_perl-XML-LibXML;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XML-LibXML}"
SRC_URI[x86_64_v2_perl-XML-LibXML.sha256sum] = "2fdf8956a0f66725af8180de7186359cf3b1416d5e1bb5d82558ef83fd18acf1"

URI_aarch64_perl-XML-LibXML = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-XML-LibXML-2.0210-4.el10_2.1.aarch64.rpm;name=aarch64_perl-XML-LibXML;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XML-LibXML}"
SRC_URI[aarch64_perl-XML-LibXML.sha256sum] = "2cd951a69c636c1714155553977011fd2df00b96a544a4bd9f3588076393d912"

RDEPENDS:perl-XML-LibXML = " \
 bash \
 glibc \
 libxml2 \
 perl-Carp \
 perl-Data-Dumper \
 perl-Encode \
 perl-Exporter \
 perl-IO \
 perl-Scalar-List-Utils \
 perl-XML-LibXML \
 perl-XML-NamespaceSupport \
 perl-XML-SAX \
 perl-XML-SAX-Base \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-overload \
 perl-parent \
 perl-vars \
 "
