# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocm-smi"
PV = "7.2.1"
PR = "2.el10_3"
PACKAGES:x86_64_v2 = " \
 rocm-smi \
 rocm-smi-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocm-smi-7.2.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c545699f32a5f2aef390e3544f49467abb2217b3c1c9305b1bc30cc004d35f1f"

URI_x86_64_v2_rocm-smi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-smi-7.2.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-smi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-smi}"
SRC_URI[x86_64_v2_rocm-smi.sha256sum] = "e01a88774e5e2d3faaa7e547ce7ee07e3127fdb48b28959af33a02c2569ac3c4"

URI_x86_64_v2_rocm-smi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-smi-devel-7.2.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-smi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-smi-devel}"
SRC_URI[x86_64_v2_rocm-smi-devel.sha256sum] = "0a7b4c0cf5eec5ddd952d91b7a8e43986bcf3ec06a0422a4c8dc27cf3d1bd5fa"

RDEPENDS:rocm-smi = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
RDEPENDS:rocm-smi-devel = " \
 cmake-filesystem \
 libdrm-devel \
 rocm-smi \
 "
