# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fontawesome4-fonts"
PE = "1"
PV = "4.7.0"
PR = "24.el10_2"
PACKAGES = " \
 fontawesome4-fonts \
 fontawesome4-fonts-web \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/fontawesome4-fonts-4.7.0-24.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca4d5fc0f5f23eda6c9413ca056b17382922a89d17d547fd54c71b69ff4c661d"

URI_x86_64_v2_fontawesome4-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fontawesome4-fonts-4.7.0-24.el10_2.noarch.rpm;name=x86_64_v2_fontawesome4-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fontawesome4-fonts}"
SRC_URI[x86_64_v2_fontawesome4-fonts.sha256sum] = "3d8688a96f1ad0ad54cac97856c395fdf3c128b2a655c152c1ee671e2921cd8c"

URI_x86_64_v2_fontawesome4-fonts-web = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/fontawesome4-fonts-web-4.7.0-24.el10_2.noarch.rpm;name=x86_64_v2_fontawesome4-fonts-web;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fontawesome4-fonts-web}"
SRC_URI[x86_64_v2_fontawesome4-fonts-web.sha256sum] = "97a17dbf918ad551be0bdbf3c8d53001876aff0efc72cbdcbe480ab455878a93"

URI_aarch64_fontawesome4-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fontawesome4-fonts-4.7.0-24.el10_2.noarch.rpm;name=aarch64_fontawesome4-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_fontawesome4-fonts}"
SRC_URI[aarch64_fontawesome4-fonts.sha256sum] = "3d8688a96f1ad0ad54cac97856c395fdf3c128b2a655c152c1ee671e2921cd8c"

URI_aarch64_fontawesome4-fonts-web = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/fontawesome4-fonts-web-4.7.0-24.el10_2.noarch.rpm;name=aarch64_fontawesome4-fonts-web;unpack=0"
SRC_URI:append = " ${URI_aarch64_fontawesome4-fonts-web}"
SRC_URI[aarch64_fontawesome4-fonts-web.sha256sum] = "97a17dbf918ad551be0bdbf3c8d53001876aff0efc72cbdcbe480ab455878a93"

RDEPENDS:fontawesome4-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:fontawesome4-fonts-web = " \
 fontawesome4-fonts \
 "
