# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-glob"
PV = "0.3.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-glob+default-devel \
 rust-glob-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-glob-0.3.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c82d9fa3343ebf30f162f6e82394b90672a0334a87c4da5b8fe8318eed65ff4f"

URI_x86_64_v2_rust-glob+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-glob+default-devel-0.3.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-glob+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-glob+default-devel}"
SRC_URI[x86_64_v2_rust-glob+default-devel.sha256sum] = "c1953d76626602c6d7d9b99e1a0b466fba7f9a09b409ddd7f47b9c880d672341"

URI_x86_64_v2_rust-glob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-glob-devel-0.3.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-glob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-glob-devel}"
SRC_URI[x86_64_v2_rust-glob-devel.sha256sum] = "b02126f0f895258a955535826318341837aaa40c72d889c4aa1525c5a46dea7a"

URI_aarch64_rust-glob+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-glob+default-devel-0.3.4-1.el10_3.noarch.rpm;name=aarch64_rust-glob+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-glob+default-devel}"
SRC_URI[aarch64_rust-glob+default-devel.sha256sum] = "ba49f14f3ecd4ab90aa6fe9d84c12e52e4b5e7793ca0771ad6d074764de739fe"

URI_aarch64_rust-glob-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-glob-devel-0.3.4-1.el10_3.noarch.rpm;name=aarch64_rust-glob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-glob-devel}"
SRC_URI[aarch64_rust-glob-devel.sha256sum] = "04f9ef770c24f0e6c6e6db80570a9ea0c91bf9a7af5293837028f5a8defbaca8"

RDEPENDS:rust-glob+default-devel = " \
 cargo \
 rust-glob-devel \
 "
RDEPENDS:rust-glob-devel = " \
 cargo \
 rust \
 "
