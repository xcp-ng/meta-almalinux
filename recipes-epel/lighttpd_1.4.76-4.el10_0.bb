# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lighttpd"
PV = "1.4.76"
PR = "4.el10_0"
PACKAGES = " \
 lighttpd \
 lighttpd-fastcgi \
 lighttpd-filesystem \
 lighttpd-mod_authn_gssapi \
 lighttpd-mod_authn_ldap \
 lighttpd-mod_authn_pam \
 lighttpd-mod_authn_sasl \
 lighttpd-mod_deflate \
 lighttpd-mod_gnutls \
 lighttpd-mod_magnet \
 lighttpd-mod_maxminddb \
 lighttpd-mod_mbedtls \
 lighttpd-mod_nss \
 lighttpd-mod_openssl \
 lighttpd-mod_vhostdb_ldap \
 lighttpd-mod_vhostdb_mysql \
 lighttpd-mod_vhostdb_pgsql \
 lighttpd-mod_webdav \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lighttpd-1.4.76-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e49ce8e02cd8bb4df6d498bb42b71e82b904999d706beac3ad36ca894610354"

URI_x86_64_v2_lighttpd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lighttpd-1.4.76-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lighttpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lighttpd}"
SRC_URI[x86_64_v2_lighttpd.sha256sum] = "25d143982b8c5e0c0910c8966cce48b4926a264a33bfef4e361838b3e89342fb"
RPROVIDES:lighttpd:x86_64_v2 = "virtual/webserver"

URI_x86_64_v2_lighttpd-fastcgi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lighttpd-fastcgi-1.4.76-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lighttpd-fastcgi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lighttpd-fastcgi}"
SRC_URI[x86_64_v2_lighttpd-fastcgi.sha256sum] = "95342837382df0566e915a1cd9a60bdfb715ac05bbb0a9a0dad49a4dbbcbbe19"

URI_x86_64_v2_lighttpd-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lighttpd-filesystem-1.4.76-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_lighttpd-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lighttpd-filesystem}"
SRC_URI[x86_64_v2_lighttpd-filesystem.sha256sum] = "290d5b58a81fa42a8248890ad124e0631adeb67f40d3d3b3472c4f003e479f1d"

URI_x86_64_v2_lighttpd-mod_authn_gssapi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lighttpd-mod_authn_gssapi-1.4.76-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lighttpd-mod_authn_gssapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lighttpd-mod_authn_gssapi}"
SRC_URI[x86_64_v2_lighttpd-mod_authn_gssapi.sha256sum] = "b676ed3a2d93cbbc86b76b8bfecd8fd099bfd11f2dc11afa80a9da7468ac5ad3"

URI_x86_64_v2_lighttpd-mod_authn_ldap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lighttpd-mod_authn_ldap-1.4.76-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lighttpd-mod_authn_ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lighttpd-mod_authn_ldap}"
SRC_URI[x86_64_v2_lighttpd-mod_authn_ldap.sha256sum] = "71d18ed5af0d1705cc848c4fb27634e6a6af99dfdd1ae12606c230299ed15d98"

URI_x86_64_v2_lighttpd-mod_authn_pam = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lighttpd-mod_authn_pam-1.4.76-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lighttpd-mod_authn_pam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lighttpd-mod_authn_pam}"
SRC_URI[x86_64_v2_lighttpd-mod_authn_pam.sha256sum] = "b24852f9ad056b929d12f254d3d86e5a0d45e427ab11467f4178fef9efc8b5e2"

URI_x86_64_v2_lighttpd-mod_authn_sasl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lighttpd-mod_authn_sasl-1.4.76-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lighttpd-mod_authn_sasl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lighttpd-mod_authn_sasl}"
SRC_URI[x86_64_v2_lighttpd-mod_authn_sasl.sha256sum] = "0c2ad5515a9fc9a538362111804e725b50c5a75d17a49bc4b84ac32625735b01"

URI_x86_64_v2_lighttpd-mod_deflate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lighttpd-mod_deflate-1.4.76-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lighttpd-mod_deflate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lighttpd-mod_deflate}"
SRC_URI[x86_64_v2_lighttpd-mod_deflate.sha256sum] = "47fddbcc0fb8c50d62a0c9c4566e7a85c035419484f0145f7074ece4ae98474f"

URI_x86_64_v2_lighttpd-mod_gnutls = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lighttpd-mod_gnutls-1.4.76-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lighttpd-mod_gnutls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lighttpd-mod_gnutls}"
SRC_URI[x86_64_v2_lighttpd-mod_gnutls.sha256sum] = "2015ed01ccfbcf71054c15b2906ecf03f2b0908af9714f58518bc0c541111be1"

URI_x86_64_v2_lighttpd-mod_magnet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lighttpd-mod_magnet-1.4.76-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lighttpd-mod_magnet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lighttpd-mod_magnet}"
SRC_URI[x86_64_v2_lighttpd-mod_magnet.sha256sum] = "b2dd89c51d9b12bddabf30a94b3ad471abc85f047e93c6543947aa1c5d5ed4eb"

URI_x86_64_v2_lighttpd-mod_maxminddb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lighttpd-mod_maxminddb-1.4.76-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lighttpd-mod_maxminddb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lighttpd-mod_maxminddb}"
SRC_URI[x86_64_v2_lighttpd-mod_maxminddb.sha256sum] = "d9a5d6e8c1cfed95c48374d1d39641b5ce6d41cfdb9fc66990a0e72c1f845525"

URI_x86_64_v2_lighttpd-mod_mbedtls = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lighttpd-mod_mbedtls-1.4.76-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lighttpd-mod_mbedtls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lighttpd-mod_mbedtls}"
SRC_URI[x86_64_v2_lighttpd-mod_mbedtls.sha256sum] = "9629a53484a1c4428fda45ff93470d49137406509ebd454c597974918d8478a5"

URI_x86_64_v2_lighttpd-mod_nss = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lighttpd-mod_nss-1.4.76-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lighttpd-mod_nss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lighttpd-mod_nss}"
SRC_URI[x86_64_v2_lighttpd-mod_nss.sha256sum] = "4bfae509e17ca9b27ce6d063f6f7f38e623582f2902346b9c7d78be258988371"

URI_x86_64_v2_lighttpd-mod_openssl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lighttpd-mod_openssl-1.4.76-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lighttpd-mod_openssl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lighttpd-mod_openssl}"
SRC_URI[x86_64_v2_lighttpd-mod_openssl.sha256sum] = "1105e26362d61408d1a89450091f562db12d68f415d9f6d54ee1337cc5e21c6f"

URI_x86_64_v2_lighttpd-mod_vhostdb_ldap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lighttpd-mod_vhostdb_ldap-1.4.76-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lighttpd-mod_vhostdb_ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lighttpd-mod_vhostdb_ldap}"
SRC_URI[x86_64_v2_lighttpd-mod_vhostdb_ldap.sha256sum] = "ed6858889d4e23725e9ab10981f312bd03a4be4247cb23a8bd6b0eef88090502"

URI_x86_64_v2_lighttpd-mod_vhostdb_mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lighttpd-mod_vhostdb_mysql-1.4.76-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lighttpd-mod_vhostdb_mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lighttpd-mod_vhostdb_mysql}"
SRC_URI[x86_64_v2_lighttpd-mod_vhostdb_mysql.sha256sum] = "38cd869ac1da8874e3d44d86717a2ba929f9d2a67c5aa027c8542fb8258944c0"

URI_x86_64_v2_lighttpd-mod_vhostdb_pgsql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lighttpd-mod_vhostdb_pgsql-1.4.76-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lighttpd-mod_vhostdb_pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lighttpd-mod_vhostdb_pgsql}"
SRC_URI[x86_64_v2_lighttpd-mod_vhostdb_pgsql.sha256sum] = "07053d8d716af33249e1924bda2c09d99b8cf940915b167e7e53d86f0fb834a8"

URI_x86_64_v2_lighttpd-mod_webdav = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lighttpd-mod_webdav-1.4.76-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lighttpd-mod_webdav;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lighttpd-mod_webdav}"
SRC_URI[x86_64_v2_lighttpd-mod_webdav.sha256sum] = "e12bec6a46784b29a6adb0b2263db7125184d62e00b6a0e14182a6576bf34432"

URI_aarch64_lighttpd = "${EPEL_MIRROR}/aarch64/Packages/l/lighttpd-1.4.76-4.el10_0.aarch64.rpm;name=aarch64_lighttpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_lighttpd}"
SRC_URI[aarch64_lighttpd.sha256sum] = "5e7cc0215992c3c7eca0187da46c3592b12691d7020d0830c4ba5f733e51fde6"
RPROVIDES:lighttpd:aarch64 = "virtual/webserver"

URI_aarch64_lighttpd-fastcgi = "${EPEL_MIRROR}/aarch64/Packages/l/lighttpd-fastcgi-1.4.76-4.el10_0.aarch64.rpm;name=aarch64_lighttpd-fastcgi;unpack=0"
SRC_URI:append = " ${URI_aarch64_lighttpd-fastcgi}"
SRC_URI[aarch64_lighttpd-fastcgi.sha256sum] = "225c575397977d8b802a0b0247fbd5a39a3e429b24a389eec2205669928cbb70"

URI_aarch64_lighttpd-filesystem = "${EPEL_MIRROR}/aarch64/Packages/l/lighttpd-filesystem-1.4.76-4.el10_0.noarch.rpm;name=aarch64_lighttpd-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_lighttpd-filesystem}"
SRC_URI[aarch64_lighttpd-filesystem.sha256sum] = "959e548663da9a9539e9490a98d6310bc85c8e0652f878b7f99830bba0617d80"

URI_aarch64_lighttpd-mod_authn_gssapi = "${EPEL_MIRROR}/aarch64/Packages/l/lighttpd-mod_authn_gssapi-1.4.76-4.el10_0.aarch64.rpm;name=aarch64_lighttpd-mod_authn_gssapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_lighttpd-mod_authn_gssapi}"
SRC_URI[aarch64_lighttpd-mod_authn_gssapi.sha256sum] = "6e7e552f0f3f25c5ce2ef55c48bc62020c8e1ef1db564f9d59886b1d41610147"

URI_aarch64_lighttpd-mod_authn_ldap = "${EPEL_MIRROR}/aarch64/Packages/l/lighttpd-mod_authn_ldap-1.4.76-4.el10_0.aarch64.rpm;name=aarch64_lighttpd-mod_authn_ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_lighttpd-mod_authn_ldap}"
SRC_URI[aarch64_lighttpd-mod_authn_ldap.sha256sum] = "4296448ff575675ead34d257ddd5f915b6a5599042d05ac01309caae4fc41fa7"

URI_aarch64_lighttpd-mod_authn_pam = "${EPEL_MIRROR}/aarch64/Packages/l/lighttpd-mod_authn_pam-1.4.76-4.el10_0.aarch64.rpm;name=aarch64_lighttpd-mod_authn_pam;unpack=0"
SRC_URI:append = " ${URI_aarch64_lighttpd-mod_authn_pam}"
SRC_URI[aarch64_lighttpd-mod_authn_pam.sha256sum] = "a1861a06ef973b0fc5b9642ed8212b8987f2a3f233cbfd82abe31a5ad9094934"

URI_aarch64_lighttpd-mod_authn_sasl = "${EPEL_MIRROR}/aarch64/Packages/l/lighttpd-mod_authn_sasl-1.4.76-4.el10_0.aarch64.rpm;name=aarch64_lighttpd-mod_authn_sasl;unpack=0"
SRC_URI:append = " ${URI_aarch64_lighttpd-mod_authn_sasl}"
SRC_URI[aarch64_lighttpd-mod_authn_sasl.sha256sum] = "60d6e4c8f9bd6e5b00e7b515076ea4f58613aed3856e950ee6025d380199cb3f"

URI_aarch64_lighttpd-mod_deflate = "${EPEL_MIRROR}/aarch64/Packages/l/lighttpd-mod_deflate-1.4.76-4.el10_0.aarch64.rpm;name=aarch64_lighttpd-mod_deflate;unpack=0"
SRC_URI:append = " ${URI_aarch64_lighttpd-mod_deflate}"
SRC_URI[aarch64_lighttpd-mod_deflate.sha256sum] = "25a819330ad90d664c277a94d71bcf37264e7a2e4c2b01e0f6663b465ac09532"

URI_aarch64_lighttpd-mod_gnutls = "${EPEL_MIRROR}/aarch64/Packages/l/lighttpd-mod_gnutls-1.4.76-4.el10_0.aarch64.rpm;name=aarch64_lighttpd-mod_gnutls;unpack=0"
SRC_URI:append = " ${URI_aarch64_lighttpd-mod_gnutls}"
SRC_URI[aarch64_lighttpd-mod_gnutls.sha256sum] = "dfd0b586c22e5dfa541687d7ca643fdef8be615516794584d87c37857338cfcd"

URI_aarch64_lighttpd-mod_magnet = "${EPEL_MIRROR}/aarch64/Packages/l/lighttpd-mod_magnet-1.4.76-4.el10_0.aarch64.rpm;name=aarch64_lighttpd-mod_magnet;unpack=0"
SRC_URI:append = " ${URI_aarch64_lighttpd-mod_magnet}"
SRC_URI[aarch64_lighttpd-mod_magnet.sha256sum] = "ab548073fba8311ee1555488563a5cdcdc4ef6675b07612d7c41f0c7f709b7c1"

URI_aarch64_lighttpd-mod_maxminddb = "${EPEL_MIRROR}/aarch64/Packages/l/lighttpd-mod_maxminddb-1.4.76-4.el10_0.aarch64.rpm;name=aarch64_lighttpd-mod_maxminddb;unpack=0"
SRC_URI:append = " ${URI_aarch64_lighttpd-mod_maxminddb}"
SRC_URI[aarch64_lighttpd-mod_maxminddb.sha256sum] = "96312b6d4c7264e55e144a88ac913b5d13aeca90eac97930891ad6310153c289"

URI_aarch64_lighttpd-mod_mbedtls = "${EPEL_MIRROR}/aarch64/Packages/l/lighttpd-mod_mbedtls-1.4.76-4.el10_0.aarch64.rpm;name=aarch64_lighttpd-mod_mbedtls;unpack=0"
SRC_URI:append = " ${URI_aarch64_lighttpd-mod_mbedtls}"
SRC_URI[aarch64_lighttpd-mod_mbedtls.sha256sum] = "a64d70a095ac8ca35e2e98989a2a6bfca6fc865c5103eec29d13182d5d1be500"

URI_aarch64_lighttpd-mod_nss = "${EPEL_MIRROR}/aarch64/Packages/l/lighttpd-mod_nss-1.4.76-4.el10_0.aarch64.rpm;name=aarch64_lighttpd-mod_nss;unpack=0"
SRC_URI:append = " ${URI_aarch64_lighttpd-mod_nss}"
SRC_URI[aarch64_lighttpd-mod_nss.sha256sum] = "cc709f418b69a4bebd18a1034fb562ba8c33d10978389c375a2402287e3d0130"

URI_aarch64_lighttpd-mod_openssl = "${EPEL_MIRROR}/aarch64/Packages/l/lighttpd-mod_openssl-1.4.76-4.el10_0.aarch64.rpm;name=aarch64_lighttpd-mod_openssl;unpack=0"
SRC_URI:append = " ${URI_aarch64_lighttpd-mod_openssl}"
SRC_URI[aarch64_lighttpd-mod_openssl.sha256sum] = "22cc1f1b03c43369434b0052cf83f84b98ec71a2ef953b785ed2ea267d80b919"

URI_aarch64_lighttpd-mod_vhostdb_ldap = "${EPEL_MIRROR}/aarch64/Packages/l/lighttpd-mod_vhostdb_ldap-1.4.76-4.el10_0.aarch64.rpm;name=aarch64_lighttpd-mod_vhostdb_ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_lighttpd-mod_vhostdb_ldap}"
SRC_URI[aarch64_lighttpd-mod_vhostdb_ldap.sha256sum] = "21fe70d5d32c82f15fce5e9c2e523f452c81d436a9beac2081534db852bc6d81"

URI_aarch64_lighttpd-mod_vhostdb_mysql = "${EPEL_MIRROR}/aarch64/Packages/l/lighttpd-mod_vhostdb_mysql-1.4.76-4.el10_0.aarch64.rpm;name=aarch64_lighttpd-mod_vhostdb_mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_lighttpd-mod_vhostdb_mysql}"
SRC_URI[aarch64_lighttpd-mod_vhostdb_mysql.sha256sum] = "2ba2e75f7126b215279e7f0acf6dbb052299cfdda596bdda634a677367e58ef4"

URI_aarch64_lighttpd-mod_vhostdb_pgsql = "${EPEL_MIRROR}/aarch64/Packages/l/lighttpd-mod_vhostdb_pgsql-1.4.76-4.el10_0.aarch64.rpm;name=aarch64_lighttpd-mod_vhostdb_pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_lighttpd-mod_vhostdb_pgsql}"
SRC_URI[aarch64_lighttpd-mod_vhostdb_pgsql.sha256sum] = "9de9f7776e83b4ff12911de53be8fe9237d47aef01226238923876a2def01545"

URI_aarch64_lighttpd-mod_webdav = "${EPEL_MIRROR}/aarch64/Packages/l/lighttpd-mod_webdav-1.4.76-4.el10_0.aarch64.rpm;name=aarch64_lighttpd-mod_webdav;unpack=0"
SRC_URI:append = " ${URI_aarch64_lighttpd-mod_webdav}"
SRC_URI[aarch64_lighttpd-mod_webdav.sha256sum] = "c783ba5877c8e53b2cea6783d1d7f0eb91b972858e0b31ce3fa4a564930577c0"

RDEPENDS:lighttpd = " \
 almalinux-logos \
 bash \
 glibc \
 libxcrypt \
 libxml2 \
 lighttpd-filesystem \
 lighttpd-mod_deflate \
 lighttpd-mod_magnet \
 lighttpd-mod_openssl \
 lighttpd-mod_webdav \
 nettle \
 pcre2 \
 sqlite-libs \
 systemd \
 "
RDEPENDS:lighttpd-fastcgi = " \
 lighttpd \
 "
RDEPENDS:lighttpd-filesystem = " \
 bash \
 shadow-utils \
 "
RDEPENDS:lighttpd-mod_authn_gssapi = " \
 glibc \
 krb5-libs \
 lighttpd \
 "
RDEPENDS:lighttpd-mod_authn_ldap = " \
 glibc \
 lighttpd \
 openldap \
 "
RDEPENDS:lighttpd-mod_authn_pam = " \
 glibc \
 lighttpd \
 pam-libs \
 "
RDEPENDS:lighttpd-mod_authn_sasl = " \
 cyrus-sasl-lib \
 glibc \
 lighttpd \
 "
RDEPENDS:lighttpd-mod_deflate = " \
 glibc \
 libbrotli \
 libzstd \
 lighttpd \
 zlib-ng-compat \
 "
RDEPENDS:lighttpd-mod_gnutls = " \
 glibc \
 gnutls \
 lighttpd \
 "
RDEPENDS:lighttpd-mod_magnet = " \
 glibc \
 lighttpd \
 lua-libs \
 nettle \
 "
RDEPENDS:lighttpd-mod_maxminddb = " \
 glibc \
 libmaxminddb \
 lighttpd \
 "
RDEPENDS:lighttpd-mod_mbedtls = " \
 glibc \
 lighttpd \
 mbedtls \
 "
RDEPENDS:lighttpd-mod_nss = " \
 glibc \
 lighttpd \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:lighttpd-mod_openssl = " \
 glibc \
 lighttpd \
 openssl-libs \
 "
RDEPENDS:lighttpd-mod_vhostdb_ldap = " \
 glibc \
 lighttpd \
 openldap \
 "
RDEPENDS:lighttpd-mod_vhostdb_mysql = " \
 glibc \
 lighttpd \
 mariadb-connector-c \
 "
RDEPENDS:lighttpd-mod_vhostdb_pgsql = " \
 glibc \
 libpq \
 lighttpd \
 "
RDEPENDS:lighttpd-mod_webdav = " \
 glibc \
 libxml2 \
 lighttpd \
 sqlite-libs \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/webserver"

PROVIDES:append:aarch64 = " rpm/virtual/webserver"
