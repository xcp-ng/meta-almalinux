# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-trait"
PV = "0.1.89"
PR = "1.el10_0"
PACKAGES = " \
 rust-async-trait+default-devel \
 rust-async-trait-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-trait-0.1.89-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "05b0ea0c7086777f028942b7b7092c1494ccd8ddbb43bf0fa122b19fc1d3bb2c"

URI_x86_64_v2_rust-async-trait+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-trait+default-devel-0.1.89-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-trait+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-trait+default-devel}"
SRC_URI[x86_64_v2_rust-async-trait+default-devel.sha256sum] = "fa4254527f07be95c2031f045ca0944aa48a75aa35b0cc8185e5aa3942e8211b"

URI_x86_64_v2_rust-async-trait-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-trait-devel-0.1.89-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-trait-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-trait-devel}"
SRC_URI[x86_64_v2_rust-async-trait-devel.sha256sum] = "e206552de38802a7049c9644b485f014914c56075d633b03413cd29373b88486"

URI_aarch64_rust-async-trait+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-trait+default-devel-0.1.89-1.el10_0.noarch.rpm;name=aarch64_rust-async-trait+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-trait+default-devel}"
SRC_URI[aarch64_rust-async-trait+default-devel.sha256sum] = "2b5cbe56b56b1ab5f573050600c882e2ca07a75ff9e9cf813632c1f93d8a87bf"

URI_aarch64_rust-async-trait-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-trait-devel-0.1.89-1.el10_0.noarch.rpm;name=aarch64_rust-async-trait-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-trait-devel}"
SRC_URI[aarch64_rust-async-trait-devel.sha256sum] = "f3ca6719e1f5324e201324dd6b9010fdc470af6ed649480307ac4aec4d4c0617"

RDEPENDS:rust-async-trait+default-devel = " \
 cargo \
 rust-async-trait-devel \
 "
RDEPENDS:rust-async-trait-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+clone-impls-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn+visit-mut-devel \
 rust-syn-devel \
 "
