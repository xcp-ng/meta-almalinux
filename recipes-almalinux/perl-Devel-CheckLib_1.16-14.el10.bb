# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Devel-CheckLib"
PV = "1.16"
PR = "14.el10"
PACKAGES = " \
 perl-Devel-CheckLib \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Devel-CheckLib-1.16-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0d2c9364fb0b3660b8cde91e3e17395dda3c1ff45f063f5900551ea911dd6032"

URI_x86_64_v2_perl-Devel-CheckLib = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Devel-CheckLib-1.16-14.el10.noarch.rpm;name=x86_64_v2_perl-Devel-CheckLib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Devel-CheckLib}"
SRC_URI[x86_64_v2_perl-Devel-CheckLib.sha256sum] = "48e9483735990448da8fceba21ae2f243bfff393faee784bfb51e918c62acb84"

URI_aarch64_perl-Devel-CheckLib = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Devel-CheckLib-1.16-14.el10.noarch.rpm;name=aarch64_perl-Devel-CheckLib;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Devel-CheckLib}"
SRC_URI[aarch64_perl-Devel-CheckLib.sha256sum] = "48e9483735990448da8fceba21ae2f243bfff393faee784bfb51e918c62acb84"

RDEPENDS:perl-Devel-CheckLib = " \
 perl-Devel-CheckLib \
 perl-Exporter \
 perl-File-Temp \
 perl-PathTools \
 perl-Text-ParseWords \
 perl-interpreter \
 perl-libs \
 perl-vars \
 redhat-rpm-config \
 "
