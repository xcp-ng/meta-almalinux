# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-camino"
PV = "1.2.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-camino+default-devel \
 rust-camino+proptest1-devel \
 rust-camino+serde1-devel \
 rust-camino-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-camino-1.2.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cdf9bc754f8681a731ef80fd9f1974db4e0490e091f7eb71a5a22ba016609962"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-camino+default-devel-1.2.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-camino+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-camino+default-devel.sha256sum] = "002ef481fa25d9556c23bc7cdeeba87a115ef9b59d5220c49bbe7f83fc6dda70"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-camino+proptest1-devel-1.2.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-camino+proptest1-devel;unpack=0"
SRC_URI[x86_64_v2_rust-camino+proptest1-devel.sha256sum] = "a97ddb7a6b59ce53c2ccf1d662b0a78ff6865b8546a0fd39543b62f112496427"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-camino+serde1-devel-1.2.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-camino+serde1-devel;unpack=0"
SRC_URI[x86_64_v2_rust-camino+serde1-devel.sha256sum] = "bc209d67ac8843d901e10363fbf563ee92a52f8065596efe746a56e76d5cec20"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-camino-devel-1.2.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-camino-devel;unpack=0"
SRC_URI[x86_64_v2_rust-camino-devel.sha256sum] = "087db0281e8fd826ff27889a6f116efefcfcbea9c73f464aed6e9c88d8666b83"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-camino+default-devel-1.2.6-1.el10_3.noarch.rpm;name=aarch64_rust-camino+default-devel;unpack=0"
SRC_URI[aarch64_rust-camino+default-devel.sha256sum] = "1492e692a2d86d66431ef82115f876cfb420c99f0034651b55c24f0e8e4186da"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-camino+proptest1-devel-1.2.6-1.el10_3.noarch.rpm;name=aarch64_rust-camino+proptest1-devel;unpack=0"
SRC_URI[aarch64_rust-camino+proptest1-devel.sha256sum] = "99e89110108f9ba64e136cd92420d59cf9a53593aa405837154131633e6752c3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-camino+serde1-devel-1.2.6-1.el10_3.noarch.rpm;name=aarch64_rust-camino+serde1-devel;unpack=0"
SRC_URI[aarch64_rust-camino+serde1-devel.sha256sum] = "f059b006bf48044b2ee92ca7881c522494244bc61fd5ed8af3474b46a0d50358"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-camino-devel-1.2.6-1.el10_3.noarch.rpm;name=aarch64_rust-camino-devel;unpack=0"
SRC_URI[aarch64_rust-camino-devel.sha256sum] = "f361bc276100bd8fe18f728c613ec0cd72705b6201487f6effe1b26e7f351b59"

RDEPENDS:rust-camino+default-devel = " \
 cargo \
 rust-camino-devel \
 "
RDEPENDS:rust-camino+proptest1-devel = " \
 cargo \
 rust-camino-devel \
 rust-proptest+default-devel \
 "
RDEPENDS:rust-camino+serde1-devel = " \
 cargo \
 rust-camino-devel \
 rust-serde_core+default-devel \
 "
RDEPENDS:rust-camino-devel = " \
 cargo \
 rust \
 "
