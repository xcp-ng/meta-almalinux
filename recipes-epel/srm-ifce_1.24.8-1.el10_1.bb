# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "srm-ifce"
PV = "1.24.8"
PR = "1.el10_1"
PACKAGES = " \
 srm-ifce \
 srm-ifce-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/srm-ifce-1.24.8-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "273df80d01d6a1849af0f11edee9dad061ca7fd589b794bbd64f24e0b9284312"

URI_x86_64_v2_srm-ifce = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/srm-ifce-1.24.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_srm-ifce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_srm-ifce}"
SRC_URI[x86_64_v2_srm-ifce.sha256sum] = "ef67b4f4cae78e5d60f117ecbd70fb371b3c9a735f0c35aa0aab9782d73d8e72"

URI_x86_64_v2_srm-ifce-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/srm-ifce-devel-1.24.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_srm-ifce-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_srm-ifce-devel}"
SRC_URI[x86_64_v2_srm-ifce-devel.sha256sum] = "4820ae56777aa28d3ead5323c59452a8b88230fdd958b23d121d835e40917bc7"

URI_aarch64_srm-ifce = "${EPEL_MIRROR}/aarch64/Packages/s/srm-ifce-1.24.8-1.el10_1.aarch64.rpm;name=aarch64_srm-ifce;unpack=0"
SRC_URI:append = " ${URI_aarch64_srm-ifce}"
SRC_URI[aarch64_srm-ifce.sha256sum] = "85ab300919652e59777f5b848ecc0b535a8dfc406229c4b480b169b5a283675e"

URI_aarch64_srm-ifce-devel = "${EPEL_MIRROR}/aarch64/Packages/s/srm-ifce-devel-1.24.8-1.el10_1.aarch64.rpm;name=aarch64_srm-ifce-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_srm-ifce-devel}"
SRC_URI[aarch64_srm-ifce-devel.sha256sum] = "9f9a2277c7fe72510c78abe642d5444cea5b0614c29facbc290d488b34c7fa48"

RDEPENDS:srm-ifce = " \
 CGSI-gSOAP \
 glib2 \
 glibc \
 gsoap \
 "
RDEPENDS:srm-ifce-devel = " \
 glib2-devel \
 pkgconf-pkg-config \
 srm-ifce \
 "
