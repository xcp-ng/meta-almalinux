# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnu-efi"
PE = "1"
PV = "3.0.18"
PR = "4.el10"
PACKAGES = " \
 gnu-efi \
 gnu-efi-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnu-efi-3.0.18-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f2572d9604c185518cc9def8557951288fab4fb24db836c563c79b5de7138202"

URI_x86_64_v2_gnu-efi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnu-efi-3.0.18-4.el10.x86_64_v2.rpm;name=x86_64_v2_gnu-efi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnu-efi}"
SRC_URI[x86_64_v2_gnu-efi.sha256sum] = "9b804bffab923ec43e6215691b15e676dbee6b4e03f294928142e21a159c1f6f"

URI_x86_64_v2_gnu-efi-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gnu-efi-devel-3.0.18-4.el10.x86_64_v2.rpm;name=x86_64_v2_gnu-efi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnu-efi-devel}"
SRC_URI[x86_64_v2_gnu-efi-devel.sha256sum] = "8ce2db05b0236bd4e6bd4b6443e0f616da71b4bb085d280a041c289c1b77c67a"

URI_aarch64_gnu-efi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnu-efi-3.0.18-4.el10.aarch64.rpm;name=aarch64_gnu-efi;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnu-efi}"
SRC_URI[aarch64_gnu-efi.sha256sum] = "467c7bd38f01fb63f2f9710f18e9286047945738337042c5ea8b122bfc44c629"

URI_aarch64_gnu-efi-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gnu-efi-devel-3.0.18-4.el10.aarch64.rpm;name=aarch64_gnu-efi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnu-efi-devel}"
SRC_URI[aarch64_gnu-efi-devel.sha256sum] = "c5dfd76ed3faa03f7476d9a10ac666c710b8a8ea423032a2f4b79928fade7729"

RDEPENDS:gnu-efi = " \
 "
RDEPENDS:gnu-efi-devel = " \
 gnu-efi \
 pkgconf-pkg-config \
 "
