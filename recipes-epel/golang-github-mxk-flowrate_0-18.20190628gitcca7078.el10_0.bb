# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-mxk-flowrate"
PV = "0"
PR = "18.20190628gitcca7078.el10_0"
PACKAGES = " \
 golang-github-mxk-flowrate-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-mxk-flowrate-0-18.20190628gitcca7078.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f13c5c748e336c9291986c94754752c37f98a2ebc01b052e9e3a5cc5c0adc32"

URI_aarch64_golang-github-mxk-flowrate-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-mxk-flowrate-devel-0-18.20190628gitcca7078.el10_0.noarch.rpm;name=aarch64_golang-github-mxk-flowrate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-mxk-flowrate-devel}"
SRC_URI[aarch64_golang-github-mxk-flowrate-devel.sha256sum] = "06f5958f13fee19c4a4164f94341fb7cdbd455a6f0cf5659df6c5519a5c24e5d"

RDEPENDS:golang-github-mxk-flowrate-devel = " \
 go-filesystem \
 "
