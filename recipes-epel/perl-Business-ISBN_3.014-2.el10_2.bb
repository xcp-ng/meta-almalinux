# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Business-ISBN"
PV = "3.014"
PR = "2.el10_2"
PACKAGES = " \
 perl-Business-ISBN \
 perl-Business-ISBN-tests \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Business-ISBN-3.014-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "697f21aab5ca14de858b99fbb96f312ecd834c8eeb4456aa120c9eb290cef181"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Business-ISBN-3.014-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Business-ISBN;unpack=0"
SRC_URI[x86_64_v2_perl-Business-ISBN.sha256sum] = "0f8a0bce4eb584d63973873027c12632cd20ce1cce1bf512cd7190e6f7a3385d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Business-ISBN-tests-3.014-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Business-ISBN-tests;unpack=0"
SRC_URI[x86_64_v2_perl-Business-ISBN-tests.sha256sum] = "f18d77fa2f2a4f18f43f8414c58e22997a76448c9c6553341d7354004913d77f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Business-ISBN-3.014-2.el10_2.noarch.rpm;name=aarch64_perl-Business-ISBN;unpack=0"
SRC_URI[aarch64_perl-Business-ISBN.sha256sum] = "c4819af4bbd3c4da76aac4f0a4560981398124c36e58155b012b711ca821710d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Business-ISBN-tests-3.014-2.el10_2.noarch.rpm;name=aarch64_perl-Business-ISBN-tests;unpack=0"
SRC_URI[aarch64_perl-Business-ISBN-tests.sha256sum] = "7bea1e1b39490934739bcff3b64cdb4a636803d4c6d37f14807870fd06ec9ca1"

RDEPENDS:perl-Business-ISBN = " \
 perl-Business-ISBN \
 perl-Business-ISBN-Data \
 perl-Carp \
 perl-Data-Dumper \
 perl-Exporter \
 perl-base \
 perl-libs \
 perl-subs \
 perl-vars \
 "
RDEPENDS:perl-Business-ISBN-tests = " \
 bash \
 perl-Business-ISBN \
 perl-Data-Dumper \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
