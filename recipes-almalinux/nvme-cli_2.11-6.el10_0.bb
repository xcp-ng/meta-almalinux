# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nvme-cli"
PV = "2.11"
PR = "6.el10_0"
PACKAGES = " \
 nvme-cli \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/nvme-cli-2.11-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c58305b647a660b65362890508448d71dd8cf6e77ae3052bda9f5543591eb55b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/nvme-cli-2.11-6.el10_0.x86_64_v2.rpm;name=x86_64_v2_nvme-cli;unpack=0"
SRC_URI[x86_64_v2_nvme-cli.sha256sum] = "00ecd0639fb5b34f9e347947978dff0f921726af1277607eb0355da35596fdaa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/nvme-cli-2.11-6.el10_0.aarch64.rpm;name=aarch64_nvme-cli;unpack=0"
SRC_URI[aarch64_nvme-cli.sha256sum] = "1041160f962dcaa2ac2654cab4b9ac6ccd92f4e4ce4f48729eae7bf35425c790"

RDEPENDS:nvme-cli = " \
 bash \
 glibc \
 json-c \
 libgcc \
 libnvme \
 util-linux \
 "
