# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-setup"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 plasma-setup \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma-setup-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5b8635a0382a606d72f7aa46b6da9582e6792263e03f2498ac4357f1b012573e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-setup-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-setup;unpack=0"
SRC_URI[x86_64_v2_plasma-setup.sha256sum] = "1d0581f135a80aedf7f802fad3204e7803861e04e14dbe3d18221caf0fc9c3f7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-setup-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-setup;unpack=0"
SRC_URI[aarch64_plasma-setup.sha256sum] = "ab3d5231c40fc067fbc40fd1d8c8f70c768454e90c00cac04d7984ec43df7bc1"

RDEPENDS:plasma-setup = " \
 bash \
 dbus-common \
 glibc \
 kf6-filesystem \
 kf6-kauth \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kpackage \
 libgcc \
 libkscreen \
 libkworkspace6 \
 libstdc++ \
 plasma-desktop \
 plasma-lookandfeel-fedora \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 virtual/system-backgrounds-kde \
 "
