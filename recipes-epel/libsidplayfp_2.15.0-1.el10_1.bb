# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsidplayfp"
PV = "2.15.0"
PR = "1.el10_1"
PACKAGES = " \
 libsidplayfp \
 libsidplayfp-devel \
 libsidplayfp-devel-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libsidplayfp-2.15.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b3dd9adcee70c315d01bda567234358cc9670591ad65a8aae6cfa150a46b505c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsidplayfp-2.15.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libsidplayfp;unpack=0"
SRC_URI[x86_64_v2_libsidplayfp.sha256sum] = "9f43f9e099c7d9e014831a062fe35b63336f89d6441fde22283658fd58e00167"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsidplayfp-devel-2.15.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libsidplayfp-devel;unpack=0"
SRC_URI[x86_64_v2_libsidplayfp-devel.sha256sum] = "ad706379e6158ff3a5fe61c5b8df1237d2588df8c155ce3181bb5d6a492aba10"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsidplayfp-devel-doc-2.15.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_libsidplayfp-devel-doc;unpack=0"
SRC_URI[x86_64_v2_libsidplayfp-devel-doc.sha256sum] = "fd8e8d1cdfcc1f923a518aef694a6336bb24258b54e003012721c5d7efac41ba"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libsidplayfp-2.15.0-1.el10_1.aarch64.rpm;name=aarch64_libsidplayfp;unpack=0"
SRC_URI[aarch64_libsidplayfp.sha256sum] = "4093d09e5f774990229d4e67db436dcb6c46f46d5d48b7142bad2a06e9cf81ba"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libsidplayfp-devel-2.15.0-1.el10_1.aarch64.rpm;name=aarch64_libsidplayfp-devel;unpack=0"
SRC_URI[aarch64_libsidplayfp-devel.sha256sum] = "dd01cad1a88008023990ba3880d5e52935962d3cc181b613a65119de46c59b74"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libsidplayfp-devel-doc-2.15.0-1.el10_1.noarch.rpm;name=aarch64_libsidplayfp-devel-doc;unpack=0"
SRC_URI[aarch64_libsidplayfp-devel-doc.sha256sum] = "a70b297bc4f8a42abd33e454d3784fe05a9d80e6fac1bba2333f10ba9d38e302"

RDEPENDS:libsidplayfp = " \
 glibc \
 libgcc \
 libgcrypt \
 libstdc++ \
 "
RDEPENDS:libsidplayfp-devel = " \
 libsidplayfp \
 pkgconf-pkg-config \
 "
RDEPENDS:libsidplayfp-devel-doc = " \
 "
