# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "quilt"
PV = "0.68"
PR = "1.el10_1"
PACKAGES = " \
 quilt \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/quilt-0.68-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e8d9fdc4c7ca0f3e2f83b2bc2c1b6c2943cd6cc52720999754cabea92b19d40"

URI_x86_64_v2_quilt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/quilt-0.68-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_quilt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_quilt}"
SRC_URI[x86_64_v2_quilt.sha256sum] = "b0126c2746efa5ae1152c335f4da659da880971f41300b70e9cb3cdc6e9acb05"

URI_aarch64_quilt = "${EPEL_MIRROR}/aarch64/Packages/q/quilt-0.68-1.el10_1.noarch.rpm;name=aarch64_quilt;unpack=0"
SRC_URI:append = " ${URI_aarch64_quilt}"
SRC_URI[aarch64_quilt.sha256sum] = "664a06e461b8682cd55bb34e09d4c06d6be2211db579f3769cedc9db99b11896"

RDEPENDS:quilt = " \
 7zip-standalone \
 bash \
 bzip2 \
 diffstat \
 diffutils \
 gawk \
 gzip \
 perl-File-Temp \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-vars \
 procmail \
 rpm-build \
 sed \
 tar \
 util-linux \
 virtual//usr/sbin/sendmail \
 virtual/coreutils \
 "
