# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgravatar"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 libgravatar \
 libgravatar-devel \
 libgravatar-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libgravatar-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b427eb7e68767faf5f71abd10045f3988c471a24af46017a168b1ae921e9d0b5"

URI_x86_64_v2_libgravatar = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgravatar-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgravatar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgravatar}"
SRC_URI[x86_64_v2_libgravatar.sha256sum] = "caafd827bc5108d6dac063dce9833dddb805272c4748feb1d649edf570b2655f"

URI_x86_64_v2_libgravatar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgravatar-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgravatar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgravatar-devel}"
SRC_URI[x86_64_v2_libgravatar-devel.sha256sum] = "7b77aea37ce8e46e9c22808ed55bfa11943ad8691cbd2015313241bb0cf50104"

URI_x86_64_v2_libgravatar-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgravatar-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_libgravatar-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgravatar-doc}"
SRC_URI[x86_64_v2_libgravatar-doc.sha256sum] = "38c8c97e5d874af8c1b6779cfc69921be60cdcbb95786c95f60e3079e0cec7cb"

URI_aarch64_libgravatar = "${EPEL_MIRROR}/aarch64/Packages/l/libgravatar-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_libgravatar;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgravatar}"
SRC_URI[aarch64_libgravatar.sha256sum] = "a9676660b62b72f13befce03db0bbad6fe23b006ca4820172d5736919270e775"

URI_aarch64_libgravatar-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libgravatar-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_libgravatar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgravatar-devel}"
SRC_URI[aarch64_libgravatar-devel.sha256sum] = "5f71076453a04a49a682d7d3200d85a75169a1de782aceba56ed04313f9c2767"

URI_aarch64_libgravatar-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libgravatar-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_libgravatar-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgravatar-doc}"
SRC_URI[aarch64_libgravatar-doc.sha256sum] = "6846bced308647512b407a87e95467fa8c14184dd51d022366f001104498991e"

RDEPENDS:libgravatar = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libgravatar-devel = " \
 cmake-filesystem \
 libgravatar \
 "
RDEPENDS:libgravatar-doc = " \
 "
