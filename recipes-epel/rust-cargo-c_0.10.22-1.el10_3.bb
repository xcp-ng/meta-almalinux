# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-c"
PV = "0.10.22"
PR = "1.el10_3"
PACKAGES = " \
 cargo-c \
 rust-cargo-c+default-devel \
 rust-cargo-c-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-c-0.10.22-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "66fda859fe4ded88ca07b08e4716fb1d9a0d8ee8456e49dc0e7e5a41cacdc2c5"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - cargo-c: libgit2.so.1.9()(64bit)

URI_x86_64_v2_cargo-c = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cargo-c-0.10.22-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cargo-c;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cargo-c}"
SRC_URI[x86_64_v2_cargo-c.sha256sum] = "a396d5b1342a6bcbecae2b2bc40af52bb1f9181a43a0b75df7b67634cb25917a"

URI_x86_64_v2_rust-cargo-c+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-c+default-devel-0.10.22-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-c+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-c+default-devel}"
SRC_URI[x86_64_v2_rust-cargo-c+default-devel.sha256sum] = "5861fb2fa0cb389ce209870f31d0286639b58f9d9d86e692d1e40168fe688715"

URI_x86_64_v2_rust-cargo-c-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-c-devel-0.10.22-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-c-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-c-devel}"
SRC_URI[x86_64_v2_rust-cargo-c-devel.sha256sum] = "d759853e1f13302c65fcf7e0a1092f3613a19c6b4b93ce4d8fb651b4a6efbead"

URI_aarch64_cargo-c = "${EPEL_MIRROR}/aarch64/Packages/c/cargo-c-0.10.22-1.el10_3.aarch64.rpm;name=aarch64_cargo-c;unpack=0"
SRC_URI:append = " ${URI_aarch64_cargo-c}"
SRC_URI[aarch64_cargo-c.sha256sum] = "27cc226dd66047f8e4c2629af84e1bca0d605e3fdb1b9651f1819902ea9c82da"

URI_aarch64_rust-cargo-c+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-c+default-devel-0.10.22-1.el10_3.noarch.rpm;name=aarch64_rust-cargo-c+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-c+default-devel}"
SRC_URI[aarch64_rust-cargo-c+default-devel.sha256sum] = "23e159ca9f34211810db1e97da6fbb4d9d91c6538ffaf6fcf69b1cffc631c71c"

URI_aarch64_rust-cargo-c-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-c-devel-0.10.22-1.el10_3.noarch.rpm;name=aarch64_rust-cargo-c-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-c-devel}"
SRC_URI[aarch64_rust-cargo-c-devel.sha256sum] = "5ac0428329b2ac7485975be663f574e61b7dc0657d6bb30bd75b3b4ba6fe98ca"

RDEPENDS:cargo-c:x86_64_v2 = " \
 glibc \
 libgcc \
 libssh2 \
 openssl-libs \
 sqlite-libs \
 virtual/libcurl.so.4___64bit_ \
"
RDEPENDS:cargo-c:aarch64 = " \
 glibc \
 libgcc \
 libgit2_1.9 \
 libssh2 \
 openssl-libs \
 sqlite-libs \
 virtual/libcurl.so.4___64bit_ \
"
RDEPENDS:rust-cargo-c+default-devel = " \
 cargo \
 rust-cargo-c-devel \
 "
RDEPENDS:rust-cargo-c-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-camino+default-devel \
 rust-cargo+default-devel \
 rust-cargo-platform+default-devel \
 rust-cargo-util+default-devel \
 rust-cbindgen-devel \
 rust-cc+default-devel \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-clap+string-devel \
 rust-clap+wrap_help-devel \
 rust-clap_complete+default-devel \
 rust-glob+default-devel \
 rust-implib+default-devel \
 rust-itertools0.14+default-devel \
 rust-log+default-devel \
 rust-object+pe-devel \
 rust-object+read_core-devel \
 rust-object+std-devel \
 rust-object-devel \
 rust-regex+default-devel \
 rust-semver+default-devel \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 rust-serde_json+default-devel \
 rust-toml0.9+default-devel \
 "
