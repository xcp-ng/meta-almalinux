# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-find-crate"
PV = "0.6.3"
PR = "11.el10_0"
PACKAGES = " \
 rust-find-crate+default-devel \
 rust-find-crate-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-find-crate-0.6.3-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6613455b35804acd141467acdbdc2e3deb93ffc4cfaae00b6d1aa2e9b254e9f7"

URI_x86_64_v2_rust-find-crate+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-find-crate+default-devel-0.6.3-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-find-crate+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-find-crate+default-devel}"
SRC_URI[x86_64_v2_rust-find-crate+default-devel.sha256sum] = "f141f7ece5884c04f875ec9a0d3167ccc9c7a4725856de18f1280afd9db5b004"

URI_x86_64_v2_rust-find-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-find-crate-devel-0.6.3-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-find-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-find-crate-devel}"
SRC_URI[x86_64_v2_rust-find-crate-devel.sha256sum] = "e4165380b0c8ac6f2c14d41275b91a4491b5b1cf951ab77dc164034b575b7547"

URI_aarch64_rust-find-crate+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-find-crate+default-devel-0.6.3-11.el10_0.noarch.rpm;name=aarch64_rust-find-crate+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-find-crate+default-devel}"
SRC_URI[aarch64_rust-find-crate+default-devel.sha256sum] = "87c9ec6ec723a39fa68756f24335d7f47d7b29e29d836a1ee2f34ff36dbc21ba"

URI_aarch64_rust-find-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-find-crate-devel-0.6.3-11.el10_0.noarch.rpm;name=aarch64_rust-find-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-find-crate-devel}"
SRC_URI[aarch64_rust-find-crate-devel.sha256sum] = "c02c4267e7688cce0f45588154f1aee823127f3e7b2ed3ec45bf36844498a2e3"

RDEPENDS:rust-find-crate+default-devel = " \
 cargo \
 rust-find-crate-devel \
 "
RDEPENDS:rust-find-crate-devel = " \
 cargo \
 rust-toml0.5+default-devel \
 "
