# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-tasty-rerun"
PV = "1.1.19"
PR = "1.el10_0"
PACKAGES = " \
 ghc-tasty-rerun \
 ghc-tasty-rerun-devel \
 ghc-tasty-rerun-doc \
 ghc-tasty-rerun-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-tasty-rerun-1.1.19-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf351ac22d32d2d5875081829257fab1ef02b1d5e1a7cd48f549e582b0fce95a"

URI_x86_64_v2_ghc-tasty-rerun = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tasty-rerun-1.1.19-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tasty-rerun;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tasty-rerun}"
SRC_URI[x86_64_v2_ghc-tasty-rerun.sha256sum] = "23b9e99cdbe82297ebaef25e2ff575d5156e9b88828038cc001ba754ace79bf1"

URI_x86_64_v2_ghc-tasty-rerun-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tasty-rerun-devel-1.1.19-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tasty-rerun-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tasty-rerun-devel}"
SRC_URI[x86_64_v2_ghc-tasty-rerun-devel.sha256sum] = "20ee39dcec32d31efc89935b526820db23a47566e4ee11606645fcdf553f2698"

URI_x86_64_v2_ghc-tasty-rerun-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tasty-rerun-doc-1.1.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-tasty-rerun-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tasty-rerun-doc}"
SRC_URI[x86_64_v2_ghc-tasty-rerun-doc.sha256sum] = "48b37256a3acdf8485bb3ace4ec6e121cace2fe1bb5c9949ec2ceb2a37f4465f"

URI_x86_64_v2_ghc-tasty-rerun-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tasty-rerun-prof-1.1.19-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tasty-rerun-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tasty-rerun-prof}"
SRC_URI[x86_64_v2_ghc-tasty-rerun-prof.sha256sum] = "9b0bb7794a5b22da375c3a3695232411b38756ee8e69ed9c4b5059dd07b35720"

URI_aarch64_ghc-tasty-rerun = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tasty-rerun-1.1.19-1.el10_0.aarch64.rpm;name=aarch64_ghc-tasty-rerun;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tasty-rerun}"
SRC_URI[aarch64_ghc-tasty-rerun.sha256sum] = "0c77dd61fe9a8bc160193ad3b9691879e459a857f1f66992728bb2fdedb40c50"

URI_aarch64_ghc-tasty-rerun-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tasty-rerun-devel-1.1.19-1.el10_0.aarch64.rpm;name=aarch64_ghc-tasty-rerun-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tasty-rerun-devel}"
SRC_URI[aarch64_ghc-tasty-rerun-devel.sha256sum] = "c4ecc36ce3700cea29c146e9676f448b031cc2536fef9b06266f780a13d2ae1c"

URI_aarch64_ghc-tasty-rerun-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tasty-rerun-doc-1.1.19-1.el10_0.noarch.rpm;name=aarch64_ghc-tasty-rerun-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tasty-rerun-doc}"
SRC_URI[aarch64_ghc-tasty-rerun-doc.sha256sum] = "1ccb405fa6337e1876f4c811289f0e4ca92f8750abe28ad771d267b7c26e3a09"

URI_aarch64_ghc-tasty-rerun-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tasty-rerun-prof-1.1.19-1.el10_0.aarch64.rpm;name=aarch64_ghc-tasty-rerun-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tasty-rerun-prof}"
SRC_URI[aarch64_ghc-tasty-rerun-prof.sha256sum] = "94d7b86cd51ffe66a15f486bfc527a270c1aacb1229f6f498016b2212d10042f"

RDEPENDS:ghc-tasty-rerun = " \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-colour \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-optparse-applicative \
 ghc-pretty \
 ghc-prettyprinter \
 ghc-prettyprinter-ansi-terminal \
 ghc-process \
 ghc-split \
 ghc-stm \
 ghc-tagged \
 ghc-tasty \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-tasty-rerun-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-mtl-devel \
 ghc-optparse-applicative-devel \
 ghc-split-devel \
 ghc-stm-devel \
 ghc-tagged-devel \
 ghc-tasty-devel \
 ghc-tasty-rerun \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-tasty-rerun-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-tasty-rerun-prof = " \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-mtl-prof \
 ghc-optparse-applicative-prof \
 ghc-split-prof \
 ghc-stm-prof \
 ghc-tagged-prof \
 ghc-tasty-prof \
 ghc-tasty-rerun-devel \
 ghc-transformers-prof \
 "
