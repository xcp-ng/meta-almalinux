# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Fedora-VSP"
PV = "0.001"
PR = "36.el10"
PACKAGES = " \
 perl-Fedora-VSP \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Fedora-VSP-0.001-36.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4c89fe4afb2cad369923ff806aa676148c230ccd8567c0a7e157916ba6652c61"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Fedora-VSP-0.001-36.el10.noarch.rpm;name=x86_64_v2_perl-Fedora-VSP;unpack=0"
SRC_URI[x86_64_v2_perl-Fedora-VSP.sha256sum] = "5b00390f79ec6fefd63cf8e2c2ebed5df7d34f23291d86e8276725831f10e892"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Fedora-VSP-0.001-36.el10.noarch.rpm;name=aarch64_perl-Fedora-VSP;unpack=0"
SRC_URI[aarch64_perl-Fedora-VSP.sha256sum] = "5b00390f79ec6fefd63cf8e2c2ebed5df7d34f23291d86e8276725831f10e892"

RDEPENDS:perl-Fedora-VSP = " \
 perl-libs \
 "
