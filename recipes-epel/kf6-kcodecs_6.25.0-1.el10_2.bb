# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcodecs"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kcodecs \
 kf6-kcodecs-devel \
 kf6-kcodecs-doc \
 kf6-kcodecs-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kcodecs-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6053bad0a3a4e84c197be52aa3f3eb1a6200507bfff7035889c7e00a149ba4ca"

URI_x86_64_v2_kf6-kcodecs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcodecs-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcodecs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcodecs}"
SRC_URI[x86_64_v2_kf6-kcodecs.sha256sum] = "727d16953ce64a3af886b607e74bf4f48c3283c21603ea653d89432677e65dd3"

URI_x86_64_v2_kf6-kcodecs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcodecs-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcodecs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcodecs-devel}"
SRC_URI[x86_64_v2_kf6-kcodecs-devel.sha256sum] = "ad6260a4470652bfb5aa51530808c216c6e3b764353867ba624e67f4da6bcee3"

URI_x86_64_v2_kf6-kcodecs-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcodecs-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcodecs-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcodecs-doc}"
SRC_URI[x86_64_v2_kf6-kcodecs-doc.sha256sum] = "47bf3a956769ca7ceebdbeafce7f0a01912219f1136a86d1e11e1f5073385d86"

URI_x86_64_v2_kf6-kcodecs-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcodecs-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcodecs-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcodecs-html}"
SRC_URI[x86_64_v2_kf6-kcodecs-html.sha256sum] = "6ecffb34e040b98b61dfd4976892a961667c07e6de30f92e4a177602d848793a"

URI_aarch64_kf6-kcodecs = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcodecs-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kcodecs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcodecs}"
SRC_URI[aarch64_kf6-kcodecs.sha256sum] = "ac715c7f31c8fa5a14a0c3fd06698aafd5eb4f01eedba592f16aec4ea9eaf74f"

URI_aarch64_kf6-kcodecs-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcodecs-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kcodecs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcodecs-devel}"
SRC_URI[aarch64_kf6-kcodecs-devel.sha256sum] = "9b2095d0fdd9a439f509635720fef7d8d0a50daac915ff7b69a593f308885cdc"

URI_aarch64_kf6-kcodecs-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcodecs-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kcodecs-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcodecs-doc}"
SRC_URI[aarch64_kf6-kcodecs-doc.sha256sum] = "50eb487150a1391e26c9d0f2f8861802e856df495397333f1fffbcf883052748"

URI_aarch64_kf6-kcodecs-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcodecs-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kcodecs-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcodecs-html}"
SRC_URI[aarch64_kf6-kcodecs-html.sha256sum] = "1d2d5ac07ca0b312c4780628f21af7fc1190ffde0e8fb45c43e5e051cfcd7cfa"

RDEPENDS:kf6-kcodecs = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kcodecs-devel = " \
 cmake-filesystem \
 kf6-kcodecs \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kcodecs-doc = " \
 "
RDEPENDS:kf6-kcodecs-html = " \
 "
