# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bluez"
PV = "5.87+1.git30db66dc971b"
PR = "1.el10"
PACKAGES = " \
 bluez \
 bluez-cups \
 bluez-libs \
 bluez-libs-devel \
 bluez-obexd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/bluez-5.87+1.git30db66dc971b-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb2fd1de848dd5c2e6870ebf8ace87f1c6b73deba9dc3c37d4eb329a56ec2bfa"

URI_x86_64_v2_bluez = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/bluez-5.87+1.git30db66dc971b-1.el10.x86_64_v2.rpm;name=x86_64_v2_bluez;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluez}"
SRC_URI[x86_64_v2_bluez.sha256sum] = "7c20cacedde53c3b865c5f89b6504db21543080ec2ab31e9c03f09ef8a2f9643"

URI_x86_64_v2_bluez-cups = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bluez-cups-5.87+1.git30db66dc971b-1.el10.x86_64_v2.rpm;name=x86_64_v2_bluez-cups;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluez-cups}"
SRC_URI[x86_64_v2_bluez-cups.sha256sum] = "80019d39984f52ddb2f5b62d0989a990b98e645109d1fee83c61d87ea095ac34"

URI_x86_64_v2_bluez-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/bluez-libs-5.87+1.git30db66dc971b-1.el10.x86_64_v2.rpm;name=x86_64_v2_bluez-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluez-libs}"
SRC_URI[x86_64_v2_bluez-libs.sha256sum] = "1d3a6e938237bfc7f5a2c2a124132c1df4425abe05da1874d196fe147a5215c1"

URI_x86_64_v2_bluez-libs-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/bluez-libs-devel-5.87+1.git30db66dc971b-1.el10.x86_64_v2.rpm;name=x86_64_v2_bluez-libs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluez-libs-devel}"
SRC_URI[x86_64_v2_bluez-libs-devel.sha256sum] = "6b4bc1ff0bf06a46dc18ac5656d16f0a5073ce37ca75df518ef2a89c5b6be953"

URI_x86_64_v2_bluez-obexd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bluez-obexd-5.87+1.git30db66dc971b-1.el10.x86_64_v2.rpm;name=x86_64_v2_bluez-obexd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluez-obexd}"
SRC_URI[x86_64_v2_bluez-obexd.sha256sum] = "72ec2e8230199a46e7c17be436b55090e1a6407fea79b967df9234f098e34392"

URI_aarch64_bluez = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/bluez-5.87+1.git30db66dc971b-1.el10.aarch64.rpm;name=aarch64_bluez;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluez}"
SRC_URI[aarch64_bluez.sha256sum] = "580ffaa032b56592342792203457139f96380b570ed4172222fbfc0521c9ed7c"

URI_aarch64_bluez-cups = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bluez-cups-5.87+1.git30db66dc971b-1.el10.aarch64.rpm;name=aarch64_bluez-cups;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluez-cups}"
SRC_URI[aarch64_bluez-cups.sha256sum] = "99952e7d2f86a1e31926984995eb3b2e0dd80d6c70e9a55d04748916acf4bcb9"

URI_aarch64_bluez-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/bluez-libs-5.87+1.git30db66dc971b-1.el10.aarch64.rpm;name=aarch64_bluez-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluez-libs}"
SRC_URI[aarch64_bluez-libs.sha256sum] = "51e3c2c2665ed270ddfa5ece7668fa0157ffdc35c057c93493c19ddacfee818a"

URI_aarch64_bluez-libs-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/bluez-libs-devel-5.87+1.git30db66dc971b-1.el10.aarch64.rpm;name=aarch64_bluez-libs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluez-libs-devel}"
SRC_URI[aarch64_bluez-libs-devel.sha256sum] = "16a588d515e876d961c1e208c3bd0b8f24376116256cca97028d5d2de5bf3f1b"

URI_aarch64_bluez-obexd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bluez-obexd-5.87+1.git30db66dc971b-1.el10.aarch64.rpm;name=aarch64_bluez-obexd;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluez-obexd}"
SRC_URI[aarch64_bluez-obexd.sha256sum] = "efed9b04914112636c65a41169b1339e8c40e41f0f234d97c6006c1c695a137f"

RDEPENDS:bluez = " \
 bash \
 dbus \
 dbus-libs \
 glib2 \
 glibc \
 readline \
 systemd \
 systemd-libs \
 "
RDEPENDS:bluez-cups = " \
 bluez \
 cups \
 dbus-libs \
 glib2 \
 glibc \
 "
RDEPENDS:bluez-libs = " \
 glibc \
 "
RDEPENDS:bluez-libs-devel = " \
 bluez-libs \
 glibc \
 pkgconf-pkg-config \
 "
RDEPENDS:bluez-obexd = " \
 bash \
 bluez \
 bluez-libs \
 dbus-libs \
 glib2 \
 glibc \
 libical \
 systemd-libs \
 "
