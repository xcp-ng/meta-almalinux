# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "enchant"
PE = "1"
PV = "1.6.0"
PR = "39.el10_0"
PACKAGES = " \
 enchant \
 enchant-devel \
 enchant-voikko \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/enchant-1.6.0-39.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8c9913c0e59993d9ee5e87964cd063483ada42fc3add6a0ad8e8a32e7826926"

URI_x86_64_v2_enchant = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/enchant-1.6.0-39.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_enchant;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_enchant}"
SRC_URI[x86_64_v2_enchant.sha256sum] = "ae526850fa611dbe7a8891a1057eabce3517f434f00ef62c4c2ecad7241f8db3"

URI_x86_64_v2_enchant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/enchant-devel-1.6.0-39.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_enchant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_enchant-devel}"
SRC_URI[x86_64_v2_enchant-devel.sha256sum] = "ea1184012bd9528c1ca6344ce3c62a66095b3cf6f1d1328db8b247900391ae31"

URI_x86_64_v2_enchant-voikko = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/enchant-voikko-1.6.0-39.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_enchant-voikko;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_enchant-voikko}"
SRC_URI[x86_64_v2_enchant-voikko.sha256sum] = "f950dbbff931a5e6dd324adafd71a2c182c04551f986cd1e29eacd3af6e6cbe0"

URI_aarch64_enchant = "${EPEL_MIRROR}/aarch64/Packages/e/enchant-1.6.0-39.el10_0.aarch64.rpm;name=aarch64_enchant;unpack=0"
SRC_URI:append = " ${URI_aarch64_enchant}"
SRC_URI[aarch64_enchant.sha256sum] = "4308e2941211586ccaa7ccb8a31a78efebd04e87f8b7e86aa0a758d31da7248c"

URI_aarch64_enchant-devel = "${EPEL_MIRROR}/aarch64/Packages/e/enchant-devel-1.6.0-39.el10_0.aarch64.rpm;name=aarch64_enchant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_enchant-devel}"
SRC_URI[aarch64_enchant-devel.sha256sum] = "44ae6dc6aa2079ac93fb33bef67bc628a4461ad9f94147c17d73a7583473f18c"

URI_aarch64_enchant-voikko = "${EPEL_MIRROR}/aarch64/Packages/e/enchant-voikko-1.6.0-39.el10_0.aarch64.rpm;name=aarch64_enchant-voikko;unpack=0"
SRC_URI:append = " ${URI_aarch64_enchant-voikko}"
SRC_URI[aarch64_enchant-voikko.sha256sum] = "18daad1a4648bb9c9d43acc22031be1e67effd87e9c96db27c797eeb1fe25afc"

RDEPENDS:enchant = " \
 glib2 \
 glibc \
 hunspell \
 libgcc \
 libstdc++ \
 "
RDEPENDS:enchant-devel = " \
 enchant \
 glib2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:enchant-voikko = " \
 enchant \
 glib2 \
 glibc \
 libvoikko \
 "
