# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gstreamer1-plugins-ugly-free"
PV = "1.26.7"
PR = "2.el10_2.2"
PACKAGES = " \
 gstreamer1-plugins-ugly-free \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gstreamer1-plugins-ugly-free-1.26.7-2.el10_2.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab1a571328978c8cf01a5f0b571374ac39c9be28d00af7256aba13bfb4254934"

URI_x86_64_v2_gstreamer1-plugins-ugly-free = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-ugly-free-1.26.7-2.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-ugly-free;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-ugly-free}"
SRC_URI[x86_64_v2_gstreamer1-plugins-ugly-free.sha256sum] = "f1f3c129ff1616f85e7b241a3ed92b06e4c061c66e3a5a401e9b9558b05421d8"

URI_aarch64_gstreamer1-plugins-ugly-free = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-ugly-free-1.26.7-2.el10_2.2.aarch64.rpm;name=aarch64_gstreamer1-plugins-ugly-free;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-ugly-free}"
SRC_URI[aarch64_gstreamer1-plugins-ugly-free.sha256sum] = "06bee9913332130808f3d673c597a625b92d6def3b5bbc99f71781fcc3dc88dc"

RDEPENDS:gstreamer1-plugins-ugly-free = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 liba52 \
 libcdio \
 libdvdread \
 libmpeg2 \
 orc \
 "
