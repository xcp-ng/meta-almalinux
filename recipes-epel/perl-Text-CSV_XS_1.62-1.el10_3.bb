# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Text-CSV_XS"
PV = "1.62"
PR = "1.el10_3"
PACKAGES = " \
 perl-Text-CSV_XS \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Text-CSV_XS-1.62-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8d55ca1ed87692911ef451c1a03127b8520e7d5d8376528c010281aa6f8082d"

URI_x86_64_v2_perl-Text-CSV_XS = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Text-CSV_XS-1.62-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Text-CSV_XS;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Text-CSV_XS}"
SRC_URI[x86_64_v2_perl-Text-CSV_XS.sha256sum] = "38e8a8870d013c066f8555a6aa2b39b5d56581a5f58dcba5208a42c134fd5730"

URI_aarch64_perl-Text-CSV_XS = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Text-CSV_XS-1.62-1.el10_3.aarch64.rpm;name=aarch64_perl-Text-CSV_XS;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Text-CSV_XS}"
SRC_URI[aarch64_perl-Text-CSV_XS.sha256sum] = "dae94503b4ba91e2192ce7de11c69df7c484e82017126314e709456f75641645"

RDEPENDS:perl-Text-CSV_XS = " \
 glibc \
 perl-Carp \
 perl-Encode \
 perl-Exporter \
 perl-IO \
 perl-UNIVERSAL-isa \
 perl-libs \
 perl-vars \
 "
