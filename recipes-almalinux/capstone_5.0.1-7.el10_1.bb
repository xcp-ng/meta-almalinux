# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "capstone"
PV = "5.0.1"
PR = "7.el10_1"
PACKAGES = " \
 capstone \
 capstone-devel \
 capstone-java \
 python3-capstone \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/capstone-5.0.1-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ffe2661dc595a28c39181863354716d73b7bedf23672c5562adfe56fd4d6a48"

URI_x86_64_v2_capstone = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/capstone-5.0.1-7.el10_1.x86_64_v2.rpm;name=x86_64_v2_capstone;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_capstone}"
SRC_URI[x86_64_v2_capstone.sha256sum] = "4a789720bed38ad7fac458648b8960be11adf333e9c7da410c4fb37a76fa597b"

URI_x86_64_v2_capstone-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/capstone-devel-5.0.1-7.el10_1.x86_64_v2.rpm;name=x86_64_v2_capstone-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_capstone-devel}"
SRC_URI[x86_64_v2_capstone-devel.sha256sum] = "3ea929d84c64e037f556927827d0b899c6d0b47b548dc9c471fa9a2339a0d940"

URI_x86_64_v2_capstone-java = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/capstone-java-5.0.1-7.el10_1.noarch.rpm;name=x86_64_v2_capstone-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_capstone-java}"
SRC_URI[x86_64_v2_capstone-java.sha256sum] = "36251294e35a6e0b2ef616b0cf22e06128bc4128fe6a420826479315ae81cd62"

URI_x86_64_v2_python3-capstone = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-capstone-5.0.1-7.el10_1.noarch.rpm;name=x86_64_v2_python3-capstone;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-capstone}"
SRC_URI[x86_64_v2_python3-capstone.sha256sum] = "daba3469816d9404c9f5c2942c47365e3484d67ef717e1142b0e4f14ab75451e"

URI_aarch64_capstone = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/capstone-5.0.1-7.el10_1.aarch64.rpm;name=aarch64_capstone;unpack=0"
SRC_URI:append = " ${URI_aarch64_capstone}"
SRC_URI[aarch64_capstone.sha256sum] = "1e6c36725b6b5f1112348b17c9737626fb3074c5878a7769d18e91a07253a2fc"

URI_aarch64_capstone-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/capstone-devel-5.0.1-7.el10_1.aarch64.rpm;name=aarch64_capstone-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_capstone-devel}"
SRC_URI[aarch64_capstone-devel.sha256sum] = "60cabf1265bc6a2dec6795b3da38c9a1cfb1b95fc6e72320492244401c258448"

URI_aarch64_capstone-java = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/capstone-java-5.0.1-7.el10_1.noarch.rpm;name=aarch64_capstone-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_capstone-java}"
SRC_URI[aarch64_capstone-java.sha256sum] = "36251294e35a6e0b2ef616b0cf22e06128bc4128fe6a420826479315ae81cd62"

URI_aarch64_python3-capstone = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-capstone-5.0.1-7.el10_1.noarch.rpm;name=aarch64_python3-capstone;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-capstone}"
SRC_URI[aarch64_python3-capstone.sha256sum] = "daba3469816d9404c9f5c2942c47365e3484d67ef717e1142b0e4f14ab75451e"

RDEPENDS:capstone = " \
 glibc \
 "
RDEPENDS:capstone-devel = " \
 capstone \
 pkgconf-pkg-config \
 "
RDEPENDS:capstone-java = " \
 capstone \
 "
RDEPENDS:python3-capstone = " \
 capstone \
 python3 \
 "
