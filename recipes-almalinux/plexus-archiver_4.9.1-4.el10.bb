# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plexus-archiver"
PV = "4.9.1"
PR = "4.el10"
PACKAGES = " \
 plexus-archiver \
 plexus-archiver-javadoc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/plexus-archiver-4.9.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "52ca77de57653829c6014528fcaedd88864fac6746dd3ef21f1990a50102e568"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/plexus-archiver-4.9.1-4.el10.noarch.rpm;name=x86_64_v2_plexus-archiver;unpack=0"
SRC_URI[x86_64_v2_plexus-archiver.sha256sum] = "5ed9eaff22559e66accc5867e9d92f4138f262f8b85d9b3e08c50cfeb239ef25"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/plexus-archiver-javadoc-4.9.1-4.el10.noarch.rpm;name=x86_64_v2_plexus-archiver-javadoc;unpack=0"
SRC_URI[x86_64_v2_plexus-archiver-javadoc.sha256sum] = "b7d1229684bd7508870c237b634ea633e120e1635260d172ad269c15dc1b613f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/plexus-archiver-4.9.1-4.el10.noarch.rpm;name=aarch64_plexus-archiver;unpack=0"
SRC_URI[aarch64_plexus-archiver.sha256sum] = "5ed9eaff22559e66accc5867e9d92f4138f262f8b85d9b3e08c50cfeb239ef25"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/plexus-archiver-javadoc-4.9.1-4.el10.noarch.rpm;name=aarch64_plexus-archiver-javadoc;unpack=0"
SRC_URI[aarch64_plexus-archiver-javadoc.sha256sum] = "b7d1229684bd7508870c237b634ea633e120e1635260d172ad269c15dc1b613f"

RDEPENDS:plexus-archiver = " \
 apache-commons-compress \
 apache-commons-io \
 atinject \
 javapackages-filesystem \
 plexus-io \
 plexus-utils \
 slf4j \
 xz-java \
 "
RDEPENDS:plexus-archiver-javadoc = " \
 javapackages-filesystem \
 "
