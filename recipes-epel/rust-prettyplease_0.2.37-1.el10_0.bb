# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-prettyplease"
PV = "0.2.37"
PR = "1.el10_0"
PACKAGES = " \
 rust-prettyplease+default-devel \
 rust-prettyplease+verbatim-devel \
 rust-prettyplease-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-prettyplease-0.2.37-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f3d9ea7fb0681fa86e7a686d9bb713570800e0e499ba57bb4087ff45722751e"

URI_x86_64_v2_rust-prettyplease+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prettyplease+default-devel-0.2.37-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prettyplease+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prettyplease+default-devel}"
SRC_URI[x86_64_v2_rust-prettyplease+default-devel.sha256sum] = "831b98aa9f762d1a2ec04bad8491923efc46c126061805e648e7abff59610931"

URI_x86_64_v2_rust-prettyplease+verbatim-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prettyplease+verbatim-devel-0.2.37-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prettyplease+verbatim-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prettyplease+verbatim-devel}"
SRC_URI[x86_64_v2_rust-prettyplease+verbatim-devel.sha256sum] = "132ccdd571ce900cdc3303311cc045ac7c426e6c8c47b2f65d6f740db26eb188"

URI_x86_64_v2_rust-prettyplease-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prettyplease-devel-0.2.37-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prettyplease-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prettyplease-devel}"
SRC_URI[x86_64_v2_rust-prettyplease-devel.sha256sum] = "b5d49a024f4bca8d94ddc4d85f2e7e28e421ed69459e6c47c64bcbae2139c4c3"

URI_aarch64_rust-prettyplease+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prettyplease+default-devel-0.2.37-1.el10_0.noarch.rpm;name=aarch64_rust-prettyplease+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prettyplease+default-devel}"
SRC_URI[aarch64_rust-prettyplease+default-devel.sha256sum] = "c709b5544ba80682f9955b266f5d241012be8d9143ecde4cf9f801484bdf7379"

URI_aarch64_rust-prettyplease+verbatim-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prettyplease+verbatim-devel-0.2.37-1.el10_0.noarch.rpm;name=aarch64_rust-prettyplease+verbatim-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prettyplease+verbatim-devel}"
SRC_URI[aarch64_rust-prettyplease+verbatim-devel.sha256sum] = "488172a1637f59c36618a0755a17cf6549924e3d43c7147191ed689ea01f38a4"

URI_aarch64_rust-prettyplease-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prettyplease-devel-0.2.37-1.el10_0.noarch.rpm;name=aarch64_rust-prettyplease-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prettyplease-devel}"
SRC_URI[aarch64_rust-prettyplease-devel.sha256sum] = "93843adcb9c92077ed62c06927efc152fff9ea49fbe79ce3599b35228f9bfeba"

RDEPENDS:rust-prettyplease+default-devel = " \
 cargo \
 rust-prettyplease-devel \
 "
RDEPENDS:rust-prettyplease+verbatim-devel = " \
 cargo \
 rust-prettyplease-devel \
 rust-syn+parsing-devel \
 "
RDEPENDS:rust-prettyplease-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 rust-syn+full-devel \
 rust-syn-devel \
 "
