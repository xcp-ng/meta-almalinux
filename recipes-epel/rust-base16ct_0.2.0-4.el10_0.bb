# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-base16ct"
PV = "0.2.0"
PR = "4.el10_0"
PACKAGES = " \
 rust-base16ct+alloc-devel \
 rust-base16ct+default-devel \
 rust-base16ct+std-devel \
 rust-base16ct-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-base16ct-0.2.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6655b4c9a64a789c79858a45605d23ac9e3cdbe73213aaa4b094e671eb10763a"

URI_x86_64_v2_rust-base16ct+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base16ct+alloc-devel-0.2.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base16ct+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base16ct+alloc-devel}"
SRC_URI[x86_64_v2_rust-base16ct+alloc-devel.sha256sum] = "51d59f60475a796cb201a71b8712724fd6abf4e67bb087942ce53e3e8b164624"

URI_x86_64_v2_rust-base16ct+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base16ct+default-devel-0.2.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base16ct+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base16ct+default-devel}"
SRC_URI[x86_64_v2_rust-base16ct+default-devel.sha256sum] = "43cf0cab9bcd3257a728b6819356af09c3af1dabe7b5c92dc105473be5395dac"

URI_x86_64_v2_rust-base16ct+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base16ct+std-devel-0.2.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base16ct+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base16ct+std-devel}"
SRC_URI[x86_64_v2_rust-base16ct+std-devel.sha256sum] = "86b4be1f716653b6d07d574e5190b15458ecef39724fd2d5c37991ba1d7e58ba"

URI_x86_64_v2_rust-base16ct-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base16ct-devel-0.2.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base16ct-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base16ct-devel}"
SRC_URI[x86_64_v2_rust-base16ct-devel.sha256sum] = "0152499c153b7a905fa6307987ddee8d154bc65eb4ca97862af4941dbf4114b1"

URI_aarch64_rust-base16ct+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base16ct+alloc-devel-0.2.0-4.el10_0.noarch.rpm;name=aarch64_rust-base16ct+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base16ct+alloc-devel}"
SRC_URI[aarch64_rust-base16ct+alloc-devel.sha256sum] = "9c68753b7913128c94d403ababd5cfa7382c27b20f1023c605a79905ae1be88f"

URI_aarch64_rust-base16ct+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base16ct+default-devel-0.2.0-4.el10_0.noarch.rpm;name=aarch64_rust-base16ct+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base16ct+default-devel}"
SRC_URI[aarch64_rust-base16ct+default-devel.sha256sum] = "ec0667085a1efc71010b64f479237c2a904c6d7f1ded853c10a70d58586107b9"

URI_aarch64_rust-base16ct+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base16ct+std-devel-0.2.0-4.el10_0.noarch.rpm;name=aarch64_rust-base16ct+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base16ct+std-devel}"
SRC_URI[aarch64_rust-base16ct+std-devel.sha256sum] = "b7c8c3e1fb6fe064f72da222b1b1053b394138be660fde7c4e864e2a55196bf9"

URI_aarch64_rust-base16ct-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base16ct-devel-0.2.0-4.el10_0.noarch.rpm;name=aarch64_rust-base16ct-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base16ct-devel}"
SRC_URI[aarch64_rust-base16ct-devel.sha256sum] = "f669eaf9562bc6aff0abc0c9bf6a1c8ddf60715daa6504ba178df46090bbb214"

RDEPENDS:rust-base16ct+alloc-devel = " \
 cargo \
 rust-base16ct-devel \
 "
RDEPENDS:rust-base16ct+default-devel = " \
 cargo \
 rust-base16ct-devel \
 "
RDEPENDS:rust-base16ct+std-devel = " \
 cargo \
 rust-base16ct+alloc-devel \
 rust-base16ct-devel \
 "
RDEPENDS:rust-base16ct-devel = " \
 cargo \
 rust \
 "
