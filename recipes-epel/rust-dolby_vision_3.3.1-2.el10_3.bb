# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dolby_vision"
PV = "3.3.1"
PR = "2.el10_3"
PACKAGES = " \
 libdovi \
 libdovi-devel \
 rust-dolby_vision+capi-devel \
 rust-dolby_vision+default-devel \
 rust-dolby_vision+libc-devel \
 rust-dolby_vision+roxmltree-devel \
 rust-dolby_vision+serde-devel \
 rust-dolby_vision+xml-devel \
 rust-dolby_vision-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dolby_vision-3.3.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf26f72477dfaf2eae547fc393f135120751b9434316251f845cf2d0ee4acc5d"

URI_x86_64_v2_libdovi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdovi-3.3.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdovi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdovi}"
SRC_URI[x86_64_v2_libdovi.sha256sum] = "2f7034b10b99c1378b3bf0fc05381c9749ec2cc8ed059095f1bfa10dfef6a55c"

URI_x86_64_v2_libdovi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdovi-devel-3.3.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdovi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdovi-devel}"
SRC_URI[x86_64_v2_libdovi-devel.sha256sum] = "146cbef5bb8910a0e7cbcfda9c0f16906fcfae0896120676be01635ba2755018"

URI_x86_64_v2_rust-dolby_vision+capi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dolby_vision+capi-devel-3.3.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dolby_vision+capi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dolby_vision+capi-devel}"
SRC_URI[x86_64_v2_rust-dolby_vision+capi-devel.sha256sum] = "5df82c1718f443c03b7669e57713887702af4018ec59ca64fdbcc321eeff1732"

URI_x86_64_v2_rust-dolby_vision+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dolby_vision+default-devel-3.3.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dolby_vision+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dolby_vision+default-devel}"
SRC_URI[x86_64_v2_rust-dolby_vision+default-devel.sha256sum] = "dd0714a6104764ae08adb8bd8ba499dcaca1652ee578782f903d6cd1e80fd4d9"

URI_x86_64_v2_rust-dolby_vision+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dolby_vision+libc-devel-3.3.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dolby_vision+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dolby_vision+libc-devel}"
SRC_URI[x86_64_v2_rust-dolby_vision+libc-devel.sha256sum] = "3842fd5c2e570d84dde17c7f8d670b049024a5d93f2d135f98763fd72fcd0731"

URI_x86_64_v2_rust-dolby_vision+roxmltree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dolby_vision+roxmltree-devel-3.3.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dolby_vision+roxmltree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dolby_vision+roxmltree-devel}"
SRC_URI[x86_64_v2_rust-dolby_vision+roxmltree-devel.sha256sum] = "b2c6900cc830412283ead5c6354f3c826cc99d70f534a9e1df4b64889461b2f2"

URI_x86_64_v2_rust-dolby_vision+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dolby_vision+serde-devel-3.3.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dolby_vision+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dolby_vision+serde-devel}"
SRC_URI[x86_64_v2_rust-dolby_vision+serde-devel.sha256sum] = "8caded167222a4eddc4a53ae36a233cc6d5c88fede37d68dd1504bdd34a335b1"

URI_x86_64_v2_rust-dolby_vision+xml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dolby_vision+xml-devel-3.3.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dolby_vision+xml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dolby_vision+xml-devel}"
SRC_URI[x86_64_v2_rust-dolby_vision+xml-devel.sha256sum] = "c2d5b0b0d797ad1d2e144369133e15b914fd1824da896a7d483ca60ad180c3f4"

URI_x86_64_v2_rust-dolby_vision-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dolby_vision-devel-3.3.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dolby_vision-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dolby_vision-devel}"
SRC_URI[x86_64_v2_rust-dolby_vision-devel.sha256sum] = "63332fa5dc5a8a13716fd7f213dfe685c3416e7b6ac35bba7b149799be589f47"

URI_aarch64_libdovi = "${EPEL_MIRROR}/aarch64/Packages/l/libdovi-3.3.1-2.el10_3.aarch64.rpm;name=aarch64_libdovi;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdovi}"
SRC_URI[aarch64_libdovi.sha256sum] = "050e7c422b66f9a5c99bb0f68382e7a7073568cb535112444cf35a3d5dbd1776"

URI_aarch64_libdovi-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libdovi-devel-3.3.1-2.el10_3.aarch64.rpm;name=aarch64_libdovi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdovi-devel}"
SRC_URI[aarch64_libdovi-devel.sha256sum] = "f59d2c8333dcb5b5a409b706261dd7fe547b0100ee118bdffdb0cf2ccf7f6119"

URI_aarch64_rust-dolby_vision+capi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dolby_vision+capi-devel-3.3.1-2.el10_3.noarch.rpm;name=aarch64_rust-dolby_vision+capi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dolby_vision+capi-devel}"
SRC_URI[aarch64_rust-dolby_vision+capi-devel.sha256sum] = "606d68b25a8a137d9b37513ff5dd50d216be308e6fa8dee55201c3c5fd4e5ce9"

URI_aarch64_rust-dolby_vision+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dolby_vision+default-devel-3.3.1-2.el10_3.noarch.rpm;name=aarch64_rust-dolby_vision+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dolby_vision+default-devel}"
SRC_URI[aarch64_rust-dolby_vision+default-devel.sha256sum] = "97476cb58c8b789bd8c46cdbeb25f86d7435691fb2c936a00c0c91f411d213c4"

URI_aarch64_rust-dolby_vision+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dolby_vision+libc-devel-3.3.1-2.el10_3.noarch.rpm;name=aarch64_rust-dolby_vision+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dolby_vision+libc-devel}"
SRC_URI[aarch64_rust-dolby_vision+libc-devel.sha256sum] = "241e68c88d37631e40da51f72dfcf4ca883349b24210484452843e5624b2d624"

URI_aarch64_rust-dolby_vision+roxmltree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dolby_vision+roxmltree-devel-3.3.1-2.el10_3.noarch.rpm;name=aarch64_rust-dolby_vision+roxmltree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dolby_vision+roxmltree-devel}"
SRC_URI[aarch64_rust-dolby_vision+roxmltree-devel.sha256sum] = "4e39ce7be82fa722bb81a0ecb9c8e8747c0b680877b62a3721289dcbde2aa314"

URI_aarch64_rust-dolby_vision+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dolby_vision+serde-devel-3.3.1-2.el10_3.noarch.rpm;name=aarch64_rust-dolby_vision+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dolby_vision+serde-devel}"
SRC_URI[aarch64_rust-dolby_vision+serde-devel.sha256sum] = "8413758246cea82bfe2618f8e8068061b7ddf844760f0cfd825a31f958ff3dea"

URI_aarch64_rust-dolby_vision+xml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dolby_vision+xml-devel-3.3.1-2.el10_3.noarch.rpm;name=aarch64_rust-dolby_vision+xml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dolby_vision+xml-devel}"
SRC_URI[aarch64_rust-dolby_vision+xml-devel.sha256sum] = "2aac74614cef5dd83597407e19346eb0211d34206343e6dab70aa6f608951366"

URI_aarch64_rust-dolby_vision-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dolby_vision-devel-3.3.1-2.el10_3.noarch.rpm;name=aarch64_rust-dolby_vision-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dolby_vision-devel}"
SRC_URI[aarch64_rust-dolby_vision-devel.sha256sum] = "d2e333038a812ad90bb8018842b833639a8f1f23ec8a856eeac4075e4288b1fa"

RDEPENDS:libdovi = " \
 glibc \
 libgcc \
 "
RDEPENDS:libdovi-devel = " \
 libdovi \
 pkgconf-pkg-config \
 "
RDEPENDS:rust-dolby_vision+capi-devel = " \
 cargo \
 rust-dolby_vision+libc-devel \
 rust-dolby_vision-devel \
 "
RDEPENDS:rust-dolby_vision+default-devel = " \
 cargo \
 rust-dolby_vision-devel \
 "
RDEPENDS:rust-dolby_vision+libc-devel = " \
 cargo \
 rust-dolby_vision-devel \
 rust-libc+default-devel \
 "
RDEPENDS:rust-dolby_vision+roxmltree-devel = " \
 cargo \
 rust-dolby_vision-devel \
 rust-roxmltree+default-devel \
 "
RDEPENDS:rust-dolby_vision+serde-devel = " \
 cargo \
 rust-dolby_vision-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-serde_json+preserve_order-devel \
 rust-tinyvec+serde-devel \
 "
RDEPENDS:rust-dolby_vision+xml-devel = " \
 cargo \
 rust-dolby_vision+roxmltree-devel \
 rust-dolby_vision-devel \
 "
RDEPENDS:rust-dolby_vision-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-bitvec+default-devel \
 rust-bitvec_helpers+bitstream-io-devel \
 rust-bitvec_helpers-devel \
 rust-crc+default-devel \
 rust-tinyvec+default-devel \
 rust-tinyvec+rustc_1_55-devel \
 "
