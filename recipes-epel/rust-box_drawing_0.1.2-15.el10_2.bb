# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-box_drawing"
PV = "0.1.2"
PR = "15.el10_2"
PACKAGES = " \
 rust-box_drawing+default-devel \
 rust-box_drawing-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-box_drawing-0.1.2-15.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9049c2e9a18c9223e5e7980122416cafe58bb633c45f4c81a10c10e5813dbc43"

URI_x86_64_v2_rust-box_drawing+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-box_drawing+default-devel-0.1.2-15.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-box_drawing+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-box_drawing+default-devel}"
SRC_URI[x86_64_v2_rust-box_drawing+default-devel.sha256sum] = "32c5e9737ff5aede0467a7cace7a0aa68080d85f8862edf6e7c6522b37ebb53e"

URI_x86_64_v2_rust-box_drawing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-box_drawing-devel-0.1.2-15.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-box_drawing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-box_drawing-devel}"
SRC_URI[x86_64_v2_rust-box_drawing-devel.sha256sum] = "f9791683f736d88aae3dcb47f2f8f06a545df08e410ed808acf17b905ce2fbc7"

URI_aarch64_rust-box_drawing+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-box_drawing+default-devel-0.1.2-15.el10_2.noarch.rpm;name=aarch64_rust-box_drawing+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-box_drawing+default-devel}"
SRC_URI[aarch64_rust-box_drawing+default-devel.sha256sum] = "307d6a70e34a766218ff411b0406f43905af861cb984898808f4ae44cbebf16b"

URI_aarch64_rust-box_drawing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-box_drawing-devel-0.1.2-15.el10_2.noarch.rpm;name=aarch64_rust-box_drawing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-box_drawing-devel}"
SRC_URI[aarch64_rust-box_drawing-devel.sha256sum] = "75115995395e0afa91cf5d4891b92f490f205a2affa1d986d730e3576401d4b4"

RDEPENDS:rust-box_drawing+default-devel = " \
 cargo \
 rust-box_drawing-devel \
 "
RDEPENDS:rust-box_drawing-devel = " \
 cargo \
 "
