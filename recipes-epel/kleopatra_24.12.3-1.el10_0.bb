# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kleopatra"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kleopatra \
 kleopatra-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kleopatra-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a9ebd94db5ff1d73c132eb7ef751c41fc2b7d62499ddba476bee8a531a7f5f9"

URI_x86_64_v2_kleopatra = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kleopatra-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kleopatra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kleopatra}"
SRC_URI[x86_64_v2_kleopatra.sha256sum] = "fe932fa34c2be0c2360504a411247123b34537d5d172a85510b11fd275aa192a"

URI_x86_64_v2_kleopatra-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kleopatra-libs-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kleopatra-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kleopatra-libs}"
SRC_URI[x86_64_v2_kleopatra-libs.sha256sum] = "b85e2cbab45dc29a692abcd928a64a1bca4cc4b208762608635f79b0110d63e0"

URI_aarch64_kleopatra = "${EPEL_MIRROR}/aarch64/Packages/k/kleopatra-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kleopatra;unpack=0"
SRC_URI:append = " ${URI_aarch64_kleopatra}"
SRC_URI[aarch64_kleopatra.sha256sum] = "236dc5589b4fa22af453c1a21dbc7fb7853d1fae85f937f40d5863a894e1f96d"

URI_aarch64_kleopatra-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kleopatra-libs-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kleopatra-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kleopatra-libs}"
SRC_URI[aarch64_kleopatra-libs.sha256sum] = "0ce0489e10e3b152cf2aa041e70d129340ac0de874639c0c9b273b6403d36bf3"

RDEPENDS:kleopatra = " \
 akonadi-mime \
 glibc \
 gpgmepp \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kitemmodels \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kidentitymanagement \
 kleopatra-libs \
 kmailtransport \
 kmime \
 libassuan \
 libgcc \
 libgpg-error \
 libkleo \
 libstdc++ \
 mimetreeparser \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kleopatra-libs = " \
 glibc \
 gpgmepp \
 kf6-kcoreaddons \
 kf6-ki18n \
 kleopatra \
 libassuan \
 libgcc \
 libgpg-error \
 libkleo \
 libstdc++ \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
