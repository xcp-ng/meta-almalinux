# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Text-CSV"
PV = "2.06"
PR = "1.el10_1"
PACKAGES = " \
 perl-Text-CSV \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Text-CSV-2.06-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7d5a23919ca3fd5474f64ebdd456decd5119a72015f10a2f8b8dfca5ac9ff38a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Text-CSV-2.06-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Text-CSV;unpack=0"
SRC_URI[x86_64_v2_perl-Text-CSV.sha256sum] = "decde04b2dde1442a970345dc59f6c025f1b08d136427a398d4acb733e888a71"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Text-CSV-2.06-1.el10_1.noarch.rpm;name=aarch64_perl-Text-CSV;unpack=0"
SRC_URI[aarch64_perl-Text-CSV.sha256sum] = "e5964998d5eaa39c564e431739735e809ec0046ef6c6c9ac1cdbc2e91a9a6ac1"

RDEPENDS:perl-Text-CSV = " \
 perl-Carp \
 perl-Exporter \
 perl-IO \
 perl-libs \
 perl-overload \
 perl-vars \
 "
