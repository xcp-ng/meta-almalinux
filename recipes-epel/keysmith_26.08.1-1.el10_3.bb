# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keysmith"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 keysmith \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/keysmith-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "214b6d7455c5ed1d33e29dc7ab9e3972391f7ad365ab7474394af89e425fc0c9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/keysmith-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_keysmith;unpack=0"
SRC_URI[x86_64_v2_keysmith.sha256sum] = "4401086b412c3d8d962e482acce25fa44cf278afa0d0c534c994998a9c908807"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/keysmith-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_keysmith;unpack=0"
SRC_URI[aarch64_keysmith.sha256sum] = "9d745644ab698f964680b6f8f8aad9efac30acb014eeffcf67873f500c7616a3"

RDEPENDS:keysmith = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kwindowsystem \
 kf6-prison \
 kf6-qqc2-desktop-style \
 libsodium \
 libstdc++ \
 openssl-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
