# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "squidclamav"
PV = "7.4"
PR = "1.el10_1"
PACKAGES = " \
 squidclamav \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/squidclamav-7.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b5b622bc2e1524c4866135861b3947206874548439910983fc34de5cbe651af9"

URI_x86_64_v2_squidclamav = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/squidclamav-7.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_squidclamav;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_squidclamav}"
SRC_URI[x86_64_v2_squidclamav.sha256sum] = "ac5dec1bcb0ce2553853fa8107c1dbc013effb3c2b6c052557c3950ab0749472"

URI_aarch64_squidclamav = "${EPEL_MIRROR}/aarch64/Packages/s/squidclamav-7.4-1.el10_1.aarch64.rpm;name=aarch64_squidclamav;unpack=0"
SRC_URI:append = " ${URI_aarch64_squidclamav}"
SRC_URI[aarch64_squidclamav.sha256sum] = "3a4c0b03af2f402045b94d60c851fce20b6002a5c0e381de364c4e3dd25b6973"

RDEPENDS:squidclamav = " \
 bzip2-libs \
 c-icap \
 glibc \
 httpd-filesystem \
 libarchive \
 perl-interpreter \
 squid \
 zlib-ng-compat \
 "
