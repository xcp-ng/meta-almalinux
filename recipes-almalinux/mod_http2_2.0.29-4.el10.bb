# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mod_http2"
PV = "2.0.29"
PR = "4.el10"
PACKAGES = " \
 mod_http2 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mod_http2-2.0.29-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "017c4b163146977fe789ba1717ca4b1aa667fdc5f2ebc44e2f75b7418d07a4eb"

URI_x86_64_v2_mod_http2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_http2-2.0.29-4.el10.x86_64_v2.rpm;name=x86_64_v2_mod_http2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_http2}"
SRC_URI[x86_64_v2_mod_http2.sha256sum] = "be7fb993ff66cd59713ceebc221d45da66ab384ba16d084a1247313f4d8eacbb"

URI_aarch64_mod_http2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_http2-2.0.29-4.el10.aarch64.rpm;name=aarch64_mod_http2;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_http2}"
SRC_URI[aarch64_mod_http2.sha256sum] = "706be179d775e300abfb71db996ec4ddc7330cff5d2c77f1f626357b17892d7b"

RDEPENDS:mod_http2 = " \
 glibc \
 httpd-core \
 libnghttp2 \
 openssl-libs \
 "
