# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-XS-Parse-Keyword-epel"
PV = "0.39"
PR = "8.el10_1"
PACKAGES = " \
 perl-XS-Parse-Keyword-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-XS-Parse-Keyword-epel-0.39-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f29b82a6e26b0648f1c1df7f50408e2976cd42b08644c3a57c763c0be9c18e1"

URI_x86_64_v2_perl-XS-Parse-Keyword-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-XS-Parse-Keyword-tests-0.39-8.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-XS-Parse-Keyword-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XS-Parse-Keyword-tests}"
SRC_URI[x86_64_v2_perl-XS-Parse-Keyword-tests.sha256sum] = "590c292c6c5dc3c9110e5d91f47a3a95b18ff858f1200ede28ea2465a3df24c0"

URI_aarch64_perl-XS-Parse-Keyword-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-XS-Parse-Keyword-tests-0.39-8.el10_1.aarch64.rpm;name=aarch64_perl-XS-Parse-Keyword-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XS-Parse-Keyword-tests}"
SRC_URI[aarch64_perl-XS-Parse-Keyword-tests.sha256sum] = "69d3141b225e36f26f2cd1a2a308ff0917b06d9c705e7a29675c4d45d0787d62"

RDEPENDS:perl-XS-Parse-Keyword-tests = " \
 bash \
 glibc \
 perl-B \
 perl-Test-Harness \
 perl-Test2-Suite \
 perl-XS-Parse-Keyword \
 perl-constant \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-overload \
 "
