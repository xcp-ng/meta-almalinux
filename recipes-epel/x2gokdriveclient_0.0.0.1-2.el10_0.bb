# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "x2gokdriveclient"
PV = "0.0.0.1"
PR = "2.el10_0"
PACKAGES = " \
 x2gokdriveclient \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/x2gokdriveclient-0.0.0.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1a29054016ea93337e246c6507e59771850aebce677ebad87eff58470d00f8c"

URI_x86_64_v2_x2gokdriveclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/x2gokdriveclient-0.0.0.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_x2gokdriveclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_x2gokdriveclient}"
SRC_URI[x86_64_v2_x2gokdriveclient.sha256sum] = "a3dce4b5a26be7220faaf259fde435e7e972bcc2a131ce6c640b808f6415fbd6"

URI_aarch64_x2gokdriveclient = "${EPEL_MIRROR}/aarch64/Packages/x/x2gokdriveclient-0.0.0.1-2.el10_0.aarch64.rpm;name=aarch64_x2gokdriveclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_x2gokdriveclient}"
SRC_URI[aarch64_x2gokdriveclient.sha256sum] = "3bc9c8d3ff95c04dfb54894377aafc3a344fb3774983d03b6a9c301864675c6d"

RDEPENDS:x2gokdriveclient = " \
 glibc \
 libgcc \
 libstdc++ \
 libxcb \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtx11extras \
 zlib-ng-compat \
 "
