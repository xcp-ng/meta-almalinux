# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unicode-linebreak"
PV = "0.1.5"
PR = "3.el10_0"
PACKAGES = " \
 rust-unicode-linebreak+default-devel \
 rust-unicode-linebreak-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unicode-linebreak-0.1.5-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "252d0bbfa0a9b7b07f6b005a2798506baa7e6d193a88b277dab4d4599fc1fe64"

URI_x86_64_v2_rust-unicode-linebreak+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-linebreak+default-devel-0.1.5-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-linebreak+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-linebreak+default-devel}"
SRC_URI[x86_64_v2_rust-unicode-linebreak+default-devel.sha256sum] = "e68005ad55015b9fbed33b6e9813445eec103ad2c57e422ede992992e3dddf7b"

URI_x86_64_v2_rust-unicode-linebreak-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-linebreak-devel-0.1.5-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-linebreak-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-linebreak-devel}"
SRC_URI[x86_64_v2_rust-unicode-linebreak-devel.sha256sum] = "ea1a0e2f4c079a6b2a2552225765ddcf9fe5abf6a74d2cb99d81df3888c76dfb"

URI_aarch64_rust-unicode-linebreak+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-linebreak+default-devel-0.1.5-3.el10_0.noarch.rpm;name=aarch64_rust-unicode-linebreak+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-linebreak+default-devel}"
SRC_URI[aarch64_rust-unicode-linebreak+default-devel.sha256sum] = "d4a3bdce424e62d5f3fce8a8bd0d2367c39bf5cc4ede7deecd26d8326964d8b1"

URI_aarch64_rust-unicode-linebreak-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-linebreak-devel-0.1.5-3.el10_0.noarch.rpm;name=aarch64_rust-unicode-linebreak-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-linebreak-devel}"
SRC_URI[aarch64_rust-unicode-linebreak-devel.sha256sum] = "c86b3d2d4c5bd91b6f1b445064797b8b09b54e4c3596cc2d768370ab736ff7fb"

RDEPENDS:rust-unicode-linebreak+default-devel = " \
 cargo \
 rust-unicode-linebreak-devel \
 "
RDEPENDS:rust-unicode-linebreak-devel = " \
 cargo \
 rust \
 "
