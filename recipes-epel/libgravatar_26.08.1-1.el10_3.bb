# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgravatar"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 libgravatar \
 libgravatar-devel \
 libgravatar-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libgravatar-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f63eb20fcb1336f04772aa06ee300f02fbe1c2b01450cf697f3a83dbf74ce0d3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgravatar-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgravatar;unpack=0"
SRC_URI[x86_64_v2_libgravatar.sha256sum] = "43e5f3a787958a0e3dc03f403e03d01a7424efc5345131fe1e02bbb5b2ae61c4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgravatar-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgravatar-devel;unpack=0"
SRC_URI[x86_64_v2_libgravatar-devel.sha256sum] = "532187f973435847a72a763a753599d5b4184c53e5b9ec257ff4bdce37670de0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgravatar-doc-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_libgravatar-doc;unpack=0"
SRC_URI[x86_64_v2_libgravatar-doc.sha256sum] = "057da4edfbee7092c083191f0553c8c324697d2f03ed3bebe483724610e65d8d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libgravatar-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_libgravatar;unpack=0"
SRC_URI[aarch64_libgravatar.sha256sum] = "77b19766a136bae895dca6b0487a8aca209930a4cdcba79f624d96d3dfb77026"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libgravatar-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_libgravatar-devel;unpack=0"
SRC_URI[aarch64_libgravatar-devel.sha256sum] = "a54a415421ddb22fa4997dd4c9d79b0379c6d4411949156a65968a08f510fd05"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libgravatar-doc-26.08.1-1.el10_3.noarch.rpm;name=aarch64_libgravatar-doc;unpack=0"
SRC_URI[aarch64_libgravatar-doc.sha256sum] = "c98936ac170bb651e0123a116a6fd595460db23d4379be5967b3e78691b803f4"

RDEPENDS:libgravatar = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libgravatar-devel = " \
 cmake-filesystem \
 libgravatar \
 "
RDEPENDS:libgravatar-doc = " \
 "
