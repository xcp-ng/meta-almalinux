# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-octaviaclient"
PV = "3.13.0"
PR = "2.el10_2"
PACKAGES = " \
 python3-octaviaclient \
 python3-octaviaclient-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-octaviaclient-3.13.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "322cf48dd6a25231e89d8919c02e62c606c08619bc48eddcc0f42301bdc2ad4a"

URI_x86_64_v2_python3-octaviaclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-octaviaclient-3.13.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-octaviaclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-octaviaclient}"
SRC_URI[x86_64_v2_python3-octaviaclient.sha256sum] = "9e6d9eae4f3ac4aca9e6e36e8182c29313c4fd9e338e8c513d817baded528554"

URI_x86_64_v2_python3-octaviaclient-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-octaviaclient-tests-3.13.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-octaviaclient-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-octaviaclient-tests}"
SRC_URI[x86_64_v2_python3-octaviaclient-tests.sha256sum] = "7038c48c07f1bdbeaadda6430ad09b04befbac77c9eaeade7ed1da9055f7641d"

URI_aarch64_python3-octaviaclient = "${EPEL_MIRROR}/aarch64/Packages/p/python3-octaviaclient-3.13.0-2.el10_2.noarch.rpm;name=aarch64_python3-octaviaclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-octaviaclient}"
SRC_URI[aarch64_python3-octaviaclient.sha256sum] = "a81774b9f2b8a9c6004e331d7f336562d97bc910cd361fe496cc33c00cd3c761"

URI_aarch64_python3-octaviaclient-tests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-octaviaclient-tests-3.13.0-2.el10_2.noarch.rpm;name=aarch64_python3-octaviaclient-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-octaviaclient-tests}"
SRC_URI[aarch64_python3-octaviaclient-tests.sha256sum] = "ad6fb7942847aa6b8a5c0e8baecc48d8fe5b3176da40f0c9f0e86ff9dbe8fb5d"

RDEPENDS:python3-octaviaclient = " \
 python3 \
 python3-cliff \
 python3-keystoneauth1 \
 python3-openstackclient \
 python3-osc-lib \
 python3-oslo-serialization \
 python3-oslo-utils \
 python3-pbr \
 python3-requests \
 "
RDEPENDS:python3-octaviaclient-tests = " \
 python3 \
 python3-fixtures \
 python3-octaviaclient \
 python3-openstackclient \
 python3-osc-lib \
 python3-oslo-log \
 python3-stestr \
 python3-subunit \
 python3-testtools \
 python3-webob \
 "
