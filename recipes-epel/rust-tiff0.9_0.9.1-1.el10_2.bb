# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tiff0.9"
PV = "0.9.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-tiff0.9+default-devel \
 rust-tiff0.9-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tiff0.9-0.9.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3738b3b8d5fc03b8e0841b9a5c65807f76d511721e255bc5dd4456744a175ce3"

URI_x86_64_v2_rust-tiff0.9+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiff0.9+default-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiff0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiff0.9+default-devel}"
SRC_URI[x86_64_v2_rust-tiff0.9+default-devel.sha256sum] = "248941e42aba43f5262a5170d542bf5b369364302602ba7dd0297df385355d52"

URI_x86_64_v2_rust-tiff0.9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiff0.9-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiff0.9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiff0.9-devel}"
SRC_URI[x86_64_v2_rust-tiff0.9-devel.sha256sum] = "8d14d5926d4ac7b1fe0c6989ec3fe2b28125b3a5e06438e20b238e5bc7b7c8c0"

URI_aarch64_rust-tiff0.9+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiff0.9+default-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-tiff0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiff0.9+default-devel}"
SRC_URI[aarch64_rust-tiff0.9+default-devel.sha256sum] = "e468332e78a28b54bf2ab2d3d65d928c49cb16176938b87c30e7060da0abe6c2"

URI_aarch64_rust-tiff0.9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiff0.9-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-tiff0.9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiff0.9-devel}"
SRC_URI[aarch64_rust-tiff0.9-devel.sha256sum] = "40f62b2e344ccd411dc82d6cee74e41c89e66d9b64aad362e10e19092c250f8c"

RDEPENDS:rust-tiff0.9+default-devel = " \
 cargo \
 rust-tiff0.9-devel \
 "
RDEPENDS:rust-tiff0.9-devel = " \
 cargo \
 rust \
 rust-flate2+default-devel \
 rust-jpeg-decoder-devel \
 rust-weezl+default-devel \
 "
