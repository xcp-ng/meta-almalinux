# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "coturn"
PV = "4.17.2"
PR = "1.el10_2"
PACKAGES = " \
 coturn \
 coturn-client-devel \
 coturn-client-libs \
 coturn-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/coturn-4.17.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50dd7d2677caa779c359f48f7c7df5f9eda591e412bd2eca64099a1ffc9f2bdf"

URI_x86_64_v2_coturn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/coturn-4.17.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_coturn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_coturn}"
SRC_URI[x86_64_v2_coturn.sha256sum] = "3d9deb81f7e9321608b5535e860dd2246de7b6f8db980bb69c96e856c34cb086"

URI_x86_64_v2_coturn-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/coturn-client-devel-4.17.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_coturn-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_coturn-client-devel}"
SRC_URI[x86_64_v2_coturn-client-devel.sha256sum] = "bdcb8f7358772e4037d5bd3636ac984b98d47f184f8c51f5e7a6f640391eaae5"

URI_x86_64_v2_coturn-client-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/coturn-client-libs-4.17.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_coturn-client-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_coturn-client-libs}"
SRC_URI[x86_64_v2_coturn-client-libs.sha256sum] = "e9ed70c50a668cb88c864a6d81298fb9d4756133bef0dcc40adfed10c8bd8479"

URI_x86_64_v2_coturn-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/coturn-utils-4.17.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_coturn-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_coturn-utils}"
SRC_URI[x86_64_v2_coturn-utils.sha256sum] = "9a9c725ee9e30bb042768bae5bbe4c8d114137f492c9b1ebc3788a7a7a274d7b"

URI_aarch64_coturn = "${EPEL_MIRROR}/aarch64/Packages/c/coturn-4.17.2-1.el10_2.aarch64.rpm;name=aarch64_coturn;unpack=0"
SRC_URI:append = " ${URI_aarch64_coturn}"
SRC_URI[aarch64_coturn.sha256sum] = "f099919a46006543542a95fb5c43565194450016732985eb0d34deb5d9d62204"

URI_aarch64_coturn-client-devel = "${EPEL_MIRROR}/aarch64/Packages/c/coturn-client-devel-4.17.2-1.el10_2.aarch64.rpm;name=aarch64_coturn-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_coturn-client-devel}"
SRC_URI[aarch64_coturn-client-devel.sha256sum] = "b4b1d32045e45da36ee7d8e83ebf4d6163b60e1c3b61a35de921bbc6f49861d1"

URI_aarch64_coturn-client-libs = "${EPEL_MIRROR}/aarch64/Packages/c/coturn-client-libs-4.17.2-1.el10_2.aarch64.rpm;name=aarch64_coturn-client-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_coturn-client-libs}"
SRC_URI[aarch64_coturn-client-libs.sha256sum] = "8c4095dc8fa723cff77e9b2628138d8d22110bcfb9ea099fd02857c95b175688"

URI_aarch64_coturn-utils = "${EPEL_MIRROR}/aarch64/Packages/c/coturn-utils-4.17.2-1.el10_2.aarch64.rpm;name=aarch64_coturn-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_coturn-utils}"
SRC_URI[aarch64_coturn-utils.sha256sum] = "6a3ad329e808d37e44587ad12f08757026d8d5f4d8a78bb6a89bb003c75d7d29"

RDEPENDS:coturn = " \
 bash \
 glibc \
 hiredis \
 libevent \
 libmicrohttpd \
 libpq \
 mariadb-connector-c \
 openssl-libs \
 shadow-utils \
 sqlite-libs \
 systemd \
 systemd-libs \
 "
RDEPENDS:coturn-client-devel = " \
 "
RDEPENDS:coturn-client-libs = " \
 "
RDEPENDS:coturn-utils = " \
 glibc \
 libevent \
 openssl-libs \
 "
