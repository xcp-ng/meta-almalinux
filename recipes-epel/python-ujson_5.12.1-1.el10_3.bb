# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ujson"
PV = "5.12.1"
PR = "1.el10_3"
PACKAGES = " \
 python3-ujson \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-ujson-5.12.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cda9ec751ffef68642ca1453ad421f8176b2f394524ebf5589bf2195d9f024d1"

URI_x86_64_v2_python3-ujson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ujson-5.12.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-ujson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ujson}"
SRC_URI[x86_64_v2_python3-ujson.sha256sum] = "531b70d7d3db723ed0a6ca8128231cd14977f9cc1fa2dbe4ce6adb342be3d6a3"

URI_aarch64_python3-ujson = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ujson-5.12.1-1.el10_3.aarch64.rpm;name=aarch64_python3-ujson;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ujson}"
SRC_URI[aarch64_python3-ujson.sha256sum] = "7c26334b9b1d62fcd826838411a6cebdf72590e2cf1750a640fdad32a6feab3c"

RDEPENDS:python3-ujson = " \
 double-conversion \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
