# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libvpl-tools"
PV = "1.6.0"
PR = "1.el10_3"
PACKAGES:x86_64_v2 = " \
 libvpl-tools \
 libvpl-tools-devel \
 libvpl-tools-libs \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/l/libvpl-tools-1.6.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "08e54c6ff60d019b8a461284e068106b7375621a1ae82a937ca7c6be501cdc1d"

URI_x86_64_v2_libvpl-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvpl-tools-1.6.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvpl-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvpl-tools}"
SRC_URI[x86_64_v2_libvpl-tools.sha256sum] = "440786b876ba4c512d20e159264b9c74c93a894cf52c72edcebded9a651d5312"

URI_x86_64_v2_libvpl-tools-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvpl-tools-devel-1.6.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvpl-tools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvpl-tools-devel}"
SRC_URI[x86_64_v2_libvpl-tools-devel.sha256sum] = "c1e781bd04b63c00abc7d78ac826faa4b71b3022bd69c4a2e234d5a605261952"

URI_x86_64_v2_libvpl-tools-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvpl-tools-libs-1.6.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvpl-tools-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvpl-tools-libs}"
SRC_URI[x86_64_v2_libvpl-tools-libs.sha256sum] = "353c73491630a9e982b30329a2a2dae61f5d331c0025e8e424184a801af8123b"

RDEPENDS:libvpl-tools = " \
 glib2 \
 glibc \
 glibmm2.68 \
 gtk4 \
 gtkmm4.0 \
 libX11 \
 libepoxy \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libva \
 libvpl \
 libvpl-tools-libs \
 "
RDEPENDS:libvpl-tools-devel = " \
 libvpl-tools-libs \
 "
RDEPENDS:libvpl-tools-libs = " \
 glibc \
 libdrm \
 libgcc \
 libstdc++ \
 libvpl-tools \
 libwayland-client \
 "
