# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-mkdocs-gen-files"
PV = "0.6.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-mkdocs-gen-files \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-mkdocs-gen-files-0.6.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47051d41b8aaf5dbaf2500a3b321ec058a45805c1565c2f21b03a17a14fd7893"

URI_x86_64_v2_python3-mkdocs-gen-files = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mkdocs-gen-files-0.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mkdocs-gen-files;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mkdocs-gen-files}"
SRC_URI[x86_64_v2_python3-mkdocs-gen-files.sha256sum] = "8766399a1a87639deba983c061a78ab692872b316bc09c2caf0611d284276339"

URI_aarch64_python3-mkdocs-gen-files = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mkdocs-gen-files-0.6.0-1.el10_2.noarch.rpm;name=aarch64_python3-mkdocs-gen-files;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mkdocs-gen-files}"
SRC_URI[aarch64_python3-mkdocs-gen-files.sha256sum] = "cf5c37ea4ff8bc577087b4d6f4568b1b03cfdd55e119a47775eb8a1d0fbd8214"

RDEPENDS:python3-mkdocs-gen-files = " \
 mkdocs \
 python3 \
 "
