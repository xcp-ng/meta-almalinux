# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_properties"
PV = "1.5.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-icu_properties+bidi-devel \
 rust-icu_properties+compiled_data-devel \
 rust-icu_properties+datagen-devel \
 rust-icu_properties+default-devel \
 rust-icu_properties+serde-devel \
 rust-icu_properties+std-devel \
 rust-icu_properties-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_properties-1.5.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91e31d1d4c085491af7efc9ca61bdc5b6c54dad3df78f2091aef6d248480d3a3"

URI_x86_64_v2_rust-icu_properties+bidi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_properties+bidi-devel-1.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_properties+bidi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_properties+bidi-devel}"
SRC_URI[x86_64_v2_rust-icu_properties+bidi-devel.sha256sum] = "b2d6d962b97b6e09f93751d7ed5faea4137f3423aed307117fb8a6317aa875aa"

URI_x86_64_v2_rust-icu_properties+compiled_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_properties+compiled_data-devel-1.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_properties+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_properties+compiled_data-devel}"
SRC_URI[x86_64_v2_rust-icu_properties+compiled_data-devel.sha256sum] = "f7778e1e278507586c0936fd9fd93da157fe5a00862bf166fc9bee16e8b87fdf"

URI_x86_64_v2_rust-icu_properties+datagen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_properties+datagen-devel-1.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_properties+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_properties+datagen-devel}"
SRC_URI[x86_64_v2_rust-icu_properties+datagen-devel.sha256sum] = "e5649f34675a8b7b9a53876b3f86479cf9fe4723051a5dec5185d0f5f45b8108"

URI_x86_64_v2_rust-icu_properties+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_properties+default-devel-1.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_properties+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_properties+default-devel}"
SRC_URI[x86_64_v2_rust-icu_properties+default-devel.sha256sum] = "68393dce2d3f7a47a5036eed3aebca34dc40513a580693e0b204cb3db39b3a1c"

URI_x86_64_v2_rust-icu_properties+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_properties+serde-devel-1.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_properties+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_properties+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_properties+serde-devel.sha256sum] = "9871c19bc4a8dd42328b9d8e4289016026660744be9a1e77aa89fbeb163d7c79"

URI_x86_64_v2_rust-icu_properties+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_properties+std-devel-1.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_properties+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_properties+std-devel}"
SRC_URI[x86_64_v2_rust-icu_properties+std-devel.sha256sum] = "396c5018b1dd3a6c5a6fff05b018213adfbe841cf9e6877945d9cd2e89eed177"

URI_x86_64_v2_rust-icu_properties-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_properties-devel-1.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_properties-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_properties-devel}"
SRC_URI[x86_64_v2_rust-icu_properties-devel.sha256sum] = "5c5b59c1f6ecd7ec364a5e820997f74f4adfc386368d5286c9e1ffd497b9e14b"

URI_aarch64_rust-icu_properties+bidi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_properties+bidi-devel-1.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-icu_properties+bidi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_properties+bidi-devel}"
SRC_URI[aarch64_rust-icu_properties+bidi-devel.sha256sum] = "0551cd22f70725d958465fb720765cad8f90eecd8949995c916a3973a8fd3f1d"

URI_aarch64_rust-icu_properties+compiled_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_properties+compiled_data-devel-1.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-icu_properties+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_properties+compiled_data-devel}"
SRC_URI[aarch64_rust-icu_properties+compiled_data-devel.sha256sum] = "7dcf98e50f591beb610f01ad719e0042e53bb10d425fef5ecca5c1853274bb89"

URI_aarch64_rust-icu_properties+datagen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_properties+datagen-devel-1.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-icu_properties+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_properties+datagen-devel}"
SRC_URI[aarch64_rust-icu_properties+datagen-devel.sha256sum] = "78e5d3ec4c754fb92c0577756ba812d560c9e884e4cdab7b0c9705d149019d19"

URI_aarch64_rust-icu_properties+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_properties+default-devel-1.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-icu_properties+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_properties+default-devel}"
SRC_URI[aarch64_rust-icu_properties+default-devel.sha256sum] = "615182afe327f4d2d57c022d7fd6d3c7f25db2bbcfa5d996dcb3d21bed44e576"

URI_aarch64_rust-icu_properties+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_properties+serde-devel-1.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-icu_properties+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_properties+serde-devel}"
SRC_URI[aarch64_rust-icu_properties+serde-devel.sha256sum] = "6dab9c8c594d397b4c4c1c983afe533abd818c88ed358973d6d5f899a2adcb24"

URI_aarch64_rust-icu_properties+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_properties+std-devel-1.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-icu_properties+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_properties+std-devel}"
SRC_URI[aarch64_rust-icu_properties+std-devel.sha256sum] = "433a7c9abeea732e8d475c85611d5475584543a1f41570aeb6b8bac4451f662b"

URI_aarch64_rust-icu_properties-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_properties-devel-1.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-icu_properties-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_properties-devel}"
SRC_URI[aarch64_rust-icu_properties-devel.sha256sum] = "4c2220b8137874021ca3fb79957235d9b95f71773c0ba6f9c1a8c7b11a0ef998"

RDEPENDS:rust-icu_properties+bidi-devel = " \
 cargo \
 rust-icu_properties-devel \
 rust-unicode-bidi-devel \
 "
RDEPENDS:rust-icu_properties+compiled_data-devel = " \
 cargo \
 rust-icu_locid_transform+compiled_data-devel \
 rust-icu_locid_transform-devel \
 rust-icu_properties-devel \
 rust-icu_properties_data-devel \
 "
RDEPENDS:rust-icu_properties+datagen-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-icu_collections+databake-devel \
 rust-icu_properties+serde-devel \
 rust-icu_properties-devel \
 rust-tinystr+databake-devel \
 rust-zerovec+databake-devel \
 "
RDEPENDS:rust-icu_properties+default-devel = " \
 cargo \
 rust-icu_properties+compiled_data-devel \
 rust-icu_properties-devel \
 "
RDEPENDS:rust-icu_properties+serde-devel = " \
 cargo \
 rust-icu_collections+serde-devel \
 rust-icu_properties-devel \
 rust-icu_provider+serde-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-tinystr+serde-devel \
 rust-zerovec+serde-devel \
 "
RDEPENDS:rust-icu_properties+std-devel = " \
 cargo \
 rust-icu_collections+std-devel \
 rust-icu_properties-devel \
 rust-icu_provider+std-devel \
 "
RDEPENDS:rust-icu_properties-devel = " \
 cargo \
 rust \
 rust-displaydoc-devel \
 rust-icu_collections-devel \
 rust-icu_provider+macros-devel \
 rust-icu_provider-devel \
 rust-tinystr+alloc-devel \
 rust-tinystr+zerovec-devel \
 rust-tinystr-devel \
 rust-zerovec+derive-devel \
 rust-zerovec-devel \
 "
