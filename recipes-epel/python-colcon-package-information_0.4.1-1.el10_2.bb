# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-package-information"
PV = "0.4.1"
PR = "1.el10_2"
PACKAGES = " \
 python3-colcon-package-information \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-colcon-package-information-0.4.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "95aba613b520fe40d69257d66e34505389292514e7209182a2a667c7adc49b5f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-package-information-0.4.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-package-information;unpack=0"
SRC_URI[x86_64_v2_python3-colcon-package-information.sha256sum] = "089b5ce6e41bff0a02c7fae94e9b8e86d8ab20185e813891cbd9b8b6f80ac42e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-package-information-0.4.1-1.el10_2.noarch.rpm;name=aarch64_python3-colcon-package-information;unpack=0"
SRC_URI[aarch64_python3-colcon-package-information.sha256sum] = "c4765559460841f9071c67690babdf960b041ee5e32e2e57a8da1ce9871b6f44"

RDEPENDS:python3-colcon-package-information = " \
 python3 \
 python3-colcon-core \
 python3-packaging \
 "
