# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-systemsettings"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 plasma-systemsettings \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma-systemsettings-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "58d080305251ef9d71e58e2688c2f0a79d7644397226f82e35d8818dbff03682"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-systemsettings-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-systemsettings;unpack=0"
SRC_URI[x86_64_v2_plasma-systemsettings.sha256sum] = "1efcb2b21e3822ded7eedd58610c3bb2c1045353f2cf90a110ae60bb4c2c14e2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-systemsettings-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-systemsettings;unpack=0"
SRC_URI[aarch64_plasma-systemsettings.sha256sum] = "44d60b2a6640dbedd414db8d1ddf49365d0a5c9bc1dd96063098bf466a7b875a"

RDEPENDS:plasma-systemsettings = " \
 glibc \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kitemmodels \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-krunner \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
