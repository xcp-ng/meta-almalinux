# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "castxml"
PV = "0.6.13"
PR = "1.el10_0"
PACKAGES = " \
 castxml \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/castxml-0.6.13-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63f1813a966caa32517c39eee2dc3972d6eb495ca7bc87e6e9d68ba8ba22a6a5"

URI_x86_64_v2_castxml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/castxml-0.6.13-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_castxml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_castxml}"
SRC_URI[x86_64_v2_castxml.sha256sum] = "6ff5a14f495b0716197cc268c2f27f83e1264379abe6b671207fe825e4a4034e"

URI_aarch64_castxml = "${EPEL_MIRROR}/aarch64/Packages/c/castxml-0.6.13-1.el10_0.aarch64.rpm;name=aarch64_castxml;unpack=0"
SRC_URI:append = " ${URI_aarch64_castxml}"
SRC_URI[aarch64_castxml.sha256sum] = "f86a7124e55cc4d1799903c56f3ee381905a099f8cd1a294a7b2e86f3cb57c58"

RDEPENDS:castxml = " \
 clang-libs \
 glibc \
 libgcc \
 libstdc++ \
 llvm-libs \
 "
