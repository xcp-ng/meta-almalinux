# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "redhat-rpm-config"
PV = "289"
PR = "1.el10_0.1.alma.1"
PACKAGES = " \
 redhat-rpm-config \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/redhat-rpm-config-289-1.el10_0.1.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87c036ab4438e2964b9328ce4c01a647ded42e3629d8bcd64bc979ca6b8dd3e2"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - redhat-rpm-config: ocaml-srpm-macros

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - redhat-rpm-config: ocaml-srpm-macros

URI_x86_64_v2_redhat-rpm-config = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/redhat-rpm-config-289-1.el10_0.1.alma.1.noarch.rpm;name=x86_64_v2_redhat-rpm-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_redhat-rpm-config}"
SRC_URI[x86_64_v2_redhat-rpm-config.sha256sum] = "19c6030fe76c83d7fbdecdcdce28f14dc9f22dc40fc83b082f82565a357ca300"

URI_aarch64_redhat-rpm-config = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/redhat-rpm-config-289-1.el10_0.1.alma.1.noarch.rpm;name=aarch64_redhat-rpm-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_redhat-rpm-config}"
SRC_URI[aarch64_redhat-rpm-config.sha256sum] = "19c6030fe76c83d7fbdecdcdce28f14dc9f22dc40fc83b082f82565a357ca300"

RDEPENDS:redhat-rpm-config = " \
 annobin-plugin-gcc \
 bash \
 dwz \
 efi-srpm-macros \
 file \
 findutils \
 fonts-srpm-macros \
 forge-srpm-macros \
 gawk \
 gcc-plugin-annobin \
 go-srpm-macros \
 grep \
 kernel-srpm-macros \
 llvm \
 lua-srpm-macros \
 openblas-srpm-macros \
 package-notes-srpm-macros \
 perl-srpm-macros \
 pyproject-srpm-macros \
 python-srpm-macros \
 qt6-srpm-macros \
 rpm \
 rust-toolset-srpm-macros \
 sed \
 virtual/coreutils \
 zip \
 "
