# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap_lex0.7"
PV = "0.7.7"
PR = "1.el10_2"
PACKAGES = " \
 rust-clap_lex0.7+default-devel \
 rust-clap_lex0.7-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap_lex0.7-0.7.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad1f9e9f10193932fe0ff8ffc0b29b45c5a2e94aa2a33bdbd835ae3263522c9f"

URI_x86_64_v2_rust-clap_lex0.7+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_lex0.7+default-devel-0.7.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_lex0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_lex0.7+default-devel}"
SRC_URI[x86_64_v2_rust-clap_lex0.7+default-devel.sha256sum] = "effbb49fcc4ff8df9bb8bcc2d88a6e78586b30d71f10d348aba0c1d66b3633c6"

URI_x86_64_v2_rust-clap_lex0.7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_lex0.7-devel-0.7.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_lex0.7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_lex0.7-devel}"
SRC_URI[x86_64_v2_rust-clap_lex0.7-devel.sha256sum] = "d5824406407fb057345be5e7e389798529a0bf39950657455a307127bf28f9a2"

URI_aarch64_rust-clap_lex0.7+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_lex0.7+default-devel-0.7.7-1.el10_2.noarch.rpm;name=aarch64_rust-clap_lex0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_lex0.7+default-devel}"
SRC_URI[aarch64_rust-clap_lex0.7+default-devel.sha256sum] = "82d0d2f3e45e7831c4689f9b34190a55c1aa5f3cbc510fe6ff1c15fb74a56720"

URI_aarch64_rust-clap_lex0.7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_lex0.7-devel-0.7.7-1.el10_2.noarch.rpm;name=aarch64_rust-clap_lex0.7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_lex0.7-devel}"
SRC_URI[aarch64_rust-clap_lex0.7-devel.sha256sum] = "bc0a64fb55458d6ec10e5f6c700c036cfdab8190af5975af0842cbd714aae31c"

RDEPENDS:rust-clap_lex0.7+default-devel = " \
 cargo \
 rust-clap_lex0.7-devel \
 "
RDEPENDS:rust-clap_lex0.7-devel = " \
 cargo \
 rust \
 "
