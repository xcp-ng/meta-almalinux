# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kwindowsystem"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kwindowsystem \
 kf6-kwindowsystem-devel \
 kf6-kwindowsystem-doc \
 kf6-kwindowsystem-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kwindowsystem-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "134ac787a03c6a4bf210eaab6cb1502783a56abae0231ad437da22f0728d310b"

URI_x86_64_v2_kf6-kwindowsystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwindowsystem-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwindowsystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwindowsystem}"
SRC_URI[x86_64_v2_kf6-kwindowsystem.sha256sum] = "7b62c79fa20d68e2f302e408a8b79feb0486048fb96366ca36dd62c606cd2b16"

URI_x86_64_v2_kf6-kwindowsystem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwindowsystem-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwindowsystem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwindowsystem-devel}"
SRC_URI[x86_64_v2_kf6-kwindowsystem-devel.sha256sum] = "eb09954e76a13383fd6c9b085cba44c9d1a4b799a6e662859f6ca52c3292b8c6"

URI_x86_64_v2_kf6-kwindowsystem-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwindowsystem-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kwindowsystem-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwindowsystem-doc}"
SRC_URI[x86_64_v2_kf6-kwindowsystem-doc.sha256sum] = "0b08e18bd3f665717e217769918dd4b3704c16d695761753b3a3e44592db008d"

URI_x86_64_v2_kf6-kwindowsystem-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwindowsystem-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kwindowsystem-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwindowsystem-html}"
SRC_URI[x86_64_v2_kf6-kwindowsystem-html.sha256sum] = "37c2277f0bc10004c847eff16de14c66be9dc58487648d038a5b8defc8c7b144"

URI_aarch64_kf6-kwindowsystem = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwindowsystem-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kwindowsystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwindowsystem}"
SRC_URI[aarch64_kf6-kwindowsystem.sha256sum] = "691add947188f7e1234c6511db030ba7633a9968de3260969006738bbac934f6"

URI_aarch64_kf6-kwindowsystem-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwindowsystem-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kwindowsystem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwindowsystem-devel}"
SRC_URI[aarch64_kf6-kwindowsystem-devel.sha256sum] = "7623e26188463022d6d0aaa3df2e3317831db8d796948075e20e5a1d99569690"

URI_aarch64_kf6-kwindowsystem-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwindowsystem-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kwindowsystem-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwindowsystem-doc}"
SRC_URI[aarch64_kf6-kwindowsystem-doc.sha256sum] = "2eafa4a7ab90e4a82cf712ee0d17958f9aa63456e3cf7662afbef03f81f68fb4"

URI_aarch64_kf6-kwindowsystem-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwindowsystem-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kwindowsystem-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwindowsystem-html}"
SRC_URI[aarch64_kf6-kwindowsystem-html.sha256sum] = "b639c3875a18add04d3b3e937ff7f01032032efb4332734ae2b4c807fa7f7b01"

RDEPENDS:kf6-kwindowsystem = " \
 glibc \
 kf6-filesystem \
 libX11 \
 libXfixes \
 libstdc++ \
 libwayland-client \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 xcb-util-keysyms \
 "
RDEPENDS:kf6-kwindowsystem-devel = " \
 cmake-filesystem \
 kf6-kwindowsystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kwindowsystem-doc = " \
 "
RDEPENDS:kf6-kwindowsystem-html = " \
 "
