# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-parallel-executor"
PV = "0.4.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-colcon-parallel-executor \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-parallel-executor-0.4.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b073f2b502fdcabdcb4b03a94b350ea0a4ca1a447466a7b1dfd90b3dff6c679c"

URI_x86_64_v2_python3-colcon-parallel-executor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-parallel-executor-0.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-parallel-executor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-parallel-executor}"
SRC_URI[x86_64_v2_python3-colcon-parallel-executor.sha256sum] = "1a4a03010822b00e310c1247e12dba7a707b8e1fad9c6587f3fbbf4506be0181"

URI_aarch64_python3-colcon-parallel-executor = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-parallel-executor-0.4.0-1.el10_1.noarch.rpm;name=aarch64_python3-colcon-parallel-executor;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-parallel-executor}"
SRC_URI[aarch64_python3-colcon-parallel-executor.sha256sum] = "37e7deeb6b650363c19d327c6ca46df7c131e95304d88d9a46aa41ace06e35c6"

RDEPENDS:python3-colcon-parallel-executor = " \
 python3 \
 python3-colcon-core \
 "
