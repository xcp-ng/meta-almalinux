# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ranger"
PV = "1.9.4"
PR = "8.el10_3"
PACKAGES = " \
 ranger \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/ranger-1.9.4-8.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b69e341b02fb4e9fd6c8e39d2b8f0fa7d23ae165beced9efd12c70bf310e35ea"

URI_x86_64_v2_ranger = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ranger-1.9.4-8.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ranger;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ranger}"
SRC_URI[x86_64_v2_ranger.sha256sum] = "3a52dd6b956ba353a1d73e3110845c6194773f33dd3dd5e051829f59deba1fd7"

URI_aarch64_ranger = "${EPEL_MIRROR}/aarch64/Packages/r/ranger-1.9.4-8.el10_3.noarch.rpm;name=aarch64_ranger;unpack=0"
SRC_URI:append = " ${URI_aarch64_ranger}"
SRC_URI[aarch64_ranger.sha256sum] = "aec9e3c1de5d471ff24555ca870e31094d74549b12e79b1c4978e68235c8cffe"

RDEPENDS:ranger = " \
 bash \
 python3 \
 "
