# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyspellchecker"
PV = "0.8.2"
PR = "1.el10_0"
PACKAGES = " \
 python3-pyspellchecker \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyspellchecker-0.8.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e19ae2d8e93e2a27603ab7561c0ef83bc9dd8a0e26d09e6b4761ccb956737d6"

URI_x86_64_v2_python3-pyspellchecker = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyspellchecker-0.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pyspellchecker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyspellchecker}"
SRC_URI[x86_64_v2_python3-pyspellchecker.sha256sum] = "bd143839a8a207514499d52a5ef0d7648493b8f2220f5cb3aa969b7a37482c7c"

URI_aarch64_python3-pyspellchecker = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyspellchecker-0.8.2-1.el10_0.noarch.rpm;name=aarch64_python3-pyspellchecker;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyspellchecker}"
SRC_URI[aarch64_python3-pyspellchecker.sha256sum] = "c734adbc8e0376e6b53848140e98857217c1851f950359b7da5474afcae39b14"

RDEPENDS:python3-pyspellchecker = " \
 python3 \
 "
