# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nsd"
PV = "4.15.2"
PR = "1.el10_3"
PACKAGES = " \
 nsd \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/n/nsd-4.15.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7fdfa5c4eab2cdb723f4d7f9a04fef6c07e0c1125b4958a448b4ab0de0c6af27"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nsd-4.15.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nsd;unpack=0"
SRC_URI[x86_64_v2_nsd.sha256sum] = "2afbc58efba285331ca95f28cd4026e360181ed4724c2436b242a35656065929"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nsd-4.15.2-1.el10_3.aarch64.rpm;name=aarch64_nsd;unpack=0"
SRC_URI[aarch64_nsd.sha256sum] = "48837ef4f3b5b7df5c14b9a6e42b55068bcf4787c7b27751d5fb0e9e1eb425b4"

RDEPENDS:nsd = " \
 bash \
 fstrm \
 glibc \
 libevent \
 openssl-libs \
 protobuf-c \
 systemd-libs \
 "
