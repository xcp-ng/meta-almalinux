# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksmtp"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 ksmtp \
 ksmtp-devel \
 ksmtp-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ksmtp-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b692de44b7b16211da96046016b858de05a7bfda2b127214566b1699a918b60"

URI_x86_64_v2_ksmtp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksmtp-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksmtp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksmtp}"
SRC_URI[x86_64_v2_ksmtp.sha256sum] = "2dcd133850cc845874ce4819b7d1758b9f74821b1315fc5ed4f7acb679af92fb"

URI_x86_64_v2_ksmtp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksmtp-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksmtp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksmtp-devel}"
SRC_URI[x86_64_v2_ksmtp-devel.sha256sum] = "d63338f351248c29b4459ddfcbdb9fbffa883a7e152a1db880480af53035a76c"

URI_x86_64_v2_ksmtp-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksmtp-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ksmtp-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksmtp-doc}"
SRC_URI[x86_64_v2_ksmtp-doc.sha256sum] = "9aba43519307b5c2cf9c4afe23d026764ec9439a8e4b478f0865030d8a127f6c"

URI_aarch64_ksmtp = "${EPEL_MIRROR}/aarch64/Packages/k/ksmtp-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_ksmtp;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksmtp}"
SRC_URI[aarch64_ksmtp.sha256sum] = "2fde3f59388612dc4cd32cbe94a6c36746dd72799956bf3e39109508aa86b278"

URI_aarch64_ksmtp-devel = "${EPEL_MIRROR}/aarch64/Packages/k/ksmtp-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_ksmtp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksmtp-devel}"
SRC_URI[aarch64_ksmtp-devel.sha256sum] = "db042d8dd6247835d43e4a1c1c7ce0a11102d221c512e864e925d48ae69a2fc4"

URI_aarch64_ksmtp-doc = "${EPEL_MIRROR}/aarch64/Packages/k/ksmtp-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_ksmtp-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksmtp-doc}"
SRC_URI[aarch64_ksmtp-doc.sha256sum] = "31bad85de0d28f6bc54a6af4b96b67fddd5f8d0ab9eb4a99e0afacef80e5582f"

RDEPENDS:ksmtp = " \
 cyrus-sasl-lib \
 cyrus-sasl-plain \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:ksmtp-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kmime-devel \
 ksmtp \
 "
RDEPENDS:ksmtp-doc = " \
 "
