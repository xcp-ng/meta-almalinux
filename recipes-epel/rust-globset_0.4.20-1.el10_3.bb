# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-globset"
PV = "0.4.20"
PR = "1.el10_3"
PACKAGES = " \
 rust-globset+arbitrary-devel \
 rust-globset+default-devel \
 rust-globset+log-devel \
 rust-globset+serde-devel \
 rust-globset+serde1-devel \
 rust-globset+simd-accel-devel \
 rust-globset-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-globset-0.4.20-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c5cbfa81b14f70e7d0f140bccfcf47120482530523ddfc37bba1a0a55983f114"

URI_x86_64_v2_rust-globset+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-globset+arbitrary-devel-0.4.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-globset+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-globset+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-globset+arbitrary-devel.sha256sum] = "20dd9368c9aa58262ff975960caa36b797f8c17d4f9b0cede7b7cb21871182ae"

URI_x86_64_v2_rust-globset+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-globset+default-devel-0.4.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-globset+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-globset+default-devel}"
SRC_URI[x86_64_v2_rust-globset+default-devel.sha256sum] = "1dc51f6e4a4e2d103907efcaf8b4b8b20614839734fa3572f71b83e92144b93a"

URI_x86_64_v2_rust-globset+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-globset+log-devel-0.4.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-globset+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-globset+log-devel}"
SRC_URI[x86_64_v2_rust-globset+log-devel.sha256sum] = "e1dc67a250647d3d6778262f0880fd9153aeb6edc65094cc9512e36fa6429744"

URI_x86_64_v2_rust-globset+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-globset+serde-devel-0.4.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-globset+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-globset+serde-devel}"
SRC_URI[x86_64_v2_rust-globset+serde-devel.sha256sum] = "2a33ceb33f73bc372836c644a37c1dd5a4c17580e0287bb617e7b23e96658e6d"

URI_x86_64_v2_rust-globset+serde1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-globset+serde1-devel-0.4.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-globset+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-globset+serde1-devel}"
SRC_URI[x86_64_v2_rust-globset+serde1-devel.sha256sum] = "019709bec76371346ecad84cd71e861c9d0b648c3a03b55f78d1c04592fb2f22"

URI_x86_64_v2_rust-globset+simd-accel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-globset+simd-accel-devel-0.4.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-globset+simd-accel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-globset+simd-accel-devel}"
SRC_URI[x86_64_v2_rust-globset+simd-accel-devel.sha256sum] = "68d967918372f7ba15dc62b7ee1d9f8218f079e603661909266badc388927871"

URI_x86_64_v2_rust-globset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-globset-devel-0.4.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-globset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-globset-devel}"
SRC_URI[x86_64_v2_rust-globset-devel.sha256sum] = "9d163637b03c0d402e60b24c3f45af3625a7c79a6d62825e0a444380f3bf8f47"

URI_aarch64_rust-globset+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-globset+arbitrary-devel-0.4.20-1.el10_3.noarch.rpm;name=aarch64_rust-globset+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-globset+arbitrary-devel}"
SRC_URI[aarch64_rust-globset+arbitrary-devel.sha256sum] = "d683aa707746821293b23a9e611b414f498fb394287b6e6aa6c976f9518667e1"

URI_aarch64_rust-globset+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-globset+default-devel-0.4.20-1.el10_3.noarch.rpm;name=aarch64_rust-globset+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-globset+default-devel}"
SRC_URI[aarch64_rust-globset+default-devel.sha256sum] = "7b8a738ed781e8592805206773fefb65b2bd404d9679ec4775d9a97c791acf7e"

URI_aarch64_rust-globset+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-globset+log-devel-0.4.20-1.el10_3.noarch.rpm;name=aarch64_rust-globset+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-globset+log-devel}"
SRC_URI[aarch64_rust-globset+log-devel.sha256sum] = "9595e18bca2d05555d49d8534ecb83d4c2dceffdfd8108e91e17904bd34be83f"

URI_aarch64_rust-globset+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-globset+serde-devel-0.4.20-1.el10_3.noarch.rpm;name=aarch64_rust-globset+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-globset+serde-devel}"
SRC_URI[aarch64_rust-globset+serde-devel.sha256sum] = "8a7cf5daadb6250ad0d49744cde2595244b04f59c056e32b8243b78a19dd1031"

URI_aarch64_rust-globset+serde1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-globset+serde1-devel-0.4.20-1.el10_3.noarch.rpm;name=aarch64_rust-globset+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-globset+serde1-devel}"
SRC_URI[aarch64_rust-globset+serde1-devel.sha256sum] = "28638c50d426c625ee58e20f089bde14dbed58436dcee64143acae2cc242d374"

URI_aarch64_rust-globset+simd-accel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-globset+simd-accel-devel-0.4.20-1.el10_3.noarch.rpm;name=aarch64_rust-globset+simd-accel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-globset+simd-accel-devel}"
SRC_URI[aarch64_rust-globset+simd-accel-devel.sha256sum] = "898112bdbaf08f8cf38d97f787a22c9f1393952a896f18e2f703401e887e4a91"

URI_aarch64_rust-globset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-globset-devel-0.4.20-1.el10_3.noarch.rpm;name=aarch64_rust-globset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-globset-devel}"
SRC_URI[aarch64_rust-globset-devel.sha256sum] = "81ec3c13edd2ccb847043767ee24e7d6bcf6d327cdf636ae94716decd8e290e4"

RDEPENDS:rust-globset+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-globset-devel \
 "
RDEPENDS:rust-globset+default-devel = " \
 cargo \
 rust-globset+log-devel \
 rust-globset-devel \
 "
RDEPENDS:rust-globset+log-devel = " \
 cargo \
 rust-globset-devel \
 rust-log+default-devel \
 "
RDEPENDS:rust-globset+serde-devel = " \
 cargo \
 rust-globset-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-globset+serde1-devel = " \
 cargo \
 rust-globset+serde-devel \
 rust-globset-devel \
 "
RDEPENDS:rust-globset+simd-accel-devel = " \
 cargo \
 rust-globset-devel \
 "
RDEPENDS:rust-globset-devel = " \
 cargo \
 rust \
 rust-aho-corasick+default-devel \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-regex-automata+hybrid-devel \
 rust-regex-automata+meta-devel \
 rust-regex-automata+nfa-devel \
 rust-regex-automata+perf-devel \
 rust-regex-automata+std-devel \
 rust-regex-automata+syntax-devel \
 rust-regex-automata-devel \
 rust-regex-syntax+std-devel \
 rust-regex-syntax-devel \
 "
