# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ammonia"
PV = "4.0.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-ammonia+default-devel \
 rust-ammonia-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ammonia-4.0.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac083f0eb25ab6120a561ae26b8db9d084c31b48dd02a3ce0701145c711ae8bf"

URI_x86_64_v2_rust-ammonia+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ammonia+default-devel-4.0.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ammonia+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ammonia+default-devel}"
SRC_URI[x86_64_v2_rust-ammonia+default-devel.sha256sum] = "d4464735e34818104c181598b61ca7fca1d58e398aa128b6e28e066ce710785b"

URI_x86_64_v2_rust-ammonia-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ammonia-devel-4.0.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ammonia-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ammonia-devel}"
SRC_URI[x86_64_v2_rust-ammonia-devel.sha256sum] = "da05fb5bb4259ffb89ae6882c38679cc4ec0535629b936c3c3672b5bf3ea00a5"

URI_aarch64_rust-ammonia+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ammonia+default-devel-4.0.3-1.el10_2.noarch.rpm;name=aarch64_rust-ammonia+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ammonia+default-devel}"
SRC_URI[aarch64_rust-ammonia+default-devel.sha256sum] = "7459dbad34f3fefaa5931b27e62b393ac71e7708c757f11e4fefd86cbd03e471"

URI_aarch64_rust-ammonia-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ammonia-devel-4.0.3-1.el10_2.noarch.rpm;name=aarch64_rust-ammonia-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ammonia-devel}"
SRC_URI[aarch64_rust-ammonia-devel.sha256sum] = "397b99256cf8b412eeabce4d3dfef1c77436e10f36bc34c017bb01d2d5f241ed"

RDEPENDS:rust-ammonia+default-devel = " \
 cargo \
 rust-ammonia-devel \
 "
RDEPENDS:rust-ammonia-devel = " \
 cargo \
 rust \
 rust-html5ever0.29+default-devel \
 rust-maplit+default-devel \
 rust-once_cell+default-devel \
 rust-tendril+default-devel \
 rust-url+default-devel \
 "
