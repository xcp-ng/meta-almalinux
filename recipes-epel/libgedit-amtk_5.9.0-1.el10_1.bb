# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgedit-amtk"
PV = "5.9.0"
PR = "1.el10_1"
PACKAGES = " \
 libgedit-amtk \
 libgedit-amtk-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libgedit-amtk-5.9.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ddedeca9f96d5d4e294912a14305e430226714be313f73953c7703c5f0c824cc"

URI_x86_64_v2_libgedit-amtk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgedit-amtk-5.9.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgedit-amtk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgedit-amtk}"
SRC_URI[x86_64_v2_libgedit-amtk.sha256sum] = "fc4053b44326a392f177833f74296ca16637c3420e975cb3acd418797a1edd34"

URI_x86_64_v2_libgedit-amtk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgedit-amtk-devel-5.9.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgedit-amtk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgedit-amtk-devel}"
SRC_URI[x86_64_v2_libgedit-amtk-devel.sha256sum] = "349cdca0551838c541bca2564111a91008e9e125786152e36584d72ae89e283a"

URI_aarch64_libgedit-amtk = "${EPEL_MIRROR}/aarch64/Packages/l/libgedit-amtk-5.9.0-1.el10_1.aarch64.rpm;name=aarch64_libgedit-amtk;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgedit-amtk}"
SRC_URI[aarch64_libgedit-amtk.sha256sum] = "8f157b7aca55996abf32feec5cb9b1e0346a698e098bcd506d46819af40d3174"

URI_aarch64_libgedit-amtk-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libgedit-amtk-devel-5.9.0-1.el10_1.aarch64.rpm;name=aarch64_libgedit-amtk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgedit-amtk-devel}"
SRC_URI[aarch64_libgedit-amtk-devel.sha256sum] = "7d65ad027acf09468ff97c0a67bbc315910572f15b9d9d4ec282481c16d7dd40"

RDEPENDS:libgedit-amtk = " \
 glib2 \
 glibc \
 gtk3 \
 "
RDEPENDS:libgedit-amtk-devel = " \
 glib2-devel \
 gtk3-devel \
 libgedit-amtk \
 pkgconf-pkg-config \
 "
