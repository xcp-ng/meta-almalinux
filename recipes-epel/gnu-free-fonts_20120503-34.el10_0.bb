# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnu-free-fonts"
PV = "20120503"
PR = "34.el10_0"
PACKAGES = " \
 gnu-free-fonts-common \
 gnu-free-mono-fonts \
 gnu-free-sans-fonts \
 gnu-free-serif-fonts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gnu-free-fonts-20120503-34.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "29c223cef720bbf5c9eb8ba71f705a82d32741bd0e356695a79b1032a2aa2dc4"

URI_x86_64_v2_gnu-free-fonts-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnu-free-fonts-common-20120503-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gnu-free-fonts-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnu-free-fonts-common}"
SRC_URI[x86_64_v2_gnu-free-fonts-common.sha256sum] = "607c13f6c2907d6d274c188503237284f8dc79e1f5a57d9abc7e1d53bde3067a"

URI_x86_64_v2_gnu-free-mono-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnu-free-mono-fonts-20120503-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gnu-free-mono-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnu-free-mono-fonts}"
SRC_URI[x86_64_v2_gnu-free-mono-fonts.sha256sum] = "585b20fa2d48f3432bfceac438b3066bc2d47b27979fcec3837c05688084f7df"

URI_x86_64_v2_gnu-free-sans-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnu-free-sans-fonts-20120503-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gnu-free-sans-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnu-free-sans-fonts}"
SRC_URI[x86_64_v2_gnu-free-sans-fonts.sha256sum] = "9f56bd83ef8d268f23d0cfc81d50867d1f133aac7c1b9218e3bfb677cfbb5b3f"

URI_x86_64_v2_gnu-free-serif-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnu-free-serif-fonts-20120503-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gnu-free-serif-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnu-free-serif-fonts}"
SRC_URI[x86_64_v2_gnu-free-serif-fonts.sha256sum] = "e71b1fbdd0628e9eb19388f684997bbc017c45e2818826f00fa82e1f1024a15e"

URI_aarch64_gnu-free-fonts-common = "${EPEL_MIRROR}/aarch64/Packages/g/gnu-free-fonts-common-20120503-34.el10_0.noarch.rpm;name=aarch64_gnu-free-fonts-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnu-free-fonts-common}"
SRC_URI[aarch64_gnu-free-fonts-common.sha256sum] = "f41b493786ea5d002b1db198dadaef943f66c6869e746d13b8a053005ea987fb"

URI_aarch64_gnu-free-mono-fonts = "${EPEL_MIRROR}/aarch64/Packages/g/gnu-free-mono-fonts-20120503-34.el10_0.noarch.rpm;name=aarch64_gnu-free-mono-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnu-free-mono-fonts}"
SRC_URI[aarch64_gnu-free-mono-fonts.sha256sum] = "12c2ef7eeb206c38e3f661491f4d69799c89e9b0e79a610a5ed281d8fd06e23f"

URI_aarch64_gnu-free-sans-fonts = "${EPEL_MIRROR}/aarch64/Packages/g/gnu-free-sans-fonts-20120503-34.el10_0.noarch.rpm;name=aarch64_gnu-free-sans-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnu-free-sans-fonts}"
SRC_URI[aarch64_gnu-free-sans-fonts.sha256sum] = "97e0a12701ecbb635f8fcdce2463cd040472dd85d788b76631de4217dbd01e9d"

URI_aarch64_gnu-free-serif-fonts = "${EPEL_MIRROR}/aarch64/Packages/g/gnu-free-serif-fonts-20120503-34.el10_0.noarch.rpm;name=aarch64_gnu-free-serif-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnu-free-serif-fonts}"
SRC_URI[aarch64_gnu-free-serif-fonts.sha256sum] = "30cc60c8a720f200384d2d68372351ae599c4ea48a6d8cec5c8a3365b7f88912"

RDEPENDS:gnu-free-fonts-common = " \
 fonts-filesystem \
 "
RDEPENDS:gnu-free-mono-fonts = " \
 gnu-free-fonts-common \
 "
RDEPENDS:gnu-free-sans-fonts = " \
 gnu-free-fonts-common \
 "
RDEPENDS:gnu-free-serif-fonts = " \
 gnu-free-fonts-common \
 "
