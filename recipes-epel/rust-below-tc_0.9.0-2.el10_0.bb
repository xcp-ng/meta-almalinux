# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-below-tc"
PV = "0.9.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-below-tc+default-devel \
 rust-below-tc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-below-tc-0.9.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "41c655f1f577ba800a63707680c3a7b7da27e6a93af2dc4d2de77a8226c58899"

URI_x86_64_v2_rust-below-tc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-tc+default-devel-0.9.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-tc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-tc+default-devel}"
SRC_URI[x86_64_v2_rust-below-tc+default-devel.sha256sum] = "b8d5ef5978b01ef04d3f79db15039c8acaffbabf1327fb7b0f7b773f5c836ada"

URI_x86_64_v2_rust-below-tc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-tc-devel-0.9.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-tc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-tc-devel}"
SRC_URI[x86_64_v2_rust-below-tc-devel.sha256sum] = "f8a141493e6e26119290ae8216838e9a0415c9e138df072b2ca7f44736faeaad"

URI_aarch64_rust-below-tc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-tc+default-devel-0.9.0-2.el10_0.noarch.rpm;name=aarch64_rust-below-tc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-tc+default-devel}"
SRC_URI[aarch64_rust-below-tc+default-devel.sha256sum] = "7e85a9d99e6d7a0b2d6da1d318ea32dff206f05d2aeeaaaad2c15ac544ed3621"

URI_aarch64_rust-below-tc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-tc-devel-0.9.0-2.el10_0.noarch.rpm;name=aarch64_rust-below-tc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-tc-devel}"
SRC_URI[aarch64_rust-below-tc-devel.sha256sum] = "39a8d5fd13588649d23d2443f9f10d989107cc4a533600baa095f2cdc80832e2"

RDEPENDS:rust-below-tc+default-devel = " \
 cargo \
 rust-below-tc-devel \
 "
RDEPENDS:rust-below-tc-devel = " \
 cargo \
 rust-netlink-packet-core+default-devel \
 rust-netlink-packet-route+default-devel \
 rust-netlink-sys+default-devel \
 rust-nix+default-devel \
 rust-nix+dir-devel \
 rust-nix+event-devel \
 rust-nix+hostname-devel \
 rust-nix+inotify-devel \
 rust-nix+ioctl-devel \
 rust-nix+mman-devel \
 rust-nix+mount-devel \
 rust-nix+net-devel \
 rust-nix+poll-devel \
 rust-nix+ptrace-devel \
 rust-nix+reboot-devel \
 rust-nix+resource-devel \
 rust-nix+sched-devel \
 rust-nix+signal-devel \
 rust-nix+term-devel \
 rust-nix+time-devel \
 rust-nix+user-devel \
 rust-nix+zerocopy-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-thiserror+default-devel \
 "
