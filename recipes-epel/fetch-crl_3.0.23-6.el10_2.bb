# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fetch-crl"
PV = "3.0.23"
PR = "6.el10_2"
PACKAGES = " \
 fetch-crl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fetch-crl-3.0.23-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "afbe4f8017bdf6c7965906fc0547bb58f3460cc4651794dd7bd6e459be789771"

URI_x86_64_v2_fetch-crl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fetch-crl-3.0.23-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_fetch-crl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fetch-crl}"
SRC_URI[x86_64_v2_fetch-crl.sha256sum] = "e953adbec22847f5fcadae0e1d9a87af684dda6c5ba5f14f4ceee7d77d71e8a3"

URI_aarch64_fetch-crl = "${EPEL_MIRROR}/aarch64/Packages/f/fetch-crl-3.0.23-6.el10_2.noarch.rpm;name=aarch64_fetch-crl;unpack=0"
SRC_URI:append = " ${URI_aarch64_fetch-crl}"
SRC_URI[aarch64_fetch-crl.sha256sum] = "e8442867b7ffcbd4a8a6d0208e35047e1c18c95c3ed626a9101921290adda9c7"

RDEPENDS:fetch-crl = " \
 bash \
 openssl \
 perl-File-Basename \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-IO \
 perl-IPC-Open3 \
 perl-LWP-Protocol-https \
 perl-POSIX \
 perl-Sys-Syslog \
 perl-Time-Local \
 perl-interpreter \
 perl-libs \
 perl-libwww-perl \
 perl-vars \
 systemd \
 "
