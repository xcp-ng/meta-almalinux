# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtconnectivity"
PV = "6.8.1"
PR = "2.el10"
PACKAGES = " \
 qt6-qtconnectivity \
 qt6-qtconnectivity-devel \
 qt6-qtconnectivity-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtconnectivity-6.8.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "991b6ce804bb33301b924135f2196bee6124175ad36d002146441d1406bcf87f"

URI_x86_64_v2_qt6-qtconnectivity = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtconnectivity-6.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtconnectivity;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtconnectivity}"
SRC_URI[x86_64_v2_qt6-qtconnectivity.sha256sum] = "94c0a5603e87087f2fc900508b11a0712cdaec87fbf8445e90bedd78f80b0f26"

URI_x86_64_v2_qt6-qtconnectivity-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtconnectivity-devel-6.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtconnectivity-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtconnectivity-devel}"
SRC_URI[x86_64_v2_qt6-qtconnectivity-devel.sha256sum] = "586d352c88372f07828cd398434d7c39ce616cb40ce84e11250dcb512400aa3c"

URI_x86_64_v2_qt6-qtconnectivity-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtconnectivity-examples-6.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtconnectivity-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtconnectivity-examples}"
SRC_URI[x86_64_v2_qt6-qtconnectivity-examples.sha256sum] = "9fed638ae284f3d39f47da060b04f7445aad2b80879edff56f531bc8d85ad1cd"

URI_aarch64_qt6-qtconnectivity = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtconnectivity-6.8.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtconnectivity;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtconnectivity}"
SRC_URI[aarch64_qt6-qtconnectivity.sha256sum] = "ed37b262f0308ddc29364c0e3340a4ddfad8320845a138b1f3827e456c8500db"

URI_aarch64_qt6-qtconnectivity-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtconnectivity-devel-6.8.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtconnectivity-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtconnectivity-devel}"
SRC_URI[aarch64_qt6-qtconnectivity-devel.sha256sum] = "bae6a46458ca445f475150aa015177bc69dc14cc559a3d922a1438370c120652"

URI_aarch64_qt6-qtconnectivity-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtconnectivity-examples-6.8.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtconnectivity-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtconnectivity-examples}"
SRC_URI[aarch64_qt6-qtconnectivity-examples.sha256sum] = "b2f90898f99abf4ce22fa97c6fe72289a7ee9199bc15d39258264a8eb66d7b70"

RDEPENDS:qt6-qtconnectivity = " \
 bluez-libs \
 glibc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:qt6-qtconnectivity-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtconnectivity \
 "
RDEPENDS:qt6-qtconnectivity-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtconnectivity \
 qt6-qtdeclarative \
 "
