# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "unbound"
PV = "1.20.0"
PR = "12.el10_0"
PACKAGES = " \
 python3-unbound \
 unbound \
 unbound-anchor \
 unbound-devel \
 unbound-dracut \
 unbound-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/unbound-1.20.0-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b5be7d92307cbb6d270710d471a5066419d3d0b1081a5841c43ae3f39adab478"

URI_x86_64_v2_python3-unbound = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-unbound-1.20.0-12.el10_0.x86_64_v2.rpm;name=x86_64_v2_python3-unbound;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-unbound}"
SRC_URI[x86_64_v2_python3-unbound.sha256sum] = "38b90126920a57d2a71227390c4e9f2561dc3aaccc97a85d732f7c53ff203893"

URI_x86_64_v2_unbound = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/unbound-1.20.0-12.el10_0.x86_64_v2.rpm;name=x86_64_v2_unbound;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unbound}"
SRC_URI[x86_64_v2_unbound.sha256sum] = "84163a6246c0da8dee4eff01d43a365754eecb3d0b518072222d3818433e5ae4"

URI_x86_64_v2_unbound-anchor = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/unbound-anchor-1.20.0-12.el10_0.x86_64_v2.rpm;name=x86_64_v2_unbound-anchor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unbound-anchor}"
SRC_URI[x86_64_v2_unbound-anchor.sha256sum] = "1e521c132e73c832a6e28455c4142317190f1638be4ca3ccc3ac60bca9eeea51"

URI_x86_64_v2_unbound-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/unbound-devel-1.20.0-12.el10_0.x86_64_v2.rpm;name=x86_64_v2_unbound-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unbound-devel}"
SRC_URI[x86_64_v2_unbound-devel.sha256sum] = "28bc5bda4d1bf4aef216126ad5a8205fdb029ec5913c18431f3691d8aa6c408b"

URI_x86_64_v2_unbound-dracut = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/unbound-dracut-1.20.0-12.el10_0.x86_64_v2.rpm;name=x86_64_v2_unbound-dracut;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unbound-dracut}"
SRC_URI[x86_64_v2_unbound-dracut.sha256sum] = "27322d8b464c6d48eae382095223ed5924ccf91dae63f2a9a4272076fb60e18c"

URI_x86_64_v2_unbound-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/unbound-libs-1.20.0-12.el10_0.x86_64_v2.rpm;name=x86_64_v2_unbound-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unbound-libs}"
SRC_URI[x86_64_v2_unbound-libs.sha256sum] = "4b598b64baf2c1d434c5e47c9ca4cbe516601f1b64dda071b26478dbfe45b288"

URI_aarch64_python3-unbound = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-unbound-1.20.0-12.el10_0.aarch64.rpm;name=aarch64_python3-unbound;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-unbound}"
SRC_URI[aarch64_python3-unbound.sha256sum] = "c274883887a317c71751e70498aa044711d35af5a7c950737ed910aac1e26466"

URI_aarch64_unbound = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/unbound-1.20.0-12.el10_0.aarch64.rpm;name=aarch64_unbound;unpack=0"
SRC_URI:append = " ${URI_aarch64_unbound}"
SRC_URI[aarch64_unbound.sha256sum] = "b7dbcf75d1d6d230db4433fb82fc11809ee46ba8b9971655031b74448fea6ad9"

URI_aarch64_unbound-anchor = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/unbound-anchor-1.20.0-12.el10_0.aarch64.rpm;name=aarch64_unbound-anchor;unpack=0"
SRC_URI:append = " ${URI_aarch64_unbound-anchor}"
SRC_URI[aarch64_unbound-anchor.sha256sum] = "8d2e2e8b4493b540051b8c61e35dcd48abdf63289e6e9508fd6f7260db21d6f3"

URI_aarch64_unbound-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/unbound-devel-1.20.0-12.el10_0.aarch64.rpm;name=aarch64_unbound-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_unbound-devel}"
SRC_URI[aarch64_unbound-devel.sha256sum] = "bebc544c4e670598e90559128608ec110faa3ad416fa8f8a1765ce2f368d6ae8"

URI_aarch64_unbound-dracut = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/unbound-dracut-1.20.0-12.el10_0.aarch64.rpm;name=aarch64_unbound-dracut;unpack=0"
SRC_URI:append = " ${URI_aarch64_unbound-dracut}"
SRC_URI[aarch64_unbound-dracut.sha256sum] = "029b024ec0a3d7635b6fff8eedc2c12cb83a8947cc64effc49639a1b809c3b2b"

URI_aarch64_unbound-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/unbound-libs-1.20.0-12.el10_0.aarch64.rpm;name=aarch64_unbound-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_unbound-libs}"
SRC_URI[aarch64_unbound-libs.sha256sum] = "e03fd99847d58d3548b80532ef814f1355209d72068f1eb4ec446076dd8f9e8c"

RDEPENDS:python3-unbound = " \
 glibc \
 libevent \
 libnghttp2 \
 openssl-libs \
 protobuf-c \
 python3 \
 python3-libs \
 systemd-libs \
 unbound-libs \
 "
RDEPENDS:unbound = " \
 bash \
 glibc \
 libevent \
 libnghttp2 \
 openssl \
 openssl-libs \
 protobuf-c \
 python3-libs \
 systemd-libs \
 unbound-anchor \
 unbound-libs \
 "
RDEPENDS:unbound-anchor = " \
 bash \
 expat \
 glibc \
 openssl-libs \
 unbound-libs \
 "
RDEPENDS:unbound-devel = " \
 libevent-devel \
 openssl-devel \
 pkgconf-pkg-config \
 python3-devel \
 unbound-libs \
 "
RDEPENDS:unbound-dracut = " \
 bash \
 dracut \
 unbound \
 "
RDEPENDS:unbound-libs = " \
 bash \
 glibc \
 libevent \
 libnghttp2 \
 openssl-libs \
 protobuf-c \
 python3-libs \
 shadow-utils \
 systemd-libs \
 "
