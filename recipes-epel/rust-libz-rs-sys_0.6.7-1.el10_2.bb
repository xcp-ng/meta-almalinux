# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libz-rs-sys"
PV = "0.6.7"
PR = "1.el10_2"
PACKAGES = " \
 rust-libz-rs-sys+c-allocator-devel \
 rust-libz-rs-sys+custom-prefix-devel \
 rust-libz-rs-sys+default-devel \
 rust-libz-rs-sys+export-symbols-devel \
 rust-libz-rs-sys+gz-devel \
 rust-libz-rs-sys+rust-allocator-devel \
 rust-libz-rs-sys+semver-prefix-devel \
 rust-libz-rs-sys+std-devel \
 rust-libz-rs-sys+testing-prefix-devel \
 rust-libz-rs-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libz-rs-sys-0.6.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d1bdbff1226120d02758aefaa1e85b86f78c183f0e9c5a87c818adfd68b3e388"

URI_x86_64_v2_rust-libz-rs-sys+c-allocator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+c-allocator-devel-0.6.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+c-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+c-allocator-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+c-allocator-devel.sha256sum] = "7711bcb0d48d462abf3465a07128e566f7d94b790bbbbd6bdc9e83646b194fc4"

URI_x86_64_v2_rust-libz-rs-sys+custom-prefix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+custom-prefix-devel-0.6.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+custom-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+custom-prefix-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+custom-prefix-devel.sha256sum] = "aa122319ef94df4e7ff66c8b858e3fde839ac2e1458495ac37407349f2989e7c"

URI_x86_64_v2_rust-libz-rs-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+default-devel-0.6.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+default-devel.sha256sum] = "f9071473922b5186f78e7b282e45a03aa80009f317751c7abb263e0b610bc29e"

URI_x86_64_v2_rust-libz-rs-sys+export-symbols-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+export-symbols-devel-0.6.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+export-symbols-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+export-symbols-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+export-symbols-devel.sha256sum] = "07a5f151524de59c273bf22c21838b0edb990fd265f60fd5587fc5fdb8fa64fc"

URI_x86_64_v2_rust-libz-rs-sys+gz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+gz-devel-0.6.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+gz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+gz-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+gz-devel.sha256sum] = "f5428ad5ab3dc08822cab423ca80a69e59d32f6d43c015bc01df64090f302729"

URI_x86_64_v2_rust-libz-rs-sys+rust-allocator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+rust-allocator-devel-0.6.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+rust-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+rust-allocator-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+rust-allocator-devel.sha256sum] = "c7424b395538fd59abf245a2ba5ae305e556497a7cfdf1e2b2bd878b30daf763"

URI_x86_64_v2_rust-libz-rs-sys+semver-prefix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+semver-prefix-devel-0.6.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+semver-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+semver-prefix-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+semver-prefix-devel.sha256sum] = "b668d11bc692271ab8d5bcd73b6e4cb73c7761af83c01baa59aac1b4e241a7f8"

URI_x86_64_v2_rust-libz-rs-sys+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+std-devel-0.6.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+std-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+std-devel.sha256sum] = "2fed10922c80363589e4f315c0475fda8f9b54dcc5d9999a40d320899e1e89aa"

URI_x86_64_v2_rust-libz-rs-sys+testing-prefix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+testing-prefix-devel-0.6.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+testing-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+testing-prefix-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+testing-prefix-devel.sha256sum] = "58d7169bbdc5fbac83d28fcdeaaeaca8f6a52e663eca0cd6e967c2d84cbe2756"

URI_x86_64_v2_rust-libz-rs-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys-devel-0.6.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys-devel.sha256sum] = "a5de1d82eae8665c8b41743881d0ed360051a697404bd18c8ef7262c08bb73ad"

URI_aarch64_rust-libz-rs-sys+c-allocator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+c-allocator-devel-0.6.7-1.el10_2.noarch.rpm;name=aarch64_rust-libz-rs-sys+c-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+c-allocator-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+c-allocator-devel.sha256sum] = "15aee94ac116433e1161f50b89b311132fc39f5be462acc55d4c81d138b5f131"

URI_aarch64_rust-libz-rs-sys+custom-prefix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+custom-prefix-devel-0.6.7-1.el10_2.noarch.rpm;name=aarch64_rust-libz-rs-sys+custom-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+custom-prefix-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+custom-prefix-devel.sha256sum] = "669452c6f2e3da040c8c8d6658f1a20754705d667c9e6555de240a5ffd6f7e4d"

URI_aarch64_rust-libz-rs-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+default-devel-0.6.7-1.el10_2.noarch.rpm;name=aarch64_rust-libz-rs-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+default-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+default-devel.sha256sum] = "40a93f6bc57bf3e3794bc086488d6ddaeb40ea1f56934cacf4d63000c444e041"

URI_aarch64_rust-libz-rs-sys+export-symbols-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+export-symbols-devel-0.6.7-1.el10_2.noarch.rpm;name=aarch64_rust-libz-rs-sys+export-symbols-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+export-symbols-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+export-symbols-devel.sha256sum] = "10c5441340b2d78066914b7bbec25417e6aa3e83723347bcdcd56574791d1a48"

URI_aarch64_rust-libz-rs-sys+gz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+gz-devel-0.6.7-1.el10_2.noarch.rpm;name=aarch64_rust-libz-rs-sys+gz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+gz-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+gz-devel.sha256sum] = "2d3a9eefc3bd548066c558bd4db6bb9e36b1861cbc539d5ac8194e48847d243c"

URI_aarch64_rust-libz-rs-sys+rust-allocator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+rust-allocator-devel-0.6.7-1.el10_2.noarch.rpm;name=aarch64_rust-libz-rs-sys+rust-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+rust-allocator-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+rust-allocator-devel.sha256sum] = "4ee386c455af7ae3b69d29033491caeea6e11e341f630de0e10d3599fffcbe48"

URI_aarch64_rust-libz-rs-sys+semver-prefix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+semver-prefix-devel-0.6.7-1.el10_2.noarch.rpm;name=aarch64_rust-libz-rs-sys+semver-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+semver-prefix-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+semver-prefix-devel.sha256sum] = "08f26d7c25a714eb2f6e3eac1aad189c90a81481313eae02979ac03a27de663e"

URI_aarch64_rust-libz-rs-sys+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+std-devel-0.6.7-1.el10_2.noarch.rpm;name=aarch64_rust-libz-rs-sys+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+std-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+std-devel.sha256sum] = "6d96c5177704b96c37a405af17425c0368c2d47d26a5409b089c5053e752fcc0"

URI_aarch64_rust-libz-rs-sys+testing-prefix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+testing-prefix-devel-0.6.7-1.el10_2.noarch.rpm;name=aarch64_rust-libz-rs-sys+testing-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+testing-prefix-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+testing-prefix-devel.sha256sum] = "967e6d84d9dc9cf137ca5d2f7ff613e9fa9a9f7875daff4c41596ecf89be792e"

URI_aarch64_rust-libz-rs-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys-devel-0.6.7-1.el10_2.noarch.rpm;name=aarch64_rust-libz-rs-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys-devel}"
SRC_URI[aarch64_rust-libz-rs-sys-devel.sha256sum] = "c18542f23f7539bf56633ecfeb2774b0ecbcd44c737137dd91c4d086afd9cc96"

RDEPENDS:rust-libz-rs-sys+c-allocator-devel = " \
 cargo \
 rust-libz-rs-sys-devel \
 rust-zlib-rs+c-allocator-devel \
 "
RDEPENDS:rust-libz-rs-sys+custom-prefix-devel = " \
 cargo \
 rust-libz-rs-sys+export-symbols-devel \
 rust-libz-rs-sys-devel \
 "
RDEPENDS:rust-libz-rs-sys+default-devel = " \
 cargo \
 rust-libz-rs-sys+rust-allocator-devel \
 rust-libz-rs-sys+std-devel \
 rust-libz-rs-sys-devel \
 "
RDEPENDS:rust-libz-rs-sys+export-symbols-devel = " \
 cargo \
 rust-libz-rs-sys-devel \
 "
RDEPENDS:rust-libz-rs-sys+gz-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-libz-rs-sys-devel \
 "
RDEPENDS:rust-libz-rs-sys+rust-allocator-devel = " \
 cargo \
 rust-libz-rs-sys-devel \
 rust-zlib-rs+rust-allocator-devel \
 "
RDEPENDS:rust-libz-rs-sys+semver-prefix-devel = " \
 cargo \
 rust-libz-rs-sys+export-symbols-devel \
 rust-libz-rs-sys-devel \
 "
RDEPENDS:rust-libz-rs-sys+std-devel = " \
 cargo \
 rust-libz-rs-sys-devel \
 rust-zlib-rs+std-devel \
 "
RDEPENDS:rust-libz-rs-sys+testing-prefix-devel = " \
 cargo \
 rust-libz-rs-sys+export-symbols-devel \
 rust-libz-rs-sys-devel \
 "
RDEPENDS:rust-libz-rs-sys-devel = " \
 cargo \
 rust \
 rust-zlib-rs+__internal-api-devel \
 rust-zlib-rs-devel \
 "
