# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hmac0.12"
PV = "0.12.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-hmac0.12+default-devel \
 rust-hmac0.12+reset-devel \
 rust-hmac0.12+std-devel \
 rust-hmac0.12-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-hmac0.12-0.12.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "acc52d673ec1658e1b3c45577d4e5f3a6a5711256d88f71ec6d47b5ad3af9ad6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hmac0.12+default-devel-0.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hmac0.12+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hmac0.12+default-devel.sha256sum] = "8e56754a991eb96b41e1c4493140f93bfa75d6abf7927060b4811c2812291d91"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hmac0.12+reset-devel-0.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hmac0.12+reset-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hmac0.12+reset-devel.sha256sum] = "9c74d1471a30921d383df6b82c3cee540ab06586b8dad3401eb081776e542ae9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hmac0.12+std-devel-0.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hmac0.12+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hmac0.12+std-devel.sha256sum] = "0f204e65a61c92f34dc4bea0d403e4870e41003c6c6ebf163cc56e5f83ffd045"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hmac0.12-devel-0.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hmac0.12-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hmac0.12-devel.sha256sum] = "c901ac786b90a72dcfc6357d80e28ac7bc0e44906bf64a530143ab7600cf98e8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hmac0.12+default-devel-0.12.1-1.el10_3.noarch.rpm;name=aarch64_rust-hmac0.12+default-devel;unpack=0"
SRC_URI[aarch64_rust-hmac0.12+default-devel.sha256sum] = "8bccee15799236959e94918fdebbd083f5556867b0341bfa3049f126b4e6d825"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hmac0.12+reset-devel-0.12.1-1.el10_3.noarch.rpm;name=aarch64_rust-hmac0.12+reset-devel;unpack=0"
SRC_URI[aarch64_rust-hmac0.12+reset-devel.sha256sum] = "460f7518a2df1ec49edc992a98dc07648c214927906feb0d67946f93b61560c8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hmac0.12+std-devel-0.12.1-1.el10_3.noarch.rpm;name=aarch64_rust-hmac0.12+std-devel;unpack=0"
SRC_URI[aarch64_rust-hmac0.12+std-devel.sha256sum] = "6440f5a5ad7cf0987c2887fcd0930edd7c031eb7639da22d3ca8478f06b55659"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hmac0.12-devel-0.12.1-1.el10_3.noarch.rpm;name=aarch64_rust-hmac0.12-devel;unpack=0"
SRC_URI[aarch64_rust-hmac0.12-devel.sha256sum] = "3a5d90c0bb027aee7d7609f35734fa3dc3e083ac724c61ad92054f7a4eeda066"

RDEPENDS:rust-hmac0.12+default-devel = " \
 cargo \
 rust-hmac0.12-devel \
 "
RDEPENDS:rust-hmac0.12+reset-devel = " \
 cargo \
 rust-hmac0.12-devel \
 "
RDEPENDS:rust-hmac0.12+std-devel = " \
 cargo \
 rust-digest0.10+std-devel \
 rust-hmac0.12-devel \
 "
RDEPENDS:rust-hmac0.12-devel = " \
 cargo \
 rust-digest0.10+default-devel \
 rust-digest0.10+mac-devel \
 "
