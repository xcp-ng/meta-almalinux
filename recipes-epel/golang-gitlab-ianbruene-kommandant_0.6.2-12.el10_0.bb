# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-gitlab-ianbruene-kommandant"
PV = "0.6.2"
PR = "12.el10_0"
PACKAGES = " \
 golang-gitlab-ianbruene-kommandant-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-gitlab-ianbruene-kommandant-0.6.2-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b5bef429ec18aa0874659a278f469f8c1570dd89f1e78af18c67f97ddde68fd8"

URI_x86_64_v2_golang-gitlab-ianbruene-kommandant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-gitlab-ianbruene-kommandant-devel-0.6.2-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-gitlab-ianbruene-kommandant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-gitlab-ianbruene-kommandant-devel}"
SRC_URI[x86_64_v2_golang-gitlab-ianbruene-kommandant-devel.sha256sum] = "5c4bfd33c62be0c18be3e0df05abecfe06c90c342f7348a87c50d1bcad191f10"

URI_aarch64_golang-gitlab-ianbruene-kommandant-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-gitlab-ianbruene-kommandant-devel-0.6.2-12.el10_0.noarch.rpm;name=aarch64_golang-gitlab-ianbruene-kommandant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-gitlab-ianbruene-kommandant-devel}"
SRC_URI[aarch64_golang-gitlab-ianbruene-kommandant-devel.sha256sum] = "fdbffcb40d03fc994e0f9e59cc3af6d86850c2609e02c3cfe83313185810361b"

RDEPENDS:golang-gitlab-ianbruene-kommandant-devel = " \
 go-filesystem \
 golang-github-chzyer-readline-devel \
 "
