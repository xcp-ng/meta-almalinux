# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unit-prefix"
PV = "0.5.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-unit-prefix+default-devel \
 rust-unit-prefix+std-devel \
 rust-unit-prefix-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unit-prefix-0.5.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "772ce218ec1d9f80395a20308bebd19b7f7ff07fc7c27cc3fa641b76e154e991"

URI_x86_64_v2_rust-unit-prefix+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unit-prefix+default-devel-0.5.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unit-prefix+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unit-prefix+default-devel}"
SRC_URI[x86_64_v2_rust-unit-prefix+default-devel.sha256sum] = "a3998f488adca81af5a5bca94652f7d2723e0621190e625dc8f09402481703c1"

URI_x86_64_v2_rust-unit-prefix+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unit-prefix+std-devel-0.5.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unit-prefix+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unit-prefix+std-devel}"
SRC_URI[x86_64_v2_rust-unit-prefix+std-devel.sha256sum] = "8232206bb30d16d9d38a339b87cb602f89c2d90ac24edf20d1f54f35c8685771"

URI_x86_64_v2_rust-unit-prefix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unit-prefix-devel-0.5.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unit-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unit-prefix-devel}"
SRC_URI[x86_64_v2_rust-unit-prefix-devel.sha256sum] = "b210133ed5a063a0fc2f5393700c41147ac6ff3173ea0b1db7a2817dc8ca9866"

URI_aarch64_rust-unit-prefix+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unit-prefix+default-devel-0.5.2-1.el10_1.noarch.rpm;name=aarch64_rust-unit-prefix+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unit-prefix+default-devel}"
SRC_URI[aarch64_rust-unit-prefix+default-devel.sha256sum] = "3125d1b427bf2f310e5a0b45b451ef05a1412f353edc685986ffef8832227638"

URI_aarch64_rust-unit-prefix+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unit-prefix+std-devel-0.5.2-1.el10_1.noarch.rpm;name=aarch64_rust-unit-prefix+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unit-prefix+std-devel}"
SRC_URI[aarch64_rust-unit-prefix+std-devel.sha256sum] = "2f01e9d2e024e0e235ebd089c3d22d3a867c0a147d8db6d2fae6918a7fc5f2f3"

URI_aarch64_rust-unit-prefix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unit-prefix-devel-0.5.2-1.el10_1.noarch.rpm;name=aarch64_rust-unit-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unit-prefix-devel}"
SRC_URI[aarch64_rust-unit-prefix-devel.sha256sum] = "5aea69fdf043d9e2bfa43e4929ff9814d59b97045691d8b568bf6d7ec49f60c9"

RDEPENDS:rust-unit-prefix+default-devel = " \
 cargo \
 rust-unit-prefix+std-devel \
 rust-unit-prefix-devel \
 "
RDEPENDS:rust-unit-prefix+std-devel = " \
 cargo \
 rust-unit-prefix-devel \
 "
RDEPENDS:rust-unit-prefix-devel = " \
 cargo \
 rust \
 "
