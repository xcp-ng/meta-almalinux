# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-merge"
PV = "0.3.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-merge+default-devel \
 rust-gix-merge+document-features-devel \
 rust-gix-merge+serde-devel \
 rust-gix-merge-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-merge-0.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f28559c5852d5da222a5b4a72e0f2650b12936e99c1929287326ab78c783bb89"

URI_x86_64_v2_rust-gix-merge+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-merge+default-devel-0.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-merge+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-merge+default-devel}"
SRC_URI[x86_64_v2_rust-gix-merge+default-devel.sha256sum] = "5459d66c8d192a9ac18c6209e71f2137d1a3b8945742809446c220916e0f156c"

URI_x86_64_v2_rust-gix-merge+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-merge+document-features-devel-0.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-merge+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-merge+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-merge+document-features-devel.sha256sum] = "c458187dfb82004d7288949c47191d05c0ceb35983e735903014d5d72a125b11"

URI_x86_64_v2_rust-gix-merge+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-merge+serde-devel-0.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-merge+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-merge+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-merge+serde-devel.sha256sum] = "006f850a5310d1f8c21f4b0df8a8f1d8ebc47c766dbd7125687e048637d21658"

URI_x86_64_v2_rust-gix-merge-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-merge-devel-0.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-merge-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-merge-devel}"
SRC_URI[x86_64_v2_rust-gix-merge-devel.sha256sum] = "facd489734f833bbf98f1e84cd49de94a466cdc42466a8d63e18175a276c7cf1"

URI_aarch64_rust-gix-merge+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-merge+default-devel-0.3.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-merge+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-merge+default-devel}"
SRC_URI[aarch64_rust-gix-merge+default-devel.sha256sum] = "2103517fda34cc7d2912e12ff378eb936c09b419098aa7b6294158b14b0bd60a"

URI_aarch64_rust-gix-merge+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-merge+document-features-devel-0.3.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-merge+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-merge+document-features-devel}"
SRC_URI[aarch64_rust-gix-merge+document-features-devel.sha256sum] = "19377eaa1c5b235d3c3d073523b2785a5c5d6175014b1e6482de96c38d7af76a"

URI_aarch64_rust-gix-merge+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-merge+serde-devel-0.3.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-merge+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-merge+serde-devel}"
SRC_URI[aarch64_rust-gix-merge+serde-devel.sha256sum] = "d9fecfc32beab15ec759060c32a0694be944882ef4081c9a51f5c46151420d1e"

URI_aarch64_rust-gix-merge-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-merge-devel-0.3.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-merge-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-merge-devel}"
SRC_URI[aarch64_rust-gix-merge-devel.sha256sum] = "e026465ba9e84fc1a9055ffba929801036a47154116016d8c3a6a5bfe12e2b62"

RDEPENDS:rust-gix-merge+default-devel = " \
 cargo \
 rust-gix-merge-devel \
 "
RDEPENDS:rust-gix-merge+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-merge-devel \
 "
RDEPENDS:rust-gix-merge+serde-devel = " \
 cargo \
 rust-gix-hash+serde-devel \
 rust-gix-merge-devel \
 rust-gix-object+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-merge-devel = " \
 cargo \
 rust \
 rust-bstr-devel \
 rust-gix-command+default-devel \
 rust-gix-diff+blob-devel \
 rust-gix-diff-devel \
 rust-gix-filter+default-devel \
 rust-gix-fs+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-index+default-devel \
 rust-gix-object+default-devel \
 rust-gix-path+default-devel \
 rust-gix-quote+default-devel \
 rust-gix-revision+merge_base-devel \
 rust-gix-revision-devel \
 rust-gix-revwalk+default-devel \
 rust-gix-tempfile+default-devel \
 rust-gix-trace+default-devel \
 rust-gix-worktree+attributes-devel \
 rust-gix-worktree-devel \
 rust-imara-diff+default-devel \
 rust-thiserror+default-devel \
 "
