# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "singularity-ce"
PV = "4.5.1"
PR = "1.el10_3"
PACKAGES = " \
 singularity-ce \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/singularity-ce-4.5.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1594b76adb066401139a1131c94240e6e80b39659f5e7d1ca4f2bff0eab9d668"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/singularity-ce-4.5.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_singularity-ce;unpack=0"
SRC_URI[x86_64_v2_singularity-ce.sha256sum] = "099ac8be9333a39c642e460932d9c64601760daea4f2bab16967ab792b7dc9ce"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/singularity-ce-4.5.1-1.el10_3.aarch64.rpm;name=aarch64_singularity-ce;unpack=0"
SRC_URI[aarch64_singularity-ce.sha256sum] = "07f79e0f45aeb2a9f2c939bef4d4d8da17330b6b6a33c301b5ec3470eb397ff6"

RDEPENDS:singularity-ce = " \
 bash \
 conmon \
 crun \
 cryptsetup \
 fuse \
 fuse3 \
 glibc \
 libseccomp \
 shadow-utils \
 shadow-utils-subid \
 squashfs-tools \
 squashfuse \
 "
