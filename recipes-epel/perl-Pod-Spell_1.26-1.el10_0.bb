# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Pod-Spell"
PV = "1.26"
PR = "1.el10_0"
PACKAGES = " \
 perl-Pod-Spell \
 perl-Pod-Spell-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Pod-Spell-1.26-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c7e70b128b21ee51d1aff4601d945c70520d5cb4144caec01beea0fdfd18c11"

URI_x86_64_v2_perl-Pod-Spell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Pod-Spell-1.26-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Pod-Spell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Pod-Spell}"
SRC_URI[x86_64_v2_perl-Pod-Spell.sha256sum] = "a88431afbc1298a50c341044ec11fcb9890dc13009a136d634cc019a8d4c26de"

URI_x86_64_v2_perl-Pod-Spell-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Pod-Spell-tests-1.26-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Pod-Spell-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Pod-Spell-tests}"
SRC_URI[x86_64_v2_perl-Pod-Spell-tests.sha256sum] = "7ef70e318d0708d6e9d7c26e6317c93681daae00f64241b383cde09cb7f7903f"

URI_aarch64_perl-Pod-Spell = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Pod-Spell-1.26-1.el10_0.noarch.rpm;name=aarch64_perl-Pod-Spell;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Pod-Spell}"
SRC_URI[aarch64_perl-Pod-Spell.sha256sum] = "9d464eb4d4bf3aae30cf9b88d5490032757092c120be5c7b105f2ad3f22c30a1"

URI_aarch64_perl-Pod-Spell-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Pod-Spell-tests-1.26-1.el10_0.noarch.rpm;name=aarch64_perl-Pod-Spell-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Pod-Spell-tests}"
SRC_URI[aarch64_perl-Pod-Spell-tests.sha256sum] = "f0831939ceddec43af482256848e4254a48bb4d7cd4aaf31550e58aa95fa8463"

RDEPENDS:perl-Pod-Spell = " \
 perl-Class-Tiny \
 perl-File-ShareDir \
 perl-Lingua-EN-Inflect \
 perl-PathTools \
 perl-Pod-Simple \
 perl-Pod-Spell \
 perl-Text-Tabs+Wrap \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-parent \
 "
RDEPENDS:perl-Pod-Spell-tests = " \
 bash \
 perl-ExtUtils-MakeMaker \
 perl-File-Temp \
 perl-IO \
 perl-IPC-Open3 \
 perl-PathTools \
 perl-Pod-Spell \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
