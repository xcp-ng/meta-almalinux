# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ppv-lite86"
PV = "0.2.21"
PR = "1.el10_0"
PACKAGES = " \
 rust-ppv-lite86+default-devel \
 rust-ppv-lite86+no_simd-devel \
 rust-ppv-lite86+simd-devel \
 rust-ppv-lite86+std-devel \
 rust-ppv-lite86-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ppv-lite86-0.2.21-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "784b941e9e4bdd79a107eddd090316044c851bc0ac9057eb295a304d21bb551c"

URI_x86_64_v2_rust-ppv-lite86+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ppv-lite86+default-devel-0.2.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ppv-lite86+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ppv-lite86+default-devel}"
SRC_URI[x86_64_v2_rust-ppv-lite86+default-devel.sha256sum] = "fa1b91bf242e2c9046a9c8c524daccae156b0c96f85d315789daeeda0c863803"

URI_x86_64_v2_rust-ppv-lite86+no_simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ppv-lite86+no_simd-devel-0.2.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ppv-lite86+no_simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ppv-lite86+no_simd-devel}"
SRC_URI[x86_64_v2_rust-ppv-lite86+no_simd-devel.sha256sum] = "90eec9e44b4a92bc39e49c307e25ce16c308aaee877417757c92a88aa878b8c3"

URI_x86_64_v2_rust-ppv-lite86+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ppv-lite86+simd-devel-0.2.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ppv-lite86+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ppv-lite86+simd-devel}"
SRC_URI[x86_64_v2_rust-ppv-lite86+simd-devel.sha256sum] = "266cfe8a79bada676bccac8b69a009d48bce832811c10aac2e1a279f164de150"

URI_x86_64_v2_rust-ppv-lite86+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ppv-lite86+std-devel-0.2.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ppv-lite86+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ppv-lite86+std-devel}"
SRC_URI[x86_64_v2_rust-ppv-lite86+std-devel.sha256sum] = "9bee1a2c98157e47daa0dc1355e02433dbe76a342b07166b6641099e95050947"

URI_x86_64_v2_rust-ppv-lite86-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ppv-lite86-devel-0.2.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ppv-lite86-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ppv-lite86-devel}"
SRC_URI[x86_64_v2_rust-ppv-lite86-devel.sha256sum] = "f185cad3ede22ff60635e5204bbcdb22103b9ea3eeeb0bf5eea07c7ccb2ebf71"

URI_aarch64_rust-ppv-lite86+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ppv-lite86+default-devel-0.2.21-1.el10_0.noarch.rpm;name=aarch64_rust-ppv-lite86+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ppv-lite86+default-devel}"
SRC_URI[aarch64_rust-ppv-lite86+default-devel.sha256sum] = "e0ff001f5a30940e837d6653bc81ee02c16ed4bcd78a1e57db8a4130ff63717a"

URI_aarch64_rust-ppv-lite86+no_simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ppv-lite86+no_simd-devel-0.2.21-1.el10_0.noarch.rpm;name=aarch64_rust-ppv-lite86+no_simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ppv-lite86+no_simd-devel}"
SRC_URI[aarch64_rust-ppv-lite86+no_simd-devel.sha256sum] = "a68befea6d2f92a09aaa147aa0f1e9c2d815fb1743e6ca1d8a539ccd969832f0"

URI_aarch64_rust-ppv-lite86+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ppv-lite86+simd-devel-0.2.21-1.el10_0.noarch.rpm;name=aarch64_rust-ppv-lite86+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ppv-lite86+simd-devel}"
SRC_URI[aarch64_rust-ppv-lite86+simd-devel.sha256sum] = "ce228c2e3516a2b848117dc529bde38c9766649f8cf463088a37d668cc92a852"

URI_aarch64_rust-ppv-lite86+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ppv-lite86+std-devel-0.2.21-1.el10_0.noarch.rpm;name=aarch64_rust-ppv-lite86+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ppv-lite86+std-devel}"
SRC_URI[aarch64_rust-ppv-lite86+std-devel.sha256sum] = "cb9ae84a403634b9c486cc5ac9af59edf3023372ea50f6b4748b6c4e6d3de950"

URI_aarch64_rust-ppv-lite86-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ppv-lite86-devel-0.2.21-1.el10_0.noarch.rpm;name=aarch64_rust-ppv-lite86-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ppv-lite86-devel}"
SRC_URI[aarch64_rust-ppv-lite86-devel.sha256sum] = "88cc0597c55224e157f343f728b60aa117cbaed9856f66070ab9a1d040834c02"

RDEPENDS:rust-ppv-lite86+default-devel = " \
 cargo \
 rust-ppv-lite86+std-devel \
 rust-ppv-lite86-devel \
 "
RDEPENDS:rust-ppv-lite86+no_simd-devel = " \
 cargo \
 rust-ppv-lite86-devel \
 "
RDEPENDS:rust-ppv-lite86+simd-devel = " \
 cargo \
 rust-ppv-lite86-devel \
 "
RDEPENDS:rust-ppv-lite86+std-devel = " \
 cargo \
 rust-ppv-lite86-devel \
 "
RDEPENDS:rust-ppv-lite86-devel = " \
 cargo \
 rust \
 rust-zerocopy+default-devel \
 rust-zerocopy+simd-devel \
 "
