# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dieharder"
PV = "3.31.1"
PR = "1.el10_1"
PACKAGES = " \
 dieharder \
 dieharder-devel \
 dieharder-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/dieharder-3.31.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d2a4a4a7ec0225fabdbcff807d4daeed1d4f629d2fbb8951c8401bd8bd3dd9af"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dieharder-3.31.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dieharder;unpack=0"
SRC_URI[x86_64_v2_dieharder.sha256sum] = "ead6b26d10023daa5dab661ad8203f4968787302a0b6cda50a3ae53e4cb21b1a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dieharder-devel-3.31.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dieharder-devel;unpack=0"
SRC_URI[x86_64_v2_dieharder-devel.sha256sum] = "fa813394d980654d3ab909e961b96083b128e4540eb8bd94954c1823a9858c62"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dieharder-libs-3.31.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dieharder-libs;unpack=0"
SRC_URI[x86_64_v2_dieharder-libs.sha256sum] = "3d88a0b59c5c5a879c1aaba96c2d940047cab7fd8c435bcf23bf17c4385659ea"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dieharder-3.31.1-1.el10_1.aarch64.rpm;name=aarch64_dieharder;unpack=0"
SRC_URI[aarch64_dieharder.sha256sum] = "e0a39c63b6de758db0f3a83a98dce502bc6768889186b93fe2f78d55242c2bda"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dieharder-devel-3.31.1-1.el10_1.aarch64.rpm;name=aarch64_dieharder-devel;unpack=0"
SRC_URI[aarch64_dieharder-devel.sha256sum] = "d81f53b62b5ed4f53fc935009a5d9f4ca1f7672fde6532eb9e4188393fe90ddb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dieharder-libs-3.31.1-1.el10_1.aarch64.rpm;name=aarch64_dieharder-libs;unpack=0"
SRC_URI[aarch64_dieharder-libs.sha256sum] = "4d0bef00191f4a9fcc17e8c734d959a9b9b47edd917acdc2cd6e4ce9cb81e7f8"

RDEPENDS:dieharder = " \
 dieharder-libs \
 glibc \
 gsl \
 "
RDEPENDS:dieharder-devel = " \
 dieharder \
 dieharder-libs \
 "
RDEPENDS:dieharder-libs = " \
 glibc \
 gsl \
 "
