# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "trafficserver"
PV = "10.2.0"
PR = "1.el10_2"
PACKAGES = " \
 trafficserver \
 trafficserver-devel \
 trafficserver-selinux \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/t/trafficserver-10.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bd9d68a63b954122e0a0f24c0ace76f8e68da82de8fbf861f6234fd6a67da0e4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/trafficserver-10.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_trafficserver;unpack=0"
SRC_URI[x86_64_v2_trafficserver.sha256sum] = "557267ddaa6a48220b91d679496d953e1929ecc8d96899aea138dca42159a0b3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/trafficserver-devel-10.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_trafficserver-devel;unpack=0"
SRC_URI[x86_64_v2_trafficserver-devel.sha256sum] = "4d1a4bd9d7a17c75d95fdd77ab432104542ccca3498874a69b11e314d9d1416e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/trafficserver-selinux-10.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_trafficserver-selinux;unpack=0"
SRC_URI[x86_64_v2_trafficserver-selinux.sha256sum] = "1fbb8f5242dc1002cfa9840050bc4bfcedccbf82f645b0a8e65d517e81bde9a6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/trafficserver-10.2.0-1.el10_2.aarch64.rpm;name=aarch64_trafficserver;unpack=0"
SRC_URI[aarch64_trafficserver.sha256sum] = "d7d2e0c0eb0643b047990cb43f3159c63f975dfdda1a6125472932cd4085313c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/trafficserver-devel-10.2.0-1.el10_2.aarch64.rpm;name=aarch64_trafficserver-devel;unpack=0"
SRC_URI[aarch64_trafficserver-devel.sha256sum] = "20a243de75941792ba82e23210ce2210c2bcf142677ed3539f01ea387dffcdcd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/trafficserver-selinux-10.2.0-1.el10_2.noarch.rpm;name=aarch64_trafficserver-selinux;unpack=0"
SRC_URI[aarch64_trafficserver-selinux.sha256sum] = "c1b3a05c056441355b53145f795b348d658025771a7c093bba5e1c1a8d4666ad"

RDEPENDS:trafficserver = " \
 bash \
 expat \
 glibc \
 hwloc \
 hwloc-libs \
 libbrotli \
 libcap \
 libgcc \
 libstdc++ \
 ncurses \
 ncurses-libs \
 openssl \
 openssl-libs \
 pcre2 \
 pkgconf-pkg-config \
 python3 \
 python3-colorama \
 python3-jsonschema \
 python3-pyyaml \
 systemd \
 trafficserver-selinux \
 virtual//usr/bin/env \
 xz \
 xz-libs \
 yaml-cpp \
 zlib-ng-compat \
 "
RDEPENDS:trafficserver-devel = " \
 pkgconf-pkg-config \
 trafficserver \
 yaml-cpp-devel \
 "
RDEPENDS:trafficserver-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
