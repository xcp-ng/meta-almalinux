# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rcgen"
PV = "0.13.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-rcgen+crypto-devel \
 rust-rcgen+default-devel \
 rust-rcgen+pem-devel \
 rust-rcgen+ring-devel \
 rust-rcgen+x509-parser-devel \
 rust-rcgen+zeroize-devel \
 rust-rcgen-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rcgen-0.13.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bee5f23792ab3d7e539c399cb0a845b70e48193ec70abecd48029997981176d9"

URI_x86_64_v2_rust-rcgen+crypto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rcgen+crypto-devel-0.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rcgen+crypto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rcgen+crypto-devel}"
SRC_URI[x86_64_v2_rust-rcgen+crypto-devel.sha256sum] = "746d58b49fb15b6c135824f852bc0312690dcad2c16c290d967331d68b87fc90"

URI_x86_64_v2_rust-rcgen+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rcgen+default-devel-0.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rcgen+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rcgen+default-devel}"
SRC_URI[x86_64_v2_rust-rcgen+default-devel.sha256sum] = "9024a14a800fb212c47fb374cf0fd8349a398eaa179444777be6effc11bfd43e"

URI_x86_64_v2_rust-rcgen+pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rcgen+pem-devel-0.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rcgen+pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rcgen+pem-devel}"
SRC_URI[x86_64_v2_rust-rcgen+pem-devel.sha256sum] = "0377e935dd11988101833d0a51aa6f6f3cbb265199d94a6c8564cb496bea9b8a"

URI_x86_64_v2_rust-rcgen+ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rcgen+ring-devel-0.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rcgen+ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rcgen+ring-devel}"
SRC_URI[x86_64_v2_rust-rcgen+ring-devel.sha256sum] = "05c1625979fba4faa530fb92decf24e4d9e6cfe9b840de3ded839c95121b6f6b"

URI_x86_64_v2_rust-rcgen+x509-parser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rcgen+x509-parser-devel-0.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rcgen+x509-parser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rcgen+x509-parser-devel}"
SRC_URI[x86_64_v2_rust-rcgen+x509-parser-devel.sha256sum] = "a1bf27dce62dcbf1c46c2bcaa59b701f047c0a03ee58d029839d6d11acc4f186"

URI_x86_64_v2_rust-rcgen+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rcgen+zeroize-devel-0.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rcgen+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rcgen+zeroize-devel}"
SRC_URI[x86_64_v2_rust-rcgen+zeroize-devel.sha256sum] = "47acab645e0fed49dd798b2e45ade19c679c3be4eaeaaaf42be7316d97a4ee9c"

URI_x86_64_v2_rust-rcgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rcgen-devel-0.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rcgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rcgen-devel}"
SRC_URI[x86_64_v2_rust-rcgen-devel.sha256sum] = "eb66e13e755d64603e9eeafeff3aaa49c54667d4ad10a74fad9bbcaf3e05a403"

URI_aarch64_rust-rcgen+crypto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rcgen+crypto-devel-0.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-rcgen+crypto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rcgen+crypto-devel}"
SRC_URI[aarch64_rust-rcgen+crypto-devel.sha256sum] = "ac276daf1f86e020ac3ebe9fc520f98e35a1a1530bdc21061a3ff001f38f08eb"

URI_aarch64_rust-rcgen+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rcgen+default-devel-0.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-rcgen+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rcgen+default-devel}"
SRC_URI[aarch64_rust-rcgen+default-devel.sha256sum] = "8778a2691c4e5e3e12e4eca0ad101f0a0d6397781b2d719e6a5f64998b74172b"

URI_aarch64_rust-rcgen+pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rcgen+pem-devel-0.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-rcgen+pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rcgen+pem-devel}"
SRC_URI[aarch64_rust-rcgen+pem-devel.sha256sum] = "b9ad96124d28a5e4f3070991aa7fe227f1e48886e559fe4c918895aeac1acbf8"

URI_aarch64_rust-rcgen+ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rcgen+ring-devel-0.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-rcgen+ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rcgen+ring-devel}"
SRC_URI[aarch64_rust-rcgen+ring-devel.sha256sum] = "f99c6e22e51cadfd36099da7fd935fd45a93dd6fa13683d2a824891b9c85d37e"

URI_aarch64_rust-rcgen+x509-parser-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rcgen+x509-parser-devel-0.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-rcgen+x509-parser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rcgen+x509-parser-devel}"
SRC_URI[aarch64_rust-rcgen+x509-parser-devel.sha256sum] = "14882106d673d76f3f39ccfc3c23847b526265255daea7b6ce96fd1ba138319d"

URI_aarch64_rust-rcgen+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rcgen+zeroize-devel-0.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-rcgen+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rcgen+zeroize-devel}"
SRC_URI[aarch64_rust-rcgen+zeroize-devel.sha256sum] = "614952b0bfe4e20e36031ec416eb8b45807890092f4bccbafdf044eea10ef3b5"

URI_aarch64_rust-rcgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rcgen-devel-0.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-rcgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rcgen-devel}"
SRC_URI[aarch64_rust-rcgen-devel.sha256sum] = "4c9835f72746afdcc3c29ded54bbdcdd6970dab29f2063ba432f1fe0352d7877"

RDEPENDS:rust-rcgen+crypto-devel = " \
 cargo \
 rust-rcgen-devel \
 "
RDEPENDS:rust-rcgen+default-devel = " \
 cargo \
 rust-rcgen+crypto-devel \
 rust-rcgen+pem-devel \
 rust-rcgen+ring-devel \
 rust-rcgen-devel \
 "
RDEPENDS:rust-rcgen+pem-devel = " \
 cargo \
 rust-pem+default-devel \
 rust-rcgen-devel \
 "
RDEPENDS:rust-rcgen+ring-devel = " \
 cargo \
 rust-rcgen+crypto-devel \
 rust-rcgen-devel \
 rust-ring+default-devel \
 "
RDEPENDS:rust-rcgen+x509-parser-devel = " \
 cargo \
 rust-rcgen-devel \
 rust-x509-parser+default-devel \
 rust-x509-parser+verify-devel \
 "
RDEPENDS:rust-rcgen+zeroize-devel = " \
 cargo \
 rust-rcgen-devel \
 rust-zeroize+default-devel \
 "
RDEPENDS:rust-rcgen-devel = " \
 cargo \
 rust-rustls-pki-types+default-devel \
 rust-time-devel \
 rust-yasna+default-devel \
 rust-yasna+std-devel \
 rust-yasna+time-devel \
 "
