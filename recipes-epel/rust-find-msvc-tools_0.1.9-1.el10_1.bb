# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-find-msvc-tools"
PV = "0.1.9"
PR = "1.el10_1"
PACKAGES = " \
 rust-find-msvc-tools+default-devel \
 rust-find-msvc-tools-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-find-msvc-tools-0.1.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a50b7453024568e18bae4ee32443fd4b51e955e4abb26bf795354dbc41daa286"

URI_x86_64_v2_rust-find-msvc-tools+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-find-msvc-tools+default-devel-0.1.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-find-msvc-tools+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-find-msvc-tools+default-devel}"
SRC_URI[x86_64_v2_rust-find-msvc-tools+default-devel.sha256sum] = "1d9d76b7c4923b79d69748b31b271140eca54c3de1f78a91d99b17d26b1ffefd"

URI_x86_64_v2_rust-find-msvc-tools-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-find-msvc-tools-devel-0.1.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-find-msvc-tools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-find-msvc-tools-devel}"
SRC_URI[x86_64_v2_rust-find-msvc-tools-devel.sha256sum] = "be77d152c88d7223e8c77eceb91d3fea36b39d2de2fd0a77c3309ebcde8268fa"

URI_aarch64_rust-find-msvc-tools+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-find-msvc-tools+default-devel-0.1.9-1.el10_1.noarch.rpm;name=aarch64_rust-find-msvc-tools+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-find-msvc-tools+default-devel}"
SRC_URI[aarch64_rust-find-msvc-tools+default-devel.sha256sum] = "e733cd4da4cd9c9a006bf150254ef641c18b8d3447de6279c6335d96571399a6"

URI_aarch64_rust-find-msvc-tools-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-find-msvc-tools-devel-0.1.9-1.el10_1.noarch.rpm;name=aarch64_rust-find-msvc-tools-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-find-msvc-tools-devel}"
SRC_URI[aarch64_rust-find-msvc-tools-devel.sha256sum] = "ebcc1aac6624dd286cc0c71d83dfb8102c646d8dbd60ce8f98dfe794955050dd"

RDEPENDS:rust-find-msvc-tools+default-devel = " \
 cargo \
 rust-find-msvc-tools-devel \
 "
RDEPENDS:rust-find-msvc-tools-devel = " \
 cargo \
 rust \
 "
