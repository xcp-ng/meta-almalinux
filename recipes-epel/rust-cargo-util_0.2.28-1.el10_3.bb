# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-util"
PV = "0.2.28"
PR = "1.el10_3"
PACKAGES = " \
 rust-cargo-util+default-devel \
 rust-cargo-util-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-util-0.2.28-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5259e93970628168c672b04db6b3df8353074cd97c7934b8aed5cd8ac5292bca"

URI_x86_64_v2_rust-cargo-util+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-util+default-devel-0.2.28-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-util+default-devel}"
SRC_URI[x86_64_v2_rust-cargo-util+default-devel.sha256sum] = "fe6bc830cf5b12367343faaada9c86d6d8ae41bf1f7c76e83e5307c729646629"

URI_x86_64_v2_rust-cargo-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-util-devel-0.2.28-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-util-devel}"
SRC_URI[x86_64_v2_rust-cargo-util-devel.sha256sum] = "27de20518f2b53e780fa75363d9200afd262bd86817a8a6723dddb6915038f17"

URI_aarch64_rust-cargo-util+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-util+default-devel-0.2.28-1.el10_3.noarch.rpm;name=aarch64_rust-cargo-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-util+default-devel}"
SRC_URI[aarch64_rust-cargo-util+default-devel.sha256sum] = "7114b0009b54966b977c1dcc4b892d38576cc8de20d2f581181158fd535aac4c"

URI_aarch64_rust-cargo-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-util-devel-0.2.28-1.el10_3.noarch.rpm;name=aarch64_rust-cargo-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-util-devel}"
SRC_URI[aarch64_rust-cargo-util-devel.sha256sum] = "3903e765591bdd77b0d4df8070bb8d47899c71a051cba189b43c185d00fc6c76"

RDEPENDS:rust-cargo-util+default-devel = " \
 cargo \
 rust-cargo-util-devel \
 "
RDEPENDS:rust-cargo-util-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-filetime+default-devel \
 rust-hex+default-devel \
 rust-ignore+default-devel \
 rust-jobserver+default-devel \
 rust-libc+default-devel \
 rust-same-file+default-devel \
 rust-sha2_0.10+default-devel \
 rust-shell-escape+default-devel \
 rust-tempfile+default-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 rust-walkdir+default-devel \
 "
