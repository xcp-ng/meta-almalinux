# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-quick-xml0.37"
PV = "0.37.5"
PR = "2.el10_1"
PACKAGES = " \
 rust-quick-xml0.37+arbitrary-devel \
 rust-quick-xml0.37+async-tokio-devel \
 rust-quick-xml0.37+default-devel \
 rust-quick-xml0.37+document-features-devel \
 rust-quick-xml0.37+encoding-devel \
 rust-quick-xml0.37+encoding_rs-devel \
 rust-quick-xml0.37+escape-html-devel \
 rust-quick-xml0.37+overlapped-lists-devel \
 rust-quick-xml0.37+serde-devel \
 rust-quick-xml0.37+serde-types-devel \
 rust-quick-xml0.37+serialize-devel \
 rust-quick-xml0.37+tokio-devel \
 rust-quick-xml0.37-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-quick-xml0.37-0.37.5-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f625cc761a763a9948ee9a60fbbd2eb6bd6ddc6707b03edc3891fc7c58afb583"

URI_x86_64_v2_rust-quick-xml0.37+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.37+arbitrary-devel-0.37.5-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.37+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.37+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.37+arbitrary-devel.sha256sum] = "2f697c8f13257776a5c0d6ffb0bfeee43d92bfbbf8965a81802ef12445bdfb39"

URI_x86_64_v2_rust-quick-xml0.37+async-tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.37+async-tokio-devel-0.37.5-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.37+async-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.37+async-tokio-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.37+async-tokio-devel.sha256sum] = "5e942da755a52eca720c004aab7296b51a38d9871d7f6f0fbb6b9808d4d9e1c3"

URI_x86_64_v2_rust-quick-xml0.37+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.37+default-devel-0.37.5-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.37+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.37+default-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.37+default-devel.sha256sum] = "df1d2d7fd84e0967d6c21b42a0b93cdccbd5984e506f1a6d2ce7b5182da5ff0f"

URI_x86_64_v2_rust-quick-xml0.37+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.37+document-features-devel-0.37.5-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.37+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.37+document-features-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.37+document-features-devel.sha256sum] = "549a8715f071780396d8a09dba432040c197a9a9e95555ec3426dc0ed5f1317f"

URI_x86_64_v2_rust-quick-xml0.37+encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.37+encoding-devel-0.37.5-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.37+encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.37+encoding-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.37+encoding-devel.sha256sum] = "fdb03c9442cd31a1a6c8d6e2396cb458c1cb8d5d363d35bf1faf424ca79aff9c"

URI_x86_64_v2_rust-quick-xml0.37+encoding_rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.37+encoding_rs-devel-0.37.5-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.37+encoding_rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.37+encoding_rs-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.37+encoding_rs-devel.sha256sum] = "faf1a616b41a185424a0cd7fa3c14e5bc607531d36c23d6235f244e632e20b54"

URI_x86_64_v2_rust-quick-xml0.37+escape-html-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.37+escape-html-devel-0.37.5-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.37+escape-html-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.37+escape-html-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.37+escape-html-devel.sha256sum] = "5be90c2f7d271cc43c2fb6fe7638ad73b9defaba28a433a75835f001017f107b"

URI_x86_64_v2_rust-quick-xml0.37+overlapped-lists-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.37+overlapped-lists-devel-0.37.5-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.37+overlapped-lists-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.37+overlapped-lists-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.37+overlapped-lists-devel.sha256sum] = "ad206f3150b5451929375f3b673c5bd758e7fcad9815c25f707f9c5d18a8026a"

URI_x86_64_v2_rust-quick-xml0.37+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.37+serde-devel-0.37.5-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.37+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.37+serde-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.37+serde-devel.sha256sum] = "286076a37d45aa9a8db38e1aaab79d66373b23ade41afbc99e83604bc97892f4"

URI_x86_64_v2_rust-quick-xml0.37+serde-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.37+serde-types-devel-0.37.5-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.37+serde-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.37+serde-types-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.37+serde-types-devel.sha256sum] = "5f5d5a5ede2ba34f5e8c24193629f8cc1cbfde73eef21e31aaea945e514912b3"

URI_x86_64_v2_rust-quick-xml0.37+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.37+serialize-devel-0.37.5-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.37+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.37+serialize-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.37+serialize-devel.sha256sum] = "4f9941089cb4668c75bb059c9785b01389d15333338c7953dd442afc381f3f78"

URI_x86_64_v2_rust-quick-xml0.37+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.37+tokio-devel-0.37.5-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.37+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.37+tokio-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.37+tokio-devel.sha256sum] = "2b835e0f2954a68ef565a0f91c7a41b9df5f69ead9402ba1c41fbd0c51a0b4c0"

URI_x86_64_v2_rust-quick-xml0.37-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.37-devel-0.37.5-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.37-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.37-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.37-devel.sha256sum] = "d023047583fac796b2fd4d2545ccf396721620fa8b3d19a64d694de87135b058"

URI_aarch64_rust-quick-xml0.37+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.37+arbitrary-devel-0.37.5-2.el10_1.noarch.rpm;name=aarch64_rust-quick-xml0.37+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.37+arbitrary-devel}"
SRC_URI[aarch64_rust-quick-xml0.37+arbitrary-devel.sha256sum] = "c245754fd4c29514230992d51bd9d695cfbdbfcb41e2852e93824951f66784dc"

URI_aarch64_rust-quick-xml0.37+async-tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.37+async-tokio-devel-0.37.5-2.el10_1.noarch.rpm;name=aarch64_rust-quick-xml0.37+async-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.37+async-tokio-devel}"
SRC_URI[aarch64_rust-quick-xml0.37+async-tokio-devel.sha256sum] = "9f17ac3efca4920bfeb035f03df38ee02a4b448707e017f2dc65cc758ad60775"

URI_aarch64_rust-quick-xml0.37+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.37+default-devel-0.37.5-2.el10_1.noarch.rpm;name=aarch64_rust-quick-xml0.37+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.37+default-devel}"
SRC_URI[aarch64_rust-quick-xml0.37+default-devel.sha256sum] = "3ddcb10ad6ed0840bd9a304aad1644c38a6d170353314db2938c9a4b9004a7c3"

URI_aarch64_rust-quick-xml0.37+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.37+document-features-devel-0.37.5-2.el10_1.noarch.rpm;name=aarch64_rust-quick-xml0.37+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.37+document-features-devel}"
SRC_URI[aarch64_rust-quick-xml0.37+document-features-devel.sha256sum] = "1b96fd125674a55cb66efb48875ba67a1ade573ba4d179d3d60f1664fbc28ea1"

URI_aarch64_rust-quick-xml0.37+encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.37+encoding-devel-0.37.5-2.el10_1.noarch.rpm;name=aarch64_rust-quick-xml0.37+encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.37+encoding-devel}"
SRC_URI[aarch64_rust-quick-xml0.37+encoding-devel.sha256sum] = "177be4cca619500ba8f43d3f080025e49d27e695ca617888c34b35f0dc0471ca"

URI_aarch64_rust-quick-xml0.37+encoding_rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.37+encoding_rs-devel-0.37.5-2.el10_1.noarch.rpm;name=aarch64_rust-quick-xml0.37+encoding_rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.37+encoding_rs-devel}"
SRC_URI[aarch64_rust-quick-xml0.37+encoding_rs-devel.sha256sum] = "7109e013c241180a562df78c9c18c5584c75f0f478974ceadcb89cd7b1d502e8"

URI_aarch64_rust-quick-xml0.37+escape-html-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.37+escape-html-devel-0.37.5-2.el10_1.noarch.rpm;name=aarch64_rust-quick-xml0.37+escape-html-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.37+escape-html-devel}"
SRC_URI[aarch64_rust-quick-xml0.37+escape-html-devel.sha256sum] = "0a8411a63d9ea80b90f59c1ec0a3069a65021e60f9c74f50ff906a5af4e741ba"

URI_aarch64_rust-quick-xml0.37+overlapped-lists-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.37+overlapped-lists-devel-0.37.5-2.el10_1.noarch.rpm;name=aarch64_rust-quick-xml0.37+overlapped-lists-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.37+overlapped-lists-devel}"
SRC_URI[aarch64_rust-quick-xml0.37+overlapped-lists-devel.sha256sum] = "25af2776e2d180c2b88cc547c8afb6704bf74914edd5acd24435ed76a694c8ae"

URI_aarch64_rust-quick-xml0.37+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.37+serde-devel-0.37.5-2.el10_1.noarch.rpm;name=aarch64_rust-quick-xml0.37+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.37+serde-devel}"
SRC_URI[aarch64_rust-quick-xml0.37+serde-devel.sha256sum] = "11f5a841f4a6bb08d1119564cb498487cc0c7ec4aadd4edbe3bf3d4b076d521b"

URI_aarch64_rust-quick-xml0.37+serde-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.37+serde-types-devel-0.37.5-2.el10_1.noarch.rpm;name=aarch64_rust-quick-xml0.37+serde-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.37+serde-types-devel}"
SRC_URI[aarch64_rust-quick-xml0.37+serde-types-devel.sha256sum] = "44890194a6871cf374837e1580b33c47a915801a47c1fabd7ebe0fd066d25351"

URI_aarch64_rust-quick-xml0.37+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.37+serialize-devel-0.37.5-2.el10_1.noarch.rpm;name=aarch64_rust-quick-xml0.37+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.37+serialize-devel}"
SRC_URI[aarch64_rust-quick-xml0.37+serialize-devel.sha256sum] = "f3852e5e17b9179cb175e36cd0b3bb338cbacd0421aaf34e00ebbefe95628d09"

URI_aarch64_rust-quick-xml0.37+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.37+tokio-devel-0.37.5-2.el10_1.noarch.rpm;name=aarch64_rust-quick-xml0.37+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.37+tokio-devel}"
SRC_URI[aarch64_rust-quick-xml0.37+tokio-devel.sha256sum] = "04acb3edc37c052df944270c767eb7932f52f81bf0f4e5cfa19eb5d0a64efb02"

URI_aarch64_rust-quick-xml0.37-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.37-devel-0.37.5-2.el10_1.noarch.rpm;name=aarch64_rust-quick-xml0.37-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.37-devel}"
SRC_URI[aarch64_rust-quick-xml0.37-devel.sha256sum] = "074eaa5f34f53e210f5d2b73828b419c129c2096b5e00c6bf6cd0d96390ec6a4"

RDEPENDS:rust-quick-xml0.37+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-quick-xml0.37-devel \
 "
RDEPENDS:rust-quick-xml0.37+async-tokio-devel = " \
 cargo \
 rust-quick-xml0.37+tokio-devel \
 rust-quick-xml0.37-devel \
 "
RDEPENDS:rust-quick-xml0.37+default-devel = " \
 cargo \
 rust-quick-xml0.37-devel \
 "
RDEPENDS:rust-quick-xml0.37+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-quick-xml0.37-devel \
 "
RDEPENDS:rust-quick-xml0.37+encoding-devel = " \
 cargo \
 rust-quick-xml0.37+encoding_rs-devel \
 rust-quick-xml0.37-devel \
 "
RDEPENDS:rust-quick-xml0.37+encoding_rs-devel = " \
 cargo \
 rust-encoding_rs+default-devel \
 rust-quick-xml0.37-devel \
 "
RDEPENDS:rust-quick-xml0.37+escape-html-devel = " \
 cargo \
 rust-quick-xml0.37-devel \
 "
RDEPENDS:rust-quick-xml0.37+overlapped-lists-devel = " \
 cargo \
 rust-quick-xml0.37-devel \
 "
RDEPENDS:rust-quick-xml0.37+serde-devel = " \
 cargo \
 rust-quick-xml0.37-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-quick-xml0.37+serde-types-devel = " \
 cargo \
 rust-quick-xml0.37-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-quick-xml0.37+serialize-devel = " \
 cargo \
 rust-quick-xml0.37+serde-devel \
 rust-quick-xml0.37-devel \
 "
RDEPENDS:rust-quick-xml0.37+tokio-devel = " \
 cargo \
 rust-quick-xml0.37-devel \
 rust-tokio+io-util-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-quick-xml0.37-devel = " \
 cargo \
 rust \
 rust-memchr+default-devel \
 "
