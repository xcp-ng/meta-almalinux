# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "liboqs"
PV = "0.12.0"
PR = "2.el10"
PACKAGES = " \
 liboqs \
 liboqs-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/liboqs-0.12.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "910cdb5c66f1fcd7e4091b4457d83a2aa16a2064b3cd30b19af0cf93ba9fb580"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/liboqs-0.12.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_liboqs;unpack=0"
SRC_URI[x86_64_v2_liboqs.sha256sum] = "b3822033c3abc5fdc6880cfc4591ca0e3aead450286ac3f353923104a07f0616"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/liboqs-devel-0.12.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_liboqs-devel;unpack=0"
SRC_URI[x86_64_v2_liboqs-devel.sha256sum] = "ea408a9e897820acf032d46911504cb2a0a3cd4e49671ecfe8318345504fe576"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/liboqs-0.12.0-2.el10.aarch64.rpm;name=aarch64_liboqs;unpack=0"
SRC_URI[aarch64_liboqs.sha256sum] = "c20a2e2bb88cbf22be032e3d8bc8dbc12209fdb526875f3d3851e5c3ea8f67af"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/liboqs-devel-0.12.0-2.el10.aarch64.rpm;name=aarch64_liboqs-devel;unpack=0"
SRC_URI[aarch64_liboqs-devel.sha256sum] = "e384d2ae86ce69f671afdde95dc11a06810e28f6a15b1d2f084c403742185bf1"

RDEPENDS:liboqs = " \
 glibc \
 "
RDEPENDS:liboqs-devel = " \
 cmake-filesystem \
 liboqs \
 openssl-devel \
 pkgconf-pkg-config \
 "
