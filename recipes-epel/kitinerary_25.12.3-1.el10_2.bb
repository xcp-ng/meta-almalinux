# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kitinerary"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kitinerary \
 kitinerary-devel \
 kitinerary-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kitinerary-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85760cef1a76e1989d2d4fdabfbaf4bc2997c8f887c5e84c85b84adbf9ee52f2"

URI_x86_64_v2_kitinerary = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kitinerary-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kitinerary;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kitinerary}"
SRC_URI[x86_64_v2_kitinerary.sha256sum] = "0a816e420c450fd5f14e6d278852572372d4bda0cab032e8ec139bd3934017c8"

URI_x86_64_v2_kitinerary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kitinerary-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kitinerary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kitinerary-devel}"
SRC_URI[x86_64_v2_kitinerary-devel.sha256sum] = "c78f9c3662967570cbc2b43cadfcac80e0cecbecee7bacf6c196915b94ef9782"

URI_x86_64_v2_kitinerary-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kitinerary-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kitinerary-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kitinerary-doc}"
SRC_URI[x86_64_v2_kitinerary-doc.sha256sum] = "e2cfb2c1381b599c03ea9ada615e4faa70bf33fe6b5c3d425fad89942df14c4f"

URI_aarch64_kitinerary = "${EPEL_MIRROR}/aarch64/Packages/k/kitinerary-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kitinerary;unpack=0"
SRC_URI:append = " ${URI_aarch64_kitinerary}"
SRC_URI[aarch64_kitinerary.sha256sum] = "2b27cf6787dc552e03c0b08ea870ea0cf65863d01c30d7fb7e4375c8a876d1b6"

URI_aarch64_kitinerary-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kitinerary-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kitinerary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kitinerary-devel}"
SRC_URI[aarch64_kitinerary-devel.sha256sum] = "a22288b675af339cf43a5d66a356447568af1a3e5f8c300c1794f1315c7cc0d6"

URI_aarch64_kitinerary-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kitinerary-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_kitinerary-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kitinerary-doc}"
SRC_URI[aarch64_kitinerary-doc.sha256sum] = "38b6eac36064a6826e89a536860c625bc53ea80c28462223c7c69772f6d4e553"

RDEPENDS:kitinerary = " \
 glibc \
 kf6-karchive \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kcontacts \
 kf6-ki18n \
 kmime \
 kpkpass \
 libgcc \
 libstdc++ \
 libxml2 \
 openssl-libs \
 poppler \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 zlib-ng-compat \
 zxing-cpp \
 "
RDEPENDS:kitinerary-devel = " \
 cmake-filesystem \
 kf6-kcalendarcore-devel \
 kf6-kcontacts-devel \
 kitinerary \
 kmime-devel \
 kpkpass-devel \
 "
RDEPENDS:kitinerary-doc = " \
 "
