# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bcrypt"
PV = "0.16.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-bcrypt+alloc-devel \
 rust-bcrypt+default-devel \
 rust-bcrypt+getrandom-devel \
 rust-bcrypt+std-devel \
 rust-bcrypt+zeroize-devel \
 rust-bcrypt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bcrypt-0.16.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "316ff8ff4c95576f8497b39b9635d3c39053776f3fbc53cac1af29ecc81cf5d3"

URI_x86_64_v2_rust-bcrypt+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bcrypt+alloc-devel-0.16.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bcrypt+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bcrypt+alloc-devel}"
SRC_URI[x86_64_v2_rust-bcrypt+alloc-devel.sha256sum] = "b79c10ada21c794a8b5a8f223f17f7c3a9ce85df6d3c0fb8bf6932206d8bab5f"

URI_x86_64_v2_rust-bcrypt+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bcrypt+default-devel-0.16.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bcrypt+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bcrypt+default-devel}"
SRC_URI[x86_64_v2_rust-bcrypt+default-devel.sha256sum] = "8fcde427490348b5de82c09866441e8a708947e9808c156d4eb1c8b0cbaa8634"

URI_x86_64_v2_rust-bcrypt+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bcrypt+getrandom-devel-0.16.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bcrypt+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bcrypt+getrandom-devel}"
SRC_URI[x86_64_v2_rust-bcrypt+getrandom-devel.sha256sum] = "36e69ca3b3ae51c76ac52af50847313b1b94d2cded7d46d8c935bebc47a2e4a2"

URI_x86_64_v2_rust-bcrypt+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bcrypt+std-devel-0.16.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bcrypt+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bcrypt+std-devel}"
SRC_URI[x86_64_v2_rust-bcrypt+std-devel.sha256sum] = "ccaf1776a53e6a04b5ceb0c0fcaa6567d4458c4c936ae6da6068a4b4c28227ee"

URI_x86_64_v2_rust-bcrypt+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bcrypt+zeroize-devel-0.16.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bcrypt+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bcrypt+zeroize-devel}"
SRC_URI[x86_64_v2_rust-bcrypt+zeroize-devel.sha256sum] = "6d5309240344b9a618dbeb713f068bc1a2f36bd0f4c92f658ed82588353d2640"

URI_x86_64_v2_rust-bcrypt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bcrypt-devel-0.16.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bcrypt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bcrypt-devel}"
SRC_URI[x86_64_v2_rust-bcrypt-devel.sha256sum] = "4e226f090f3e8c0d7a01236454f901ced2b629c0ee4b4c26e6458ca85218b4bc"

URI_aarch64_rust-bcrypt+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bcrypt+alloc-devel-0.16.0-1.el10_0.noarch.rpm;name=aarch64_rust-bcrypt+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bcrypt+alloc-devel}"
SRC_URI[aarch64_rust-bcrypt+alloc-devel.sha256sum] = "0e3396bd348943cfde124ef59427bf4ece21c635a0ad669278c908a70635ba2e"

URI_aarch64_rust-bcrypt+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bcrypt+default-devel-0.16.0-1.el10_0.noarch.rpm;name=aarch64_rust-bcrypt+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bcrypt+default-devel}"
SRC_URI[aarch64_rust-bcrypt+default-devel.sha256sum] = "4d882d93e7d0d0e8e3a65c71d7125a242c354a1b7b8abac2374ea31146ba1314"

URI_aarch64_rust-bcrypt+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bcrypt+getrandom-devel-0.16.0-1.el10_0.noarch.rpm;name=aarch64_rust-bcrypt+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bcrypt+getrandom-devel}"
SRC_URI[aarch64_rust-bcrypt+getrandom-devel.sha256sum] = "13c916759257f37dd15053ad977020028c4d9c13ba67ce3c84ad1d56ab8160e8"

URI_aarch64_rust-bcrypt+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bcrypt+std-devel-0.16.0-1.el10_0.noarch.rpm;name=aarch64_rust-bcrypt+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bcrypt+std-devel}"
SRC_URI[aarch64_rust-bcrypt+std-devel.sha256sum] = "10f7e059e59989ac19e7416421220b5f019308353cbcbd5833704e0943f49107"

URI_aarch64_rust-bcrypt+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bcrypt+zeroize-devel-0.16.0-1.el10_0.noarch.rpm;name=aarch64_rust-bcrypt+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bcrypt+zeroize-devel}"
SRC_URI[aarch64_rust-bcrypt+zeroize-devel.sha256sum] = "9e4810e147482faf2ea104191ce0512ef74829f63e880245970da371524b1eab"

URI_aarch64_rust-bcrypt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bcrypt-devel-0.16.0-1.el10_0.noarch.rpm;name=aarch64_rust-bcrypt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bcrypt-devel}"
SRC_URI[aarch64_rust-bcrypt-devel.sha256sum] = "117e0e2d8bdb37d4f09ebaca3a288f67704a17a76dd18888b7dd81adc5285aa7"

RDEPENDS:rust-bcrypt+alloc-devel = " \
 cargo \
 rust-base64+alloc-devel \
 rust-bcrypt+getrandom-devel \
 rust-bcrypt-devel \
 "
RDEPENDS:rust-bcrypt+default-devel = " \
 cargo \
 rust-bcrypt+std-devel \
 rust-bcrypt+zeroize-devel \
 rust-bcrypt-devel \
 "
RDEPENDS:rust-bcrypt+getrandom-devel = " \
 cargo \
 rust-bcrypt-devel \
 rust-getrandom0.2-devel \
 "
RDEPENDS:rust-bcrypt+std-devel = " \
 cargo \
 rust-base64+std-devel \
 rust-bcrypt-devel \
 rust-getrandom0.2+std-devel \
 rust-getrandom0.2-devel \
 "
RDEPENDS:rust-bcrypt+zeroize-devel = " \
 cargo \
 rust-bcrypt-devel \
 rust-zeroize+default-devel \
 "
RDEPENDS:rust-bcrypt-devel = " \
 cargo \
 rust-base64-devel \
 rust-blowfish+bcrypt-devel \
 rust-blowfish+default-devel \
 rust-subtle-devel \
 "
