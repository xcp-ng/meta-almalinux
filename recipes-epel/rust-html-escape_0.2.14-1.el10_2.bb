# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-html-escape"
PV = "0.2.14"
PR = "1.el10_2"
PACKAGES = " \
 rust-html-escape+default-devel \
 rust-html-escape+std-devel \
 rust-html-escape-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-html-escape-0.2.14-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a17169c59c37368e8959c2ab94c67fa69912865c5f59febf5866529140d8be3"

URI_x86_64_v2_rust-html-escape+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html-escape+default-devel-0.2.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html-escape+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html-escape+default-devel}"
SRC_URI[x86_64_v2_rust-html-escape+default-devel.sha256sum] = "ca943869e0090a42b038985362e0e52943e8448bfda5f913528ec761373b39ad"

URI_x86_64_v2_rust-html-escape+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html-escape+std-devel-0.2.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html-escape+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html-escape+std-devel}"
SRC_URI[x86_64_v2_rust-html-escape+std-devel.sha256sum] = "e0e0ca787db6c9bc125cc6a9de4f04b4a3ecb092d9712d21314ce29ac261ef53"

URI_x86_64_v2_rust-html-escape-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html-escape-devel-0.2.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html-escape-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html-escape-devel}"
SRC_URI[x86_64_v2_rust-html-escape-devel.sha256sum] = "2e82a319d0e89853006d55bfe8ff175c19c3acd5dfad600f9b5900295df393b5"

URI_aarch64_rust-html-escape+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html-escape+default-devel-0.2.14-1.el10_2.noarch.rpm;name=aarch64_rust-html-escape+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html-escape+default-devel}"
SRC_URI[aarch64_rust-html-escape+default-devel.sha256sum] = "a64f75fb6c6627be368e10209ad85d78c90c1bf083fd1269ad4d335daf2b079f"

URI_aarch64_rust-html-escape+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html-escape+std-devel-0.2.14-1.el10_2.noarch.rpm;name=aarch64_rust-html-escape+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html-escape+std-devel}"
SRC_URI[aarch64_rust-html-escape+std-devel.sha256sum] = "25b92d4a43cb7440edd4ce9ca7e29e723e099eb684517a35cdacdf121ac0c62e"

URI_aarch64_rust-html-escape-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html-escape-devel-0.2.14-1.el10_2.noarch.rpm;name=aarch64_rust-html-escape-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html-escape-devel}"
SRC_URI[aarch64_rust-html-escape-devel.sha256sum] = "b2ee2d82d0acd4413317e4b4ebffb087f28b73007c0bfff05ad81561854eb347"

RDEPENDS:rust-html-escape+default-devel = " \
 cargo \
 rust-html-escape+std-devel \
 rust-html-escape-devel \
 "
RDEPENDS:rust-html-escape+std-devel = " \
 cargo \
 rust-html-escape-devel \
 "
RDEPENDS:rust-html-escape-devel = " \
 cargo \
 rust \
 "
