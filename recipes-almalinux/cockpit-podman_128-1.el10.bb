# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cockpit-podman"
PV = "128"
PR = "1.el10"
PACKAGES = " \
 cockpit-podman \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cockpit-podman-128-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "549a6e275da8d991687d602626a5432f2f35952bf992ffec8fb15c6a4b1aa7db"

URI_x86_64_v2_cockpit-podman = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cockpit-podman-128-1.el10.noarch.rpm;name=x86_64_v2_cockpit-podman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-podman}"
SRC_URI[x86_64_v2_cockpit-podman.sha256sum] = "8a7c0e8357a2bd2b13dd63a84234f0f6b86e47710a21a5434cc8b0ecbdea3d0c"

URI_aarch64_cockpit-podman = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cockpit-podman-128-1.el10.noarch.rpm;name=aarch64_cockpit-podman;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-podman}"
SRC_URI[aarch64_cockpit-podman.sha256sum] = "8a7c0e8357a2bd2b13dd63a84234f0f6b86e47710a21a5434cc8b0ecbdea3d0c"

RDEPENDS:cockpit-podman = " \
 cockpit-bridge \
 podman \
 "
