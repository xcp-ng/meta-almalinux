# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openpgm"
PV = "5.2.122"
PR = "36.el10_0"
PACKAGES = " \
 openpgm \
 openpgm-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/o/openpgm-5.2.122-36.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "173ea7306525c286596cdacd7a51f1c415c35bc99f4da43fef8c753885c10647"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openpgm-5.2.122-36.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openpgm;unpack=0"
SRC_URI[x86_64_v2_openpgm.sha256sum] = "666ab4c0e30eb09b6845f55f9650bfca217cd9cc2fd2c4914baeb0ff3aca01d7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openpgm-devel-5.2.122-36.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openpgm-devel;unpack=0"
SRC_URI[x86_64_v2_openpgm-devel.sha256sum] = "43df652032b1df56604abdb83c46c1f87c8bb724a6cc77b22558f7540289c7a3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/openpgm-5.2.122-36.el10_0.aarch64.rpm;name=aarch64_openpgm;unpack=0"
SRC_URI[aarch64_openpgm.sha256sum] = "69b512986c5346632f9c5fd481c3d73e1e0799d2c47817e1efb958806bef571e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/openpgm-devel-5.2.122-36.el10_0.aarch64.rpm;name=aarch64_openpgm-devel;unpack=0"
SRC_URI[aarch64_openpgm-devel.sha256sum] = "f6bece215f797c1672b7e004174a5c4f53b23319ff4359b515df7e55344819dc"

RDEPENDS:openpgm = " \
 glibc \
 "
RDEPENDS:openpgm-devel = " \
 openpgm \
 pkgconf-pkg-config \
 "
