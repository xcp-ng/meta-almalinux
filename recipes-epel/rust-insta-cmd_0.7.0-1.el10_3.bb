# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-insta-cmd"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-insta-cmd+default-devel \
 rust-insta-cmd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-insta-cmd-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e497c364a4f1b9cc2db7a9533eb01ec869695d3c8e9e57e77b70ffe5b2fb6cb2"

URI_x86_64_v2_rust-insta-cmd+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta-cmd+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta-cmd+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta-cmd+default-devel}"
SRC_URI[x86_64_v2_rust-insta-cmd+default-devel.sha256sum] = "8088db8185eacc570f15ba3d51f16cfb92aea559d81cdb6643cc0ef48f359bfe"

URI_x86_64_v2_rust-insta-cmd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta-cmd-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta-cmd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta-cmd-devel}"
SRC_URI[x86_64_v2_rust-insta-cmd-devel.sha256sum] = "eeb72babc1ebab791e8397d93814d9890270e4baf9a00ea7afd2350c3bb77455"

URI_aarch64_rust-insta-cmd+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta-cmd+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-insta-cmd+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta-cmd+default-devel}"
SRC_URI[aarch64_rust-insta-cmd+default-devel.sha256sum] = "47951821fe04157ff1a28ac780332efa1f375f09c9ed82239f2212f682b4ca19"

URI_aarch64_rust-insta-cmd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta-cmd-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-insta-cmd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta-cmd-devel}"
SRC_URI[aarch64_rust-insta-cmd-devel.sha256sum] = "706759718f159719876a381ba0c1556668336d0bca13c6dfd909f956f390ed17"

RDEPENDS:rust-insta-cmd+default-devel = " \
 cargo \
 rust-insta-cmd-devel \
 "
RDEPENDS:rust-insta-cmd-devel = " \
 cargo \
 rust \
 rust-insta+default-devel \
 rust-insta+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 "
