# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-click-option-group"
PV = "0.5.7"
PR = "6.el10_3"
PACKAGES = " \
 python3-click-option-group \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-click-option-group-0.5.7-6.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "171916564e89169d950e7635439b26b3de89f8a77a9eabd8f2ceba2c938a5695"

URI_x86_64_v2_python3-click-option-group = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-click-option-group-0.5.7-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-click-option-group;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-click-option-group}"
SRC_URI[x86_64_v2_python3-click-option-group.sha256sum] = "477ea5f1dba29e4f961b84c74de387e8cce5cbbe1e8edf9fd4e3e485dd90c886"

URI_aarch64_python3-click-option-group = "${EPEL_MIRROR}/aarch64/Packages/p/python3-click-option-group-0.5.7-6.el10_3.noarch.rpm;name=aarch64_python3-click-option-group;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-click-option-group}"
SRC_URI[aarch64_python3-click-option-group.sha256sum] = "cb00a9548c424484c789b6a5e947ac319c991c2c99a55662f9d6584803f58593"

RDEPENDS:python3-click-option-group = " \
 python3 \
 python3-click \
 "
