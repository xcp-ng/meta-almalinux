# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bitcoin-core-selinux"
PV = "0.2"
PR = "1.el10_3"
PACKAGES = " \
 bitcoin-core-selinux \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bitcoin-core-selinux-0.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "10015283b2dcf76fe642030e1bf658159f8f25ba8d72abcad678d9985ed65eb6"

URI_x86_64_v2_bitcoin-core-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bitcoin-core-selinux-0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_bitcoin-core-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bitcoin-core-selinux}"
SRC_URI[x86_64_v2_bitcoin-core-selinux.sha256sum] = "b78ffab5546ba778b5f58f67d8662e0877f3d78fa5bc1e94a0e4376f55ebd00d"

URI_aarch64_bitcoin-core-selinux = "${EPEL_MIRROR}/aarch64/Packages/b/bitcoin-core-selinux-0.2-1.el10_3.noarch.rpm;name=aarch64_bitcoin-core-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_bitcoin-core-selinux}"
SRC_URI[aarch64_bitcoin-core-selinux.sha256sum] = "e2faebd83e205e589d06b9fcc823092938b9f9470a61d37d2d267ab44870b987"

RDEPENDS:bitcoin-core-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
