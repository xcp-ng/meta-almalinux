# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_bytes"
PV = "0.11.16"
PR = "1.el10_0"
PACKAGES = " \
 rust-serde_bytes+alloc-devel \
 rust-serde_bytes+default-devel \
 rust-serde_bytes+std-devel \
 rust-serde_bytes-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-serde_bytes-0.11.16-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b89392a5cb2624f14b2ba12e7d056905911e700388957c0c2102f72b3641ada3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_bytes+alloc-devel-0.11.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_bytes+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde_bytes+alloc-devel.sha256sum] = "848fda4d5cf1788e6647fde6236a2f7653c72941c2ad478d0a3ddd5aa25fafaa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_bytes+default-devel-0.11.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_bytes+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde_bytes+default-devel.sha256sum] = "5cf731eb1774e47529ee902bf64a558cda0fcb60861804161c1cb87c8631a7cf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_bytes+std-devel-0.11.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_bytes+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde_bytes+std-devel.sha256sum] = "674e3bb0caffa56687048f301efdcd59250762a9b232afa535dcc93cbcb45407"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_bytes-devel-0.11.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_bytes-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde_bytes-devel.sha256sum] = "6e7d5b0736bce676e7edfe0b70eb319fa186565908dcb13d4c2b44b13bb66597"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_bytes+alloc-devel-0.11.16-1.el10_0.noarch.rpm;name=aarch64_rust-serde_bytes+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-serde_bytes+alloc-devel.sha256sum] = "1b936bd0e3c044c3a65f6d4f5484afe124d1d142945fd1c32f5d90719c871583"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_bytes+default-devel-0.11.16-1.el10_0.noarch.rpm;name=aarch64_rust-serde_bytes+default-devel;unpack=0"
SRC_URI[aarch64_rust-serde_bytes+default-devel.sha256sum] = "4c3a9f6c75f76ab21daf87445015d8c87b4778b3dbdf4b6677f7d9d7003f428a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_bytes+std-devel-0.11.16-1.el10_0.noarch.rpm;name=aarch64_rust-serde_bytes+std-devel;unpack=0"
SRC_URI[aarch64_rust-serde_bytes+std-devel.sha256sum] = "295669369703287dca06cc666c8759f12cbf023cfa863417b5a02a38bc5d3781"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_bytes-devel-0.11.16-1.el10_0.noarch.rpm;name=aarch64_rust-serde_bytes-devel;unpack=0"
SRC_URI[aarch64_rust-serde_bytes-devel.sha256sum] = "46d1486669a7c83c747f631231711e7ed36ae846b029dc87112f62610b396aab"

RDEPENDS:rust-serde_bytes+alloc-devel = " \
 cargo \
 rust-serde+alloc-devel \
 rust-serde_bytes-devel \
 "
RDEPENDS:rust-serde_bytes+default-devel = " \
 cargo \
 rust-serde_bytes+std-devel \
 rust-serde_bytes-devel \
 "
RDEPENDS:rust-serde_bytes+std-devel = " \
 cargo \
 rust-serde+std-devel \
 rust-serde_bytes-devel \
 "
RDEPENDS:rust-serde_bytes-devel = " \
 cargo \
 rust \
 rust-serde-devel \
 "
