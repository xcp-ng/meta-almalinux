# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "variant-lite"
PV = "2.0.0"
PR = "1.el10_0"
PACKAGES = " \
 variant-lite-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/variant-lite-2.0.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b3abbb5dc5ec2ac86406343f388e6ecc1582e596c2ad381acf5277ea078ea35"

URI_x86_64_v2_variant-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/variant-lite-devel-2.0.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_variant-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_variant-lite-devel}"
SRC_URI[x86_64_v2_variant-lite-devel.sha256sum] = "01245efee337465b9d971a0b909011b7fc958ed2dd16c70d578da71afee83add"

URI_aarch64_variant-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/v/variant-lite-devel-2.0.0-1.el10_0.aarch64.rpm;name=aarch64_variant-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_variant-lite-devel}"
SRC_URI[aarch64_variant-lite-devel.sha256sum] = "e105bb51a2bf254624a6f67d017bec3f27bbc1bbc6b366a63860256deb3a8d9d"

RDEPENDS:variant-lite-devel = " \
 cmake-filesystem \
 "
