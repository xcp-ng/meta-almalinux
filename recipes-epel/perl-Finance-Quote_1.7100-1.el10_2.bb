# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Finance-Quote"
PV = "1.7100"
PR = "1.el10_2"
PACKAGES = " \
 perl-Finance-Quote \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Finance-Quote-1.7100-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e4e7ed7ea877ae0a3410601113bc3fd3eeb9eda4e6ffa9170d9996e3a59abd8b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Finance-Quote-1.7100-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Finance-Quote;unpack=0"
SRC_URI[x86_64_v2_perl-Finance-Quote.sha256sum] = "0c5737174e1f74ac544d75f389e626cd4e0fec66471fc16abb4eef43b6b10c03"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Finance-Quote-1.7100-1.el10_2.noarch.rpm;name=aarch64_perl-Finance-Quote;unpack=0"
SRC_URI[aarch64_perl-Finance-Quote.sha256sum] = "58c3b7a126f35c564d218d147c667530511ec9d65f16648bf571c7829ed4cd06"

RDEPENDS:perl-Finance-Quote = " \
 perl-Carp \
 perl-DateTime-Format-Strptime \
 perl-Encode \
 perl-Exporter \
 perl-Finance-Quote \
 perl-HTML-Parser \
 perl-HTML-TableExtract \
 perl-HTML-Tree \
 perl-HTML-TreeBuilder-XPath \
 perl-HTTP-CookieJar \
 perl-HTTP-Cookies \
 perl-HTTP-Message \
 perl-IO-Compress \
 perl-IO-String \
 perl-JSON \
 perl-LWP-Protocol-https \
 perl-Module-Load \
 perl-POSIX \
 perl-Readonly \
 perl-Scalar-List-Utils \
 perl-String-Util \
 perl-Text-Template \
 perl-Time-Piece \
 perl-TimeDate \
 perl-URI \
 perl-Web-Scraper \
 perl-XML-LibXML \
 perl-base \
 perl-constant \
 perl-if \
 perl-libs \
 perl-libwww-perl \
 perl-vars \
 "
