# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-munge"
PV = "0.4.7"
PR = "1.el10_2"
PACKAGES = " \
 rust-munge+default-devel \
 rust-munge-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-munge-0.4.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a429aa545c25ebfe1e2cf80ef1ee1a1fe234ba9a8638070b9d08ecc398a1dde"

URI_x86_64_v2_rust-munge+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-munge+default-devel-0.4.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-munge+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-munge+default-devel}"
SRC_URI[x86_64_v2_rust-munge+default-devel.sha256sum] = "8a8f53d1ed4bb0cb19b5ea2a4b01f39233403277e044b7bb7018073f8d990f35"

URI_x86_64_v2_rust-munge-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-munge-devel-0.4.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-munge-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-munge-devel}"
SRC_URI[x86_64_v2_rust-munge-devel.sha256sum] = "268a2d98924971de3a6996a0b528378670c4491ce26342ef27fbd6ccbca45aa9"

URI_aarch64_rust-munge+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-munge+default-devel-0.4.7-1.el10_2.noarch.rpm;name=aarch64_rust-munge+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-munge+default-devel}"
SRC_URI[aarch64_rust-munge+default-devel.sha256sum] = "6bd3739231295ef322f70bf0eff798062797867e680371154e66ddceb08e5331"

URI_aarch64_rust-munge-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-munge-devel-0.4.7-1.el10_2.noarch.rpm;name=aarch64_rust-munge-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-munge-devel}"
SRC_URI[aarch64_rust-munge-devel.sha256sum] = "eba96a51cdedaf631c0c0b9746d8fcba186e7a45819b1743ab41d4712e45b855"

RDEPENDS:rust-munge+default-devel = " \
 cargo \
 rust-munge-devel \
 "
RDEPENDS:rust-munge-devel = " \
 cargo \
 rust \
 rust-munge_macro-devel \
 "
