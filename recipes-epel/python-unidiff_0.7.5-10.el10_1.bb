# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-unidiff"
PV = "0.7.5"
PR = "10.el10_1"
PACKAGES = " \
 python3-unidiff \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-unidiff-0.7.5-10.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e5614400cb2a339b24062f954570781d23fd21113d8f0a9aff8754f8eeff39e"

URI_x86_64_v2_python3-unidiff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-unidiff-0.7.5-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-unidiff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-unidiff}"
SRC_URI[x86_64_v2_python3-unidiff.sha256sum] = "b9b0f0d196f763f513e1ba412cd5bcc49f7298598c20d72c5801495403419b4f"

URI_aarch64_python3-unidiff = "${EPEL_MIRROR}/aarch64/Packages/p/python3-unidiff-0.7.5-10.el10_1.noarch.rpm;name=aarch64_python3-unidiff;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-unidiff}"
SRC_URI[aarch64_python3-unidiff.sha256sum] = "eeab6492282bba03120a6028c6b24fd8f074321c98b4bdf810dd32ee725f6aee"

RDEPENDS:python3-unidiff = " \
 python3 \
 "
