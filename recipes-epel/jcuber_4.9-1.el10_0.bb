# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jcuber"
PV = "4.9"
PR = "1.el10_0"
PACKAGES = " \
 jcuber \
 jcuber-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/jcuber-4.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "781a14edcd8e69254ae574425c64655bf31b81ee3f2106cacea8350f848a3a0e"

URI_x86_64_v2_jcuber = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jcuber-4.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_jcuber;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jcuber}"
SRC_URI[x86_64_v2_jcuber.sha256sum] = "bd19faf25a548ce09ef94603a3e8faed6559f7ce92689ecd1735fcf9bce908b4"

URI_x86_64_v2_jcuber-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jcuber-doc-4.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_jcuber-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jcuber-doc}"
SRC_URI[x86_64_v2_jcuber-doc.sha256sum] = "3df092758643b2cfb4ab8b61ed32537233568aed3e40680ea8f058400f8face9"

URI_aarch64_jcuber = "${EPEL_MIRROR}/aarch64/Packages/j/jcuber-4.9-1.el10_0.noarch.rpm;name=aarch64_jcuber;unpack=0"
SRC_URI:append = " ${URI_aarch64_jcuber}"
SRC_URI[aarch64_jcuber.sha256sum] = "3141e38adc8d7ad3978ac463e7a9c5e112c39de5032aba0bc09d06370b12da2b"

URI_aarch64_jcuber-doc = "${EPEL_MIRROR}/aarch64/Packages/j/jcuber-doc-4.9-1.el10_0.noarch.rpm;name=aarch64_jcuber-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_jcuber-doc}"
SRC_URI[aarch64_jcuber-doc.sha256sum] = "035e968200a68e52d502cea26549754559fd1af04f843df2d2d79c8c2ceaef94"

RDEPENDS:jcuber = " \
 bash \
 java-21-openjdk \
 javapackages-tools \
 "
RDEPENDS:jcuber-doc = " \
 "
