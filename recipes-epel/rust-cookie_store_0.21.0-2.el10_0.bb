# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cookie_store"
PV = "0.21.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-cookie_store+default-devel \
 rust-cookie_store+indexmap-devel \
 rust-cookie_store+log_secure_cookie_values-devel \
 rust-cookie_store+preserve_order-devel \
 rust-cookie_store+public_suffix-devel \
 rust-cookie_store+publicsuffix-devel \
 rust-cookie_store-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cookie_store-0.21.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a55005900742cb5187296bf840a2c3d799f52aa1bb58616919bae29b7fca3712"

URI_x86_64_v2_rust-cookie_store+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie_store+default-devel-0.21.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie_store+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie_store+default-devel}"
SRC_URI[x86_64_v2_rust-cookie_store+default-devel.sha256sum] = "c9804181d7a7161fd83d1f56fcfd1135a0a0dedd720003709ee7a548577af6f7"

URI_x86_64_v2_rust-cookie_store+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie_store+indexmap-devel-0.21.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie_store+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie_store+indexmap-devel}"
SRC_URI[x86_64_v2_rust-cookie_store+indexmap-devel.sha256sum] = "ad45d4a3b09f13c0b775530a37aac0eb2364c261a5022a6932e44915ad26dc77"

URI_x86_64_v2_rust-cookie_store+log_secure_cookie_values-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie_store+log_secure_cookie_values-devel-0.21.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie_store+log_secure_cookie_values-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie_store+log_secure_cookie_values-devel}"
SRC_URI[x86_64_v2_rust-cookie_store+log_secure_cookie_values-devel.sha256sum] = "1bd3a82f3e5fb49e1bb739733616f92ba6749487ff76f7753ab276a281385569"

URI_x86_64_v2_rust-cookie_store+preserve_order-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie_store+preserve_order-devel-0.21.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie_store+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie_store+preserve_order-devel}"
SRC_URI[x86_64_v2_rust-cookie_store+preserve_order-devel.sha256sum] = "c82d9fdae71e6d06e53445d227b5e0a5bcad9434aeccad464360b86d92ec5818"

URI_x86_64_v2_rust-cookie_store+public_suffix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie_store+public_suffix-devel-0.21.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie_store+public_suffix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie_store+public_suffix-devel}"
SRC_URI[x86_64_v2_rust-cookie_store+public_suffix-devel.sha256sum] = "2e7911b19b8bc14345b5ef003bd30cfcc9562536de10b11be6526144ed450fb5"

URI_x86_64_v2_rust-cookie_store+publicsuffix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie_store+publicsuffix-devel-0.21.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie_store+publicsuffix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie_store+publicsuffix-devel}"
SRC_URI[x86_64_v2_rust-cookie_store+publicsuffix-devel.sha256sum] = "49ce64698463e9116557eb02ff45300f3382f9ca09b4790ab011f23a4949273d"

URI_x86_64_v2_rust-cookie_store-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie_store-devel-0.21.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie_store-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie_store-devel}"
SRC_URI[x86_64_v2_rust-cookie_store-devel.sha256sum] = "5f40ae0fb8b3063a9014b90ddb79214c8dc2080fc16ae8aad0457b3d1f208286"

URI_aarch64_rust-cookie_store+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie_store+default-devel-0.21.0-2.el10_0.noarch.rpm;name=aarch64_rust-cookie_store+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie_store+default-devel}"
SRC_URI[aarch64_rust-cookie_store+default-devel.sha256sum] = "eae125069dce17653fbc9ae3910ff4e83900b8694d268af3a46ba9276979a93c"

URI_aarch64_rust-cookie_store+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie_store+indexmap-devel-0.21.0-2.el10_0.noarch.rpm;name=aarch64_rust-cookie_store+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie_store+indexmap-devel}"
SRC_URI[aarch64_rust-cookie_store+indexmap-devel.sha256sum] = "62013be360e3d74f640e9984b4795c3adf506ea941a7db1741846d30ca317764"

URI_aarch64_rust-cookie_store+log_secure_cookie_values-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie_store+log_secure_cookie_values-devel-0.21.0-2.el10_0.noarch.rpm;name=aarch64_rust-cookie_store+log_secure_cookie_values-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie_store+log_secure_cookie_values-devel}"
SRC_URI[aarch64_rust-cookie_store+log_secure_cookie_values-devel.sha256sum] = "8a822c53dff94ef008a3f092407747c29a7f82bee12ebd6a444fdb2a1c16609c"

URI_aarch64_rust-cookie_store+preserve_order-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie_store+preserve_order-devel-0.21.0-2.el10_0.noarch.rpm;name=aarch64_rust-cookie_store+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie_store+preserve_order-devel}"
SRC_URI[aarch64_rust-cookie_store+preserve_order-devel.sha256sum] = "9fdde3fb747991ae213e78658f5931a577c491b601f48de003e347bec9df7ecf"

URI_aarch64_rust-cookie_store+public_suffix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie_store+public_suffix-devel-0.21.0-2.el10_0.noarch.rpm;name=aarch64_rust-cookie_store+public_suffix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie_store+public_suffix-devel}"
SRC_URI[aarch64_rust-cookie_store+public_suffix-devel.sha256sum] = "324e3eee3fc3bdcf5df49f518e0da755d0f721b83f687f98ffa14fc01f49ab44"

URI_aarch64_rust-cookie_store+publicsuffix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie_store+publicsuffix-devel-0.21.0-2.el10_0.noarch.rpm;name=aarch64_rust-cookie_store+publicsuffix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie_store+publicsuffix-devel}"
SRC_URI[aarch64_rust-cookie_store+publicsuffix-devel.sha256sum] = "15880e9024bab34ca98c65bfd987e8637966e9831f497c2cbc4a1c7253b031ae"

URI_aarch64_rust-cookie_store-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie_store-devel-0.21.0-2.el10_0.noarch.rpm;name=aarch64_rust-cookie_store-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie_store-devel}"
SRC_URI[aarch64_rust-cookie_store-devel.sha256sum] = "dd86613ba135683e631771d87824051afc371c507ab6cf4cf352456fe70585aa"

RDEPENDS:rust-cookie_store+default-devel = " \
 cargo \
 rust-cookie_store+public_suffix-devel \
 rust-cookie_store-devel \
 "
RDEPENDS:rust-cookie_store+indexmap-devel = " \
 cargo \
 rust-cookie_store-devel \
 rust-indexmap+default-devel \
 "
RDEPENDS:rust-cookie_store+log_secure_cookie_values-devel = " \
 cargo \
 rust-cookie_store-devel \
 "
RDEPENDS:rust-cookie_store+preserve_order-devel = " \
 cargo \
 rust-cookie_store+indexmap-devel \
 rust-cookie_store-devel \
 "
RDEPENDS:rust-cookie_store+public_suffix-devel = " \
 cargo \
 rust-cookie_store+publicsuffix-devel \
 rust-cookie_store-devel \
 "
RDEPENDS:rust-cookie_store+publicsuffix-devel = " \
 cargo \
 rust-cookie_store-devel \
 rust-publicsuffix+default-devel \
 "
RDEPENDS:rust-cookie_store-devel = " \
 bash \
 cargo \
 rust-cookie+default-devel \
 rust-cookie+percent-encode-devel \
 rust-idna+default-devel \
 rust-log+default-devel \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 rust-serde_json+default-devel \
 rust-time+default-devel \
 rust-url+default-devel \
 "
