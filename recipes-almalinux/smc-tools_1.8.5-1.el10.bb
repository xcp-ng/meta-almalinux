# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "smc-tools"
PV = "1.8.5"
PR = "1.el10"
PACKAGES = " \
 smc-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/smc-tools-1.8.5-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "689cbfe71e50a81930b2f87d2e19b91fcb0a985ce127563a827f7539447f33e9"

URI_x86_64_v2_smc-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/smc-tools-1.8.5-1.el10.x86_64_v2.rpm;name=x86_64_v2_smc-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_smc-tools}"
SRC_URI[x86_64_v2_smc-tools.sha256sum] = "7c60ed7717d7e4c707b8fd80d915610401d77f37cd650bb392661df4406a4cf5"

URI_aarch64_smc-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/smc-tools-1.8.5-1.el10.aarch64.rpm;name=aarch64_smc-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_smc-tools}"
SRC_URI[aarch64_smc-tools.sha256sum] = "09c1fcfd3661799324a394b064985efa4af878ce3cc96b1d463bd554ec598740"

RDEPENDS:smc-tools = " \
 bash \
 glibc \
 libnl3 \
 "
