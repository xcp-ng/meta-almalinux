# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansible-freeipa"
PV = "1.15.1"
PR = "1.el10"
PACKAGES = " \
 ansible-freeipa \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ansible-freeipa-1.15.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d2bbec9b53cdfb33ea01d687b702a7b58b334c431ff084c7f43d7e81dec8d77c"

URI_x86_64_v2_ansible-freeipa = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ansible-freeipa-1.15.1-1.el10.noarch.rpm;name=x86_64_v2_ansible-freeipa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-freeipa}"
SRC_URI[x86_64_v2_ansible-freeipa.sha256sum] = "c2d477601ccd7f84e27984301cee1356ec76244c5bf76b39fbac91c7fa00ae22"

URI_aarch64_ansible-freeipa = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ansible-freeipa-1.15.1-1.el10.noarch.rpm;name=aarch64_ansible-freeipa;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-freeipa}"
SRC_URI[aarch64_ansible-freeipa.sha256sum] = "c2d477601ccd7f84e27984301cee1356ec76244c5bf76b39fbac91c7fa00ae22"

RDEPENDS:ansible-freeipa = " \
 ansible-core \
 bash \
 python3 \
 "
