# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-base-orphans"
PV = "0.9.2"
PR = "1.el10_0"
PACKAGES = " \
 ghc-base-orphans \
 ghc-base-orphans-devel \
 ghc-base-orphans-doc \
 ghc-base-orphans-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-base-orphans-0.9.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "db1e99a2d0fa1093c7c0a24d042292948e5d3fe0148176aaa3a28833cfdd1523"

URI_x86_64_v2_ghc-base-orphans = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-base-orphans-0.9.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-base-orphans;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-base-orphans}"
SRC_URI[x86_64_v2_ghc-base-orphans.sha256sum] = "a27bb13903bf56c7f082a03dfdefb4dc32bcea69711d9502ead7f6fd881fe42a"

URI_x86_64_v2_ghc-base-orphans-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-base-orphans-devel-0.9.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-base-orphans-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-base-orphans-devel}"
SRC_URI[x86_64_v2_ghc-base-orphans-devel.sha256sum] = "faddfd5bf962841768904958e174cded7955a8e17a6f16e46e91f6bb90f5b546"

URI_x86_64_v2_ghc-base-orphans-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-base-orphans-doc-0.9.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-base-orphans-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-base-orphans-doc}"
SRC_URI[x86_64_v2_ghc-base-orphans-doc.sha256sum] = "5ddf04167431f5ff94ed48c24a21c5dccc8d7a808b45bb2feaed4619a970ff5f"

URI_x86_64_v2_ghc-base-orphans-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-base-orphans-prof-0.9.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-base-orphans-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-base-orphans-prof}"
SRC_URI[x86_64_v2_ghc-base-orphans-prof.sha256sum] = "fc221c2c633b6267993f74e02fff5d906cba9a8ba791e91ea5962ef4860ee111"

URI_aarch64_ghc-base-orphans = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-base-orphans-0.9.2-1.el10_0.aarch64.rpm;name=aarch64_ghc-base-orphans;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-base-orphans}"
SRC_URI[aarch64_ghc-base-orphans.sha256sum] = "60f8c4832dca6c8b8232b1d41de994ef429a44cc5d9d9a564359f4d63f2110f5"

URI_aarch64_ghc-base-orphans-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-base-orphans-devel-0.9.2-1.el10_0.aarch64.rpm;name=aarch64_ghc-base-orphans-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-base-orphans-devel}"
SRC_URI[aarch64_ghc-base-orphans-devel.sha256sum] = "351278841f235f225e15539a7c772bdfac109d952eb9cce1a5d3acc0d650a76f"

URI_aarch64_ghc-base-orphans-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-base-orphans-doc-0.9.2-1.el10_0.noarch.rpm;name=aarch64_ghc-base-orphans-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-base-orphans-doc}"
SRC_URI[aarch64_ghc-base-orphans-doc.sha256sum] = "8a20b74f0dd4104a4153b9cd429a8ff75b44db5bae0b5021352f6fa429bdfb40"

URI_aarch64_ghc-base-orphans-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-base-orphans-prof-0.9.2-1.el10_0.aarch64.rpm;name=aarch64_ghc-base-orphans-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-base-orphans-prof}"
SRC_URI[aarch64_ghc-base-orphans-prof.sha256sum] = "6a729a8cbba2abc63162930efce119bf8491b3eb01a0572c658994d9e45f6cd2"

RDEPENDS:ghc-base-orphans = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-base-orphans-devel = " \
 ghc-base-devel \
 ghc-base-orphans \
 ghc-compiler \
 "
RDEPENDS:ghc-base-orphans-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-base-orphans-prof = " \
 ghc-base-orphans-devel \
 ghc-base-prof \
 "
