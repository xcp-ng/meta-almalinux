# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-below-btrfs"
PV = "0.9.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-below-btrfs+default-devel \
 rust-below-btrfs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-below-btrfs-0.9.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e36a686d5c925932472d9ea9139fa78f65026e6430eff70863219188678e0a4"

URI_x86_64_v2_rust-below-btrfs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-btrfs+default-devel-0.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-btrfs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-btrfs+default-devel}"
SRC_URI[x86_64_v2_rust-below-btrfs+default-devel.sha256sum] = "94b947e9f1f98a0daef0f07385919b2636622e19ff8b98e521538944d81cb7eb"

URI_x86_64_v2_rust-below-btrfs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-btrfs-devel-0.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-btrfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-btrfs-devel}"
SRC_URI[x86_64_v2_rust-below-btrfs-devel.sha256sum] = "f8d12d538108b4e3993af903767c8c886cae4f48b38679e4be31dcf88354f238"

URI_aarch64_rust-below-btrfs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-btrfs+default-devel-0.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-below-btrfs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-btrfs+default-devel}"
SRC_URI[aarch64_rust-below-btrfs+default-devel.sha256sum] = "66843169775315e5bf507c9f02c68f86132d3548d3b8e8203ad2b4609023aa8a"

URI_aarch64_rust-below-btrfs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-btrfs-devel-0.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-below-btrfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-btrfs-devel}"
SRC_URI[aarch64_rust-below-btrfs-devel.sha256sum] = "e14f692c3553bcead31e782cb6f5601d79d062d9ebe27f5b161bd69ed6be4eac"

RDEPENDS:rust-below-btrfs+default-devel = " \
 cargo \
 rust-below-btrfs-devel \
 "
RDEPENDS:rust-below-btrfs-devel = " \
 cargo \
 rust-below-common+default-devel \
 rust-libc+default-devel \
 rust-nix0.29+default-devel \
 rust-nix0.29+dir-devel \
 rust-nix0.29+event-devel \
 rust-nix0.29+hostname-devel \
 rust-nix0.29+inotify-devel \
 rust-nix0.29+ioctl-devel \
 rust-nix0.29+mman-devel \
 rust-nix0.29+mount-devel \
 rust-nix0.29+net-devel \
 rust-nix0.29+poll-devel \
 rust-nix0.29+ptrace-devel \
 rust-nix0.29+reboot-devel \
 rust-nix0.29+resource-devel \
 rust-nix0.29+sched-devel \
 rust-nix0.29+signal-devel \
 rust-nix0.29+term-devel \
 rust-nix0.29+time-devel \
 rust-nix0.29+user-devel \
 rust-nix0.29+zerocopy-devel \
 rust-openat+default-devel \
 rust-rand0.8+default-devel \
 rust-rand0.8+small_rng-devel \
 rust-rand_distr0.4+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-slog+default-devel \
 rust-slog+max_level_trace-devel \
 rust-slog+nested-values-devel \
 rust-thiserror+default-devel \
 "
