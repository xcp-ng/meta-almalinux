# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mod_auth_openidc"
PV = "2.4.15"
PR = "4.el10"
PACKAGES = " \
 mod_auth_openidc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mod_auth_openidc-2.4.15-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc8c3d935f1a5f9f978fcabd74aa816760198f0361198d1befc456d4919e1a25"

URI_x86_64_v2_mod_auth_openidc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_auth_openidc-2.4.15-4.el10.x86_64_v2.rpm;name=x86_64_v2_mod_auth_openidc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_auth_openidc}"
SRC_URI[x86_64_v2_mod_auth_openidc.sha256sum] = "d9f628e1be799ac952d40e9ad498f18285e02cbe315af6b5c93f78a540157a90"

URI_aarch64_mod_auth_openidc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_auth_openidc-2.4.15-4.el10.aarch64.rpm;name=aarch64_mod_auth_openidc;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_auth_openidc}"
SRC_URI[aarch64_mod_auth_openidc.sha256sum] = "98fd02aa7b8929fd6e3a44ee3902471392da502de69c83478096cc3e8690c5d3"

RDEPENDS:mod_auth_openidc = " \
 apr \
 apr-util \
 cjose \
 expat \
 glibc \
 httpd-core \
 jansson \
 jq \
 libxcrypt \
 openldap \
 openssl-libs \
 pcre2 \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
