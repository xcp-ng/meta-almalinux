# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sparsehash"
PV = "2.0.4"
PR = "1.el10_1"
PACKAGES = " \
 sparsehash-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sparsehash-2.0.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a23400dc173bf9ce7b42b76c6f6133ffd64bbe8e9a1965f3bcf4944d7144077e"

URI_x86_64_v2_sparsehash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sparsehash-devel-2.0.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sparsehash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sparsehash-devel}"
SRC_URI[x86_64_v2_sparsehash-devel.sha256sum] = "e0030857601dfcc267838be2f378f4c634636ea299cf72b975dfd4d81994ee75"

URI_aarch64_sparsehash-devel = "${EPEL_MIRROR}/aarch64/Packages/s/sparsehash-devel-2.0.4-1.el10_1.aarch64.rpm;name=aarch64_sparsehash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sparsehash-devel}"
SRC_URI[aarch64_sparsehash-devel.sha256sum] = "1ddac7da7e338961432cba1377eb1f6b806f9041e56d53b66c16bc807abfeefa"

RDEPENDS:sparsehash-devel = " \
 pkgconf-pkg-config \
 "
