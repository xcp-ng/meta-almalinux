# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tomcat9"
PE = "1"
PV = "9.0.87"
PR = "8.el10_1.1"
PACKAGES = " \
 tomcat9 \
 tomcat9-admin-webapps \
 tomcat9-docs-webapp \
 tomcat9-el-3.0-api \
 tomcat9-jsp-2.3-api \
 tomcat9-lib \
 tomcat9-servlet-4.0-api \
 tomcat9-webapps \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tomcat9-9.0.87-8.el10_1.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a4d387a865abd09259eb80d07d989598befb128ef198f8cb3a0013dddfa7ce8"

URI_x86_64_v2_tomcat9 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-9.0.87-8.el10_1.1.noarch.rpm;name=x86_64_v2_tomcat9;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat9}"
SRC_URI[x86_64_v2_tomcat9.sha256sum] = "bbc04103b9f730b9ed20d3c6b9089fb5c015604ea2815e2e78a339d2e9b17104"

URI_x86_64_v2_tomcat9-admin-webapps = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-admin-webapps-9.0.87-8.el10_1.1.noarch.rpm;name=x86_64_v2_tomcat9-admin-webapps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat9-admin-webapps}"
SRC_URI[x86_64_v2_tomcat9-admin-webapps.sha256sum] = "d12b701fa61c7e1d606284dcc6feb6ec7b957679be81aa5ba3a8fceb2e320fe0"

URI_x86_64_v2_tomcat9-docs-webapp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-docs-webapp-9.0.87-8.el10_1.1.noarch.rpm;name=x86_64_v2_tomcat9-docs-webapp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat9-docs-webapp}"
SRC_URI[x86_64_v2_tomcat9-docs-webapp.sha256sum] = "f626d6d4f19cb1b6ba26ac4fa47d563ace20bd4439b1d5b4d4f55d7d6d7ccd4c"

URI_x86_64_v2_tomcat9-el-3.0-api = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-el-3.0-api-9.0.87-8.el10_1.1.noarch.rpm;name=x86_64_v2_tomcat9-el-3.0-api;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat9-el-3.0-api}"
SRC_URI[x86_64_v2_tomcat9-el-3.0-api.sha256sum] = "1835f0bc3ca9b3201e899a9e8d7801418412d8651d0b502ce2d0f19e62c6b063"

URI_x86_64_v2_tomcat9-jsp-2.3-api = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-jsp-2.3-api-9.0.87-8.el10_1.1.noarch.rpm;name=x86_64_v2_tomcat9-jsp-2.3-api;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat9-jsp-2.3-api}"
SRC_URI[x86_64_v2_tomcat9-jsp-2.3-api.sha256sum] = "06b9ffb04a18b2c62901d425e1a577f385bdbb5f3dca4fb05a64c0a05b8917cb"

URI_x86_64_v2_tomcat9-lib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-lib-9.0.87-8.el10_1.1.noarch.rpm;name=x86_64_v2_tomcat9-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat9-lib}"
SRC_URI[x86_64_v2_tomcat9-lib.sha256sum] = "5fbb9c0ce4fb1f0f3c001cd13ba638bde0f0f6cbaaf11fe7c9e4a88c4b669bc6"
RPROVIDES:tomcat9-lib:x86_64_v2 = "virtual/mvn_org.apache.tomcat_tomcat-catalina_ virtual/mvn_org.apache.tomcat_tomcat-catalina__ge_9.0.62 virtual/mvn_org.apache.tomcat_tomcat-coyote_ virtual/mvn_org.apache.tomcat_tomcat-coyote__ge_9.0.62 virtual/mvn_org.apache.tomcat_tomcat-juli_ virtual/mvn_org.apache.tomcat_tomcat-juli__ge_9.0.62"

URI_x86_64_v2_tomcat9-servlet-4.0-api = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-servlet-4.0-api-9.0.87-8.el10_1.1.noarch.rpm;name=x86_64_v2_tomcat9-servlet-4.0-api;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat9-servlet-4.0-api}"
SRC_URI[x86_64_v2_tomcat9-servlet-4.0-api.sha256sum] = "44e7a8721279cb2fff33fdf94aae06088663ef8b818471da1389b9216a066586"

URI_x86_64_v2_tomcat9-webapps = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-webapps-9.0.87-8.el10_1.1.noarch.rpm;name=x86_64_v2_tomcat9-webapps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat9-webapps}"
SRC_URI[x86_64_v2_tomcat9-webapps.sha256sum] = "d267a9c403d045721056b9f62d6d5a58e8d3aa3e524d568d19eb12345e211daf"

URI_aarch64_tomcat9 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-9.0.87-8.el10_1.1.noarch.rpm;name=aarch64_tomcat9;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat9}"
SRC_URI[aarch64_tomcat9.sha256sum] = "bbc04103b9f730b9ed20d3c6b9089fb5c015604ea2815e2e78a339d2e9b17104"

URI_aarch64_tomcat9-admin-webapps = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-admin-webapps-9.0.87-8.el10_1.1.noarch.rpm;name=aarch64_tomcat9-admin-webapps;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat9-admin-webapps}"
SRC_URI[aarch64_tomcat9-admin-webapps.sha256sum] = "d12b701fa61c7e1d606284dcc6feb6ec7b957679be81aa5ba3a8fceb2e320fe0"

URI_aarch64_tomcat9-docs-webapp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-docs-webapp-9.0.87-8.el10_1.1.noarch.rpm;name=aarch64_tomcat9-docs-webapp;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat9-docs-webapp}"
SRC_URI[aarch64_tomcat9-docs-webapp.sha256sum] = "f626d6d4f19cb1b6ba26ac4fa47d563ace20bd4439b1d5b4d4f55d7d6d7ccd4c"

URI_aarch64_tomcat9-el-3.0-api = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-el-3.0-api-9.0.87-8.el10_1.1.noarch.rpm;name=aarch64_tomcat9-el-3.0-api;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat9-el-3.0-api}"
SRC_URI[aarch64_tomcat9-el-3.0-api.sha256sum] = "1835f0bc3ca9b3201e899a9e8d7801418412d8651d0b502ce2d0f19e62c6b063"

URI_aarch64_tomcat9-jsp-2.3-api = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-jsp-2.3-api-9.0.87-8.el10_1.1.noarch.rpm;name=aarch64_tomcat9-jsp-2.3-api;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat9-jsp-2.3-api}"
SRC_URI[aarch64_tomcat9-jsp-2.3-api.sha256sum] = "06b9ffb04a18b2c62901d425e1a577f385bdbb5f3dca4fb05a64c0a05b8917cb"

URI_aarch64_tomcat9-lib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-lib-9.0.87-8.el10_1.1.noarch.rpm;name=aarch64_tomcat9-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat9-lib}"
SRC_URI[aarch64_tomcat9-lib.sha256sum] = "5fbb9c0ce4fb1f0f3c001cd13ba638bde0f0f6cbaaf11fe7c9e4a88c4b669bc6"
RPROVIDES:tomcat9-lib:aarch64 = "virtual/mvn_org.apache.tomcat_tomcat-catalina_ virtual/mvn_org.apache.tomcat_tomcat-catalina__ge_9.0.62 virtual/mvn_org.apache.tomcat_tomcat-coyote_ virtual/mvn_org.apache.tomcat_tomcat-coyote__ge_9.0.62 virtual/mvn_org.apache.tomcat_tomcat-juli_ virtual/mvn_org.apache.tomcat_tomcat-juli__ge_9.0.62"

URI_aarch64_tomcat9-servlet-4.0-api = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-servlet-4.0-api-9.0.87-8.el10_1.1.noarch.rpm;name=aarch64_tomcat9-servlet-4.0-api;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat9-servlet-4.0-api}"
SRC_URI[aarch64_tomcat9-servlet-4.0-api.sha256sum] = "44e7a8721279cb2fff33fdf94aae06088663ef8b818471da1389b9216a066586"

URI_aarch64_tomcat9-webapps = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-webapps-9.0.87-8.el10_1.1.noarch.rpm;name=aarch64_tomcat9-webapps;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat9-webapps}"
SRC_URI[aarch64_tomcat9-webapps.sha256sum] = "d267a9c403d045721056b9f62d6d5a58e8d3aa3e524d568d19eb12345e211daf"

RDEPENDS:tomcat9 = " \
 bash \
 java-21-openjdk-headless \
 javapackages-tools \
 shadow-utils \
 systemd \
 tomcat9-lib \
 "
RDEPENDS:tomcat9-admin-webapps = " \
 tomcat9 \
 "
RDEPENDS:tomcat9-docs-webapp = " \
 tomcat9 \
 "
RDEPENDS:tomcat9-el-3.0-api = " \
 bash \
 javapackages-filesystem \
 "
RDEPENDS:tomcat9-jsp-2.3-api = " \
 bash \
 javapackages-filesystem \
 tomcat9-el-3.0-api \
 tomcat9-servlet-4.0-api \
 "
RDEPENDS:tomcat9-lib = " \
 ecj \
 javapackages-filesystem \
 tomcat9-el-3.0-api \
 tomcat9-jsp-2.3-api \
 tomcat9-servlet-4.0-api \
 virtual/coreutils \
 "
RDEPENDS:tomcat9-servlet-4.0-api = " \
 bash \
 javapackages-filesystem \
 "
RDEPENDS:tomcat9-webapps = " \
 tomcat9 \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/mvn_org.apache.tomcat_tomcat-catalina_ rpm/virtual/mvn_org.apache.tomcat_tomcat-catalina__ge_9.0.62 rpm/virtual/mvn_org.apache.tomcat_tomcat-coyote_ rpm/virtual/mvn_org.apache.tomcat_tomcat-coyote__ge_9.0.62 rpm/virtual/mvn_org.apache.tomcat_tomcat-juli_ rpm/virtual/mvn_org.apache.tomcat_tomcat-juli__ge_9.0.62"

PROVIDES:append:aarch64 = " rpm/virtual/mvn_org.apache.tomcat_tomcat-catalina_ rpm/virtual/mvn_org.apache.tomcat_tomcat-catalina__ge_9.0.62 rpm/virtual/mvn_org.apache.tomcat_tomcat-coyote_ rpm/virtual/mvn_org.apache.tomcat_tomcat-coyote__ge_9.0.62 rpm/virtual/mvn_org.apache.tomcat_tomcat-juli_ rpm/virtual/mvn_org.apache.tomcat_tomcat-juli__ge_9.0.62"
