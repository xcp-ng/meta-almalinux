# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-macros"
PV = "0.25.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-pyo3-macros+default-devel \
 rust-pyo3-macros+experimental-async-devel \
 rust-pyo3-macros+experimental-inspect-devel \
 rust-pyo3-macros+multiple-pymethods-devel \
 rust-pyo3-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-macros-0.25.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62aabf7d1bce1a5e4f6dc8450b22c09011d7bdce12b6439a2710ae6025bc442b"

URI_x86_64_v2_rust-pyo3-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros+default-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros+default-devel.sha256sum] = "38dad621387d229a29d16353b31f8a082e74935395ef24d066a8e96f12b2350d"

URI_x86_64_v2_rust-pyo3-macros+experimental-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros+experimental-async-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros+experimental-async-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros+experimental-async-devel.sha256sum] = "fd6a6448d54f38ecbc1df2d7bfd756c807385bee754926fd3ca543bc0640b61c"

URI_x86_64_v2_rust-pyo3-macros+experimental-inspect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros+experimental-inspect-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros+experimental-inspect-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros+experimental-inspect-devel.sha256sum] = "f085f7480dce82bd3e7f6a3cbd5ebdba678a83c937b197fe8032847e28413c83"

URI_x86_64_v2_rust-pyo3-macros+multiple-pymethods-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros+multiple-pymethods-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros+multiple-pymethods-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros+multiple-pymethods-devel.sha256sum] = "075c0b06efaddca3cd7e065693767dd72b82dc4d44a99a0b9b4e90fc4e0f43cd"

URI_x86_64_v2_rust-pyo3-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-devel.sha256sum] = "dceb64961cbed0d5f863f0c50bf84cc36c1d205bd212133513d46536b80c31cd"

URI_aarch64_rust-pyo3-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros+default-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros+default-devel}"
SRC_URI[aarch64_rust-pyo3-macros+default-devel.sha256sum] = "d077d528825acd8415dc705347114c6109b71a74a9da1438265ffca90b9777e2"

URI_aarch64_rust-pyo3-macros+experimental-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros+experimental-async-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-macros+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros+experimental-async-devel}"
SRC_URI[aarch64_rust-pyo3-macros+experimental-async-devel.sha256sum] = "90a8e970ba79773bd3cba2a1f20ce2ae1a7b1b584b84551e3c30171e174fdba2"

URI_aarch64_rust-pyo3-macros+experimental-inspect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros+experimental-inspect-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-macros+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros+experimental-inspect-devel}"
SRC_URI[aarch64_rust-pyo3-macros+experimental-inspect-devel.sha256sum] = "e92abaa8490864294e461349257adf079610a46104a06fc2b277aa1f975e4885"

URI_aarch64_rust-pyo3-macros+multiple-pymethods-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros+multiple-pymethods-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-macros+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros+multiple-pymethods-devel}"
SRC_URI[aarch64_rust-pyo3-macros+multiple-pymethods-devel.sha256sum] = "048a10df7932df6deea811b5ac74dbf950af4e339c8aea61780700b76da9917f"

URI_aarch64_rust-pyo3-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-devel}"
SRC_URI[aarch64_rust-pyo3-macros-devel.sha256sum] = "830914c9defb943f049e76400eb3c0b76d5deea713c7849e3889f7c7749d9b23"

RDEPENDS:rust-pyo3-macros+default-devel = " \
 cargo \
 rust-pyo3-macros-devel \
 "
RDEPENDS:rust-pyo3-macros+experimental-async-devel = " \
 cargo \
 rust-pyo3-macros-backend+experimental-async-devel \
 rust-pyo3-macros-devel \
 "
RDEPENDS:rust-pyo3-macros+experimental-inspect-devel = " \
 cargo \
 rust-pyo3-macros-backend+experimental-inspect-devel \
 rust-pyo3-macros-devel \
 "
RDEPENDS:rust-pyo3-macros+multiple-pymethods-devel = " \
 cargo \
 rust-pyo3-macros-devel \
 "
RDEPENDS:rust-pyo3-macros-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 rust-pyo3-macros-backend+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 "
