# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tracing-core"
PV = "0.1.36"
PR = "1.el10_2"
PACKAGES = " \
 rust-tracing-core+default-devel \
 rust-tracing-core+once_cell-devel \
 rust-tracing-core+std-devel \
 rust-tracing-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tracing-core-0.1.36-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e7aa6c3dbefef780ba7f025b3ec3ad16342606c033b5aea45b7036c89b56196"

URI_x86_64_v2_rust-tracing-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-core+default-devel-0.1.36-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-core+default-devel}"
SRC_URI[x86_64_v2_rust-tracing-core+default-devel.sha256sum] = "4c6f18da97fdad1698b160cc9f72f7606567b66b8c4668496cc5067388f11c6d"

URI_x86_64_v2_rust-tracing-core+once_cell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-core+once_cell-devel-0.1.36-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-core+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-core+once_cell-devel}"
SRC_URI[x86_64_v2_rust-tracing-core+once_cell-devel.sha256sum] = "87ad675db16fad71af33d846ad82e610ed28d0a119dcf774794ee202605150eb"

URI_x86_64_v2_rust-tracing-core+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-core+std-devel-0.1.36-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-core+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-core+std-devel}"
SRC_URI[x86_64_v2_rust-tracing-core+std-devel.sha256sum] = "8423d47aa11e17b40d1e6e410336926647ff361e60241b283c89bcff08ea73b9"

URI_x86_64_v2_rust-tracing-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-core-devel-0.1.36-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-core-devel}"
SRC_URI[x86_64_v2_rust-tracing-core-devel.sha256sum] = "66b791c52e386e77f42809763b3bff4d0f462cc52be58c58fafdf408892d890f"

URI_aarch64_rust-tracing-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-core+default-devel-0.1.36-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-core+default-devel}"
SRC_URI[aarch64_rust-tracing-core+default-devel.sha256sum] = "d58741efb1d9dc39026fae725fff731782e4e61572296f9bac5fb2293309ce24"

URI_aarch64_rust-tracing-core+once_cell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-core+once_cell-devel-0.1.36-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-core+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-core+once_cell-devel}"
SRC_URI[aarch64_rust-tracing-core+once_cell-devel.sha256sum] = "eae63282e42b23e93c88e96cb695e633f6da9a10d23b9e90c2117ba4f1a277e9"

URI_aarch64_rust-tracing-core+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-core+std-devel-0.1.36-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-core+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-core+std-devel}"
SRC_URI[aarch64_rust-tracing-core+std-devel.sha256sum] = "e8ce6ce342a6cf5bd8c2197c86fee19b9e0a96c275d131693867ef8c3e08cfea"

URI_aarch64_rust-tracing-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-core-devel-0.1.36-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-core-devel}"
SRC_URI[aarch64_rust-tracing-core-devel.sha256sum] = "ae260091c7ea2c0fe5404ed5ecbb3fc1089297bbf7214146d7e48cc29c577cdb"

RDEPENDS:rust-tracing-core+default-devel = " \
 cargo \
 rust-tracing-core+std-devel \
 rust-tracing-core-devel \
 "
RDEPENDS:rust-tracing-core+once_cell-devel = " \
 cargo \
 rust-once_cell+default-devel \
 rust-tracing-core-devel \
 "
RDEPENDS:rust-tracing-core+std-devel = " \
 cargo \
 rust-tracing-core+once_cell-devel \
 rust-tracing-core-devel \
 "
RDEPENDS:rust-tracing-core-devel = " \
 cargo \
 rust \
 "
