# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rusqlite"
PV = "0.38.0"
PR = "3.el10_3"
PACKAGES = " \
 rust-rusqlite+array-devel \
 rust-rusqlite+backup-devel \
 rust-rusqlite+blob-devel \
 rust-rusqlite+buildtime_bindgen-devel \
 rust-rusqlite+cache-devel \
 rust-rusqlite+chrono-devel \
 rust-rusqlite+collation-devel \
 rust-rusqlite+column_decltype-devel \
 rust-rusqlite+column_metadata-devel \
 rust-rusqlite+csv-devel \
 rust-rusqlite+csvtab-devel \
 rust-rusqlite+default-devel \
 rust-rusqlite+extra_check-devel \
 rust-rusqlite+fallible_uint-devel \
 rust-rusqlite+functions-devel \
 rust-rusqlite+hashlink-devel \
 rust-rusqlite+hooks-devel \
 rust-rusqlite+i128_blob-devel \
 rust-rusqlite+jiff-devel \
 rust-rusqlite+limits-devel \
 rust-rusqlite+load_extension-devel \
 rust-rusqlite+modern-full-devel \
 rust-rusqlite+modern_sqlite-devel \
 rust-rusqlite+preupdate_hook-devel \
 rust-rusqlite+serde_json-devel \
 rust-rusqlite+serialize-devel \
 rust-rusqlite+series-devel \
 rust-rusqlite+session-devel \
 rust-rusqlite+time-devel \
 rust-rusqlite+trace-devel \
 rust-rusqlite+unlock_notify-devel \
 rust-rusqlite+url-devel \
 rust-rusqlite+uuid-devel \
 rust-rusqlite+vtab-devel \
 rust-rusqlite+window-devel \
 rust-rusqlite-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rusqlite-0.38.0-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12dc6316f8b647eefbbc67aa177654fea2248a7dba6602f6a467e5b017604dc8"

URI_x86_64_v2_rust-rusqlite+array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+array-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+array-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+array-devel.sha256sum] = "1d2f60d6fe91e81b76ae054548b946f0176ccbce470b2ba4769ca3f12b010fb2"

URI_x86_64_v2_rust-rusqlite+backup-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+backup-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+backup-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+backup-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+backup-devel.sha256sum] = "ce1a5fedfc87727e9de4dd20827d994df0c95ab0721fed6172eb0ee4a066f5a5"

URI_x86_64_v2_rust-rusqlite+blob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+blob-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+blob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+blob-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+blob-devel.sha256sum] = "2d2bb67a0d16dbaa52fc9c42ad729368c93fcddb4985a1b0a99f50c09c93b8b3"
RPROVIDES:rust-rusqlite+blob-devel:x86_64_v2 = "virtual/crate_rusqlite/blob__ge_0.29.0_with_crate_rusqlite/blob__lt_0.40.0~"

URI_x86_64_v2_rust-rusqlite+buildtime_bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+buildtime_bindgen-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+buildtime_bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+buildtime_bindgen-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+buildtime_bindgen-devel.sha256sum] = "4192343c7ea60b4460c201633b60cf0466c9d8b727ce4a1f7cf912ec13797bdf"

URI_x86_64_v2_rust-rusqlite+cache-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+cache-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+cache-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+cache-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+cache-devel.sha256sum] = "2f7e08b5553adacfbc8a61fa6d77dcd9890e4663574b68d58c598f8d8334fcc6"

URI_x86_64_v2_rust-rusqlite+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+chrono-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+chrono-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+chrono-devel.sha256sum] = "8769eed369cfef6f5f8bfa82e68b24efc865a08b2ad513253285a728e1b2f814"

URI_x86_64_v2_rust-rusqlite+collation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+collation-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+collation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+collation-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+collation-devel.sha256sum] = "e2e8f3a47445ba6b90940d6df395bd5e926a188aee7fa2e755c376cb94a05453"
RPROVIDES:rust-rusqlite+collation-devel:x86_64_v2 = "virtual/crate_rusqlite/collation__ge_0.29.0_with_crate_rusqlite/collation__lt_0.40.0~"

URI_x86_64_v2_rust-rusqlite+column_decltype-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+column_decltype-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+column_decltype-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+column_decltype-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+column_decltype-devel.sha256sum] = "8871e681ccb22ba9d14b2221a853ce8e6718f390ccb816fa2b2b6e7d903ec269"

URI_x86_64_v2_rust-rusqlite+column_metadata-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+column_metadata-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+column_metadata-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+column_metadata-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+column_metadata-devel.sha256sum] = "b3f487e10a833cb4586790d1e2e46c392ab4db874f79a6ff4b40000904dcaf54"

URI_x86_64_v2_rust-rusqlite+csv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+csv-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+csv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+csv-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+csv-devel.sha256sum] = "94e24e5b0d4caa4fe9ddd7590aaf078a7a3915a81ff04063a0fdee6fa77f44bb"

URI_x86_64_v2_rust-rusqlite+csvtab-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+csvtab-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+csvtab-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+csvtab-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+csvtab-devel.sha256sum] = "0c2ee5edb9a0a1b23803254606fc3231baaeee3fed4129573a4a697393aa490a"

URI_x86_64_v2_rust-rusqlite+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+default-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+default-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+default-devel.sha256sum] = "1040bf213679c26f0286499facd574b420e241cbbc757babacb4fd0fd77d2188"
RPROVIDES:rust-rusqlite+default-devel:x86_64_v2 = "virtual/crate_rusqlite/default__ge_0.29.0_with_crate_rusqlite/default__lt_0.40.0~"

URI_x86_64_v2_rust-rusqlite+extra_check-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+extra_check-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+extra_check-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+extra_check-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+extra_check-devel.sha256sum] = "5b20d291cf5c0af1809e5979f0d5d4b1bfe4e0ef939909a20fe070a79c9ab6bb"

URI_x86_64_v2_rust-rusqlite+fallible_uint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+fallible_uint-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+fallible_uint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+fallible_uint-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+fallible_uint-devel.sha256sum] = "39fbfb4b4d66d93cc48b59c6ee56496ad5b6b0c800890dccf31a54b817a70b94"

URI_x86_64_v2_rust-rusqlite+functions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+functions-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+functions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+functions-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+functions-devel.sha256sum] = "676d71fe5e9770dc6e354f523edf253b929d1954cb00e4a847be4fcd3a7593c1"

URI_x86_64_v2_rust-rusqlite+hashlink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+hashlink-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+hashlink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+hashlink-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+hashlink-devel.sha256sum] = "2006bd3395e49874db9de56645351c00a79cdf8d231523f990ae6f8d4b88a503"

URI_x86_64_v2_rust-rusqlite+hooks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+hooks-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+hooks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+hooks-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+hooks-devel.sha256sum] = "f1504b759ad153d4b4edb68d04652be51dcdaa14dfe105e43a6803c2dfba4bca"

URI_x86_64_v2_rust-rusqlite+i128_blob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+i128_blob-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+i128_blob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+i128_blob-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+i128_blob-devel.sha256sum] = "b379e73e4f2a1d1ed55e0d0c3241a4c17edf015c3e5d99077cd87ad6d810bb62"

URI_x86_64_v2_rust-rusqlite+jiff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+jiff-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+jiff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+jiff-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+jiff-devel.sha256sum] = "4a7e214464d7e58b81e01b574e222504244bffa7fc7849a6d89af63c56b7caa8"

URI_x86_64_v2_rust-rusqlite+limits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+limits-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+limits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+limits-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+limits-devel.sha256sum] = "485aa4023ab8ffc39c651ae08f4c8e09d2086c45a012126ac46e23cab3368cb8"

URI_x86_64_v2_rust-rusqlite+load_extension-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+load_extension-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+load_extension-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+load_extension-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+load_extension-devel.sha256sum] = "c9169215a5a07142ff05969a78bf9763bad18694c7122ce0c48dc3d0cf070d01"

URI_x86_64_v2_rust-rusqlite+modern-full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+modern-full-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+modern-full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+modern-full-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+modern-full-devel.sha256sum] = "858e62ef17f210681bce11d541d6b31a125253a418e1dcb99647d6185de06e61"

URI_x86_64_v2_rust-rusqlite+modern_sqlite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+modern_sqlite-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+modern_sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+modern_sqlite-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+modern_sqlite-devel.sha256sum] = "5c26854d9bfbf84ba7bc710d225635b64ab91e2541cb35194ab579c0cbdff7cc"

URI_x86_64_v2_rust-rusqlite+preupdate_hook-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+preupdate_hook-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+preupdate_hook-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+preupdate_hook-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+preupdate_hook-devel.sha256sum] = "241195090e0d5697076e1a3288a4182921f415124b4b703c24796bfcf06e86a6"

URI_x86_64_v2_rust-rusqlite+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+serde_json-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+serde_json-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+serde_json-devel.sha256sum] = "a9e831216ed5615d261408ba17d4efad7e117798e15b1c2766c04502e08a5421"

URI_x86_64_v2_rust-rusqlite+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+serialize-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+serialize-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+serialize-devel.sha256sum] = "1488b967c8c61cab8d538fdee40cb03216036a9d0c5b2e643c3254566d814b08"

URI_x86_64_v2_rust-rusqlite+series-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+series-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+series-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+series-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+series-devel.sha256sum] = "1f2b84d1e5bd187d92a980edad8e819a8b1d4a7102d94fe417642a24e0c29d0a"

URI_x86_64_v2_rust-rusqlite+session-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+session-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+session-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+session-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+session-devel.sha256sum] = "b451ae854cad38c713336e325c5ffe3829e807afeb3551a26c435a37d8df5b59"

URI_x86_64_v2_rust-rusqlite+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+time-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+time-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+time-devel.sha256sum] = "4ea004f76bfb1151d63a6b2a0b82673f36f333b6ec64da4e43340ab1595c0d02"

URI_x86_64_v2_rust-rusqlite+trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+trace-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+trace-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+trace-devel.sha256sum] = "ae570a6b0aa5948bd640b5cbd5e90015eff28a5a1000371cf56fb98ffbc94110"
RPROVIDES:rust-rusqlite+trace-devel:x86_64_v2 = "virtual/crate_rusqlite/trace__ge_0.29.0_with_crate_rusqlite/trace__lt_0.40.0~"

URI_x86_64_v2_rust-rusqlite+unlock_notify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+unlock_notify-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+unlock_notify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+unlock_notify-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+unlock_notify-devel.sha256sum] = "a09b268427f32e77e4813ae0da764e5bc0ba4c7f0b76e8f6b32118de956b8a62"

URI_x86_64_v2_rust-rusqlite+url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+url-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+url-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+url-devel.sha256sum] = "434f45e5bf86f005bb9fb4cb403f0e093742d8ced8e4f12c046ac9a81baf27e6"

URI_x86_64_v2_rust-rusqlite+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+uuid-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+uuid-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+uuid-devel.sha256sum] = "690e6576871e00144b6aaf16d4d111655cbc9896626c8feef8c75d438e5d7295"

URI_x86_64_v2_rust-rusqlite+vtab-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+vtab-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+vtab-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+vtab-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+vtab-devel.sha256sum] = "c7fee2355e5aedbdd5fc88c6ba767fe618e7c51a1bf715c950ff019506f8c3c5"

URI_x86_64_v2_rust-rusqlite+window-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+window-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+window-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+window-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+window-devel.sha256sum] = "9a532e492a0ccbc0637e3deffc585b2daeda12a9c8c9650627def549f09d3fab"

URI_x86_64_v2_rust-rusqlite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite-devel-0.38.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite-devel}"
SRC_URI[x86_64_v2_rust-rusqlite-devel.sha256sum] = "bf3777de9fc136651294260412db27273407a5887aae7323f76e08ff4a96da7a"

URI_aarch64_rust-rusqlite+array-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+array-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+array-devel}"
SRC_URI[aarch64_rust-rusqlite+array-devel.sha256sum] = "454db3cc5ea34349c2387e9c1fd2785dd4cb1e770c28d39c57f97ae921e239e6"

URI_aarch64_rust-rusqlite+backup-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+backup-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+backup-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+backup-devel}"
SRC_URI[aarch64_rust-rusqlite+backup-devel.sha256sum] = "fd2e447c1bf2eba56df3fba9322ad57ae71c4dd91cdb6612a6b73e6c2b4d0eed"

URI_aarch64_rust-rusqlite+blob-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+blob-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+blob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+blob-devel}"
SRC_URI[aarch64_rust-rusqlite+blob-devel.sha256sum] = "5369472638f53b22e1ef838d295db355861d3d191ea406c581c7ff76055ad500"
RPROVIDES:rust-rusqlite+blob-devel:aarch64 = "virtual/crate_rusqlite/blob__ge_0.29.0_with_crate_rusqlite/blob__lt_0.40.0~"

URI_aarch64_rust-rusqlite+buildtime_bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+buildtime_bindgen-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+buildtime_bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+buildtime_bindgen-devel}"
SRC_URI[aarch64_rust-rusqlite+buildtime_bindgen-devel.sha256sum] = "c4c3be2f85d2eb1a4d354063f8e169dff4df615c2209b1b0729cceb866e5ec04"

URI_aarch64_rust-rusqlite+cache-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+cache-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+cache-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+cache-devel}"
SRC_URI[aarch64_rust-rusqlite+cache-devel.sha256sum] = "2ab5156eb489a52bd9dd0746094b55efa83239cf15729019550db2c5603d0a33"

URI_aarch64_rust-rusqlite+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+chrono-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+chrono-devel}"
SRC_URI[aarch64_rust-rusqlite+chrono-devel.sha256sum] = "c1200fcc3f9aafc2c0bf6081119a7116cfbe0b16df35e02e33d20e0401b1c061"

URI_aarch64_rust-rusqlite+collation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+collation-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+collation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+collation-devel}"
SRC_URI[aarch64_rust-rusqlite+collation-devel.sha256sum] = "e58d609bd13b74777ac9a2369f8cb0fda56a47ea048767d33b005065fb3b594c"
RPROVIDES:rust-rusqlite+collation-devel:aarch64 = "virtual/crate_rusqlite/collation__ge_0.29.0_with_crate_rusqlite/collation__lt_0.40.0~"

URI_aarch64_rust-rusqlite+column_decltype-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+column_decltype-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+column_decltype-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+column_decltype-devel}"
SRC_URI[aarch64_rust-rusqlite+column_decltype-devel.sha256sum] = "535fbe171f5b18a2ef7e728bfeb6194ee48386cde8546b6e6eb3adb0ecab2903"

URI_aarch64_rust-rusqlite+column_metadata-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+column_metadata-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+column_metadata-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+column_metadata-devel}"
SRC_URI[aarch64_rust-rusqlite+column_metadata-devel.sha256sum] = "7a0a1d664c2510dbc3e33aec21a81c987e5334de1fbb6e81c47b1d06f2f7d0de"

URI_aarch64_rust-rusqlite+csv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+csv-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+csv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+csv-devel}"
SRC_URI[aarch64_rust-rusqlite+csv-devel.sha256sum] = "5a209d84027f4165dfe942ed141879f51c3c27d9b44a5f491489dc8d0d63438e"

URI_aarch64_rust-rusqlite+csvtab-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+csvtab-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+csvtab-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+csvtab-devel}"
SRC_URI[aarch64_rust-rusqlite+csvtab-devel.sha256sum] = "addc7a3882003becdc6647958245db746d409eb20533a93de8d072ccdc01e82a"

URI_aarch64_rust-rusqlite+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+default-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+default-devel}"
SRC_URI[aarch64_rust-rusqlite+default-devel.sha256sum] = "4482a45aed0443b85b00c0085a2b8edaed230a4b599a38a582569a3d66ae2592"
RPROVIDES:rust-rusqlite+default-devel:aarch64 = "virtual/crate_rusqlite/default__ge_0.29.0_with_crate_rusqlite/default__lt_0.40.0~"

URI_aarch64_rust-rusqlite+extra_check-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+extra_check-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+extra_check-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+extra_check-devel}"
SRC_URI[aarch64_rust-rusqlite+extra_check-devel.sha256sum] = "aeace747a6e78b35b5f9b0bedbe91218a965cb36fd06625a38bb7541e17557c4"

URI_aarch64_rust-rusqlite+fallible_uint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+fallible_uint-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+fallible_uint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+fallible_uint-devel}"
SRC_URI[aarch64_rust-rusqlite+fallible_uint-devel.sha256sum] = "7cae0d9ef86c7dd975a9d18f378f5694f40d04a86545f929b7a9438b2ce74538"

URI_aarch64_rust-rusqlite+functions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+functions-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+functions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+functions-devel}"
SRC_URI[aarch64_rust-rusqlite+functions-devel.sha256sum] = "7a7e7bd4c9532fa9b32d464570d72ff4fa21a2f4444ff6c222b7e932d8f89207"

URI_aarch64_rust-rusqlite+hashlink-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+hashlink-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+hashlink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+hashlink-devel}"
SRC_URI[aarch64_rust-rusqlite+hashlink-devel.sha256sum] = "6bd8fe817cfb8b2651a15a04c2ccbdfed5d641dc8653089f6d66395435ca0463"

URI_aarch64_rust-rusqlite+hooks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+hooks-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+hooks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+hooks-devel}"
SRC_URI[aarch64_rust-rusqlite+hooks-devel.sha256sum] = "c972bc1b6cb273057f42ae9d85444fdfc6e66631ab7fbe900738e31b7572c9f9"

URI_aarch64_rust-rusqlite+i128_blob-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+i128_blob-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+i128_blob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+i128_blob-devel}"
SRC_URI[aarch64_rust-rusqlite+i128_blob-devel.sha256sum] = "a7a1bbf7c89afd58df3646bbd6bbaed63b1f8330e5548ded70b24368aa0c4902"

URI_aarch64_rust-rusqlite+jiff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+jiff-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+jiff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+jiff-devel}"
SRC_URI[aarch64_rust-rusqlite+jiff-devel.sha256sum] = "6456c9db8cc4031bdeced42f72d280d9129887352e088bd86ea76d5ed4752a92"

URI_aarch64_rust-rusqlite+limits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+limits-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+limits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+limits-devel}"
SRC_URI[aarch64_rust-rusqlite+limits-devel.sha256sum] = "e5ac1a6f08f73542e118e4c20d16a8f13fb055748110044da976db87aea608e4"

URI_aarch64_rust-rusqlite+load_extension-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+load_extension-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+load_extension-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+load_extension-devel}"
SRC_URI[aarch64_rust-rusqlite+load_extension-devel.sha256sum] = "732d1be0c724092f274da13c56df4a2f84372737ae2f59f5ce1f572c1c3b3b1d"

URI_aarch64_rust-rusqlite+modern-full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+modern-full-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+modern-full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+modern-full-devel}"
SRC_URI[aarch64_rust-rusqlite+modern-full-devel.sha256sum] = "6850ab26ac0e0c3a81a0058456cff07a6febff2acff37b30e870df59a470f832"

URI_aarch64_rust-rusqlite+modern_sqlite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+modern_sqlite-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+modern_sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+modern_sqlite-devel}"
SRC_URI[aarch64_rust-rusqlite+modern_sqlite-devel.sha256sum] = "0be698487e5446bee03539b2999cbfa6bcf14245e45b78aae527ea6265a6de9f"

URI_aarch64_rust-rusqlite+preupdate_hook-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+preupdate_hook-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+preupdate_hook-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+preupdate_hook-devel}"
SRC_URI[aarch64_rust-rusqlite+preupdate_hook-devel.sha256sum] = "134808ad674e7e86879acb095ac307fe4f7586ced7301d1d4e5a07ec2cee34b3"

URI_aarch64_rust-rusqlite+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+serde_json-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+serde_json-devel}"
SRC_URI[aarch64_rust-rusqlite+serde_json-devel.sha256sum] = "10d2674c6915a0f7c3afa8ba458a1989c06990badcd3fde4388321bfdefcbdd2"

URI_aarch64_rust-rusqlite+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+serialize-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+serialize-devel}"
SRC_URI[aarch64_rust-rusqlite+serialize-devel.sha256sum] = "b7c75a8a54753ecb1d7880cff0f90a9e50b44a2c1412b30f555dce1ed294b2a7"

URI_aarch64_rust-rusqlite+series-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+series-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+series-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+series-devel}"
SRC_URI[aarch64_rust-rusqlite+series-devel.sha256sum] = "b192d30c2244ec35b54ac14da923e44e64ca399eb56fdbeed11a50367b72a410"

URI_aarch64_rust-rusqlite+session-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+session-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+session-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+session-devel}"
SRC_URI[aarch64_rust-rusqlite+session-devel.sha256sum] = "13c751311c7fff67bca4a6cc65e0c6bc295d838f36e9189f8a522395f021fd70"

URI_aarch64_rust-rusqlite+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+time-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+time-devel}"
SRC_URI[aarch64_rust-rusqlite+time-devel.sha256sum] = "3fc6c7d9135ce6df628da1e143b0c11e3103fdd89caa6a27f485179f0ba8db14"

URI_aarch64_rust-rusqlite+trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+trace-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+trace-devel}"
SRC_URI[aarch64_rust-rusqlite+trace-devel.sha256sum] = "1c67ecf27ba0fe893bd5e570a5d1b27136de54a7e3288c02ae5bfb65c65b1f59"
RPROVIDES:rust-rusqlite+trace-devel:aarch64 = "virtual/crate_rusqlite/trace__ge_0.29.0_with_crate_rusqlite/trace__lt_0.40.0~"

URI_aarch64_rust-rusqlite+unlock_notify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+unlock_notify-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+unlock_notify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+unlock_notify-devel}"
SRC_URI[aarch64_rust-rusqlite+unlock_notify-devel.sha256sum] = "23f45143f742d2ecdb3a3f13278bca621ce7181d4d6178360856b6a0eddc1f5f"

URI_aarch64_rust-rusqlite+url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+url-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+url-devel}"
SRC_URI[aarch64_rust-rusqlite+url-devel.sha256sum] = "3dc82ab552a3f6ed9ebd0db0a3e2ae06dad72b552ac6c3488514399fd118f4f4"

URI_aarch64_rust-rusqlite+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+uuid-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+uuid-devel}"
SRC_URI[aarch64_rust-rusqlite+uuid-devel.sha256sum] = "cf92882ef2f9fbcec55843dc2d1ee8318413f90471a6d2ab82e65e35bf07828c"

URI_aarch64_rust-rusqlite+vtab-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+vtab-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+vtab-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+vtab-devel}"
SRC_URI[aarch64_rust-rusqlite+vtab-devel.sha256sum] = "6e3ebbe4f80a977f0a6d185712b778b3b24d75be262f1a37c769672bcc59fb09"

URI_aarch64_rust-rusqlite+window-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+window-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite+window-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+window-devel}"
SRC_URI[aarch64_rust-rusqlite+window-devel.sha256sum] = "9eff74f181604dda5ed7a3c3afc78f24083cfe6246a3b90787d62bfc5f33b431"

URI_aarch64_rust-rusqlite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite-devel-0.38.0-3.el10_3.noarch.rpm;name=aarch64_rust-rusqlite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite-devel}"
SRC_URI[aarch64_rust-rusqlite-devel.sha256sum] = "82d351256fdb0185f8e5ad324bf825df5d0bcf9ef9eec8899cc46b5b961b857a"

RDEPENDS:rust-rusqlite+array-devel = " \
 cargo \
 rust-rusqlite+vtab-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+backup-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+blob-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+buildtime_bindgen-devel = " \
 cargo \
 rust-libsqlite3-sys+buildtime_bindgen-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+cache-devel = " \
 cargo \
 rust-rusqlite+hashlink-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+chrono-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+collation-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+column_decltype-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+column_metadata-devel = " \
 cargo \
 rust-libsqlite3-sys+column_metadata-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+csv-devel = " \
 cargo \
 rust-csv+default-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+csvtab-devel = " \
 cargo \
 rust-rusqlite+csv-devel \
 rust-rusqlite+vtab-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+default-devel = " \
 cargo \
 rust-rusqlite+cache-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+extra_check-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+fallible_uint-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+functions-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+hashlink-devel = " \
 cargo \
 rust-hashlink+default-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+hooks-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+i128_blob-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+jiff-devel = " \
 cargo \
 rust-jiff+std-devel \
 rust-jiff-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+limits-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+load_extension-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+modern-full-devel = " \
 cargo \
 rust-rusqlite+array-devel \
 rust-rusqlite+backup-devel \
 rust-rusqlite+blob-devel \
 rust-rusqlite+chrono-devel \
 rust-rusqlite+collation-devel \
 rust-rusqlite+column_decltype-devel \
 rust-rusqlite+column_metadata-devel \
 rust-rusqlite+csvtab-devel \
 rust-rusqlite+extra_check-devel \
 rust-rusqlite+functions-devel \
 rust-rusqlite+hooks-devel \
 rust-rusqlite+i128_blob-devel \
 rust-rusqlite+jiff-devel \
 rust-rusqlite+limits-devel \
 rust-rusqlite+load_extension-devel \
 rust-rusqlite+modern_sqlite-devel \
 rust-rusqlite+serde_json-devel \
 rust-rusqlite+serialize-devel \
 rust-rusqlite+series-devel \
 rust-rusqlite+time-devel \
 rust-rusqlite+trace-devel \
 rust-rusqlite+unlock_notify-devel \
 rust-rusqlite+url-devel \
 rust-rusqlite+uuid-devel \
 rust-rusqlite+vtab-devel \
 rust-rusqlite+window-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+modern_sqlite-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+preupdate_hook-devel = " \
 cargo \
 rust-libsqlite3-sys+preupdate_hook-devel \
 rust-rusqlite+hooks-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+serde_json-devel = " \
 cargo \
 rust-rusqlite-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-rusqlite+serialize-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+series-devel = " \
 cargo \
 rust-rusqlite+vtab-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+session-devel = " \
 cargo \
 rust-libsqlite3-sys+session-devel \
 rust-rusqlite+hooks-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+time-devel = " \
 cargo \
 rust-rusqlite-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+macros-devel \
 rust-time+parsing-devel \
 "
RDEPENDS:rust-rusqlite+trace-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+unlock_notify-devel = " \
 cargo \
 rust-libsqlite3-sys+unlock_notify-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+url-devel = " \
 cargo \
 rust-rusqlite-devel \
 rust-url+default-devel \
 "
RDEPENDS:rust-rusqlite+uuid-devel = " \
 cargo \
 rust-rusqlite-devel \
 rust-uuid+default-devel \
 "
RDEPENDS:rust-rusqlite+vtab-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+window-devel = " \
 cargo \
 rust-rusqlite+functions-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite-devel = " \
 cargo \
 rust-bitflags+default-devel \
 rust-fallible-iterator+default-devel \
 rust-fallible-streaming-iterator+default-devel \
 rust-libsqlite3-sys+default-devel \
 rust-smallvec+default-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_rusqlite/blob__ge_0.29.0_with_crate_rusqlite/blob__lt_0.40.0~ rpm/virtual/crate_rusqlite/collation__ge_0.29.0_with_crate_rusqlite/collation__lt_0.40.0~ rpm/virtual/crate_rusqlite/default__ge_0.29.0_with_crate_rusqlite/default__lt_0.40.0~ rpm/virtual/crate_rusqlite/trace__ge_0.29.0_with_crate_rusqlite/trace__lt_0.40.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_rusqlite/blob__ge_0.29.0_with_crate_rusqlite/blob__lt_0.40.0~ rpm/virtual/crate_rusqlite/collation__ge_0.29.0_with_crate_rusqlite/collation__lt_0.40.0~ rpm/virtual/crate_rusqlite/default__ge_0.29.0_with_crate_rusqlite/default__lt_0.40.0~ rpm/virtual/crate_rusqlite/trace__ge_0.29.0_with_crate_rusqlite/trace__lt_0.40.0~"
