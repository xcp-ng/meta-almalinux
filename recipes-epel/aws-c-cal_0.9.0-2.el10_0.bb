# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aws-c-cal"
PV = "0.9.0"
PR = "2.el10_0"
PACKAGES = " \
 aws-c-cal \
 aws-c-cal-devel \
 aws-c-cal-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aws-c-cal-0.9.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e259f8d5b0fdfd094fe363475dab114d96ca7e45ad6122e3550985a5cf55b69"

URI_x86_64_v2_aws-c-cal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-cal-0.9.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-cal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-cal}"
SRC_URI[x86_64_v2_aws-c-cal.sha256sum] = "d09dbc08135a9a829b1cb56b892f44e337a01b1fb26d14728067f5b49a6c9465"

URI_x86_64_v2_aws-c-cal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-cal-devel-0.9.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-cal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-cal-devel}"
SRC_URI[x86_64_v2_aws-c-cal-devel.sha256sum] = "0a953f1d6298bfc19314b9ce6d5017a0f59c721a4b0e4656ec5f73ecb1379a4f"

URI_x86_64_v2_aws-c-cal-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-cal-libs-0.9.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-cal-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-cal-libs}"
SRC_URI[x86_64_v2_aws-c-cal-libs.sha256sum] = "3a4dce1cc4471271440e9d901f545709e2a9bbb575f0b5cab3a72d845bfd9c04"

URI_aarch64_aws-c-cal = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-cal-0.9.0-2.el10_0.aarch64.rpm;name=aarch64_aws-c-cal;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-cal}"
SRC_URI[aarch64_aws-c-cal.sha256sum] = "35d660cd50e4894b5a97a93a7247940b660acbaa891d0e46840d39076a7c4c87"

URI_aarch64_aws-c-cal-devel = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-cal-devel-0.9.0-2.el10_0.aarch64.rpm;name=aarch64_aws-c-cal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-cal-devel}"
SRC_URI[aarch64_aws-c-cal-devel.sha256sum] = "272e8deeeb6bba934eca6258534a4cd0ed3dea8ac6851c8edb7376b53133e729"

URI_aarch64_aws-c-cal-libs = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-cal-libs-0.9.0-2.el10_0.aarch64.rpm;name=aarch64_aws-c-cal-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-cal-libs}"
SRC_URI[aarch64_aws-c-cal-libs.sha256sum] = "0915635e46a4b8b72979bfeee69b1b3ff422f98ba0983692dc43c925c987190a"

RDEPENDS:aws-c-cal = " \
 "
RDEPENDS:aws-c-cal-devel = " \
 aws-c-cal-libs \
 aws-c-common-devel \
 cmake-filesystem \
 openssl-devel \
 "
RDEPENDS:aws-c-cal-libs = " \
 aws-c-cal \
 aws-c-common-libs \
 glibc \
 openssl-libs \
 "
