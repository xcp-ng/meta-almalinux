# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-negotiate"
PV = "0.18.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-negotiate+default-devel \
 rust-gix-negotiate-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-negotiate-0.18.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "813f3ebe3598a184e075bf585ec5e3c66d2248ecb4f072d9ce63c16ab7c4dd89"

URI_x86_64_v2_rust-gix-negotiate+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-negotiate+default-devel-0.18.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-negotiate+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-negotiate+default-devel}"
SRC_URI[x86_64_v2_rust-gix-negotiate+default-devel.sha256sum] = "45c76409c8608fd396ad6e31e8c3fb2acaa5b8b9baeb2150d7d37d86e333009a"

URI_x86_64_v2_rust-gix-negotiate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-negotiate-devel-0.18.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-negotiate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-negotiate-devel}"
SRC_URI[x86_64_v2_rust-gix-negotiate-devel.sha256sum] = "a35ee77a059911ac0bb2a1236eab5a319126cacbb686cb4b659bc82f7d39252c"

URI_aarch64_rust-gix-negotiate+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-negotiate+default-devel-0.18.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-negotiate+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-negotiate+default-devel}"
SRC_URI[aarch64_rust-gix-negotiate+default-devel.sha256sum] = "14f01b22e519bd9ac08a4d8faa6eadc7a762007271be9c29359affc1fbd2a726"

URI_aarch64_rust-gix-negotiate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-negotiate-devel-0.18.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-negotiate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-negotiate-devel}"
SRC_URI[aarch64_rust-gix-negotiate-devel.sha256sum] = "05e2e9facf2f8a9c9aea3456ab88b30e01844e7131fae55540c50391e15003da"

RDEPENDS:rust-gix-negotiate+default-devel = " \
 cargo \
 rust-gix-negotiate-devel \
 "
RDEPENDS:rust-gix-negotiate-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-gix-commitgraph+default-devel \
 rust-gix-date+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-object+default-devel \
 rust-gix-revwalk+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 "
