# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "edg-gridftp-client"
PV = "1.2.9.2"
PR = "42.el10_2"
PACKAGES = " \
 edg-gridftp-client \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/edg-gridftp-client-1.2.9.2-42.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "95b2763f0109fad07d5eeabc8b21f47795f570b0e2b0c4048933403d15c66150"

URI_x86_64_v2_edg-gridftp-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/edg-gridftp-client-1.2.9.2-42.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_edg-gridftp-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_edg-gridftp-client}"
SRC_URI[x86_64_v2_edg-gridftp-client.sha256sum] = "691714389580d1400ca556066d03192ad9d3a926fac026b28f518d10faf0d1ad"

URI_aarch64_edg-gridftp-client = "${EPEL_MIRROR}/aarch64/Packages/e/edg-gridftp-client-1.2.9.2-42.el10_2.aarch64.rpm;name=aarch64_edg-gridftp-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_edg-gridftp-client}"
SRC_URI[aarch64_edg-gridftp-client.sha256sum] = "69d8eb7d52f76f4088058a6ce16674d988d7a02d8110fc2b02391240fc013411"

RDEPENDS:edg-gridftp-client = " \
 glibc \
 globus-common \
 globus-ftp-client \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-PathTools \
 perl-interpreter \
 perl-libs \
 "
