# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocs"
PV = "25.12.0"
PR = "1.el10_2"
PACKAGES = " \
 rocs \
 rocs-devel \
 rocs-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocs-25.12.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dae287a5be42d03134072a204d8c1265bb30f562610ec18277284025cb3b3d26"

URI_x86_64_v2_rocs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocs-25.12.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocs}"
SRC_URI[x86_64_v2_rocs.sha256sum] = "3eddc01bc1408236e592d6e208fd4650ac23723b41d68037de33ec33c56ec5d5"

URI_x86_64_v2_rocs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocs-devel-25.12.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocs-devel}"
SRC_URI[x86_64_v2_rocs-devel.sha256sum] = "5e518618491a3629c31a998b9d7017a358131bdb9a3166c35d41d99b00905d38"

URI_x86_64_v2_rocs-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocs-libs-25.12.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocs-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocs-libs}"
SRC_URI[x86_64_v2_rocs-libs.sha256sum] = "2e69832e12a1ea4974c592cbbd68d9a68f1f6e05c0d567153281cbcb4c87ecfc"

URI_aarch64_rocs = "${EPEL_MIRROR}/aarch64/Packages/r/rocs-25.12.0-1.el10_2.aarch64.rpm;name=aarch64_rocs;unpack=0"
SRC_URI:append = " ${URI_aarch64_rocs}"
SRC_URI[aarch64_rocs.sha256sum] = "228d91b80694ee2caae8d92ef44426c70d030e151800204355734dff2def9eeb"

URI_aarch64_rocs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rocs-devel-25.12.0-1.el10_2.aarch64.rpm;name=aarch64_rocs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rocs-devel}"
SRC_URI[aarch64_rocs-devel.sha256sum] = "9f92f7a942f3c0f0dc5f982e770e9bc36e4f109302bf64618d273435ad3f66a1"

URI_aarch64_rocs-libs = "${EPEL_MIRROR}/aarch64/Packages/r/rocs-libs-25.12.0-1.el10_2.aarch64.rpm;name=aarch64_rocs-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_rocs-libs}"
SRC_URI[aarch64_rocs-libs.sha256sum] = "be2fe6384a0a09f2f8f03107f44b80cd77eca0f4db79a4ba9cad7a2d6fba37ae"

RDEPENDS:rocs = " \
 glibc \
 kf6-karchive \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kitemviews \
 kf6-kparts \
 kf6-ktexteditor \
 kf6-ktexttemplate \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 rocs-libs \
 "
RDEPENDS:rocs-devel = " \
 rocs-libs \
 "
RDEPENDS:rocs-libs = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kitemviews \
 kf6-kwidgetsaddons \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 rocs \
 "
