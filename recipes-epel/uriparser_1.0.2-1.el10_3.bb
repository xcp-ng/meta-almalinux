# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "uriparser"
PV = "1.0.2"
PR = "1.el10_3"
PACKAGES = " \
 mingw32-uriparser \
 mingw64-uriparser \
 uriparser \
 uriparser-devel \
 uriparser-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/uriparser-1.0.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6c4833ec00e59161d3fcd7ac574222c2c9d901d0922be40abc0ecedaff4978d"

URI_x86_64_v2_mingw32-uriparser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw32-uriparser-1.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_mingw32-uriparser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-uriparser}"
SRC_URI[x86_64_v2_mingw32-uriparser.sha256sum] = "29240a782be0fbff5ec96918c3203135e3acdaac4f8aab745b783fa3c37682f5"

URI_x86_64_v2_mingw64-uriparser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw64-uriparser-1.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_mingw64-uriparser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-uriparser}"
SRC_URI[x86_64_v2_mingw64-uriparser.sha256sum] = "8825fb3299caf6ab052af38f9960ac8b6673ba108e27fc2d38673ab0637a4c8d"

URI_x86_64_v2_uriparser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uriparser-1.0.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uriparser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uriparser}"
SRC_URI[x86_64_v2_uriparser.sha256sum] = "8235f53cc0a894e35dbffdb621688dcda579be6870011426b8e52e121c11dc1a"

URI_x86_64_v2_uriparser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uriparser-devel-1.0.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uriparser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uriparser-devel}"
SRC_URI[x86_64_v2_uriparser-devel.sha256sum] = "1d8fda82f8c5d8f22e9eec2a866d26f6b8ba8a2b75bba560be888104858e7bfa"

URI_x86_64_v2_uriparser-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uriparser-doc-1.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_uriparser-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uriparser-doc}"
SRC_URI[x86_64_v2_uriparser-doc.sha256sum] = "db24dd3e8f2f853880824c3c383b42a529da6e8e2bc6ffe583edffd39ad70b5d"

URI_aarch64_mingw32-uriparser = "${EPEL_MIRROR}/aarch64/Packages/m/mingw32-uriparser-1.0.2-1.el10_3.noarch.rpm;name=aarch64_mingw32-uriparser;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw32-uriparser}"
SRC_URI[aarch64_mingw32-uriparser.sha256sum] = "29af9698afcab78c0c882481038791b2205d6a99b1d5bed798cdc0a6143f5df4"

URI_aarch64_mingw64-uriparser = "${EPEL_MIRROR}/aarch64/Packages/m/mingw64-uriparser-1.0.2-1.el10_3.noarch.rpm;name=aarch64_mingw64-uriparser;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw64-uriparser}"
SRC_URI[aarch64_mingw64-uriparser.sha256sum] = "1ddc87c7c28cee2b0871544836772b0c27092d0b65160a854c756808dc342f3f"

URI_aarch64_uriparser = "${EPEL_MIRROR}/aarch64/Packages/u/uriparser-1.0.2-1.el10_3.aarch64.rpm;name=aarch64_uriparser;unpack=0"
SRC_URI:append = " ${URI_aarch64_uriparser}"
SRC_URI[aarch64_uriparser.sha256sum] = "fa989eb6f5fcdb20678917453b4a9e85d0aaa1317a7062f4a002cb10ddb0f022"

URI_aarch64_uriparser-devel = "${EPEL_MIRROR}/aarch64/Packages/u/uriparser-devel-1.0.2-1.el10_3.aarch64.rpm;name=aarch64_uriparser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_uriparser-devel}"
SRC_URI[aarch64_uriparser-devel.sha256sum] = "0668528e2278f03c945a5e96d8d8d8d7e0a1c00225c80c3274ac289660bc9704"

URI_aarch64_uriparser-doc = "${EPEL_MIRROR}/aarch64/Packages/u/uriparser-doc-1.0.2-1.el10_3.noarch.rpm;name=aarch64_uriparser-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_uriparser-doc}"
SRC_URI[aarch64_uriparser-doc.sha256sum] = "cb60db19a48212bc32ace86a9fed7ede7cb42190b9f716d9dc903a657952e0ba"

RDEPENDS:mingw32-uriparser = " \
 mingw32-crt \
 mingw32-filesystem \
 "
RDEPENDS:mingw64-uriparser = " \
 mingw64-crt \
 mingw64-filesystem \
 "
RDEPENDS:uriparser = " \
 glibc \
 "
RDEPENDS:uriparser-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 uriparser \
 "
RDEPENDS:uriparser-doc = " \
 "
