# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kiwi-stackbuild-plugin"
PV = "1.0.14"
PR = "1.el10_3"
PACKAGES = " \
 kiwi-stackbuild-plugin \
 python3-kiwi-stackbuild-plugin \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kiwi-stackbuild-plugin-1.0.14-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "81c4a8d04f0ae789c25ff9e75fe0f707ad6efd3a6653e0bbc32f77d9680c9c0f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-stackbuild-plugin-1.0.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kiwi-stackbuild-plugin;unpack=0"
SRC_URI[x86_64_v2_kiwi-stackbuild-plugin.sha256sum] = "21ea584e504a1f5fdc18bdeddda6778dfb5badbbc9c0b3f52c98ad76bd018996"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kiwi-stackbuild-plugin-1.0.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-kiwi-stackbuild-plugin;unpack=0"
SRC_URI[x86_64_v2_python3-kiwi-stackbuild-plugin.sha256sum] = "6b576d6233df9d6187f74da599e042394356cf5753184a4831c8467c511a7a36"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-stackbuild-plugin-1.0.14-1.el10_3.noarch.rpm;name=aarch64_kiwi-stackbuild-plugin;unpack=0"
SRC_URI[aarch64_kiwi-stackbuild-plugin.sha256sum] = "265b6eeeea2b57d214f803dd327d7bb2fbb48b0a9d7596b4eb6c7418acfccc3d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-kiwi-stackbuild-plugin-1.0.14-1.el10_3.noarch.rpm;name=aarch64_python3-kiwi-stackbuild-plugin;unpack=0"
SRC_URI[aarch64_python3-kiwi-stackbuild-plugin.sha256sum] = "51af42e3cbc8ec6b707dbb9051d661b420d1afbe2cb5d8d571b8e6eb4aa47ca4"

RDEPENDS:kiwi-stackbuild-plugin = " \
 python3-kiwi-stackbuild-plugin \
 "
RDEPENDS:python3-kiwi-stackbuild-plugin = " \
 kiwi-systemdeps-containers \
 python3 \
 python3-docopt-ng \
 python3-kiwi \
 "
