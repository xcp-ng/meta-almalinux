# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-snap"
PV = "1.1.1"
PR = "4.el10_0"
PACKAGES = " \
 rust-snap+default-devel \
 rust-snap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-snap-1.1.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "70aacfcb7c4746cde88078adca119811f8f9baf2158f186e998c2810d4a26e02"

URI_x86_64_v2_rust-snap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snap+default-devel-1.1.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snap+default-devel}"
SRC_URI[x86_64_v2_rust-snap+default-devel.sha256sum] = "5bc1369b935e9126a7a8835030f8fff39667ac707d38d51238a47ad6cd104e1c"

URI_x86_64_v2_rust-snap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snap-devel-1.1.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snap-devel}"
SRC_URI[x86_64_v2_rust-snap-devel.sha256sum] = "7b0565a36a834aeb691b13ada546afc9170077dfd8ca98294d15f4806a259ad9"

URI_aarch64_rust-snap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snap+default-devel-1.1.1-4.el10_0.noarch.rpm;name=aarch64_rust-snap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snap+default-devel}"
SRC_URI[aarch64_rust-snap+default-devel.sha256sum] = "a7d62efe4a149f0dc611817d42afacb30319dd41d7dbc4fb5f9da7132b3fbd31"

URI_aarch64_rust-snap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snap-devel-1.1.1-4.el10_0.noarch.rpm;name=aarch64_rust-snap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snap-devel}"
SRC_URI[aarch64_rust-snap-devel.sha256sum] = "6d7483d1e8cadd551bd163f941ceaacda6dcfab8793bd3ab5a551a7f4a334360"

RDEPENDS:rust-snap+default-devel = " \
 cargo \
 rust-snap-devel \
 "
RDEPENDS:rust-snap-devel = " \
 cargo \
 "
