# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_core"
PV = "0.9.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-rand_core+default-devel \
 rust-rand_core+os_rng-devel \
 rust-rand_core+serde-devel \
 rust-rand_core+std-devel \
 rust-rand_core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_core-0.9.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28557db49acfa889e1f2c6e15689749a29dd4001d0aa83bed8c4812cc6f5c14b"

URI_x86_64_v2_rust-rand_core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_core+default-devel-0.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_core+default-devel}"
SRC_URI[x86_64_v2_rust-rand_core+default-devel.sha256sum] = "9b9525d4a0fc2c4e36cc4945520fb738b9534b21c7153aeff28c8f122af72be9"

URI_x86_64_v2_rust-rand_core+os_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_core+os_rng-devel-0.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_core+os_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_core+os_rng-devel}"
SRC_URI[x86_64_v2_rust-rand_core+os_rng-devel.sha256sum] = "cded601b1c5e6dfd14f2501c52e2d12183b326ea7370346213ef709e0545ee87"

URI_x86_64_v2_rust-rand_core+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_core+serde-devel-0.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_core+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_core+serde-devel}"
SRC_URI[x86_64_v2_rust-rand_core+serde-devel.sha256sum] = "293838225ac78bd9dcdf2ee53044593e06a85ae57dcf5ef278a58cabec0ec4f0"

URI_x86_64_v2_rust-rand_core+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_core+std-devel-0.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_core+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_core+std-devel}"
SRC_URI[x86_64_v2_rust-rand_core+std-devel.sha256sum] = "26dc80affbb7a991b43a87aa0550c13ee1bff5320b7d3ad8b6d68a396e0bd80d"

URI_x86_64_v2_rust-rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_core-devel-0.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_core-devel}"
SRC_URI[x86_64_v2_rust-rand_core-devel.sha256sum] = "11a54653c00e84ecd8c30814edef56a3cdb27be2ba8f7b309e736d3d6eee7bcc"

URI_aarch64_rust-rand_core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_core+default-devel-0.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-rand_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_core+default-devel}"
SRC_URI[aarch64_rust-rand_core+default-devel.sha256sum] = "82545fe89d9b149f97972f8231479ecdbccf498f9562dde85d8f178f53978196"

URI_aarch64_rust-rand_core+os_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_core+os_rng-devel-0.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-rand_core+os_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_core+os_rng-devel}"
SRC_URI[aarch64_rust-rand_core+os_rng-devel.sha256sum] = "3896bcf020f20c9bc30179fa6f36dc4407ed76478718c6701ae9e7af64fc16f8"

URI_aarch64_rust-rand_core+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_core+serde-devel-0.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-rand_core+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_core+serde-devel}"
SRC_URI[aarch64_rust-rand_core+serde-devel.sha256sum] = "802480f0e0aacf62d8b752dffb3c4a2891e8fd577a3413e6f38ca991b821cec4"

URI_aarch64_rust-rand_core+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_core+std-devel-0.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-rand_core+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_core+std-devel}"
SRC_URI[aarch64_rust-rand_core+std-devel.sha256sum] = "488ed2692e0df879a655087008a3c7f3f3f96971b2c84d2ae43576ec973cd20e"

URI_aarch64_rust-rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_core-devel-0.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_core-devel}"
SRC_URI[aarch64_rust-rand_core-devel.sha256sum] = "8ac6bc160e21b530ce79c713138484e893efbf35e1507f9bb565c0322d1bc341"

RDEPENDS:rust-rand_core+default-devel = " \
 cargo \
 rust-rand_core-devel \
 "
RDEPENDS:rust-rand_core+os_rng-devel = " \
 cargo \
 rust-getrandom+default-devel \
 rust-rand_core-devel \
 "
RDEPENDS:rust-rand_core+serde-devel = " \
 cargo \
 rust-rand_core-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand_core+std-devel = " \
 cargo \
 rust-getrandom+default-devel \
 rust-getrandom+std-devel \
 rust-rand_core-devel \
 "
RDEPENDS:rust-rand_core-devel = " \
 cargo \
 rust \
 "
