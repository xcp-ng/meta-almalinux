# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Authen-Radius"
PV = "0.32"
PR = "8.el10_0"
PACKAGES = " \
 perl-Authen-Radius \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Authen-Radius-0.32-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b4230b446dabaffee29cc15ded0e88d3aba944efaf5046791ad87e05a6bfa746"

URI_x86_64_v2_perl-Authen-Radius = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Authen-Radius-0.32-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Authen-Radius;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Authen-Radius}"
SRC_URI[x86_64_v2_perl-Authen-Radius.sha256sum] = "656318e2833f389e32d392a2c9c3a33b2fed13812d71f616308d7ba027f97ae5"

URI_aarch64_perl-Authen-Radius = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Authen-Radius-0.32-8.el10_0.noarch.rpm;name=aarch64_perl-Authen-Radius;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Authen-Radius}"
SRC_URI[aarch64_perl-Authen-Radius.sha256sum] = "ae003bc83a5fcedf887886981cb8ee5897f76281acb5ae930e469ba525875f63"

RDEPENDS:perl-Authen-Radius = " \
 perl-Data-Dumper \
 perl-Data-HexDump \
 perl-Digest-MD5 \
 perl-Exporter \
 perl-FileHandle \
 perl-IO \
 perl-Net-IP \
 perl-Time-HiRes \
 perl-constant \
 perl-libs \
 perl-vars \
 "
