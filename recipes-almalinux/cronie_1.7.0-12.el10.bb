# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cronie"
PV = "1.7.0"
PR = "12.el10"
PACKAGES = " \
 cronie \
 cronie-anacron \
 cronie-noanacron \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/cronie-1.7.0-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "efd80ea5ac6b1ce6aa6e080125adf7193c140a9647a9e4e698e0dbfebe7ab117"

URI_x86_64_v2_cronie = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cronie-1.7.0-12.el10.x86_64_v2.rpm;name=x86_64_v2_cronie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cronie}"
SRC_URI[x86_64_v2_cronie.sha256sum] = "c0d1ccc01f20e9945d04fb837363195cc729826aabab7d6a565a6884fe98b9a4"

URI_x86_64_v2_cronie-anacron = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cronie-anacron-1.7.0-12.el10.x86_64_v2.rpm;name=x86_64_v2_cronie-anacron;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cronie-anacron}"
SRC_URI[x86_64_v2_cronie-anacron.sha256sum] = "7e78d80518ab502b3ec369b473320477b8017b19deccfa650e83e1d4a020f778"
RPROVIDES:cronie-anacron:x86_64_v2 = "virtual/dailyjobs"

URI_x86_64_v2_cronie-noanacron = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cronie-noanacron-1.7.0-12.el10.x86_64_v2.rpm;name=x86_64_v2_cronie-noanacron;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cronie-noanacron}"
SRC_URI[x86_64_v2_cronie-noanacron.sha256sum] = "2084c66b3d62458538237b0f025099120944a615c5e3c5fe5010181709838dc5"
RPROVIDES:cronie-noanacron:x86_64_v2 = "virtual/dailyjobs"

URI_aarch64_cronie = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cronie-1.7.0-12.el10.aarch64.rpm;name=aarch64_cronie;unpack=0"
SRC_URI:append = " ${URI_aarch64_cronie}"
SRC_URI[aarch64_cronie.sha256sum] = "2dd67aee5bfcab59284b1a803cf6388a63abb60f50c0752c63a53bb92bad8bfc"

URI_aarch64_cronie-anacron = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cronie-anacron-1.7.0-12.el10.aarch64.rpm;name=aarch64_cronie-anacron;unpack=0"
SRC_URI:append = " ${URI_aarch64_cronie-anacron}"
SRC_URI[aarch64_cronie-anacron.sha256sum] = "60e9b5561a9cd2fabf876d16fed4463559bf27ff0326514608f773760fd3fc94"
RPROVIDES:cronie-anacron:aarch64 = "virtual/dailyjobs"

URI_aarch64_cronie-noanacron = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cronie-noanacron-1.7.0-12.el10.aarch64.rpm;name=aarch64_cronie-noanacron;unpack=0"
SRC_URI:append = " ${URI_aarch64_cronie-noanacron}"
SRC_URI[aarch64_cronie-noanacron.sha256sum] = "198f39a0cca5c2d43485be30fcd09a159889c0281249c1cd04c73067161dd4eb"
RPROVIDES:cronie-noanacron:aarch64 = "virtual/dailyjobs"

RDEPENDS:cronie = " \
 audit-libs \
 bash \
 glibc \
 libselinux \
 pam \
 pam-libs \
 sed \
 virtual/coreutils \
 virtual/dailyjobs \
 "
RDEPENDS:cronie-anacron = " \
 bash \
 cronie \
 crontabs \
 glibc \
 virtual/coreutils \
 "
RDEPENDS:cronie-noanacron = " \
 cronie \
 crontabs \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/dailyjobs"

PROVIDES:append:aarch64 = " rpm/virtual/dailyjobs"
