# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pysmb"
PV = "1.2.4"
PR = "14.el10_0"
PACKAGES = " \
 python3-pysmb \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pysmb-1.2.4-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9551efbea9ec770cd7573192ca15c0919c52d5b77c94ff409ac438a0c1de063b"

URI_x86_64_v2_python3-pysmb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pysmb-1.2.4-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pysmb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pysmb}"
SRC_URI[x86_64_v2_python3-pysmb.sha256sum] = "a5af89d5ab26800e830b696fec4eddf50cf1619f2942a60bb7861ec5ddd05435"

URI_aarch64_python3-pysmb = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pysmb-1.2.4-14.el10_0.noarch.rpm;name=aarch64_python3-pysmb;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pysmb}"
SRC_URI[aarch64_python3-pysmb.sha256sum] = "9c25d6872afe24a5634568b5fa132f81b608af8732817eb8526ff396032f5a21"

RDEPENDS:python3-pysmb = " \
 python3 \
 python3-pyasn1 \
 "
