# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-OpenSSL-AES"
PV = "0.23"
PR = "1.el10_1"
PACKAGES = " \
 perl-Crypt-OpenSSL-AES \
 perl-Crypt-OpenSSL-AES-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-OpenSSL-AES-0.23-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "17783d275386e05bc57a0c0936fe2299708fca01b7801486fade44bdbe522431"

URI_x86_64_v2_perl-Crypt-OpenSSL-AES = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-OpenSSL-AES-0.23-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Crypt-OpenSSL-AES;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-OpenSSL-AES}"
SRC_URI[x86_64_v2_perl-Crypt-OpenSSL-AES.sha256sum] = "612bbd05dfe530a4f9eb9db196955942a5b48f8dc9b9b60196c5da5b7f7ce642"

URI_x86_64_v2_perl-Crypt-OpenSSL-AES-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-OpenSSL-AES-tests-0.23-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Crypt-OpenSSL-AES-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-OpenSSL-AES-tests}"
SRC_URI[x86_64_v2_perl-Crypt-OpenSSL-AES-tests.sha256sum] = "e6613cddc12409baa76e2b72f24db77ac510fcad80be1a37408ae14382ce3282"

URI_aarch64_perl-Crypt-OpenSSL-AES = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-OpenSSL-AES-0.23-1.el10_1.aarch64.rpm;name=aarch64_perl-Crypt-OpenSSL-AES;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-OpenSSL-AES}"
SRC_URI[aarch64_perl-Crypt-OpenSSL-AES.sha256sum] = "575775b883c921050766b93a32e7c3b588b6f607f4ef10ff8bdb779d16c22191"

URI_aarch64_perl-Crypt-OpenSSL-AES-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-OpenSSL-AES-tests-0.23-1.el10_1.noarch.rpm;name=aarch64_perl-Crypt-OpenSSL-AES-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-OpenSSL-AES-tests}"
SRC_URI[aarch64_perl-Crypt-OpenSSL-AES-tests.sha256sum] = "4a8b2a81ed475081dc7bec18acd363d6c8581ac04f2d1f1b54b8d6d9d8c402b6"

RDEPENDS:perl-Crypt-OpenSSL-AES = " \
 glibc \
 openssl-libs \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Crypt-OpenSSL-AES-tests = " \
 bash \
 openssl \
 perl-Crypt-OpenSSL-AES \
 perl-Crypt-OpenSSL-Guess \
 perl-Crypt-URandom \
 perl-Digest-SHA \
 perl-MIME-Base64 \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
