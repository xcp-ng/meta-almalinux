# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-shell-extension-dash-to-panel"
PV = "65"
PR = "1.el10"
PACKAGES = " \
 gnome-shell-extension-dash-to-panel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-shell-extension-dash-to-panel-65-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f5319aa96eb69444b3c7a3552c3e3af4dc4d4134c928b4149b0183602b5f108"

URI_x86_64_v2_gnome-shell-extension-dash-to-panel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-dash-to-panel-65-1.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-dash-to-panel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-dash-to-panel}"
SRC_URI[x86_64_v2_gnome-shell-extension-dash-to-panel.sha256sum] = "4add494302f40ccbb657e03e9d3f7ac123c1e7778c09555cc813fa1a869b52f5"

URI_aarch64_gnome-shell-extension-dash-to-panel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-dash-to-panel-65-1.el10.noarch.rpm;name=aarch64_gnome-shell-extension-dash-to-panel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-dash-to-panel}"
SRC_URI[aarch64_gnome-shell-extension-dash-to-panel.sha256sum] = "4add494302f40ccbb657e03e9d3f7ac123c1e7778c09555cc813fa1a869b52f5"

RDEPENDS:gnome-shell-extension-dash-to-panel = " \
 gnome-shell \
 "
