# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_plurals_data"
PV = "2.2.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-icu_plurals_data+default-devel \
 rust-icu_plurals_data-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_plurals_data-2.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09883e4e23dc3db86e38e644db38923ba7f9c57e4d2c068a013408b59aac4d70"

URI_x86_64_v2_rust-icu_plurals_data+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_plurals_data+default-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_plurals_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_plurals_data+default-devel}"
SRC_URI[x86_64_v2_rust-icu_plurals_data+default-devel.sha256sum] = "cc332dc8fd8d18aaca8395db3bd182b2758628c0806ababab1f6f985a925efda"

URI_x86_64_v2_rust-icu_plurals_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_plurals_data-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_plurals_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_plurals_data-devel}"
SRC_URI[x86_64_v2_rust-icu_plurals_data-devel.sha256sum] = "2c493634f2ff372e0589bd0a728acfcf9c09c6f525138c0436868ca8010b9101"

URI_aarch64_rust-icu_plurals_data+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_plurals_data+default-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_plurals_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_plurals_data+default-devel}"
SRC_URI[aarch64_rust-icu_plurals_data+default-devel.sha256sum] = "851bce5fd56bfc0ecc64df4c360c962bcbcbcfbb2b511bcc3828412d3f5a8807"

URI_aarch64_rust-icu_plurals_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_plurals_data-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_plurals_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_plurals_data-devel}"
SRC_URI[aarch64_rust-icu_plurals_data-devel.sha256sum] = "2821ed516387dd6459256109d8df512aadce72d2f415362ab874d16de1e42090"

RDEPENDS:rust-icu_plurals_data+default-devel = " \
 cargo \
 rust-icu_plurals_data-devel \
 "
RDEPENDS:rust-icu_plurals_data-devel = " \
 cargo \
 rust \
 "
