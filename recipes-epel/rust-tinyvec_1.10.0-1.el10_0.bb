# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tinyvec"
PV = "1.10.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-tinyvec+alloc-devel \
 rust-tinyvec+arbitrary-devel \
 rust-tinyvec+default-devel \
 rust-tinyvec+experimental_write_impl-devel \
 rust-tinyvec+grab_spare_slice-devel \
 rust-tinyvec+nightly_slice_partition_dedup-devel \
 rust-tinyvec+rustc_1_40-devel \
 rust-tinyvec+rustc_1_55-devel \
 rust-tinyvec+rustc_1_57-devel \
 rust-tinyvec+rustc_1_61-devel \
 rust-tinyvec+serde-devel \
 rust-tinyvec+std-devel \
 rust-tinyvec+tinyvec_macros-devel \
 rust-tinyvec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tinyvec-1.10.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a5f3a6c798544f5beefc2a943d8e36c061da186210b6ec3fe4487aab33a9751"

URI_x86_64_v2_rust-tinyvec+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+alloc-devel-1.10.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+alloc-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+alloc-devel.sha256sum] = "d96ba7beb24c47f5466d245fcbe6d63dce57a5bf7f6179e9ea7e9f69429bd4c4"

URI_x86_64_v2_rust-tinyvec+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+arbitrary-devel-1.10.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+arbitrary-devel.sha256sum] = "722d451b5d665d7bbedd29036dbd8d1eeb4a561d286107589e4319db86d0ebb2"

URI_x86_64_v2_rust-tinyvec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+default-devel-1.10.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+default-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+default-devel.sha256sum] = "b40f4e3e01f1ada32175ead9d2e7b2ffaf7c020e38c7f92eee473f074546844a"

URI_x86_64_v2_rust-tinyvec+experimental_write_impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+experimental_write_impl-devel-1.10.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+experimental_write_impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+experimental_write_impl-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+experimental_write_impl-devel.sha256sum] = "fd9c273d6ef7177a88a034ca8883c9d4ae6777e9c4946321bb866d10001f6f68"

URI_x86_64_v2_rust-tinyvec+grab_spare_slice-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+grab_spare_slice-devel-1.10.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+grab_spare_slice-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+grab_spare_slice-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+grab_spare_slice-devel.sha256sum] = "091cce9c0337d14093c4b7090d7e501558f2de6466c6a4b5a6f1818917464166"

URI_x86_64_v2_rust-tinyvec+nightly_slice_partition_dedup-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+nightly_slice_partition_dedup-devel-1.10.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+nightly_slice_partition_dedup-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+nightly_slice_partition_dedup-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+nightly_slice_partition_dedup-devel.sha256sum] = "db3b38850f1a36cdc77681571585bd6f9feffa922c7845568f5af29696e55472"

URI_x86_64_v2_rust-tinyvec+rustc_1_40-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+rustc_1_40-devel-1.10.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+rustc_1_40-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+rustc_1_40-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+rustc_1_40-devel.sha256sum] = "57565b80a6dc4e7c6c6e7edaaadd7bd47ecd1fab4bb67c1400340a6ea75eebe8"

URI_x86_64_v2_rust-tinyvec+rustc_1_55-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+rustc_1_55-devel-1.10.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+rustc_1_55-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+rustc_1_55-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+rustc_1_55-devel.sha256sum] = "3ead9f13758b699ff07704e9d84abc2c524f9e7729d9dedc49dadde9cc1ab693"

URI_x86_64_v2_rust-tinyvec+rustc_1_57-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+rustc_1_57-devel-1.10.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+rustc_1_57-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+rustc_1_57-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+rustc_1_57-devel.sha256sum] = "8169873a4915efde245a7d8f16cc1bf173de79627f4d9afde676cb979d738b9a"

URI_x86_64_v2_rust-tinyvec+rustc_1_61-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+rustc_1_61-devel-1.10.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+rustc_1_61-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+rustc_1_61-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+rustc_1_61-devel.sha256sum] = "416aaf50abfcf60237ea557ebd4a38935c73924bbc7521f6accb2b9b9bddc7bb"

URI_x86_64_v2_rust-tinyvec+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+serde-devel-1.10.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+serde-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+serde-devel.sha256sum] = "34b232e60eb4ba43bf73bdf591cf1f8473360ab16921bf1ce0da8fdf66758b9e"

URI_x86_64_v2_rust-tinyvec+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+std-devel-1.10.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+std-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+std-devel.sha256sum] = "04783a71bdaae14e680d4b8755d90a99fb6787c04e477170b7536021b8aa3871"

URI_x86_64_v2_rust-tinyvec+tinyvec_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+tinyvec_macros-devel-1.10.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+tinyvec_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+tinyvec_macros-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+tinyvec_macros-devel.sha256sum] = "9d2fb2c57a7829bc7ace44f92d74977936f375bc01b195e03677e98aa70e68d6"

URI_x86_64_v2_rust-tinyvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec-devel-1.10.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec-devel}"
SRC_URI[x86_64_v2_rust-tinyvec-devel.sha256sum] = "090b5ac59c17e5eab88157cd0a758508004848b63798cd6419c53bedbbaa8af1"

URI_aarch64_rust-tinyvec+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+alloc-devel-1.10.0-1.el10_0.noarch.rpm;name=aarch64_rust-tinyvec+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+alloc-devel}"
SRC_URI[aarch64_rust-tinyvec+alloc-devel.sha256sum] = "6d22596ed0fa866ccef8712aaba751d1d0b70e2670bc3759c18076a6d4629f6c"

URI_aarch64_rust-tinyvec+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+arbitrary-devel-1.10.0-1.el10_0.noarch.rpm;name=aarch64_rust-tinyvec+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+arbitrary-devel}"
SRC_URI[aarch64_rust-tinyvec+arbitrary-devel.sha256sum] = "2927bd88081fd7ddfa3d143a79c2dc6b6c7f69e6ff6011dcab957d69c66fa4fc"

URI_aarch64_rust-tinyvec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+default-devel-1.10.0-1.el10_0.noarch.rpm;name=aarch64_rust-tinyvec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+default-devel}"
SRC_URI[aarch64_rust-tinyvec+default-devel.sha256sum] = "650ed8c4bce485d30fec42a6bebb09e22d27e7c8beea38552af0afe2da4f070f"

URI_aarch64_rust-tinyvec+experimental_write_impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+experimental_write_impl-devel-1.10.0-1.el10_0.noarch.rpm;name=aarch64_rust-tinyvec+experimental_write_impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+experimental_write_impl-devel}"
SRC_URI[aarch64_rust-tinyvec+experimental_write_impl-devel.sha256sum] = "0fce754dcd489d077b331393d0d367d3ca1c6291e6f0f3a1b72d0629387d2b53"

URI_aarch64_rust-tinyvec+grab_spare_slice-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+grab_spare_slice-devel-1.10.0-1.el10_0.noarch.rpm;name=aarch64_rust-tinyvec+grab_spare_slice-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+grab_spare_slice-devel}"
SRC_URI[aarch64_rust-tinyvec+grab_spare_slice-devel.sha256sum] = "9a0a2244a6ee8d52c03dd8c9fcde92443edcfd4781f3c0c537681c21541d8d01"

URI_aarch64_rust-tinyvec+nightly_slice_partition_dedup-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+nightly_slice_partition_dedup-devel-1.10.0-1.el10_0.noarch.rpm;name=aarch64_rust-tinyvec+nightly_slice_partition_dedup-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+nightly_slice_partition_dedup-devel}"
SRC_URI[aarch64_rust-tinyvec+nightly_slice_partition_dedup-devel.sha256sum] = "d43707d2ceec88cc67147af9350d143a7af47dc80575a4cf4f4140a9341f3a2a"

URI_aarch64_rust-tinyvec+rustc_1_40-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+rustc_1_40-devel-1.10.0-1.el10_0.noarch.rpm;name=aarch64_rust-tinyvec+rustc_1_40-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+rustc_1_40-devel}"
SRC_URI[aarch64_rust-tinyvec+rustc_1_40-devel.sha256sum] = "ec6508c27d9ebfb5ca4b14f57254dac46d1a823ffc91f1a11c32356814c160e3"

URI_aarch64_rust-tinyvec+rustc_1_55-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+rustc_1_55-devel-1.10.0-1.el10_0.noarch.rpm;name=aarch64_rust-tinyvec+rustc_1_55-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+rustc_1_55-devel}"
SRC_URI[aarch64_rust-tinyvec+rustc_1_55-devel.sha256sum] = "9cbd17901db68d35fb6377f3d3e2508e85d889e8679efe72c7a529b92e5ffe13"

URI_aarch64_rust-tinyvec+rustc_1_57-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+rustc_1_57-devel-1.10.0-1.el10_0.noarch.rpm;name=aarch64_rust-tinyvec+rustc_1_57-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+rustc_1_57-devel}"
SRC_URI[aarch64_rust-tinyvec+rustc_1_57-devel.sha256sum] = "9a4984b77690629774f3529a2178c43e90cc41dc2820b854784d86d3f2fe8a8e"

URI_aarch64_rust-tinyvec+rustc_1_61-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+rustc_1_61-devel-1.10.0-1.el10_0.noarch.rpm;name=aarch64_rust-tinyvec+rustc_1_61-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+rustc_1_61-devel}"
SRC_URI[aarch64_rust-tinyvec+rustc_1_61-devel.sha256sum] = "bf1d35af39389076b0a70a40282df22457b62a280dc81c9bdf40db71db395946"

URI_aarch64_rust-tinyvec+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+serde-devel-1.10.0-1.el10_0.noarch.rpm;name=aarch64_rust-tinyvec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+serde-devel}"
SRC_URI[aarch64_rust-tinyvec+serde-devel.sha256sum] = "c7290585022158a73ef44faeb77d18b09c98929e9fbb788d3fbf93e903ff266f"

URI_aarch64_rust-tinyvec+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+std-devel-1.10.0-1.el10_0.noarch.rpm;name=aarch64_rust-tinyvec+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+std-devel}"
SRC_URI[aarch64_rust-tinyvec+std-devel.sha256sum] = "288d1b58c4ead330babdea8cd5443c8b2e847eff52618c0a34abee59ee5b964b"

URI_aarch64_rust-tinyvec+tinyvec_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+tinyvec_macros-devel-1.10.0-1.el10_0.noarch.rpm;name=aarch64_rust-tinyvec+tinyvec_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+tinyvec_macros-devel}"
SRC_URI[aarch64_rust-tinyvec+tinyvec_macros-devel.sha256sum] = "54546cf57cdf1e89584032c1924f68b959741441ee717c351478e40fed57a989"

URI_aarch64_rust-tinyvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec-devel-1.10.0-1.el10_0.noarch.rpm;name=aarch64_rust-tinyvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec-devel}"
SRC_URI[aarch64_rust-tinyvec-devel.sha256sum] = "97f0b6d26a4fed427e5a99f58e9b321aac0b847c2e276999a77b750f7bf1ce35"

RDEPENDS:rust-tinyvec+alloc-devel = " \
 cargo \
 rust-tinyvec+tinyvec_macros-devel \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+default-devel = " \
 cargo \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+experimental_write_impl-devel = " \
 cargo \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+grab_spare_slice-devel = " \
 cargo \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+nightly_slice_partition_dedup-devel = " \
 cargo \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+rustc_1_40-devel = " \
 cargo \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+rustc_1_55-devel = " \
 cargo \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+rustc_1_57-devel = " \
 cargo \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+rustc_1_61-devel = " \
 cargo \
 rust-tinyvec+rustc_1_57-devel \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+serde-devel = " \
 cargo \
 rust-serde-devel \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+std-devel = " \
 cargo \
 rust-tinyvec+alloc-devel \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+tinyvec_macros-devel = " \
 cargo \
 rust-tinyvec-devel \
 rust-tinyvec_macros+default-devel \
 "
RDEPENDS:rust-tinyvec-devel = " \
 cargo \
 "
