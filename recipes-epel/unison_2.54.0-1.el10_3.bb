# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "unison"
PV = "2.54.0"
PR = "1.el10_3"
PACKAGES = " \
 unison \
 unison-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/unison-2.54.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "851ebe0064d284d6c1fa260e19000666abd3162f98153e553837f39f860c055b"

URI_x86_64_v2_unison = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/unison-2.54.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_unison;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unison}"
SRC_URI[x86_64_v2_unison.sha256sum] = "5759d3e558a9cba1dc1d884810d94fd783f72c3fefce5ba18328eef523189e88"

URI_x86_64_v2_unison-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/unison-doc-2.54.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_unison-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unison-doc}"
SRC_URI[x86_64_v2_unison-doc.sha256sum] = "07030f5e3ac1adcad86934d118fc6a16cc07cb1d236de6b9745cb20809580baa"

URI_aarch64_unison = "${EPEL_MIRROR}/aarch64/Packages/u/unison-2.54.0-1.el10_3.aarch64.rpm;name=aarch64_unison;unpack=0"
SRC_URI:append = " ${URI_aarch64_unison}"
SRC_URI[aarch64_unison.sha256sum] = "e1191fafd93f34e2dc8a13aae773ec2cb82e3ec5eab65444681e2624058afc5c"

URI_aarch64_unison-doc = "${EPEL_MIRROR}/aarch64/Packages/u/unison-doc-2.54.0-1.el10_3.noarch.rpm;name=aarch64_unison-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_unison-doc}"
SRC_URI[aarch64_unison-doc.sha256sum] = "f68a4b2a35b501626d58b18b27f8452394e21c4663929ee4b143f42a2ac1f9ab"

RDEPENDS:unison = " \
 glibc \
 "
RDEPENDS:unison-doc = " \
 "
