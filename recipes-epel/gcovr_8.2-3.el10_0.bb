# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gcovr"
PV = "8.2"
PR = "3.el10_0"
PACKAGES = " \
 gcovr \
 gcovr-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gcovr-8.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b072dd9f7e1cca8ce38999dc83408788b022407239fcc50a4f40628d6f290591"

URI_x86_64_v2_gcovr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcovr-8.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gcovr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcovr}"
SRC_URI[x86_64_v2_gcovr.sha256sum] = "10ea49373175255f754f22a404c051c1fe8389cb598f6f695fec8972b581af61"

URI_x86_64_v2_gcovr-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcovr-doc-8.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gcovr-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcovr-doc}"
SRC_URI[x86_64_v2_gcovr-doc.sha256sum] = "815d8577959fed919d6023a180aa025f591aacc420e8725816bc94dc66092ec6"

URI_aarch64_gcovr = "${EPEL_MIRROR}/aarch64/Packages/g/gcovr-8.2-3.el10_0.noarch.rpm;name=aarch64_gcovr;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcovr}"
SRC_URI[aarch64_gcovr.sha256sum] = "6292cdf20e6badaf183d51c1bbaf6f6bb56768eda5b80e3862d1ed2f62e59718"

URI_aarch64_gcovr-doc = "${EPEL_MIRROR}/aarch64/Packages/g/gcovr-doc-8.2-3.el10_0.noarch.rpm;name=aarch64_gcovr-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcovr-doc}"
SRC_URI[aarch64_gcovr-doc.sha256sum] = "1c0c577bf3eb2be63e80f1beb802bcafd505054e4dca1ca0985b58f0fe41571c"

RDEPENDS:gcovr = " \
 gcc \
 python3 \
 python3-colorlog \
 python3-jinja2 \
 python3-lxml \
 python3-pygments \
 "
RDEPENDS:gcovr-doc = " \
 "
