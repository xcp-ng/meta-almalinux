# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-CPAN-Requirements-Dynamic"
PV = "0.001"
PR = "3.el10_0"
PACKAGES = " \
 perl-CPAN-Requirements-Dynamic \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-CPAN-Requirements-Dynamic-0.001-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64f23dc5a9f2d26f38fb9e13297a9efb9c8a340829f1694999bc1dd73f7c9161"

URI_x86_64_v2_perl-CPAN-Requirements-Dynamic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-CPAN-Requirements-Dynamic-0.001-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-CPAN-Requirements-Dynamic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-CPAN-Requirements-Dynamic}"
SRC_URI[x86_64_v2_perl-CPAN-Requirements-Dynamic.sha256sum] = "5f78a6d05eee5bc6306d8828b9b6bb8f0f4156c1f0ed6e807efd1c4a9d10780c"

URI_aarch64_perl-CPAN-Requirements-Dynamic = "${EPEL_MIRROR}/aarch64/Packages/p/perl-CPAN-Requirements-Dynamic-0.001-3.el10_0.noarch.rpm;name=aarch64_perl-CPAN-Requirements-Dynamic;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-CPAN-Requirements-Dynamic}"
SRC_URI[aarch64_perl-CPAN-Requirements-Dynamic.sha256sum] = "fe27c94401b5ddb17399b3b29f55e7168037348bc7563c806ac3990dbeb7a825"

RDEPENDS:perl-CPAN-Requirements-Dynamic = " \
 perl-CPAN-Meta \
 perl-CPAN-Meta-Requirements \
 perl-Carp \
 perl-ExtUtils-Config \
 perl-ExtUtils-HasCompiler \
 perl-IPC-Cmd \
 perl-Module-Metadata \
 perl-Perl-OSType \
 perl-libs \
 "
