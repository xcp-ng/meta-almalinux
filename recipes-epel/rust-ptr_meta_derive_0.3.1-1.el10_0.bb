# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ptr_meta_derive"
PV = "0.3.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-ptr_meta_derive+default-devel \
 rust-ptr_meta_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ptr_meta_derive-0.3.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7c55bcf8c6b343257715f8c9740d02e50396d875c8d4ef69864988bc8d1eecd"

URI_x86_64_v2_rust-ptr_meta_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ptr_meta_derive+default-devel-0.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ptr_meta_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ptr_meta_derive+default-devel}"
SRC_URI[x86_64_v2_rust-ptr_meta_derive+default-devel.sha256sum] = "0769f729c7868254f36799f1558d4ff512e33f0ce272dd6b45eb984a2e02524d"

URI_x86_64_v2_rust-ptr_meta_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ptr_meta_derive-devel-0.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ptr_meta_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ptr_meta_derive-devel}"
SRC_URI[x86_64_v2_rust-ptr_meta_derive-devel.sha256sum] = "38a92f9494dc82c2ffa364126899b5e619fce8cf153285459025e1999aeff22e"

URI_aarch64_rust-ptr_meta_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ptr_meta_derive+default-devel-0.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-ptr_meta_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ptr_meta_derive+default-devel}"
SRC_URI[aarch64_rust-ptr_meta_derive+default-devel.sha256sum] = "996d5b075550ffa1359f27aa55b7a80a856ba552b8a6edb9379c3366a99a9e73"

URI_aarch64_rust-ptr_meta_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ptr_meta_derive-devel-0.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-ptr_meta_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ptr_meta_derive-devel}"
SRC_URI[aarch64_rust-ptr_meta_derive-devel.sha256sum] = "70f1097cf583d98ab2a127902d4f1647f02e41acb255beb260cc78af9f816f7c"

RDEPENDS:rust-ptr_meta_derive+default-devel = " \
 cargo \
 rust-ptr_meta_derive-devel \
 "
RDEPENDS:rust-ptr_meta_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+proc-macro-devel \
 rust-proc-macro2-devel \
 rust-quote+proc-macro-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
