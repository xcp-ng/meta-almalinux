# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-copilot-libraries"
PV = "3.19.1"
PR = "2.el10_0"
PACKAGES = " \
 ghc-copilot-libraries \
 ghc-copilot-libraries-devel \
 ghc-copilot-libraries-doc \
 ghc-copilot-libraries-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-copilot-libraries-3.19.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af2bbcca2991bd5a97c8974d2c1ae00c06fcec43e2e9d03ce087f8d1493a7db0"

URI_x86_64_v2_ghc-copilot-libraries = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-copilot-libraries-3.19.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-copilot-libraries;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-copilot-libraries}"
SRC_URI[x86_64_v2_ghc-copilot-libraries.sha256sum] = "dcae2cd51012960456862ea401bb6b5bffd10b5fd2ed15cd9376027496e7cc6b"

URI_x86_64_v2_ghc-copilot-libraries-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-copilot-libraries-devel-3.19.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-copilot-libraries-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-copilot-libraries-devel}"
SRC_URI[x86_64_v2_ghc-copilot-libraries-devel.sha256sum] = "b32c64a1f97c40766a2810391bc9e22525e03291921c8581984a975c071239c8"

URI_x86_64_v2_ghc-copilot-libraries-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-copilot-libraries-doc-3.19.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-copilot-libraries-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-copilot-libraries-doc}"
SRC_URI[x86_64_v2_ghc-copilot-libraries-doc.sha256sum] = "fbc9bf129499ac54130fee571f4f9fea4cf15d2a0552c724d0a144dd73f757e7"

URI_x86_64_v2_ghc-copilot-libraries-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-copilot-libraries-prof-3.19.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-copilot-libraries-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-copilot-libraries-prof}"
SRC_URI[x86_64_v2_ghc-copilot-libraries-prof.sha256sum] = "8daa688870804e65a5309c62855612a7cded9f2cdcff21d41f08df6883f6c5f8"

URI_aarch64_ghc-copilot-libraries = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-copilot-libraries-3.19.1-2.el10_0.aarch64.rpm;name=aarch64_ghc-copilot-libraries;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-copilot-libraries}"
SRC_URI[aarch64_ghc-copilot-libraries.sha256sum] = "ca8ed2a8e2edcf04e886282fbad50eb8375af469c24a38501383fa736eb24e7b"

URI_aarch64_ghc-copilot-libraries-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-copilot-libraries-devel-3.19.1-2.el10_0.aarch64.rpm;name=aarch64_ghc-copilot-libraries-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-copilot-libraries-devel}"
SRC_URI[aarch64_ghc-copilot-libraries-devel.sha256sum] = "cfebe139a05a9c03b448dd2f47b24611a217d234971fc6876f79f62457ce5b95"

URI_aarch64_ghc-copilot-libraries-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-copilot-libraries-doc-3.19.1-2.el10_0.noarch.rpm;name=aarch64_ghc-copilot-libraries-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-copilot-libraries-doc}"
SRC_URI[aarch64_ghc-copilot-libraries-doc.sha256sum] = "8381deb9f25c487bfa309ef9f2c4017f5b042e24f3d9489a0460a5b0d33d62ce"

URI_aarch64_ghc-copilot-libraries-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-copilot-libraries-prof-3.19.1-2.el10_0.aarch64.rpm;name=aarch64_ghc-copilot-libraries-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-copilot-libraries-prof}"
SRC_URI[aarch64_ghc-copilot-libraries-prof.sha256sum] = "2dd4c6c3bf0bb457d90c0a6dd884d038156f3dbce0bf4ea2509c4faa8c0ff70c"

RDEPENDS:ghc-copilot-libraries = " \
 ghc-BoundedChan \
 ghc-OneTuple \
 ghc-StateVar \
 ghc-adjunctions \
 ghc-array \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-orphans \
 ghc-bifunctors \
 ghc-bimap \
 ghc-binary \
 ghc-bitwise \
 ghc-boring \
 ghc-bv-sized \
 ghc-bytestring \
 ghc-call-stack \
 ghc-case-insensitive \
 ghc-comonad \
 ghc-concurrent-extra \
 ghc-config-value \
 ghc-constraints \
 ghc-containers \
 ghc-contravariant \
 ghc-copilot-core \
 ghc-copilot-interpreter \
 ghc-copilot-language \
 ghc-copilot-prettyprinter \
 ghc-copilot-theorem \
 ghc-data-default \
 ghc-data-default-class \
 ghc-data-default-instances-containers \
 ghc-data-default-instances-dlist \
 ghc-data-default-instances-old-locale \
 ghc-data-reify \
 ghc-deepseq \
 ghc-deriving-compat \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-fingertree \
 ghc-free \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-gitrev \
 ghc-hashable \
 ghc-hashtables \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-invariant \
 ghc-io-streams \
 ghc-kan-extensions \
 ghc-lens \
 ghc-libBF \
 ghc-megaparsec \
 ghc-mtl \
 ghc-network \
 ghc-old-locale \
 ghc-ordered-containers \
 ghc-os-string \
 ghc-panic \
 ghc-parallel \
 ghc-parameterized-utils \
 ghc-parsec \
 ghc-parser-combinators \
 ghc-pretty \
 ghc-prettyprinter \
 ghc-primitive \
 ghc-process \
 ghc-profunctors \
 ghc-random \
 ghc-reflection \
 ghc-s-cargot \
 ghc-safe-exceptions \
 ghc-scientific \
 ghc-semigroupoids \
 ghc-semigroups \
 ghc-splitmix \
 ghc-stm \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-temporary \
 ghc-text \
 ghc-th-abstraction \
 ghc-th-lift \
 ghc-th-lift-instances \
 ghc-these \
 ghc-time \
 ghc-transformers \
 ghc-transformers-base \
 ghc-transformers-compat \
 ghc-unbounded-delays \
 ghc-unix \
 ghc-unliftio \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-utf8-string \
 ghc-vector \
 ghc-vector-stream \
 ghc-versions \
 ghc-void \
 ghc-what4 \
 ghc-xml \
 ghc-zenc \
 ghc-zlib \
 ghc-zlib-bindings \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-copilot-libraries-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-copilot-language-devel \
 ghc-copilot-libraries \
 ghc-mtl-devel \
 ghc-parsec-devel \
 "
RDEPENDS:ghc-copilot-libraries-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-copilot-libraries-prof = " \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-copilot-language-prof \
 ghc-copilot-libraries-devel \
 ghc-mtl-prof \
 ghc-parsec-prof \
 "
