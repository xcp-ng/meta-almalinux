# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dav1d-sys"
PV = "0.8.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-dav1d-sys+default-devel \
 rust-dav1d-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dav1d-sys-0.8.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f702a76a1b64d96a6b4f800c7d9c7a5533c6599e194c54af418b03e614c732db"

URI_x86_64_v2_rust-dav1d-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dav1d-sys+default-devel-0.8.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dav1d-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dav1d-sys+default-devel}"
SRC_URI[x86_64_v2_rust-dav1d-sys+default-devel.sha256sum] = "317085032e13d4e7d874bb05125c376a043ed3e4a15cfe13e042db943247996f"

URI_x86_64_v2_rust-dav1d-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dav1d-sys-devel-0.8.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dav1d-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dav1d-sys-devel}"
SRC_URI[x86_64_v2_rust-dav1d-sys-devel.sha256sum] = "2e82f2ecb34e329b8acbc33332f9cb104ec7139b3299a68f1d79fcd21a91aca8"

URI_aarch64_rust-dav1d-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dav1d-sys+default-devel-0.8.3-1.el10_1.noarch.rpm;name=aarch64_rust-dav1d-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dav1d-sys+default-devel}"
SRC_URI[aarch64_rust-dav1d-sys+default-devel.sha256sum] = "087d2fca42c8d904999d22077f4f7c8f025c218c13db2af34a35beeb6d969187"

URI_aarch64_rust-dav1d-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dav1d-sys-devel-0.8.3-1.el10_1.noarch.rpm;name=aarch64_rust-dav1d-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dav1d-sys-devel}"
SRC_URI[aarch64_rust-dav1d-sys-devel.sha256sum] = "c8ed5a2009035992d59d243699578b36ef1aab878326e36f74dca43ab1a6fd95"

RDEPENDS:rust-dav1d-sys+default-devel = " \
 cargo \
 rust-dav1d-sys-devel \
 "
RDEPENDS:rust-dav1d-sys-devel = " \
 cargo \
 libdav1d-devel \
 rust \
 rust-libc+default-devel \
 rust-system-deps+default-devel \
 "
