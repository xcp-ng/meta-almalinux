# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-indexmap1"
PV = "1.9.3"
PR = "4.el10_0"
PACKAGES = " \
 rust-indexmap1+arbitrary-devel \
 rust-indexmap1+default-devel \
 rust-indexmap1+quickcheck-devel \
 rust-indexmap1+rayon-devel \
 rust-indexmap1+serde-1-devel \
 rust-indexmap1+serde-devel \
 rust-indexmap1+std-devel \
 rust-indexmap1+test_debug-devel \
 rust-indexmap1+test_low_transition_point-devel \
 rust-indexmap1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-indexmap1-1.9.3-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a379f5f97d48981f13fa4a1deafa312e694da2e6d144098d894f9540b12368a"

URI_x86_64_v2_rust-indexmap1+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap1+arbitrary-devel-1.9.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap1+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap1+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-indexmap1+arbitrary-devel.sha256sum] = "6e83883de4ead8879ea26c4d684e16331fa03798a0780a3523a241eb85cdfc9c"

URI_x86_64_v2_rust-indexmap1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap1+default-devel-1.9.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap1+default-devel}"
SRC_URI[x86_64_v2_rust-indexmap1+default-devel.sha256sum] = "2bf33bebf8d4b21f9c48214971cc81c16b1a7f0001df6326581e533571c108d5"
RPROVIDES:rust-indexmap1+default-devel:x86_64_v2 = "virtual/crate_indexmap/default__ge_1.6.0_with_crate_indexmap/default__lt_3.0.0~"

URI_x86_64_v2_rust-indexmap1+quickcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap1+quickcheck-devel-1.9.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap1+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap1+quickcheck-devel}"
SRC_URI[x86_64_v2_rust-indexmap1+quickcheck-devel.sha256sum] = "2e4171d1461f7ff8a8685b9a57cf776b2aecedef797de8fc5a7e931a544afe73"

URI_x86_64_v2_rust-indexmap1+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap1+rayon-devel-1.9.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap1+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap1+rayon-devel}"
SRC_URI[x86_64_v2_rust-indexmap1+rayon-devel.sha256sum] = "d1cb8fce1c0e5731b4c03c37717c00418c87f515442e9d5e2ae3e24f1b0dabb7"

URI_x86_64_v2_rust-indexmap1+serde-1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap1+serde-1-devel-1.9.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap1+serde-1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap1+serde-1-devel}"
SRC_URI[x86_64_v2_rust-indexmap1+serde-1-devel.sha256sum] = "27378bc325a0eeeaa2cafb3e984e9319d6637bf93235428d4a02a338513a7395"

URI_x86_64_v2_rust-indexmap1+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap1+serde-devel-1.9.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap1+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap1+serde-devel}"
SRC_URI[x86_64_v2_rust-indexmap1+serde-devel.sha256sum] = "579b951edd4348841098189da1a9809e08691c0aad758ec2fa788a9061866254"

URI_x86_64_v2_rust-indexmap1+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap1+std-devel-1.9.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap1+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap1+std-devel}"
SRC_URI[x86_64_v2_rust-indexmap1+std-devel.sha256sum] = "5e7ebf1b9e455f72d90a81070dc85588cd12522ab8af587ed2f1ea16dd00f0fe"

URI_x86_64_v2_rust-indexmap1+test_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap1+test_debug-devel-1.9.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap1+test_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap1+test_debug-devel}"
SRC_URI[x86_64_v2_rust-indexmap1+test_debug-devel.sha256sum] = "1e5b326340a091f669f0757d0f67ac39b4a684ded7110148871aa52439217c7b"

URI_x86_64_v2_rust-indexmap1+test_low_transition_point-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap1+test_low_transition_point-devel-1.9.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap1+test_low_transition_point-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap1+test_low_transition_point-devel}"
SRC_URI[x86_64_v2_rust-indexmap1+test_low_transition_point-devel.sha256sum] = "78da50919c78ee0d89af6d468babc1c3e2bf7ae7b7f069ee83898c6f5986366e"

URI_x86_64_v2_rust-indexmap1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap1-devel-1.9.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap1-devel}"
SRC_URI[x86_64_v2_rust-indexmap1-devel.sha256sum] = "e64d96e54ab0d195d34975ac5fda6e6fb74594ac3393d39db2f75280aec35899"

URI_aarch64_rust-indexmap1+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap1+arbitrary-devel-1.9.3-4.el10_0.noarch.rpm;name=aarch64_rust-indexmap1+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap1+arbitrary-devel}"
SRC_URI[aarch64_rust-indexmap1+arbitrary-devel.sha256sum] = "7984254bb9c6f11c93ae5e53b92922918b1e6ccc2b80e5487cfe7c30bd903c92"

URI_aarch64_rust-indexmap1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap1+default-devel-1.9.3-4.el10_0.noarch.rpm;name=aarch64_rust-indexmap1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap1+default-devel}"
SRC_URI[aarch64_rust-indexmap1+default-devel.sha256sum] = "1655bcf78c1954c474997e9134ab3a66706505f80b7afd350290ea7344b0d735"
RPROVIDES:rust-indexmap1+default-devel:aarch64 = "virtual/crate_indexmap/default__ge_1.6.0_with_crate_indexmap/default__lt_3.0.0~"

URI_aarch64_rust-indexmap1+quickcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap1+quickcheck-devel-1.9.3-4.el10_0.noarch.rpm;name=aarch64_rust-indexmap1+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap1+quickcheck-devel}"
SRC_URI[aarch64_rust-indexmap1+quickcheck-devel.sha256sum] = "3b7c02889273199937c333f771157c5d647cf308d3f91f88057c773fb35352c5"

URI_aarch64_rust-indexmap1+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap1+rayon-devel-1.9.3-4.el10_0.noarch.rpm;name=aarch64_rust-indexmap1+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap1+rayon-devel}"
SRC_URI[aarch64_rust-indexmap1+rayon-devel.sha256sum] = "8676f761871ef5f1766233f0ff3ca730105b82a0c6ca6003d708c263519f00ef"

URI_aarch64_rust-indexmap1+serde-1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap1+serde-1-devel-1.9.3-4.el10_0.noarch.rpm;name=aarch64_rust-indexmap1+serde-1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap1+serde-1-devel}"
SRC_URI[aarch64_rust-indexmap1+serde-1-devel.sha256sum] = "0d9c9af30082db5953308091af95463a32af59fcfabba4a12efc3f5f7179b572"

URI_aarch64_rust-indexmap1+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap1+serde-devel-1.9.3-4.el10_0.noarch.rpm;name=aarch64_rust-indexmap1+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap1+serde-devel}"
SRC_URI[aarch64_rust-indexmap1+serde-devel.sha256sum] = "505a8c47508b9433fc87fd8752fb1f992c21477c02ca8d7ddd2e92df80ab2fa5"

URI_aarch64_rust-indexmap1+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap1+std-devel-1.9.3-4.el10_0.noarch.rpm;name=aarch64_rust-indexmap1+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap1+std-devel}"
SRC_URI[aarch64_rust-indexmap1+std-devel.sha256sum] = "aad9006b9d52d7300e85e451b01001c12970bf99b00d9c2e2bf266e688abac3f"

URI_aarch64_rust-indexmap1+test_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap1+test_debug-devel-1.9.3-4.el10_0.noarch.rpm;name=aarch64_rust-indexmap1+test_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap1+test_debug-devel}"
SRC_URI[aarch64_rust-indexmap1+test_debug-devel.sha256sum] = "92a584278d222a33b895731987118db077dad028da4efa216526e32b31519a45"

URI_aarch64_rust-indexmap1+test_low_transition_point-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap1+test_low_transition_point-devel-1.9.3-4.el10_0.noarch.rpm;name=aarch64_rust-indexmap1+test_low_transition_point-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap1+test_low_transition_point-devel}"
SRC_URI[aarch64_rust-indexmap1+test_low_transition_point-devel.sha256sum] = "a4788d55067827b222ca639a057ab09e415230e3b34257cef46466a5ae756fff"

URI_aarch64_rust-indexmap1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap1-devel-1.9.3-4.el10_0.noarch.rpm;name=aarch64_rust-indexmap1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap1-devel}"
SRC_URI[aarch64_rust-indexmap1-devel.sha256sum] = "325c4f7077d94adb97e91a9ccf907a997b36195aa092c37f18989ea3b4f47a77"

RDEPENDS:rust-indexmap1+arbitrary-devel = " \
 cargo \
 rust-arbitrary-devel \
 rust-indexmap1-devel \
 "
RDEPENDS:rust-indexmap1+default-devel = " \
 cargo \
 rust-indexmap1-devel \
 "
RDEPENDS:rust-indexmap1+quickcheck-devel = " \
 cargo \
 rust-indexmap1-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-indexmap1+rayon-devel = " \
 cargo \
 rust-indexmap1-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-indexmap1+serde-1-devel = " \
 cargo \
 rust-indexmap1+serde-devel \
 rust-indexmap1-devel \
 "
RDEPENDS:rust-indexmap1+serde-devel = " \
 cargo \
 rust-indexmap1-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-indexmap1+std-devel = " \
 cargo \
 rust-indexmap1-devel \
 "
RDEPENDS:rust-indexmap1+test_debug-devel = " \
 cargo \
 rust-indexmap1-devel \
 "
RDEPENDS:rust-indexmap1+test_low_transition_point-devel = " \
 cargo \
 rust-indexmap1-devel \
 "
RDEPENDS:rust-indexmap1-devel = " \
 cargo \
 rust \
 rust-autocfg+default-devel \
 rust-hashbrown0.12+raw-devel \
 rust-hashbrown0.12-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_indexmap/default__ge_1.6.0_with_crate_indexmap/default__lt_3.0.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_indexmap/default__ge_1.6.0_with_crate_indexmap/default__lt_3.0.0~"
