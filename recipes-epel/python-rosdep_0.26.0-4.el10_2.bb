# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rosdep"
PV = "0.26.0"
PR = "4.el10_2"
PACKAGES = " \
 python-rosdep-doc \
 python3-rosdep \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-rosdep-0.26.0-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "026394ce7b449ca09bb7eb87b4b93a7fb29082eb06ef119939271f32c0e13e77"

URI_x86_64_v2_python-rosdep-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-rosdep-doc-0.26.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-rosdep-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-rosdep-doc}"
SRC_URI[x86_64_v2_python-rosdep-doc.sha256sum] = "33682ba6f8931bee8f76d7664373ee79000170fabfe9aec387089b7216b02e31"

URI_x86_64_v2_python3-rosdep = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rosdep-0.26.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rosdep;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rosdep}"
SRC_URI[x86_64_v2_python3-rosdep.sha256sum] = "202499cb49e52c0fe7b1e502287f80dd550f73ecf79adcd2fc59512a594c37e0"

URI_aarch64_python-rosdep-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-rosdep-doc-0.26.0-4.el10_2.noarch.rpm;name=aarch64_python-rosdep-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-rosdep-doc}"
SRC_URI[aarch64_python-rosdep-doc.sha256sum] = "1a6a817d25236df84f03b8d155c04dd37ab5aaa7258aea9bf58e4ae7e048a2fe"

URI_aarch64_python3-rosdep = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rosdep-0.26.0-4.el10_2.noarch.rpm;name=aarch64_python3-rosdep;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rosdep}"
SRC_URI[aarch64_python3-rosdep.sha256sum] = "752dfb69cbdff4100070d16be9f1e33366ca98ed688327f4bd754e902ae1bb65"

RDEPENDS:python-rosdep-doc = " \
 "
RDEPENDS:python3-rosdep = " \
 python-srpm-macros \
 python3 \
 python3-catkin_pkg \
 python3-pyyaml \
 python3-rosdistro \
 python3-rospkg \
 "
