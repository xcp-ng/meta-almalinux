# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "spectacle"
PE = "1"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 spectacle \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/spectacle-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "45406c2ad8131919d1c2a408a591a6493e3e0338d4ae5ca707bfb95c9eae86a3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/spectacle-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_spectacle;unpack=0"
SRC_URI[x86_64_v2_spectacle.sha256sum] = "f4f99968415ee34320b4a0c88bfb4bc1b77daecc71bccf13df98393aca024fe5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/spectacle-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_spectacle;unpack=0"
SRC_URI[aarch64_spectacle.sha256sum] = "0fa6b32889ca9e05ec7bb78096b9e7b8eea4c543b791d7d64197fbb7cdd69d6c"

RDEPENDS:spectacle = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-prison \
 kf6-purpose \
 kpipewire \
 kquickimageeditor-qt6 \
 layer-shell-qt \
 libgcc \
 libstdc++ \
 libwayland-client \
 libxcb \
 opencv-core \
 opencv-imgproc \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 tesseract \
 xcb-util \
 xcb-util-cursor \
 xcb-util-image \
 "
