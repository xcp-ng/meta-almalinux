# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iftop"
PV = "1.0"
PR = "0.34.pre4.el10_0"
PACKAGES = " \
 iftop \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/iftop-1.0-0.34.pre4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4102a036ac4f081f38ae09a592e5e5505d168ceec1e21dd4fd2afab94a3deba"

URI_x86_64_v2_iftop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/iftop-1.0-0.34.pre4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_iftop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iftop}"
SRC_URI[x86_64_v2_iftop.sha256sum] = "67257ed33d9df4b5d91fb259d82a37b995275237ca984e94df527f4d94614aa5"

URI_aarch64_iftop = "${EPEL_MIRROR}/aarch64/Packages/i/iftop-1.0-0.34.pre4.el10_0.aarch64.rpm;name=aarch64_iftop;unpack=0"
SRC_URI:append = " ${URI_aarch64_iftop}"
SRC_URI[aarch64_iftop.sha256sum] = "253301fb547df5a3a891dc36145c3d8bb23408ced887218a8b0558b785c11828"

RDEPENDS:iftop = " \
 glibc \
 libpcap \
 ncurses-libs \
 "
