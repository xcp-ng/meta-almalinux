# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ogr"
PV = "0.63.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-ogr \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-ogr-0.63.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b517105ba3d53ca8c2192ce37c16f748d111e2805db0b554aeed6111bb30f73d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ogr-0.63.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ogr;unpack=0"
SRC_URI[x86_64_v2_python3-ogr.sha256sum] = "acd72328538d1a54a0040fbd4238df7e75e1c748c0f47e34e2543d4924db7e0b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-ogr-0.63.0-1.el10_3.noarch.rpm;name=aarch64_python3-ogr;unpack=0"
SRC_URI[aarch64_python3-ogr.sha256sum] = "645fdb2a7921cb84399b90aabc827d88c1f6570c52701b65cf4c70c6236c30e8"

RDEPENDS:python3-ogr = " \
 python3 \
 python3-GitPython \
 python3-cryptography \
 python3-deprecated \
 python3-gitlab \
 python3-httpx \
 python3-pyforgejo \
 python3-pygithub \
 python3-pyyaml \
 python3-requests \
 python3-urllib3 \
 "
