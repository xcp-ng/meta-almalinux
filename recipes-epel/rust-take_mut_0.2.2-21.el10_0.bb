# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-take_mut"
PV = "0.2.2"
PR = "21.el10_0"
PACKAGES = " \
 rust-take_mut+default-devel \
 rust-take_mut-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-take_mut-0.2.2-21.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e404a83ca7c8b207042ee2e42a8ce3c979d9ef7438683f89ae9af687027259be"

URI_x86_64_v2_rust-take_mut+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-take_mut+default-devel-0.2.2-21.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-take_mut+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-take_mut+default-devel}"
SRC_URI[x86_64_v2_rust-take_mut+default-devel.sha256sum] = "02b14ed712e506357b65cbcf90e7e7b6a26fada277f1f13c6f9ef0067e02b5f2"

URI_x86_64_v2_rust-take_mut-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-take_mut-devel-0.2.2-21.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-take_mut-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-take_mut-devel}"
SRC_URI[x86_64_v2_rust-take_mut-devel.sha256sum] = "f6cc2fd91ee1bcc1ac85391f386f51bbfdd3a0cea69dfc564994bfe4e4113266"

URI_aarch64_rust-take_mut+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-take_mut+default-devel-0.2.2-21.el10_0.noarch.rpm;name=aarch64_rust-take_mut+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-take_mut+default-devel}"
SRC_URI[aarch64_rust-take_mut+default-devel.sha256sum] = "4835655bdf2c9a508aa56792811f4b73cc509336937154cdecb8afedf0d954f7"

URI_aarch64_rust-take_mut-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-take_mut-devel-0.2.2-21.el10_0.noarch.rpm;name=aarch64_rust-take_mut-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-take_mut-devel}"
SRC_URI[aarch64_rust-take_mut-devel.sha256sum] = "d9c2b19e21b954ce11d1d47809c510b1601863f4bc16f744dd3ca6f4dc079c99"

RDEPENDS:rust-take_mut+default-devel = " \
 cargo \
 rust-take_mut-devel \
 "
RDEPENDS:rust-take_mut-devel = " \
 cargo \
 "
