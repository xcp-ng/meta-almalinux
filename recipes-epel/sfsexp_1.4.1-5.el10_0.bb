# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sfsexp"
PV = "1.4.1"
PR = "5.el10_0"
PACKAGES = " \
 sfsexp \
 sfsexp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sfsexp-1.4.1-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da209a261629869c570d5eaeab2342dcfdbfa4835b8a0ce0f138d52d6f97743e"

URI_x86_64_v2_sfsexp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sfsexp-1.4.1-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sfsexp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sfsexp}"
SRC_URI[x86_64_v2_sfsexp.sha256sum] = "8c856cfface0ab9bec31a8964c9b2324634b8f9bac02e10fe4fb2a42ec0b11fc"

URI_x86_64_v2_sfsexp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sfsexp-devel-1.4.1-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sfsexp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sfsexp-devel}"
SRC_URI[x86_64_v2_sfsexp-devel.sha256sum] = "3873e09596d2555c231ad1b62c1df660277c2df21b4c0ec4ad03fdb7c54b2244"

URI_aarch64_sfsexp = "${EPEL_MIRROR}/aarch64/Packages/s/sfsexp-1.4.1-5.el10_0.aarch64.rpm;name=aarch64_sfsexp;unpack=0"
SRC_URI:append = " ${URI_aarch64_sfsexp}"
SRC_URI[aarch64_sfsexp.sha256sum] = "3389dff25727f2a7b9fb64e1dd221c2ab5676f3b4034327b1e6507fb817509ae"

URI_aarch64_sfsexp-devel = "${EPEL_MIRROR}/aarch64/Packages/s/sfsexp-devel-1.4.1-5.el10_0.aarch64.rpm;name=aarch64_sfsexp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sfsexp-devel}"
SRC_URI[aarch64_sfsexp-devel.sha256sum] = "f7344f229bb76e2df1edd4a6ec1e157846072f03ae0062c476d196212961fbf0"

RDEPENDS:sfsexp = " \
 glibc \
 "
RDEPENDS:sfsexp-devel = " \
 pkgconf-pkg-config \
 sfsexp \
 "
