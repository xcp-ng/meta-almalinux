# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Data-OptList"
PV = "0.114"
PR = "7.el10"
PACKAGES = " \
 perl-Data-OptList \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Data-OptList-0.114-7.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2a0425c2ee72a2ea0f6d4e8c2bcd3dd55a28f3d070807b5cb30fa4cfa1df02f3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Data-OptList-0.114-7.el10.noarch.rpm;name=x86_64_v2_perl-Data-OptList;unpack=0"
SRC_URI[x86_64_v2_perl-Data-OptList.sha256sum] = "17d77bab02dba929a5be184e62880e37c910c973863d679a3de19a385296d919"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Data-OptList-0.114-7.el10.noarch.rpm;name=aarch64_perl-Data-OptList;unpack=0"
SRC_URI[aarch64_perl-Data-OptList.sha256sum] = "17d77bab02dba929a5be184e62880e37c910c973863d679a3de19a385296d919"

RDEPENDS:perl-Data-OptList = " \
 perl-Params-Util \
 perl-Scalar-List-Utils \
 perl-Sub-Install \
 perl-libs \
 "
