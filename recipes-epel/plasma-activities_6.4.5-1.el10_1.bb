# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-activities"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 plasma-activities \
 plasma-activities-devel \
 plasma-activities-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-activities-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "05225e16bfff161425fe94ee947b8734b272331bcd313ebc56df46bde904cc05"

URI_x86_64_v2_plasma-activities = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-activities-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-activities;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-activities}"
SRC_URI[x86_64_v2_plasma-activities.sha256sum] = "a394873fc5f4ff207dce8c7c701fc3add5db68de687673661eef34afb5b7090e"

URI_x86_64_v2_plasma-activities-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-activities-devel-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-activities-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-activities-devel}"
SRC_URI[x86_64_v2_plasma-activities-devel.sha256sum] = "d481796ac7fa0f11d2412cf26f7dbaff5e0d9472f033849d504703303529db94"

URI_x86_64_v2_plasma-activities-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-activities-doc-6.4.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-activities-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-activities-doc}"
SRC_URI[x86_64_v2_plasma-activities-doc.sha256sum] = "77bc91a330231cd3a1829b56e2bb7232bcaa2f4c22c730ac05eaf1edf1c5463a"

URI_aarch64_plasma-activities = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-activities-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_plasma-activities;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-activities}"
SRC_URI[aarch64_plasma-activities.sha256sum] = "6286080535721b229d84a9dbac1c0484c7de5ed2e9e740e6ceed637cd37f2612"

URI_aarch64_plasma-activities-devel = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-activities-devel-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_plasma-activities-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-activities-devel}"
SRC_URI[aarch64_plasma-activities-devel.sha256sum] = "0044e02205aa6329ca4555943421e2005cc0255ad43700d5fdad91c2c14c52be"

URI_aarch64_plasma-activities-doc = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-activities-doc-6.4.5-1.el10_1.noarch.rpm;name=aarch64_plasma-activities-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-activities-doc}"
SRC_URI[aarch64_plasma-activities-doc.sha256sum] = "2ce5d6ad85cfe7f9adb81302ec11e63d8b64501f028ce982d180b2ac14e977aa"

RDEPENDS:plasma-activities = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:plasma-activities-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 plasma-activities \
 qt6-qtbase-devel \
 "
RDEPENDS:plasma-activities-doc = " \
 "
