# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap_builder"
PV = "4.5.54"
PR = "1.el10_1"
PACKAGES = " \
 rust-clap_builder+cargo-devel \
 rust-clap_builder+color-devel \
 rust-clap_builder+debug-devel \
 rust-clap_builder+default-devel \
 rust-clap_builder+deprecated-devel \
 rust-clap_builder+env-devel \
 rust-clap_builder+error-context-devel \
 rust-clap_builder+help-devel \
 rust-clap_builder+std-devel \
 rust-clap_builder+string-devel \
 rust-clap_builder+suggestions-devel \
 rust-clap_builder+unicode-devel \
 rust-clap_builder+unstable-doc-devel \
 rust-clap_builder+unstable-ext-devel \
 rust-clap_builder+unstable-styles-devel \
 rust-clap_builder+unstable-v5-devel \
 rust-clap_builder+usage-devel \
 rust-clap_builder+wrap_help-devel \
 rust-clap_builder-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap_builder-4.5.54-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "558a59471062a40eb80f847a3afcb6cd9511d43f6213091de4d0262c3a1db3ef"

URI_x86_64_v2_rust-clap_builder+cargo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+cargo-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+cargo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+cargo-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+cargo-devel.sha256sum] = "551947e6f02d55f52143673561b964cd67f466188f9863ddc4ea6b4b2e0a2d43"

URI_x86_64_v2_rust-clap_builder+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+color-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+color-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+color-devel.sha256sum] = "1d8c4764e8c542ed434148ebfb2cc6a132e548c77197b7fcec4ab06937f2b496"

URI_x86_64_v2_rust-clap_builder+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+debug-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+debug-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+debug-devel.sha256sum] = "23afe5296af5a433f0a1de835d96b148b1727cb7eff083467361b93e04636c2c"

URI_x86_64_v2_rust-clap_builder+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+default-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+default-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+default-devel.sha256sum] = "805460ef23f2e37203004a1094c94c77a0f243ca125666a038c0b67cef7803c2"

URI_x86_64_v2_rust-clap_builder+deprecated-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+deprecated-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+deprecated-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+deprecated-devel.sha256sum] = "81d0c2c3a3867b594b733ef02daa713f697f9460aa1d4610520e69d25c40bc87"

URI_x86_64_v2_rust-clap_builder+env-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+env-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+env-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+env-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+env-devel.sha256sum] = "789691e6d0e1a887a9105e5e67cbbd19a812da7c048f1205cc1b52405f137bf5"

URI_x86_64_v2_rust-clap_builder+error-context-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+error-context-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+error-context-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+error-context-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+error-context-devel.sha256sum] = "15a72f75ab8bb25a282bce5dc2fedda0f8ec31a2ec80432fef30b36ef618a1bf"

URI_x86_64_v2_rust-clap_builder+help-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+help-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+help-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+help-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+help-devel.sha256sum] = "a5680f46addfe411a1847217e360d09f3e9c69a44d845f768c0606ab29708b96"

URI_x86_64_v2_rust-clap_builder+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+std-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+std-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+std-devel.sha256sum] = "d2b8ba4fc2229fad7cc0c1572ddab5a39ecde27bbe92080ca3ee1ed526fb160b"

URI_x86_64_v2_rust-clap_builder+string-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+string-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+string-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+string-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+string-devel.sha256sum] = "c7114667b27f9329779606358f0d0702313d9f990e5dd0753e8768db186bd36b"

URI_x86_64_v2_rust-clap_builder+suggestions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+suggestions-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+suggestions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+suggestions-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+suggestions-devel.sha256sum] = "152a664316f5489a02cae4ee9b5aca90219f79b2dd0ab0a2dca8d161791b6f4e"

URI_x86_64_v2_rust-clap_builder+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+unicode-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+unicode-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+unicode-devel.sha256sum] = "33ece2a464921ff35e4054e2538809d9ee50a60995bd06369e8fc4e908a8c4ec"

URI_x86_64_v2_rust-clap_builder+unstable-doc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+unstable-doc-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+unstable-doc-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+unstable-doc-devel.sha256sum] = "54d306ff119de9031a8f17ff0cf817383e70b59ddff220c9bf395a6b3fb5f952"

URI_x86_64_v2_rust-clap_builder+unstable-ext-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+unstable-ext-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+unstable-ext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+unstable-ext-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+unstable-ext-devel.sha256sum] = "d8a86fd8c462a49723929beeca4172a4f1453e7b9eccbf29035fb79b521705da"

URI_x86_64_v2_rust-clap_builder+unstable-styles-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+unstable-styles-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+unstable-styles-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+unstable-styles-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+unstable-styles-devel.sha256sum] = "2c790bcc4bcfe53028ccc77334465d29b3d01f4293e11d35d7f05c39850f469c"

URI_x86_64_v2_rust-clap_builder+unstable-v5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+unstable-v5-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+unstable-v5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+unstable-v5-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+unstable-v5-devel.sha256sum] = "4e7028324ebda50b5be35ee116ada074bfa750ff7a62d7f9d076082b41cf0e10"

URI_x86_64_v2_rust-clap_builder+usage-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+usage-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+usage-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+usage-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+usage-devel.sha256sum] = "6b9bd844bcf29937cf587f5a9f47e03a5128236c442e1a7920cd9d3abcc94ad2"

URI_x86_64_v2_rust-clap_builder+wrap_help-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+wrap_help-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+wrap_help-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+wrap_help-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+wrap_help-devel.sha256sum] = "6c0a9ad732390e256a2f86445f70a6c21186ca2e0a6de31819852f8c39c9121a"

URI_x86_64_v2_rust-clap_builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder-devel-4.5.54-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder-devel}"
SRC_URI[x86_64_v2_rust-clap_builder-devel.sha256sum] = "acc3e35ad344d68d15668e5bafb17a79916f455c0fdf62561d6d656ccd542df9"

URI_aarch64_rust-clap_builder+cargo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+cargo-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap_builder+cargo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+cargo-devel}"
SRC_URI[aarch64_rust-clap_builder+cargo-devel.sha256sum] = "d580938a9729969681a6f3a6c118d156f55f56c4a8ad649b761bae1ba6a08ce2"

URI_aarch64_rust-clap_builder+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+color-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap_builder+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+color-devel}"
SRC_URI[aarch64_rust-clap_builder+color-devel.sha256sum] = "08516363d88e4b16dc18f51a1ec07b43ccee7aef71ab8a053ccbdbc01c40f3a5"

URI_aarch64_rust-clap_builder+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+debug-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap_builder+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+debug-devel}"
SRC_URI[aarch64_rust-clap_builder+debug-devel.sha256sum] = "c029f8d926245b8f8450e5ff1e26bdb953e5b75318aaaf620c17dc65b310bc93"

URI_aarch64_rust-clap_builder+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+default-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap_builder+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+default-devel}"
SRC_URI[aarch64_rust-clap_builder+default-devel.sha256sum] = "b846110328305d00cc59920333f67ef856ac33549ff8eed73b969ad85c9aa442"

URI_aarch64_rust-clap_builder+deprecated-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+deprecated-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap_builder+deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+deprecated-devel}"
SRC_URI[aarch64_rust-clap_builder+deprecated-devel.sha256sum] = "30f3f4376fcdcccf755415fc93420954c7743c1f457cba6932407189aec339de"

URI_aarch64_rust-clap_builder+env-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+env-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap_builder+env-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+env-devel}"
SRC_URI[aarch64_rust-clap_builder+env-devel.sha256sum] = "a3e33155e9872cfddadcbbf41c4ad59b68691361deb6f9dfb9f6ca2a001fedce"

URI_aarch64_rust-clap_builder+error-context-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+error-context-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap_builder+error-context-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+error-context-devel}"
SRC_URI[aarch64_rust-clap_builder+error-context-devel.sha256sum] = "fd7480256ac717624b77fa52d21b7e2184e00bddff33eee4c459d4f364ba2dd7"

URI_aarch64_rust-clap_builder+help-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+help-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap_builder+help-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+help-devel}"
SRC_URI[aarch64_rust-clap_builder+help-devel.sha256sum] = "b65a9d47a4275b79944fc24c8e758ac7070d6c5c06b372a81a6a5eb9f8f8dce0"

URI_aarch64_rust-clap_builder+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+std-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap_builder+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+std-devel}"
SRC_URI[aarch64_rust-clap_builder+std-devel.sha256sum] = "44bd1159d378abdb3590b7e74f12e2479351b181cee6b8ea811def3c8f020e28"

URI_aarch64_rust-clap_builder+string-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+string-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap_builder+string-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+string-devel}"
SRC_URI[aarch64_rust-clap_builder+string-devel.sha256sum] = "d5168c521ccfa1bfdc62339ef70177ab0f63dfd0d43f76b6529aaf3062cb5687"

URI_aarch64_rust-clap_builder+suggestions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+suggestions-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap_builder+suggestions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+suggestions-devel}"
SRC_URI[aarch64_rust-clap_builder+suggestions-devel.sha256sum] = "24787b2e4ed223108117ad0a6e16e0582eba22d5f1ed2126b6d735440c4a67c5"

URI_aarch64_rust-clap_builder+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+unicode-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap_builder+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+unicode-devel}"
SRC_URI[aarch64_rust-clap_builder+unicode-devel.sha256sum] = "5f8a0efd88443324427af8320ce9b7d4f5a4199a63b221c7536034ab59e225b4"

URI_aarch64_rust-clap_builder+unstable-doc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+unstable-doc-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap_builder+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+unstable-doc-devel}"
SRC_URI[aarch64_rust-clap_builder+unstable-doc-devel.sha256sum] = "d190b04439812f48154b2b6b6bd074dfbb931efc983f83db7a5afffbf1fae2ec"

URI_aarch64_rust-clap_builder+unstable-ext-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+unstable-ext-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap_builder+unstable-ext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+unstable-ext-devel}"
SRC_URI[aarch64_rust-clap_builder+unstable-ext-devel.sha256sum] = "9c394bedf1bd01dce031e4ce591768aac4195c43eb557f18e89e53d183ed191b"

URI_aarch64_rust-clap_builder+unstable-styles-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+unstable-styles-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap_builder+unstable-styles-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+unstable-styles-devel}"
SRC_URI[aarch64_rust-clap_builder+unstable-styles-devel.sha256sum] = "ca71eec6dd63e63718b0ef6df7ade90d695d510fbe8e8853c9f89425b4815ea9"

URI_aarch64_rust-clap_builder+unstable-v5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+unstable-v5-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap_builder+unstable-v5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+unstable-v5-devel}"
SRC_URI[aarch64_rust-clap_builder+unstable-v5-devel.sha256sum] = "8d3c17ba1d924e4eb7695c21a89a1eef677681a6ba88e5835601a06bb63f9f70"

URI_aarch64_rust-clap_builder+usage-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+usage-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap_builder+usage-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+usage-devel}"
SRC_URI[aarch64_rust-clap_builder+usage-devel.sha256sum] = "3cdb2636a30f6924d5d157e3e8339be1c99c55ebd1f55862330621a4738782c5"

URI_aarch64_rust-clap_builder+wrap_help-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+wrap_help-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap_builder+wrap_help-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+wrap_help-devel}"
SRC_URI[aarch64_rust-clap_builder+wrap_help-devel.sha256sum] = "1df16026283a072392efcaf9b0de9d0809916b71550737e9735ee4ec701d8987"

URI_aarch64_rust-clap_builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder-devel-4.5.54-1.el10_1.noarch.rpm;name=aarch64_rust-clap_builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder-devel}"
SRC_URI[aarch64_rust-clap_builder-devel.sha256sum] = "40342f24218b70d63f3afee4aaf997a468c5d5106c31df16473fceda938d57d0"

RDEPENDS:rust-clap_builder+cargo-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+color-devel = " \
 cargo \
 rust-anstream+default-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+debug-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+default-devel = " \
 cargo \
 rust-clap_builder+color-devel \
 rust-clap_builder+error-context-devel \
 rust-clap_builder+help-devel \
 rust-clap_builder+std-devel \
 rust-clap_builder+suggestions-devel \
 rust-clap_builder+usage-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+deprecated-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+env-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+error-context-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+help-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+std-devel = " \
 cargo \
 rust-anstyle+std-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+string-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+suggestions-devel = " \
 cargo \
 rust-clap_builder+error-context-devel \
 rust-clap_builder-devel \
 rust-strsim+default-devel \
 "
RDEPENDS:rust-clap_builder+unicode-devel = " \
 cargo \
 rust-clap_builder-devel \
 rust-unicase+default-devel \
 rust-unicode-width+default-devel \
 "
RDEPENDS:rust-clap_builder+unstable-doc-devel = " \
 cargo \
 rust-clap_builder+cargo-devel \
 rust-clap_builder+env-devel \
 rust-clap_builder+string-devel \
 rust-clap_builder+unicode-devel \
 rust-clap_builder+unstable-ext-devel \
 rust-clap_builder+wrap_help-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+unstable-ext-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+unstable-styles-devel = " \
 cargo \
 rust-clap_builder+color-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+unstable-v5-devel = " \
 cargo \
 rust-clap_builder+deprecated-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+usage-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+wrap_help-devel = " \
 cargo \
 rust-clap_builder+help-devel \
 rust-clap_builder-devel \
 rust-terminal_size+default-devel \
 "
RDEPENDS:rust-clap_builder-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-clap_lex+default-devel \
 "
