# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-vsprintf"
PV = "2.0.0"
PR = "11.el10_1"
PACKAGES = " \
 rust-vsprintf+default-devel \
 rust-vsprintf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-vsprintf-2.0.0-11.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27d9d73c7c8cc9f3196675cb9f7b19ce50f136064a5f894da78b6b146402aa8b"

URI_x86_64_v2_rust-vsprintf+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vsprintf+default-devel-2.0.0-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vsprintf+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vsprintf+default-devel}"
SRC_URI[x86_64_v2_rust-vsprintf+default-devel.sha256sum] = "1c372f42930143986c3f5b0c1e08cb19d248b0169e0b0a61860b54003ecbcf81"

URI_x86_64_v2_rust-vsprintf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vsprintf-devel-2.0.0-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vsprintf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vsprintf-devel}"
SRC_URI[x86_64_v2_rust-vsprintf-devel.sha256sum] = "4eb4b75a3f7607f69d50beb71b8a82777e4898a4378723f805f3991392e6b6a9"

URI_aarch64_rust-vsprintf+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vsprintf+default-devel-2.0.0-11.el10_1.noarch.rpm;name=aarch64_rust-vsprintf+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vsprintf+default-devel}"
SRC_URI[aarch64_rust-vsprintf+default-devel.sha256sum] = "075317a88aa81cbf34691c14141da2ee3836fcb85cda6da934bb690742853175"

URI_aarch64_rust-vsprintf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vsprintf-devel-2.0.0-11.el10_1.noarch.rpm;name=aarch64_rust-vsprintf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vsprintf-devel}"
SRC_URI[aarch64_rust-vsprintf-devel.sha256sum] = "c2d007a1c1c525060474cc9069ffc362f54ca10dcf8fda438be2a994cd319934"

RDEPENDS:rust-vsprintf+default-devel = " \
 cargo \
 rust-vsprintf-devel \
 "
RDEPENDS:rust-vsprintf-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-libc+default-devel \
 "
