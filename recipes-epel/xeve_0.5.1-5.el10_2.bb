# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xeve"
PV = "0.5.1"
PR = "5.el10_2"
PACKAGES = " \
 xeve \
 xeve-devel \
 xeve-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xeve-0.5.1-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b6ef9d54d6066c9c01735032ecf362d11fbf49bb2d16f5bd7a48b5e5262d9d96"

URI_x86_64_v2_xeve = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xeve-0.5.1-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xeve;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xeve}"
SRC_URI[x86_64_v2_xeve.sha256sum] = "edb00f2d8f552d2bf4cec92e4ac7c5b65cb470441767ffe289e197e1e1822aa9"

URI_x86_64_v2_xeve-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xeve-devel-0.5.1-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xeve-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xeve-devel}"
SRC_URI[x86_64_v2_xeve-devel.sha256sum] = "9fa1a8c118d1a1139ed4cf5931268bca48e06a900891e393f2abeaca869f57e5"

URI_x86_64_v2_xeve-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xeve-libs-0.5.1-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xeve-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xeve-libs}"
SRC_URI[x86_64_v2_xeve-libs.sha256sum] = "8eae1952a0be7330acb885396ad50284f5ca7166cf49157c7d909bd2de04cd7a"

URI_aarch64_xeve = "${EPEL_MIRROR}/aarch64/Packages/x/xeve-0.5.1-5.el10_2.aarch64.rpm;name=aarch64_xeve;unpack=0"
SRC_URI:append = " ${URI_aarch64_xeve}"
SRC_URI[aarch64_xeve.sha256sum] = "56f660d07f972effe48ddef01723dcef3861e4d0e1532f4cc1a306cf1ec50f53"

URI_aarch64_xeve-devel = "${EPEL_MIRROR}/aarch64/Packages/x/xeve-devel-0.5.1-5.el10_2.aarch64.rpm;name=aarch64_xeve-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xeve-devel}"
SRC_URI[aarch64_xeve-devel.sha256sum] = "95bf82fd055ce94d5e83840e32a873a2351257e9b4a220e40b0f7aa7ed5114df"

URI_aarch64_xeve-libs = "${EPEL_MIRROR}/aarch64/Packages/x/xeve-libs-0.5.1-5.el10_2.aarch64.rpm;name=aarch64_xeve-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_xeve-libs}"
SRC_URI[aarch64_xeve-libs.sha256sum] = "8610a2dd08597a587aafe89f4476388d87226ec2e660dcd927349395d738d104"

RDEPENDS:xeve = " \
 glibc \
 xeve-libs \
 "
RDEPENDS:xeve-devel = " \
 pkgconf-pkg-config \
 xeve-libs \
 "
RDEPENDS:xeve-libs = " \
 glibc \
 "
