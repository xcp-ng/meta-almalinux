# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-displaydoc"
PV = "0.2.5"
PR = "3.el10_0"
PACKAGES = " \
 rust-displaydoc+default-devel \
 rust-displaydoc+std-devel \
 rust-displaydoc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-displaydoc-0.2.5-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7061495178439faf62eacbdb6328f45617529a04ee814dad9d6138bb14fb2d3e"

URI_x86_64_v2_rust-displaydoc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-displaydoc+default-devel-0.2.5-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-displaydoc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-displaydoc+default-devel}"
SRC_URI[x86_64_v2_rust-displaydoc+default-devel.sha256sum] = "c96024310143298541628a9e0150805aa8fb0340b1ec822216757723ceb56ed4"

URI_x86_64_v2_rust-displaydoc+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-displaydoc+std-devel-0.2.5-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-displaydoc+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-displaydoc+std-devel}"
SRC_URI[x86_64_v2_rust-displaydoc+std-devel.sha256sum] = "972544a047d146b4e9b5721651186003ca3723f18a7e5051789a327354c31c72"

URI_x86_64_v2_rust-displaydoc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-displaydoc-devel-0.2.5-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-displaydoc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-displaydoc-devel}"
SRC_URI[x86_64_v2_rust-displaydoc-devel.sha256sum] = "c08128eff440835aba23eab4e288b1eea8910cd131720877f7cc4853321e43c0"

URI_aarch64_rust-displaydoc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-displaydoc+default-devel-0.2.5-3.el10_0.noarch.rpm;name=aarch64_rust-displaydoc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-displaydoc+default-devel}"
SRC_URI[aarch64_rust-displaydoc+default-devel.sha256sum] = "44d5ab7110493be1cafae9b512cf69ff5e45398395b1c9b076120c49aa3f81af"

URI_aarch64_rust-displaydoc+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-displaydoc+std-devel-0.2.5-3.el10_0.noarch.rpm;name=aarch64_rust-displaydoc+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-displaydoc+std-devel}"
SRC_URI[aarch64_rust-displaydoc+std-devel.sha256sum] = "cdbff7cbedd3b2547237ef21767bcbc4c9908e14b49969b6bca4b407c1b9e922"

URI_aarch64_rust-displaydoc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-displaydoc-devel-0.2.5-3.el10_0.noarch.rpm;name=aarch64_rust-displaydoc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-displaydoc-devel}"
SRC_URI[aarch64_rust-displaydoc-devel.sha256sum] = "d59a34545d056c91f7049df13fe95677ecb4960c4511f33e5d8e8a1957072a01"

RDEPENDS:rust-displaydoc+default-devel = " \
 cargo \
 rust-displaydoc+std-devel \
 rust-displaydoc-devel \
 "
RDEPENDS:rust-displaydoc+std-devel = " \
 cargo \
 rust-displaydoc-devel \
 "
RDEPENDS:rust-displaydoc-devel = " \
 bash \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
