# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustflags"
PV = "0.1.7"
PR = "1.el10_2"
PACKAGES = " \
 rust-rustflags+default-devel \
 rust-rustflags-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustflags-0.1.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65283bca10e11e965a5c567f8eb369ad112d4d9c19e75a55ae01c83b3d970379"

URI_x86_64_v2_rust-rustflags+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustflags+default-devel-0.1.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustflags+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustflags+default-devel}"
SRC_URI[x86_64_v2_rust-rustflags+default-devel.sha256sum] = "f7547e15200e5735410923bf075b9df6296de1e84c97a94ac7c4a3d5ffa8df04"

URI_x86_64_v2_rust-rustflags-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustflags-devel-0.1.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustflags-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustflags-devel}"
SRC_URI[x86_64_v2_rust-rustflags-devel.sha256sum] = "d2b5bf9d36e98ef889ad87b4270fcc0eb0a0532614a8f2750414ff92581a6504"

URI_aarch64_rust-rustflags+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustflags+default-devel-0.1.7-1.el10_2.noarch.rpm;name=aarch64_rust-rustflags+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustflags+default-devel}"
SRC_URI[aarch64_rust-rustflags+default-devel.sha256sum] = "252bdc4980d482a595fa10e71c6e806736057ec55bae6e4193cf9ca5cd12e15a"

URI_aarch64_rust-rustflags-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustflags-devel-0.1.7-1.el10_2.noarch.rpm;name=aarch64_rust-rustflags-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustflags-devel}"
SRC_URI[aarch64_rust-rustflags-devel.sha256sum] = "91e55efa1d73e22938a8aa30814fffd49f4ac41d23b43a144343f8fc99bb3313"

RDEPENDS:rust-rustflags+default-devel = " \
 cargo \
 rust-rustflags-devel \
 "
RDEPENDS:rust-rustflags-devel = " \
 cargo \
 rust \
 "
