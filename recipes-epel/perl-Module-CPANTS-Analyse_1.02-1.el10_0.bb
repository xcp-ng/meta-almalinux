# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Module-CPANTS-Analyse"
PV = "1.02"
PR = "1.el10_0"
PACKAGES = " \
 perl-Module-CPANTS-Analyse \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Module-CPANTS-Analyse-1.02-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "24fdb94a28eb8cb7f892d99e696540ba7f9bc3ad54555014b299712ab5a48094"

URI_x86_64_v2_perl-Module-CPANTS-Analyse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Module-CPANTS-Analyse-1.02-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Module-CPANTS-Analyse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Module-CPANTS-Analyse}"
SRC_URI[x86_64_v2_perl-Module-CPANTS-Analyse.sha256sum] = "0b0f74625d66db16b98a8666bed9613b2c5a43d97dcb3e191501461d47bf42d8"

URI_aarch64_perl-Module-CPANTS-Analyse = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Module-CPANTS-Analyse-1.02-1.el10_0.noarch.rpm;name=aarch64_perl-Module-CPANTS-Analyse;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Module-CPANTS-Analyse}"
SRC_URI[aarch64_perl-Module-CPANTS-Analyse.sha256sum] = "accf8d0b5949b4448ab9f04a93470664c49aac0f8b4468a2b4bb3529471bdbee"

RDEPENDS:perl-Module-CPANTS-Analyse = " \
 perl-Archive-Any-Lite \
 perl-Archive-Tar \
 perl-Array-Diff \
 perl-CPAN-Meta \
 perl-CPAN-Meta-YAML \
 perl-Carp \
 perl-Class-Accessor \
 perl-Data-Binary \
 perl-Encode \
 perl-Exporter \
 perl-ExtUtils-Manifest \
 perl-File-Copy \
 perl-File-Find-Object \
 perl-File-Temp \
 perl-File-stat \
 perl-JSON-PP \
 perl-Module-CPANfile \
 perl-Module-Find \
 perl-Parse-Distname \
 perl-PathTools \
 perl-Perl-PrereqScanner-NotQuiteLite \
 perl-Scalar-List-Utils \
 perl-Software-License \
 perl-Text-Balanced \
 perl-base \
 perl-libs \
 perl-version \
 "
