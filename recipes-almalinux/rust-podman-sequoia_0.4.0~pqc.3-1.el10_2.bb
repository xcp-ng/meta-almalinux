# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-podman-sequoia"
PV = "0.4.0~pqc.3"
PR = "1.el10_2"
PACKAGES = " \
 podman-sequoia \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rust-podman-sequoia-0.4.0~pqc.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c9af15621cec772435ec726a280c49571590b51eb307b80420b7a53220150958"

URI_x86_64_v2_podman-sequoia = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/podman-sequoia-0.4.0~pqc.3-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_podman-sequoia;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_podman-sequoia}"
SRC_URI[x86_64_v2_podman-sequoia.sha256sum] = "b6f76c688b074a17429c786a1a2133407a5c1b6b5ae2a5c56fc72aed25424691"

URI_aarch64_podman-sequoia = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/podman-sequoia-0.4.0~pqc.3-1.el10_2.aarch64.rpm;name=aarch64_podman-sequoia;unpack=0"
SRC_URI:append = " ${URI_aarch64_podman-sequoia}"
SRC_URI[aarch64_podman-sequoia.sha256sum] = "d71eb0a21087d218a06cf3137b51a3bd54425e0f2f08f2ac8c92dbdf988db77c"

RDEPENDS:podman-sequoia = " \
 glibc \
 libgcc \
 openssl-libs \
 sqlite-libs \
 "
