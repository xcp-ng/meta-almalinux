# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opendmarc"
PV = "1.4.2"
PR = "33.el10_0"
PACKAGES = " \
 libopendmarc \
 libopendmarc-devel \
 opendmarc \
 opendmarc-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/opendmarc-1.4.2-33.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c5fb274ddba93cb5ad4923464fb7525ed1c345e3f01251184eaf544908180c96"

URI_x86_64_v2_libopendmarc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libopendmarc-1.4.2-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libopendmarc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libopendmarc}"
SRC_URI[x86_64_v2_libopendmarc.sha256sum] = "a55126973b63a2194ff434e0762c45b03b021ee55ad849bccc97e4c194d61a1a"

URI_x86_64_v2_libopendmarc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libopendmarc-devel-1.4.2-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libopendmarc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libopendmarc-devel}"
SRC_URI[x86_64_v2_libopendmarc-devel.sha256sum] = "bdd4e7f9f8b474a6178ea42c5e6671f44b10f55a0f42468c9c73d718f9f8045e"

URI_x86_64_v2_opendmarc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opendmarc-1.4.2-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opendmarc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opendmarc}"
SRC_URI[x86_64_v2_opendmarc.sha256sum] = "8be45564147945fb57ed462eb21f670775cd753185c296be83ba6db78cb0796a"

URI_x86_64_v2_opendmarc-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opendmarc-tools-1.4.2-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opendmarc-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opendmarc-tools}"
SRC_URI[x86_64_v2_opendmarc-tools.sha256sum] = "ef45a4946c2206a8ebd61f8ff57d4c40fba31ea852d33e3aba5171f8c00cda96"

URI_aarch64_libopendmarc = "${EPEL_MIRROR}/aarch64/Packages/l/libopendmarc-1.4.2-33.el10_0.aarch64.rpm;name=aarch64_libopendmarc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libopendmarc}"
SRC_URI[aarch64_libopendmarc.sha256sum] = "98a5a81e11a4353e57754c36f07f61be555cf5f1d3bf65bcb397f1f25a0cd4fa"

URI_aarch64_libopendmarc-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libopendmarc-devel-1.4.2-33.el10_0.aarch64.rpm;name=aarch64_libopendmarc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libopendmarc-devel}"
SRC_URI[aarch64_libopendmarc-devel.sha256sum] = "9c92c9bdd6d7d4c6f98dceb4759ea2bfd07fb502dfb9e43b8f93020a88b7c640"

URI_aarch64_opendmarc = "${EPEL_MIRROR}/aarch64/Packages/o/opendmarc-1.4.2-33.el10_0.aarch64.rpm;name=aarch64_opendmarc;unpack=0"
SRC_URI:append = " ${URI_aarch64_opendmarc}"
SRC_URI[aarch64_opendmarc.sha256sum] = "a01ae08ede58b08cf2d6d7f9a1dbadb573b612263f65078c064d954bf26ef05b"

URI_aarch64_opendmarc-tools = "${EPEL_MIRROR}/aarch64/Packages/o/opendmarc-tools-1.4.2-33.el10_0.aarch64.rpm;name=aarch64_opendmarc-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_opendmarc-tools}"
SRC_URI[aarch64_opendmarc-tools.sha256sum] = "781ab1b38a639b5d76f0a3979277f16921f0764a6838c085e586f16da42b6438"

RDEPENDS:libopendmarc = " \
 glibc \
 libspf2 \
 "
RDEPENDS:libopendmarc-devel = " \
 libopendmarc \
 "
RDEPENDS:opendmarc = " \
 bash \
 glibc \
 libopendmarc \
 sendmail-milter \
 shadow-utils \
 "
RDEPENDS:opendmarc-tools = " \
 bash \
 libopendmarc \
 perl-DBD-MySQL \
 perl-DBI \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-HTTP-Message \
 perl-IO \
 perl-IO-Compress \
 perl-JSON \
 perl-MIME-Base64 \
 perl-POSIX \
 perl-Switch \
 perl-Time-Local \
 perl-interpreter \
 perl-libnet \
 perl-libs \
 "
