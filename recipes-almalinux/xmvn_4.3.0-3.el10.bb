# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xmvn"
PV = "4.3.0"
PR = "3.el10"
PACKAGES = " \
 xmvn \
 xmvn-core \
 xmvn-javadoc \
 xmvn-minimal \
 xmvn-mojo \
 xmvn-toolchain-openjdk21 \
 xmvn-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/xmvn-4.3.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc81391a882f858f5c29acb5a170748958bbda62ec18edb1187d0c339097baa8"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - xmvn-minimal: maven-jdk-binding

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - xmvn-minimal: maven-jdk-binding

URI_x86_64_v2_xmvn = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xmvn-4.3.0-3.el10.noarch.rpm;name=x86_64_v2_xmvn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmvn}"
SRC_URI[x86_64_v2_xmvn.sha256sum] = "320710b00cc1cd2d99868443da656473cd780b0c047f77eb61a0473f39420afd"

URI_x86_64_v2_xmvn-core = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xmvn-core-4.3.0-3.el10.noarch.rpm;name=x86_64_v2_xmvn-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmvn-core}"
SRC_URI[x86_64_v2_xmvn-core.sha256sum] = "15a47307e58b3c2d30d6fdad83d9e15b759cc629c62b33a9abef40e416b5fbdd"

URI_x86_64_v2_xmvn-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xmvn-javadoc-4.3.0-3.el10.noarch.rpm;name=x86_64_v2_xmvn-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmvn-javadoc}"
SRC_URI[x86_64_v2_xmvn-javadoc.sha256sum] = "5a67b8bbf3e8d9a433c876ae62a3c3007af366abd2feeb9dec18b5e12381a751"

URI_x86_64_v2_xmvn-minimal = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xmvn-minimal-4.3.0-3.el10.noarch.rpm;name=x86_64_v2_xmvn-minimal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmvn-minimal}"
SRC_URI[x86_64_v2_xmvn-minimal.sha256sum] = "df741d8fc829e6beca5ded4bbf512c041bfe38fcf54ec927ec39af7e24194232"

URI_x86_64_v2_xmvn-mojo = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xmvn-mojo-4.3.0-3.el10.noarch.rpm;name=x86_64_v2_xmvn-mojo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmvn-mojo}"
SRC_URI[x86_64_v2_xmvn-mojo.sha256sum] = "eeb50434bb03005bfb2b308f69ed4f3d6e7ee9284c6574d2c2dc4e34bc1ddea0"

URI_x86_64_v2_xmvn-toolchain-openjdk21 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xmvn-toolchain-openjdk21-4.3.0-3.el10.noarch.rpm;name=x86_64_v2_xmvn-toolchain-openjdk21;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmvn-toolchain-openjdk21}"
SRC_URI[x86_64_v2_xmvn-toolchain-openjdk21.sha256sum] = "73d7bb573693a4aaa3a7425586b1538656bda191ac324cb3d42dab85ea220f01"

URI_x86_64_v2_xmvn-tools = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xmvn-tools-4.3.0-3.el10.noarch.rpm;name=x86_64_v2_xmvn-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmvn-tools}"
SRC_URI[x86_64_v2_xmvn-tools.sha256sum] = "5505df7c208c75f92edc3d83b6a59c6e09500eb2fc42caebfc9106f450ebeee6"

URI_aarch64_xmvn = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xmvn-4.3.0-3.el10.noarch.rpm;name=aarch64_xmvn;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmvn}"
SRC_URI[aarch64_xmvn.sha256sum] = "320710b00cc1cd2d99868443da656473cd780b0c047f77eb61a0473f39420afd"

URI_aarch64_xmvn-core = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xmvn-core-4.3.0-3.el10.noarch.rpm;name=aarch64_xmvn-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmvn-core}"
SRC_URI[aarch64_xmvn-core.sha256sum] = "15a47307e58b3c2d30d6fdad83d9e15b759cc629c62b33a9abef40e416b5fbdd"

URI_aarch64_xmvn-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xmvn-javadoc-4.3.0-3.el10.noarch.rpm;name=aarch64_xmvn-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmvn-javadoc}"
SRC_URI[aarch64_xmvn-javadoc.sha256sum] = "5a67b8bbf3e8d9a433c876ae62a3c3007af366abd2feeb9dec18b5e12381a751"

URI_aarch64_xmvn-minimal = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xmvn-minimal-4.3.0-3.el10.noarch.rpm;name=aarch64_xmvn-minimal;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmvn-minimal}"
SRC_URI[aarch64_xmvn-minimal.sha256sum] = "df741d8fc829e6beca5ded4bbf512c041bfe38fcf54ec927ec39af7e24194232"

URI_aarch64_xmvn-mojo = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xmvn-mojo-4.3.0-3.el10.noarch.rpm;name=aarch64_xmvn-mojo;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmvn-mojo}"
SRC_URI[aarch64_xmvn-mojo.sha256sum] = "eeb50434bb03005bfb2b308f69ed4f3d6e7ee9284c6574d2c2dc4e34bc1ddea0"

URI_aarch64_xmvn-toolchain-openjdk21 = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xmvn-toolchain-openjdk21-4.3.0-3.el10.noarch.rpm;name=aarch64_xmvn-toolchain-openjdk21;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmvn-toolchain-openjdk21}"
SRC_URI[aarch64_xmvn-toolchain-openjdk21.sha256sum] = "73d7bb573693a4aaa3a7425586b1538656bda191ac324cb3d42dab85ea220f01"

URI_aarch64_xmvn-tools = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xmvn-tools-4.3.0-3.el10.noarch.rpm;name=aarch64_xmvn-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmvn-tools}"
SRC_URI[aarch64_xmvn-tools.sha256sum] = "5505df7c208c75f92edc3d83b6a59c6e09500eb2fc42caebfc9106f450ebeee6"

RDEPENDS:xmvn = " \
 maven \
 xmvn-minimal \
 "
RDEPENDS:xmvn-core = " \
 javapackages-filesystem \
 "
RDEPENDS:xmvn-javadoc = " \
 "
RDEPENDS:xmvn-minimal = " \
 apache-commons-cli \
 apache-commons-compress \
 atinject \
 bash \
 beust-jcommander \
 google-guice \
 guava \
 javapackages-filesystem \
 maven-lib \
 maven-resolver \
 maven-wagon \
 objectweb-asm \
 plexus-cipher \
 plexus-classworlds \
 plexus-containers-component-annotations \
 plexus-interpolation \
 plexus-sec-dispatcher \
 plexus-utils \
 sisu \
 slf4j \
 xmvn-core \
 xmvn-tools \
 "
RDEPENDS:xmvn-mojo = " \
 javapackages-filesystem \
 maven-resolver \
 objectweb-asm \
 xmvn-core \
 "
RDEPENDS:xmvn-toolchain-openjdk21 = " \
 java-21-openjdk-devel \
 javapackages-tools \
 xmvn-minimal \
 "
RDEPENDS:xmvn-tools = " \
 apache-commons-compress \
 bash \
 beust-jcommander \
 javapackages-filesystem \
 objectweb-asm \
 slf4j \
 xmvn-core \
 "
