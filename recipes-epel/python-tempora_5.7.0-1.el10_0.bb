# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-tempora"
PV = "5.7.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-tempora \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-tempora-5.7.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e3132ada91dd8ef4aef976a650fe27b1b9842294ea11a936e669f0d8aa611eaa"

URI_x86_64_v2_python3-tempora = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-tempora-5.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-tempora;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tempora}"
SRC_URI[x86_64_v2_python3-tempora.sha256sum] = "fd49cbb5c4676dc1a1ff8d4b155ceac0390843aa7a96e95c6ed1fb01b6171bc0"

URI_aarch64_python3-tempora = "${EPEL_MIRROR}/aarch64/Packages/p/python3-tempora-5.7.0-1.el10_0.noarch.rpm;name=aarch64_python3-tempora;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tempora}"
SRC_URI[aarch64_python3-tempora.sha256sum] = "f45bd9658200b26aa3cc98323777ef9a5473a28a6477d8a1f1deabfaf5a87a1f"

RDEPENDS:python3-tempora = " \
 python3 \
 python3-dateutil \
 python3-jaraco-functools \
 "
