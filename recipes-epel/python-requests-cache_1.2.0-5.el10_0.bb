# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-requests-cache"
PV = "1.2.0"
PR = "5.el10_0"
PACKAGES = " \
 python3-requests-cache \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-requests-cache-1.2.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1d1b3bd7963d2ecca659b2ee60a1051b4362467ecd017b468fab54e2dc4050b"

URI_x86_64_v2_python3-requests-cache = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-requests-cache-1.2.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-requests-cache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-requests-cache}"
SRC_URI[x86_64_v2_python3-requests-cache.sha256sum] = "579a092db168aa15b0b68617d0aa2309b84735a6ebdca9573ea50ea929031795"

URI_aarch64_python3-requests-cache = "${EPEL_MIRROR}/aarch64/Packages/p/python3-requests-cache-1.2.0-5.el10_0.noarch.rpm;name=aarch64_python3-requests-cache;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-requests-cache}"
SRC_URI[aarch64_python3-requests-cache.sha256sum] = "7e9021ebc2ee3afa53ccac012bd764731688a749255b0eba3ea16bc2a06ce003"

RDEPENDS:python3-requests-cache = " \
 python3 \
 python3-attrs \
 python3-cattrs \
 python3-platformdirs \
 python3-requests \
 python3-url-normalize \
 python3-urllib3 \
 "
