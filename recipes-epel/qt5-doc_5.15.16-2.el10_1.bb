# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-doc"
PV = "5.15.16"
PR = "2.el10_1"
PACKAGES = " \
 qt5-doc \
 qt5-qt3d-doc \
 qt5-qtbase-doc \
 qt5-qtcharts-doc \
 qt5-qtconnectivity-doc \
 qt5-qtdatavis3d-doc \
 qt5-qtdeclarative-doc \
 qt5-qtgamepad-doc \
 qt5-qtgraphicaleffects-doc \
 qt5-qtimageformats-doc \
 qt5-qtlocation-doc \
 qt5-qtmultimedia-doc \
 qt5-qtpurchasing-doc \
 qt5-qtquickcontrols-doc \
 qt5-qtquickcontrols2-doc \
 qt5-qtremoteobjects-doc \
 qt5-qtscript-doc \
 qt5-qtscxml-doc \
 qt5-qtsensors-doc \
 qt5-qtserialbus-doc \
 qt5-qtserialport-doc \
 qt5-qtspeech-doc \
 qt5-qtsvg-doc \
 qt5-qttools-doc \
 qt5-qtvirtualkeyboard-doc \
 qt5-qtwayland-doc \
 qt5-qtwebchannel-doc \
 qt5-qtwebsockets-doc \
 qt5-qtwebview-doc \
 qt5-qtx11extras-doc \
 qt5-qtxmlpatterns-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-doc-5.15.16-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c15bed0098de61ab9c404cac4b02a8339eaec0bb68f147fa25d48b075b7dd334"

URI_x86_64_v2_qt5-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-doc-5.15.16-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-doc}"
SRC_URI[x86_64_v2_qt5-doc.sha256sum] = "0c0a23726e3b88606617809007ccec0bee6fe13887961ff3f728e59c13da56db"

URI_x86_64_v2_qt5-qt3d-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qt3d-doc-5.15.16-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qt3d-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qt3d-doc}"
SRC_URI[x86_64_v2_qt5-qt3d-doc.sha256sum] = "ccd358d410634311bb4235aa553940fc2ed27c9a7b40cadc115e4d1866eab103"

URI_x86_64_v2_qt5-qtbase-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtbase-doc-5.15.16-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtbase-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtbase-doc}"
SRC_URI[x86_64_v2_qt5-qtbase-doc.sha256sum] = "03b0929499504196486dbd35f33e1a52c90ab9c4f30e7d31515b55b8d05e4390"

URI_x86_64_v2_qt5-qtcharts-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtcharts-doc-5.15.16-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtcharts-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtcharts-doc}"
SRC_URI[x86_64_v2_qt5-qtcharts-doc.sha256sum] = "7fe10d168cad3edcd9eaac9312a0d9ee66c289072ebab6bfae10f93f86a9daf1"

URI_x86_64_v2_qt5-qtconnectivity-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtconnectivity-doc-5.15.16-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtconnectivity-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtconnectivity-doc}"
SRC_URI[x86_64_v2_qt5-qtconnectivity-doc.sha256sum] = "5834a3995249e055cf598bc21164dec55d9fd94c1bc0b094d82c119af8f7833c"

URI_x86_64_v2_qt5-qtdatavis3d-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtdatavis3d-doc-5.15.16-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtdatavis3d-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtdatavis3d-doc}"
SRC_URI[x86_64_v2_qt5-qtdatavis3d-doc.sha256sum] = "de0ea2894d557587ac11d546ce9e5c1dcfbd722a1e19f62382d5e147c5affc98"

URI_x86_64_v2_qt5-qtdeclarative-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtdeclarative-doc-5.15.16-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtdeclarative-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtdeclarative-doc}"
SRC_URI[x86_64_v2_qt5-qtdeclarative-doc.sha256sum] = "b155f0720b14845d93b71a146b5bd7a956f6258fadc637a57578479a63c9eca6"

URI_x86_64_v2_qt5-qtgamepad-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtgamepad-doc-5.15.16-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtgamepad-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtgamepad-doc}"
SRC_URI[x86_64_v2_qt5-qtgamepad-doc.sha256sum] = "b1ad9ed748de1deedfd1d2c125eb5c4f0137904fc99ea1976bfb00624ef76943"

URI_x86_64_v2_qt5-qtgraphicaleffects-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtgraphicaleffects-doc-5.15.16-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtgraphicaleffects-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtgraphicaleffects-doc}"
SRC_URI[x86_64_v2_qt5-qtgraphicaleffects-doc.sha256sum] = "d549e629985db5fe5e581f64c185028c0b6d65581b9d77639181fec7fe3694d4"

URI_x86_64_v2_qt5-qtimageformats-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtimageformats-doc-5.15.16-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtimageformats-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtimageformats-doc}"
SRC_URI[x86_64_v2_qt5-qtimageformats-doc.sha256sum] = "0a3343bccc0cd7796c8ab33bf1c98ae15405b353665722c72fe5052960d2fc34"

URI_x86_64_v2_qt5-qtlocation-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtlocation-doc-5.15.16-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtlocation-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtlocation-doc}"
SRC_URI[x86_64_v2_qt5-qtlocation-doc.sha256sum] = "02b502d9028dceacd73cf238a20cba17b5ede991e24816f9c7f05fc2a5fcc45b"

URI_x86_64_v2_qt5-qtmultimedia-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtmultimedia-doc-5.15.16-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtmultimedia-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtmultimedia-doc}"
SRC_URI[x86_64_v2_qt5-qtmultimedia-doc.sha256sum] = "5b346d340f2dfb11cf3128bd92ed3cbe11153da0a27b9067ccf9a38c459900d2"

URI_x86_64_v2_qt5-qtpurchasing-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtpurchasing-doc-5.15.16-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtpurchasing-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtpurchasing-doc}"
SRC_URI[x86_64_v2_qt5-qtpurchasing-doc.sha256sum] = "5d88c8ebe6eb37fa4334309160f7bd6bac1f339e36c5094a56cf2356235ee426"

URI_x86_64_v2_qt5-qtquickcontrols-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtquickcontrols-doc-5.15.16-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtquickcontrols-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtquickcontrols-doc}"
SRC_URI[x86_64_v2_qt5-qtquickcontrols-doc.sha256sum] = "0d8a74735d85e9d493b42fa8ac4ad15e7286ae1bedba53bab4ac7e4ffa1810b9"

URI_x86_64_v2_qt5-qtquickcontrols2-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtquickcontrols2-doc-5.15.16-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtquickcontrols2-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtquickcontrols2-doc}"
SRC_URI[x86_64_v2_qt5-qtquickcontrols2-doc.sha256sum] = "582404703281de7c566ad8c1a49c77c9ea2b314d5b459501304a8c13c19cc4a4"

URI_x86_64_v2_qt5-qtremoteobjects-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtremoteobjects-doc-5.15.16-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtremoteobjects-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtremoteobjects-doc}"
SRC_URI[x86_64_v2_qt5-qtremoteobjects-doc.sha256sum] = "45c52d6e0539caa58cbc6090db502f620e34ba303d04ae735ed0e19f04ceb141"

URI_x86_64_v2_qt5-qtscript-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtscript-doc-5.15.16-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtscript-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtscript-doc}"
SRC_URI[x86_64_v2_qt5-qtscript-doc.sha256sum] = "5d8997f3eeb7ad0951760a2522a7ca1dcd56ae7210aeade01215adbbef380b73"

URI_x86_64_v2_qt5-qtscxml-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtscxml-doc-5.15.16-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtscxml-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtscxml-doc}"
SRC_URI[x86_64_v2_qt5-qtscxml-doc.sha256sum] = "32f8aafa169df6829af089531775a9ed3e9754aba3ebb299e084881b24aeea08"

URI_x86_64_v2_qt5-qtsensors-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtsensors-doc-5.15.16-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtsensors-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtsensors-doc}"
SRC_URI[x86_64_v2_qt5-qtsensors-doc.sha256sum] = "bf6cdc81b4ab92d06417957eaf0902bedc05de5f7c45c240bc4b26137a6c2f30"

URI_x86_64_v2_qt5-qtserialbus-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtserialbus-doc-5.15.16-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtserialbus-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtserialbus-doc}"
SRC_URI[x86_64_v2_qt5-qtserialbus-doc.sha256sum] = "dc5364fbac3ea8885e335d434ef3b0e3885be86448d34079e5e12ef78a449c60"

URI_x86_64_v2_qt5-qtserialport-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtserialport-doc-5.15.16-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtserialport-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtserialport-doc}"
SRC_URI[x86_64_v2_qt5-qtserialport-doc.sha256sum] = "8216da6f8c2d21377568e3ec71b8c1bd4846aa1c641c5b199fd7c1e7de204310"

URI_x86_64_v2_qt5-qtspeech-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtspeech-doc-5.15.16-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtspeech-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtspeech-doc}"
SRC_URI[x86_64_v2_qt5-qtspeech-doc.sha256sum] = "157a2d7448cf7b2cf87e8fa77af32644af96826f9748adc3e50b7ccd8821f7ab"

URI_x86_64_v2_qt5-qtsvg-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtsvg-doc-5.15.16-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtsvg-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtsvg-doc}"
SRC_URI[x86_64_v2_qt5-qtsvg-doc.sha256sum] = "7409f11a53767a223a9315d127eb7e54d1e0525b317c3294df25c8ceca25c8d7"

URI_x86_64_v2_qt5-qttools-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-doc-5.15.16-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qttools-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qttools-doc}"
SRC_URI[x86_64_v2_qt5-qttools-doc.sha256sum] = "9cf27e99c8418f6d8a973bd4ba479f498c66674b0561469014d146d95105a8df"

URI_x86_64_v2_qt5-qtvirtualkeyboard-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtvirtualkeyboard-doc-5.15.16-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtvirtualkeyboard-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtvirtualkeyboard-doc}"
SRC_URI[x86_64_v2_qt5-qtvirtualkeyboard-doc.sha256sum] = "1767e4f584cf61dd9a0fc4682648954e708e3c47a8f40f6c7c7b59f3519bd014"

URI_x86_64_v2_qt5-qtwayland-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwayland-doc-5.15.16-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtwayland-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwayland-doc}"
SRC_URI[x86_64_v2_qt5-qtwayland-doc.sha256sum] = "d7fba9764ef970931ac99ed82bf119425ac96b04c4bbccddebe5bb20fd82a3dc"

URI_x86_64_v2_qt5-qtwebchannel-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwebchannel-doc-5.15.16-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtwebchannel-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwebchannel-doc}"
SRC_URI[x86_64_v2_qt5-qtwebchannel-doc.sha256sum] = "a50a489b4727d22db5387b8b13c6aea2191e2214d3b88013377e7df91162eb87"

URI_x86_64_v2_qt5-qtwebsockets-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwebsockets-doc-5.15.16-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtwebsockets-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwebsockets-doc}"
SRC_URI[x86_64_v2_qt5-qtwebsockets-doc.sha256sum] = "d78001b3da6eb58a5b2061a370c2d7748b747a7bbd905bd6303853b915857cd4"

URI_x86_64_v2_qt5-qtwebview-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwebview-doc-5.15.16-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtwebview-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwebview-doc}"
SRC_URI[x86_64_v2_qt5-qtwebview-doc.sha256sum] = "06e3d23ee83867a9b321f1cc128689333c0f3a91a5ff7c509c7df4ca1b015cd2"

URI_x86_64_v2_qt5-qtx11extras-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtx11extras-doc-5.15.16-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtx11extras-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtx11extras-doc}"
SRC_URI[x86_64_v2_qt5-qtx11extras-doc.sha256sum] = "22d6f7f30e504a126d8a6f09621145d3067e7e4c1b1235f9d8d7d9d5353c5090"

URI_x86_64_v2_qt5-qtxmlpatterns-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtxmlpatterns-doc-5.15.16-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtxmlpatterns-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtxmlpatterns-doc}"
SRC_URI[x86_64_v2_qt5-qtxmlpatterns-doc.sha256sum] = "0d323d20bc2f8439071e8c4bf3aa8ae00a765c650481af10f128dfdc0f0eecfb"

URI_aarch64_qt5-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-doc-5.15.16-2.el10_1.noarch.rpm;name=aarch64_qt5-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-doc}"
SRC_URI[aarch64_qt5-doc.sha256sum] = "d514d6162443250cbd77bcd95f1092e72cf436360ca7b2d6862bdaf0786a68e1"

URI_aarch64_qt5-qt3d-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qt3d-doc-5.15.16-2.el10_1.noarch.rpm;name=aarch64_qt5-qt3d-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qt3d-doc}"
SRC_URI[aarch64_qt5-qt3d-doc.sha256sum] = "380bc2c97624eac627d8b1577ea6fd25f7ece71748ac7fb18959ef82b847a688"

URI_aarch64_qt5-qtbase-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtbase-doc-5.15.16-2.el10_1.noarch.rpm;name=aarch64_qt5-qtbase-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtbase-doc}"
SRC_URI[aarch64_qt5-qtbase-doc.sha256sum] = "76340271a215821a3ca47258d0318a8bd0de975e29593d2248d372aafb484272"

URI_aarch64_qt5-qtcharts-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtcharts-doc-5.15.16-2.el10_1.noarch.rpm;name=aarch64_qt5-qtcharts-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtcharts-doc}"
SRC_URI[aarch64_qt5-qtcharts-doc.sha256sum] = "e0f43f16e7994a39cd298b3e969eadd19fa91952e875e14f97b643fb1e8540c7"

URI_aarch64_qt5-qtconnectivity-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtconnectivity-doc-5.15.16-2.el10_1.noarch.rpm;name=aarch64_qt5-qtconnectivity-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtconnectivity-doc}"
SRC_URI[aarch64_qt5-qtconnectivity-doc.sha256sum] = "9946accc589d914f2090dc3819b64d4d17341f1f05b5c1c6379dc0b918b03639"

URI_aarch64_qt5-qtdatavis3d-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtdatavis3d-doc-5.15.16-2.el10_1.noarch.rpm;name=aarch64_qt5-qtdatavis3d-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtdatavis3d-doc}"
SRC_URI[aarch64_qt5-qtdatavis3d-doc.sha256sum] = "2db5280dabd725319e685494954617d44e5923a0c83cf46f28d8f586553f116f"

URI_aarch64_qt5-qtdeclarative-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtdeclarative-doc-5.15.16-2.el10_1.noarch.rpm;name=aarch64_qt5-qtdeclarative-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtdeclarative-doc}"
SRC_URI[aarch64_qt5-qtdeclarative-doc.sha256sum] = "2abe073a20838071fa67ab38f9c33b6ad5d23b72b9124492d48c7da274dbd448"

URI_aarch64_qt5-qtgamepad-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtgamepad-doc-5.15.16-2.el10_1.noarch.rpm;name=aarch64_qt5-qtgamepad-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtgamepad-doc}"
SRC_URI[aarch64_qt5-qtgamepad-doc.sha256sum] = "a060e3aa9ddafd0f1399ed87e26f74fd4cd2204b74d2ad55103a699844484a94"

URI_aarch64_qt5-qtgraphicaleffects-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtgraphicaleffects-doc-5.15.16-2.el10_1.noarch.rpm;name=aarch64_qt5-qtgraphicaleffects-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtgraphicaleffects-doc}"
SRC_URI[aarch64_qt5-qtgraphicaleffects-doc.sha256sum] = "a5b35c5383dfaf1d646c7acd44f7cd99418f03cdc26917c5a460a612db4e4a6b"

URI_aarch64_qt5-qtimageformats-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtimageformats-doc-5.15.16-2.el10_1.noarch.rpm;name=aarch64_qt5-qtimageformats-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtimageformats-doc}"
SRC_URI[aarch64_qt5-qtimageformats-doc.sha256sum] = "86c35527666381f0405e5fb04683ccd473695b911fe38e5f4f12e00ec2cf603d"

URI_aarch64_qt5-qtlocation-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtlocation-doc-5.15.16-2.el10_1.noarch.rpm;name=aarch64_qt5-qtlocation-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtlocation-doc}"
SRC_URI[aarch64_qt5-qtlocation-doc.sha256sum] = "50bb70716580fdc3d9fa519a4a5e908d713b75e02def2d8c1edd9a7a659a3026"

URI_aarch64_qt5-qtmultimedia-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtmultimedia-doc-5.15.16-2.el10_1.noarch.rpm;name=aarch64_qt5-qtmultimedia-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtmultimedia-doc}"
SRC_URI[aarch64_qt5-qtmultimedia-doc.sha256sum] = "4da2336cdb4ea5c1b5bb4dd5bb2489f0b86bd9ddb92a19becbcd2cdb106d24ab"

URI_aarch64_qt5-qtpurchasing-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtpurchasing-doc-5.15.16-2.el10_1.noarch.rpm;name=aarch64_qt5-qtpurchasing-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtpurchasing-doc}"
SRC_URI[aarch64_qt5-qtpurchasing-doc.sha256sum] = "1d2bb841b991cfb7f6b89389227b3d41e0a08dffbccdfd8f57ca69866c70e6ac"

URI_aarch64_qt5-qtquickcontrols-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtquickcontrols-doc-5.15.16-2.el10_1.noarch.rpm;name=aarch64_qt5-qtquickcontrols-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtquickcontrols-doc}"
SRC_URI[aarch64_qt5-qtquickcontrols-doc.sha256sum] = "7b81d5443a0bccad0be70e6ee809af0216243b0b6a81a32566e547a6ff78aa48"

URI_aarch64_qt5-qtquickcontrols2-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtquickcontrols2-doc-5.15.16-2.el10_1.noarch.rpm;name=aarch64_qt5-qtquickcontrols2-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtquickcontrols2-doc}"
SRC_URI[aarch64_qt5-qtquickcontrols2-doc.sha256sum] = "75fcf07646e2c2703c82b2342059dbab85e598765a2146e035a2abdd18101375"

URI_aarch64_qt5-qtremoteobjects-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtremoteobjects-doc-5.15.16-2.el10_1.noarch.rpm;name=aarch64_qt5-qtremoteobjects-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtremoteobjects-doc}"
SRC_URI[aarch64_qt5-qtremoteobjects-doc.sha256sum] = "e5f5b444aed1a2dc67f230fa4b449a6016ff29d11cb61aae5f834fd39821b7fe"

URI_aarch64_qt5-qtscript-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtscript-doc-5.15.16-2.el10_1.noarch.rpm;name=aarch64_qt5-qtscript-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtscript-doc}"
SRC_URI[aarch64_qt5-qtscript-doc.sha256sum] = "425c4f3824bd3e48d82e586536bee0d0a9f7f9203f64fbb2da39df26e1afd7fb"

URI_aarch64_qt5-qtscxml-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtscxml-doc-5.15.16-2.el10_1.noarch.rpm;name=aarch64_qt5-qtscxml-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtscxml-doc}"
SRC_URI[aarch64_qt5-qtscxml-doc.sha256sum] = "a9c2f480894cd889ea0e77b604bbb3fa12b17653ba3a921fbc5b6fff8a35b2b8"

URI_aarch64_qt5-qtsensors-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtsensors-doc-5.15.16-2.el10_1.noarch.rpm;name=aarch64_qt5-qtsensors-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtsensors-doc}"
SRC_URI[aarch64_qt5-qtsensors-doc.sha256sum] = "3bbd0179ec05e875db163150c1c9613599c7ded1887061cbf44397409651f5c5"

URI_aarch64_qt5-qtserialbus-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtserialbus-doc-5.15.16-2.el10_1.noarch.rpm;name=aarch64_qt5-qtserialbus-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtserialbus-doc}"
SRC_URI[aarch64_qt5-qtserialbus-doc.sha256sum] = "ba49ebe17cf2050a550484b4bed86c28ea1a281d5cccbdf19cf2726e1e1d9347"

URI_aarch64_qt5-qtserialport-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtserialport-doc-5.15.16-2.el10_1.noarch.rpm;name=aarch64_qt5-qtserialport-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtserialport-doc}"
SRC_URI[aarch64_qt5-qtserialport-doc.sha256sum] = "b494df2a1ec87d0b442b2b5043af9ae1e81b474841231b7200a5fd064d9863ad"

URI_aarch64_qt5-qtspeech-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtspeech-doc-5.15.16-2.el10_1.noarch.rpm;name=aarch64_qt5-qtspeech-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtspeech-doc}"
SRC_URI[aarch64_qt5-qtspeech-doc.sha256sum] = "9decf1ce8d0d48e8c88c54c00e3e0311a25d0975bd3dd5ce255b5c7633f9e0bf"

URI_aarch64_qt5-qtsvg-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtsvg-doc-5.15.16-2.el10_1.noarch.rpm;name=aarch64_qt5-qtsvg-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtsvg-doc}"
SRC_URI[aarch64_qt5-qtsvg-doc.sha256sum] = "442f8963af9f5545f20f06160f16c9f39081bd051694e5e0582e4c839516a4ed"

URI_aarch64_qt5-qttools-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-doc-5.15.16-2.el10_1.noarch.rpm;name=aarch64_qt5-qttools-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qttools-doc}"
SRC_URI[aarch64_qt5-qttools-doc.sha256sum] = "61327601350b201cf2af8de2a445d763a3057999b8ac6343f5171753aecd9e2b"

URI_aarch64_qt5-qtvirtualkeyboard-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtvirtualkeyboard-doc-5.15.16-2.el10_1.noarch.rpm;name=aarch64_qt5-qtvirtualkeyboard-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtvirtualkeyboard-doc}"
SRC_URI[aarch64_qt5-qtvirtualkeyboard-doc.sha256sum] = "ee554d35cb2eb171ff9956c717d237c0bd530532b360bfdf053a1031c07b5564"

URI_aarch64_qt5-qtwayland-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwayland-doc-5.15.16-2.el10_1.noarch.rpm;name=aarch64_qt5-qtwayland-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwayland-doc}"
SRC_URI[aarch64_qt5-qtwayland-doc.sha256sum] = "f889b3ce788b1b0640748968e6000e21ad593e3ff85922ca5df2224d91212fb5"

URI_aarch64_qt5-qtwebchannel-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwebchannel-doc-5.15.16-2.el10_1.noarch.rpm;name=aarch64_qt5-qtwebchannel-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwebchannel-doc}"
SRC_URI[aarch64_qt5-qtwebchannel-doc.sha256sum] = "5b8edd1762c53f3afaf95d825ff657eace6d69ef28864880b3afd98be5e8f677"

URI_aarch64_qt5-qtwebsockets-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwebsockets-doc-5.15.16-2.el10_1.noarch.rpm;name=aarch64_qt5-qtwebsockets-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwebsockets-doc}"
SRC_URI[aarch64_qt5-qtwebsockets-doc.sha256sum] = "a37ccb84da45b5d87c02cfed54ac88eb52a5391c911428ad8964a6818c9e05b7"

URI_aarch64_qt5-qtwebview-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwebview-doc-5.15.16-2.el10_1.noarch.rpm;name=aarch64_qt5-qtwebview-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwebview-doc}"
SRC_URI[aarch64_qt5-qtwebview-doc.sha256sum] = "95f1ca66fbb959b206ec860db803a16c5f9effade9524c6b29d74ababbf5e98e"

URI_aarch64_qt5-qtx11extras-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtx11extras-doc-5.15.16-2.el10_1.noarch.rpm;name=aarch64_qt5-qtx11extras-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtx11extras-doc}"
SRC_URI[aarch64_qt5-qtx11extras-doc.sha256sum] = "83e32fdefc046fa747ace9b677008592c41484b91e2e2732ef4fbb5f3dc7ba21"

URI_aarch64_qt5-qtxmlpatterns-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtxmlpatterns-doc-5.15.16-2.el10_1.noarch.rpm;name=aarch64_qt5-qtxmlpatterns-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtxmlpatterns-doc}"
SRC_URI[aarch64_qt5-qtxmlpatterns-doc.sha256sum] = "a2b0799604a2eb363ec5b294a138247fcc0729be504ca2c47cc3ae420bcdbfe4"

RDEPENDS:qt5-doc = " \
 qt5-qt3d-doc \
 qt5-qtbase-doc \
 qt5-qtcharts-doc \
 qt5-qtconnectivity-doc \
 qt5-qtdatavis3d-doc \
 qt5-qtdeclarative-doc \
 qt5-qtgamepad-doc \
 qt5-qtgraphicaleffects-doc \
 qt5-qtimageformats-doc \
 qt5-qtlocation-doc \
 qt5-qtmultimedia-doc \
 qt5-qtpurchasing-doc \
 qt5-qtquickcontrols-doc \
 qt5-qtquickcontrols2-doc \
 qt5-qtremoteobjects-doc \
 qt5-qtscript-doc \
 qt5-qtscxml-doc \
 qt5-qtsensors-doc \
 qt5-qtserialbus-doc \
 qt5-qtserialport-doc \
 qt5-qtspeech-doc \
 qt5-qtsvg-doc \
 qt5-qttools-doc \
 qt5-qtvirtualkeyboard-doc \
 qt5-qtwayland-doc \
 qt5-qtwebchannel-doc \
 qt5-qtwebsockets-doc \
 qt5-qtwebview-doc \
 qt5-qtx11extras-doc \
 qt5-qtxmlpatterns-doc \
 "
RDEPENDS:qt5-qt3d-doc = " \
 "
RDEPENDS:qt5-qtbase-doc = " \
 "
RDEPENDS:qt5-qtcharts-doc = " \
 "
RDEPENDS:qt5-qtconnectivity-doc = " \
 "
RDEPENDS:qt5-qtdatavis3d-doc = " \
 "
RDEPENDS:qt5-qtdeclarative-doc = " \
 "
RDEPENDS:qt5-qtgamepad-doc = " \
 "
RDEPENDS:qt5-qtgraphicaleffects-doc = " \
 "
RDEPENDS:qt5-qtimageformats-doc = " \
 "
RDEPENDS:qt5-qtlocation-doc = " \
 "
RDEPENDS:qt5-qtmultimedia-doc = " \
 "
RDEPENDS:qt5-qtpurchasing-doc = " \
 "
RDEPENDS:qt5-qtquickcontrols-doc = " \
 "
RDEPENDS:qt5-qtquickcontrols2-doc = " \
 "
RDEPENDS:qt5-qtremoteobjects-doc = " \
 "
RDEPENDS:qt5-qtscript-doc = " \
 "
RDEPENDS:qt5-qtscxml-doc = " \
 "
RDEPENDS:qt5-qtsensors-doc = " \
 "
RDEPENDS:qt5-qtserialbus-doc = " \
 "
RDEPENDS:qt5-qtserialport-doc = " \
 "
RDEPENDS:qt5-qtspeech-doc = " \
 "
RDEPENDS:qt5-qtsvg-doc = " \
 "
RDEPENDS:qt5-qttools-doc = " \
 "
RDEPENDS:qt5-qtvirtualkeyboard-doc = " \
 "
RDEPENDS:qt5-qtwayland-doc = " \
 "
RDEPENDS:qt5-qtwebchannel-doc = " \
 "
RDEPENDS:qt5-qtwebsockets-doc = " \
 "
RDEPENDS:qt5-qtwebview-doc = " \
 "
RDEPENDS:qt5-qtx11extras-doc = " \
 "
RDEPENDS:qt5-qtxmlpatterns-doc = " \
 "
