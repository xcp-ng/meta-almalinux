# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-rpm-macros"
PV = "2.9.3"
PR = "1.el10_2"
PACKAGES = " \
 ghc-rpm-macros \
 ghc-rpm-macros-extra \
 ghc-rpm-macros-quick \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-rpm-macros-2.9.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e67104ef1e4036e2dfc74a3962fa5e2d6ade63d885a5b80d8f787d76b276215a"

URI_x86_64_v2_ghc-rpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-rpm-macros-2.9.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-rpm-macros}"
SRC_URI[x86_64_v2_ghc-rpm-macros.sha256sum] = "d9a8f94ef3243da47c1f9e84fe61c48099811afc5aa6254ca76e3b037b3af5c9"

URI_x86_64_v2_ghc-rpm-macros-extra = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-rpm-macros-extra-2.9.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-rpm-macros-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-rpm-macros-extra}"
SRC_URI[x86_64_v2_ghc-rpm-macros-extra.sha256sum] = "78da36771cfee3536453c6b3297021a1c63547cd22fd32be745649ce4f6d27d6"

URI_x86_64_v2_ghc-rpm-macros-quick = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-rpm-macros-quick-2.9.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-rpm-macros-quick;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-rpm-macros-quick}"
SRC_URI[x86_64_v2_ghc-rpm-macros-quick.sha256sum] = "c891e5e6b6dd2eb924bcc737e3008df31e392bac5a4a38b5d20eee425762f6c9"

URI_aarch64_ghc-rpm-macros = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-rpm-macros-2.9.3-1.el10_2.noarch.rpm;name=aarch64_ghc-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-rpm-macros}"
SRC_URI[aarch64_ghc-rpm-macros.sha256sum] = "a55bbdcefab936d040aedac38c43872083bf2c1d13246c7228895ea83315f57f"

URI_aarch64_ghc-rpm-macros-extra = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-rpm-macros-extra-2.9.3-1.el10_2.noarch.rpm;name=aarch64_ghc-rpm-macros-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-rpm-macros-extra}"
SRC_URI[aarch64_ghc-rpm-macros-extra.sha256sum] = "ca6a0f873332fce07cf0401ac9378709dd51761677876dd60a20ba7e14d958b7"

URI_aarch64_ghc-rpm-macros-quick = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-rpm-macros-quick-2.9.3-1.el10_2.noarch.rpm;name=aarch64_ghc-rpm-macros-quick;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-rpm-macros-quick}"
SRC_URI[aarch64_ghc-rpm-macros-quick.sha256sum] = "40bd6f77e86464d4e9aabf37cca89cb6f8b1e1e9824dafad1bf73b4146d60f2e"

RDEPENDS:ghc-rpm-macros = " \
 bash \
 chrpath \
 redhat-rpm-config \
 "
RDEPENDS:ghc-rpm-macros-extra = " \
 ghc-rpm-macros \
 "
RDEPENDS:ghc-rpm-macros-quick = " \
 ghc-rpm-macros \
 "
