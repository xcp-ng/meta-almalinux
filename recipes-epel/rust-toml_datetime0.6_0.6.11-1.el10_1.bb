# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-toml_datetime0.6"
PV = "0.6.11"
PR = "1.el10_1"
PACKAGES = " \
 rust-toml_datetime0.6+default-devel \
 rust-toml_datetime0.6+serde-devel \
 rust-toml_datetime0.6-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-toml_datetime0.6-0.6.11-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "dd3fe3a3c374612b00cddebb5a56699db74fa9ef4563fc767b46ce49668ed9e5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_datetime0.6+default-devel-0.6.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_datetime0.6+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-toml_datetime0.6+default-devel.sha256sum] = "86b7861e756385b20713a5c0289c5d4937a3451eeb60a6ffc85939e3b0b4f2a8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_datetime0.6+serde-devel-0.6.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_datetime0.6+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-toml_datetime0.6+serde-devel.sha256sum] = "dcbe9380f03fdd157ec32dca1ecef78bdd72d13b198ca3e62396ec490560f042"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_datetime0.6-devel-0.6.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_datetime0.6-devel;unpack=0"
SRC_URI[x86_64_v2_rust-toml_datetime0.6-devel.sha256sum] = "8efaca32aea85b44da6a428a2ac92ddaa9d5b3c4b35de9aa0253bfdec88b8c64"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_datetime0.6+default-devel-0.6.11-1.el10_1.noarch.rpm;name=aarch64_rust-toml_datetime0.6+default-devel;unpack=0"
SRC_URI[aarch64_rust-toml_datetime0.6+default-devel.sha256sum] = "009bfcf6f12a6e6207dc9f3a4fc844be506aeeb4fda7ba0e229a2aef41b430ff"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_datetime0.6+serde-devel-0.6.11-1.el10_1.noarch.rpm;name=aarch64_rust-toml_datetime0.6+serde-devel;unpack=0"
SRC_URI[aarch64_rust-toml_datetime0.6+serde-devel.sha256sum] = "2dfd5052d5de930dc3035c831b0b131c4e9071d4d0a51a9a0f34d4f0604874cc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_datetime0.6-devel-0.6.11-1.el10_1.noarch.rpm;name=aarch64_rust-toml_datetime0.6-devel;unpack=0"
SRC_URI[aarch64_rust-toml_datetime0.6-devel.sha256sum] = "dd985a747669b9cc06d275d240bac6ffce919a7140dcb0c73f97b89f54ffb658"

RDEPENDS:rust-toml_datetime0.6+default-devel = " \
 cargo \
 rust-toml_datetime0.6-devel \
 "
RDEPENDS:rust-toml_datetime0.6+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-toml_datetime0.6-devel \
 "
RDEPENDS:rust-toml_datetime0.6-devel = " \
 cargo \
 rust \
 "
