# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-inventory"
PV = "0.3.22"
PR = "1.el10_1"
PACKAGES = " \
 rust-inventory+default-devel \
 rust-inventory-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-inventory-0.3.22-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3fa24227e016f99b6f4007116601dd3d38fe852ede2aedea145d68d18fcd018e"

URI_x86_64_v2_rust-inventory+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inventory+default-devel-0.3.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inventory+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inventory+default-devel}"
SRC_URI[x86_64_v2_rust-inventory+default-devel.sha256sum] = "bf77b07fb6e07c6e5dcac4b541631eadad7ccc11986a989dec87e7d1f675ae18"

URI_x86_64_v2_rust-inventory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inventory-devel-0.3.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inventory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inventory-devel}"
SRC_URI[x86_64_v2_rust-inventory-devel.sha256sum] = "e867dca56459c1086733184c1813efbab953ddc242d5ff070025323c741b1b10"

URI_aarch64_rust-inventory+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inventory+default-devel-0.3.22-1.el10_1.noarch.rpm;name=aarch64_rust-inventory+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inventory+default-devel}"
SRC_URI[aarch64_rust-inventory+default-devel.sha256sum] = "da719e15c491abf2fa2bd02ad4f946d149cf84450460e9b88ab3f25081ee1a4b"

URI_aarch64_rust-inventory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inventory-devel-0.3.22-1.el10_1.noarch.rpm;name=aarch64_rust-inventory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inventory-devel}"
SRC_URI[aarch64_rust-inventory-devel.sha256sum] = "16a5e04e2edc6946ea97a4c36b04461cf246c1cce9e9043fa995c84ba4c008c2"

RDEPENDS:rust-inventory+default-devel = " \
 cargo \
 rust-inventory-devel \
 "
RDEPENDS:rust-inventory-devel = " \
 cargo \
 rust \
 "
