# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opari2"
PV = "2.0.10"
PR = "1.el10_3"
PACKAGES = " \
 opari2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/opari2-2.0.10-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b86d2b3f2702037f44362b8d42e135a72a983d5d790115a007a2c97bcaaee701"

URI_x86_64_v2_opari2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opari2-2.0.10-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opari2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opari2}"
SRC_URI[x86_64_v2_opari2.sha256sum] = "6051cf9009349418523ceb013c28f98829219d1aa2a67de4517e1976434c0f24"

URI_aarch64_opari2 = "${EPEL_MIRROR}/aarch64/Packages/o/opari2-2.0.10-1.el10_3.aarch64.rpm;name=aarch64_opari2;unpack=0"
SRC_URI:append = " ${URI_aarch64_opari2}"
SRC_URI[aarch64_opari2.sha256sum] = "55be3595854a0e4cf499aa586c05a22368b7a8693296423210a9d12550fde75d"

RDEPENDS:opari2 = " \
 gawk \
 glibc \
 libgcc \
 libstdc++ \
 "
