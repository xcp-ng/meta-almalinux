# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-weezl"
PV = "0.1.10"
PR = "1.el10_0"
PACKAGES = " \
 rust-weezl+alloc-devel \
 rust-weezl+async-devel \
 rust-weezl+default-devel \
 rust-weezl+futures-devel \
 rust-weezl+std-devel \
 rust-weezl-devel \
 weezl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-weezl-0.1.10-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "464e5e1becd16a2d8f000f28527b8ab6bedb87cb22236403d520269b582d418a"

URI_x86_64_v2_rust-weezl+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-weezl+alloc-devel-0.1.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-weezl+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-weezl+alloc-devel}"
SRC_URI[x86_64_v2_rust-weezl+alloc-devel.sha256sum] = "15be69fad8aaa1a6ed0d4348901814be0e0d07d7a9a568ff4d01970fedf5a889"

URI_x86_64_v2_rust-weezl+async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-weezl+async-devel-0.1.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-weezl+async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-weezl+async-devel}"
SRC_URI[x86_64_v2_rust-weezl+async-devel.sha256sum] = "e77edd3ae9d865bd6f7bfeb2f735fc4ade3c75c6150b4ec749309fedb1d59259"

URI_x86_64_v2_rust-weezl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-weezl+default-devel-0.1.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-weezl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-weezl+default-devel}"
SRC_URI[x86_64_v2_rust-weezl+default-devel.sha256sum] = "e4f7e70832c434c0df5529a8891477b933d6d4436f49e7f6bf93c2fca906dbab"

URI_x86_64_v2_rust-weezl+futures-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-weezl+futures-devel-0.1.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-weezl+futures-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-weezl+futures-devel}"
SRC_URI[x86_64_v2_rust-weezl+futures-devel.sha256sum] = "cbd91baa906ccc4b306bbe1484e535cb580c98ee7355a6a7a76395297ab20d61"

URI_x86_64_v2_rust-weezl+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-weezl+std-devel-0.1.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-weezl+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-weezl+std-devel}"
SRC_URI[x86_64_v2_rust-weezl+std-devel.sha256sum] = "b1a1c29f800ddfb369dc1d4a547c04e3f3536dc5b785d06181fd834c17adb078"

URI_x86_64_v2_rust-weezl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-weezl-devel-0.1.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-weezl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-weezl-devel}"
SRC_URI[x86_64_v2_rust-weezl-devel.sha256sum] = "6b6ac5674e6d697ea0e8c95b11ec169cb386f118f51d36be986b95b2c03659d7"

URI_x86_64_v2_weezl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/weezl-0.1.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_weezl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_weezl}"
SRC_URI[x86_64_v2_weezl.sha256sum] = "c2d6cffe4ee5c89f0c626084e01746d4a45d3b98e6bcf8fa9046e2046c4947a7"

URI_aarch64_rust-weezl+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-weezl+alloc-devel-0.1.10-1.el10_0.noarch.rpm;name=aarch64_rust-weezl+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-weezl+alloc-devel}"
SRC_URI[aarch64_rust-weezl+alloc-devel.sha256sum] = "13a16c20f844880b7da59a0dc8f565928ada1e391b8b0144a98177b401b4b6fd"

URI_aarch64_rust-weezl+async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-weezl+async-devel-0.1.10-1.el10_0.noarch.rpm;name=aarch64_rust-weezl+async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-weezl+async-devel}"
SRC_URI[aarch64_rust-weezl+async-devel.sha256sum] = "98b91fee0a2a06fbefbe71471636e215f03e87bf400d7f6a75bdf152c96f99e1"

URI_aarch64_rust-weezl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-weezl+default-devel-0.1.10-1.el10_0.noarch.rpm;name=aarch64_rust-weezl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-weezl+default-devel}"
SRC_URI[aarch64_rust-weezl+default-devel.sha256sum] = "72fa82fdab09e2bedf3dbdaca3fddbbe088efed63a5263cdb4857e5a8d0369af"

URI_aarch64_rust-weezl+futures-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-weezl+futures-devel-0.1.10-1.el10_0.noarch.rpm;name=aarch64_rust-weezl+futures-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-weezl+futures-devel}"
SRC_URI[aarch64_rust-weezl+futures-devel.sha256sum] = "d128d1b7a56e259fa1d56315d39982e1069e9b2af0413dc2938417e03b8a2309"

URI_aarch64_rust-weezl+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-weezl+std-devel-0.1.10-1.el10_0.noarch.rpm;name=aarch64_rust-weezl+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-weezl+std-devel}"
SRC_URI[aarch64_rust-weezl+std-devel.sha256sum] = "87e3749a9f81bed9d3d041e847c2f3fc71c6ee3cd558e09da31f4a83839ce9fc"

URI_aarch64_rust-weezl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-weezl-devel-0.1.10-1.el10_0.noarch.rpm;name=aarch64_rust-weezl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-weezl-devel}"
SRC_URI[aarch64_rust-weezl-devel.sha256sum] = "546ee7b82ed0a7e923b51c47d21335d3598e443788db3cb091219440b0e74d1f"

URI_aarch64_weezl = "${EPEL_MIRROR}/aarch64/Packages/w/weezl-0.1.10-1.el10_0.aarch64.rpm;name=aarch64_weezl;unpack=0"
SRC_URI:append = " ${URI_aarch64_weezl}"
SRC_URI[aarch64_weezl.sha256sum] = "de44a0fbdd05192985fa271778064c0dc5cf96f31361314827fdf0bdda94468e"

RDEPENDS:rust-weezl+alloc-devel = " \
 cargo \
 rust-weezl-devel \
 "
RDEPENDS:rust-weezl+async-devel = " \
 cargo \
 rust-weezl+futures-devel \
 rust-weezl+std-devel \
 rust-weezl-devel \
 "
RDEPENDS:rust-weezl+default-devel = " \
 cargo \
 rust-weezl+std-devel \
 rust-weezl-devel \
 "
RDEPENDS:rust-weezl+futures-devel = " \
 cargo \
 rust-futures+std-devel \
 rust-futures-devel \
 rust-weezl-devel \
 "
RDEPENDS:rust-weezl+std-devel = " \
 cargo \
 rust-weezl+alloc-devel \
 rust-weezl-devel \
 "
RDEPENDS:rust-weezl-devel = " \
 cargo \
 "
RDEPENDS:weezl = " \
 glibc \
 libgcc \
 "
