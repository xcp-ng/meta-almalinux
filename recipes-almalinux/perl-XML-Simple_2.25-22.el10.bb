# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-XML-Simple"
PV = "2.25"
PR = "22.el10"
PACKAGES = " \
 perl-XML-Simple \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-XML-Simple-2.25-22.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "082af027166ea6b37fedb06d55b863474f99deaefa6f8ad9657ac83c92e4f712"

URI_x86_64_v2_perl-XML-Simple = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-XML-Simple-2.25-22.el10.noarch.rpm;name=x86_64_v2_perl-XML-Simple;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XML-Simple}"
SRC_URI[x86_64_v2_perl-XML-Simple.sha256sum] = "74ab4e61af54d73fc4bb18eee4fa573d5c9d59a68ee3a278918d006e607c8f8c"

URI_aarch64_perl-XML-Simple = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-XML-Simple-2.25-22.el10.noarch.rpm;name=aarch64_perl-XML-Simple;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XML-Simple}"
SRC_URI[aarch64_perl-XML-Simple.sha256sum] = "74ab4e61af54d73fc4bb18eee4fa573d5c9d59a68ee3a278918d006e607c8f8c"

RDEPENDS:perl-XML-Simple = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Basename \
 perl-IO \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-XML-NamespaceSupport \
 perl-XML-Parser \
 perl-XML-SAX \
 perl-libs \
 perl-vars \
 "
