# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3-lxc"
PV = "5.0.0"
PR = "14.el10_0"
PACKAGES = " \
 python3-lxc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python3-lxc-5.0.0-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee9907dddf2a0a757bb4bcde725e51648df70fdb068dccadd85e403621368dee"

URI_x86_64_v2_python3-lxc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-lxc-5.0.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-lxc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lxc}"
SRC_URI[x86_64_v2_python3-lxc.sha256sum] = "2684a08225061a2c54087e4f4072334518b9ea795134f6f8bd3f226576c53c0c"

URI_aarch64_python3-lxc = "${EPEL_MIRROR}/aarch64/Packages/p/python3-lxc-5.0.0-14.el10_0.aarch64.rpm;name=aarch64_python3-lxc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lxc}"
SRC_URI[aarch64_python3-lxc.sha256sum] = "2c6ba82ec32755469d98090a5b9f99e5ab6cc15c2b702b9d7b9fdbee743cc26f"

RDEPENDS:python3-lxc = " \
 glibc \
 lxc-libs \
 python3 \
 "
