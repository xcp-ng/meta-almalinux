# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-moka"
PV = "0.12.16"
PR = "1.el10_3"
PACKAGES = " \
 rust-moka+default-devel \
 rust-moka+future-devel \
 rust-moka+logging-devel \
 rust-moka+quanta-devel \
 rust-moka+sync-devel \
 rust-moka-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-moka-0.12.16-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "dc064a8f17e0b3cd151bda5d02720a5396667570f52e6bae3d39e626cffd31d6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moka+default-devel-0.12.16-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moka+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-moka+default-devel.sha256sum] = "860a10b3f927779dae6cdf7e1376944916c72ec5b8c4cf62aff2e67e18579afe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moka+future-devel-0.12.16-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moka+future-devel;unpack=0"
SRC_URI[x86_64_v2_rust-moka+future-devel.sha256sum] = "607cc779bbb1b673c38156670dc86cce446eb65865ba1a001c61965691ae9379"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moka+logging-devel-0.12.16-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moka+logging-devel;unpack=0"
SRC_URI[x86_64_v2_rust-moka+logging-devel.sha256sum] = "cacca455ee04cfac5ad4f067a32b57b7cfbf58fb4a0cf071fdf55dae7076bc7c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moka+quanta-devel-0.12.16-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moka+quanta-devel;unpack=0"
SRC_URI[x86_64_v2_rust-moka+quanta-devel.sha256sum] = "ccb2e5274aa47e0838a5060050386ff57caf5314def33407356a9b9a86915479"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moka+sync-devel-0.12.16-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moka+sync-devel;unpack=0"
SRC_URI[x86_64_v2_rust-moka+sync-devel.sha256sum] = "7382db8a7ede9849f0b6d82941e46d0b51cb64f9ae65ceac2d8d841e0b8b238d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moka-devel-0.12.16-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moka-devel;unpack=0"
SRC_URI[x86_64_v2_rust-moka-devel.sha256sum] = "2f9439d8d30001a26c8e9bc88e6fc610fcad6ea6e51f54f6c3039e12eab0ed11"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-moka+default-devel-0.12.16-1.el10_3.noarch.rpm;name=aarch64_rust-moka+default-devel;unpack=0"
SRC_URI[aarch64_rust-moka+default-devel.sha256sum] = "01cf6957f53407db34ac6408bc5c3d3d6d94d00e39e000a0a6f8345df4828200"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-moka+future-devel-0.12.16-1.el10_3.noarch.rpm;name=aarch64_rust-moka+future-devel;unpack=0"
SRC_URI[aarch64_rust-moka+future-devel.sha256sum] = "194fe61f2e67258e0aeb9f04ab5ad5a2965b527306fc1ad71a12a1a006759229"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-moka+logging-devel-0.12.16-1.el10_3.noarch.rpm;name=aarch64_rust-moka+logging-devel;unpack=0"
SRC_URI[aarch64_rust-moka+logging-devel.sha256sum] = "6f9e61ab6c49f3fec6ec857cfdc13d8da19ced55a0b595cee978fd4cee8a28f4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-moka+quanta-devel-0.12.16-1.el10_3.noarch.rpm;name=aarch64_rust-moka+quanta-devel;unpack=0"
SRC_URI[aarch64_rust-moka+quanta-devel.sha256sum] = "a650e9d47a44f0adcfc01378e2ddaa46bdb19e37dc15e45cccd81b5205998f4a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-moka+sync-devel-0.12.16-1.el10_3.noarch.rpm;name=aarch64_rust-moka+sync-devel;unpack=0"
SRC_URI[aarch64_rust-moka+sync-devel.sha256sum] = "412b28775681f3ef84bfd8d270c2f4ba043e90ac31a9558040a94d48909a9fed"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-moka-devel-0.12.16-1.el10_3.noarch.rpm;name=aarch64_rust-moka-devel;unpack=0"
SRC_URI[aarch64_rust-moka-devel.sha256sum] = "1ca01de00231730b321cdf272bbb00d9bdd232b0cf785cc8946d1715a312adbb"

RDEPENDS:rust-moka+default-devel = " \
 cargo \
 rust-moka-devel \
 "
RDEPENDS:rust-moka+future-devel = " \
 cargo \
 rust-async-lock+default-devel \
 rust-event-listener+default-devel \
 rust-futures-util+default-devel \
 rust-moka-devel \
 "
RDEPENDS:rust-moka+logging-devel = " \
 cargo \
 rust-log+default-devel \
 rust-moka-devel \
 "
RDEPENDS:rust-moka+quanta-devel = " \
 cargo \
 rust-moka-devel \
 rust-quanta+default-devel \
 "
RDEPENDS:rust-moka+sync-devel = " \
 cargo \
 rust-moka-devel \
 "
RDEPENDS:rust-moka-devel = " \
 cargo \
 rust \
 rust-crossbeam-channel+default-devel \
 rust-crossbeam-epoch+default-devel \
 rust-crossbeam-utils+default-devel \
 rust-equivalent+default-devel \
 rust-parking_lot+default-devel \
 rust-portable-atomic+default-devel \
 rust-smallvec+default-devel \
 rust-tagptr+default-devel \
 rust-uuid+default-devel \
 rust-uuid+v4-devel \
 "
