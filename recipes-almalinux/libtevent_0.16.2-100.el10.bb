# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libtevent"
PV = "0.16.2"
PR = "100.el10"
PACKAGES = " \
 libtevent \
 libtevent-devel \
 python3-tevent \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libtevent-0.16.2-100.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ef825c672d2ea07726c8967e2a2d24e9978b2f84eae0a236c6e5febdcefd01a5"

URI_x86_64_v2_libtevent = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libtevent-0.16.2-100.el10.x86_64_v2.rpm;name=x86_64_v2_libtevent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtevent}"
SRC_URI[x86_64_v2_libtevent.sha256sum] = "a3d789436dba3e55fb377d7d3d1c53e0b22efdb289ddaa800277bbac3e4a033a"

URI_x86_64_v2_libtevent-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libtevent-devel-0.16.2-100.el10.x86_64_v2.rpm;name=x86_64_v2_libtevent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtevent-devel}"
SRC_URI[x86_64_v2_libtevent-devel.sha256sum] = "c5238f0656dff50ec2cd431be2418cedcbb813db82ed7d6efee47201b0400386"

URI_x86_64_v2_python3-tevent = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-tevent-0.16.2-100.el10.x86_64_v2.rpm;name=x86_64_v2_python3-tevent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tevent}"
SRC_URI[x86_64_v2_python3-tevent.sha256sum] = "866f03ab20b3c6c2bc0c0d2506c7dce07a1b463e33395d5d2ecf40803dccec92"

URI_aarch64_libtevent = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libtevent-0.16.2-100.el10.aarch64.rpm;name=aarch64_libtevent;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtevent}"
SRC_URI[aarch64_libtevent.sha256sum] = "db356ac47ea81124c45d352e06de019191429159e04f07c91e74912178aa1c72"

URI_aarch64_libtevent-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libtevent-devel-0.16.2-100.el10.aarch64.rpm;name=aarch64_libtevent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtevent-devel}"
SRC_URI[aarch64_libtevent-devel.sha256sum] = "c92fd41935fec207f94a90de706b1d37d31ad0f6f043b880006f0b0bbbcbe8a7"

URI_aarch64_python3-tevent = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-tevent-0.16.2-100.el10.aarch64.rpm;name=aarch64_python3-tevent;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tevent}"
SRC_URI[aarch64_python3-tevent.sha256sum] = "24378f36c9da510d1cd0d0073bba14204d8984a6b724a1b0d650759e11d1e878"

RDEPENDS:libtevent = " \
 glibc \
 libtalloc \
 "
RDEPENDS:libtevent-devel = " \
 libtalloc-devel \
 libtevent \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-tevent = " \
 glibc \
 libtalloc \
 libtevent \
 python3 \
 "
