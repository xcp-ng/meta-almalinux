# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-http-range-header"
PV = "0.4.2"
PR = "2.el10_0"
PACKAGES = " \
 rust-http-range-header+default-devel \
 rust-http-range-header-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-http-range-header-0.4.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "533a97091ccc85421c10b672704717b36435bb3fc2bb102485f6f5ccec619108"

URI_x86_64_v2_rust-http-range-header+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-range-header+default-devel-0.4.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-range-header+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-range-header+default-devel}"
SRC_URI[x86_64_v2_rust-http-range-header+default-devel.sha256sum] = "3ad20eb8899931e5c687658c6046437127c8a696b5b41b3ac771de238237b695"

URI_x86_64_v2_rust-http-range-header-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-range-header-devel-0.4.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-range-header-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-range-header-devel}"
SRC_URI[x86_64_v2_rust-http-range-header-devel.sha256sum] = "abfefd153bc4fa7d50c580d082cd785e77ec90988b4b2925f9e022df0df5bf90"

URI_aarch64_rust-http-range-header+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-range-header+default-devel-0.4.2-2.el10_0.noarch.rpm;name=aarch64_rust-http-range-header+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-range-header+default-devel}"
SRC_URI[aarch64_rust-http-range-header+default-devel.sha256sum] = "7ead9c99b883389b86a863fa4ebf7749e308057c26dd81ad92103ec82e37a75e"

URI_aarch64_rust-http-range-header-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-range-header-devel-0.4.2-2.el10_0.noarch.rpm;name=aarch64_rust-http-range-header-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-range-header-devel}"
SRC_URI[aarch64_rust-http-range-header-devel.sha256sum] = "b1c2d160bcc32a95796010b1032d9c599c3ef72a08f08c71a3a024ed18a6c685"

RDEPENDS:rust-http-range-header+default-devel = " \
 cargo \
 rust-http-range-header-devel \
 "
RDEPENDS:rust-http-range-header-devel = " \
 cargo \
 "
