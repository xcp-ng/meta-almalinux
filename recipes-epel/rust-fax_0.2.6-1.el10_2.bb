# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fax"
PV = "0.2.6"
PR = "1.el10_2"
PACKAGES = " \
 rust-fax+debug-devel \
 rust-fax+default-devel \
 rust-fax-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fax-0.2.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e7e0aadadd7c5794cf6f91b74cc204e65d74e24784f99e43a349c391571dfc87"

URI_x86_64_v2_rust-fax+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fax+debug-devel-0.2.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fax+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fax+debug-devel}"
SRC_URI[x86_64_v2_rust-fax+debug-devel.sha256sum] = "404744bc96f1b075039409e3347755a5a7b81c68e4ad21573f5e2f07a1a6bd60"

URI_x86_64_v2_rust-fax+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fax+default-devel-0.2.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fax+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fax+default-devel}"
SRC_URI[x86_64_v2_rust-fax+default-devel.sha256sum] = "6456d58056d660e94848ffb4d06a0a5f9571d4a7c776ddd393479ec086a43b41"

URI_x86_64_v2_rust-fax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fax-devel-0.2.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fax-devel}"
SRC_URI[x86_64_v2_rust-fax-devel.sha256sum] = "aa59fc5c4ef2af1cce55bb5d5f2c7be8c1b82a6c24b4d63654ebdeca704a9048"

URI_aarch64_rust-fax+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fax+debug-devel-0.2.6-1.el10_2.noarch.rpm;name=aarch64_rust-fax+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fax+debug-devel}"
SRC_URI[aarch64_rust-fax+debug-devel.sha256sum] = "d9babd3bab3abf633674ce3122edafbb3b8259713a10c674d8cab16e60b3cddf"

URI_aarch64_rust-fax+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fax+default-devel-0.2.6-1.el10_2.noarch.rpm;name=aarch64_rust-fax+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fax+default-devel}"
SRC_URI[aarch64_rust-fax+default-devel.sha256sum] = "e99d3fbb3276e0b28d1e3276402e7e3ad54a8d878277da89c07046f2254f69b5"

URI_aarch64_rust-fax-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fax-devel-0.2.6-1.el10_2.noarch.rpm;name=aarch64_rust-fax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fax-devel}"
SRC_URI[aarch64_rust-fax-devel.sha256sum] = "5fa78210d029088a653acecdcb4692b3a6f65d43e0cc24e6d83accb6c7c3e779"

RDEPENDS:rust-fax+debug-devel = " \
 cargo \
 rust-fax-devel \
 "
RDEPENDS:rust-fax+default-devel = " \
 cargo \
 rust-fax-devel \
 "
RDEPENDS:rust-fax-devel = " \
 cargo \
 rust-fax_derive+default-devel \
 "
