# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_hostname"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_hostname+default-devel \
 rust-uu_hostname-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_hostname-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d42267f51c29aab9b9f2666ea2c8463ada29e8f89fbbf5a8724b916443bf98cd"

URI_x86_64_v2_rust-uu_hostname+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_hostname+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_hostname+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_hostname+default-devel}"
SRC_URI[x86_64_v2_rust-uu_hostname+default-devel.sha256sum] = "655ba153b93bbe9df222c46629afdd7c9e5f82bc0c4e1b06eaea6b08782b8a52"

URI_x86_64_v2_rust-uu_hostname-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_hostname-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_hostname-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_hostname-devel}"
SRC_URI[x86_64_v2_rust-uu_hostname-devel.sha256sum] = "89ac6cfac324ad49b09cf08ad1b40e641d50d3decca0b5eaed57301054d7bf58"

URI_aarch64_rust-uu_hostname+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_hostname+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_hostname+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_hostname+default-devel}"
SRC_URI[aarch64_rust-uu_hostname+default-devel.sha256sum] = "a78b552937482e042a7d29ce8ff342f5b84a0aa952312954406fbbb2fb9b0c09"

URI_aarch64_rust-uu_hostname-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_hostname-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_hostname-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_hostname-devel}"
SRC_URI[aarch64_rust-uu_hostname-devel.sha256sum] = "cfa8d2e5bed62002bcc0862273ca63cebae1a48c20a975c58f3b76b8de98009d"

RDEPENDS:rust-uu_hostname+default-devel = " \
 cargo \
 rust-uu_hostname-devel \
 "
RDEPENDS:rust-uu_hostname-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-hostname+default-devel \
 rust-hostname+set-devel \
 rust-uucore+default-devel \
 rust-uucore+wide-devel \
 "
