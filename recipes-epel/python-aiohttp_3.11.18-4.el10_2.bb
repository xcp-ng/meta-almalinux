# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-aiohttp"
PV = "3.11.18"
PR = "4.el10_2"
PACKAGES = " \
 python3-aiohttp \
 python3-aiohttp+speedups \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-aiohttp-3.11.18-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab92981fd67257d6e19d4d1fd4026e283312e73020f8f6d234f45e27131d43d1"

URI_x86_64_v2_python3-aiohttp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-aiohttp-3.11.18-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-aiohttp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-aiohttp}"
SRC_URI[x86_64_v2_python3-aiohttp.sha256sum] = "1137760cbb25796f467bb0199438e4dc90433b4f27e8df24058c30f58dfb85bb"

URI_x86_64_v2_python3-aiohttp+speedups = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-aiohttp+speedups-3.11.18-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-aiohttp+speedups;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-aiohttp+speedups}"
SRC_URI[x86_64_v2_python3-aiohttp+speedups.sha256sum] = "12af395f56cbc52295e78d4dcbabb8428ea1300ddd432c8eceedd432b3dd9d28"

URI_aarch64_python3-aiohttp = "${EPEL_MIRROR}/aarch64/Packages/p/python3-aiohttp-3.11.18-4.el10_2.aarch64.rpm;name=aarch64_python3-aiohttp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-aiohttp}"
SRC_URI[aarch64_python3-aiohttp.sha256sum] = "f4870831cbcbbed5cbd3120fbc5dcd4c9eab1768573e9f06469eea3af47d605a"

URI_aarch64_python3-aiohttp+speedups = "${EPEL_MIRROR}/aarch64/Packages/p/python3-aiohttp+speedups-3.11.18-4.el10_2.aarch64.rpm;name=aarch64_python3-aiohttp+speedups;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-aiohttp+speedups}"
SRC_URI[aarch64_python3-aiohttp+speedups.sha256sum] = "4a09288604aef055d6df69cbb686965ad7e9350590ba4c9dd61b3b559ba7e16d"

RDEPENDS:python3-aiohttp = " \
 glibc \
 llhttp \
 python3 \
 python3-aiohappyeyeballs \
 python3-aiosignal \
 python3-attrs \
 python3-frozenlist \
 python3-multidict \
 python3-propcache \
 python3-yarl \
 "
RDEPENDS:python3-aiohttp+speedups = " \
 python3 \
 python3-aiodns \
 python3-aiohttp \
 python3-brotli \
 "
