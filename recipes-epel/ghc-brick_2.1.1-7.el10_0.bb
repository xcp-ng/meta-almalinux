# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-brick"
PV = "2.1.1"
PR = "7.el10_0"
PACKAGES = " \
 ghc-bimap \
 ghc-bimap-devel \
 ghc-bimap-doc \
 ghc-bimap-prof \
 ghc-brick \
 ghc-brick-devel \
 ghc-brick-doc \
 ghc-brick-prof \
 ghc-vty-crossplatform \
 ghc-vty-crossplatform-devel \
 ghc-vty-crossplatform-doc \
 ghc-vty-crossplatform-prof \
 ghc-vty-unix \
 ghc-vty-unix-devel \
 ghc-vty-unix-doc \
 ghc-vty-unix-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-brick-2.1.1-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "832c0ce479807d82ceaf064819b07314b535fefa163d1946ec3a4e19decd5a86"

URI_x86_64_v2_ghc-bimap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bimap-0.5.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-bimap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bimap}"
SRC_URI[x86_64_v2_ghc-bimap.sha256sum] = "fb7f10c92d67ad4f1c204ad10997dd665c556d2c3ba7c8b84d31f00546b19a34"

URI_x86_64_v2_ghc-bimap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bimap-devel-0.5.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-bimap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bimap-devel}"
SRC_URI[x86_64_v2_ghc-bimap-devel.sha256sum] = "d7ebeb71ecb1784e673aa1a0a732449ed9fbe1ccd78a77c1593eee4213cc7225"

URI_x86_64_v2_ghc-bimap-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bimap-doc-0.5.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-bimap-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bimap-doc}"
SRC_URI[x86_64_v2_ghc-bimap-doc.sha256sum] = "5dff599be3653887f41768543d9a052d7f171dfe779248a8fa83396bfd92f7df"

URI_x86_64_v2_ghc-bimap-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bimap-prof-0.5.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-bimap-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bimap-prof}"
SRC_URI[x86_64_v2_ghc-bimap-prof.sha256sum] = "b58278524ae427a41f222a9f6f32e55cf47b906268dad53d93ec0cd479c682fc"

URI_x86_64_v2_ghc-brick = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-brick-2.1.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-brick;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-brick}"
SRC_URI[x86_64_v2_ghc-brick.sha256sum] = "e49371ee6c38b200a4b6d34e94842d9aa63bf49e06750c2678919b2cf8050f48"

URI_x86_64_v2_ghc-brick-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-brick-devel-2.1.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-brick-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-brick-devel}"
SRC_URI[x86_64_v2_ghc-brick-devel.sha256sum] = "19a6abb0338f6a31dd6ad4e20777fb884187a1d2c2796d564b31eb44d92ada7b"

URI_x86_64_v2_ghc-brick-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-brick-doc-2.1.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-brick-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-brick-doc}"
SRC_URI[x86_64_v2_ghc-brick-doc.sha256sum] = "915c5690ab5c1ce30e744e291ec0da30dc6e595b59ddee0080d54524ed1fe0e0"

URI_x86_64_v2_ghc-brick-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-brick-prof-2.1.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-brick-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-brick-prof}"
SRC_URI[x86_64_v2_ghc-brick-prof.sha256sum] = "10398dae1a5f4c7fca6abcd491e56adf9aa1d1225792f43a457af448ef78ed1d"

URI_x86_64_v2_ghc-vty-crossplatform = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-vty-crossplatform-0.4.0.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-vty-crossplatform;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-vty-crossplatform}"
SRC_URI[x86_64_v2_ghc-vty-crossplatform.sha256sum] = "4d244a4d76f1c017b24b5178f1589ba4fb2019e47973f67c4f2f23bc878fcaab"

URI_x86_64_v2_ghc-vty-crossplatform-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-vty-crossplatform-devel-0.4.0.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-vty-crossplatform-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-vty-crossplatform-devel}"
SRC_URI[x86_64_v2_ghc-vty-crossplatform-devel.sha256sum] = "a75df02ff168f57e9f58c1b2d14d6b6752ce98b21fcb07b1907119abc889b749"

URI_x86_64_v2_ghc-vty-crossplatform-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-vty-crossplatform-doc-0.4.0.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-vty-crossplatform-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-vty-crossplatform-doc}"
SRC_URI[x86_64_v2_ghc-vty-crossplatform-doc.sha256sum] = "aef1dfa0dd42295da976883387b7e3ac3f83255a7c8a79f04fe44eeaa93c0415"

URI_x86_64_v2_ghc-vty-crossplatform-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-vty-crossplatform-prof-0.4.0.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-vty-crossplatform-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-vty-crossplatform-prof}"
SRC_URI[x86_64_v2_ghc-vty-crossplatform-prof.sha256sum] = "9695ff2c57dbec0fa235cbb8b87d12040dbbe7e578662e2daeec60ebb17e34f6"

URI_x86_64_v2_ghc-vty-unix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-vty-unix-0.2.0.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-vty-unix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-vty-unix}"
SRC_URI[x86_64_v2_ghc-vty-unix.sha256sum] = "5f69b6dfc80d8f72717e28d46d6f6332a67fc02bae6aef47171e6e66ff6fc91c"

URI_x86_64_v2_ghc-vty-unix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-vty-unix-devel-0.2.0.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-vty-unix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-vty-unix-devel}"
SRC_URI[x86_64_v2_ghc-vty-unix-devel.sha256sum] = "1455efb48182b56275c33a66de2f9ac72d5205f2d204b50b8ef97d0d79a10033"

URI_x86_64_v2_ghc-vty-unix-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-vty-unix-doc-0.2.0.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-vty-unix-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-vty-unix-doc}"
SRC_URI[x86_64_v2_ghc-vty-unix-doc.sha256sum] = "43f9958f23b6ff1816ed07f45bda3ea3ad950fb73ff4bb9fda7b5456f6f755d0"

URI_x86_64_v2_ghc-vty-unix-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-vty-unix-prof-0.2.0.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-vty-unix-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-vty-unix-prof}"
SRC_URI[x86_64_v2_ghc-vty-unix-prof.sha256sum] = "a668eaeba1abc2adb3176a49ff94ecea989ea246b2646b4fc44fafe193845d78"

URI_aarch64_ghc-bimap = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bimap-0.5.0-7.el10_0.aarch64.rpm;name=aarch64_ghc-bimap;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bimap}"
SRC_URI[aarch64_ghc-bimap.sha256sum] = "4591c9d09a5a2fda65818e14a534164720b5df6c8d6bc1841e6759b06f594e42"

URI_aarch64_ghc-bimap-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bimap-devel-0.5.0-7.el10_0.aarch64.rpm;name=aarch64_ghc-bimap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bimap-devel}"
SRC_URI[aarch64_ghc-bimap-devel.sha256sum] = "156297eebc42a9dbb534e812ad22b4971ec8f480e77d9ac32d2a2747d090210e"

URI_aarch64_ghc-bimap-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bimap-doc-0.5.0-7.el10_0.noarch.rpm;name=aarch64_ghc-bimap-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bimap-doc}"
SRC_URI[aarch64_ghc-bimap-doc.sha256sum] = "0e62133d2abacb936f92efa1d91226c885d2ff9148fbc428f23fb8032b9deadc"

URI_aarch64_ghc-bimap-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bimap-prof-0.5.0-7.el10_0.aarch64.rpm;name=aarch64_ghc-bimap-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bimap-prof}"
SRC_URI[aarch64_ghc-bimap-prof.sha256sum] = "9d18c097e633ce385a1d956d612efbc0e112278b9a5c83371fef18b0990620e4"

URI_aarch64_ghc-brick = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-brick-2.1.1-7.el10_0.aarch64.rpm;name=aarch64_ghc-brick;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-brick}"
SRC_URI[aarch64_ghc-brick.sha256sum] = "1dd5cf471d7717ec0861f5eacb16cbfa68c0d2c770f71b22bd16654effb8ab91"

URI_aarch64_ghc-brick-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-brick-devel-2.1.1-7.el10_0.aarch64.rpm;name=aarch64_ghc-brick-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-brick-devel}"
SRC_URI[aarch64_ghc-brick-devel.sha256sum] = "6c30077905edbaa3900e973ed2a03ce920cf11a3a0ddb36d9da4730e49933867"

URI_aarch64_ghc-brick-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-brick-doc-2.1.1-7.el10_0.noarch.rpm;name=aarch64_ghc-brick-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-brick-doc}"
SRC_URI[aarch64_ghc-brick-doc.sha256sum] = "b22f18028e4e34a5409629b59840ed67e3ba54884ed4afe9cf6da21a6909989a"

URI_aarch64_ghc-brick-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-brick-prof-2.1.1-7.el10_0.aarch64.rpm;name=aarch64_ghc-brick-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-brick-prof}"
SRC_URI[aarch64_ghc-brick-prof.sha256sum] = "0ae645d0171762a759199ca2f2f20c9d84be6d7901b6bef21bf02bd9aada29cd"

URI_aarch64_ghc-vty-crossplatform = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-vty-crossplatform-0.4.0.0-7.el10_0.aarch64.rpm;name=aarch64_ghc-vty-crossplatform;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-vty-crossplatform}"
SRC_URI[aarch64_ghc-vty-crossplatform.sha256sum] = "3d4a3eb8f6dd98f79ac8c852b3293d51da7b732bb2b3c118302312d952a37f6e"

URI_aarch64_ghc-vty-crossplatform-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-vty-crossplatform-devel-0.4.0.0-7.el10_0.aarch64.rpm;name=aarch64_ghc-vty-crossplatform-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-vty-crossplatform-devel}"
SRC_URI[aarch64_ghc-vty-crossplatform-devel.sha256sum] = "6eace9e26dea7fc74bb6e90b1ed91472be0e63de16f2d5d461136c7f3050669e"

URI_aarch64_ghc-vty-crossplatform-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-vty-crossplatform-doc-0.4.0.0-7.el10_0.noarch.rpm;name=aarch64_ghc-vty-crossplatform-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-vty-crossplatform-doc}"
SRC_URI[aarch64_ghc-vty-crossplatform-doc.sha256sum] = "17dcabf1eff914e13c5b4646c3833c968eed7f745d8eb86381108fa2f1055b06"

URI_aarch64_ghc-vty-crossplatform-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-vty-crossplatform-prof-0.4.0.0-7.el10_0.aarch64.rpm;name=aarch64_ghc-vty-crossplatform-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-vty-crossplatform-prof}"
SRC_URI[aarch64_ghc-vty-crossplatform-prof.sha256sum] = "97ba5cde63fa95ebf5c2b332ba55d5079971ba1e4ba20a23f713c01bfaeb8c92"

URI_aarch64_ghc-vty-unix = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-vty-unix-0.2.0.0-7.el10_0.aarch64.rpm;name=aarch64_ghc-vty-unix;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-vty-unix}"
SRC_URI[aarch64_ghc-vty-unix.sha256sum] = "1c06b1d129e70b2fed243e008d36ffb5a4a426e314e28db427fd8bdcf3d85c02"

URI_aarch64_ghc-vty-unix-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-vty-unix-devel-0.2.0.0-7.el10_0.aarch64.rpm;name=aarch64_ghc-vty-unix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-vty-unix-devel}"
SRC_URI[aarch64_ghc-vty-unix-devel.sha256sum] = "1e444a898d01ec7a87fc89cbe411b4f6604841d43f32061d647444105ab1cc7b"

URI_aarch64_ghc-vty-unix-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-vty-unix-doc-0.2.0.0-7.el10_0.noarch.rpm;name=aarch64_ghc-vty-unix-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-vty-unix-doc}"
SRC_URI[aarch64_ghc-vty-unix-doc.sha256sum] = "ee702d7d33a8d7232ea3683a305556292bb162db75881a3a3e6b89e1240f8fd0"

URI_aarch64_ghc-vty-unix-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-vty-unix-prof-0.2.0.0-7.el10_0.aarch64.rpm;name=aarch64_ghc-vty-unix-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-vty-unix-prof}"
SRC_URI[aarch64_ghc-vty-unix-prof.sha256sum] = "5a176780a32f5f7e045c5401ef1af8f6ea24d7de7ec981106b4e22e9311d3424"

RDEPENDS:ghc-bimap = " \
 ghc-array \
 ghc-base \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-bimap-devel = " \
 ghc-base-devel \
 ghc-bimap \
 ghc-compiler \
 ghc-containers-devel \
 ghc-deepseq-devel \
 ghc-exceptions-devel \
 "
RDEPENDS:ghc-bimap-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-bimap-prof = " \
 ghc-base-prof \
 ghc-bimap-devel \
 ghc-containers-prof \
 ghc-deepseq-prof \
 ghc-exceptions-prof \
 "
RDEPENDS:ghc-brick = " \
 ghc-array \
 ghc-base \
 ghc-bimap \
 ghc-binary \
 ghc-blaze-builder \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-config-ini \
 ghc-containers \
 ghc-data-clist \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-integer-logarithms \
 ghc-megaparsec \
 ghc-microlens \
 ghc-microlens-mtl \
 ghc-microlens-th \
 ghc-mtl \
 ghc-os-string \
 ghc-parsec \
 ghc-parser-combinators \
 ghc-pretty \
 ghc-primitive \
 ghc-scientific \
 ghc-stm \
 ghc-template-haskell \
 ghc-terminfo \
 ghc-text \
 ghc-text-zipper \
 ghc-th-abstraction \
 ghc-time \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unix-compat \
 ghc-unordered-containers \
 ghc-utf8-string \
 ghc-vector \
 ghc-vector-stream \
 ghc-vty \
 ghc-vty-crossplatform \
 ghc-vty-unix \
 ghc-word-wrap \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc-brick-devel = " \
 ghc-base-devel \
 ghc-bimap-devel \
 ghc-brick \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-config-ini-devel \
 ghc-containers-devel \
 ghc-data-clist-devel \
 ghc-deepseq-devel \
 ghc-directory-devel \
 ghc-exceptions-devel \
 ghc-filepath-devel \
 ghc-microlens-devel \
 ghc-microlens-mtl-devel \
 ghc-microlens-th-devel \
 ghc-mtl-devel \
 ghc-stm-devel \
 ghc-template-haskell-devel \
 ghc-text-devel \
 ghc-text-zipper-devel \
 ghc-unix-compat-devel \
 ghc-vector-devel \
 ghc-vty-crossplatform-devel \
 ghc-vty-devel \
 ghc-word-wrap-devel \
 "
RDEPENDS:ghc-brick-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-brick-prof = " \
 ghc-base-prof \
 ghc-bimap-prof \
 ghc-brick-devel \
 ghc-bytestring-prof \
 ghc-config-ini-prof \
 ghc-containers-prof \
 ghc-data-clist-prof \
 ghc-deepseq-prof \
 ghc-directory-prof \
 ghc-exceptions-prof \
 ghc-filepath-prof \
 ghc-microlens-mtl-prof \
 ghc-microlens-prof \
 ghc-microlens-th-prof \
 ghc-mtl-prof \
 ghc-stm-prof \
 ghc-template-haskell-prof \
 ghc-text-prof \
 ghc-text-zipper-prof \
 ghc-unix-compat-prof \
 ghc-vector-prof \
 ghc-vty-crossplatform-prof \
 ghc-vty-prof \
 ghc-word-wrap-prof \
 "
RDEPENDS:ghc-vty-crossplatform = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-blaze-builder \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-microlens \
 ghc-microlens-mtl \
 ghc-microlens-th \
 ghc-mtl \
 ghc-parsec \
 ghc-pretty \
 ghc-primitive \
 ghc-stm \
 ghc-template-haskell \
 ghc-terminfo \
 ghc-text \
 ghc-th-abstraction \
 ghc-time \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 ghc-utf8-string \
 ghc-vector \
 ghc-vector-stream \
 ghc-vty \
 ghc-vty-unix \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc-vty-crossplatform-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-vty-crossplatform \
 ghc-vty-devel \
 ghc-vty-unix-devel \
 "
RDEPENDS:ghc-vty-crossplatform-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-vty-crossplatform-prof = " \
 ghc-base-prof \
 ghc-vty-crossplatform-devel \
 ghc-vty-prof \
 ghc-vty-unix-prof \
 "
RDEPENDS:ghc-vty-unix = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-blaze-builder \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-microlens \
 ghc-microlens-mtl \
 ghc-microlens-th \
 ghc-mtl \
 ghc-parsec \
 ghc-pretty \
 ghc-primitive \
 ghc-stm \
 ghc-template-haskell \
 ghc-terminfo \
 ghc-text \
 ghc-th-abstraction \
 ghc-time \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 ghc-utf8-string \
 ghc-vector \
 ghc-vector-stream \
 ghc-vty \
 glibc \
 gmp \
 libffi \
 ncurses-libs \
 "
RDEPENDS:ghc-vty-unix-devel = " \
 ghc-base-devel \
 ghc-blaze-builder-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-deepseq-devel \
 ghc-microlens-devel \
 ghc-microlens-mtl-devel \
 ghc-microlens-th-devel \
 ghc-mtl-devel \
 ghc-parsec-devel \
 ghc-stm-devel \
 ghc-terminfo-devel \
 ghc-transformers-devel \
 ghc-unix-devel \
 ghc-utf8-string-devel \
 ghc-vector-devel \
 ghc-vty-devel \
 ghc-vty-unix \
 "
RDEPENDS:ghc-vty-unix-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-vty-unix-prof = " \
 ghc-base-prof \
 ghc-blaze-builder-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-deepseq-prof \
 ghc-microlens-mtl-prof \
 ghc-microlens-prof \
 ghc-microlens-th-prof \
 ghc-mtl-prof \
 ghc-parsec-prof \
 ghc-stm-prof \
 ghc-terminfo-prof \
 ghc-transformers-prof \
 ghc-unix-prof \
 ghc-utf8-string-prof \
 ghc-vector-prof \
 ghc-vty-prof \
 ghc-vty-unix-devel \
 "
