# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "scitokens-cpp"
PV = "1.4.1"
PR = "1.el10_1"
PACKAGES = " \
 scitokens-cpp \
 scitokens-cpp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/scitokens-cpp-1.4.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "83a7e6784880615e8b7f64e00bc1895f480f1ddf896c1e8da475007bb5058abc"

URI_x86_64_v2_scitokens-cpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scitokens-cpp-1.4.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scitokens-cpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scitokens-cpp}"
SRC_URI[x86_64_v2_scitokens-cpp.sha256sum] = "df6b5603b02467256018eff07534294e832cbc0277c2d50b36e9c61334cbf3d0"

URI_x86_64_v2_scitokens-cpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scitokens-cpp-devel-1.4.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scitokens-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scitokens-cpp-devel}"
SRC_URI[x86_64_v2_scitokens-cpp-devel.sha256sum] = "80210f1950d8a02d16c337bcdb8f90127679c886d02841d9ae912eb43315c0e2"

URI_aarch64_scitokens-cpp = "${EPEL_MIRROR}/aarch64/Packages/s/scitokens-cpp-1.4.1-1.el10_1.aarch64.rpm;name=aarch64_scitokens-cpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_scitokens-cpp}"
SRC_URI[aarch64_scitokens-cpp.sha256sum] = "f8abbc01630d9f448cb98214bacbed11c4dc2340b2d550265853abbbcd7a0c43"

URI_aarch64_scitokens-cpp-devel = "${EPEL_MIRROR}/aarch64/Packages/s/scitokens-cpp-devel-1.4.1-1.el10_1.aarch64.rpm;name=aarch64_scitokens-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_scitokens-cpp-devel}"
SRC_URI[aarch64_scitokens-cpp-devel.sha256sum] = "cbb0701620ecbd192559c70d1584364b3bb071efadb6b8c02ed358cd3a185f35"

RDEPENDS:scitokens-cpp = " \
 glibc \
 libgcc \
 libstdc++ \
 libuuid \
 openssl-libs \
 sqlite-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:scitokens-cpp-devel = " \
 scitokens-cpp \
 "
