# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-nh3"
PV = "0.2.21"
PR = "2.el10_1"
PACKAGES = " \
 python3-nh3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-nh3-0.2.21-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7d3ae32f0f9463787d6b39bbd6c1221b88b4f8c16dac4fbc083c7400f7e73744"

URI_x86_64_v2_python3-nh3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-nh3-0.2.21-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-nh3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-nh3}"
SRC_URI[x86_64_v2_python3-nh3.sha256sum] = "d6e01a77cd99dac7b5732ce069487d4992e91641756fc71e910b8acee174a36d"

URI_aarch64_python3-nh3 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-nh3-0.2.21-2.el10_1.aarch64.rpm;name=aarch64_python3-nh3;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-nh3}"
SRC_URI[aarch64_python3-nh3.sha256sum] = "44d0fc931aee36472443b4f304912e90d2e8189e6f6b80381d315bfdf1be17c7"

RDEPENDS:python3-nh3 = " \
 glibc \
 libgcc \
 python3 \
 "
