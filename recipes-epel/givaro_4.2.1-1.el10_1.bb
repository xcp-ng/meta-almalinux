# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "givaro"
PV = "4.2.1"
PR = "1.el10_1"
PACKAGES = " \
 givaro \
 givaro-devel \
 givaro-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/givaro-4.2.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "658b1913f84a9f123ee4de018658d239f7347ab84b1355bc3e7a0577be644b0e"

URI_x86_64_v2_givaro = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/givaro-4.2.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_givaro;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_givaro}"
SRC_URI[x86_64_v2_givaro.sha256sum] = "756cfeb04a29dada901b4365b4d34a3dc778aa43cd754bfff891a4922274745d"

URI_x86_64_v2_givaro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/givaro-devel-4.2.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_givaro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_givaro-devel}"
SRC_URI[x86_64_v2_givaro-devel.sha256sum] = "f5c619b8606bb57ef66c1312c448fec67464eb87c83b7ab16205ff1d307ea53d"

URI_x86_64_v2_givaro-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/givaro-static-4.2.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_givaro-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_givaro-static}"
SRC_URI[x86_64_v2_givaro-static.sha256sum] = "30cde5055d0fdffa4a5422e4758911a6a8e469e52f42c8e4813fdcb3a6317be9"

URI_aarch64_givaro = "${EPEL_MIRROR}/aarch64/Packages/g/givaro-4.2.1-1.el10_1.aarch64.rpm;name=aarch64_givaro;unpack=0"
SRC_URI:append = " ${URI_aarch64_givaro}"
SRC_URI[aarch64_givaro.sha256sum] = "cae9bdff4abbaebfe814f9e13a86694374499371de6469373786517dd488a574"

URI_aarch64_givaro-devel = "${EPEL_MIRROR}/aarch64/Packages/g/givaro-devel-4.2.1-1.el10_1.aarch64.rpm;name=aarch64_givaro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_givaro-devel}"
SRC_URI[aarch64_givaro-devel.sha256sum] = "885436e92d89675dc4b369d731f406c03cd96425af773925a56c02a09b73f4cc"

URI_aarch64_givaro-static = "${EPEL_MIRROR}/aarch64/Packages/g/givaro-static-4.2.1-1.el10_1.aarch64.rpm;name=aarch64_givaro-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_givaro-static}"
SRC_URI[aarch64_givaro-static.sha256sum] = "484d4e84d3b3799e692ed1a01925c5a9f367af2d0986ba6cdefe063afc1f1f87"

RDEPENDS:givaro = " \
 glibc \
 gmp \
 gmp-c++ \
 libgcc \
 libstdc++ \
 "
RDEPENDS:givaro-devel = " \
 bash \
 givaro \
 pkgconf-pkg-config \
 "
RDEPENDS:givaro-static = " \
 givaro-devel \
 "
