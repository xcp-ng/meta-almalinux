# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gtkd"
PV = "3.11.0"
PR = "2.el10_2"
PACKAGES = " \
 gtkd \
 gtkd-devel \
 gtkd-geany-tags \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gtkd-3.11.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b7a206783cb0f62ee6f9375b21e92f7b3b949a3405d8a43b53feed32f5b6c8fa"

URI_x86_64_v2_gtkd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gtkd-3.11.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gtkd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtkd}"
SRC_URI[x86_64_v2_gtkd.sha256sum] = "51ef7920b936cf6e9dd301229739357c168db0aaad86b51ec5ab892c2f44b5b1"

URI_x86_64_v2_gtkd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gtkd-devel-3.11.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gtkd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtkd-devel}"
SRC_URI[x86_64_v2_gtkd-devel.sha256sum] = "54c7cb11d11d756c26672be2c1a69bd8b0ff3adaba12fdb4f62cb8d701fb60ee"

URI_x86_64_v2_gtkd-geany-tags = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gtkd-geany-tags-3.11.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_gtkd-geany-tags;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtkd-geany-tags}"
SRC_URI[x86_64_v2_gtkd-geany-tags.sha256sum] = "143da1d50a30d3cfe5f6f03d44ead007e4a369840c0526b4019f9ca133aed5d6"

URI_aarch64_gtkd = "${EPEL_MIRROR}/aarch64/Packages/g/gtkd-3.11.0-2.el10_2.aarch64.rpm;name=aarch64_gtkd;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtkd}"
SRC_URI[aarch64_gtkd.sha256sum] = "abf13a58d4239d15135e316d17e619bb1bddc20171bef6f9a9817546a5ad307d"

URI_aarch64_gtkd-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gtkd-devel-3.11.0-2.el10_2.aarch64.rpm;name=aarch64_gtkd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtkd-devel}"
SRC_URI[aarch64_gtkd-devel.sha256sum] = "1d0d10ed00759a24dd7d497f7977cce8dc846acbb0bed3cf82ef20511477c9c8"

URI_aarch64_gtkd-geany-tags = "${EPEL_MIRROR}/aarch64/Packages/g/gtkd-geany-tags-3.11.0-2.el10_2.noarch.rpm;name=aarch64_gtkd-geany-tags;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtkd-geany-tags}"
SRC_URI[aarch64_gtkd-geany-tags.sha256sum] = "8017f6eafdb4b3a35f41d3befa801d7d346c3114fe102247f22472703a5ddcda"

RDEPENDS:gtkd:x86_64_v2 = " \
 atk \
 cairo \
 gdk-pixbuf2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 gtk3 \
 gtksourceview4 \
 ldc-libs \
 libgcc \
 libpeas1 \
 libpeas1-gtk \
 librsvg2 \
 mesa-libGL \
 mesa-libGLU \
 pango \
 virtual/libcurl_x86-64_ \
 vte291 \
"
RDEPENDS:gtkd:aarch64 = " \
 atk \
 cairo \
 gdk-pixbuf2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 gtk3 \
 gtksourceview4 \
 ldc-libs \
 libgcc \
 libpeas1 \
 libpeas1-gtk \
 librsvg2 \
 mesa-libGL \
 mesa-libGLU \
 pango \
 virtual/libcurl_aarch-64_ \
 vte291 \
"
RDEPENDS:gtkd-devel = " \
 atk-devel \
 cairo-devel \
 cairo-gobject-devel \
 glib2-devel \
 gstreamer1-devel \
 gtk3-devel \
 gtkd \
 gtkd-devel \
 gtkglext-devel \
 gtksourceview4-devel \
 libpeas1-devel \
 librsvg2-devel \
 pango-devel \
 pkgconf-pkg-config \
 vte291-devel \
 "
RDEPENDS:gtkd-geany-tags = " \
 geany \
 gtkd \
 "
