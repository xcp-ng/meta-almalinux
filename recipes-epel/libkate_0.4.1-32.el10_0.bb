# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkate"
PV = "0.4.1"
PR = "32.el10_0"
PACKAGES = " \
 libkate \
 libkate-devel \
 libkate-docs \
 libkate-utils \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libkate-0.4.1-32.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7ea390223d2f8a5c76b1a9713cf09759be48fa07e98c679377625693ff394893"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkate-0.4.1-32.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkate;unpack=0"
SRC_URI[x86_64_v2_libkate.sha256sum] = "8ca642db827a5ffa22284222fc74ada8d70b730cb8eb3372a7d85888a2e81d61"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkate-devel-0.4.1-32.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkate-devel;unpack=0"
SRC_URI[x86_64_v2_libkate-devel.sha256sum] = "f17a6c48616796e4646471327884344d7728ebe281754fe7bbfe2161a8bfcead"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkate-docs-0.4.1-32.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_libkate-docs;unpack=0"
SRC_URI[x86_64_v2_libkate-docs.sha256sum] = "3005f440dd7ff7a3220e13c5e28f0cb808a9f4e554a12d30ffeee3a8ee6c17cc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkate-utils-0.4.1-32.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkate-utils;unpack=0"
SRC_URI[x86_64_v2_libkate-utils.sha256sum] = "4985da7140c65ad8ac218c85efd5f73a24770f834d1f18d91f8b1f2a62584348"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libkate-0.4.1-32.el10_0.aarch64.rpm;name=aarch64_libkate;unpack=0"
SRC_URI[aarch64_libkate.sha256sum] = "d295a2794b28ae4aa25893ad547a6b78678caaf09c31bf8d03934b1660555fde"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libkate-devel-0.4.1-32.el10_0.aarch64.rpm;name=aarch64_libkate-devel;unpack=0"
SRC_URI[aarch64_libkate-devel.sha256sum] = "8f7060af655ffe3463af73f73b4631e3020f282fc12c2d76c4e9d4463c3dd591"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libkate-docs-0.4.1-32.el10_0.noarch.rpm;name=aarch64_libkate-docs;unpack=0"
SRC_URI[aarch64_libkate-docs.sha256sum] = "bba7de463b676d1a8eb515d77b7d78e9810e1b2f8c5f8b9f05ecd9bfe1a447d2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libkate-utils-0.4.1-32.el10_0.aarch64.rpm;name=aarch64_libkate-utils;unpack=0"
SRC_URI[aarch64_libkate-utils.sha256sum] = "7766772c99bf687e1dc4644d063a9fb39d9ddf1db15592a20efaafed61868464"

RDEPENDS:libkate = " \
 glibc \
 "
RDEPENDS:libkate-devel = " \
 libkate \
 libkate-devel \
 libogg-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libkate-docs = " \
 "
RDEPENDS:libkate-utils = " \
 glibc \
 libkate \
 libogg \
 liboggz \
 libpng \
 "
