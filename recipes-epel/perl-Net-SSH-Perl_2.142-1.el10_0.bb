# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-SSH-Perl"
PV = "2.142"
PR = "1.el10_0"
PACKAGES = " \
 perl-Net-SSH-Perl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-SSH-Perl-2.142-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "46dc846555dfa96d292818006899ffbe69f0ae73df5885b4313034be1f6b1e70"

URI_x86_64_v2_perl-Net-SSH-Perl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-SSH-Perl-2.142-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Net-SSH-Perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-SSH-Perl}"
SRC_URI[x86_64_v2_perl-Net-SSH-Perl.sha256sum] = "70149e598971cf6f348ef029a91ce95221092d1b520a8cac9d66b2efb23f6f92"

URI_aarch64_perl-Net-SSH-Perl = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-SSH-Perl-2.142-1.el10_0.aarch64.rpm;name=aarch64_perl-Net-SSH-Perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-SSH-Perl}"
SRC_URI[aarch64_perl-Net-SSH-Perl.sha256sum] = "9e0a8f3c3a7866084d7347bf25f6cd338e9ab1be68a4fcb1fcd1cf24ae5cb46a"

RDEPENDS:perl-Net-SSH-Perl = " \
 glibc \
 perl-Carp \
 perl-Crypt-Curve25519 \
 perl-Crypt-IDEA \
 perl-CryptX \
 perl-Digest-BubbleBabble \
 perl-Digest-MD5 \
 perl-Errno \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-HomeDir \
 perl-File-Path \
 perl-IO \
 perl-IO-Compress \
 perl-IO-Socket-Socks \
 perl-Math-GMP \
 perl-Net-SSH-Perl \
 perl-POSIX \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Socket \
 perl-String-CRC32 \
 perl-Symbol \
 perl-Sys-Hostname \
 perl-TermReadKey \
 perl-Tie \
 perl-base \
 perl-constant \
 perl-if \
 perl-libs \
 perl-vars \
 "
