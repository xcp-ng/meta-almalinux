# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-time-humanize"
PV = "0.1.3"
PR = "4.el10_0"
PACKAGES = " \
 rust-time-humanize+default-devel \
 rust-time-humanize+time-devel \
 rust-time-humanize-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-time-humanize-0.1.3-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab128bcb9f684c1326fd7706d357c9f00a4a18811ff977780705ac8c62e010a1"

URI_x86_64_v2_rust-time-humanize+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time-humanize+default-devel-0.1.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time-humanize+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time-humanize+default-devel}"
SRC_URI[x86_64_v2_rust-time-humanize+default-devel.sha256sum] = "d4b9d0354d75a1f191676c15e00684ba779ab90db1cf8bd63dc54df6b522bd57"

URI_x86_64_v2_rust-time-humanize+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time-humanize+time-devel-0.1.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time-humanize+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time-humanize+time-devel}"
SRC_URI[x86_64_v2_rust-time-humanize+time-devel.sha256sum] = "6eba92ab3ecd93ed43f80f86c9065f06853d9bd8acd2334693ec1e1cb26f108a"

URI_x86_64_v2_rust-time-humanize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time-humanize-devel-0.1.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time-humanize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time-humanize-devel}"
SRC_URI[x86_64_v2_rust-time-humanize-devel.sha256sum] = "b63dd064c6e520fcc52c4fd705cbd7e671a71c66b4f678ae2d798c9955612152"

URI_aarch64_rust-time-humanize+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time-humanize+default-devel-0.1.3-4.el10_0.noarch.rpm;name=aarch64_rust-time-humanize+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time-humanize+default-devel}"
SRC_URI[aarch64_rust-time-humanize+default-devel.sha256sum] = "9d599ab22c119bd2ac02d21bbbb98e5e90746a31708fe0c176d2f86b44a5ced8"

URI_aarch64_rust-time-humanize+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time-humanize+time-devel-0.1.3-4.el10_0.noarch.rpm;name=aarch64_rust-time-humanize+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time-humanize+time-devel}"
SRC_URI[aarch64_rust-time-humanize+time-devel.sha256sum] = "d69206584c84cb7fd016cad23ed0f0147afc6ba6302daa3619a8b6260b351418"

URI_aarch64_rust-time-humanize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time-humanize-devel-0.1.3-4.el10_0.noarch.rpm;name=aarch64_rust-time-humanize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time-humanize-devel}"
SRC_URI[aarch64_rust-time-humanize-devel.sha256sum] = "1f88a931180e8bf9d9c6f68904a9c31edfdbc97cef8d2570b22160dd8aa8b062"

RDEPENDS:rust-time-humanize+default-devel = " \
 cargo \
 rust-time-humanize-devel \
 "
RDEPENDS:rust-time-humanize+time-devel = " \
 cargo \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time-humanize-devel \
 "
RDEPENDS:rust-time-humanize-devel = " \
 cargo \
 "
