# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-hjsmin"
PV = "0.2.1"
PR = "4.el10_0"
PACKAGES = " \
 ghc-hjsmin \
 ghc-hjsmin-devel \
 ghc-hjsmin-doc \
 ghc-hjsmin-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-hjsmin-0.2.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3a83136fafbee8b1a2d85abac817abe103b76cd50be0754d161c3b3145dcace9"

URI_x86_64_v2_ghc-hjsmin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hjsmin-0.2.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hjsmin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hjsmin}"
SRC_URI[x86_64_v2_ghc-hjsmin.sha256sum] = "6bb08221ee25ce42f35d3269094310705cdaf5859da6f022211a83e329d7d079"

URI_x86_64_v2_ghc-hjsmin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hjsmin-devel-0.2.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hjsmin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hjsmin-devel}"
SRC_URI[x86_64_v2_ghc-hjsmin-devel.sha256sum] = "0200d03f536e9c1a65ec18f65292ffebaf75348d0762f69b5e75a5f36bed328d"

URI_x86_64_v2_ghc-hjsmin-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hjsmin-doc-0.2.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hjsmin-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hjsmin-doc}"
SRC_URI[x86_64_v2_ghc-hjsmin-doc.sha256sum] = "a015c8b1b01326c07c3000edf19ad1224d6f04f51f6ffcd4415951a2a88ccba0"

URI_x86_64_v2_ghc-hjsmin-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hjsmin-prof-0.2.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hjsmin-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hjsmin-prof}"
SRC_URI[x86_64_v2_ghc-hjsmin-prof.sha256sum] = "42355189c22f986e7221e6665ed3d43d00294241f015bbcef2d392578f499bdd"

URI_aarch64_ghc-hjsmin = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hjsmin-0.2.1-4.el10_0.aarch64.rpm;name=aarch64_ghc-hjsmin;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hjsmin}"
SRC_URI[aarch64_ghc-hjsmin.sha256sum] = "22592526627fcc90352431cdbd83eef5286e631e5a290a734488772b7d04a371"

URI_aarch64_ghc-hjsmin-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hjsmin-devel-0.2.1-4.el10_0.aarch64.rpm;name=aarch64_ghc-hjsmin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hjsmin-devel}"
SRC_URI[aarch64_ghc-hjsmin-devel.sha256sum] = "e5e8a01d4728f8e3548eb428826fb1b1d60e23784dd7e457b29510066c04c082"

URI_aarch64_ghc-hjsmin-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hjsmin-doc-0.2.1-4.el10_0.noarch.rpm;name=aarch64_ghc-hjsmin-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hjsmin-doc}"
SRC_URI[aarch64_ghc-hjsmin-doc.sha256sum] = "eca5ec96d37ce7f5c7d6c402e62d1b1749e2e7ea5980eb8dcb7fc259508dfa47"

URI_aarch64_ghc-hjsmin-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hjsmin-prof-0.2.1-4.el10_0.aarch64.rpm;name=aarch64_ghc-hjsmin-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hjsmin-prof}"
SRC_URI[aarch64_ghc-hjsmin-prof.sha256sum] = "dc78857116657b73c5587ba328373153f131476f97eedfe6823e2c5a1595eda7"

RDEPENDS:ghc-hjsmin = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-blaze-builder \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-language-javascript \
 ghc-mtl \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 ghc-utf8-string \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hjsmin-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-hjsmin \
 ghc-language-javascript-devel \
 ghc-text-devel \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc-hjsmin-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hjsmin-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-hjsmin-devel \
 ghc-language-javascript-prof \
 ghc-text-prof \
 "
