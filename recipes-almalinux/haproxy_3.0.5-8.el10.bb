# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "haproxy"
PV = "3.0.5"
PR = "8.el10"
PACKAGES = " \
 haproxy \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/haproxy-3.0.5-8.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "536a0ca9678686c38ee080676f04dfc723b76514f379026bdadc4e962e50dd06"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/haproxy-3.0.5-8.el10.x86_64_v2.rpm;name=x86_64_v2_haproxy;unpack=0"
SRC_URI[x86_64_v2_haproxy.sha256sum] = "48cd8756e2068d28cbc41ac7bb7f06e68f4539e211a0dd71ba847678ed65a82c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/haproxy-3.0.5-8.el10.aarch64.rpm;name=aarch64_haproxy;unpack=0"
SRC_URI[aarch64_haproxy.sha256sum] = "03e802725f8dbe23f8e0932f60f46e35629b79c76252fbbf29b6c759cda0fb7e"

RDEPENDS:haproxy = " \
 bash \
 glibc \
 libxcrypt \
 lua-libs \
 openssl-libs \
 pcre2 \
 shadow-utils \
 systemd \
 "
