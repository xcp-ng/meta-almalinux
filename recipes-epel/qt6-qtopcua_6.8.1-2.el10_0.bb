# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtopcua"
PV = "6.8.1"
PR = "2.el10_0"
PACKAGES = " \
 qt6-qtopcua \
 qt6-qtopcua-devel \
 qt6-qtopcua-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt6-qtopcua-6.8.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72da39f0a410aaa5b995a0cf81d2d4abe286e1438db07f8f197e7bf18e651057"

URI_x86_64_v2_qt6-qtopcua = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtopcua-6.8.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtopcua;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtopcua}"
SRC_URI[x86_64_v2_qt6-qtopcua.sha256sum] = "6c2dff5323462b6c77b34395242e963519be75ad5db021ca3b4430aaabc76b8a"

URI_x86_64_v2_qt6-qtopcua-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtopcua-devel-6.8.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtopcua-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtopcua-devel}"
SRC_URI[x86_64_v2_qt6-qtopcua-devel.sha256sum] = "ca3ae98a4ea72497f752e558dff137ae78396bc507bcbbb15565de462e007860"

URI_x86_64_v2_qt6-qtopcua-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtopcua-examples-6.8.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtopcua-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtopcua-examples}"
SRC_URI[x86_64_v2_qt6-qtopcua-examples.sha256sum] = "4fd246db23c9e30215065cc59649132b782ecbb43e5c41f6693a8a7893993b19"

URI_aarch64_qt6-qtopcua = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtopcua-6.8.1-2.el10_0.aarch64.rpm;name=aarch64_qt6-qtopcua;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtopcua}"
SRC_URI[aarch64_qt6-qtopcua.sha256sum] = "8342e016d4386bb39b7f1246ed3cbc1791c2efd6faa231935ad9a58ced126599"

URI_aarch64_qt6-qtopcua-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtopcua-devel-6.8.1-2.el10_0.aarch64.rpm;name=aarch64_qt6-qtopcua-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtopcua-devel}"
SRC_URI[aarch64_qt6-qtopcua-devel.sha256sum] = "a70da638c06f5ad322d2e7a5403c3d754ccfdd0a4d911673b47c5d9ee6ae85e2"

URI_aarch64_qt6-qtopcua-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtopcua-examples-6.8.1-2.el10_0.aarch64.rpm;name=aarch64_qt6-qtopcua-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtopcua-examples}"
SRC_URI[aarch64_qt6-qtopcua-examples.sha256sum] = "c7f36e90a345c078175b492c30bbc41e3fa30c43df4953981c21d8edc1b642e6"

RDEPENDS:qt6-qtopcua = " \
 glibc \
 libstdc++ \
 openssl-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:qt6-qtopcua-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtopcua \
 qt6-qtopcua-devel \
 "
RDEPENDS:qt6-qtopcua-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtopcua \
 qt6-qtopcua-devel \
 "
