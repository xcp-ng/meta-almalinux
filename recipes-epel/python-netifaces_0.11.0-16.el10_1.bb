# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-netifaces"
PV = "0.11.0"
PR = "16.el10_1"
PACKAGES = " \
 python3-netifaces \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-netifaces-0.11.0-16.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45b3542d3b41db578bcd7473b40c61025792c9f2f1ebeac9019b79e2bb02c3a0"

URI_x86_64_v2_python3-netifaces = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-netifaces-0.11.0-16.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-netifaces;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-netifaces}"
SRC_URI[x86_64_v2_python3-netifaces.sha256sum] = "940cccf4d054dceb89cd744784bf3b3ed14a5c2f09d70bbeb80a113ee9b68d0a"

URI_aarch64_python3-netifaces = "${EPEL_MIRROR}/aarch64/Packages/p/python3-netifaces-0.11.0-16.el10_1.aarch64.rpm;name=aarch64_python3-netifaces;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-netifaces}"
SRC_URI[aarch64_python3-netifaces.sha256sum] = "7c7f939663ddab0dcc5e3a8b6ccc8eec52e2f72d93aa14c4404aa82c4f3fc103"

RDEPENDS:python3-netifaces = " \
 glibc \
 python3 \
 "
