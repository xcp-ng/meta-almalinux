# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pcp"
PV = "6.3.7"
PR = "5.el10"
PACKAGES:x86_64_v2 = " \
 pcp \
 pcp-conf \
 pcp-devel \
 pcp-doc \
 pcp-export-pcp2elasticsearch \
 pcp-export-pcp2graphite \
 pcp-export-pcp2influxdb \
 pcp-export-pcp2json \
 pcp-export-pcp2openmetrics \
 pcp-export-pcp2spark \
 pcp-export-pcp2xml \
 pcp-export-pcp2zabbix \
 pcp-export-zabbix-agent \
 pcp-geolocate \
 pcp-gui \
 pcp-import-collectl2pcp \
 pcp-import-ganglia2pcp \
 pcp-import-iostat2pcp \
 pcp-import-mrtg2pcp \
 pcp-import-sar2pcp \
 pcp-libs \
 pcp-libs-devel \
 pcp-pmda-activemq \
 pcp-pmda-amdgpu \
 pcp-pmda-apache \
 pcp-pmda-bash \
 pcp-pmda-bcc \
 pcp-pmda-bind2 \
 pcp-pmda-bonding \
 pcp-pmda-bpf \
 pcp-pmda-bpftrace \
 pcp-pmda-cifs \
 pcp-pmda-cisco \
 pcp-pmda-dbping \
 pcp-pmda-denki \
 pcp-pmda-dm \
 pcp-pmda-docker \
 pcp-pmda-ds389 \
 pcp-pmda-ds389log \
 pcp-pmda-elasticsearch \
 pcp-pmda-farm \
 pcp-pmda-gluster \
 pcp-pmda-gpfs \
 pcp-pmda-gpsd \
 pcp-pmda-hacluster \
 pcp-pmda-haproxy \
 pcp-pmda-infiniband \
 pcp-pmda-json \
 pcp-pmda-libvirt \
 pcp-pmda-lio \
 pcp-pmda-lmsensors \
 pcp-pmda-logger \
 pcp-pmda-lustre \
 pcp-pmda-lustrecomm \
 pcp-pmda-mailq \
 pcp-pmda-memcache \
 pcp-pmda-mic \
 pcp-pmda-mongodb \
 pcp-pmda-mounts \
 pcp-pmda-mssql \
 pcp-pmda-mysql \
 pcp-pmda-named \
 pcp-pmda-netcheck \
 pcp-pmda-netfilter \
 pcp-pmda-news \
 pcp-pmda-nfsclient \
 pcp-pmda-nginx \
 pcp-pmda-nvidia-gpu \
 pcp-pmda-openmetrics \
 pcp-pmda-openvswitch \
 pcp-pmda-oracle \
 pcp-pmda-pdns \
 pcp-pmda-perfevent \
 pcp-pmda-podman \
 pcp-pmda-postfix \
 pcp-pmda-postgresql \
 pcp-pmda-rabbitmq \
 pcp-pmda-redis \
 pcp-pmda-resctrl \
 pcp-pmda-roomtemp \
 pcp-pmda-rsyslog \
 pcp-pmda-samba \
 pcp-pmda-sendmail \
 pcp-pmda-shping \
 pcp-pmda-slurm \
 pcp-pmda-smart \
 pcp-pmda-snmp \
 pcp-pmda-sockets \
 pcp-pmda-statsd \
 pcp-pmda-summary \
 pcp-pmda-systemd \
 pcp-pmda-trace \
 pcp-pmda-unbound \
 pcp-pmda-uwsgi \
 pcp-pmda-weblog \
 pcp-pmda-zimbra \
 pcp-pmda-zswap \
 pcp-selinux \
 pcp-system-tools \
 pcp-testsuite \
 pcp-zeroconf \
 perl-PCP-LogImport \
 perl-PCP-LogSummary \
 perl-PCP-MMV \
 perl-PCP-PMDA \
 python3-pcp \
"
PACKAGES:aarch64 = " \
 pcp \
 pcp-conf \
 pcp-devel \
 pcp-doc \
 pcp-export-pcp2elasticsearch \
 pcp-export-pcp2graphite \
 pcp-export-pcp2influxdb \
 pcp-export-pcp2json \
 pcp-export-pcp2openmetrics \
 pcp-export-pcp2spark \
 pcp-export-pcp2xml \
 pcp-export-pcp2zabbix \
 pcp-export-zabbix-agent \
 pcp-geolocate \
 pcp-gui \
 pcp-import-collectl2pcp \
 pcp-import-ganglia2pcp \
 pcp-import-iostat2pcp \
 pcp-import-mrtg2pcp \
 pcp-import-sar2pcp \
 pcp-libs \
 pcp-libs-devel \
 pcp-pmda-activemq \
 pcp-pmda-amdgpu \
 pcp-pmda-apache \
 pcp-pmda-bash \
 pcp-pmda-bcc \
 pcp-pmda-bind2 \
 pcp-pmda-bonding \
 pcp-pmda-bpf \
 pcp-pmda-bpftrace \
 pcp-pmda-cifs \
 pcp-pmda-cisco \
 pcp-pmda-dbping \
 pcp-pmda-denki \
 pcp-pmda-dm \
 pcp-pmda-docker \
 pcp-pmda-ds389 \
 pcp-pmda-ds389log \
 pcp-pmda-elasticsearch \
 pcp-pmda-farm \
 pcp-pmda-gluster \
 pcp-pmda-gpfs \
 pcp-pmda-gpsd \
 pcp-pmda-hacluster \
 pcp-pmda-haproxy \
 pcp-pmda-infiniband \
 pcp-pmda-json \
 pcp-pmda-libvirt \
 pcp-pmda-lio \
 pcp-pmda-lmsensors \
 pcp-pmda-logger \
 pcp-pmda-lustre \
 pcp-pmda-lustrecomm \
 pcp-pmda-mailq \
 pcp-pmda-memcache \
 pcp-pmda-mic \
 pcp-pmda-mongodb \
 pcp-pmda-mounts \
 pcp-pmda-mysql \
 pcp-pmda-named \
 pcp-pmda-netcheck \
 pcp-pmda-netfilter \
 pcp-pmda-news \
 pcp-pmda-nfsclient \
 pcp-pmda-nginx \
 pcp-pmda-nvidia-gpu \
 pcp-pmda-openmetrics \
 pcp-pmda-openvswitch \
 pcp-pmda-oracle \
 pcp-pmda-pdns \
 pcp-pmda-perfevent \
 pcp-pmda-podman \
 pcp-pmda-postfix \
 pcp-pmda-postgresql \
 pcp-pmda-rabbitmq \
 pcp-pmda-redis \
 pcp-pmda-roomtemp \
 pcp-pmda-rsyslog \
 pcp-pmda-samba \
 pcp-pmda-sendmail \
 pcp-pmda-shping \
 pcp-pmda-slurm \
 pcp-pmda-smart \
 pcp-pmda-snmp \
 pcp-pmda-sockets \
 pcp-pmda-statsd \
 pcp-pmda-summary \
 pcp-pmda-systemd \
 pcp-pmda-trace \
 pcp-pmda-unbound \
 pcp-pmda-uwsgi \
 pcp-pmda-weblog \
 pcp-pmda-zimbra \
 pcp-pmda-zswap \
 pcp-selinux \
 pcp-system-tools \
 pcp-testsuite \
 pcp-zeroconf \
 perl-PCP-LogImport \
 perl-PCP-LogSummary \
 perl-PCP-MMV \
 perl-PCP-PMDA \
 python3-pcp \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pcp-6.3.7-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "214f06a01e2d4e6623871e2e33a95ea0fecd7acf3b8be91ba638d2eaba1fcc5a"

URI_x86_64_v2_pcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp}"
SRC_URI[x86_64_v2_pcp.sha256sum] = "a73b14ff0d0038f50211a54ba57da67923e6a3b7a8181b8505d56d141d41169c"

URI_x86_64_v2_pcp-conf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-conf-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-conf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-conf}"
SRC_URI[x86_64_v2_pcp-conf.sha256sum] = "a51b6f3579ba9d57772b7762e9f2e9dbc94360542d58c5ea0791e2bf1c0cf7cb"

URI_x86_64_v2_pcp-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-devel-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-devel}"
SRC_URI[x86_64_v2_pcp-devel.sha256sum] = "9d0611a4d8bb84dd92a9913dd4ece0f7d1b667cb28943f6154614afd985572f6"

URI_x86_64_v2_pcp-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-doc-6.3.7-5.el10.noarch.rpm;name=x86_64_v2_pcp-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-doc}"
SRC_URI[x86_64_v2_pcp-doc.sha256sum] = "527a2cbe750d677648159033d4674b7da011f9edfab4e9b74987460e7114fe7d"

URI_x86_64_v2_pcp-export-pcp2elasticsearch = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2elasticsearch-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2elasticsearch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2elasticsearch}"
SRC_URI[x86_64_v2_pcp-export-pcp2elasticsearch.sha256sum] = "eed94836ff27318d4d8576538c883150c9d47c039001b035bbe5f13e6b3dc423"

URI_x86_64_v2_pcp-export-pcp2graphite = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2graphite-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2graphite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2graphite}"
SRC_URI[x86_64_v2_pcp-export-pcp2graphite.sha256sum] = "f341d21bfa95965319a96fb02061099e27ec4eb6e65411ca28425d1d79e2217d"

URI_x86_64_v2_pcp-export-pcp2influxdb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2influxdb-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2influxdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2influxdb}"
SRC_URI[x86_64_v2_pcp-export-pcp2influxdb.sha256sum] = "40312a46941da3f13c2a78a2a1b752137f64e0ce1aaeeaefd8b8c97016806596"

URI_x86_64_v2_pcp-export-pcp2json = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2json-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2json;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2json}"
SRC_URI[x86_64_v2_pcp-export-pcp2json.sha256sum] = "90edd46d9aa9e339e300082b579008736c4a6322fa2a53b242e70567911f55cc"

URI_x86_64_v2_pcp-export-pcp2openmetrics = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2openmetrics-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2openmetrics;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2openmetrics}"
SRC_URI[x86_64_v2_pcp-export-pcp2openmetrics.sha256sum] = "66591e5e5122fd9ba62e4a8cb028ba68d9bf6eefee972390b9ed086268156a44"

URI_x86_64_v2_pcp-export-pcp2spark = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2spark-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2spark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2spark}"
SRC_URI[x86_64_v2_pcp-export-pcp2spark.sha256sum] = "22423355da38dd08ddc0d46a0d31cfcf7af58e7b65325bdddeeedc7f7a18b146"

URI_x86_64_v2_pcp-export-pcp2xml = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2xml-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2xml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2xml}"
SRC_URI[x86_64_v2_pcp-export-pcp2xml.sha256sum] = "54985272c99cbd103f98515fa54ec411f40630edb6ea7f26cbe87c3a694c8551"

URI_x86_64_v2_pcp-export-pcp2zabbix = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2zabbix-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2zabbix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2zabbix}"
SRC_URI[x86_64_v2_pcp-export-pcp2zabbix.sha256sum] = "5c795b94a36efac94b9b8c60cf634c7dbb74f843810c8cd0fa923a361fa0712b"

URI_x86_64_v2_pcp-export-zabbix-agent = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-zabbix-agent-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-export-zabbix-agent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-zabbix-agent}"
SRC_URI[x86_64_v2_pcp-export-zabbix-agent.sha256sum] = "cf709e714b70d4b2067a194dbe53c77e234e03e172c19ef8d93abf2b4258a312"

URI_x86_64_v2_pcp-geolocate = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-geolocate-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-geolocate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-geolocate}"
SRC_URI[x86_64_v2_pcp-geolocate.sha256sum] = "7343e77842a75a9e2954b61159fc229c797ac36a4adfecf6593592587dcf76e0"

URI_x86_64_v2_pcp-gui = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-gui-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-gui}"
SRC_URI[x86_64_v2_pcp-gui.sha256sum] = "c3a28f31e72fdf8a0811a6ad91a958ac40da4ff688b262408fb875d9cb284a08"

URI_x86_64_v2_pcp-import-collectl2pcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-import-collectl2pcp-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-import-collectl2pcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-import-collectl2pcp}"
SRC_URI[x86_64_v2_pcp-import-collectl2pcp.sha256sum] = "67aac9e76b954c13436ade169137fc95580ecd3f2f6f79c32edc47466549d651"

URI_x86_64_v2_pcp-import-ganglia2pcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-import-ganglia2pcp-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-import-ganglia2pcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-import-ganglia2pcp}"
SRC_URI[x86_64_v2_pcp-import-ganglia2pcp.sha256sum] = "0136274356683f599100ed52b2d7b1616a92555d78ef8c1d5e51c8afb753ebf3"

URI_x86_64_v2_pcp-import-iostat2pcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-import-iostat2pcp-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-import-iostat2pcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-import-iostat2pcp}"
SRC_URI[x86_64_v2_pcp-import-iostat2pcp.sha256sum] = "928ea481e81512bf39807f63cddca13815a16ab24cecfe41d712d9b755b61ea7"

URI_x86_64_v2_pcp-import-mrtg2pcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-import-mrtg2pcp-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-import-mrtg2pcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-import-mrtg2pcp}"
SRC_URI[x86_64_v2_pcp-import-mrtg2pcp.sha256sum] = "36eba3ba075c3d319a39c7bb27eb3548eb6313847ac3e59f4a1990101ed0896c"

URI_x86_64_v2_pcp-import-sar2pcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-import-sar2pcp-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-import-sar2pcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-import-sar2pcp}"
SRC_URI[x86_64_v2_pcp-import-sar2pcp.sha256sum] = "35074dc0d2c5d5d55c45cb2a4df634477a247d65eaca204ec14aa1a40f966525"

URI_x86_64_v2_pcp-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-libs-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-libs}"
SRC_URI[x86_64_v2_pcp-libs.sha256sum] = "7638bc96ef61a049ce650a03404748604196e5daa2d822c9bb1851026372b5ba"

URI_x86_64_v2_pcp-libs-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-libs-devel-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-libs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-libs-devel}"
SRC_URI[x86_64_v2_pcp-libs-devel.sha256sum] = "8518b7b1050694ab351c3543d1b4c9eb12a5921392966ad7c6cb55aac9f139f5"

URI_x86_64_v2_pcp-pmda-activemq = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-activemq-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-activemq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-activemq}"
SRC_URI[x86_64_v2_pcp-pmda-activemq.sha256sum] = "cf545295276a7d9dc1c141e6577166d379d7410b23034be2ee1c1dd5e38a1c81"

URI_x86_64_v2_pcp-pmda-amdgpu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-amdgpu-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-amdgpu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-amdgpu}"
SRC_URI[x86_64_v2_pcp-pmda-amdgpu.sha256sum] = "0bf3618405f24d01d5d2c04004e5fea57d6fe0a8c7d3441cd49d3f8d02c64b2d"

URI_x86_64_v2_pcp-pmda-apache = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-apache-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-apache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-apache}"
SRC_URI[x86_64_v2_pcp-pmda-apache.sha256sum] = "945e4dea2be366180db08362c132da6d8e03ae1a0b4a7b14794c47094b006374"

URI_x86_64_v2_pcp-pmda-bash = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-bash-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-bash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-bash}"
SRC_URI[x86_64_v2_pcp-pmda-bash.sha256sum] = "e2934e612671de8150b1e32578fb8a91bad4dfd71cf8d0b35c1a1462a2c71840"

URI_x86_64_v2_pcp-pmda-bcc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-bcc-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-bcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-bcc}"
SRC_URI[x86_64_v2_pcp-pmda-bcc.sha256sum] = "631834b5bffd9f071bcbdf210ece0fd1591d08474c2faba551c00ad1ad4af4f7"

URI_x86_64_v2_pcp-pmda-bind2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-bind2-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-bind2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-bind2}"
SRC_URI[x86_64_v2_pcp-pmda-bind2.sha256sum] = "1e056ac64c996ea889c6325278fde679b7d55488561aecbc2ef5a4464dc0907d"

URI_x86_64_v2_pcp-pmda-bonding = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-bonding-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-bonding;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-bonding}"
SRC_URI[x86_64_v2_pcp-pmda-bonding.sha256sum] = "50c946eb12f2d40da566b398fc2bf13b2e65de90ea85f80fe3db6615be917fa3"

URI_x86_64_v2_pcp-pmda-bpf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-bpf-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-bpf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-bpf}"
SRC_URI[x86_64_v2_pcp-pmda-bpf.sha256sum] = "a020c165206b19d2833263586400a7a8d97ef74227cfbd1855893d656d7a4e40"

URI_x86_64_v2_pcp-pmda-bpftrace = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-bpftrace-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-bpftrace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-bpftrace}"
SRC_URI[x86_64_v2_pcp-pmda-bpftrace.sha256sum] = "5a9eb5c44c69c24a7b903ed88ac7d2808bd5f2720b93c2cde4db2a3eed622ccf"

URI_x86_64_v2_pcp-pmda-cifs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-cifs-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-cifs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-cifs}"
SRC_URI[x86_64_v2_pcp-pmda-cifs.sha256sum] = "de2bc731f907e28648d85fa3cd24dfc93254733bd8ae3f3b294a7ef38b1f989f"

URI_x86_64_v2_pcp-pmda-cisco = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-cisco-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-cisco;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-cisco}"
SRC_URI[x86_64_v2_pcp-pmda-cisco.sha256sum] = "546299affa883aae587678f957c3991db1c8e4f3cffdf57fc107246a59aeaf02"

URI_x86_64_v2_pcp-pmda-dbping = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-dbping-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-dbping;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-dbping}"
SRC_URI[x86_64_v2_pcp-pmda-dbping.sha256sum] = "d60f5083df1cc7e63c436a07fd3308c98e16ff601c66d9154c99f238f44d6c33"

URI_x86_64_v2_pcp-pmda-denki = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-denki-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-denki;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-denki}"
SRC_URI[x86_64_v2_pcp-pmda-denki.sha256sum] = "7fdf5ba0572ae0d4caa3820621f9a15ea974fdf69a2c1f947ae20a2073f8aa72"

URI_x86_64_v2_pcp-pmda-dm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-dm-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-dm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-dm}"
SRC_URI[x86_64_v2_pcp-pmda-dm.sha256sum] = "ded5e988c25595b41b9387714a728b6eab2f6c058cad896831f7bbece8065f2e"

URI_x86_64_v2_pcp-pmda-docker = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-docker-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-docker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-docker}"
SRC_URI[x86_64_v2_pcp-pmda-docker.sha256sum] = "4a38bc5639697f2aed5576f8fda3cfd452ce1bcd35969425f85c74be1fe1e653"

URI_x86_64_v2_pcp-pmda-ds389 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-ds389-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-ds389;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-ds389}"
SRC_URI[x86_64_v2_pcp-pmda-ds389.sha256sum] = "8ebbf6b1fe3d64f047f6c2761fdf35232a21796e7bc4e756f4122b74d2214d60"

URI_x86_64_v2_pcp-pmda-ds389log = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-ds389log-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-ds389log;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-ds389log}"
SRC_URI[x86_64_v2_pcp-pmda-ds389log.sha256sum] = "aa7849ea4a581126ffe565aaec7af6d51a7dd2e28998e148d736ab4b69096326"

URI_x86_64_v2_pcp-pmda-elasticsearch = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-elasticsearch-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-elasticsearch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-elasticsearch}"
SRC_URI[x86_64_v2_pcp-pmda-elasticsearch.sha256sum] = "b5306543ca7c0e9abe7668605c747049040c7c900dd7381ddf0922ea8703173a"

URI_x86_64_v2_pcp-pmda-farm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-farm-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-farm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-farm}"
SRC_URI[x86_64_v2_pcp-pmda-farm.sha256sum] = "12fe8c87673ec0c3c341c2327046f3933364f68d270ddde081da7f5e6b7f9bbf"

URI_x86_64_v2_pcp-pmda-gluster = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-gluster-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-gluster;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-gluster}"
SRC_URI[x86_64_v2_pcp-pmda-gluster.sha256sum] = "f92091e3dda0c8757048d7ef562ce9a7efcb87507443795ae2eb7ace24684876"

URI_x86_64_v2_pcp-pmda-gpfs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-gpfs-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-gpfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-gpfs}"
SRC_URI[x86_64_v2_pcp-pmda-gpfs.sha256sum] = "70ff3ab8255234bc42413044a0118a813f47522473ca0da70500448dfb606623"

URI_x86_64_v2_pcp-pmda-gpsd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-gpsd-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-gpsd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-gpsd}"
SRC_URI[x86_64_v2_pcp-pmda-gpsd.sha256sum] = "9670944e75d213271df8642b86a4b35823c16484f1e5c82270a4bd7deeca6a7a"

URI_x86_64_v2_pcp-pmda-hacluster = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-hacluster-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-hacluster;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-hacluster}"
SRC_URI[x86_64_v2_pcp-pmda-hacluster.sha256sum] = "7d86f35499cbf4787e784c8b69b1ed04fb3ae27fc3cc52c5719d04465fc5d29b"

URI_x86_64_v2_pcp-pmda-haproxy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-haproxy-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-haproxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-haproxy}"
SRC_URI[x86_64_v2_pcp-pmda-haproxy.sha256sum] = "c61ed678b86f7dd8425adb75e5e3773e9f6a961d515a13637503dc921ffa2055"

URI_x86_64_v2_pcp-pmda-infiniband = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-infiniband-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-infiniband;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-infiniband}"
SRC_URI[x86_64_v2_pcp-pmda-infiniband.sha256sum] = "9015642a5e993521a010f40b5360ccb4679ea2ff380a2a2771b48860d5845914"

URI_x86_64_v2_pcp-pmda-json = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-json-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-json;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-json}"
SRC_URI[x86_64_v2_pcp-pmda-json.sha256sum] = "209c67ed6de70104537fa33d64c4e4761a6874788cee1382fd47dbf8a633e1bb"

URI_x86_64_v2_pcp-pmda-libvirt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-libvirt-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-libvirt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-libvirt}"
SRC_URI[x86_64_v2_pcp-pmda-libvirt.sha256sum] = "680dcb62b6f1db57bfdb2264bb982545fc28f07e82d144bc1471c219730bc20d"

URI_x86_64_v2_pcp-pmda-lio = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-lio-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-lio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-lio}"
SRC_URI[x86_64_v2_pcp-pmda-lio.sha256sum] = "7c312ac2088d40cb614a4e45cc59046ccef440426a54f7fbbdd5ab655a78b5ea"

URI_x86_64_v2_pcp-pmda-lmsensors = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-lmsensors-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-lmsensors;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-lmsensors}"
SRC_URI[x86_64_v2_pcp-pmda-lmsensors.sha256sum] = "a91147334298e8ca8bfbe5b00b4ba6e96f6bd1e0d9caf750ba5863d2935172d5"

URI_x86_64_v2_pcp-pmda-logger = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-logger-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-logger;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-logger}"
SRC_URI[x86_64_v2_pcp-pmda-logger.sha256sum] = "67b1f4402f37000ba61e05a2631d2b01cfa11bd5b2e0f56db35ca7fb0220bfea"

URI_x86_64_v2_pcp-pmda-lustre = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-lustre-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-lustre;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-lustre}"
SRC_URI[x86_64_v2_pcp-pmda-lustre.sha256sum] = "48ae099a6fde1c91fcfac520b2625e031494098865c6900d8dd09a3c4725164b"

URI_x86_64_v2_pcp-pmda-lustrecomm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-lustrecomm-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-lustrecomm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-lustrecomm}"
SRC_URI[x86_64_v2_pcp-pmda-lustrecomm.sha256sum] = "f33ff3ac776cb78433f43b3d79d13b7d9a50ad9c32e531dfc2a2b477ffe6e896"

URI_x86_64_v2_pcp-pmda-mailq = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-mailq-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-mailq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-mailq}"
SRC_URI[x86_64_v2_pcp-pmda-mailq.sha256sum] = "095a79195ba067af48d37b237b84aff416f02163c331c838cffcf9b71138103d"

URI_x86_64_v2_pcp-pmda-memcache = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-memcache-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-memcache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-memcache}"
SRC_URI[x86_64_v2_pcp-pmda-memcache.sha256sum] = "caf8783e99a1b043da5d94f170f37f7728e196e85946fa7923a96d8185fd2ec4"

URI_x86_64_v2_pcp-pmda-mic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-mic-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-mic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-mic}"
SRC_URI[x86_64_v2_pcp-pmda-mic.sha256sum] = "d4d647da88bf5deee023b76df1765fbf693ff3fc0bd761e2aa48e986ff07d2d4"

URI_x86_64_v2_pcp-pmda-mongodb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-mongodb-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-mongodb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-mongodb}"
SRC_URI[x86_64_v2_pcp-pmda-mongodb.sha256sum] = "47845072b2b3968afc670158f8d9a5a7a692d2d440ff70c185d4884738b46be7"

URI_x86_64_v2_pcp-pmda-mounts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-mounts-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-mounts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-mounts}"
SRC_URI[x86_64_v2_pcp-pmda-mounts.sha256sum] = "bbb7e69a8da5c6b5b10e8856f0ad8d909d433585ae6fd414ba2ba6f96502fc2a"

URI_x86_64_v2_pcp-pmda-mssql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-mssql-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-mssql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-mssql}"
SRC_URI[x86_64_v2_pcp-pmda-mssql.sha256sum] = "30cbe3d47c86ae40c5890a680358be55135d936ca05e937acf4a29aabfe42e47"

URI_x86_64_v2_pcp-pmda-mysql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-mysql-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-mysql}"
SRC_URI[x86_64_v2_pcp-pmda-mysql.sha256sum] = "483f3aa074aacc5549c31fb948b68602bb29674b7dedacf7ae9b48b7215aa98a"

URI_x86_64_v2_pcp-pmda-named = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-named-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-named;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-named}"
SRC_URI[x86_64_v2_pcp-pmda-named.sha256sum] = "bb3a1967905d7ce73c317da6b0e25ee3cd997f84e6d83b3d4f26f26c31ce9809"

URI_x86_64_v2_pcp-pmda-netcheck = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-netcheck-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-netcheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-netcheck}"
SRC_URI[x86_64_v2_pcp-pmda-netcheck.sha256sum] = "5206f288e77dbd48ec09f4b8c72ce8244861eab5e0a6c70be5021d0fb90edc27"

URI_x86_64_v2_pcp-pmda-netfilter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-netfilter-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-netfilter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-netfilter}"
SRC_URI[x86_64_v2_pcp-pmda-netfilter.sha256sum] = "eb9e85b9caa7966356e8166d468694d7d51ff2c20f9567a05ed7429066139f47"

URI_x86_64_v2_pcp-pmda-news = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-news-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-news;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-news}"
SRC_URI[x86_64_v2_pcp-pmda-news.sha256sum] = "74f615910d757106fd83c805670ffed160115ff099d8f2ff8d2e4045b7800f85"

URI_x86_64_v2_pcp-pmda-nfsclient = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-nfsclient-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-nfsclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-nfsclient}"
SRC_URI[x86_64_v2_pcp-pmda-nfsclient.sha256sum] = "1b450e538d684956d753a57ef6f5e3d07815eb30cd43608b9aefd99912844118"

URI_x86_64_v2_pcp-pmda-nginx = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-nginx-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-nginx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-nginx}"
SRC_URI[x86_64_v2_pcp-pmda-nginx.sha256sum] = "8135b0b2634288b5c718525529a6da4f798adad002adb502bcc2c1161b215d9d"

URI_x86_64_v2_pcp-pmda-nvidia-gpu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-nvidia-gpu-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-nvidia-gpu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-nvidia-gpu}"
SRC_URI[x86_64_v2_pcp-pmda-nvidia-gpu.sha256sum] = "6d3256ba953575b599e457e8e8bf9965fd683ce6843db9c416957e422c230077"

URI_x86_64_v2_pcp-pmda-openmetrics = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-openmetrics-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-openmetrics;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-openmetrics}"
SRC_URI[x86_64_v2_pcp-pmda-openmetrics.sha256sum] = "ee2e8c6fbdd3a63199d1093dc91c881a50b767d287bf0c2f329ec0a869f83ebd"

URI_x86_64_v2_pcp-pmda-openvswitch = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-openvswitch-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-openvswitch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-openvswitch}"
SRC_URI[x86_64_v2_pcp-pmda-openvswitch.sha256sum] = "e7511755f53d31dd7d384f4c904ddc06e80cdf904473017e322d9f1d0713afcb"

URI_x86_64_v2_pcp-pmda-oracle = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-oracle-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-oracle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-oracle}"
SRC_URI[x86_64_v2_pcp-pmda-oracle.sha256sum] = "7323a974329ec73bf59a061c0ce36a0c438316abda4be153d820783b6e72ddc7"

URI_x86_64_v2_pcp-pmda-pdns = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-pdns-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-pdns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-pdns}"
SRC_URI[x86_64_v2_pcp-pmda-pdns.sha256sum] = "5c63ec7f47b1d1218211dc9dd2ee22cc8453c207615ea9de73c08f2d6045de1d"

URI_x86_64_v2_pcp-pmda-perfevent = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-perfevent-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-perfevent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-perfevent}"
SRC_URI[x86_64_v2_pcp-pmda-perfevent.sha256sum] = "4bab1889f003a15a667d14896590ba7e89fd7d123ba5d1862ce9be2fad1574b5"

URI_x86_64_v2_pcp-pmda-podman = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-podman-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-podman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-podman}"
SRC_URI[x86_64_v2_pcp-pmda-podman.sha256sum] = "bed2271502f6f9ade6311f23bc78bbf5d33de98191a7cac0a4fd8261fc998b32"

URI_x86_64_v2_pcp-pmda-postfix = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-postfix-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-postfix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-postfix}"
SRC_URI[x86_64_v2_pcp-pmda-postfix.sha256sum] = "bc1fd5598ddba0b4dee47c722048350d29aa72311228852d3883116411e1498e"

URI_x86_64_v2_pcp-pmda-postgresql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-postgresql-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-postgresql}"
SRC_URI[x86_64_v2_pcp-pmda-postgresql.sha256sum] = "fe8bf6165f122b08411feda7e6e9ee9534c1f8e91289cbe5c5002d4ad0b705ba"

URI_x86_64_v2_pcp-pmda-rabbitmq = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-rabbitmq-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-rabbitmq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-rabbitmq}"
SRC_URI[x86_64_v2_pcp-pmda-rabbitmq.sha256sum] = "d5ae40e980d7abf548f75f7e8b608edff7bc36c36a4fab44ce7cde6a4ac42350"

URI_x86_64_v2_pcp-pmda-redis = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-redis-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-redis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-redis}"
SRC_URI[x86_64_v2_pcp-pmda-redis.sha256sum] = "5115e71c0424c51e2ab3e6983af33654ee7b0628ebb161631aaf454f380b8701"

URI_x86_64_v2_pcp-pmda-resctrl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-resctrl-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-resctrl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-resctrl}"
SRC_URI[x86_64_v2_pcp-pmda-resctrl.sha256sum] = "f6759614b0db4db56eaacab16b5ffbde4f4acf30f13cd9800198621b00ca6c66"

URI_x86_64_v2_pcp-pmda-roomtemp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-roomtemp-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-roomtemp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-roomtemp}"
SRC_URI[x86_64_v2_pcp-pmda-roomtemp.sha256sum] = "73adbcf2a76dae6da4ab4faf2184b9bea2bd0a887f4156c5a712f2bb7e742a9f"

URI_x86_64_v2_pcp-pmda-rsyslog = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-rsyslog-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-rsyslog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-rsyslog}"
SRC_URI[x86_64_v2_pcp-pmda-rsyslog.sha256sum] = "3d266274d1cc3ea216c11d8f2f9d8d6965890ea669d68248891f3b25f0712709"

URI_x86_64_v2_pcp-pmda-samba = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-samba-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-samba;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-samba}"
SRC_URI[x86_64_v2_pcp-pmda-samba.sha256sum] = "c14150eb3a48f691f0c092b494d7283796077c68b29a68e91a370e8e602e9f1c"

URI_x86_64_v2_pcp-pmda-sendmail = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-sendmail-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-sendmail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-sendmail}"
SRC_URI[x86_64_v2_pcp-pmda-sendmail.sha256sum] = "20c402903659beadbc3fd948e1170db7ed8bd88055001380cc2a7d553e037554"

URI_x86_64_v2_pcp-pmda-shping = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-shping-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-shping;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-shping}"
SRC_URI[x86_64_v2_pcp-pmda-shping.sha256sum] = "17ef90ef01db2bf0a278734931f588510b89fd2d02855810d219ed1bda362186"

URI_x86_64_v2_pcp-pmda-slurm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-slurm-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-slurm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-slurm}"
SRC_URI[x86_64_v2_pcp-pmda-slurm.sha256sum] = "ff73760b3265b5e4b5b26906e43f109059ec2364218662c42e72c1d2024d6db7"

URI_x86_64_v2_pcp-pmda-smart = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-smart-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-smart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-smart}"
SRC_URI[x86_64_v2_pcp-pmda-smart.sha256sum] = "41d74590afa340f5e9884901d84c94cbe5adec308b343cd11785be9da18d8e69"

URI_x86_64_v2_pcp-pmda-snmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-snmp-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-snmp}"
SRC_URI[x86_64_v2_pcp-pmda-snmp.sha256sum] = "b9a851364fe6cee63ff5e9a545d4f8fa709cc92466b7367cdab810913271b045"

URI_x86_64_v2_pcp-pmda-sockets = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-sockets-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-sockets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-sockets}"
SRC_URI[x86_64_v2_pcp-pmda-sockets.sha256sum] = "4b3f323a714942ee7bbeb3569fd033187e51d75e9a3c62fc3cf6bd66ea2ab8e9"

URI_x86_64_v2_pcp-pmda-statsd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-statsd-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-statsd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-statsd}"
SRC_URI[x86_64_v2_pcp-pmda-statsd.sha256sum] = "396a4f43ba0e660d67f0693da17bf9c5666a8735a0eff554504b2572e1d2c030"

URI_x86_64_v2_pcp-pmda-summary = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-summary-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-summary;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-summary}"
SRC_URI[x86_64_v2_pcp-pmda-summary.sha256sum] = "61043c068610373c5d1005afdd747ad3a9c146675b75be47e436a1120475f098"

URI_x86_64_v2_pcp-pmda-systemd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-systemd-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-systemd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-systemd}"
SRC_URI[x86_64_v2_pcp-pmda-systemd.sha256sum] = "ad32e682ecf3d9aa2663fec22a4b3fe000d1264e8de3ef39cbe1c834063cefa0"

URI_x86_64_v2_pcp-pmda-trace = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-trace-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-trace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-trace}"
SRC_URI[x86_64_v2_pcp-pmda-trace.sha256sum] = "012a7bd6a4e64189ad4149eddc3e06fcce5e0bf23c97558abfefe8cdcdbc134f"

URI_x86_64_v2_pcp-pmda-unbound = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-unbound-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-unbound;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-unbound}"
SRC_URI[x86_64_v2_pcp-pmda-unbound.sha256sum] = "7c549c8067ffd7959190ac563c0e3381cf873bde1c976798fca3aabef8c8fd41"

URI_x86_64_v2_pcp-pmda-uwsgi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-uwsgi-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-uwsgi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-uwsgi}"
SRC_URI[x86_64_v2_pcp-pmda-uwsgi.sha256sum] = "4609e6851460eca25abbedae77c0ba0e677c3a6afad988bddb0af77cba70e797"

URI_x86_64_v2_pcp-pmda-weblog = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-weblog-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-weblog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-weblog}"
SRC_URI[x86_64_v2_pcp-pmda-weblog.sha256sum] = "f815499b26fe26365776cded7a3650400a2db93f7a03f4268d21eb01eb9ed9b9"

URI_x86_64_v2_pcp-pmda-zimbra = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-zimbra-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-zimbra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-zimbra}"
SRC_URI[x86_64_v2_pcp-pmda-zimbra.sha256sum] = "c80c6ed62ac5b803fb12c2d36e2f54c240a32e6ce2d6a2a7ad67e11de4fe9ecf"

URI_x86_64_v2_pcp-pmda-zswap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-zswap-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-zswap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-zswap}"
SRC_URI[x86_64_v2_pcp-pmda-zswap.sha256sum] = "5f1957805dc278400a4e82b55d709bd6f1660992703b84c783b08b4cf8f41ea4"

URI_x86_64_v2_pcp-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-selinux-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-selinux}"
SRC_URI[x86_64_v2_pcp-selinux.sha256sum] = "f3d0ab63cb0393c6ac38ef67f5b18c928c2c81179642d20f980319fec4baa86d"

URI_x86_64_v2_pcp-system-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-system-tools-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-system-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-system-tools}"
SRC_URI[x86_64_v2_pcp-system-tools.sha256sum] = "1f9cd7b8aca2bf82d2c4bb59bf92770ad8db411309ec465fb7e2d4227d936d0b"

URI_x86_64_v2_pcp-testsuite = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/pcp-testsuite-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-testsuite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-testsuite}"
SRC_URI[x86_64_v2_pcp-testsuite.sha256sum] = "5bccb4c8f74c2d655a9d20f8a894a163f90df0e9afd8fb6a3b55981caf540a97"

URI_x86_64_v2_pcp-zeroconf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-zeroconf-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-zeroconf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-zeroconf}"
SRC_URI[x86_64_v2_pcp-zeroconf.sha256sum] = "9a2d97c28c07ef40f728bdd832049c442ec2026ac4878d32a300d133a670c42a"

URI_x86_64_v2_perl-PCP-LogImport = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-PCP-LogImport-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_perl-PCP-LogImport;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-PCP-LogImport}"
SRC_URI[x86_64_v2_perl-PCP-LogImport.sha256sum] = "4298522603cfb94ec78fcc2cdc8705e130f0cf7f46da3cf0177920ea6efdc502"

URI_x86_64_v2_perl-PCP-LogSummary = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-PCP-LogSummary-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_perl-PCP-LogSummary;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-PCP-LogSummary}"
SRC_URI[x86_64_v2_perl-PCP-LogSummary.sha256sum] = "d1af4e4f216d8ecd6876618f196a726a251fe559db0716bc767f987d24b05071"

URI_x86_64_v2_perl-PCP-MMV = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-PCP-MMV-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_perl-PCP-MMV;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-PCP-MMV}"
SRC_URI[x86_64_v2_perl-PCP-MMV.sha256sum] = "8743d5d86b2dd867e3f83134dc64f0fec296c1eaf330f403212ec13039a6d2cc"

URI_x86_64_v2_perl-PCP-PMDA = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-PCP-PMDA-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_perl-PCP-PMDA;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-PCP-PMDA}"
SRC_URI[x86_64_v2_perl-PCP-PMDA.sha256sum] = "e56246c9e28639f0079bde7d2372e400fa56722743c821b9a77e78ef7c4b199a"

URI_x86_64_v2_python3-pcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pcp-6.3.7-5.el10.x86_64_v2.rpm;name=x86_64_v2_python3-pcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pcp}"
SRC_URI[x86_64_v2_python3-pcp.sha256sum] = "b828c05e79d0f0b5d2a9aaa12df2428ded8d7a6bc00f96e4077f38b6ba2a5828"

URI_aarch64_pcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp}"
SRC_URI[aarch64_pcp.sha256sum] = "687a61f669cc1eba2b363f16ee7fb344ba712186ae4030f7dd5ab5666e23d326"

URI_aarch64_pcp-conf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-conf-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-conf;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-conf}"
SRC_URI[aarch64_pcp-conf.sha256sum] = "e69a0dcb471ff4a4bc91ee463b976d6da11f0a1e36e697de51c860f76817a666"

URI_aarch64_pcp-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-devel-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-devel}"
SRC_URI[aarch64_pcp-devel.sha256sum] = "825534e665599d94bda7fd5be0fee56621b636e1ef3fcf6ba9086437b5cf85c4"

URI_aarch64_pcp-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-doc-6.3.7-5.el10.noarch.rpm;name=aarch64_pcp-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-doc}"
SRC_URI[aarch64_pcp-doc.sha256sum] = "527a2cbe750d677648159033d4674b7da011f9edfab4e9b74987460e7114fe7d"

URI_aarch64_pcp-export-pcp2elasticsearch = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2elasticsearch-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-export-pcp2elasticsearch;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2elasticsearch}"
SRC_URI[aarch64_pcp-export-pcp2elasticsearch.sha256sum] = "7c1e1c8be5096bc7816d512d60e49b4d75d2f679d7a12964829a9c9872fcbd6e"

URI_aarch64_pcp-export-pcp2graphite = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2graphite-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-export-pcp2graphite;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2graphite}"
SRC_URI[aarch64_pcp-export-pcp2graphite.sha256sum] = "866d88f685dee70a6b6ea3a0c0daae598b560fb32d0350cf086e5cfea5a64f0d"

URI_aarch64_pcp-export-pcp2influxdb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2influxdb-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-export-pcp2influxdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2influxdb}"
SRC_URI[aarch64_pcp-export-pcp2influxdb.sha256sum] = "649594786922e608502fdef188730276c18ee2e3d6f9f2ae4217c6613c870df4"

URI_aarch64_pcp-export-pcp2json = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2json-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-export-pcp2json;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2json}"
SRC_URI[aarch64_pcp-export-pcp2json.sha256sum] = "89fe7d959878b8d309fd16e501d5e86e7bd4533cc4ecb42082f62f86ac40b123"

URI_aarch64_pcp-export-pcp2openmetrics = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2openmetrics-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-export-pcp2openmetrics;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2openmetrics}"
SRC_URI[aarch64_pcp-export-pcp2openmetrics.sha256sum] = "25ca027ea0a8e40d2518234c4c076cf19b57d8af2dd40f1fc14c6ba94aa489f4"

URI_aarch64_pcp-export-pcp2spark = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2spark-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-export-pcp2spark;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2spark}"
SRC_URI[aarch64_pcp-export-pcp2spark.sha256sum] = "058d12aca9bbbf63f9cd502c6d6dd83592977c6440eb9e6540a1a5c3b6164f90"

URI_aarch64_pcp-export-pcp2xml = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2xml-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-export-pcp2xml;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2xml}"
SRC_URI[aarch64_pcp-export-pcp2xml.sha256sum] = "28832d787f215b4511bd1db3a1b61483daef9fd1bb901121c8db5c46f9203afd"

URI_aarch64_pcp-export-pcp2zabbix = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2zabbix-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-export-pcp2zabbix;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2zabbix}"
SRC_URI[aarch64_pcp-export-pcp2zabbix.sha256sum] = "ce9129cd72db69a56bd5eb39ef9da55de87a85319351631892683ea2ce072f1d"

URI_aarch64_pcp-export-zabbix-agent = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-zabbix-agent-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-export-zabbix-agent;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-zabbix-agent}"
SRC_URI[aarch64_pcp-export-zabbix-agent.sha256sum] = "3715e93b21a876e66d346478323eecc573644891d64367f37a203d3f042c6b54"

URI_aarch64_pcp-geolocate = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-geolocate-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-geolocate;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-geolocate}"
SRC_URI[aarch64_pcp-geolocate.sha256sum] = "e9c29f01f8190df055cc6f7adfbe53d24cf43bd7bb0ba4dba69489e3b10399e3"

URI_aarch64_pcp-gui = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-gui-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-gui}"
SRC_URI[aarch64_pcp-gui.sha256sum] = "d1839b3595706ff2033f0cc3b72d9fb7b77fab3c8ddcb6d7a9e3c495cff582f5"

URI_aarch64_pcp-import-collectl2pcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-import-collectl2pcp-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-import-collectl2pcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-import-collectl2pcp}"
SRC_URI[aarch64_pcp-import-collectl2pcp.sha256sum] = "64f3a8ed34809e8bb7bb0f86c7158319c161ab33d04e18f8a99aa3a7c3315268"

URI_aarch64_pcp-import-ganglia2pcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-import-ganglia2pcp-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-import-ganglia2pcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-import-ganglia2pcp}"
SRC_URI[aarch64_pcp-import-ganglia2pcp.sha256sum] = "33f2dfe74a8a24cf3d513ae85bebc60a382b5947adea875e867ac05f6948d71f"

URI_aarch64_pcp-import-iostat2pcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-import-iostat2pcp-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-import-iostat2pcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-import-iostat2pcp}"
SRC_URI[aarch64_pcp-import-iostat2pcp.sha256sum] = "7b777aabc75d2205c441984c25d0b68c7395e0a5a4c011b184862abe5aa406ba"

URI_aarch64_pcp-import-mrtg2pcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-import-mrtg2pcp-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-import-mrtg2pcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-import-mrtg2pcp}"
SRC_URI[aarch64_pcp-import-mrtg2pcp.sha256sum] = "41319620ea72985f81f1f5cfcd6023f21b60382af9d7148aed735f2956b1c71e"

URI_aarch64_pcp-import-sar2pcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-import-sar2pcp-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-import-sar2pcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-import-sar2pcp}"
SRC_URI[aarch64_pcp-import-sar2pcp.sha256sum] = "f1b68db59765fed6304002dcb341a33cb796093d93f9a8674d89b280e142defa"

URI_aarch64_pcp-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-libs-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-libs}"
SRC_URI[aarch64_pcp-libs.sha256sum] = "d769a195a8702228974d2ed1e9475dd9e5f56639f7ce374f4f56274b8b622f08"

URI_aarch64_pcp-libs-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-libs-devel-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-libs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-libs-devel}"
SRC_URI[aarch64_pcp-libs-devel.sha256sum] = "397bd2438a22108f9a40434b66b2d8dfadbcb2b83689cbbee79f7350c1d55f3b"

URI_aarch64_pcp-pmda-activemq = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-activemq-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-activemq;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-activemq}"
SRC_URI[aarch64_pcp-pmda-activemq.sha256sum] = "6a23ab8c758f970946ba54349fe6a6e420fbf8f52b9bf09b3d19c286eb5d37b4"

URI_aarch64_pcp-pmda-amdgpu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-amdgpu-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-amdgpu;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-amdgpu}"
SRC_URI[aarch64_pcp-pmda-amdgpu.sha256sum] = "24463874b7d02403ddd65fabef3ac16c8edbc39b149c15f0252a52cf065f0ef0"

URI_aarch64_pcp-pmda-apache = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-apache-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-apache;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-apache}"
SRC_URI[aarch64_pcp-pmda-apache.sha256sum] = "b0bacba89167358e62abfad37b98d4d752e4ac05a0b6c53f5971a989f23860b9"

URI_aarch64_pcp-pmda-bash = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-bash-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-bash;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-bash}"
SRC_URI[aarch64_pcp-pmda-bash.sha256sum] = "46a05dd861f0ca650301d5946e903d00ac87fbc9d16363613cf0504a88150475"

URI_aarch64_pcp-pmda-bcc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-bcc-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-bcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-bcc}"
SRC_URI[aarch64_pcp-pmda-bcc.sha256sum] = "e71cadd3820cf25fd7e202fee79ff9796690c438909ff37bfef622da491f6044"

URI_aarch64_pcp-pmda-bind2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-bind2-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-bind2;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-bind2}"
SRC_URI[aarch64_pcp-pmda-bind2.sha256sum] = "0e94f91ecf919437f93182ff282452473e3d7fac346633efef2b7aa9cd57c32d"

URI_aarch64_pcp-pmda-bonding = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-bonding-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-bonding;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-bonding}"
SRC_URI[aarch64_pcp-pmda-bonding.sha256sum] = "cd70c8cbf785cd93bbe23c83820c5168313c1de7c655142f9100edcb56262d62"

URI_aarch64_pcp-pmda-bpf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-bpf-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-bpf;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-bpf}"
SRC_URI[aarch64_pcp-pmda-bpf.sha256sum] = "222f10706f0c1ade281445915287ad6c14f3bc2649875773298e23227bafac75"

URI_aarch64_pcp-pmda-bpftrace = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-bpftrace-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-bpftrace;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-bpftrace}"
SRC_URI[aarch64_pcp-pmda-bpftrace.sha256sum] = "a44b76bf20e64844e7f63b8e584f1f9b2490e4cbcf2ccd6220d45abf7698652f"

URI_aarch64_pcp-pmda-cifs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-cifs-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-cifs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-cifs}"
SRC_URI[aarch64_pcp-pmda-cifs.sha256sum] = "1a45306faf08595284cbf4a2cab0d80041ca327d5ae4d11c370810a2cc657c0e"

URI_aarch64_pcp-pmda-cisco = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-cisco-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-cisco;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-cisco}"
SRC_URI[aarch64_pcp-pmda-cisco.sha256sum] = "2d8e614ffc13fb8a487823e2b8733770a007d816144e73cc227b5b46b8cb204c"

URI_aarch64_pcp-pmda-dbping = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-dbping-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-dbping;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-dbping}"
SRC_URI[aarch64_pcp-pmda-dbping.sha256sum] = "2bd576d0e7522d2b4553be18f5f473ceb0c767cecfe9701bf53d9cec2112ccad"

URI_aarch64_pcp-pmda-denki = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-denki-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-denki;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-denki}"
SRC_URI[aarch64_pcp-pmda-denki.sha256sum] = "6e92f13e26d099f98630fbd86d01b8726e556d92b4c18c6c8ffbce12ee5ca9b7"

URI_aarch64_pcp-pmda-dm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-dm-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-dm;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-dm}"
SRC_URI[aarch64_pcp-pmda-dm.sha256sum] = "097437babead600876a4688d07d3b9265afb2c0b690211aa135d42374e810f44"

URI_aarch64_pcp-pmda-docker = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-docker-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-docker;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-docker}"
SRC_URI[aarch64_pcp-pmda-docker.sha256sum] = "6b53421b6afffff4893bd2f0c700a47f240f18177e62a034456ead5c6741c254"

URI_aarch64_pcp-pmda-ds389 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-ds389-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-ds389;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-ds389}"
SRC_URI[aarch64_pcp-pmda-ds389.sha256sum] = "5775c7f32f66fff0b12fce6ab33988fa4e888dc1f38a4ca9b2a16ca6acfb13e5"

URI_aarch64_pcp-pmda-ds389log = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-ds389log-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-ds389log;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-ds389log}"
SRC_URI[aarch64_pcp-pmda-ds389log.sha256sum] = "6572fea32cded5e09f9bc7c3bc371b4ea00b902e80cc7dc49d4fa950832dd06d"

URI_aarch64_pcp-pmda-elasticsearch = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-elasticsearch-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-elasticsearch;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-elasticsearch}"
SRC_URI[aarch64_pcp-pmda-elasticsearch.sha256sum] = "703c11481ba960267c2dd427a8e7b39a0e7289a4ef10d5546ee4031903077277"

URI_aarch64_pcp-pmda-farm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-farm-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-farm;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-farm}"
SRC_URI[aarch64_pcp-pmda-farm.sha256sum] = "4c10d09254af5dcd4a18319a308873ff610ce0d7ff67d0b6effeae64fdbbf088"

URI_aarch64_pcp-pmda-gluster = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-gluster-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-gluster;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-gluster}"
SRC_URI[aarch64_pcp-pmda-gluster.sha256sum] = "9f3ac1dda34d0c1ad00117b73c1d3a770fb5e39a0fdb97c3932ddd8e4baab204"

URI_aarch64_pcp-pmda-gpfs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-gpfs-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-gpfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-gpfs}"
SRC_URI[aarch64_pcp-pmda-gpfs.sha256sum] = "cd9ebc018f1efe1a5d4283f66074e86b32675eecd684dbfe3374aade94611264"

URI_aarch64_pcp-pmda-gpsd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-gpsd-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-gpsd;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-gpsd}"
SRC_URI[aarch64_pcp-pmda-gpsd.sha256sum] = "3bdc8e3596ef3b69172416677b7c6b73fb79d1500d01ceec2de51706395ac295"

URI_aarch64_pcp-pmda-hacluster = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-hacluster-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-hacluster;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-hacluster}"
SRC_URI[aarch64_pcp-pmda-hacluster.sha256sum] = "0fd70aad2304d5e89ee5cccc5c7427db2f74855f6d4472dfc90b4119ef3b466b"

URI_aarch64_pcp-pmda-haproxy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-haproxy-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-haproxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-haproxy}"
SRC_URI[aarch64_pcp-pmda-haproxy.sha256sum] = "79682cc82eee8822d9506536ddbe97067a0cd3df379421c4952c89ad5dea0ddf"

URI_aarch64_pcp-pmda-infiniband = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-infiniband-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-infiniband;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-infiniband}"
SRC_URI[aarch64_pcp-pmda-infiniband.sha256sum] = "971831790b6f61b3f317426c21913049723e6e647c6d5970c1535ff8b1c0dc00"

URI_aarch64_pcp-pmda-json = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-json-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-json;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-json}"
SRC_URI[aarch64_pcp-pmda-json.sha256sum] = "5d04773edfc3f6546790cb5e21bb11d5123fe2483c75e6377e17cb63f53f36c3"

URI_aarch64_pcp-pmda-libvirt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-libvirt-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-libvirt;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-libvirt}"
SRC_URI[aarch64_pcp-pmda-libvirt.sha256sum] = "13a649d738b36417473057693cf9dc1a519ba69602cdd49c722dfe981e0d05e1"

URI_aarch64_pcp-pmda-lio = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-lio-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-lio;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-lio}"
SRC_URI[aarch64_pcp-pmda-lio.sha256sum] = "f46bb017e79d073381a1fc429a432215eb7bf391d77192500e169539ad766c62"

URI_aarch64_pcp-pmda-lmsensors = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-lmsensors-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-lmsensors;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-lmsensors}"
SRC_URI[aarch64_pcp-pmda-lmsensors.sha256sum] = "30e894723a598b5cfe20d7c26c46d67e3ce4b92cb848fd7eec495cee85e20511"

URI_aarch64_pcp-pmda-logger = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-logger-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-logger;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-logger}"
SRC_URI[aarch64_pcp-pmda-logger.sha256sum] = "18cf770ad4836c4361356eb8b93279ad7bc4adac27bc7d41e0d575e280231620"

URI_aarch64_pcp-pmda-lustre = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-lustre-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-lustre;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-lustre}"
SRC_URI[aarch64_pcp-pmda-lustre.sha256sum] = "8f29fdd76233919213167a7eb5bb16d53db26c8d55366dfa5af964f89d87ef57"

URI_aarch64_pcp-pmda-lustrecomm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-lustrecomm-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-lustrecomm;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-lustrecomm}"
SRC_URI[aarch64_pcp-pmda-lustrecomm.sha256sum] = "b2f9088d1fd21aecfb9bb37a03f529c63bb01a115847d15451c2d993f540e49e"

URI_aarch64_pcp-pmda-mailq = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-mailq-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-mailq;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-mailq}"
SRC_URI[aarch64_pcp-pmda-mailq.sha256sum] = "5063c26c24991884cb687f851fa08aef982ed3f438d439e7f79d36f4676ab568"

URI_aarch64_pcp-pmda-memcache = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-memcache-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-memcache;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-memcache}"
SRC_URI[aarch64_pcp-pmda-memcache.sha256sum] = "12710bd2f2280f5c412dea246b0dc348743d19b3598926c57b26c5bb5a11e476"

URI_aarch64_pcp-pmda-mic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-mic-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-mic;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-mic}"
SRC_URI[aarch64_pcp-pmda-mic.sha256sum] = "b144b7ce7934dfb0f6a1329d0222f2ff5a53dba7c5c3490ee066d047c93dab6c"

URI_aarch64_pcp-pmda-mongodb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-mongodb-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-mongodb;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-mongodb}"
SRC_URI[aarch64_pcp-pmda-mongodb.sha256sum] = "b7a2372afc7d7d23a4c0194350b560009baf091ae373a089228b375398f64758"

URI_aarch64_pcp-pmda-mounts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-mounts-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-mounts;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-mounts}"
SRC_URI[aarch64_pcp-pmda-mounts.sha256sum] = "69d81588ac2c41bc3134734891ccf62842a9d6882948f78983686fbb3b9e8864"

URI_aarch64_pcp-pmda-mysql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-mysql-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-mysql}"
SRC_URI[aarch64_pcp-pmda-mysql.sha256sum] = "538b6b1423d2b8d19f51271eee22c868520f5c451e4cbec706142347ae791eed"

URI_aarch64_pcp-pmda-named = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-named-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-named;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-named}"
SRC_URI[aarch64_pcp-pmda-named.sha256sum] = "2d1c234fe5788435f348a6b69f3e3454da2c8ef256d82e0d0cc6ed048ae4d717"

URI_aarch64_pcp-pmda-netcheck = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-netcheck-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-netcheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-netcheck}"
SRC_URI[aarch64_pcp-pmda-netcheck.sha256sum] = "f0c5ffc5bcd79ea3535fdf7d1ddb6d66f33e4d4d91aaff9a7f89342c13b225cb"

URI_aarch64_pcp-pmda-netfilter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-netfilter-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-netfilter;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-netfilter}"
SRC_URI[aarch64_pcp-pmda-netfilter.sha256sum] = "6ce1e53a2d92597a34fe04d014137bafa254392fd23518321e817460dfdc5998"

URI_aarch64_pcp-pmda-news = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-news-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-news;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-news}"
SRC_URI[aarch64_pcp-pmda-news.sha256sum] = "3bc42ba7342df70a9f26b84a18b9ca078105225cdcde52b978acac66df715cf7"

URI_aarch64_pcp-pmda-nfsclient = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-nfsclient-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-nfsclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-nfsclient}"
SRC_URI[aarch64_pcp-pmda-nfsclient.sha256sum] = "41dd5a80227b284e892cc7e4d358b146e1205ae691e1dd99e849fa969b2e5151"

URI_aarch64_pcp-pmda-nginx = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-nginx-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-nginx;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-nginx}"
SRC_URI[aarch64_pcp-pmda-nginx.sha256sum] = "18df1b739558d7b82b2d6f326bb7f1beaccbc0a8d26a46a17d5350ba79919dfa"

URI_aarch64_pcp-pmda-nvidia-gpu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-nvidia-gpu-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-nvidia-gpu;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-nvidia-gpu}"
SRC_URI[aarch64_pcp-pmda-nvidia-gpu.sha256sum] = "031db87f696f6966bb3c154cc63db376e8d8fc7a2ec747671390fca0e5e652e9"

URI_aarch64_pcp-pmda-openmetrics = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-openmetrics-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-openmetrics;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-openmetrics}"
SRC_URI[aarch64_pcp-pmda-openmetrics.sha256sum] = "6bb3f64e42669faf032b032721a7ed4d898f76f0e3919c3c89b5267fc6ffaa95"

URI_aarch64_pcp-pmda-openvswitch = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-openvswitch-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-openvswitch;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-openvswitch}"
SRC_URI[aarch64_pcp-pmda-openvswitch.sha256sum] = "f5b7d5ccbf31d30afb8d53ff9e877d2ded1e408e1137fe4e57afcbee2cc136a9"

URI_aarch64_pcp-pmda-oracle = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-oracle-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-oracle;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-oracle}"
SRC_URI[aarch64_pcp-pmda-oracle.sha256sum] = "29c296399c79c671973133db5096c442266236cf56dd27575558e2d2f4974758"

URI_aarch64_pcp-pmda-pdns = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-pdns-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-pdns;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-pdns}"
SRC_URI[aarch64_pcp-pmda-pdns.sha256sum] = "7345823ff5811437b48f28726dfc413e4b20fc0c096c3e4d729ccd3300d7a306"

URI_aarch64_pcp-pmda-perfevent = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-perfevent-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-perfevent;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-perfevent}"
SRC_URI[aarch64_pcp-pmda-perfevent.sha256sum] = "4b43200859944da8ffd045cb692aaf46dd970027d06785c0212b4f901580ec77"

URI_aarch64_pcp-pmda-podman = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-podman-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-podman;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-podman}"
SRC_URI[aarch64_pcp-pmda-podman.sha256sum] = "a5e3e5f963d0d296df67fe05e39b712697fb783896f30b5c337280fa4510769c"

URI_aarch64_pcp-pmda-postfix = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-postfix-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-postfix;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-postfix}"
SRC_URI[aarch64_pcp-pmda-postfix.sha256sum] = "a49764abc783058a5ab6d41b121cd4a48ebce494e1612e0555e22bec8ec8efd2"

URI_aarch64_pcp-pmda-postgresql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-postgresql-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-postgresql}"
SRC_URI[aarch64_pcp-pmda-postgresql.sha256sum] = "aa47d5cc542d244a35eaefaa681013092595608e4fbf79940f51e4986c932c7b"

URI_aarch64_pcp-pmda-rabbitmq = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-rabbitmq-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-rabbitmq;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-rabbitmq}"
SRC_URI[aarch64_pcp-pmda-rabbitmq.sha256sum] = "6d97a517556087d9579c9ab4cb27ea1fc09688a8039fc2ef489d5d4310640ab8"

URI_aarch64_pcp-pmda-redis = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-redis-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-redis;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-redis}"
SRC_URI[aarch64_pcp-pmda-redis.sha256sum] = "630354624b7e95e769f1bed701dc05d9230c09b34762963170fd9b3359018799"

URI_aarch64_pcp-pmda-roomtemp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-roomtemp-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-roomtemp;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-roomtemp}"
SRC_URI[aarch64_pcp-pmda-roomtemp.sha256sum] = "b1b2c6bcf8ab25f14e35adfa336f57f25170a59c3a4aaa76b6527df1b1fd4082"

URI_aarch64_pcp-pmda-rsyslog = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-rsyslog-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-rsyslog;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-rsyslog}"
SRC_URI[aarch64_pcp-pmda-rsyslog.sha256sum] = "f72197bd0f370e6a3a818f60cb521ab330c853fe0e0a5f30649de80f7c6f4ae7"

URI_aarch64_pcp-pmda-samba = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-samba-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-samba;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-samba}"
SRC_URI[aarch64_pcp-pmda-samba.sha256sum] = "cae1c6f24dedcb985ea681b1091c07ffabfb618ad4c9e2fe6ec2f24e1fe02db3"

URI_aarch64_pcp-pmda-sendmail = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-sendmail-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-sendmail;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-sendmail}"
SRC_URI[aarch64_pcp-pmda-sendmail.sha256sum] = "115e1a6f2e6285a666d1de8d654efafef9c3d5c9152429742cde0b4b4d4872de"

URI_aarch64_pcp-pmda-shping = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-shping-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-shping;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-shping}"
SRC_URI[aarch64_pcp-pmda-shping.sha256sum] = "4b881f51b7ad339dd0eb53451b9cb05459f1f41525da96e65808bcb8e4993e30"

URI_aarch64_pcp-pmda-slurm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-slurm-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-slurm;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-slurm}"
SRC_URI[aarch64_pcp-pmda-slurm.sha256sum] = "548aa8af97836bf7bde1495e640803b920340648fdefd2afe2a47ea57cc30048"

URI_aarch64_pcp-pmda-smart = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-smart-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-smart;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-smart}"
SRC_URI[aarch64_pcp-pmda-smart.sha256sum] = "355a18abc442af965a2961a640e4ad7612fbdc192fd3f13e5ecd7f3f9433045a"

URI_aarch64_pcp-pmda-snmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-snmp-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-snmp}"
SRC_URI[aarch64_pcp-pmda-snmp.sha256sum] = "f82e00ed481d822a62f6f891420a6c6e5bc769a45809ae0ecdf476058de85bfb"

URI_aarch64_pcp-pmda-sockets = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-sockets-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-sockets;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-sockets}"
SRC_URI[aarch64_pcp-pmda-sockets.sha256sum] = "b9b0b10f22049fcae91eaf1c76d189bad02ffc7bd98ef5dd2059a51886d40d86"

URI_aarch64_pcp-pmda-statsd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-statsd-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-statsd;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-statsd}"
SRC_URI[aarch64_pcp-pmda-statsd.sha256sum] = "45f13e3b159dcf4f7dc38d4e97a1879c5159f9bd753ce940b28709a29e8756c9"

URI_aarch64_pcp-pmda-summary = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-summary-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-summary;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-summary}"
SRC_URI[aarch64_pcp-pmda-summary.sha256sum] = "ff47eac152039707ee7396ee84b9f7b7a7fc334a04a3923f8435b0bd42f669df"

URI_aarch64_pcp-pmda-systemd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-systemd-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-systemd;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-systemd}"
SRC_URI[aarch64_pcp-pmda-systemd.sha256sum] = "4d7b1fcc343bf0a5e64b4431b57a98a5a7e8bde6e1ab99889adea8d054d8fabd"

URI_aarch64_pcp-pmda-trace = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-trace-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-trace;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-trace}"
SRC_URI[aarch64_pcp-pmda-trace.sha256sum] = "93c1e83183ec954c94211926c9ea83f58bc1b06c87acabf0ac5598c609de0d9f"

URI_aarch64_pcp-pmda-unbound = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-unbound-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-unbound;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-unbound}"
SRC_URI[aarch64_pcp-pmda-unbound.sha256sum] = "3981fbbaaecfa876c0d49019f2dfa53a20e301352966391526c52f1199fe048b"

URI_aarch64_pcp-pmda-uwsgi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-uwsgi-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-uwsgi;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-uwsgi}"
SRC_URI[aarch64_pcp-pmda-uwsgi.sha256sum] = "c08d2cb56b019a099cd2e0524b77ad857cb057bccd45a4c0ab55cc4e92aaccdf"

URI_aarch64_pcp-pmda-weblog = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-weblog-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-weblog;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-weblog}"
SRC_URI[aarch64_pcp-pmda-weblog.sha256sum] = "cf873e0d0f863cf1d5e99ee14d380ad02e81d8dd6f20cf1be62a86574939cf2e"

URI_aarch64_pcp-pmda-zimbra = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-zimbra-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-zimbra;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-zimbra}"
SRC_URI[aarch64_pcp-pmda-zimbra.sha256sum] = "1a139f10e472023d69703926d04987f6f9c4f45c8c5582b3ae81f85d22ae7053"

URI_aarch64_pcp-pmda-zswap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-zswap-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-pmda-zswap;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-zswap}"
SRC_URI[aarch64_pcp-pmda-zswap.sha256sum] = "c80b96dea14140f6303e9dbf4d01970f5a5ae1c417f55e36220ee22d643c229c"

URI_aarch64_pcp-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-selinux-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-selinux}"
SRC_URI[aarch64_pcp-selinux.sha256sum] = "e586ddce17c7e5439f775f9b573b6941887321935db1adc43055f15b5c92f1ce"

URI_aarch64_pcp-system-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-system-tools-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-system-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-system-tools}"
SRC_URI[aarch64_pcp-system-tools.sha256sum] = "44e8d29b1d59742229f97a501776e97357a76ada093eff6296f61f118ae89cfc"

URI_aarch64_pcp-testsuite = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/pcp-testsuite-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-testsuite;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-testsuite}"
SRC_URI[aarch64_pcp-testsuite.sha256sum] = "707f088c4361d5070b7294b5088e622cad2c9e97dc4d407d3e373e2cbf234a0d"

URI_aarch64_pcp-zeroconf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-zeroconf-6.3.7-5.el10.aarch64.rpm;name=aarch64_pcp-zeroconf;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-zeroconf}"
SRC_URI[aarch64_pcp-zeroconf.sha256sum] = "9a631fca4e06f4263ff068cbb2277b9458c3ef356fb04bd8a956e80548e7d9b8"

URI_aarch64_perl-PCP-LogImport = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-PCP-LogImport-6.3.7-5.el10.aarch64.rpm;name=aarch64_perl-PCP-LogImport;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-PCP-LogImport}"
SRC_URI[aarch64_perl-PCP-LogImport.sha256sum] = "78b8bb8ccc21e6b575e03a07dc4c7c4338b035747bacd788ccabae8350bc3337"

URI_aarch64_perl-PCP-LogSummary = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-PCP-LogSummary-6.3.7-5.el10.aarch64.rpm;name=aarch64_perl-PCP-LogSummary;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-PCP-LogSummary}"
SRC_URI[aarch64_perl-PCP-LogSummary.sha256sum] = "98f60cf87e4a9ccba7b5f688b32b8445ab4479b340d0a28d747e6c2cbec45f47"

URI_aarch64_perl-PCP-MMV = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-PCP-MMV-6.3.7-5.el10.aarch64.rpm;name=aarch64_perl-PCP-MMV;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-PCP-MMV}"
SRC_URI[aarch64_perl-PCP-MMV.sha256sum] = "7e16a3b32c20f254602c7e803c74b465615e3a8bad3ef322d311cef34dcf2443"

URI_aarch64_perl-PCP-PMDA = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-PCP-PMDA-6.3.7-5.el10.aarch64.rpm;name=aarch64_perl-PCP-PMDA;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-PCP-PMDA}"
SRC_URI[aarch64_perl-PCP-PMDA.sha256sum] = "b0de579e2b56e2975e7197a72ffd06f5588c6b92b38eb81bb94454a3c2929ddf"

URI_aarch64_python3-pcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pcp-6.3.7-5.el10.aarch64.rpm;name=aarch64_python3-pcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pcp}"
SRC_URI[aarch64_python3-pcp.sha256sum] = "9c874886152f2071e6041ead64bcb6bc6f1fc6791f62b3c58721194d24c5a084"

RDEPENDS:pcp = " \
 bash \
 diffutils \
 findutils \
 gawk \
 glibc \
 grep \
 hostname \
 libuv \
 openssl-libs \
 pcp-libs \
 pcp-selinux \
 pkgconf-pkg-config \
 procps-ng \
 readline \
 sed \
 virtual/coreutils \
 which \
 xz \
 zlib-ng-compat \
 "
RDEPENDS:pcp-conf = " \
 "
RDEPENDS:pcp-devel = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 pcp-libs-devel \
 perl-PCP-PMDA \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:pcp-doc = " \
 "
RDEPENDS:pcp-export-pcp2elasticsearch = " \
 pcp \
 pcp-libs \
 python3-pcp \
 python3-requests \
 "
RDEPENDS:pcp-export-pcp2graphite = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-export-pcp2influxdb = " \
 pcp \
 pcp-libs \
 python3-pcp \
 python3-requests \
 "
RDEPENDS:pcp-export-pcp2json = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-export-pcp2openmetrics = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-export-pcp2spark = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-export-pcp2xml = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-export-pcp2zabbix = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-export-zabbix-agent = " \
 glibc \
 pcp-libs \
 "
RDEPENDS:pcp-geolocate = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-gui = " \
 bash \
 glibc \
 liberation-sans-fonts \
 libgcc \
 libstdc++ \
 pcp \
 pcp-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
RDEPENDS:pcp-import-collectl2pcp = " \
 glibc \
 pcp-libs \
 "
RDEPENDS:pcp-import-ganglia2pcp = " \
 pcp-libs \
 perl-File-Basename \
 perl-Getopt-Std \
 perl-PCP-LogImport \
 perl-POSIX \
 perl-TimeDate \
 perl-interpreter \
 perl-libs \
 perl-vars \
 rrdtool-perl \
 "
RDEPENDS:pcp-import-iostat2pcp = " \
 pcp-libs \
 perl-Getopt-Std \
 perl-PCP-LogImport \
 perl-TimeDate \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:pcp-import-mrtg2pcp = " \
 pcp-libs \
 perl-PCP-LogImport \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:pcp-import-sar2pcp = " \
 pcp-libs \
 perl-PCP-LogImport \
 perl-TimeDate \
 perl-XML-TokeParser \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:pcp-libs = " \
 avahi-libs \
 cyrus-sasl-lib \
 glibc \
 libuv \
 openssl-libs \
 pcp-conf \
 systemd-libs \
 xz-libs \
 "
RDEPENDS:pcp-libs-devel = " \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-activemq = " \
 bash \
 pcp \
 pcp-libs \
 perl-Digest-MD5 \
 perl-JSON \
 perl-PCP-PMDA \
 perl-Time-HiRes \
 perl-libs \
 perl-libwww-perl \
 "
RDEPENDS:pcp-pmda-amdgpu = " \
 bash \
 glibc \
 libdrm \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-apache = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-bash = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-bcc = " \
 bash \
 pcp \
 pcp-libs \
 python3-bcc \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-bind2 = " \
 bash \
 pcp \
 pcp-libs \
 perl-File-Slurp \
 perl-PCP-PMDA \
 perl-Time-HiRes \
 perl-XML-LibXML \
 perl-autodie \
 perl-libwww-perl \
 "
RDEPENDS:pcp-pmda-bonding = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-bpf = " \
 bash \
 elfutils-libelf \
 glibc \
 libbpf \
 pcp \
 pcp-libs \
 zlib-ng-compat \
 "
RDEPENDS:pcp-pmda-bpftrace = " \
 bash \
 bpftrace \
 pcp \
 pcp-libs \
 python3 \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-cifs = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-cisco = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-dbping = " \
 bash \
 pcp \
 pcp-libs \
 perl-DBI \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-denki = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-dm = " \
 bash \
 device-mapper-libs \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-docker = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-ds389 = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-ds389log = " \
 bash \
 pcp \
 pcp-libs \
 perl-Date-Manip \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-elasticsearch = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-farm = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 smartmontools \
 "
RDEPENDS:pcp-pmda-gluster = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-gpfs = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-gpsd = " \
 bash \
 pcp \
 pcp-libs \
 perl-JSON \
 perl-PCP-PMDA \
 perl-Time-HiRes \
 "
RDEPENDS:pcp-pmda-hacluster = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-haproxy = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-infiniband = " \
 bash \
 glibc \
 infiniband-diags \
 libibumad \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-json = " \
 bash \
 pcp \
 pcp-libs \
 python3-jsonpointer \
 python3-pcp \
 python3-six \
 "
RDEPENDS:pcp-pmda-libvirt = " \
 bash \
 pcp \
 pcp-libs \
 python3-libvirt \
 python3-lxml \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-lio = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 python3-rtslib \
 "
RDEPENDS:pcp-pmda-lmsensors = " \
 bash \
 lm_sensors \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-logger = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-lustre = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-lustrecomm = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-mailq = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-memcache = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-mic = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-mongodb = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-mounts = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-mssql = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 python3-pyodbc \
 "
RDEPENDS:pcp-pmda-mysql = " \
 bash \
 pcp \
 pcp-libs \
 perl-DBD-MySQL \
 perl-DBI \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-named = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-netcheck = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-netfilter = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-news = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-nfsclient = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-nginx = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 perl-libwww-perl \
 "
RDEPENDS:pcp-pmda-nvidia-gpu = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-openmetrics = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 python3-requests \
 "
RDEPENDS:pcp-pmda-openvswitch = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-oracle = " \
 bash \
 pcp \
 pcp-libs \
 perl-DBI \
 perl-PCP-PMDA \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:pcp-pmda-pdns = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 perl-Time-HiRes \
 "
RDEPENDS:pcp-pmda-perfevent = " \
 bash \
 glibc \
 libpfm \
 pcp \
 pcp-libs \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:pcp-pmda-podman = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-postfix = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 perl-Time-HiRes \
 postfix-perl-scripts \
 "
RDEPENDS:pcp-pmda-postgresql = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 python3-psycopg2 \
 "
RDEPENDS:pcp-pmda-rabbitmq = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-redis = " \
 bash \
 pcp \
 pcp-libs \
 perl-Data-Dumper \
 perl-PCP-PMDA \
 perl-Time-HiRes \
 perl-autodie \
 "
RDEPENDS:pcp-pmda-resctrl = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-roomtemp = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-rsyslog = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-samba = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-sendmail = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-shping = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-slurm = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-smart = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 smartmontools \
 "
RDEPENDS:pcp-pmda-snmp = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-sockets = " \
 bash \
 glibc \
 iproute \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-statsd = " \
 HdrHistogram_c \
 bash \
 chan \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-summary = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-systemd = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 systemd-libs \
 "
RDEPENDS:pcp-pmda-trace = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-unbound = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-uwsgi = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-weblog = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-zimbra = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-zswap = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-selinux = " \
 bash \
 policycoreutils \
 selinux-policy-targeted \
 "
RDEPENDS:pcp-system-tools = " \
 bash \
 glibc \
 ncurses-libs \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-testsuite:x86_64_v2 = " \
 avahi-libs \
 bash \
 bc \
 bzip2 \
 cyrus-sasl-lib \
 gcc \
 glibc \
 gzip \
 libgcc \
 libstdc++ \
 openssl-libs \
 pcp \
 pcp-devel \
 pcp-export-pcp2json \
 pcp-export-pcp2openmetrics \
 pcp-export-pcp2spark \
 pcp-export-pcp2xml \
 pcp-export-pcp2zabbix \
 pcp-geolocate \
 pcp-gui \
 pcp-libs \
 pcp-libs-devel \
 pcp-pmda-activemq \
 pcp-pmda-amdgpu \
 pcp-pmda-apache \
 pcp-pmda-bash \
 pcp-pmda-bcc \
 pcp-pmda-bind2 \
 pcp-pmda-bonding \
 pcp-pmda-bpf \
 pcp-pmda-bpftrace \
 pcp-pmda-cisco \
 pcp-pmda-dbping \
 pcp-pmda-denki \
 pcp-pmda-dm \
 pcp-pmda-docker \
 pcp-pmda-ds389 \
 pcp-pmda-ds389log \
 pcp-pmda-elasticsearch \
 pcp-pmda-farm \
 pcp-pmda-gluster \
 pcp-pmda-gpfs \
 pcp-pmda-gpsd \
 pcp-pmda-hacluster \
 pcp-pmda-haproxy \
 pcp-pmda-json \
 pcp-pmda-libvirt \
 pcp-pmda-lio \
 pcp-pmda-lmsensors \
 pcp-pmda-logger \
 pcp-pmda-lustre \
 pcp-pmda-lustrecomm \
 pcp-pmda-mailq \
 pcp-pmda-memcache \
 pcp-pmda-mic \
 pcp-pmda-mongodb \
 pcp-pmda-mounts \
 pcp-pmda-mssql \
 pcp-pmda-mysql \
 pcp-pmda-named \
 pcp-pmda-netcheck \
 pcp-pmda-netfilter \
 pcp-pmda-news \
 pcp-pmda-nfsclient \
 pcp-pmda-nginx \
 pcp-pmda-nvidia-gpu \
 pcp-pmda-openmetrics \
 pcp-pmda-openvswitch \
 pcp-pmda-oracle \
 pcp-pmda-pdns \
 pcp-pmda-podman \
 pcp-pmda-postfix \
 pcp-pmda-postgresql \
 pcp-pmda-rabbitmq \
 pcp-pmda-resctrl \
 pcp-pmda-roomtemp \
 pcp-pmda-samba \
 pcp-pmda-sendmail \
 pcp-pmda-shping \
 pcp-pmda-slurm \
 pcp-pmda-smart \
 pcp-pmda-snmp \
 pcp-pmda-sockets \
 pcp-pmda-statsd \
 pcp-pmda-summary \
 pcp-pmda-trace \
 pcp-pmda-unbound \
 pcp-pmda-uwsgi \
 pcp-pmda-weblog \
 pcp-pmda-zimbra \
 pcp-pmda-zswap \
 pcp-system-tools \
 perl-Exporter \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-IO \
 perl-PCP-LogImport \
 perl-TimeDate \
 perl-interpreter \
 perl-libnet \
 perl-libs \
 python3 \
 qt6-qtbase \
 qt6-qtbase-gui \
 redhat-rpm-config \
 selinux-policy-devel \
 selinux-policy-targeted \
 setools-console \
 systemd-libs \
 xz-libs \
"
RDEPENDS:pcp-testsuite:aarch64 = " \
 avahi-libs \
 bash \
 bc \
 bzip2 \
 cyrus-sasl-lib \
 gcc \
 glibc \
 gzip \
 libgcc \
 libstdc++ \
 openssl-libs \
 pcp \
 pcp-devel \
 pcp-export-pcp2json \
 pcp-export-pcp2openmetrics \
 pcp-export-pcp2spark \
 pcp-export-pcp2xml \
 pcp-export-pcp2zabbix \
 pcp-geolocate \
 pcp-gui \
 pcp-libs \
 pcp-libs-devel \
 pcp-pmda-activemq \
 pcp-pmda-amdgpu \
 pcp-pmda-apache \
 pcp-pmda-bash \
 pcp-pmda-bcc \
 pcp-pmda-bind2 \
 pcp-pmda-bonding \
 pcp-pmda-bpf \
 pcp-pmda-bpftrace \
 pcp-pmda-cisco \
 pcp-pmda-dbping \
 pcp-pmda-denki \
 pcp-pmda-dm \
 pcp-pmda-docker \
 pcp-pmda-ds389 \
 pcp-pmda-ds389log \
 pcp-pmda-elasticsearch \
 pcp-pmda-farm \
 pcp-pmda-gluster \
 pcp-pmda-gpfs \
 pcp-pmda-gpsd \
 pcp-pmda-hacluster \
 pcp-pmda-haproxy \
 pcp-pmda-json \
 pcp-pmda-libvirt \
 pcp-pmda-lio \
 pcp-pmda-lmsensors \
 pcp-pmda-logger \
 pcp-pmda-lustre \
 pcp-pmda-lustrecomm \
 pcp-pmda-mailq \
 pcp-pmda-memcache \
 pcp-pmda-mic \
 pcp-pmda-mongodb \
 pcp-pmda-mounts \
 pcp-pmda-mysql \
 pcp-pmda-named \
 pcp-pmda-netcheck \
 pcp-pmda-netfilter \
 pcp-pmda-news \
 pcp-pmda-nfsclient \
 pcp-pmda-nginx \
 pcp-pmda-nvidia-gpu \
 pcp-pmda-openmetrics \
 pcp-pmda-openvswitch \
 pcp-pmda-oracle \
 pcp-pmda-pdns \
 pcp-pmda-podman \
 pcp-pmda-postfix \
 pcp-pmda-postgresql \
 pcp-pmda-rabbitmq \
 pcp-pmda-roomtemp \
 pcp-pmda-samba \
 pcp-pmda-sendmail \
 pcp-pmda-shping \
 pcp-pmda-slurm \
 pcp-pmda-smart \
 pcp-pmda-snmp \
 pcp-pmda-sockets \
 pcp-pmda-statsd \
 pcp-pmda-summary \
 pcp-pmda-trace \
 pcp-pmda-unbound \
 pcp-pmda-uwsgi \
 pcp-pmda-weblog \
 pcp-pmda-zimbra \
 pcp-pmda-zswap \
 pcp-system-tools \
 perl-Exporter \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-IO \
 perl-PCP-LogImport \
 perl-TimeDate \
 perl-interpreter \
 perl-libnet \
 perl-libs \
 python3 \
 qt6-qtbase \
 qt6-qtbase-gui \
 redhat-rpm-config \
 selinux-policy-devel \
 selinux-policy-targeted \
 setools-console \
 systemd-libs \
 xz-libs \
"
RDEPENDS:pcp-zeroconf = " \
 bash \
 pcp \
 pcp-doc \
 pcp-libs \
 pcp-pmda-dm \
 pcp-pmda-nfsclient \
 pcp-pmda-openmetrics \
 pcp-system-tools \
 "
RDEPENDS:perl-PCP-LogImport = " \
 glibc \
 pcp-libs \
 perl-DynaLoader \
 perl-Exporter \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:perl-PCP-LogSummary = " \
 pcp-libs \
 perl-Exporter \
 perl-PCP-LogSummary \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-PCP-MMV = " \
 glibc \
 pcp-libs \
 perl-DynaLoader \
 perl-Exporter \
 perl-PCP-MMV \
 perl-Time-HiRes \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-PCP-PMDA = " \
 glibc \
 pcp-libs \
 perl-DynaLoader \
 perl-Exporter \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:python3-pcp = " \
 glibc \
 pcp \
 pcp-libs \
 python3 \
 "
