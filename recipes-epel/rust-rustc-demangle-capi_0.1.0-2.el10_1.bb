# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustc-demangle-capi"
PV = "0.1.0"
PR = "2.el10_1"
PACKAGES = " \
 librustc_demangle \
 librustc_demangle-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustc-demangle-capi-0.1.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52c403f7e9de6adb8a514525eac5c29839180c6f9cff0d3db1546a6da3e1695d"

URI_x86_64_v2_librustc_demangle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librustc_demangle-0.1.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librustc_demangle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librustc_demangle}"
SRC_URI[x86_64_v2_librustc_demangle.sha256sum] = "f8f640ef91d8e67aeb78403692b992e940a25e907c4fc04d45dcf55d39605feb"

URI_x86_64_v2_librustc_demangle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librustc_demangle-devel-0.1.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librustc_demangle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librustc_demangle-devel}"
SRC_URI[x86_64_v2_librustc_demangle-devel.sha256sum] = "2706367400ae721b1538fb949932dbaa6083281db5b57e6d5786cef61033c3f6"

URI_aarch64_librustc_demangle = "${EPEL_MIRROR}/aarch64/Packages/l/librustc_demangle-0.1.0-2.el10_1.aarch64.rpm;name=aarch64_librustc_demangle;unpack=0"
SRC_URI:append = " ${URI_aarch64_librustc_demangle}"
SRC_URI[aarch64_librustc_demangle.sha256sum] = "c81975d5f234ff04e32f2e4284e1bb091f76de1dac4c72b8e47f5a934218bc3d"

URI_aarch64_librustc_demangle-devel = "${EPEL_MIRROR}/aarch64/Packages/l/librustc_demangle-devel-0.1.0-2.el10_1.aarch64.rpm;name=aarch64_librustc_demangle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_librustc_demangle-devel}"
SRC_URI[aarch64_librustc_demangle-devel.sha256sum] = "8abc003db3e43733c39337144ba35bfb9072bd3a6b8831f2fe1d32148af12b54"

RDEPENDS:librustc_demangle = " \
 glibc \
 libgcc \
 "
RDEPENDS:librustc_demangle-devel = " \
 librustc_demangle \
 pkgconf-pkg-config \
 "
