# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "portmidi"
PV = "217"
PR = "58.el10_0"
PACKAGES = " \
 portmidi \
 portmidi-devel \
 portmidi-tools \
 python3-portmidi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/portmidi-217-58.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "35a69c62bde81574a9a43f917759d7c544e2bce6475d6427c1da9b2b37315782"

URI_x86_64_v2_portmidi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/portmidi-217-58.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_portmidi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_portmidi}"
SRC_URI[x86_64_v2_portmidi.sha256sum] = "82f6d37164fee874c6387751421fd62f8228dc4e06df9ef1bf5ec5412f5b871f"

URI_x86_64_v2_portmidi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/portmidi-devel-217-58.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_portmidi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_portmidi-devel}"
SRC_URI[x86_64_v2_portmidi-devel.sha256sum] = "e673f2c4f2ab2f8b032fcc40185e48c0d4ba48acafe7bbfb1a9b09907ea89010"

URI_x86_64_v2_portmidi-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/portmidi-tools-217-58.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_portmidi-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_portmidi-tools}"
SRC_URI[x86_64_v2_portmidi-tools.sha256sum] = "89744a5403984f2de9e330b0f7d29271a14019338c77ddab96f4267cd1f1d959"

URI_x86_64_v2_python3-portmidi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-portmidi-217-58.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-portmidi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-portmidi}"
SRC_URI[x86_64_v2_python3-portmidi.sha256sum] = "c1f26dd2476b49e3ece298625dffc4dd37a481d1de8ae59b00f6008a2f7e9bef"

URI_aarch64_portmidi = "${EPEL_MIRROR}/aarch64/Packages/p/portmidi-217-58.el10_0.aarch64.rpm;name=aarch64_portmidi;unpack=0"
SRC_URI:append = " ${URI_aarch64_portmidi}"
SRC_URI[aarch64_portmidi.sha256sum] = "fef9ab5a655e9c459f1c706d77953fe47cdb3ee11cbc02ec06ce1b266582e488"

URI_aarch64_portmidi-devel = "${EPEL_MIRROR}/aarch64/Packages/p/portmidi-devel-217-58.el10_0.aarch64.rpm;name=aarch64_portmidi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_portmidi-devel}"
SRC_URI[aarch64_portmidi-devel.sha256sum] = "9e03d73b11631eff7f2ff7771b7569c3a5215cfa2ffeef593c7cdf34be7ffe70"

URI_aarch64_portmidi-tools = "${EPEL_MIRROR}/aarch64/Packages/p/portmidi-tools-217-58.el10_0.aarch64.rpm;name=aarch64_portmidi-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_portmidi-tools}"
SRC_URI[aarch64_portmidi-tools.sha256sum] = "fbdf60311cf10edade9e1521c90393be33d2641ddbecbb05be655f718caa7a22"

URI_aarch64_python3-portmidi = "${EPEL_MIRROR}/aarch64/Packages/p/python3-portmidi-217-58.el10_0.aarch64.rpm;name=aarch64_python3-portmidi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-portmidi}"
SRC_URI[aarch64_python3-portmidi.sha256sum] = "b7d907941bb199479f267ae20aaf40f197c2d20265e40771938f2e98f1b74def"

RDEPENDS:portmidi = " \
 alsa-lib \
 glibc \
 "
RDEPENDS:portmidi-devel = " \
 portmidi \
 "
RDEPENDS:portmidi-tools = " \
 alsa-lib \
 bash \
 glibc \
 hicolor-icon-theme \
 java-21-openjdk \
 portmidi \
 "
RDEPENDS:python3-portmidi = " \
 glibc \
 portmidi \
 python3 \
 "
