# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-google-cmdtest"
PV = "0.4.0"
PR = "6.el10_0"
PACKAGES = " \
 golang-github-google-cmdtest-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-google-cmdtest-0.4.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f7f84819ec16b9c11710d43eaf457a81b9a195946aa8959285973a2a5b629de"

URI_x86_64_v2_golang-github-google-cmdtest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-google-cmdtest-devel-0.4.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-google-cmdtest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-google-cmdtest-devel}"
SRC_URI[x86_64_v2_golang-github-google-cmdtest-devel.sha256sum] = "f3d0fb534b36c3bb375aa850d5c6e8a5cb40241425b2e32da55f8f6f5e36a3b4"

URI_aarch64_golang-github-google-cmdtest-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-google-cmdtest-devel-0.4.0-6.el10_0.noarch.rpm;name=aarch64_golang-github-google-cmdtest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-google-cmdtest-devel}"
SRC_URI[aarch64_golang-github-google-cmdtest-devel.sha256sum] = "7746b525ca8ae5f8e84703a0de96f18e36d8ef21966c7789acccf997f80f73a0"

RDEPENDS:golang-github-google-cmdtest-devel = " \
 go-filesystem \
 golang-github-google-cmp-devel \
 golang-github-google-renameio-devel \
 "
