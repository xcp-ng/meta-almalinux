# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-openprinting-ipp-usb"
PV = "0.9.27"
PR = "7.el10_2.2"
PACKAGES = " \
 ipp-usb \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/golang-github-openprinting-ipp-usb-0.9.27-7.el10_2.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64bb19731003fc00ff4ca4924bf78b78fbecaecd5b5d31e3d33d462084d912cf"

URI_x86_64_v2_ipp-usb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipp-usb-0.9.27-7.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_ipp-usb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipp-usb}"
SRC_URI[x86_64_v2_ipp-usb.sha256sum] = "ede13f4cfbb2ccf8c0f5f76257570b12cebfb798d01228c235509c0439192965"

URI_aarch64_ipp-usb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipp-usb-0.9.27-7.el10_2.2.aarch64.rpm;name=aarch64_ipp-usb;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipp-usb}"
SRC_URI[aarch64_ipp-usb.sha256sum] = "efb3e86a8c1fcd099dd599a57cc96ca0ed329382570fb2dee97b61a707ddfb5b"

RDEPENDS:ipp-usb = " \
 avahi-libs \
 bash \
 glibc \
 libusb1 \
 systemd \
 systemd-udev \
 "
