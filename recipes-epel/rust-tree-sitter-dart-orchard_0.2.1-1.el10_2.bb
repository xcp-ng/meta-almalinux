# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-dart-orchard"
PV = "0.2.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-tree-sitter-dart-orchard+default-devel \
 rust-tree-sitter-dart-orchard-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-dart-orchard-0.2.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "459d0c678c6798f26f1cb4d5ee4e4c5dc6450dc539132a72e3350ac578d64320"

URI_x86_64_v2_rust-tree-sitter-dart-orchard+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-dart-orchard+default-devel-0.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-dart-orchard+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-dart-orchard+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-dart-orchard+default-devel.sha256sum] = "6c1459cec250eddc977fe5652f01be22910644655e679c141c32994b07d46f3a"

URI_x86_64_v2_rust-tree-sitter-dart-orchard-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-dart-orchard-devel-0.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-dart-orchard-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-dart-orchard-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-dart-orchard-devel.sha256sum] = "7292db381066f42c5914c8926ac41c2b3ef84e504b0b78a3745e9d88f98898b0"

URI_aarch64_rust-tree-sitter-dart-orchard+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-dart-orchard+default-devel-0.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-dart-orchard+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-dart-orchard+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-dart-orchard+default-devel.sha256sum] = "be64c8d162f1a591e728272594943af45e11e149377797fbe80558e0b7b027c5"

URI_aarch64_rust-tree-sitter-dart-orchard-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-dart-orchard-devel-0.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-dart-orchard-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-dart-orchard-devel}"
SRC_URI[aarch64_rust-tree-sitter-dart-orchard-devel.sha256sum] = "54fcb65df39c525ead1fe4aaf4fc76075b1511eefd10eef666f4ce004c1c60c0"

RDEPENDS:rust-tree-sitter-dart-orchard+default-devel = " \
 cargo \
 rust-tree-sitter-dart-orchard-devel \
 "
RDEPENDS:rust-tree-sitter-dart-orchard-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
