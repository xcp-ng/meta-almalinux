# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xe-guest-utilities-latest"
PV = "8.4.0"
PR = "8.el10_2"
PACKAGES:x86_64_v2 = " \
 xe-guest-utilities-latest \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/x/xe-guest-utilities-latest-8.4.0-8.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b45a9ad8db88d10b5011c2f3683f0cf1d2d53a285d5bcf2732230da79d75b019"

URI_x86_64_v2_xe-guest-utilities-latest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xe-guest-utilities-latest-8.4.0-8.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xe-guest-utilities-latest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xe-guest-utilities-latest}"
SRC_URI[x86_64_v2_xe-guest-utilities-latest.sha256sum] = "32eef210a17ff3ab62cc8906576be56fceea24cd582a467506a3ffc248321615"

RDEPENDS:xe-guest-utilities-latest = " \
 bash \
 systemd \
 "
