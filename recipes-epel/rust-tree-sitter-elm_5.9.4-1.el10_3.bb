# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-elm"
PV = "5.9.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-tree-sitter-elm+default-devel \
 rust-tree-sitter-elm-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-elm-5.9.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3edcb394ac8e11ad109bdccdad29761f2602558fc19fc740da9d176467f6ccc0"

URI_x86_64_v2_rust-tree-sitter-elm+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-elm+default-devel-5.9.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-elm+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-elm+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-elm+default-devel.sha256sum] = "a46074c5fe3254aa2670c1c3c93c9b267c36620a1e5715a6816558cde6277f8a"

URI_x86_64_v2_rust-tree-sitter-elm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-elm-devel-5.9.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-elm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-elm-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-elm-devel.sha256sum] = "7ea3a08e9f1fd9de93ed01e90d6d2532c96eafd721daadf357cfb529972f0363"

URI_aarch64_rust-tree-sitter-elm+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-elm+default-devel-5.9.4-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-elm+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-elm+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-elm+default-devel.sha256sum] = "2eb25b1736c9abd52f06e797e6be1844205660f0b81dd6b5e43c9d2a769663ce"

URI_aarch64_rust-tree-sitter-elm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-elm-devel-5.9.4-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-elm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-elm-devel}"
SRC_URI[aarch64_rust-tree-sitter-elm-devel.sha256sum] = "eec6ec5b3edf08d3f9b72d819437aaed1ff70f89bafce272f0689474f3d7c0bd"

RDEPENDS:rust-tree-sitter-elm+default-devel = " \
 cargo \
 rust-tree-sitter-elm-devel \
 "
RDEPENDS:rust-tree-sitter-elm-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
