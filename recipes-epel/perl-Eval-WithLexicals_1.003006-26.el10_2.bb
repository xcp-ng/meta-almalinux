# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Eval-WithLexicals"
PV = "1.003006"
PR = "26.el10_2"
PACKAGES = " \
 perl-Eval-WithLexicals \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Eval-WithLexicals-1.003006-26.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fecd7ed9b84ecdff3d8f752308bbcde924230af190db662a1ea0013aab144152"

URI_x86_64_v2_perl-Eval-WithLexicals = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Eval-WithLexicals-1.003006-26.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Eval-WithLexicals;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Eval-WithLexicals}"
SRC_URI[x86_64_v2_perl-Eval-WithLexicals.sha256sum] = "1b52b1d44529ea31c1e993af342a11a63c9bb83a5cf7afb4e5652e76ad271a66"

URI_aarch64_perl-Eval-WithLexicals = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Eval-WithLexicals-1.003006-26.el10_2.noarch.rpm;name=aarch64_perl-Eval-WithLexicals;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Eval-WithLexicals}"
SRC_URI[aarch64_perl-Eval-WithLexicals.sha256sum] = "5984b99f5bc59e8e712e6cd36a45b02c03341216b2886e445a0fdf14b3070057"

RDEPENDS:perl-Eval-WithLexicals = " \
 perl-B \
 perl-Data-Dumper \
 perl-Eval-WithLexicals \
 perl-Getopt-Long \
 perl-Moo \
 perl-Sub-Quote \
 perl-Term-ReadLine \
 perl-interpreter \
 perl-libs \
 perl-strictures \
 "
