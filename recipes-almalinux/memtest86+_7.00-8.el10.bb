# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "memtest86+"
PV = "7.00"
PR = "8.el10"
PACKAGES:x86_64_v2 = " \
 memtest86+ \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/memtest86+-7.00-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3eee3e78315c9aa3527cc8931d7afff320e1c005eacc715131ccbed23224fbe8"

URI_x86_64_v2_memtest86+ = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/memtest86+-7.00-8.el10.x86_64_v2.rpm;name=x86_64_v2_memtest86+;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_memtest86+}"
SRC_URI[x86_64_v2_memtest86+.sha256sum] = "7a9b57c0dd974319bc98478a1d868ea390985757dd4fbbca5312139a497cc84c"

RDEPENDS:memtest86+ = " \
 bash \
 systemd-udev \
 "
