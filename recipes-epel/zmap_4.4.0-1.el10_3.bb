# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zmap"
PV = "4.4.0"
PR = "1.el10_3"
PACKAGES = " \
 zmap \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/z/zmap-4.4.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc9ac9ac59a18b414d8471075cd057517b96db13c3704b230cc13b7e48d8325f"

URI_x86_64_v2_zmap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zmap-4.4.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zmap}"
SRC_URI[x86_64_v2_zmap.sha256sum] = "bf78141ba6cd8d0b2d84b29b8f84253f36e1df2f2777ea63497577ca721b7b35"

URI_aarch64_zmap = "${EPEL_MIRROR}/aarch64/Packages/z/zmap-4.4.0-1.el10_3.aarch64.rpm;name=aarch64_zmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_zmap}"
SRC_URI[aarch64_zmap.sha256sum] = "bb9c5f8e890831e303c3ddae2cd36d03e3c66faa8892590c75c1361bf080e4f3"

RDEPENDS:zmap = " \
 Judy \
 glibc \
 gmp \
 json-c \
 libpcap \
 libunistring \
 "
