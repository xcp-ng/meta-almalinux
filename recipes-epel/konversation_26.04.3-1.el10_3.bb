# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "konversation"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 konversation \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/konversation-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a96011fb557e5fc6643c5b4de18e18d002bf8008a54563835e9ac0205711f4c"

URI_x86_64_v2_konversation = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konversation-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konversation;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_konversation}"
SRC_URI[x86_64_v2_konversation.sha256sum] = "cc5c3d11806419ec633f3b1731cf47a4927bd5066cd5077ddd9e5b7b6d7d9163"

URI_aarch64_konversation = "${EPEL_MIRROR}/aarch64/Packages/k/konversation-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_konversation;unpack=0"
SRC_URI:append = " ${URI_aarch64_konversation}"
SRC_URI[aarch64_konversation.sha256sum] = "469bcbe2197f8569d9bedee4e167b2954d0c91f0b2364bf2c97b1efb1335ff46"

RDEPENDS:konversation = " \
 bash \
 glibc \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kidletime \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kparts \
 kf6-kstatusnotifieritem \
 kf6-ktextwidgets \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 perl-interpreter \
 python3 \
 qca-qt6 \
 qca-qt6-ossl \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 "
