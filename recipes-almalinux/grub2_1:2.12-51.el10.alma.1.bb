# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grub2"
PE = "1"
PV = "2.12"
PR = "51.el10.alma.1"
PACKAGES:x86_64_v2 = " \
 grub2-common \
 grub2-efi-aa64-modules \
 grub2-efi-x64 \
 grub2-efi-x64-cdboot \
 grub2-efi-x64-modules \
 grub2-pc \
 grub2-pc-modules \
 grub2-ppc64le-modules \
 grub2-tools \
 grub2-tools-efi \
 grub2-tools-extra \
 grub2-tools-minimal \
"
PACKAGES:aarch64 = " \
 grub2-common \
 grub2-efi-aa64 \
 grub2-efi-aa64-cdboot \
 grub2-efi-aa64-modules \
 grub2-efi-x64-modules \
 grub2-pc-modules \
 grub2-ppc64le-modules \
 grub2-tools \
 grub2-tools-extra \
 grub2-tools-minimal \
"

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/grub2-2.12-51.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd34701061d764775264c6ba2d4a543a06edc2d636e3cd6c24cdbd40bf12e066"

URI_x86_64_v2_grub2-common = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-common-2.12-51.el10.alma.1.noarch.rpm;name=x86_64_v2_grub2-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-common}"
SRC_URI[x86_64_v2_grub2-common.sha256sum] = "b5e3183e476cf0cf7f38f44dfea6e356079673b8dc5eced83f9e634d399bc487"

URI_x86_64_v2_grub2-efi-aa64-modules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-efi-aa64-modules-2.12-51.el10.alma.1.noarch.rpm;name=x86_64_v2_grub2-efi-aa64-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-efi-aa64-modules}"
SRC_URI[x86_64_v2_grub2-efi-aa64-modules.sha256sum] = "4d99ec8afeedcf83f976d9d8515c3782b84cc98190b9e04bb0230070a20f6618"

URI_x86_64_v2_grub2-efi-x64 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-efi-x64-2.12-51.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-efi-x64;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-efi-x64}"
SRC_URI[x86_64_v2_grub2-efi-x64.sha256sum] = "a47fc4b1d718ac85df7a3793f6c935c961e545a97af14e200552f1df271923b5"

URI_x86_64_v2_grub2-efi-x64-cdboot = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-efi-x64-cdboot-2.12-51.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-efi-x64-cdboot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-efi-x64-cdboot}"
SRC_URI[x86_64_v2_grub2-efi-x64-cdboot.sha256sum] = "3af23a0589315c8f6c41b1574c170055b78233d697f65f4ef8d08922ce8d9f9b"

URI_x86_64_v2_grub2-efi-x64-modules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-efi-x64-modules-2.12-51.el10.alma.1.noarch.rpm;name=x86_64_v2_grub2-efi-x64-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-efi-x64-modules}"
SRC_URI[x86_64_v2_grub2-efi-x64-modules.sha256sum] = "9d4bd9223b1cf7b34ae094f7d68606d68ecc0feaad02bff01e5d2e295db76c0c"

URI_x86_64_v2_grub2-pc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-pc-2.12-51.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-pc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-pc}"
SRC_URI[x86_64_v2_grub2-pc.sha256sum] = "52fa1b0e09e11ea6b83f5f103ec96c450ca99cea6aef7ba4ba555800194aa330"

URI_x86_64_v2_grub2-pc-modules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-pc-modules-2.12-51.el10.alma.1.noarch.rpm;name=x86_64_v2_grub2-pc-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-pc-modules}"
SRC_URI[x86_64_v2_grub2-pc-modules.sha256sum] = "337fd1bbea342c680cf5cb53134a1e7eee26f375208c3edf7efd7df6270cecdd"

URI_x86_64_v2_grub2-ppc64le-modules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-ppc64le-modules-2.12-51.el10.alma.1.noarch.rpm;name=x86_64_v2_grub2-ppc64le-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-ppc64le-modules}"
SRC_URI[x86_64_v2_grub2-ppc64le-modules.sha256sum] = "413d417533798c6675de7ef5627ad9bfc0d025f047f9a8664f65d95f7aec22d9"

URI_x86_64_v2_grub2-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-tools-2.12-51.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-tools}"
SRC_URI[x86_64_v2_grub2-tools.sha256sum] = "4eae32bf6ed645019b0514f76eb61a76b2d15336b4ef0a6421bb4f536b42e552"

URI_x86_64_v2_grub2-tools-efi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-tools-efi-2.12-51.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-tools-efi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-tools-efi}"
SRC_URI[x86_64_v2_grub2-tools-efi.sha256sum] = "7fc4f33f83a05a477e242fcecabbb76c4bfd25173bba17b88495f888f2689e6b"

URI_x86_64_v2_grub2-tools-extra = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-tools-extra-2.12-51.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-tools-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-tools-extra}"
SRC_URI[x86_64_v2_grub2-tools-extra.sha256sum] = "db36c38a743466cf888224175f8133fefe23d7f3f72ae07da06866a53eff349a"

URI_x86_64_v2_grub2-tools-minimal = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-tools-minimal-2.12-51.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-tools-minimal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-tools-minimal}"
SRC_URI[x86_64_v2_grub2-tools-minimal.sha256sum] = "c821a50e299ef75b11ef4efa1dab5e831380489408e86ab7aeac6f9d22bd2ebb"

URI_aarch64_grub2-common = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-common-2.12-51.el10.alma.1.noarch.rpm;name=aarch64_grub2-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-common}"
SRC_URI[aarch64_grub2-common.sha256sum] = "b5e3183e476cf0cf7f38f44dfea6e356079673b8dc5eced83f9e634d399bc487"

URI_aarch64_grub2-efi-aa64 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-efi-aa64-2.12-51.el10.alma.1.aarch64.rpm;name=aarch64_grub2-efi-aa64;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-efi-aa64}"
SRC_URI[aarch64_grub2-efi-aa64.sha256sum] = "658ffc0e64816bc0ce668905425edab1a8d4bd64b5406a71dcbe0320e3cbdee2"

URI_aarch64_grub2-efi-aa64-cdboot = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-efi-aa64-cdboot-2.12-51.el10.alma.1.aarch64.rpm;name=aarch64_grub2-efi-aa64-cdboot;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-efi-aa64-cdboot}"
SRC_URI[aarch64_grub2-efi-aa64-cdboot.sha256sum] = "05d83d0e2793a847682ddfab36f9ab15cbb1511f0bda666ae77859e47efa9106"

URI_aarch64_grub2-efi-aa64-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-efi-aa64-modules-2.12-51.el10.alma.1.noarch.rpm;name=aarch64_grub2-efi-aa64-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-efi-aa64-modules}"
SRC_URI[aarch64_grub2-efi-aa64-modules.sha256sum] = "4d99ec8afeedcf83f976d9d8515c3782b84cc98190b9e04bb0230070a20f6618"

URI_aarch64_grub2-efi-x64-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-efi-x64-modules-2.12-51.el10.alma.1.noarch.rpm;name=aarch64_grub2-efi-x64-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-efi-x64-modules}"
SRC_URI[aarch64_grub2-efi-x64-modules.sha256sum] = "9d4bd9223b1cf7b34ae094f7d68606d68ecc0feaad02bff01e5d2e295db76c0c"

URI_aarch64_grub2-pc-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-pc-modules-2.12-51.el10.alma.1.noarch.rpm;name=aarch64_grub2-pc-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-pc-modules}"
SRC_URI[aarch64_grub2-pc-modules.sha256sum] = "337fd1bbea342c680cf5cb53134a1e7eee26f375208c3edf7efd7df6270cecdd"

URI_aarch64_grub2-ppc64le-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-ppc64le-modules-2.12-51.el10.alma.1.noarch.rpm;name=aarch64_grub2-ppc64le-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-ppc64le-modules}"
SRC_URI[aarch64_grub2-ppc64le-modules.sha256sum] = "413d417533798c6675de7ef5627ad9bfc0d025f047f9a8664f65d95f7aec22d9"

URI_aarch64_grub2-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-tools-2.12-51.el10.alma.1.aarch64.rpm;name=aarch64_grub2-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-tools}"
SRC_URI[aarch64_grub2-tools.sha256sum] = "560373463771c4bed7d9dc03e3bee9e1de640fa43dea9fd0c686f946ca3dfae4"

URI_aarch64_grub2-tools-extra = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-tools-extra-2.12-51.el10.alma.1.aarch64.rpm;name=aarch64_grub2-tools-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-tools-extra}"
SRC_URI[aarch64_grub2-tools-extra.sha256sum] = "7f350eae3025c0e10b1113251f741d536e1942f2acfa3dff28f512c389e6255d"

URI_aarch64_grub2-tools-minimal = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-tools-minimal-2.12-51.el10.alma.1.aarch64.rpm;name=aarch64_grub2-tools-minimal;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-tools-minimal}"
SRC_URI[aarch64_grub2-tools-minimal.sha256sum] = "51ce781e143b083b81efcbee28ed99f3cd61ab2793dc8978dbcacf4ad4b6715e"

RDEPENDS:grub2-common = " \
 bash \
 grep \
 util-linux-core \
 virtual/coreutils \
 "
RDEPENDS:grub2-efi-aa64-modules = " \
 grub2-common \
 "
RDEPENDS:grub2-efi-x64 = " \
 bash \
 efi-filesystem \
 grub2-common \
 grub2-tools \
 grub2-tools-minimal \
 "
RDEPENDS:grub2-efi-x64-cdboot = " \
 grub2-common \
 "
RDEPENDS:grub2-efi-x64-modules = " \
 grub2-common \
 "
RDEPENDS:grub2-pc = " \
 dracut \
 file \
 gettext-runtime \
 grub2-common \
 grub2-pc-modules \
 grub2-tools \
 grub2-tools-minimal \
 which \
 "
RDEPENDS:grub2-pc-modules = " \
 grub2-common \
 "
RDEPENDS:grub2-ppc64le-modules = " \
 grub2-common \
 "
RDEPENDS:grub2-tools = " \
 bash \
 device-mapper-libs \
 dracut \
 file \
 gettext-runtime \
 glibc \
 grep \
 grub2-common \
 os-prober \
 sed \
 systemd \
 xz-libs \
 "
RDEPENDS:grub2-tools-efi = " \
 device-mapper-libs \
 file \
 gettext-runtime \
 glibc \
 grub2-common \
 os-prober \
 "
RDEPENDS:grub2-tools-extra = " \
 bash \
 device-mapper-libs \
 file \
 freetype \
 gettext-runtime \
 glibc \
 grub2-common \
 grub2-tools-minimal \
 mtools \
 os-prober \
 xz-libs \
 "
RDEPENDS:grub2-tools-minimal = " \
 bash \
 device-mapper-libs \
 fuse-libs \
 gettext-runtime \
 glibc \
 grub2-common \
 xz-libs \
 "
RDEPENDS:grub2-efi-aa64 = " \
 bash \
 efi-filesystem \
 grub2-common \
 grub2-tools \
 grub2-tools-minimal \
 "
RDEPENDS:grub2-efi-aa64-cdboot = " \
 grub2-common \
 "
