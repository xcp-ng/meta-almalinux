# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-weezl"
PV = "0.1.12"
PR = "1.el10_1"
PACKAGES = " \
 rust-weezl+alloc-devel \
 rust-weezl+async-devel \
 rust-weezl+default-devel \
 rust-weezl+futures-devel \
 rust-weezl+std-devel \
 rust-weezl-devel \
 weezl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-weezl-0.1.12-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe57be8c5f55eeb22588a3bb7b635f9ecfcd80f1caff3cdb3a035cc7da05658c"

URI_x86_64_v2_rust-weezl+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-weezl+alloc-devel-0.1.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-weezl+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-weezl+alloc-devel}"
SRC_URI[x86_64_v2_rust-weezl+alloc-devel.sha256sum] = "c40e6c40fc4d453e2dc6d6373e19b9732a2d43c8b5395f4ff4dbea7d2bff0261"

URI_x86_64_v2_rust-weezl+async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-weezl+async-devel-0.1.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-weezl+async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-weezl+async-devel}"
SRC_URI[x86_64_v2_rust-weezl+async-devel.sha256sum] = "13d787feeb8f9434012a3ca1b6c4a36620297421df4fb2be9585026e183087f2"

URI_x86_64_v2_rust-weezl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-weezl+default-devel-0.1.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-weezl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-weezl+default-devel}"
SRC_URI[x86_64_v2_rust-weezl+default-devel.sha256sum] = "4b92aec68a02fffefdac576fa4209b368fb5b70f2b8bde3e305102424411ccdf"

URI_x86_64_v2_rust-weezl+futures-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-weezl+futures-devel-0.1.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-weezl+futures-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-weezl+futures-devel}"
SRC_URI[x86_64_v2_rust-weezl+futures-devel.sha256sum] = "807ea3f05da78d8edd826c22bc82c0e1f05e1e7f4df99bed59aa7ecafcde5e5e"

URI_x86_64_v2_rust-weezl+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-weezl+std-devel-0.1.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-weezl+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-weezl+std-devel}"
SRC_URI[x86_64_v2_rust-weezl+std-devel.sha256sum] = "dc23359c4520df4f8bda6787e80e5fc72a5fd61a3c67706e42a63bb9a3749b1c"

URI_x86_64_v2_rust-weezl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-weezl-devel-0.1.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-weezl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-weezl-devel}"
SRC_URI[x86_64_v2_rust-weezl-devel.sha256sum] = "a7502a73dfd693d5971dc86c3ff261c7d3ba6d718c663464c2e9a05c148c949e"

URI_x86_64_v2_weezl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/weezl-0.1.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_weezl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_weezl}"
SRC_URI[x86_64_v2_weezl.sha256sum] = "2111a082b79915bc221a03605b1995ec8134f6cb0fcce79db26b050e02fa7287"

URI_aarch64_rust-weezl+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-weezl+alloc-devel-0.1.12-1.el10_1.noarch.rpm;name=aarch64_rust-weezl+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-weezl+alloc-devel}"
SRC_URI[aarch64_rust-weezl+alloc-devel.sha256sum] = "32a8b1520edf3c1d0d129168f89ec9e9d3cace60ee4e4a21e91078801b16ad23"

URI_aarch64_rust-weezl+async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-weezl+async-devel-0.1.12-1.el10_1.noarch.rpm;name=aarch64_rust-weezl+async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-weezl+async-devel}"
SRC_URI[aarch64_rust-weezl+async-devel.sha256sum] = "92817427e1d9209bb817d16171a06bbe810159c2d1535ebd02055904b3a75c0e"

URI_aarch64_rust-weezl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-weezl+default-devel-0.1.12-1.el10_1.noarch.rpm;name=aarch64_rust-weezl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-weezl+default-devel}"
SRC_URI[aarch64_rust-weezl+default-devel.sha256sum] = "1168e0237936dec87cda2f88b2b5131c98b976e91e40ef376b868c97748b0715"

URI_aarch64_rust-weezl+futures-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-weezl+futures-devel-0.1.12-1.el10_1.noarch.rpm;name=aarch64_rust-weezl+futures-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-weezl+futures-devel}"
SRC_URI[aarch64_rust-weezl+futures-devel.sha256sum] = "baaf3c762f352ff584071332be5de59b553fa0ee8cf4e7081138a4f19f6be68f"

URI_aarch64_rust-weezl+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-weezl+std-devel-0.1.12-1.el10_1.noarch.rpm;name=aarch64_rust-weezl+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-weezl+std-devel}"
SRC_URI[aarch64_rust-weezl+std-devel.sha256sum] = "b6bebda109c043a55269cc86273ffc1ed9332859daead29d33c09c0383a30edd"

URI_aarch64_rust-weezl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-weezl-devel-0.1.12-1.el10_1.noarch.rpm;name=aarch64_rust-weezl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-weezl-devel}"
SRC_URI[aarch64_rust-weezl-devel.sha256sum] = "353ca4817160eec95d45eb134f1d8d1c8ed70527866c4d8d25fabe19d5b42882"

URI_aarch64_weezl = "${EPEL_MIRROR}/aarch64/Packages/w/weezl-0.1.12-1.el10_1.aarch64.rpm;name=aarch64_weezl;unpack=0"
SRC_URI:append = " ${URI_aarch64_weezl}"
SRC_URI[aarch64_weezl.sha256sum] = "21d1781d1ddae482f8339de22bce4db583df13a1c1fb58ffc0a17a8f14148a76"

RDEPENDS:rust-weezl+alloc-devel = " \
 cargo \
 rust-weezl-devel \
 "
RDEPENDS:rust-weezl+async-devel = " \
 cargo \
 rust-weezl+futures-devel \
 rust-weezl+std-devel \
 rust-weezl-devel \
 "
RDEPENDS:rust-weezl+default-devel = " \
 cargo \
 rust-weezl+std-devel \
 rust-weezl-devel \
 "
RDEPENDS:rust-weezl+futures-devel = " \
 cargo \
 rust-futures+std-devel \
 rust-futures-devel \
 rust-weezl-devel \
 "
RDEPENDS:rust-weezl+std-devel = " \
 cargo \
 rust-weezl+alloc-devel \
 rust-weezl-devel \
 "
RDEPENDS:rust-weezl-devel = " \
 cargo \
 "
RDEPENDS:weezl = " \
 glibc \
 libgcc \
 "
