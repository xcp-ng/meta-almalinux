# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "alsa-lib"
PV = "1.2.13"
PR = "2.el10"
PACKAGES = " \
 alsa-lib \
 alsa-lib-devel \
 alsa-ucm \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/alsa-lib-1.2.13-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a8fb90f0c6cb00235e5e35b769d206a45a1082b46d9fc726a86969bb7296db4e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/alsa-lib-1.2.13-2.el10.x86_64_v2.rpm;name=x86_64_v2_alsa-lib;unpack=0"
SRC_URI[x86_64_v2_alsa-lib.sha256sum] = "e4d8bd5330136498cd623878bfc16e01d37b415a32946cff0adb3bb5abaca452"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/alsa-lib-devel-1.2.13-2.el10.x86_64_v2.rpm;name=x86_64_v2_alsa-lib-devel;unpack=0"
SRC_URI[x86_64_v2_alsa-lib-devel.sha256sum] = "d2f37e916ddbc0efa4c6dfa5a2081af01aee00c8d78d31a3010e65d69f6acf1e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/alsa-ucm-1.2.13-2.el10.noarch.rpm;name=x86_64_v2_alsa-ucm;unpack=0"
SRC_URI[x86_64_v2_alsa-ucm.sha256sum] = "1d897338a7e0478ebcc4aa0389e19ad1d25b89f937ab5f2715d9f69ccee9556a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/alsa-lib-1.2.13-2.el10.aarch64.rpm;name=aarch64_alsa-lib;unpack=0"
SRC_URI[aarch64_alsa-lib.sha256sum] = "fe02e5d3bf58434469fcb4aaf41b55fc20bcf7482ae2e697f3037272c957d0dd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/alsa-lib-devel-1.2.13-2.el10.aarch64.rpm;name=aarch64_alsa-lib-devel;unpack=0"
SRC_URI[aarch64_alsa-lib-devel.sha256sum] = "74a3e5838c8f9fffe09d22ac9caee7925b25fe5fcead708f81d801478eacd9fa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/alsa-ucm-1.2.13-2.el10.noarch.rpm;name=aarch64_alsa-ucm;unpack=0"
SRC_URI[aarch64_alsa-ucm.sha256sum] = "1d897338a7e0478ebcc4aa0389e19ad1d25b89f937ab5f2715d9f69ccee9556a"

RDEPENDS:alsa-lib = " \
 glibc \
 "
RDEPENDS:alsa-lib-devel = " \
 alsa-lib \
 alsa-lib-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:alsa-ucm = " \
 alsa-lib \
 "
