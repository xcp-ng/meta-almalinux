# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-env_home"
PV = "0.1.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-env_home+default-devel \
 rust-env_home-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-env_home-0.1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a1113a3a33310a04d301a45b20be2ff6fc013f46ca6dd0f9b9ae8b73092fc8e6"

URI_x86_64_v2_rust-env_home+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_home+default-devel-0.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_home+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_home+default-devel}"
SRC_URI[x86_64_v2_rust-env_home+default-devel.sha256sum] = "2ab8e4a5bb4c6c734465184f469084dfd5f86bc4b5fa7fd021925c71c2e039e1"

URI_x86_64_v2_rust-env_home-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_home-devel-0.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_home-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_home-devel}"
SRC_URI[x86_64_v2_rust-env_home-devel.sha256sum] = "d8afb26810004b1b530093e5ed9a7f66ffafb80ab49b437b5e7ac54b819636c1"

URI_aarch64_rust-env_home+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_home+default-devel-0.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-env_home+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_home+default-devel}"
SRC_URI[aarch64_rust-env_home+default-devel.sha256sum] = "b5a28351cfc3be0a24a913d052277cb27e76c849a8a29a3dcef3ac5970c64a10"

URI_aarch64_rust-env_home-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_home-devel-0.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-env_home-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_home-devel}"
SRC_URI[aarch64_rust-env_home-devel.sha256sum] = "3f282ffd6b8b2efa864289d4d6b7701ade8cc8a8c0ae69cdc4bdc209d7c9fd3c"

RDEPENDS:rust-env_home+default-devel = " \
 cargo \
 rust-env_home-devel \
 "
RDEPENDS:rust-env_home-devel = " \
 cargo \
 "
