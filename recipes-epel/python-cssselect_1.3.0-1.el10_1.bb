# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cssselect"
PV = "1.3.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-cssselect \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cssselect-1.3.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4dfd9e1a1fdcd529f9f2b129ff2e723ee61c44563d0c8905fa4ce6d9abdb7c5c"

URI_x86_64_v2_python3-cssselect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cssselect-1.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cssselect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cssselect}"
SRC_URI[x86_64_v2_python3-cssselect.sha256sum] = "9beb0f2f9963cfadc6e8ff2b34b7d8e3118220bf368ba66363e2bfffef846b83"

URI_aarch64_python3-cssselect = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cssselect-1.3.0-1.el10_1.noarch.rpm;name=aarch64_python3-cssselect;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cssselect}"
SRC_URI[aarch64_python3-cssselect.sha256sum] = "c1a063b7a02af0309a26d8fb978a80d6d8a79c8baa8775c7c7b364417ea69f4e"

RDEPENDS:python3-cssselect = " \
 python3 \
 "
