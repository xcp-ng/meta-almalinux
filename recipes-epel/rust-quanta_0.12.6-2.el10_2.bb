# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-quanta"
PV = "0.12.6"
PR = "2.el10_2"
PACKAGES = " \
 rust-quanta+default-devel \
 rust-quanta+flaky_tests-devel \
 rust-quanta+prost-devel \
 rust-quanta+prost-types-devel \
 rust-quanta-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-quanta-0.12.6-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e760e643e029bc6ba59e65fbe6942867611190a63c6d79ba9e2cc02226c51d2"

URI_x86_64_v2_rust-quanta+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quanta+default-devel-0.12.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quanta+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quanta+default-devel}"
SRC_URI[x86_64_v2_rust-quanta+default-devel.sha256sum] = "b95606e8aa1567a3fb89f068da11d39b9115394ef15b172e2d6ebabf546464a9"

URI_x86_64_v2_rust-quanta+flaky_tests-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quanta+flaky_tests-devel-0.12.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quanta+flaky_tests-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quanta+flaky_tests-devel}"
SRC_URI[x86_64_v2_rust-quanta+flaky_tests-devel.sha256sum] = "f42f81680dbb952db5998b466d7e9807c007364f10786b4b7851374452b89f86"

URI_x86_64_v2_rust-quanta+prost-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quanta+prost-devel-0.12.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quanta+prost-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quanta+prost-devel}"
SRC_URI[x86_64_v2_rust-quanta+prost-devel.sha256sum] = "8d88d33beeb6864cd71cabcd38f62fb99ec057e9b01cf6daf4d838d6c0c4171d"

URI_x86_64_v2_rust-quanta+prost-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quanta+prost-types-devel-0.12.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quanta+prost-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quanta+prost-types-devel}"
SRC_URI[x86_64_v2_rust-quanta+prost-types-devel.sha256sum] = "45a1915317449f1c65aa0e60015323fb2199a98c7a0e88c96bc7914afe7b4224"

URI_x86_64_v2_rust-quanta-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quanta-devel-0.12.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quanta-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quanta-devel}"
SRC_URI[x86_64_v2_rust-quanta-devel.sha256sum] = "f375584418c436419bf27dc265b8febff561fd22f3e9c700acb8855336d9da34"

URI_aarch64_rust-quanta+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quanta+default-devel-0.12.6-2.el10_2.noarch.rpm;name=aarch64_rust-quanta+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quanta+default-devel}"
SRC_URI[aarch64_rust-quanta+default-devel.sha256sum] = "ec8198b9dce320bf90a69121160c0e9e470144c14d2bf540101572ccb4bf552d"

URI_aarch64_rust-quanta+flaky_tests-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quanta+flaky_tests-devel-0.12.6-2.el10_2.noarch.rpm;name=aarch64_rust-quanta+flaky_tests-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quanta+flaky_tests-devel}"
SRC_URI[aarch64_rust-quanta+flaky_tests-devel.sha256sum] = "9fe42e40f5d50f0954df6b612c1e329237ec8cbadbe662b721b369a0df9d6ea1"

URI_aarch64_rust-quanta+prost-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quanta+prost-devel-0.12.6-2.el10_2.noarch.rpm;name=aarch64_rust-quanta+prost-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quanta+prost-devel}"
SRC_URI[aarch64_rust-quanta+prost-devel.sha256sum] = "b8594de1c8bd323aeb02e9122176da8251aea8d4d1bfb2720131b449af7fb86d"

URI_aarch64_rust-quanta+prost-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quanta+prost-types-devel-0.12.6-2.el10_2.noarch.rpm;name=aarch64_rust-quanta+prost-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quanta+prost-types-devel}"
SRC_URI[aarch64_rust-quanta+prost-types-devel.sha256sum] = "ea350f4d57a670da26b4ebc6ad09244443f39723079c96182f8cde0a3cf357a6"

URI_aarch64_rust-quanta-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quanta-devel-0.12.6-2.el10_2.noarch.rpm;name=aarch64_rust-quanta-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quanta-devel}"
SRC_URI[aarch64_rust-quanta-devel.sha256sum] = "f7ca0a5a713bc5a1bc8d31a2b252f5f397f9cf1a494a38c8169ed6630192c842"

RDEPENDS:rust-quanta+default-devel = " \
 cargo \
 rust-quanta-devel \
 "
RDEPENDS:rust-quanta+flaky_tests-devel = " \
 cargo \
 rust-quanta-devel \
 "
RDEPENDS:rust-quanta+prost-devel = " \
 cargo \
 rust-quanta+prost-types-devel \
 rust-quanta-devel \
 "
RDEPENDS:rust-quanta+prost-types-devel = " \
 cargo \
 rust-prost-types-devel \
 rust-quanta-devel \
 "
RDEPENDS:rust-quanta-devel = " \
 cargo \
 rust \
 rust-crossbeam-utils+default-devel \
 rust-libc+default-devel \
 rust-once_cell+default-devel \
 rust-raw-cpuid+default-devel \
 "
