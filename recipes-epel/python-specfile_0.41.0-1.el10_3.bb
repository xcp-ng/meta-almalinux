# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-specfile"
PV = "0.41.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-specfile \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-specfile-0.41.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3397004c4ae2acb7a4b7d792887f36c44edbd0cd1e1d49b7109786147bd68f0e"

URI_x86_64_v2_python3-specfile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-specfile-0.41.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-specfile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-specfile}"
SRC_URI[x86_64_v2_python3-specfile.sha256sum] = "6e7be372ffb89747175acfa45f2c40e4ddcd77107c9e3e34a0f7755965a2dcb7"

URI_aarch64_python3-specfile = "${EPEL_MIRROR}/aarch64/Packages/p/python3-specfile-0.41.0-1.el10_3.noarch.rpm;name=aarch64_python3-specfile;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-specfile}"
SRC_URI[aarch64_python3-specfile.sha256sum] = "3666100bb479f731e5cb41673ecb51bdd0bab4b63a5127958c884f46826e10d0"

RDEPENDS:python3-specfile = " \
 python3 \
 python3-rpm \
 "
