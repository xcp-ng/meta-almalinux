# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qttools"
PV = "5.15.17"
PR = "1.el10_1"
PACKAGES = " \
 qt5-assistant \
 qt5-designer \
 qt5-doctools \
 qt5-linguist \
 qt5-qdbusviewer \
 qt5-qttools \
 qt5-qttools-common \
 qt5-qttools-devel \
 qt5-qttools-examples \
 qt5-qttools-libs-designer \
 qt5-qttools-libs-designercomponents \
 qt5-qttools-libs-help \
 qt5-qttools-static \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/q/qt5-qttools-5.15.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "556d22e4ab63e98b1bc6233def889a846eb45a8aa163e164fb5e15b99aa1ad48"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-assistant-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-assistant;unpack=0"
SRC_URI[x86_64_v2_qt5-assistant.sha256sum] = "19847654b9acf9f4f33da2af40e0ae7bbe3085b14ff3e63ed2510f18fecb0e4b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-designer-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-designer;unpack=0"
SRC_URI[x86_64_v2_qt5-designer.sha256sum] = "a5ea68d87b393e57f89a28cbd9b8614e9ef87311ada5d4f78977da7d1d2639e2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-doctools-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-doctools;unpack=0"
SRC_URI[x86_64_v2_qt5-doctools.sha256sum] = "bfd18967072caf89ee480b630bafb283c8c6c4880c3f8416e91ee7f0df1ac717"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-linguist-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-linguist;unpack=0"
SRC_URI[x86_64_v2_qt5-linguist.sha256sum] = "3d8b98f586a5a05301d0451aa3ce916894bf108038abb60a614079e7c0b804e0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qdbusviewer-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qdbusviewer;unpack=0"
SRC_URI[x86_64_v2_qt5-qdbusviewer.sha256sum] = "d678d47e82c6d1f6a1e750871a8087e7b49d5462aec9db336231c04451ae0396"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qttools;unpack=0"
SRC_URI[x86_64_v2_qt5-qttools.sha256sum] = "cd7b0429389389388c35b2ca6d9f5957cf54f587ff142234ee05ecd7e9d05992"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-common-5.15.17-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qttools-common;unpack=0"
SRC_URI[x86_64_v2_qt5-qttools-common.sha256sum] = "bc31a83399a6aa174ff2245b9270e8fb556852cd0060da92cf90a17ffecaa9f2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-devel-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qttools-devel;unpack=0"
SRC_URI[x86_64_v2_qt5-qttools-devel.sha256sum] = "0982831ab739686d346c82323cb76e035da87428ca9641a3b2ce3bb648ec5785"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-examples-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qttools-examples;unpack=0"
SRC_URI[x86_64_v2_qt5-qttools-examples.sha256sum] = "ab2bd5e7dc6eed3f4540393ca330e3c49d81af1fccdc939f0e1d11547856403b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-libs-designer-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qttools-libs-designer;unpack=0"
SRC_URI[x86_64_v2_qt5-qttools-libs-designer.sha256sum] = "7d5669ea96cd938cf6039cdf50e2029f1d002bfbd0542e887ec869695f87c75f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-libs-designercomponents-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qttools-libs-designercomponents;unpack=0"
SRC_URI[x86_64_v2_qt5-qttools-libs-designercomponents.sha256sum] = "f15268f6fe47ae49894de70658526b47761983041e80b3ef2f56849357f8b9f4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-libs-help-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qttools-libs-help;unpack=0"
SRC_URI[x86_64_v2_qt5-qttools-libs-help.sha256sum] = "14e77cd396949b134e3b064a30eebfdeb63c2aa68fb40dbbb2d04a857bc2e046"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-static-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qttools-static;unpack=0"
SRC_URI[x86_64_v2_qt5-qttools-static.sha256sum] = "ef9ef10ee7537e5c9cae1a03a142debe2b9115d74f51a676ec7a5cda1bcd48a6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt5-assistant-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-assistant;unpack=0"
SRC_URI[aarch64_qt5-assistant.sha256sum] = "046bb5cb7a356241414b5520584e41ab287f0cb937282cc7983410cad2568e40"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt5-designer-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-designer;unpack=0"
SRC_URI[aarch64_qt5-designer.sha256sum] = "ece5b28ae6a9748eeac162481da0d26465de79e3f869d0a3b6f33b97c9af8fc9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt5-doctools-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-doctools;unpack=0"
SRC_URI[aarch64_qt5-doctools.sha256sum] = "824216cafc42009805696dd33661f63fbeb32e91dd1a97dc5478f5151c4509d6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt5-linguist-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-linguist;unpack=0"
SRC_URI[aarch64_qt5-linguist.sha256sum] = "6ec97fa9c3da8863c249541090856c22f0c6e560389b2ec6528760dd9483e08a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt5-qdbusviewer-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qdbusviewer;unpack=0"
SRC_URI[aarch64_qt5-qdbusviewer.sha256sum] = "34c645ad70b3a2b491d2aa77a070b38dc8501284467074181778c6f689dd8883"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qttools;unpack=0"
SRC_URI[aarch64_qt5-qttools.sha256sum] = "13a0965b2d00ebda3860b0a74cc5dcd6c3b76e0d717dfebd791416bada3df45c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-common-5.15.17-1.el10_1.noarch.rpm;name=aarch64_qt5-qttools-common;unpack=0"
SRC_URI[aarch64_qt5-qttools-common.sha256sum] = "a3439ee185f07560ccf0ee3f94915823f2296581425310ae3f9faa60fced5368"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-devel-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qttools-devel;unpack=0"
SRC_URI[aarch64_qt5-qttools-devel.sha256sum] = "5aa78bd6f6d9ec4274bcb52664ef5157f9c681831b096d6988f47769166ea5c9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-examples-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qttools-examples;unpack=0"
SRC_URI[aarch64_qt5-qttools-examples.sha256sum] = "413d36e55a2f12caaca20ee58f3c7fcd063f0f9daee9a7f57ab22c482f1d7bec"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-libs-designer-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qttools-libs-designer;unpack=0"
SRC_URI[aarch64_qt5-qttools-libs-designer.sha256sum] = "1893a35fcf7e29fbef36551088a80f411df7170bfa4899581301f01223efd799"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-libs-designercomponents-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qttools-libs-designercomponents;unpack=0"
SRC_URI[aarch64_qt5-qttools-libs-designercomponents.sha256sum] = "5eab020704a9139481cc44cd3dbb1f8d1d4334ebcccec35c7c445fbae1a951a3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-libs-help-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qttools-libs-help;unpack=0"
SRC_URI[aarch64_qt5-qttools-libs-help.sha256sum] = "d8f98955f3b53c0ffe26134c89239393121cfcde31a18b20a0c47db8deaa7b56"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-static-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qttools-static;unpack=0"
SRC_URI[aarch64_qt5-qttools-static.sha256sum] = "4f7f375ec250206e10d376a1a494bc60ccaa5b07d0383acf233569b8ebe3efb7"

RDEPENDS:qt5-assistant = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qttools-common \
 qt5-qttools-libs-help \
 "
RDEPENDS:qt5-designer = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qttools-libs-designer \
 qt5-qttools-libs-designercomponents \
 "
RDEPENDS:qt5-doctools = " \
 clang-libs \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qttools-libs-help \
 "
RDEPENDS:qt5-linguist = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qttools-common \
 "
RDEPENDS:qt5-qdbusviewer = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qttools-common \
 "
RDEPENDS:qt5-qttools = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qttools-common \
 "
RDEPENDS:qt5-qttools-common = " \
 "
RDEPENDS:qt5-qttools-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt5-designer \
 qt5-doctools \
 qt5-linguist \
 qt5-qtbase \
 qt5-qtbase-devel \
 qt5-qtbase-gui \
 qt5-qttools \
 qt5-qttools-libs-designer \
 qt5-qttools-libs-designercomponents \
 qt5-qttools-libs-help \
 "
RDEPENDS:qt5-qttools-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qttools-common \
 qt5-qttools-libs-designer \
 qt5-qttools-libs-help \
 "
RDEPENDS:qt5-qttools-libs-designer = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qttools-common \
 "
RDEPENDS:qt5-qttools-libs-designercomponents = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qttools-common \
 qt5-qttools-libs-designer \
 "
RDEPENDS:qt5-qttools-libs-help = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qttools-common \
 "
RDEPENDS:qt5-qttools-static = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qttools-devel \
 "
