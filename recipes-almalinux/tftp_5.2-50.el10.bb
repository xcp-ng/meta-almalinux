# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tftp"
PV = "5.2"
PR = "50.el10"
PACKAGES = " \
 tftp \
 tftp-server \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tftp-5.2-50.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74e8c39c5fb95dfe8f48f00cf130a80109db67ed5c3176487e328c11dcecbc40"

URI_x86_64_v2_tftp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tftp-5.2-50.el10.x86_64_v2.rpm;name=x86_64_v2_tftp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tftp}"
SRC_URI[x86_64_v2_tftp.sha256sum] = "9f67cf7ab997a2b6dfa851a66a66d0833840d1ddd7150acd45cd7934d2e36ffe"

URI_x86_64_v2_tftp-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tftp-server-5.2-50.el10.x86_64_v2.rpm;name=x86_64_v2_tftp-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tftp-server}"
SRC_URI[x86_64_v2_tftp-server.sha256sum] = "9efe2214c50317a8b182c7ba77156009865f7b4eba5a5783b2b4769b4eba1e8b"

URI_aarch64_tftp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tftp-5.2-50.el10.aarch64.rpm;name=aarch64_tftp;unpack=0"
SRC_URI:append = " ${URI_aarch64_tftp}"
SRC_URI[aarch64_tftp.sha256sum] = "d397915b4349583d9380606fc83060d11059b357abf1fd61eedaf3c8d1802bc7"

URI_aarch64_tftp-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tftp-server-5.2-50.el10.aarch64.rpm;name=aarch64_tftp-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_tftp-server}"
SRC_URI[aarch64_tftp-server.sha256sum] = "2d8005e9be9f9ea194707fe49d56550919433982d9257d47890a6876354716d8"

RDEPENDS:tftp = " \
 glibc \
 readline \
 "
RDEPENDS:tftp-server = " \
 bash \
 glibc \
 systemd \
 "
