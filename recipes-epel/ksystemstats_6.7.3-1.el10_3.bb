# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksystemstats"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 ksystemstats \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ksystemstats-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "53b82737e40833ddb424e83675375886411ff5db35a5eb6e3fdf4e8c2eb58710"

URI_x86_64_v2_ksystemstats = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksystemstats-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksystemstats;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksystemstats}"
SRC_URI[x86_64_v2_ksystemstats.sha256sum] = "45e4fbfbfcd4eed591d1d0112b77c665f8d30de9fb162f7c01326d837bd560d5"

URI_aarch64_ksystemstats = "${EPEL_MIRROR}/aarch64/Packages/k/ksystemstats-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_ksystemstats;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksystemstats}"
SRC_URI[aarch64_ksystemstats.sha256sum] = "46bf4cb602be8bffb5d2ef871deb15278813b005592a9821d777b0a9fe33cee6"

RDEPENDS:ksystemstats = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-networkmanager-qt \
 kf6-solid \
 libksysguard \
 libnl3 \
 libstdc++ \
 lm_sensors-libs \
 qt6-qtbase \
 systemd-libs \
 "
