# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.12"
PV = "3.12.9"
PR = "2.el10_0.3"
PACKAGES = " \
 python-unversioned-command \
 python3 \
 python3-debug \
 python3-devel \
 python3-idle \
 python3-libs \
 python3-test \
 python3-tkinter \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python3.12-3.12.9-2.el10_0.3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "160a1da806e0e2787893690f57162e67fc3ebbff48f85fc5dd44dff0cf0238c7"

URI_x86_64_v2_python-unversioned-command = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python-unversioned-command-3.12.9-2.el10_0.3.noarch.rpm;name=x86_64_v2_python-unversioned-command;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-unversioned-command}"
SRC_URI[x86_64_v2_python-unversioned-command.sha256sum] = "c92f0df9edffbf73d01895a506c80c94c3c1873b611329019ae5c7a4a3df76c7"

URI_x86_64_v2_python3 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-3.12.9-2.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_python3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3}"
SRC_URI[x86_64_v2_python3.sha256sum] = "01ca8a51e1752b995cfa87099996a64f08bd43edd1330ae4ddbbd9c5bbd33143"

URI_x86_64_v2_python3-debug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-debug-3.12.9-2.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_python3-debug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-debug}"
SRC_URI[x86_64_v2_python3-debug.sha256sum] = "3c26cae3a163f5e562761cc012eb12899b049a1aa25bcab4a186b652566ceca1"

URI_x86_64_v2_python3-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-devel-3.12.9-2.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_python3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-devel}"
SRC_URI[x86_64_v2_python3-devel.sha256sum] = "0c3198837e7d12b37119fbad4c7e6dc9b1d5bac168984cb3ca9ef428077e06a3"

URI_x86_64_v2_python3-idle = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-idle-3.12.9-2.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_python3-idle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-idle}"
SRC_URI[x86_64_v2_python3-idle.sha256sum] = "3f72061d895d074ccc4afad1bdebc06e2a2084209760000b47d4747f808e8f04"

URI_x86_64_v2_python3-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-libs-3.12.9-2.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_python3-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libs}"
SRC_URI[x86_64_v2_python3-libs.sha256sum] = "50e67397f679a7fb0d35d5d5946055037e499d14b0871c919ccfbfd542418e07"

URI_x86_64_v2_python3-test = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-test-3.12.9-2.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_python3-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-test}"
SRC_URI[x86_64_v2_python3-test.sha256sum] = "f03b1dd5836c718e8bdedccc87be53e30b799fdc672c0bef4012bc5607b34208"

URI_x86_64_v2_python3-tkinter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-tkinter-3.12.9-2.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_python3-tkinter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tkinter}"
SRC_URI[x86_64_v2_python3-tkinter.sha256sum] = "408dc226e831266e6bb569cd4a9e136b597bebecf916a6629aa8fa2e1b7324c5"

URI_aarch64_python-unversioned-command = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python-unversioned-command-3.12.9-2.el10_0.3.noarch.rpm;name=aarch64_python-unversioned-command;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-unversioned-command}"
SRC_URI[aarch64_python-unversioned-command.sha256sum] = "c92f0df9edffbf73d01895a506c80c94c3c1873b611329019ae5c7a4a3df76c7"

URI_aarch64_python3 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-3.12.9-2.el10_0.3.aarch64.rpm;name=aarch64_python3;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3}"
SRC_URI[aarch64_python3.sha256sum] = "73b9688893124be59c128a9ae5471e1ec825d626dac6dbb7d8907c6e8a8bc5af"

URI_aarch64_python3-debug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-debug-3.12.9-2.el10_0.3.aarch64.rpm;name=aarch64_python3-debug;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-debug}"
SRC_URI[aarch64_python3-debug.sha256sum] = "b9af4a592911cb918d4f64e15d94bc83246b9441c7820a2c085b550e73c958ac"

URI_aarch64_python3-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-devel-3.12.9-2.el10_0.3.aarch64.rpm;name=aarch64_python3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-devel}"
SRC_URI[aarch64_python3-devel.sha256sum] = "6b01d0f0fa7fe2a98f7a017d3ba592f489732c9189c660020d754377039389aa"

URI_aarch64_python3-idle = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-idle-3.12.9-2.el10_0.3.aarch64.rpm;name=aarch64_python3-idle;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-idle}"
SRC_URI[aarch64_python3-idle.sha256sum] = "d9f3633a75a178d72bda7a09a56ff67008f491a5c9a5b9df9b985cd0eb791a20"

URI_aarch64_python3-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-libs-3.12.9-2.el10_0.3.aarch64.rpm;name=aarch64_python3-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libs}"
SRC_URI[aarch64_python3-libs.sha256sum] = "5fdd4ad12d2b7d106af1de64a1adc26d3c791225352fa35e8e80d4b39bff6765"

URI_aarch64_python3-test = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-test-3.12.9-2.el10_0.3.aarch64.rpm;name=aarch64_python3-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-test}"
SRC_URI[aarch64_python3-test.sha256sum] = "fa306e9177b4badfb56d5bee03a95c010dfd273698666f56ec1cac570c93966f"

URI_aarch64_python3-tkinter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-tkinter-3.12.9-2.el10_0.3.aarch64.rpm;name=aarch64_python3-tkinter;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tkinter}"
SRC_URI[aarch64_python3-tkinter.sha256sum] = "7a1e1f62574835663c1d43d24df77e34152619bfa341a0d136463d79bd42b63a"

RDEPENDS:python-unversioned-command = " \
 python3 \
 "
RDEPENDS:python3 = " \
 glibc \
 python3-libs \
 "
RDEPENDS:python3-debug = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libuuid \
 libxcrypt \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 pkgconf-pkg-config \
 python3 \
 python3-devel \
 python3-idle \
 python3-libs \
 python3-test \
 python3-tkinter \
 readline \
 sqlite-libs \
 tcl \
 tk \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3-devel = " \
 bash \
 pkgconf-pkg-config \
 python-rpm-macros \
 python3 \
 python3-libs \
 python3-rpm-generators \
 python3-rpm-macros \
 "
RDEPENDS:python3-idle = " \
 python3 \
 python3-tkinter \
 "
RDEPENDS:python3-libs = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libuuid \
 libxcrypt \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 python3-pip-wheel \
 readline \
 sqlite-libs \
 tzdata \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3-test = " \
 bash \
 glibc \
 python3 \
 python3-libs \
 python3-setuptools-wheel \
 python3-wheel-wheel \
 "
RDEPENDS:python3-tkinter = " \
 glibc \
 python3 \
 tcl \
 tk \
 "
