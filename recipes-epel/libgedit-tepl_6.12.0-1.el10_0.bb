# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgedit-tepl"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 libgedit-tepl \
 libgedit-tepl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libgedit-tepl-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a96db80b825cc7dad2da2784dff8c788cfd4c7398734075665fcd1d8b85886a"

URI_x86_64_v2_libgedit-tepl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgedit-tepl-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgedit-tepl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgedit-tepl}"
SRC_URI[x86_64_v2_libgedit-tepl.sha256sum] = "1f288877739b81280d2e4ac0932ad66f5b736ad0d7c4e65c25cfadf9985ef83c"

URI_x86_64_v2_libgedit-tepl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgedit-tepl-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgedit-tepl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgedit-tepl-devel}"
SRC_URI[x86_64_v2_libgedit-tepl-devel.sha256sum] = "4da0c15ca9b91b6d2c509eca6aba8852d47f19b7a642d8abfaca4506c4760fc9"

URI_aarch64_libgedit-tepl = "${EPEL_MIRROR}/aarch64/Packages/l/libgedit-tepl-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_libgedit-tepl;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgedit-tepl}"
SRC_URI[aarch64_libgedit-tepl.sha256sum] = "f989b4dac49f6e067654b124e5847ad27384edbf09be4968c75727a5ea2e25bb"

URI_aarch64_libgedit-tepl-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libgedit-tepl-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_libgedit-tepl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgedit-tepl-devel}"
SRC_URI[aarch64_libgedit-tepl-devel.sha256sum] = "fbc155c962674c0b5c16bfca2d7306a9a385b3c4d6c9c40fdc2879e055c10f20"

RDEPENDS:libgedit-tepl = " \
 cairo \
 glib2 \
 glibc \
 gtk3 \
 libgedit-amtk \
 libgedit-gfls \
 libgedit-gtksourceview \
 libhandy \
 libicu \
 pango \
 "
RDEPENDS:libgedit-tepl-devel = " \
 glib2-devel \
 gsettings-desktop-schemas-devel \
 gtk3-devel \
 libgedit-amtk-devel \
 libgedit-gfls-devel \
 libgedit-gtksourceview-devel \
 libgedit-tepl \
 libhandy-devel \
 libicu-devel \
 pkgconf-pkg-config \
 "
