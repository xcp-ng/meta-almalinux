# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crypto_secretbox"
PV = "0.1.1"
PR = "5.el10_3"
PACKAGES = " \
 rust-crypto_secretbox+alloc-devel \
 rust-crypto_secretbox+chacha20-devel \
 rust-crypto_secretbox+default-devel \
 rust-crypto_secretbox+getrandom-devel \
 rust-crypto_secretbox+heapless-devel \
 rust-crypto_secretbox+rand_core-devel \
 rust-crypto_secretbox+salsa20-devel \
 rust-crypto_secretbox+std-devel \
 rust-crypto_secretbox+stream-devel \
 rust-crypto_secretbox-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crypto_secretbox-0.1.1-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5dc2d964fd5aeeaef13462b308eb67f359ff2eb5e78740cbbb0fa150ab9860e0"

URI_x86_64_v2_rust-crypto_secretbox+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto_secretbox+alloc-devel-0.1.1-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto_secretbox+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto_secretbox+alloc-devel}"
SRC_URI[x86_64_v2_rust-crypto_secretbox+alloc-devel.sha256sum] = "6b3772684490977054484f8aa38c160330b82378af8269544bf1c3d7515358be"

URI_x86_64_v2_rust-crypto_secretbox+chacha20-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto_secretbox+chacha20-devel-0.1.1-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto_secretbox+chacha20-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto_secretbox+chacha20-devel}"
SRC_URI[x86_64_v2_rust-crypto_secretbox+chacha20-devel.sha256sum] = "8321950cd32420a5fcf90623232f89e74ca55c30f8225cc1392d0fbb03a9efa1"

URI_x86_64_v2_rust-crypto_secretbox+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto_secretbox+default-devel-0.1.1-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto_secretbox+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto_secretbox+default-devel}"
SRC_URI[x86_64_v2_rust-crypto_secretbox+default-devel.sha256sum] = "592e980942fd99f848ba28b03062a2fee8ccb3e70776b9f0a442c5d1b8ca3998"

URI_x86_64_v2_rust-crypto_secretbox+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto_secretbox+getrandom-devel-0.1.1-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto_secretbox+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto_secretbox+getrandom-devel}"
SRC_URI[x86_64_v2_rust-crypto_secretbox+getrandom-devel.sha256sum] = "5f3f4cc83310bee36cb45b42e534f122be22bc63ff424259a1f3cc7f04465804"

URI_x86_64_v2_rust-crypto_secretbox+heapless-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto_secretbox+heapless-devel-0.1.1-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto_secretbox+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto_secretbox+heapless-devel}"
SRC_URI[x86_64_v2_rust-crypto_secretbox+heapless-devel.sha256sum] = "08588589d17ce3c671fd6dce2948e1000924b2a4c5704b8283cc4b49c465a3fd"

URI_x86_64_v2_rust-crypto_secretbox+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto_secretbox+rand_core-devel-0.1.1-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto_secretbox+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto_secretbox+rand_core-devel}"
SRC_URI[x86_64_v2_rust-crypto_secretbox+rand_core-devel.sha256sum] = "074ceace852dd602c62beabad080e8ed29447ac67ee91c03b2a5a6e6e59a1c4a"

URI_x86_64_v2_rust-crypto_secretbox+salsa20-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto_secretbox+salsa20-devel-0.1.1-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto_secretbox+salsa20-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto_secretbox+salsa20-devel}"
SRC_URI[x86_64_v2_rust-crypto_secretbox+salsa20-devel.sha256sum] = "0f3d5c770f1248889c706e554179bb8d77222ce2df2d5fe4402d011e4cf6da60"

URI_x86_64_v2_rust-crypto_secretbox+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto_secretbox+std-devel-0.1.1-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto_secretbox+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto_secretbox+std-devel}"
SRC_URI[x86_64_v2_rust-crypto_secretbox+std-devel.sha256sum] = "3b8551b3b0ab4cbb5c269b6182e2d09d63be3b7b0a08c8e97a15f0b742a4abf3"

URI_x86_64_v2_rust-crypto_secretbox+stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto_secretbox+stream-devel-0.1.1-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto_secretbox+stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto_secretbox+stream-devel}"
SRC_URI[x86_64_v2_rust-crypto_secretbox+stream-devel.sha256sum] = "7817ddd878df57842ce0b0de9bce6f8d703cf4201535a75a3716e91ffeb6d8a3"

URI_x86_64_v2_rust-crypto_secretbox-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto_secretbox-devel-0.1.1-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto_secretbox-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto_secretbox-devel}"
SRC_URI[x86_64_v2_rust-crypto_secretbox-devel.sha256sum] = "fc436597ab8d085d67271731c2adcc27e0c0190d446ae357acabaf73824ef06f"

URI_aarch64_rust-crypto_secretbox+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto_secretbox+alloc-devel-0.1.1-5.el10_3.noarch.rpm;name=aarch64_rust-crypto_secretbox+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto_secretbox+alloc-devel}"
SRC_URI[aarch64_rust-crypto_secretbox+alloc-devel.sha256sum] = "8a588853a92d71223cd3474947415d0f699d26eaf8655d50e5caef7af0aecd27"

URI_aarch64_rust-crypto_secretbox+chacha20-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto_secretbox+chacha20-devel-0.1.1-5.el10_3.noarch.rpm;name=aarch64_rust-crypto_secretbox+chacha20-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto_secretbox+chacha20-devel}"
SRC_URI[aarch64_rust-crypto_secretbox+chacha20-devel.sha256sum] = "72f552a12b98a44364ee52985aaeedbfb21df2b6e6870203ecce649e623d00ff"

URI_aarch64_rust-crypto_secretbox+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto_secretbox+default-devel-0.1.1-5.el10_3.noarch.rpm;name=aarch64_rust-crypto_secretbox+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto_secretbox+default-devel}"
SRC_URI[aarch64_rust-crypto_secretbox+default-devel.sha256sum] = "f29cf7d2353f9aef88d33cf96ddd0a3c9316b735ab76aa5266d56f654d18d14e"

URI_aarch64_rust-crypto_secretbox+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto_secretbox+getrandom-devel-0.1.1-5.el10_3.noarch.rpm;name=aarch64_rust-crypto_secretbox+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto_secretbox+getrandom-devel}"
SRC_URI[aarch64_rust-crypto_secretbox+getrandom-devel.sha256sum] = "8517cb3e75c034f0a76a42a51691401ba7332271af9115e1fbdd2e7837636644"

URI_aarch64_rust-crypto_secretbox+heapless-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto_secretbox+heapless-devel-0.1.1-5.el10_3.noarch.rpm;name=aarch64_rust-crypto_secretbox+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto_secretbox+heapless-devel}"
SRC_URI[aarch64_rust-crypto_secretbox+heapless-devel.sha256sum] = "87e090179eee56131edc045de1f71002c423702f6c3827a99fccbc6bb91d5011"

URI_aarch64_rust-crypto_secretbox+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto_secretbox+rand_core-devel-0.1.1-5.el10_3.noarch.rpm;name=aarch64_rust-crypto_secretbox+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto_secretbox+rand_core-devel}"
SRC_URI[aarch64_rust-crypto_secretbox+rand_core-devel.sha256sum] = "b4af6cf5b003d058345b66971d72eae3d1f4c2f3334d0d1014ce1f803b8ade91"

URI_aarch64_rust-crypto_secretbox+salsa20-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto_secretbox+salsa20-devel-0.1.1-5.el10_3.noarch.rpm;name=aarch64_rust-crypto_secretbox+salsa20-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto_secretbox+salsa20-devel}"
SRC_URI[aarch64_rust-crypto_secretbox+salsa20-devel.sha256sum] = "609a6c3806d2071728c35ea6aa3a8c58bc184976cc92fa21852e280cf0f6199f"

URI_aarch64_rust-crypto_secretbox+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto_secretbox+std-devel-0.1.1-5.el10_3.noarch.rpm;name=aarch64_rust-crypto_secretbox+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto_secretbox+std-devel}"
SRC_URI[aarch64_rust-crypto_secretbox+std-devel.sha256sum] = "72f8145faf4e960df5188d32e817d3434553c557829e384eb49170bad1770448"

URI_aarch64_rust-crypto_secretbox+stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto_secretbox+stream-devel-0.1.1-5.el10_3.noarch.rpm;name=aarch64_rust-crypto_secretbox+stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto_secretbox+stream-devel}"
SRC_URI[aarch64_rust-crypto_secretbox+stream-devel.sha256sum] = "8f48900a296705f552150ebab0c9ecaacefadc1771772b2b9fa8f884682cb3d4"

URI_aarch64_rust-crypto_secretbox-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto_secretbox-devel-0.1.1-5.el10_3.noarch.rpm;name=aarch64_rust-crypto_secretbox-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto_secretbox-devel}"
SRC_URI[aarch64_rust-crypto_secretbox-devel.sha256sum] = "1cc3830462e8257abc8bf2260e4fa2f6f35e6be36818aa1d2213a964809972ca"

RDEPENDS:rust-crypto_secretbox+alloc-devel = " \
 cargo \
 rust-aead+alloc-devel \
 rust-crypto_secretbox-devel \
 "
RDEPENDS:rust-crypto_secretbox+chacha20-devel = " \
 cargo \
 rust-chacha20_0.9+default-devel \
 rust-chacha20_0.9+zeroize-devel \
 rust-crypto_secretbox-devel \
 "
RDEPENDS:rust-crypto_secretbox+default-devel = " \
 cargo \
 rust-crypto_secretbox+alloc-devel \
 rust-crypto_secretbox+getrandom-devel \
 rust-crypto_secretbox+salsa20-devel \
 rust-crypto_secretbox-devel \
 "
RDEPENDS:rust-crypto_secretbox+getrandom-devel = " \
 cargo \
 rust-aead+getrandom-devel \
 rust-crypto_secretbox+rand_core-devel \
 rust-crypto_secretbox-devel \
 "
RDEPENDS:rust-crypto_secretbox+heapless-devel = " \
 cargo \
 rust-aead+heapless-devel \
 rust-crypto_secretbox-devel \
 "
RDEPENDS:rust-crypto_secretbox+rand_core-devel = " \
 cargo \
 rust-aead+rand_core-devel \
 rust-crypto_secretbox-devel \
 "
RDEPENDS:rust-crypto_secretbox+salsa20-devel = " \
 cargo \
 rust-crypto_secretbox-devel \
 rust-salsa20_0.10+default-devel \
 rust-salsa20_0.10+zeroize-devel \
 "
RDEPENDS:rust-crypto_secretbox+std-devel = " \
 cargo \
 rust-aead+std-devel \
 rust-crypto_secretbox+alloc-devel \
 rust-crypto_secretbox-devel \
 "
RDEPENDS:rust-crypto_secretbox+stream-devel = " \
 cargo \
 rust-aead+stream-devel \
 rust-crypto_secretbox-devel \
 "
RDEPENDS:rust-crypto_secretbox-devel = " \
 cargo \
 rust \
 rust-aead-devel \
 rust-cipher0.4-devel \
 rust-generic-array+zeroize-devel \
 rust-generic-array-devel \
 rust-poly1305+default-devel \
 rust-subtle-devel \
 rust-zeroize-devel \
 "
