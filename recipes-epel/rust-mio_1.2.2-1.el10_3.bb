# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mio"
PV = "1.2.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-mio+default-devel \
 rust-mio+log-devel \
 rust-mio+net-devel \
 rust-mio+os-ext-devel \
 rust-mio+os-poll-devel \
 rust-mio-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mio-1.2.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b36793bd27e3ab16d3c44b7c506bfc7bbbbe2ef872a14dc10a4780c7a1975d00"

URI_x86_64_v2_rust-mio+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio+default-devel-1.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio+default-devel}"
SRC_URI[x86_64_v2_rust-mio+default-devel.sha256sum] = "d26c83c40ade0d7115084a9b209d39b47b82b7ba388caab9c66e3f27b364b4a4"

URI_x86_64_v2_rust-mio+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio+log-devel-1.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio+log-devel}"
SRC_URI[x86_64_v2_rust-mio+log-devel.sha256sum] = "ea13200a6d6dfce356a417e74a44c014a8b9bd133625a0c1bb48aaae26d1f0ba"

URI_x86_64_v2_rust-mio+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio+net-devel-1.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio+net-devel}"
SRC_URI[x86_64_v2_rust-mio+net-devel.sha256sum] = "aecdc4992fe08674ef9f08ee23254d20a1638d8836bfc9cd6d2e0d2fa0ed69c8"

URI_x86_64_v2_rust-mio+os-ext-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio+os-ext-devel-1.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio+os-ext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio+os-ext-devel}"
SRC_URI[x86_64_v2_rust-mio+os-ext-devel.sha256sum] = "b047b22e7732c4e9ac5aeb31d649eee629d582abe283029f11f43ae0abd2fcbc"

URI_x86_64_v2_rust-mio+os-poll-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio+os-poll-devel-1.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio+os-poll-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio+os-poll-devel}"
SRC_URI[x86_64_v2_rust-mio+os-poll-devel.sha256sum] = "9f26568b1be9a3326aaa71a1072fbc478cc01b3f2e87cfa112492b23c335339e"

URI_x86_64_v2_rust-mio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio-devel-1.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio-devel}"
SRC_URI[x86_64_v2_rust-mio-devel.sha256sum] = "5b68981a9617fef9350c26c9589fc40b25a48d2bf41a1e5f48529e17a3d0ef3f"

URI_aarch64_rust-mio+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio+default-devel-1.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-mio+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio+default-devel}"
SRC_URI[aarch64_rust-mio+default-devel.sha256sum] = "b438dba071ffb65df93685a1edeac22272623bbeb7ba164e1d7181c0186bc752"

URI_aarch64_rust-mio+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio+log-devel-1.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-mio+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio+log-devel}"
SRC_URI[aarch64_rust-mio+log-devel.sha256sum] = "455f52ca05a083e08f5f09d68b194bcf7d5be059a84bc74b448fd82532059e62"

URI_aarch64_rust-mio+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio+net-devel-1.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-mio+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio+net-devel}"
SRC_URI[aarch64_rust-mio+net-devel.sha256sum] = "a67b49a1707a7e38437af690578a92333860457d45d63163949cd7870d5e7670"

URI_aarch64_rust-mio+os-ext-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio+os-ext-devel-1.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-mio+os-ext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio+os-ext-devel}"
SRC_URI[aarch64_rust-mio+os-ext-devel.sha256sum] = "499bd67507144415a70ce348997191ac58d80355e81b646c74968df6234f7197"

URI_aarch64_rust-mio+os-poll-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio+os-poll-devel-1.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-mio+os-poll-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio+os-poll-devel}"
SRC_URI[aarch64_rust-mio+os-poll-devel.sha256sum] = "d147f4e15c5a0ac7665936b5d4c83618ecfc82c15a277ff63469c36272a6f599"

URI_aarch64_rust-mio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio-devel-1.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-mio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio-devel}"
SRC_URI[aarch64_rust-mio-devel.sha256sum] = "f60e97f19f6ecef7d9abef3941ffe94bc789ed0730f345d625d2a6808c5773be"

RDEPENDS:rust-mio+default-devel = " \
 cargo \
 rust-mio+log-devel \
 rust-mio-devel \
 "
RDEPENDS:rust-mio+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-mio-devel \
 "
RDEPENDS:rust-mio+net-devel = " \
 cargo \
 rust-mio-devel \
 "
RDEPENDS:rust-mio+os-ext-devel = " \
 cargo \
 rust-mio+os-poll-devel \
 rust-mio-devel \
 "
RDEPENDS:rust-mio+os-poll-devel = " \
 cargo \
 rust-mio-devel \
 "
RDEPENDS:rust-mio-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
