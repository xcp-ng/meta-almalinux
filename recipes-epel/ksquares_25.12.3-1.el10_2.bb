# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksquares"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 ksquares \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ksquares-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4ebce342d504fd63e4c7a2aa5bb38967d4ede17ba9a96ba628a57966527468d"

URI_x86_64_v2_ksquares = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksquares-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksquares;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksquares}"
SRC_URI[x86_64_v2_ksquares.sha256sum] = "0c83e7505d47b85f137735a9f9dfc1d45a50b40fb269969544fa9adedef11ca6"

URI_aarch64_ksquares = "${EPEL_MIRROR}/aarch64/Packages/k/ksquares-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_ksquares;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksquares}"
SRC_URI[aarch64_ksquares.sha256sum] = "00d697b41b5cab5aa0be2de1d1abde966b59af4b5d30e6da19df8db407caabbb"

RDEPENDS:ksquares = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
