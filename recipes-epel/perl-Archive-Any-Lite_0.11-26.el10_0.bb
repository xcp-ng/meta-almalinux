# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Archive-Any-Lite"
PV = "0.11"
PR = "26.el10_0"
PACKAGES = " \
 perl-Archive-Any-Lite \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Archive-Any-Lite-0.11-26.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5409f498a35b4c2add5baba30aa9cfa44df466764ce1d20be5b9ca29001dc756"

URI_x86_64_v2_perl-Archive-Any-Lite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Archive-Any-Lite-0.11-26.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Archive-Any-Lite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Archive-Any-Lite}"
SRC_URI[x86_64_v2_perl-Archive-Any-Lite.sha256sum] = "e77ea4c56df4693a9e4daf48db6c78bc98c3941eb137a7a8c3714e913831b0a7"

URI_aarch64_perl-Archive-Any-Lite = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Archive-Any-Lite-0.11-26.el10_0.noarch.rpm;name=aarch64_perl-Archive-Any-Lite;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Archive-Any-Lite}"
SRC_URI[aarch64_perl-Archive-Any-Lite.sha256sum] = "f1a61aac9501547ac302d028ae926ca8bffd88a8e0cd7510bb582d4f230a0f0b"

RDEPENDS:perl-Archive-Any-Lite = " \
 perl-Archive-Tar \
 perl-Archive-Zip \
 perl-IO-Compress \
 perl-IO-Zlib \
 perl-PathTools \
 perl-libs \
 "
