# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtshadertools"
PV = "6.10.1"
PR = "2.el10"
PACKAGES = " \
 qt6-qtshadertools \
 qt6-qtshadertools-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtshadertools-6.10.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b09e0e970689998ea3534d48ac66f05691707965442f3f5f27945ca1cc4d4e95"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtshadertools-6.10.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtshadertools;unpack=0"
SRC_URI[x86_64_v2_qt6-qtshadertools.sha256sum] = "5ca3c86e291a41f6cd52321d1d3033ea8c1ad5644ab77af29bdef1290a5b4f55"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtshadertools-devel-6.10.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtshadertools-devel;unpack=0"
SRC_URI[x86_64_v2_qt6-qtshadertools-devel.sha256sum] = "dc420d493bd3d25dc74714b130996b2ef6938cbbc4aa5269bc03ff1262ea32e4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtshadertools-6.10.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtshadertools;unpack=0"
SRC_URI[aarch64_qt6-qtshadertools.sha256sum] = "01ab5dd038d9c4d2469d142a4a1592a153b35b4837a9560003a4d06377ca90c0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtshadertools-devel-6.10.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtshadertools-devel;unpack=0"
SRC_URI[aarch64_qt6-qtshadertools-devel.sha256sum] = "b34dc83ffdbb2ffc2fb42f076c6593b01ad3dff43e31b8b682e194eb2ef12443"

RDEPENDS:qt6-qtshadertools = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 spirv-tools-libs \
 "
RDEPENDS:qt6-qtshadertools-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtshadertools \
 spirv-tools \
 "
