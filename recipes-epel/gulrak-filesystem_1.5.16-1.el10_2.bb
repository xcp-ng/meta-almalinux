# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gulrak-filesystem"
PV = "1.5.16"
PR = "1.el10_2"
PACKAGES = " \
 gulrak-filesystem-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gulrak-filesystem-1.5.16-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ff66aa6face24fef6130cf8843dabef4118c16daae85a73589e9347a6361a63"

URI_x86_64_v2_gulrak-filesystem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gulrak-filesystem-devel-1.5.16-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gulrak-filesystem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gulrak-filesystem-devel}"
SRC_URI[x86_64_v2_gulrak-filesystem-devel.sha256sum] = "67fb4fc33756e2e49b6ff202ebd8b2b5215c6f49b169ff2e5d08598ac5b27c1c"

URI_aarch64_gulrak-filesystem-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gulrak-filesystem-devel-1.5.16-1.el10_2.aarch64.rpm;name=aarch64_gulrak-filesystem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gulrak-filesystem-devel}"
SRC_URI[aarch64_gulrak-filesystem-devel.sha256sum] = "66a842b3a965555995c3d77ac49e44e8c6e364292abc9e370be4410d631cf0ed"

RDEPENDS:gulrak-filesystem-devel = " \
 cmake-filesystem \
 "
