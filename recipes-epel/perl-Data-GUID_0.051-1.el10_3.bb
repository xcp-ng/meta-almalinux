# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Data-GUID"
PV = "0.051"
PR = "1.el10_3"
PACKAGES = " \
 perl-Data-GUID \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Data-GUID-0.051-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e5668d656f537c670d42c6f67f0690cc3cbd4c65737ec48fcbd167e839c15bda"

URI_x86_64_v2_perl-Data-GUID = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Data-GUID-0.051-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Data-GUID;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Data-GUID}"
SRC_URI[x86_64_v2_perl-Data-GUID.sha256sum] = "646953d633350f50d2973774a56e3e261e1807776b4536b22bdb595b7470b654"

URI_aarch64_perl-Data-GUID = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Data-GUID-0.051-1.el10_3.noarch.rpm;name=aarch64_perl-Data-GUID;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Data-GUID}"
SRC_URI[aarch64_perl-Data-GUID.sha256sum] = "6b1781d9d44f2f8415e77506a667fdc7db70deda077ecefe9e81ef37159067ca"

RDEPENDS:perl-Data-GUID = " \
 perl-Carp \
 perl-Data-UUID \
 perl-Sub-Exporter \
 perl-Sub-Install \
 perl-libs \
 perl-overload \
 "
