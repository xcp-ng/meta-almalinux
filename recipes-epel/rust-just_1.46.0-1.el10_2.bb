# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-just"
PV = "1.46.0"
PR = "1.el10_2"
PACKAGES = " \
 just \
 rust-just+default-devel \
 rust-just-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-just-1.46.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2c2d894b18690eb9f6b5725ddd4c210c1d5376752f4ba62a453816b72f47379a"

URI_x86_64_v2_just = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/just-1.46.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_just;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_just}"
SRC_URI[x86_64_v2_just.sha256sum] = "c6ff9c03b2d5180d9bd97bcea533f9006f5d850395bce6d76b81ef6efa495771"

URI_x86_64_v2_rust-just+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-just+default-devel-1.46.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-just+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-just+default-devel}"
SRC_URI[x86_64_v2_rust-just+default-devel.sha256sum] = "110281724a743afac13ca1587c78575baa7b6b93f33d0a1e387a1cb1db8fae09"

URI_x86_64_v2_rust-just-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-just-devel-1.46.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-just-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-just-devel}"
SRC_URI[x86_64_v2_rust-just-devel.sha256sum] = "039bbfe663b357c51bcd86f9fef70e4c187661f5d82545f67f035bb09b6b498b"

URI_aarch64_just = "${EPEL_MIRROR}/aarch64/Packages/j/just-1.46.0-1.el10_2.aarch64.rpm;name=aarch64_just;unpack=0"
SRC_URI:append = " ${URI_aarch64_just}"
SRC_URI[aarch64_just.sha256sum] = "2fc4fbe890f6018f4cf58ddc47e2960d1b75ba193fb4fd5e56346de02bbd29ee"

URI_aarch64_rust-just+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-just+default-devel-1.46.0-1.el10_2.noarch.rpm;name=aarch64_rust-just+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-just+default-devel}"
SRC_URI[aarch64_rust-just+default-devel.sha256sum] = "8f28587f682f89b2a489e553f7193543214ed73f51098b3c21e17ad59e093c49"

URI_aarch64_rust-just-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-just-devel-1.46.0-1.el10_2.noarch.rpm;name=aarch64_rust-just-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-just-devel}"
SRC_URI[aarch64_rust-just-devel.sha256sum] = "b4d06f7fde5a4cacbcff7cbdf111ef948ade64e0b0b25961daa8ed76b2148e63"

RDEPENDS:just = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-just+default-devel = " \
 cargo \
 rust-just-devel \
 "
RDEPENDS:rust-just-devel = " \
 bash \
 cargo \
 rust \
 rust-ansi_term+default-devel \
 rust-blake3+default-devel \
 rust-blake3+mmap-devel \
 rust-blake3+rayon-devel \
 rust-camino+default-devel \
 rust-chrono+default-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-clap+env-devel \
 rust-clap+wrap_help-devel \
 rust-clap_mangen+default-devel \
 rust-derive-where+default-devel \
 rust-dirs+default-devel \
 rust-dotenvy+default-devel \
 rust-edit-distance+default-devel \
 rust-heck+default-devel \
 rust-is_executable+default-devel \
 rust-lexiclean+default-devel \
 rust-libc+default-devel \
 rust-nix0.30+default-devel \
 rust-nix0.30+fs-devel \
 rust-nix0.30+signal-devel \
 rust-nix0.30+user-devel \
 rust-num_cpus+default-devel \
 rust-percent-encoding+default-devel \
 rust-rand0.9+default-devel \
 rust-regex+default-devel \
 rust-rustversion+default-devel \
 rust-semver+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-serde_json+default-devel \
 rust-sha2+default-devel \
 rust-shellexpand+default-devel \
 rust-similar+default-devel \
 rust-similar+unicode-devel \
 rust-snafu+default-devel \
 rust-strum+default-devel \
 rust-strum+derive-devel \
 rust-target+default-devel \
 rust-tempfile+default-devel \
 rust-typed-arena+default-devel \
 rust-unicode-width+default-devel \
 rust-uuid+default-devel \
 rust-uuid+v4-devel \
 "
