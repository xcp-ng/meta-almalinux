# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-test-tag"
PV = "0.1.6"
PR = "1.el10_1"
PACKAGES = " \
 rust-test-tag+default-devel \
 rust-test-tag-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-test-tag-0.1.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7dfb9e32486bd33a1af5f9063be3021ea6b62210be5adbfd0b905808d91a892"

URI_x86_64_v2_rust-test-tag+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-tag+default-devel-0.1.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-tag+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-tag+default-devel}"
SRC_URI[x86_64_v2_rust-test-tag+default-devel.sha256sum] = "deb2b3a81ff4819dc06d18c5418b7f0417628f935049b6f6608f931213405ee8"

URI_x86_64_v2_rust-test-tag-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-tag-devel-0.1.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-tag-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-tag-devel}"
SRC_URI[x86_64_v2_rust-test-tag-devel.sha256sum] = "72d062023c722720c0eb59bd8a574abd02129ec5dcec004bc8d978c48f0d6e1c"

URI_aarch64_rust-test-tag+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-tag+default-devel-0.1.6-1.el10_1.noarch.rpm;name=aarch64_rust-test-tag+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-tag+default-devel}"
SRC_URI[aarch64_rust-test-tag+default-devel.sha256sum] = "55448a4bd4d441baf09b3a2e2d0d8d3e7e55a876fdae0de825297eacd3b45dd0"

URI_aarch64_rust-test-tag-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-tag-devel-0.1.6-1.el10_1.noarch.rpm;name=aarch64_rust-test-tag-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-tag-devel}"
SRC_URI[aarch64_rust-test-tag-devel.sha256sum] = "aac177354e07b7a98833796ada075e5691cb42df50f91a5441fbbab6bde72c57"

RDEPENDS:rust-test-tag+default-devel = " \
 cargo \
 rust-test-tag-devel \
 "
RDEPENDS:rust-test-tag-devel = " \
 cargo \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
