# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crc-any"
PV = "2.5.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-crc-any+alloc-devel \
 rust-crc-any+debug-helper-devel \
 rust-crc-any+default-devel \
 rust-crc-any+development-devel \
 rust-crc-any+heapless-devel \
 rust-crc-any+std-devel \
 rust-crc-any-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crc-any-2.5.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c5037a7f6eebb087830e5a021d00e17f66cf6dc8a0061775ff372a1116d6fa7f"

URI_x86_64_v2_rust-crc-any+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc-any+alloc-devel-2.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc-any+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc-any+alloc-devel}"
SRC_URI[x86_64_v2_rust-crc-any+alloc-devel.sha256sum] = "50cc4239e4bd4257d4c1d3538e812f79bdd83fbbfe14e548464632b464918d3d"

URI_x86_64_v2_rust-crc-any+debug-helper-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc-any+debug-helper-devel-2.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc-any+debug-helper-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc-any+debug-helper-devel}"
SRC_URI[x86_64_v2_rust-crc-any+debug-helper-devel.sha256sum] = "a50e5c3617fc4985f44874f13cb04da1dbd5fefecc7efe5f66976907eb9f08ad"

URI_x86_64_v2_rust-crc-any+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc-any+default-devel-2.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc-any+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc-any+default-devel}"
SRC_URI[x86_64_v2_rust-crc-any+default-devel.sha256sum] = "ece6786c9432b18e8e1a11c59538f23eef5dd56db6288e8315c374fbcedf0c03"

URI_x86_64_v2_rust-crc-any+development-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc-any+development-devel-2.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc-any+development-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc-any+development-devel}"
SRC_URI[x86_64_v2_rust-crc-any+development-devel.sha256sum] = "616959b57b148a4e32d6376068ba13bf95bb71f2d3cc977527081868067e2e14"

URI_x86_64_v2_rust-crc-any+heapless-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc-any+heapless-devel-2.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc-any+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc-any+heapless-devel}"
SRC_URI[x86_64_v2_rust-crc-any+heapless-devel.sha256sum] = "29f679b9aa4743db44be08e908508800144259ba2e73a9d5e22489516166fb6b"

URI_x86_64_v2_rust-crc-any+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc-any+std-devel-2.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc-any+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc-any+std-devel}"
SRC_URI[x86_64_v2_rust-crc-any+std-devel.sha256sum] = "fb84f80e40d536e8311dddd2de34639bd1fc9fac6a84f817b22058a5003a2f25"

URI_x86_64_v2_rust-crc-any-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc-any-devel-2.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc-any-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc-any-devel}"
SRC_URI[x86_64_v2_rust-crc-any-devel.sha256sum] = "e966fbd1b62260a04e5e06ef6733f2a3f7acde1720475edd7a01ef151db1a7c7"

URI_aarch64_rust-crc-any+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc-any+alloc-devel-2.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-crc-any+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc-any+alloc-devel}"
SRC_URI[aarch64_rust-crc-any+alloc-devel.sha256sum] = "44b71513d59a3ecb238875c8951d073fac4c78ee3f1a4982a3d7390bfbf9e807"

URI_aarch64_rust-crc-any+debug-helper-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc-any+debug-helper-devel-2.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-crc-any+debug-helper-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc-any+debug-helper-devel}"
SRC_URI[aarch64_rust-crc-any+debug-helper-devel.sha256sum] = "c5424c85048ca4c0020c0454055f34cc4604d4b0d1ef6257bc98d115f36b7439"

URI_aarch64_rust-crc-any+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc-any+default-devel-2.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-crc-any+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc-any+default-devel}"
SRC_URI[aarch64_rust-crc-any+default-devel.sha256sum] = "2658c17804eb16740172138b689686fcbc62816882f6dc9f48926837e70270b7"

URI_aarch64_rust-crc-any+development-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc-any+development-devel-2.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-crc-any+development-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc-any+development-devel}"
SRC_URI[aarch64_rust-crc-any+development-devel.sha256sum] = "201897f869ba264b65af820d3cbe057a1f6d165fdc7c3826ae77a38aaf98463a"

URI_aarch64_rust-crc-any+heapless-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc-any+heapless-devel-2.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-crc-any+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc-any+heapless-devel}"
SRC_URI[aarch64_rust-crc-any+heapless-devel.sha256sum] = "0c6c1d820c3dfbe8fe5314e57bd72eb5b12a0aa8cd386f4fd8654bcbfe495a63"

URI_aarch64_rust-crc-any+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc-any+std-devel-2.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-crc-any+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc-any+std-devel}"
SRC_URI[aarch64_rust-crc-any+std-devel.sha256sum] = "adbea5a7c49cffe4127095dbd5a874192318a391aa053f6570a08737fbdb0149"

URI_aarch64_rust-crc-any-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc-any-devel-2.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-crc-any-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc-any-devel}"
SRC_URI[aarch64_rust-crc-any-devel.sha256sum] = "eddbcdf86bd0c561060dd76f64bcfbf5b5215d878aedad65cb577e71f66240e5"

RDEPENDS:rust-crc-any+alloc-devel = " \
 cargo \
 rust-crc-any+debug-helper-devel \
 rust-crc-any-devel \
 "
RDEPENDS:rust-crc-any+debug-helper-devel = " \
 cargo \
 rust-crc-any-devel \
 rust-debug-helper+default-devel \
 "
RDEPENDS:rust-crc-any+default-devel = " \
 cargo \
 rust-crc-any+alloc-devel \
 rust-crc-any-devel \
 "
RDEPENDS:rust-crc-any+development-devel = " \
 cargo \
 rust-crc-any+std-devel \
 rust-crc-any-devel \
 "
RDEPENDS:rust-crc-any+heapless-devel = " \
 cargo \
 rust-crc-any-devel \
 rust-heapless0.8+default-devel \
 "
RDEPENDS:rust-crc-any+std-devel = " \
 cargo \
 rust-crc-any-devel \
 "
RDEPENDS:rust-crc-any-devel = " \
 cargo \
 rust \
 "
