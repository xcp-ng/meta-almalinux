# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-GLURaw"
PV = "2.0.0.5"
PR = "9.el10_0"
PACKAGES = " \
 ghc-GLURaw \
 ghc-GLURaw-devel \
 ghc-GLURaw-doc \
 ghc-GLURaw-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-GLURaw-2.0.0.5-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f66aaaa742c71c3cda4569a5152604ec0147bdb30365351d043672195c17e468"

URI_x86_64_v2_ghc-GLURaw = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-GLURaw-2.0.0.5-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-GLURaw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-GLURaw}"
SRC_URI[x86_64_v2_ghc-GLURaw.sha256sum] = "ca02fc6bac1816452f058685e8a189f7342a0c902a58c84c561a961b62038539"

URI_x86_64_v2_ghc-GLURaw-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-GLURaw-devel-2.0.0.5-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-GLURaw-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-GLURaw-devel}"
SRC_URI[x86_64_v2_ghc-GLURaw-devel.sha256sum] = "0d26788e8ae9b2febb1238c656e07cc82a7842488ff75573be8a8a0a52f755e2"

URI_x86_64_v2_ghc-GLURaw-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-GLURaw-doc-2.0.0.5-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-GLURaw-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-GLURaw-doc}"
SRC_URI[x86_64_v2_ghc-GLURaw-doc.sha256sum] = "fc5bbeeda1d569d5b2c4122c09c9ed8c09dddc09a60b1087d0c1047be045c0ab"

URI_x86_64_v2_ghc-GLURaw-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-GLURaw-prof-2.0.0.5-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-GLURaw-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-GLURaw-prof}"
SRC_URI[x86_64_v2_ghc-GLURaw-prof.sha256sum] = "e926abfc1bb7d53cc9547d301b77d6a97f3b3654d4f3a75f83e8a5b5efa34954"

URI_aarch64_ghc-GLURaw = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-GLURaw-2.0.0.5-9.el10_0.aarch64.rpm;name=aarch64_ghc-GLURaw;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-GLURaw}"
SRC_URI[aarch64_ghc-GLURaw.sha256sum] = "7010d1b6a5bac8667cf2bfa1cc646ba83cea7a574f6324bef8118033c9390098"

URI_aarch64_ghc-GLURaw-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-GLURaw-devel-2.0.0.5-9.el10_0.aarch64.rpm;name=aarch64_ghc-GLURaw-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-GLURaw-devel}"
SRC_URI[aarch64_ghc-GLURaw-devel.sha256sum] = "2cbc84a1d3630c7cd1c36fe0b030679935ea4f0e908f079d7176727ce3d7f918"

URI_aarch64_ghc-GLURaw-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-GLURaw-doc-2.0.0.5-9.el10_0.noarch.rpm;name=aarch64_ghc-GLURaw-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-GLURaw-doc}"
SRC_URI[aarch64_ghc-GLURaw-doc.sha256sum] = "c10f233f384ac133ca7bdfbf98c5530e1a9bc9bbf608fb4319d23c3b7abc1556"

URI_aarch64_ghc-GLURaw-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-GLURaw-prof-2.0.0.5-9.el10_0.aarch64.rpm;name=aarch64_ghc-GLURaw-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-GLURaw-prof}"
SRC_URI[aarch64_ghc-GLURaw-prof.sha256sum] = "c1330c7f0b32d22ec60bf8ceb14ecab094caf5e7132b1da63ee7c8547b04498f"

RDEPENDS:ghc-GLURaw = " \
 ghc-OpenGLRaw \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-fixed \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-half \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 libglvnd-glx \
 mesa-libGLU \
 "
RDEPENDS:ghc-GLURaw-devel = " \
 ghc-GLURaw \
 ghc-OpenGLRaw-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-transformers-devel \
 mesa-libGLU-devel \
 "
RDEPENDS:ghc-GLURaw-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-GLURaw-prof = " \
 ghc-GLURaw-devel \
 ghc-OpenGLRaw-prof \
 ghc-base-prof \
 ghc-transformers-prof \
 "
