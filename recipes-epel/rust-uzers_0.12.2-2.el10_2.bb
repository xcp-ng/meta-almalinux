# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uzers"
PV = "0.12.2"
PR = "2.el10_2"
PACKAGES = " \
 rust-uzers+cache-devel \
 rust-uzers+default-devel \
 rust-uzers+log-devel \
 rust-uzers+logging-devel \
 rust-uzers+mock-devel \
 rust-uzers+test-integration-devel \
 rust-uzers-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uzers-0.12.2-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0340c0cde3f87c371036814e166df43399eaf6522a4a2c4d77fc357b57b09e0"

URI_x86_64_v2_rust-uzers+cache-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uzers+cache-devel-0.12.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uzers+cache-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uzers+cache-devel}"
SRC_URI[x86_64_v2_rust-uzers+cache-devel.sha256sum] = "f1ad16cfb45eed245525ca89c135eed51b488f49231ed25363aa3f69e15b5616"

URI_x86_64_v2_rust-uzers+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uzers+default-devel-0.12.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uzers+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uzers+default-devel}"
SRC_URI[x86_64_v2_rust-uzers+default-devel.sha256sum] = "cc0aa91aa058b0ed3e8cc32d3c6384aa02425ea6004c8c6ff2261565a0720953"

URI_x86_64_v2_rust-uzers+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uzers+log-devel-0.12.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uzers+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uzers+log-devel}"
SRC_URI[x86_64_v2_rust-uzers+log-devel.sha256sum] = "3079257956cf8ec8903f0bc5fea71d981311fad30a55c8f2d6ad73e325d74f34"

URI_x86_64_v2_rust-uzers+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uzers+logging-devel-0.12.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uzers+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uzers+logging-devel}"
SRC_URI[x86_64_v2_rust-uzers+logging-devel.sha256sum] = "50eceb440166f4b2c3ab9eebd1c7ff466a668e94341d5b7f83bc7589a1cda501"

URI_x86_64_v2_rust-uzers+mock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uzers+mock-devel-0.12.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uzers+mock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uzers+mock-devel}"
SRC_URI[x86_64_v2_rust-uzers+mock-devel.sha256sum] = "5e6e15454d54705dca2ddfa23d2909d1a5463a18920cd011ab8b87d99b8de191"

URI_x86_64_v2_rust-uzers+test-integration-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uzers+test-integration-devel-0.12.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uzers+test-integration-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uzers+test-integration-devel}"
SRC_URI[x86_64_v2_rust-uzers+test-integration-devel.sha256sum] = "703d144b5ac4b8072ce6141245f9f6d1b819ad89b8f895485b4ad7d92f00ce95"

URI_x86_64_v2_rust-uzers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uzers-devel-0.12.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uzers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uzers-devel}"
SRC_URI[x86_64_v2_rust-uzers-devel.sha256sum] = "5de2cd00f5bec58b8160f03956bde58befd47063f149c53ed3662ca3b75c6324"

URI_aarch64_rust-uzers+cache-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uzers+cache-devel-0.12.2-2.el10_2.noarch.rpm;name=aarch64_rust-uzers+cache-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uzers+cache-devel}"
SRC_URI[aarch64_rust-uzers+cache-devel.sha256sum] = "98793e84b519890bec6a3d3cc1ebd32ce7c294ef466a60e6ed9fdd52ed3a64f8"

URI_aarch64_rust-uzers+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uzers+default-devel-0.12.2-2.el10_2.noarch.rpm;name=aarch64_rust-uzers+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uzers+default-devel}"
SRC_URI[aarch64_rust-uzers+default-devel.sha256sum] = "59d921ccdb2fe4684a6211f9b44cb061eed93f440d0238ff948a0f04756d0993"

URI_aarch64_rust-uzers+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uzers+log-devel-0.12.2-2.el10_2.noarch.rpm;name=aarch64_rust-uzers+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uzers+log-devel}"
SRC_URI[aarch64_rust-uzers+log-devel.sha256sum] = "8f82bfcff3fda9f9d3e51c53eaf5634e85c23a94c84507a8d068c9b895dcd43c"

URI_aarch64_rust-uzers+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uzers+logging-devel-0.12.2-2.el10_2.noarch.rpm;name=aarch64_rust-uzers+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uzers+logging-devel}"
SRC_URI[aarch64_rust-uzers+logging-devel.sha256sum] = "c9f37611945a9f9f87adbc38245c0e498dd5ae1fa6e647fcddd88d139857c27e"

URI_aarch64_rust-uzers+mock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uzers+mock-devel-0.12.2-2.el10_2.noarch.rpm;name=aarch64_rust-uzers+mock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uzers+mock-devel}"
SRC_URI[aarch64_rust-uzers+mock-devel.sha256sum] = "7ca95bd04a8e255c0d9ede10025104ef049b4c6fd0bf857cceff34f6f07edea2"

URI_aarch64_rust-uzers+test-integration-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uzers+test-integration-devel-0.12.2-2.el10_2.noarch.rpm;name=aarch64_rust-uzers+test-integration-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uzers+test-integration-devel}"
SRC_URI[aarch64_rust-uzers+test-integration-devel.sha256sum] = "9854bebca4bb6af499f677631cb80681364a6c60c64f098c5c0d7f92087b0515"

URI_aarch64_rust-uzers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uzers-devel-0.12.2-2.el10_2.noarch.rpm;name=aarch64_rust-uzers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uzers-devel}"
SRC_URI[aarch64_rust-uzers-devel.sha256sum] = "e8d017722b46126d43c29e62c5b5e2c8dbb741740367be015d6223300d6928bb"

RDEPENDS:rust-uzers+cache-devel = " \
 cargo \
 rust-uzers-devel \
 "
RDEPENDS:rust-uzers+default-devel = " \
 cargo \
 rust-uzers+cache-devel \
 rust-uzers+logging-devel \
 rust-uzers+mock-devel \
 rust-uzers-devel \
 "
RDEPENDS:rust-uzers+log-devel = " \
 cargo \
 rust-log-devel \
 rust-uzers-devel \
 "
RDEPENDS:rust-uzers+logging-devel = " \
 cargo \
 rust-uzers+log-devel \
 rust-uzers-devel \
 "
RDEPENDS:rust-uzers+mock-devel = " \
 cargo \
 rust-uzers-devel \
 "
RDEPENDS:rust-uzers+test-integration-devel = " \
 cargo \
 rust-uzers-devel \
 "
RDEPENDS:rust-uzers-devel = " \
 cargo \
 rust-libc+default-devel \
 "
