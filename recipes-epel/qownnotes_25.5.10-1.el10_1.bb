# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qownnotes"
PV = "25.5.10"
PR = "1.el10_1"
PACKAGES = " \
 qownnotes \
 qownnotes-translations \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qownnotes-25.5.10-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0253f74e59599dfa49f9e81a0ceae84cf08790940ae0b4792915bc605d24abd"

URI_x86_64_v2_qownnotes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qownnotes-25.5.10-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qownnotes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qownnotes}"
SRC_URI[x86_64_v2_qownnotes.sha256sum] = "16aa0b72ee7e2dd2b1298de874add359ef9758d0e3308b5b3cfc27f70708537a"

URI_x86_64_v2_qownnotes-translations = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qownnotes-translations-25.5.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qownnotes-translations;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qownnotes-translations}"
SRC_URI[x86_64_v2_qownnotes-translations.sha256sum] = "3475e3f376ce7381f1bd16ad9807f311c086422fb29cd2de96ef1bf84d9f73a3"

URI_aarch64_qownnotes = "${EPEL_MIRROR}/aarch64/Packages/q/qownnotes-25.5.10-1.el10_1.aarch64.rpm;name=aarch64_qownnotes;unpack=0"
SRC_URI:append = " ${URI_aarch64_qownnotes}"
SRC_URI[aarch64_qownnotes.sha256sum] = "1a4c87233a6b2e25a19d0ce4cad4c3f48e9815cc7b8fe70f93b5fc6be39d17d5"

URI_aarch64_qownnotes-translations = "${EPEL_MIRROR}/aarch64/Packages/q/qownnotes-translations-25.5.10-1.el10_1.noarch.rpm;name=aarch64_qownnotes-translations;unpack=0"
SRC_URI:append = " ${URI_aarch64_qownnotes-translations}"
SRC_URI[aarch64_qownnotes-translations.sha256sum] = "22a1c51b8d4e9996495f92bef8708bb93df8b5f9c890c154c02921389600e959"

RDEPENDS:qownnotes = " \
 glibc \
 hicolor-icon-theme \
 libX11 \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtwebsockets \
 qt5-qtx11extras \
 "
RDEPENDS:qownnotes-translations = " \
 qownnotes \
 "
