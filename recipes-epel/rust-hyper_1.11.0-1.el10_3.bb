# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hyper"
PV = "1.11.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-hyper+capi-devel \
 rust-hyper+client-devel \
 rust-hyper+default-devel \
 rust-hyper+ffi-devel \
 rust-hyper+full-devel \
 rust-hyper+http1-devel \
 rust-hyper+http2-devel \
 rust-hyper+server-devel \
 rust-hyper+tracing-devel \
 rust-hyper-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hyper-1.11.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8fa142c57995c1aa41baede0136405053f41bf36b93d2f64be9cf364fa1fc8fd"

URI_x86_64_v2_rust-hyper+capi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+capi-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+capi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+capi-devel}"
SRC_URI[x86_64_v2_rust-hyper+capi-devel.sha256sum] = "fdf63e9bf646b2ec40ea898cd274b604e48e18556e93143ef4be3b470385ee0e"

URI_x86_64_v2_rust-hyper+client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+client-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+client-devel}"
SRC_URI[x86_64_v2_rust-hyper+client-devel.sha256sum] = "6cf5dd44b1e02a248c070706a38acc4c55df893c9ef8a1648356f26a5e09ce13"

URI_x86_64_v2_rust-hyper+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+default-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+default-devel}"
SRC_URI[x86_64_v2_rust-hyper+default-devel.sha256sum] = "3856a24643a116403cab3afc83aebc46381e27e1dce1bf2880bc2cc9d85af4c4"

URI_x86_64_v2_rust-hyper+ffi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+ffi-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+ffi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+ffi-devel}"
SRC_URI[x86_64_v2_rust-hyper+ffi-devel.sha256sum] = "4df77ab0018ff86f8a85859d63d3093897fe94371c2eee7302d71d63993939c7"

URI_x86_64_v2_rust-hyper+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+full-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+full-devel}"
SRC_URI[x86_64_v2_rust-hyper+full-devel.sha256sum] = "bcbcb5b9041571cead3c1b4d143c926150b3a36c2ff8f350d240dd2cb4467f24"

URI_x86_64_v2_rust-hyper+http1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+http1-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+http1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+http1-devel}"
SRC_URI[x86_64_v2_rust-hyper+http1-devel.sha256sum] = "d24e32446b9ae5ecb7e855de9414422e311f460bb60df0c620c5794caa27d0ce"

URI_x86_64_v2_rust-hyper+http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+http2-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+http2-devel}"
SRC_URI[x86_64_v2_rust-hyper+http2-devel.sha256sum] = "0a10eb6fda2b38b40465a91255a806f6a1edc32e48ce1a77d77b53559923b506"

URI_x86_64_v2_rust-hyper+server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+server-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+server-devel}"
SRC_URI[x86_64_v2_rust-hyper+server-devel.sha256sum] = "31653e668ed013cec6e4cd4474b1ff5f7298f9e22599d95331b5ea1831bad9d1"

URI_x86_64_v2_rust-hyper+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+tracing-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+tracing-devel}"
SRC_URI[x86_64_v2_rust-hyper+tracing-devel.sha256sum] = "bdf7adfe2ba0a57d9958df114b6f12046cd09ecda298215e322598fba2c9d97a"

URI_x86_64_v2_rust-hyper-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-devel}"
SRC_URI[x86_64_v2_rust-hyper-devel.sha256sum] = "936c5a62d4bb21686b755ed77469f212dab22fd8b86865302dbcd1add99e7eb6"

URI_aarch64_rust-hyper+capi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+capi-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-hyper+capi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+capi-devel}"
SRC_URI[aarch64_rust-hyper+capi-devel.sha256sum] = "302153970aaeeabc35a77364ec49663d3d7882a57297100157d678696a85f036"

URI_aarch64_rust-hyper+client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+client-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-hyper+client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+client-devel}"
SRC_URI[aarch64_rust-hyper+client-devel.sha256sum] = "f87b1bb0a922191bef5fab046f2b376fcc17628bcb44973b5c6a86d832927cfe"

URI_aarch64_rust-hyper+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+default-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-hyper+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+default-devel}"
SRC_URI[aarch64_rust-hyper+default-devel.sha256sum] = "bb270e75055650ffa58d146a3a5a94732e1241db6746cc00968ee40f0b5ea731"

URI_aarch64_rust-hyper+ffi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+ffi-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-hyper+ffi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+ffi-devel}"
SRC_URI[aarch64_rust-hyper+ffi-devel.sha256sum] = "adce19df5598c17befeecbc42aea9c80f90474ebb7805d2708710c7939fa0492"

URI_aarch64_rust-hyper+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+full-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-hyper+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+full-devel}"
SRC_URI[aarch64_rust-hyper+full-devel.sha256sum] = "4a4ed400d9673557eca9cf45f8cad348feecede4f31b6124342bb543f8acc011"

URI_aarch64_rust-hyper+http1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+http1-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-hyper+http1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+http1-devel}"
SRC_URI[aarch64_rust-hyper+http1-devel.sha256sum] = "02fd0de0b41a3fdc9cb1df870105d5177fa1e7c5781eddb44e9a945433bb1ed0"

URI_aarch64_rust-hyper+http2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+http2-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-hyper+http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+http2-devel}"
SRC_URI[aarch64_rust-hyper+http2-devel.sha256sum] = "6e0d8192c1bab9201006cd083489efe10e78c236e406e5633de776bd9e35670f"

URI_aarch64_rust-hyper+server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+server-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-hyper+server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+server-devel}"
SRC_URI[aarch64_rust-hyper+server-devel.sha256sum] = "30473b51a27cacccf18467199e17b2d63db80c2c821d966ed858e472753ee41a"

URI_aarch64_rust-hyper+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+tracing-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-hyper+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+tracing-devel}"
SRC_URI[aarch64_rust-hyper+tracing-devel.sha256sum] = "2e63bd0c47ab324c4d425dde7c936380439855f9119dee059754583d72d142a5"

URI_aarch64_rust-hyper-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-devel}"
SRC_URI[aarch64_rust-hyper-devel.sha256sum] = "e39964e17930a1934d04d0918cf488d1f20d1d438b440dc4aed9e4ea77a34620"

RDEPENDS:rust-hyper+capi-devel = " \
 cargo \
 rust-hyper-devel \
 "
RDEPENDS:rust-hyper+client-devel = " \
 cargo \
 rust-hyper-devel \
 rust-pin-project-lite+default-devel \
 rust-smallvec+const_generics-devel \
 rust-smallvec+const_new-devel \
 rust-smallvec+default-devel \
 rust-want+default-devel \
 "
RDEPENDS:rust-hyper+default-devel = " \
 cargo \
 rust-hyper-devel \
 "
RDEPENDS:rust-hyper+ffi-devel = " \
 cargo \
 rust-futures-util+alloc-devel \
 rust-futures-util-devel \
 rust-http-body-util+default-devel \
 rust-hyper-devel \
 "
RDEPENDS:rust-hyper+full-devel = " \
 cargo \
 rust-hyper+client-devel \
 rust-hyper+http1-devel \
 rust-hyper+http2-devel \
 rust-hyper+server-devel \
 rust-hyper-devel \
 "
RDEPENDS:rust-hyper+http1-devel = " \
 cargo \
 rust-atomic-waker+default-devel \
 rust-futures-channel+default-devel \
 rust-futures-core+default-devel \
 rust-httparse+default-devel \
 rust-hyper-devel \
 rust-itoa+default-devel \
 "
RDEPENDS:rust-hyper+http2-devel = " \
 cargo \
 rust-atomic-waker+default-devel \
 rust-futures-channel+default-devel \
 rust-futures-core+default-devel \
 rust-h2+default-devel \
 rust-hyper-devel \
 "
RDEPENDS:rust-hyper+server-devel = " \
 cargo \
 rust-httpdate+default-devel \
 rust-hyper-devel \
 rust-pin-project-lite+default-devel \
 rust-smallvec+const_generics-devel \
 rust-smallvec+const_new-devel \
 rust-smallvec+default-devel \
 "
RDEPENDS:rust-hyper+tracing-devel = " \
 cargo \
 rust-hyper-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-hyper-devel = " \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-http+default-devel \
 rust-http-body+default-devel \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 "
