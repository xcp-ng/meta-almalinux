# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-core"
PV = "0.21.1"
PR = "1.el10_2"
PACKAGES = " \
 python3-colcon-core \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-core-0.21.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b52a237496fc9f43a8f9dcd101dfb0d0bee0b06fe816d82420e4a4c1227c0e12"

URI_x86_64_v2_python3-colcon-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-core-0.21.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-core}"
SRC_URI[x86_64_v2_python3-colcon-core.sha256sum] = "5e35ae0781aaca770306474bb05d6788e2e0652dff9c6d4cc6de8a0a85732dc7"

URI_aarch64_python3-colcon-core = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-core-0.21.1-1.el10_2.noarch.rpm;name=aarch64_python3-colcon-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-core}"
SRC_URI[aarch64_python3-colcon-core.sha256sum] = "e5fff4d675b207aed86999f9955d3da4d17e496f9343e137a9d64bd1ed9e1147"

RDEPENDS:python3-colcon-core = " \
 python3 \
 python3-distlib \
 python3-empy \
 python3-packaging \
 python3-setuptools \
 "
