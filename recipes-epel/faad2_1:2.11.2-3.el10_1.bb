# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "faad2"
PE = "1"
PV = "2.11.2"
PR = "3.el10_1"
PACKAGES = " \
 faad2 \
 faad2-devel \
 faad2-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/faad2-2.11.2-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ebc8a48c87d1545a8efff0d030eaf96a6408214973acc15d7a8ad144aa19f76"

URI_x86_64_v2_faad2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/faad2-2.11.2-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_faad2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_faad2}"
SRC_URI[x86_64_v2_faad2.sha256sum] = "b9aeae9ee408954a994573a7e7d2988ef31677689e63b64f2cbc2a44d11ab9ef"

URI_x86_64_v2_faad2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/faad2-devel-2.11.2-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_faad2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_faad2-devel}"
SRC_URI[x86_64_v2_faad2-devel.sha256sum] = "479aaf9f0c9e5e712f4398b4790b1a450c503a990aa0e10f6788ffa5631f65ae"

URI_x86_64_v2_faad2-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/faad2-libs-2.11.2-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_faad2-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_faad2-libs}"
SRC_URI[x86_64_v2_faad2-libs.sha256sum] = "085a9b93e290d29c96b648ec8cc18bda0df0ab3e79100f4c6ce30595b55902c4"

URI_aarch64_faad2 = "${EPEL_MIRROR}/aarch64/Packages/f/faad2-2.11.2-3.el10_1.aarch64.rpm;name=aarch64_faad2;unpack=0"
SRC_URI:append = " ${URI_aarch64_faad2}"
SRC_URI[aarch64_faad2.sha256sum] = "92848ab1332cff321e277942beea5f7049c21ece0e9ef93c344020bde57a56dd"

URI_aarch64_faad2-devel = "${EPEL_MIRROR}/aarch64/Packages/f/faad2-devel-2.11.2-3.el10_1.aarch64.rpm;name=aarch64_faad2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_faad2-devel}"
SRC_URI[aarch64_faad2-devel.sha256sum] = "c69dcd586bfaa0369f7cdae562b571f54298e84ca97dff9b649eab01d4047b3f"

URI_aarch64_faad2-libs = "${EPEL_MIRROR}/aarch64/Packages/f/faad2-libs-2.11.2-3.el10_1.aarch64.rpm;name=aarch64_faad2-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_faad2-libs}"
SRC_URI[aarch64_faad2-libs.sha256sum] = "4ba6a060bfd5d9c9aa7e8fe72d59a76807a98045950d10e093a5a1e62b7ce053"

RDEPENDS:faad2 = " \
 faad2-libs \
 glibc \
 "
RDEPENDS:faad2-devel = " \
 faad2-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:faad2-libs = " \
 glibc \
 "
