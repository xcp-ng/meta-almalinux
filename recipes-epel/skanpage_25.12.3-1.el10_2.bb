# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "skanpage"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 skanpage \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/skanpage-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "daac257950645b8b975a36fb235a1262e85fd8e0ac75d48551550b22619147ee"

URI_x86_64_v2_skanpage = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/skanpage-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_skanpage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_skanpage}"
SRC_URI[x86_64_v2_skanpage.sha256sum] = "414406fa4ed0171cdba74127faad6a953b45c3a3fbbe65d32725c582e87ca60d"

URI_aarch64_skanpage = "${EPEL_MIRROR}/aarch64/Packages/s/skanpage-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_skanpage;unpack=0"
SRC_URI:append = " ${URI_aarch64_skanpage}"
SRC_URI[aarch64_skanpage.sha256sum] = "1fd0074dbf9816ba2fa6bcf84722a9616280a7f2fbcb74e5e1046ea2e7cf5d65"

RDEPENDS:skanpage = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kirigami \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kquickimageeditor-qt6 \
 ksanecore \
 leptonica \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtpdf \
 tesseract \
 "
