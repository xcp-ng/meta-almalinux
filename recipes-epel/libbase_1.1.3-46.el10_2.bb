# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libbase"
PV = "1.1.3"
PR = "46.el10_2"
PACKAGES = " \
 libbase \
 libbase-javadoc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libbase-1.1.3-46.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6a4b2c83d71445745b2780f1baa6f8b6c61470227775c33fe963e6e9b37910d"

URI_x86_64_v2_libbase = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbase-1.1.3-46.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_libbase;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbase}"
SRC_URI[x86_64_v2_libbase.sha256sum] = "a2bdb959d8c7241c97f75c91d5ff3e979ed351ba81ab5a2e60a0e339e96839c2"

URI_x86_64_v2_libbase-javadoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbase-javadoc-1.1.3-46.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_libbase-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbase-javadoc}"
SRC_URI[x86_64_v2_libbase-javadoc.sha256sum] = "96cf8057170366c1fdf6f5429af2825569404dfae10d1221490c9c17e7a735ae"

URI_aarch64_libbase = "${EPEL_MIRROR}/aarch64/Packages/l/libbase-1.1.3-46.el10_2.noarch.rpm;name=aarch64_libbase;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbase}"
SRC_URI[aarch64_libbase.sha256sum] = "82f2f84c4f0d9dcebdbd47d16893bf5f76c236dcbfdd36e52380a686052a30bc"

URI_aarch64_libbase-javadoc = "${EPEL_MIRROR}/aarch64/Packages/l/libbase-javadoc-1.1.3-46.el10_2.noarch.rpm;name=aarch64_libbase-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbase-javadoc}"
SRC_URI[aarch64_libbase-javadoc.sha256sum] = "3c698360b32cfcbad5877abf53d2cc05860f79041c2a7478ca54022eacc4c613"

RDEPENDS:libbase = " \
 java-21-openjdk-headless \
 javapackages-tools \
 "
RDEPENDS:libbase-javadoc = " \
 javapackages-tools \
 libbase \
 "
