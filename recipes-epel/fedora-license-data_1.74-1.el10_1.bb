# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fedora-license-data"
PV = "1.74"
PR = "1.el10_1"
PACKAGES = " \
 fedora-license-data \
 rpmlint-fedora-license-data \
 rpmlint-fedora-license-data-legacy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fedora-license-data-1.74-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b7d3b0243c632cac6eb28d0489d3ca62627c29025657ec93980ce9c53f2909d7"

URI_x86_64_v2_fedora-license-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedora-license-data-1.74-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_fedora-license-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fedora-license-data}"
SRC_URI[x86_64_v2_fedora-license-data.sha256sum] = "b278a47851b3eb4038bbe312b75c90228aa58a044367c32faddd54d0091595c1"

URI_x86_64_v2_rpmlint-fedora-license-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpmlint-fedora-license-data-1.74-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rpmlint-fedora-license-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpmlint-fedora-license-data}"
SRC_URI[x86_64_v2_rpmlint-fedora-license-data.sha256sum] = "c15a31711fd091dd27d5ab2ec0e0768bbf74bf81a4e58544d3db6da6d00c4778"

URI_x86_64_v2_rpmlint-fedora-license-data-legacy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpmlint-fedora-license-data-legacy-1.74-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rpmlint-fedora-license-data-legacy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpmlint-fedora-license-data-legacy}"
SRC_URI[x86_64_v2_rpmlint-fedora-license-data-legacy.sha256sum] = "c7bd520833dbf8ec95934b5704ecf95ee202281be976af747bfa20edd4566cfe"

URI_aarch64_fedora-license-data = "${EPEL_MIRROR}/aarch64/Packages/f/fedora-license-data-1.74-1.el10_1.noarch.rpm;name=aarch64_fedora-license-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_fedora-license-data}"
SRC_URI[aarch64_fedora-license-data.sha256sum] = "5b5621d8b287b6fbdfa22646ac0c098e925a951ad327a1a34351001e8c561eb4"

URI_aarch64_rpmlint-fedora-license-data = "${EPEL_MIRROR}/aarch64/Packages/r/rpmlint-fedora-license-data-1.74-1.el10_1.noarch.rpm;name=aarch64_rpmlint-fedora-license-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpmlint-fedora-license-data}"
SRC_URI[aarch64_rpmlint-fedora-license-data.sha256sum] = "9942162d12c74406bd730a9d0cc0eacce9b3bdc6f3cdfb673a2fc43e6c1ec98a"

URI_aarch64_rpmlint-fedora-license-data-legacy = "${EPEL_MIRROR}/aarch64/Packages/r/rpmlint-fedora-license-data-legacy-1.74-1.el10_1.noarch.rpm;name=aarch64_rpmlint-fedora-license-data-legacy;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpmlint-fedora-license-data-legacy}"
SRC_URI[aarch64_rpmlint-fedora-license-data-legacy.sha256sum] = "9f5e7109fe677dc4f8c1c55403327a962f330e8992205ac19a257cd15786966c"

RDEPENDS:fedora-license-data = " \
 "
RDEPENDS:rpmlint-fedora-license-data = " \
 rpmlint \
 "
RDEPENDS:rpmlint-fedora-license-data-legacy = " \
 rpmlint \
 "
