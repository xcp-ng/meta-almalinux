# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "foosnapper"
PV = "1.5"
PR = "1.el10_3"
PACKAGES = " \
 foosnapper \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/foosnapper-1.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8af79e5d9df42947f7ffc45753425549bfd38d9e2fe348ba1f0e5964904cf086"

URI_x86_64_v2_foosnapper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/foosnapper-1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_foosnapper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_foosnapper}"
SRC_URI[x86_64_v2_foosnapper.sha256sum] = "ac52547459a77778922093b926b6c3b0348dda712d0a184b9e44c76b69376787"

URI_aarch64_foosnapper = "${EPEL_MIRROR}/aarch64/Packages/f/foosnapper-1.5-1.el10_3.noarch.rpm;name=aarch64_foosnapper;unpack=0"
SRC_URI:append = " ${URI_aarch64_foosnapper}"
SRC_URI[aarch64_foosnapper.sha256sum] = "413b8941735bb94a1d482804f1078c50c039f8d6e2ad08cbff83055b792e64ab"

RDEPENDS:foosnapper = " \
 bash \
 python3 \
 systemd \
 "
