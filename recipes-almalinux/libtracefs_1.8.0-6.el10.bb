# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libtracefs"
PV = "1.8.0"
PR = "6.el10"
PACKAGES = " \
 libtracefs \
 libtracefs-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libtracefs-1.8.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a2d3a2b1af65611282795e1f638d9f155084793582a990aeebe182f502575689"

URI_x86_64_v2_libtracefs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libtracefs-1.8.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_libtracefs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtracefs}"
SRC_URI[x86_64_v2_libtracefs.sha256sum] = "40958664f7b1b62896aabd3582ea0c309076bc9d2d67ce96e51835763dccf95f"

URI_x86_64_v2_libtracefs-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libtracefs-devel-1.8.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_libtracefs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtracefs-devel}"
SRC_URI[x86_64_v2_libtracefs-devel.sha256sum] = "74669190b29ab9101aeb5f5528a8466f07b4bf25b239517d85103fcbbea6fce9"

URI_aarch64_libtracefs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libtracefs-1.8.0-6.el10.aarch64.rpm;name=aarch64_libtracefs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtracefs}"
SRC_URI[aarch64_libtracefs.sha256sum] = "0d2811c7237cdff97bb7d67c4b38bba6c5171f47208adc58292b590f4baed4f9"

URI_aarch64_libtracefs-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libtracefs-devel-1.8.0-6.el10.aarch64.rpm;name=aarch64_libtracefs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtracefs-devel}"
SRC_URI[aarch64_libtracefs-devel.sha256sum] = "a86b3a80b327b97387031050111cd7f461a45f1c950a6a7c513a90e1272ac753"

RDEPENDS:libtracefs = " \
 glibc \
 libtraceevent \
 "
RDEPENDS:libtracefs-devel = " \
 libtraceevent-devel \
 libtracefs \
 pkgconf-pkg-config \
 "
