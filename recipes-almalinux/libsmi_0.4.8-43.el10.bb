# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsmi"
PV = "0.4.8"
PR = "43.el10"
PACKAGES = " \
 libsmi \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libsmi-0.4.8-43.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e5323dd9483f581fdfd799bac7b946ca01568d887c78208284e2ef8f81abe871"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsmi-0.4.8-43.el10.x86_64_v2.rpm;name=x86_64_v2_libsmi;unpack=0"
SRC_URI[x86_64_v2_libsmi.sha256sum] = "9b007e53df94dcdfa3a1b15c9a3dc7323bbe34bd2c980bf5a1611dbc6ab4a87b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsmi-0.4.8-43.el10.aarch64.rpm;name=aarch64_libsmi;unpack=0"
SRC_URI[aarch64_libsmi.sha256sum] = "d211e3d1acaacf794cd7a0876e05acbea0248d7b1ef4667c85db39f42fb76f31"

RDEPENDS:libsmi = " \
 bash \
 gawk \
 glibc \
 wget \
 "
