# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gstreamer1-plugins-good"
PV = "1.26.7"
PR = "2.el10_2.5"
PACKAGES = " \
 gstreamer1-plugins-good \
 gstreamer1-plugins-good-gtk \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gstreamer1-plugins-good-1.26.7-2.el10_2.5.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e930c9df8ea5c05d63abd3e269982668b449409f3371c70754c79f99c2a83dd"

URI_x86_64_v2_gstreamer1-plugins-good = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-good-1.26.7-2.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-good;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-good}"
SRC_URI[x86_64_v2_gstreamer1-plugins-good.sha256sum] = "00c3bfd4685ae9e7fceea6d2dd9848d68719acce2956c6899f7ab06a2cbfd7cc"

URI_x86_64_v2_gstreamer1-plugins-good-gtk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-good-gtk-1.26.7-2.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-good-gtk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-good-gtk}"
SRC_URI[x86_64_v2_gstreamer1-plugins-good-gtk.sha256sum] = "8dd8046fa825088d8513f2886b8d582a41e6c4db7f7bebb2671ff85a44c07ac6"

URI_aarch64_gstreamer1-plugins-good = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-good-1.26.7-2.el10_2.5.aarch64.rpm;name=aarch64_gstreamer1-plugins-good;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-good}"
SRC_URI[aarch64_gstreamer1-plugins-good.sha256sum] = "a1fa46497d1310241888cd81beb7d4a8d88b860466d32446b51bea04f10fb0fb"

URI_aarch64_gstreamer1-plugins-good-gtk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-good-gtk-1.26.7-2.el10_2.5.aarch64.rpm;name=aarch64_gstreamer1-plugins-good-gtk;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-good-gtk}"
SRC_URI[aarch64_gstreamer1-plugins-good-gtk.sha256sum] = "e5f7c79f813dd03e18eafbf3532271fa92d448a1bd5312c9cb01d36e28ead608"

RDEPENDS:gstreamer1-plugins-good = " \
 bzip2-libs \
 cairo \
 cairo-gobject \
 flac-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 lame-libs \
 libX11 \
 libXdamage \
 libXext \
 libXfixes \
 libXtst \
 libgcc \
 libgudev \
 libjpeg-turbo \
 libpng \
 libshout \
 libstdc++ \
 libv4l \
 libvpx \
 libxml2 \
 mpg123-libs \
 openssl-libs \
 orc \
 pulseaudio-libs \
 speex \
 taglib \
 twolame-libs \
 wavpack \
 zlib-ng-compat \
 "
RDEPENDS:gstreamer1-plugins-good-gtk = " \
 cairo \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 gstreamer1-plugins-good \
 gtk3 \
 "
