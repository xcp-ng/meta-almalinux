# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ivf"
PV = "0.1.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-ivf+default-devel \
 rust-ivf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ivf-0.1.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c19f793d85cf835c80fd832ebf9ccf62e7aea36578d76ac79f29e280b2e11264"

URI_x86_64_v2_rust-ivf+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ivf+default-devel-0.1.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ivf+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ivf+default-devel}"
SRC_URI[x86_64_v2_rust-ivf+default-devel.sha256sum] = "6e1714e747a0feadbe9e99273654231d0625193da5f139feb2658c727f13a8eb"

URI_x86_64_v2_rust-ivf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ivf-devel-0.1.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ivf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ivf-devel}"
SRC_URI[x86_64_v2_rust-ivf-devel.sha256sum] = "357b9887b7713d8e2d6f45661b9fea1b9aa2cf921df41dd636c9132e9a9cdb69"

URI_aarch64_rust-ivf+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ivf+default-devel-0.1.4-1.el10_1.noarch.rpm;name=aarch64_rust-ivf+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ivf+default-devel}"
SRC_URI[aarch64_rust-ivf+default-devel.sha256sum] = "823ad8fa52251c66de324118fbea378a526c16d82ebcee517c11e124ff09d93c"

URI_aarch64_rust-ivf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ivf-devel-0.1.4-1.el10_1.noarch.rpm;name=aarch64_rust-ivf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ivf-devel}"
SRC_URI[aarch64_rust-ivf-devel.sha256sum] = "1860ede1c5f762317d401e6bb4fc3a10753f2b28a2d6e838489eedc652494279"

RDEPENDS:rust-ivf+default-devel = " \
 cargo \
 rust-ivf-devel \
 "
RDEPENDS:rust-ivf-devel = " \
 cargo \
 rust-bitstream-io+default-devel \
 "
