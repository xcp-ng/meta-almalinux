# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gupnp"
PV = "1.6.8"
PR = "1.el10_1"
PACKAGES = " \
 gupnp \
 gupnp-devel \
 gupnp-docs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gupnp-1.6.8-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f684cb5d9eaff7791868b6bf5221e4931f0f13913429b1ac2c7cfa8a61732298"

URI_x86_64_v2_gupnp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gupnp-1.6.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gupnp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gupnp}"
SRC_URI[x86_64_v2_gupnp.sha256sum] = "7921a9d283f845bf45ec6e5921bcce6d330a5baa9ef2d1fe778622cdb9e497de"

URI_x86_64_v2_gupnp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gupnp-devel-1.6.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gupnp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gupnp-devel}"
SRC_URI[x86_64_v2_gupnp-devel.sha256sum] = "3369fadac6a863d4e6acf21fa1ee8133293a0490ba1bb7385001b64206761186"

URI_x86_64_v2_gupnp-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gupnp-docs-1.6.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_gupnp-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gupnp-docs}"
SRC_URI[x86_64_v2_gupnp-docs.sha256sum] = "a464f91693cb310740346326a6a5504b7d4657bfb0a98ddcecf04f6758657871"

URI_aarch64_gupnp = "${EPEL_MIRROR}/aarch64/Packages/g/gupnp-1.6.8-1.el10_1.aarch64.rpm;name=aarch64_gupnp;unpack=0"
SRC_URI:append = " ${URI_aarch64_gupnp}"
SRC_URI[aarch64_gupnp.sha256sum] = "b94464ad2f477fa9d7d7d75de8034cb21fc199cb777b4fb1c933320ddfbcd284"

URI_aarch64_gupnp-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gupnp-devel-1.6.8-1.el10_1.aarch64.rpm;name=aarch64_gupnp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gupnp-devel}"
SRC_URI[aarch64_gupnp-devel.sha256sum] = "4cfba57d241fc05ab6a9613fc6e0368a66f8866f96fbcc0b25a1ce6180f2a50f"

URI_aarch64_gupnp-docs = "${EPEL_MIRROR}/aarch64/Packages/g/gupnp-docs-1.6.8-1.el10_1.noarch.rpm;name=aarch64_gupnp-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gupnp-docs}"
SRC_URI[aarch64_gupnp-docs.sha256sum] = "5fc92c7ef424acba7ef0ccd675750e176b18788f9ed1ce5873ecc8a33fde8070"

RDEPENDS:gupnp = " \
 dbus \
 glib2 \
 glibc \
 gssdp \
 libgcc \
 libsoup3 \
 libxml2 \
 "
RDEPENDS:gupnp-devel = " \
 glib2-devel \
 gssdp-devel \
 gupnp \
 libsoup3-devel \
 libxml2-devel \
 pkgconf-pkg-config \
 python3 \
 "
RDEPENDS:gupnp-docs = " \
 gupnp \
 "
