# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cscope"
PV = "15.9"
PR = "26.el10"
PACKAGES = " \
 cscope \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cscope-15.9-26.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5592bfa802212990c627801fde08f34831b401e1ceb03d00802a976c1a3ee77f"

URI_x86_64_v2_cscope = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cscope-15.9-26.el10.x86_64_v2.rpm;name=x86_64_v2_cscope;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cscope}"
SRC_URI[x86_64_v2_cscope.sha256sum] = "e856e3393ea8ce21c49fab6ce1d5045b9d577679b83950b091c8a62ef67451c3"

URI_aarch64_cscope = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cscope-15.9-26.el10.aarch64.rpm;name=aarch64_cscope;unpack=0"
SRC_URI:append = " ${URI_aarch64_cscope}"
SRC_URI[aarch64_cscope.sha256sum] = "409278511665fa4d82da76bb2cc5ee0c60a9ea7b8274903f599f8da32514712f"

RDEPENDS:cscope = " \
 bash \
 ed \
 emacs-filesystem \
 glibc \
 ncurses-libs \
 virtual/coreutils \
 "
