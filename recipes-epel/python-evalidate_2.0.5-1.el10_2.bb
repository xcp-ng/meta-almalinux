# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-evalidate"
PV = "2.0.5"
PR = "1.el10_2"
PACKAGES = " \
 python3-evalidate \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-evalidate-2.0.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a58e0f0f40cfeb08dff589a6d2435dbb76d1af29ed42b46e6d2e854aacd9049"

URI_x86_64_v2_python3-evalidate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-evalidate-2.0.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-evalidate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-evalidate}"
SRC_URI[x86_64_v2_python3-evalidate.sha256sum] = "22380aa01bc34b45fb578964b55b65909a558775c8235b3cd5246067199f31ef"

URI_aarch64_python3-evalidate = "${EPEL_MIRROR}/aarch64/Packages/p/python3-evalidate-2.0.5-1.el10_2.noarch.rpm;name=aarch64_python3-evalidate;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-evalidate}"
SRC_URI[aarch64_python3-evalidate.sha256sum] = "6f26b0c899b3330edf16d914f90a61ab6b09e79161f3d05c5a9ec4e0360e498d"

RDEPENDS:python3-evalidate = " \
 python3 \
 "
