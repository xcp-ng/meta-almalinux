# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openexr"
PV = "3.1.10"
PR = "8.el10_2.4"
PACKAGES = " \
 openexr \
 openexr-devel \
 openexr-libs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/openexr-3.1.10-8.el10_2.4.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d9348b53f141f69774498c50d0f6fb069bf80e7633d1328f2e86bc114ef32e3d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openexr-3.1.10-8.el10_2.4.x86_64_v2.rpm;name=x86_64_v2_openexr;unpack=0"
SRC_URI[x86_64_v2_openexr.sha256sum] = "50e821af450c993614baca125bca5e7a23c6284d24117834c18f09b1cc4608e1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openexr-devel-3.1.10-8.el10_2.4.x86_64_v2.rpm;name=x86_64_v2_openexr-devel;unpack=0"
SRC_URI[x86_64_v2_openexr-devel.sha256sum] = "c0f6b09744333347c213f274e2a439c8afabd9a263dbd31291516190d227f6ea"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openexr-libs-3.1.10-8.el10_2.4.x86_64_v2.rpm;name=x86_64_v2_openexr-libs;unpack=0"
SRC_URI[x86_64_v2_openexr-libs.sha256sum] = "d705f98be1ffd5854768a90222765c9db0ecc0bdf5fea253b16445a521db8103"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openexr-3.1.10-8.el10_2.4.aarch64.rpm;name=aarch64_openexr;unpack=0"
SRC_URI[aarch64_openexr.sha256sum] = "f4fbc01cd3af4171bbfe0399a8f43cd2aba6d03b8217c7d2297b1534908e3904"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openexr-devel-3.1.10-8.el10_2.4.aarch64.rpm;name=aarch64_openexr-devel;unpack=0"
SRC_URI[aarch64_openexr-devel.sha256sum] = "d58c24762fd69918f604ee739b1389328c4927ed30341c1de59489ad948ef8c1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openexr-libs-3.1.10-8.el10_2.4.aarch64.rpm;name=aarch64_openexr-libs;unpack=0"
SRC_URI[aarch64_openexr-libs.sha256sum] = "5f9028c55327634d084bb7920ee9ed92ffe37cfc14adbd09ee2aa5ee8f99eb0b"

RDEPENDS:openexr = " \
 glibc \
 imath \
 libgcc \
 libstdc++ \
 openexr-libs \
 "
RDEPENDS:openexr-devel = " \
 cmake-filesystem \
 imath-devel \
 openexr-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:openexr-libs = " \
 glibc \
 imath \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
