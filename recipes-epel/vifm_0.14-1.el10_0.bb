# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vifm"
PV = "0.14"
PR = "1.el10_0"
PACKAGES = " \
 vifm \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/v/vifm-0.14-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3e50b53e9bddbc23be99dc10a1b5d1b99fd2b4a4681973eed7c2bc5d5b60642c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vifm-0.14-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vifm;unpack=0"
SRC_URI[x86_64_v2_vifm.sha256sum] = "dbd8167ed251b92d19c839325d9ea12a75069f4651c71de4b9ae2fe1785a6263"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vifm-0.14-1.el10_0.aarch64.rpm;name=aarch64_vifm;unpack=0"
SRC_URI[aarch64_vifm.sha256sum] = "b9bfbb3fd4aa0e0dccc373fddd27255575fb9fdf1073acfc44d46c6bdd14c0cf"

RDEPENDS:vifm = " \
 bash \
 file-libs \
 glibc \
 hicolor-icon-theme \
 ncurses-libs \
 perl-interpreter \
 perl-libs \
 "
