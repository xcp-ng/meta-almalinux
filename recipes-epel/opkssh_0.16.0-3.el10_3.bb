# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opkssh"
PV = "0.16.0"
PR = "3.el10_3"
PACKAGES = " \
 opkssh \
 opkssh-doc \
 opkssh-server \
 opkssh-server-selinux \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/o/opkssh-0.16.0-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "87010e7c44fa42f8bf854fdbf39552d5afcb307be1c43d42f3ce067c7c0a6a43"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opkssh-0.16.0-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opkssh;unpack=0"
SRC_URI[x86_64_v2_opkssh.sha256sum] = "16efd60ee2dbf784d6c7eb7f6bae99d75bffae68bb651c8ce7b4f79dac4e410f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opkssh-doc-0.16.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_opkssh-doc;unpack=0"
SRC_URI[x86_64_v2_opkssh-doc.sha256sum] = "a31673e76999adf30d8de8389e4b1121eeab57ceb7d5b132933cc3b102287eb5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opkssh-server-0.16.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_opkssh-server;unpack=0"
SRC_URI[x86_64_v2_opkssh-server.sha256sum] = "99d5aa60a137680436619b45e50c3e23e8a5a91e42f00f78bf5b7c3d13314349"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opkssh-server-selinux-0.16.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_opkssh-server-selinux;unpack=0"
SRC_URI[x86_64_v2_opkssh-server-selinux.sha256sum] = "2ba47a321e637007e119f6f2023c901934db4e4f0cf7d6cf95ed4df5c9fae255"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/opkssh-0.16.0-3.el10_3.aarch64.rpm;name=aarch64_opkssh;unpack=0"
SRC_URI[aarch64_opkssh.sha256sum] = "34c86970035db9bac5d2f20bee4ea9376c9263a5f6a729e199db3ed209761289"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/opkssh-doc-0.16.0-3.el10_3.noarch.rpm;name=aarch64_opkssh-doc;unpack=0"
SRC_URI[aarch64_opkssh-doc.sha256sum] = "112f9de2ccd83fb7266959497a3f479ada680115f8e4c560dc4260ca10b03a19"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/opkssh-server-0.16.0-3.el10_3.noarch.rpm;name=aarch64_opkssh-server;unpack=0"
SRC_URI[aarch64_opkssh-server.sha256sum] = "54a1707a67c5ae0de0a85710cd5331d0a54a11a3fecb19cded8976666662ebda"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/opkssh-server-selinux-0.16.0-3.el10_3.noarch.rpm;name=aarch64_opkssh-server-selinux;unpack=0"
SRC_URI[aarch64_opkssh-server-selinux.sha256sum] = "91a5dfcbd2ec394ac3c4b8e87007108455e0c643fa1b43a592fc02e67ab477ca"

RDEPENDS:opkssh = " \
 glibc \
 shadow-utils \
 "
RDEPENDS:opkssh-doc = " \
 "
RDEPENDS:opkssh-server = " \
 bash \
 opkssh \
 opkssh-server-selinux \
 "
RDEPENDS:opkssh-server-selinux = " \
 bash \
 selinux-policy-targeted \
 "
