# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-regex-automata"
PV = "0.4.11"
PR = "1.el10_0"
PACKAGES = " \
 rust-regex-automata+alloc-devel \
 rust-regex-automata+default-devel \
 rust-regex-automata+dfa-build-devel \
 rust-regex-automata+dfa-devel \
 rust-regex-automata+dfa-onepass-devel \
 rust-regex-automata+dfa-search-devel \
 rust-regex-automata+hybrid-devel \
 rust-regex-automata+internal-instrument-devel \
 rust-regex-automata+internal-instrument-pikevm-devel \
 rust-regex-automata+logging-devel \
 rust-regex-automata+meta-devel \
 rust-regex-automata+nfa-backtrack-devel \
 rust-regex-automata+nfa-devel \
 rust-regex-automata+nfa-pikevm-devel \
 rust-regex-automata+nfa-thompson-devel \
 rust-regex-automata+perf-devel \
 rust-regex-automata+perf-inline-devel \
 rust-regex-automata+perf-literal-devel \
 rust-regex-automata+perf-literal-multisubstring-devel \
 rust-regex-automata+perf-literal-substring-devel \
 rust-regex-automata+std-devel \
 rust-regex-automata+syntax-devel \
 rust-regex-automata+unicode-age-devel \
 rust-regex-automata+unicode-bool-devel \
 rust-regex-automata+unicode-case-devel \
 rust-regex-automata+unicode-devel \
 rust-regex-automata+unicode-gencat-devel \
 rust-regex-automata+unicode-perl-devel \
 rust-regex-automata+unicode-script-devel \
 rust-regex-automata+unicode-segment-devel \
 rust-regex-automata+unicode-word-boundary-devel \
 rust-regex-automata-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-regex-automata-0.4.11-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6b2e605d54c39e252c086b5ba3e783f8824f2200c4e1c1a02f6507f8f72a5e3"

URI_x86_64_v2_rust-regex-automata+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+alloc-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+alloc-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+alloc-devel.sha256sum] = "9b43f46875abbb3274857da4a408bb7db480cecdaa601ed4212cde774345f4b9"

URI_x86_64_v2_rust-regex-automata+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+default-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+default-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+default-devel.sha256sum] = "f52bdcca9b65613a1aacba9b6dbc9202e934b0fa06e52cfa92786def0aa15f3b"

URI_x86_64_v2_rust-regex-automata+dfa-build-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+dfa-build-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+dfa-build-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+dfa-build-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+dfa-build-devel.sha256sum] = "9435f0ccb90fa99aa852a6939670c5886b16325320d019bc5b99758239d2c500"

URI_x86_64_v2_rust-regex-automata+dfa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+dfa-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+dfa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+dfa-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+dfa-devel.sha256sum] = "b56f709914ba9d5f118a04e4573414108bb0fd6ba8f3b93e3c7fd36a11eaab0a"

URI_x86_64_v2_rust-regex-automata+dfa-onepass-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+dfa-onepass-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+dfa-onepass-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+dfa-onepass-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+dfa-onepass-devel.sha256sum] = "d15b0f516ced9ed0e5cfe9a76696728ac7967ebd52454e2042908ac95f68c03e"

URI_x86_64_v2_rust-regex-automata+dfa-search-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+dfa-search-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+dfa-search-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+dfa-search-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+dfa-search-devel.sha256sum] = "ecaa97c62481ba2073c38a2ea14604ba6e504c9082668e2d460cf7a785954fe0"

URI_x86_64_v2_rust-regex-automata+hybrid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+hybrid-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+hybrid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+hybrid-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+hybrid-devel.sha256sum] = "ff64d9045e6b1e46f5666cfe62228a356ebd92072a1f33b61119e3f41b63aa76"

URI_x86_64_v2_rust-regex-automata+internal-instrument-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+internal-instrument-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+internal-instrument-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+internal-instrument-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+internal-instrument-devel.sha256sum] = "081ef205d320571c07f4cb9594dc35da9610a14146b7839b3b1868fbc813fdec"

URI_x86_64_v2_rust-regex-automata+internal-instrument-pikevm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+internal-instrument-pikevm-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+internal-instrument-pikevm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+internal-instrument-pikevm-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+internal-instrument-pikevm-devel.sha256sum] = "e463aaeb1a233f41adc0503c125c85053bff242d7539b2e9883a6db41419679f"

URI_x86_64_v2_rust-regex-automata+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+logging-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+logging-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+logging-devel.sha256sum] = "3657b7b1e148554e2ab8530f7ad765083e1cdee1275fab9d861bda5a9845d611"

URI_x86_64_v2_rust-regex-automata+meta-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+meta-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+meta-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+meta-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+meta-devel.sha256sum] = "33adab780c499a1b7ec3553349eb57ad2592de6865591b42692c561397453c25"

URI_x86_64_v2_rust-regex-automata+nfa-backtrack-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+nfa-backtrack-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+nfa-backtrack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+nfa-backtrack-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+nfa-backtrack-devel.sha256sum] = "85cd50632e29d2a402a839f186f4f4804cfcaa76731d03fc61728e3ce46e20c6"

URI_x86_64_v2_rust-regex-automata+nfa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+nfa-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+nfa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+nfa-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+nfa-devel.sha256sum] = "0ea5806d6bb216b7c2f39d44aafa77a80e4eb06422bdbd529d3a869a1ba80acf"

URI_x86_64_v2_rust-regex-automata+nfa-pikevm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+nfa-pikevm-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+nfa-pikevm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+nfa-pikevm-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+nfa-pikevm-devel.sha256sum] = "bf5ae5a0aaaa6f095ebc23cef54775431c2ae186355cf5614de7ca02d18492fc"

URI_x86_64_v2_rust-regex-automata+nfa-thompson-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+nfa-thompson-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+nfa-thompson-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+nfa-thompson-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+nfa-thompson-devel.sha256sum] = "0c1f275c1c636213885cf9440497557ee9ae437660b46bc80b113e7a16b62b4d"

URI_x86_64_v2_rust-regex-automata+perf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+perf-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+perf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+perf-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+perf-devel.sha256sum] = "ab807b2393d868d85a4770c0e27142ff4f5567a7054e013e85d6bf4940e309c3"

URI_x86_64_v2_rust-regex-automata+perf-inline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+perf-inline-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+perf-inline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+perf-inline-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+perf-inline-devel.sha256sum] = "0ac10d3007fa4cdf9d79deca5c4994910be980221fbf5578f108c2a3d0f0b97c"

URI_x86_64_v2_rust-regex-automata+perf-literal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+perf-literal-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+perf-literal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+perf-literal-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+perf-literal-devel.sha256sum] = "ce6e29eba058e85a7a0665a17666c5db3089a05fa15037bf617f6a39f850b360"

URI_x86_64_v2_rust-regex-automata+perf-literal-multisubstring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+perf-literal-multisubstring-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+perf-literal-multisubstring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+perf-literal-multisubstring-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+perf-literal-multisubstring-devel.sha256sum] = "3be3f20d135d7af9559af564747f1d09f42005afe0802737b9d177a998e1ed9d"

URI_x86_64_v2_rust-regex-automata+perf-literal-substring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+perf-literal-substring-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+perf-literal-substring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+perf-literal-substring-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+perf-literal-substring-devel.sha256sum] = "9058356340de2c47d43192208fe53daf268c33c267315eb78b0dbea9132d848b"

URI_x86_64_v2_rust-regex-automata+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+std-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+std-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+std-devel.sha256sum] = "64101c5603e251aad17971d5146cd5297e3f560810e06a98bd0032f2349a88b2"

URI_x86_64_v2_rust-regex-automata+syntax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+syntax-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+syntax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+syntax-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+syntax-devel.sha256sum] = "90c59bff29494aa60b082e904a9e68dd2ce1d039907dc8fa8441071b0d68a5a8"

URI_x86_64_v2_rust-regex-automata+unicode-age-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-age-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-age-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-age-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-age-devel.sha256sum] = "530ed972d2afe990a97c7392836a05d7049435f9b9d34a0a6505ef80874cc764"

URI_x86_64_v2_rust-regex-automata+unicode-bool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-bool-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-bool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-bool-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-bool-devel.sha256sum] = "cf6dfd711164ab6c870a905cad1d73fa2e2a7fa2e44b2f1f6c7e3ab8b8a37320"

URI_x86_64_v2_rust-regex-automata+unicode-case-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-case-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-case-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-case-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-case-devel.sha256sum] = "0afd677c9b0ee7940f990b64732ad1995458da2cf132e66413fd582ec26ac2ae"

URI_x86_64_v2_rust-regex-automata+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-devel.sha256sum] = "a36bfe8e42458731f6fa4e0200d12d530e41fc6078a300e22f08957372ac8dfa"

URI_x86_64_v2_rust-regex-automata+unicode-gencat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-gencat-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-gencat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-gencat-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-gencat-devel.sha256sum] = "39d0991d5553569d4482f67976e6135d264da2b6e5de63c452355279d610a4d7"

URI_x86_64_v2_rust-regex-automata+unicode-perl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-perl-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-perl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-perl-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-perl-devel.sha256sum] = "28dc07d8bdad7838c4b85ecc5aabb7b93949e0bf86bd592256297235ece01bab"

URI_x86_64_v2_rust-regex-automata+unicode-script-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-script-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-script-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-script-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-script-devel.sha256sum] = "91a27260d542e554934ccceabcff15c0d2fa3aba43abf4036a4a87f2f6a4f3c0"

URI_x86_64_v2_rust-regex-automata+unicode-segment-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-segment-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-segment-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-segment-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-segment-devel.sha256sum] = "8903efc50b2a8e57c9e748cbc2f2ffbd421da2554501bc641cbb4e1ae581a37d"

URI_x86_64_v2_rust-regex-automata+unicode-word-boundary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-word-boundary-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-word-boundary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-word-boundary-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-word-boundary-devel.sha256sum] = "fe68f71ab498b5051a088c5dab2ce1eb8c57e481154ff3181b6e1ff2bdd254c6"

URI_x86_64_v2_rust-regex-automata-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata-devel}"
SRC_URI[x86_64_v2_rust-regex-automata-devel.sha256sum] = "fbdc8beabb6a4cad46ea7a00504dae6c9596dd3d4ae8f414aed4987d0d6b6df2"

URI_aarch64_rust-regex-automata+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+alloc-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-regex-automata+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+alloc-devel}"
SRC_URI[aarch64_rust-regex-automata+alloc-devel.sha256sum] = "407d96da6728bf63a85a387930946fe9668bb9a64e756a99176196c73f128663"

URI_aarch64_rust-regex-automata+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+default-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-regex-automata+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+default-devel}"
SRC_URI[aarch64_rust-regex-automata+default-devel.sha256sum] = "d275cdb361837066c2b02f4862394257d413563c254f9f49cd7f594c6e3eae2e"

URI_aarch64_rust-regex-automata+dfa-build-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+dfa-build-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-regex-automata+dfa-build-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+dfa-build-devel}"
SRC_URI[aarch64_rust-regex-automata+dfa-build-devel.sha256sum] = "ea7522fc4b9436b20bfd10898c93314a597967c6d6f137be3e1aa8638b0d6f21"

URI_aarch64_rust-regex-automata+dfa-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+dfa-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-regex-automata+dfa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+dfa-devel}"
SRC_URI[aarch64_rust-regex-automata+dfa-devel.sha256sum] = "f7425b80ca43a9db0a45d9a2fac9fc0b1e181bdeaa4836e140600628223ecc19"

URI_aarch64_rust-regex-automata+dfa-onepass-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+dfa-onepass-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-regex-automata+dfa-onepass-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+dfa-onepass-devel}"
SRC_URI[aarch64_rust-regex-automata+dfa-onepass-devel.sha256sum] = "92b74633438b689cf42b7cde7ec93e752fba5187123b53331ac81d5c84c852e8"

URI_aarch64_rust-regex-automata+dfa-search-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+dfa-search-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-regex-automata+dfa-search-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+dfa-search-devel}"
SRC_URI[aarch64_rust-regex-automata+dfa-search-devel.sha256sum] = "67328ed6fc17b476cd274191068eb3eee674a27ab920b43dbd418a00b32219f2"

URI_aarch64_rust-regex-automata+hybrid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+hybrid-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-regex-automata+hybrid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+hybrid-devel}"
SRC_URI[aarch64_rust-regex-automata+hybrid-devel.sha256sum] = "7a8d9c58f5dcac5d68bb307ac8cce533e6cba40a3c87abbc6801092d91c82305"

URI_aarch64_rust-regex-automata+internal-instrument-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+internal-instrument-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-regex-automata+internal-instrument-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+internal-instrument-devel}"
SRC_URI[aarch64_rust-regex-automata+internal-instrument-devel.sha256sum] = "18573df259d5534d260865a6d8c390456e2df4d6f6890db62ab1c749641f1859"

URI_aarch64_rust-regex-automata+internal-instrument-pikevm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+internal-instrument-pikevm-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-regex-automata+internal-instrument-pikevm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+internal-instrument-pikevm-devel}"
SRC_URI[aarch64_rust-regex-automata+internal-instrument-pikevm-devel.sha256sum] = "84a09833fe985d6c12100c3b2703900b5d392a066793eac7f866f26299ed8c61"

URI_aarch64_rust-regex-automata+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+logging-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-regex-automata+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+logging-devel}"
SRC_URI[aarch64_rust-regex-automata+logging-devel.sha256sum] = "58b61279d6170240ab04fdef8ae222cffaf3c460b64fd949fa9e41c2c458525f"

URI_aarch64_rust-regex-automata+meta-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+meta-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-regex-automata+meta-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+meta-devel}"
SRC_URI[aarch64_rust-regex-automata+meta-devel.sha256sum] = "807833b77b864810a8805c1f51a7189b88a7992e68e5e6c0b128b9f39984ad15"

URI_aarch64_rust-regex-automata+nfa-backtrack-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+nfa-backtrack-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-regex-automata+nfa-backtrack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+nfa-backtrack-devel}"
SRC_URI[aarch64_rust-regex-automata+nfa-backtrack-devel.sha256sum] = "7bb34c3a5ca9b7b90a82d3dd188184a7b387be3fe6507318385479b3f021f6f0"

URI_aarch64_rust-regex-automata+nfa-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+nfa-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-regex-automata+nfa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+nfa-devel}"
SRC_URI[aarch64_rust-regex-automata+nfa-devel.sha256sum] = "239964f635f54c3e3b3739c08e8737ee6e553401c148f15a1f1b4c3a804ba361"

URI_aarch64_rust-regex-automata+nfa-pikevm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+nfa-pikevm-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-regex-automata+nfa-pikevm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+nfa-pikevm-devel}"
SRC_URI[aarch64_rust-regex-automata+nfa-pikevm-devel.sha256sum] = "a5e584ffa106cfd2856cfac8bb5bb4b8c0735b482bc0aa962d18a3fff0a75468"

URI_aarch64_rust-regex-automata+nfa-thompson-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+nfa-thompson-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-regex-automata+nfa-thompson-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+nfa-thompson-devel}"
SRC_URI[aarch64_rust-regex-automata+nfa-thompson-devel.sha256sum] = "7f19544a37311ea62fbb778f1fdb3aa3ca37d42e3dc88a7ca6efb7d9a0ac3020"

URI_aarch64_rust-regex-automata+perf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+perf-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-regex-automata+perf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+perf-devel}"
SRC_URI[aarch64_rust-regex-automata+perf-devel.sha256sum] = "6c6a295e0a217e40c8a93efc9e930bda27f5fd4489d4193f74304df0902c6a93"

URI_aarch64_rust-regex-automata+perf-inline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+perf-inline-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-regex-automata+perf-inline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+perf-inline-devel}"
SRC_URI[aarch64_rust-regex-automata+perf-inline-devel.sha256sum] = "c70e20fd0b2d0bb708c2a1d7d1c383e161d2884cad6f421396cdf3dc17cafc9b"

URI_aarch64_rust-regex-automata+perf-literal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+perf-literal-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-regex-automata+perf-literal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+perf-literal-devel}"
SRC_URI[aarch64_rust-regex-automata+perf-literal-devel.sha256sum] = "4cfb436e8531f37fec5101ad209199e1673a30de82ac2b00f91efacc2b4f3045"

URI_aarch64_rust-regex-automata+perf-literal-multisubstring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+perf-literal-multisubstring-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-regex-automata+perf-literal-multisubstring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+perf-literal-multisubstring-devel}"
SRC_URI[aarch64_rust-regex-automata+perf-literal-multisubstring-devel.sha256sum] = "aab988f24917ea86a3bd6b3c98ec3ed7197befeb685d32df6b0a9506ab0a1835"

URI_aarch64_rust-regex-automata+perf-literal-substring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+perf-literal-substring-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-regex-automata+perf-literal-substring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+perf-literal-substring-devel}"
SRC_URI[aarch64_rust-regex-automata+perf-literal-substring-devel.sha256sum] = "cf7fde6aa1c444a1f2252da37b9a649c76f12e9558dd2148d1db37a34da02e71"

URI_aarch64_rust-regex-automata+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+std-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-regex-automata+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+std-devel}"
SRC_URI[aarch64_rust-regex-automata+std-devel.sha256sum] = "5ea653a0cd8211ae7229f9e280dd955ef54b3de236fcb4ba1c46dc2e6409f4f7"

URI_aarch64_rust-regex-automata+syntax-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+syntax-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-regex-automata+syntax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+syntax-devel}"
SRC_URI[aarch64_rust-regex-automata+syntax-devel.sha256sum] = "2cb4682d24be361772658b4bd11898a719a21ff666698c61c73bf065ca8dff1c"

URI_aarch64_rust-regex-automata+unicode-age-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-age-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-regex-automata+unicode-age-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-age-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-age-devel.sha256sum] = "b6be3ae78c0c070d1fa92e243bc7255d6dfc62f0a7390ef40ffd6b9de16e7c0e"

URI_aarch64_rust-regex-automata+unicode-bool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-bool-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-regex-automata+unicode-bool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-bool-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-bool-devel.sha256sum] = "c04e1f478a287c2c5d7431adac1c9561413e864f3f45437ff647b6567209414f"

URI_aarch64_rust-regex-automata+unicode-case-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-case-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-regex-automata+unicode-case-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-case-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-case-devel.sha256sum] = "28ddb5fda9d2e680b662f82e78c4e50a0473f81a8db4fa57d25c692e0be0145c"

URI_aarch64_rust-regex-automata+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-regex-automata+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-devel.sha256sum] = "ec643cdfc57416897363c47dd0344970be8759daaccc2995bef102d5629e7c3f"

URI_aarch64_rust-regex-automata+unicode-gencat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-gencat-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-regex-automata+unicode-gencat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-gencat-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-gencat-devel.sha256sum] = "f3ac485090b93ba5ec85a1383d25f895c55943b62465e303c7a3934458903406"

URI_aarch64_rust-regex-automata+unicode-perl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-perl-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-regex-automata+unicode-perl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-perl-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-perl-devel.sha256sum] = "4a5c59db681998319d462fb5a0cbb957b30f9242e19a19741e74d6f03474d21f"

URI_aarch64_rust-regex-automata+unicode-script-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-script-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-regex-automata+unicode-script-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-script-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-script-devel.sha256sum] = "18d00195077a52ed4055bac5223ccc7b84f6edf8061537205e87147b53f89241"

URI_aarch64_rust-regex-automata+unicode-segment-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-segment-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-regex-automata+unicode-segment-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-segment-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-segment-devel.sha256sum] = "045a3eafba091e004d59ff98c2ad74c45e5e8a494989f941757bf5609bddcf83"

URI_aarch64_rust-regex-automata+unicode-word-boundary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-word-boundary-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-regex-automata+unicode-word-boundary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-word-boundary-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-word-boundary-devel.sha256sum] = "88264fff8f5253583a43e960f1af939ab9cfd6ea0a995b6c2e3fb38e1f91de35"

URI_aarch64_rust-regex-automata-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-regex-automata-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata-devel}"
SRC_URI[aarch64_rust-regex-automata-devel.sha256sum] = "8aa35169da6b39dd3b2f5ac8081ebd1af972f439e2b665af554d7e4130d19aab"

RDEPENDS:rust-regex-automata+alloc-devel = " \
 cargo \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+default-devel = " \
 cargo \
 rust-regex-automata+dfa-devel \
 rust-regex-automata+hybrid-devel \
 rust-regex-automata+meta-devel \
 rust-regex-automata+nfa-devel \
 rust-regex-automata+perf-devel \
 rust-regex-automata+std-devel \
 rust-regex-automata+syntax-devel \
 rust-regex-automata+unicode-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+dfa-build-devel = " \
 cargo \
 rust-regex-automata+dfa-search-devel \
 rust-regex-automata+nfa-thompson-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+dfa-devel = " \
 cargo \
 rust-regex-automata+dfa-build-devel \
 rust-regex-automata+dfa-onepass-devel \
 rust-regex-automata+dfa-search-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+dfa-onepass-devel = " \
 cargo \
 rust-regex-automata+nfa-thompson-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+dfa-search-devel = " \
 cargo \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+hybrid-devel = " \
 cargo \
 rust-regex-automata+alloc-devel \
 rust-regex-automata+nfa-thompson-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+internal-instrument-devel = " \
 cargo \
 rust-regex-automata+internal-instrument-pikevm-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+internal-instrument-pikevm-devel = " \
 cargo \
 rust-regex-automata+logging-devel \
 rust-regex-automata+std-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+logging-devel = " \
 cargo \
 rust-aho-corasick+logging-devel \
 rust-aho-corasick-devel \
 rust-log+default-devel \
 rust-memchr+logging-devel \
 rust-memchr-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+meta-devel = " \
 cargo \
 rust-regex-automata+nfa-pikevm-devel \
 rust-regex-automata+syntax-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+nfa-backtrack-devel = " \
 cargo \
 rust-regex-automata+nfa-thompson-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+nfa-devel = " \
 cargo \
 rust-regex-automata+nfa-backtrack-devel \
 rust-regex-automata+nfa-pikevm-devel \
 rust-regex-automata+nfa-thompson-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+nfa-pikevm-devel = " \
 cargo \
 rust-regex-automata+nfa-thompson-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+nfa-thompson-devel = " \
 cargo \
 rust-regex-automata+alloc-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+perf-devel = " \
 cargo \
 rust-regex-automata+perf-inline-devel \
 rust-regex-automata+perf-literal-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+perf-inline-devel = " \
 cargo \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+perf-literal-devel = " \
 cargo \
 rust-regex-automata+perf-literal-multisubstring-devel \
 rust-regex-automata+perf-literal-substring-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+perf-literal-multisubstring-devel = " \
 cargo \
 rust-aho-corasick-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+perf-literal-substring-devel = " \
 cargo \
 rust-aho-corasick+perf-literal-devel \
 rust-aho-corasick-devel \
 rust-memchr-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+std-devel = " \
 cargo \
 rust-aho-corasick+std-devel \
 rust-aho-corasick-devel \
 rust-memchr+std-devel \
 rust-memchr-devel \
 rust-regex-automata+alloc-devel \
 rust-regex-automata-devel \
 rust-regex-syntax+std-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+syntax-devel = " \
 cargo \
 rust-regex-automata+alloc-devel \
 rust-regex-automata-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-age-devel = " \
 cargo \
 rust-regex-automata-devel \
 rust-regex-syntax+unicode-age-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-bool-devel = " \
 cargo \
 rust-regex-automata-devel \
 rust-regex-syntax+unicode-bool-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-case-devel = " \
 cargo \
 rust-regex-automata-devel \
 rust-regex-syntax+unicode-case-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-devel = " \
 cargo \
 rust-regex-automata+unicode-age-devel \
 rust-regex-automata+unicode-bool-devel \
 rust-regex-automata+unicode-case-devel \
 rust-regex-automata+unicode-gencat-devel \
 rust-regex-automata+unicode-perl-devel \
 rust-regex-automata+unicode-script-devel \
 rust-regex-automata+unicode-segment-devel \
 rust-regex-automata+unicode-word-boundary-devel \
 rust-regex-automata-devel \
 rust-regex-syntax+unicode-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-gencat-devel = " \
 cargo \
 rust-regex-automata-devel \
 rust-regex-syntax+unicode-gencat-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-perl-devel = " \
 cargo \
 rust-regex-automata-devel \
 rust-regex-syntax+unicode-perl-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-script-devel = " \
 cargo \
 rust-regex-automata-devel \
 rust-regex-syntax+unicode-script-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-segment-devel = " \
 cargo \
 rust-regex-automata-devel \
 rust-regex-syntax+unicode-segment-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-word-boundary-devel = " \
 cargo \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata-devel = " \
 bash \
 cargo \
 rust \
 "
