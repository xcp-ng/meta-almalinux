# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-azure-storage"
PV = "3.1.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-reqsign-azure-storage+default-devel \
 rust-reqsign-azure-storage-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-azure-storage-3.1.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a20400431452662a14ddd13a82a9020142cab86e9041f58100ed2799991ff54c"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - rust-reqsign-azure-storage-devel: (crate(pem/default) >= 3.0.0 with crate(pem/default) < 4.0.0~)

URI_x86_64_v2_rust-reqsign-azure-storage+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-azure-storage+default-devel-3.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-azure-storage+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-azure-storage+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign-azure-storage+default-devel.sha256sum] = "2e34d52771f7c6c0eb44c70e65aa06bd0e7ba02c834f8c66b2272a20b9facc18"

URI_x86_64_v2_rust-reqsign-azure-storage-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-azure-storage-devel-3.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-azure-storage-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-azure-storage-devel}"
SRC_URI[x86_64_v2_rust-reqsign-azure-storage-devel.sha256sum] = "a748f7de307abb662b250d4497340683b06aafd8ddb5dc2c700aa831c5944a06"

URI_aarch64_rust-reqsign-azure-storage+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-azure-storage+default-devel-3.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-azure-storage+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-azure-storage+default-devel}"
SRC_URI[aarch64_rust-reqsign-azure-storage+default-devel.sha256sum] = "3777539e8480a2e2abd52beb6155154bfdd11c46575befc4086ae5c2931505cc"

URI_aarch64_rust-reqsign-azure-storage-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-azure-storage-devel-3.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-azure-storage-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-azure-storage-devel}"
SRC_URI[aarch64_rust-reqsign-azure-storage-devel.sha256sum] = "e99dabf1e0669270d7fb2f060592cba05a745dc7a47dc3be979a1d6bf37ae740"

RDEPENDS:rust-reqsign-azure-storage+default-devel = " \
 cargo \
 rust-reqsign-azure-storage-devel \
 "
RDEPENDS:rust-reqsign-azure-storage-devel:x86_64_v2 = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-base64_0.22+default-devel \
 rust-bytes+default-devel \
 rust-form_urlencoded+default-devel \
 rust-http+default-devel \
 rust-log+default-devel \
 rust-percent-encoding+default-devel \
 rust-reqsign-core+default-devel \
 rust-reqsign-core+jwt-devel \
 rust-rsa+default-devel \
 rust-rsa+pkcs5-devel \
 rust-rsa+sha2-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-sha1+default-devel \
"
RDEPENDS:rust-reqsign-azure-storage-devel:aarch64 = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-base64_0.22+default-devel \
 rust-bytes+default-devel \
 rust-form_urlencoded+default-devel \
 rust-http+default-devel \
 rust-log+default-devel \
 rust-pem3+default-devel \
 rust-percent-encoding+default-devel \
 rust-reqsign-core+default-devel \
 rust-reqsign-core+jwt-devel \
 rust-rsa+default-devel \
 rust-rsa+pkcs5-devel \
 rust-rsa+sha2-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-sha1+default-devel \
"
