# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-en"
PV = "0.20201207"
PR = "11.el10"
PACKAGES = " \
 hunspell-en \
 hunspell-en-GB \
 hunspell-en-US \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-en-0.20201207-11.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d441698d6dad3bc200b813361ffc19da3da9a68ae0b05da491ed185875f781d1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-en-0.20201207-11.el10.noarch.rpm;name=x86_64_v2_hunspell-en;unpack=0"
SRC_URI[x86_64_v2_hunspell-en.sha256sum] = "cb44aaa16dbc1d37f5a919d49b767750f5a5303ca62d8c978621c66f2bff0cbe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-en-GB-0.20201207-11.el10.noarch.rpm;name=x86_64_v2_hunspell-en-GB;unpack=0"
SRC_URI[x86_64_v2_hunspell-en-GB.sha256sum] = "c0c373bf981cb5f1798a71c74d6f0435f6e35b23ab8f13133f8e00b650b6ab51"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-en-US-0.20201207-11.el10.noarch.rpm;name=x86_64_v2_hunspell-en-US;unpack=0"
SRC_URI[x86_64_v2_hunspell-en-US.sha256sum] = "70180e88547e3baef51fcb9d9708c4a10a84a2f602721f8a28b19cb409ef6a77"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-en-0.20201207-11.el10.noarch.rpm;name=aarch64_hunspell-en;unpack=0"
SRC_URI[aarch64_hunspell-en.sha256sum] = "cb44aaa16dbc1d37f5a919d49b767750f5a5303ca62d8c978621c66f2bff0cbe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-en-GB-0.20201207-11.el10.noarch.rpm;name=aarch64_hunspell-en-GB;unpack=0"
SRC_URI[aarch64_hunspell-en-GB.sha256sum] = "c0c373bf981cb5f1798a71c74d6f0435f6e35b23ab8f13133f8e00b650b6ab51"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-en-US-0.20201207-11.el10.noarch.rpm;name=aarch64_hunspell-en-US;unpack=0"
SRC_URI[aarch64_hunspell-en-US.sha256sum] = "70180e88547e3baef51fcb9d9708c4a10a84a2f602721f8a28b19cb409ef6a77"

RDEPENDS:hunspell-en = " \
 hunspell \
 hunspell-en-GB \
 hunspell-en-US \
 "
RDEPENDS:hunspell-en-GB = " \
 hunspell \
 hunspell-filesystem \
 "
RDEPENDS:hunspell-en-US = " \
 hunspell \
 hunspell-filesystem \
 "
