# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-outref"
PV = "0.5.2"
PR = "4.el10_3"
PACKAGES = " \
 rust-outref+default-devel \
 rust-outref-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-outref-0.5.2-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "196b5c8df006e1577e83b04f1b8f602aa45b7422a99953b82e4dad2076387dd7"

URI_x86_64_v2_rust-outref+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-outref+default-devel-0.5.2-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-outref+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-outref+default-devel}"
SRC_URI[x86_64_v2_rust-outref+default-devel.sha256sum] = "a11ce2dce0c83d0be1804c11fc1836f7d672e181c75cc873784c76a0202c1e53"

URI_x86_64_v2_rust-outref-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-outref-devel-0.5.2-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-outref-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-outref-devel}"
SRC_URI[x86_64_v2_rust-outref-devel.sha256sum] = "914532ecdc20c2552a29058e4f88cd3e7df9317939d730bd720731bb0084507b"

URI_aarch64_rust-outref+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-outref+default-devel-0.5.2-4.el10_3.noarch.rpm;name=aarch64_rust-outref+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-outref+default-devel}"
SRC_URI[aarch64_rust-outref+default-devel.sha256sum] = "df5f616f3714b5ab5a1d94657e3e1fe3c1a76fd29f0524a62d8f8dfdd7e9dac5"

URI_aarch64_rust-outref-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-outref-devel-0.5.2-4.el10_3.noarch.rpm;name=aarch64_rust-outref-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-outref-devel}"
SRC_URI[aarch64_rust-outref-devel.sha256sum] = "1766143573d8327a519883cbacd0de3945b1ecc0b184812c9a99987bfc0831e8"

RDEPENDS:rust-outref+default-devel = " \
 cargo \
 rust-outref-devel \
 "
RDEPENDS:rust-outref-devel = " \
 cargo \
 rust \
 "
