# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-os_str_bytes"
PV = "6.6.1"
PR = "3.el10_0"
PACKAGES = " \
 rust-os_str_bytes+checked_conversions-devel \
 rust-os_str_bytes+conversions-devel \
 rust-os_str_bytes+default-devel \
 rust-os_str_bytes+memchr-devel \
 rust-os_str_bytes+print_bytes-devel \
 rust-os_str_bytes+raw_os_str-devel \
 rust-os_str_bytes-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-os_str_bytes-6.6.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15756c843654aa5b6761b4678da20a6fab38d63a7130250ebbe1ce775db2b2cc"

URI_x86_64_v2_rust-os_str_bytes+checked_conversions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_str_bytes+checked_conversions-devel-6.6.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_str_bytes+checked_conversions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_str_bytes+checked_conversions-devel}"
SRC_URI[x86_64_v2_rust-os_str_bytes+checked_conversions-devel.sha256sum] = "f77c83676810d33903aa27f2d7d6e3d6b53e75c8768e088ce7a9021b69e4fe6c"

URI_x86_64_v2_rust-os_str_bytes+conversions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_str_bytes+conversions-devel-6.6.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_str_bytes+conversions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_str_bytes+conversions-devel}"
SRC_URI[x86_64_v2_rust-os_str_bytes+conversions-devel.sha256sum] = "9229d119a6d69973bc9f6cb2f38ba7e4b7e28378cb488d509a976cf99127bcec"

URI_x86_64_v2_rust-os_str_bytes+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_str_bytes+default-devel-6.6.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_str_bytes+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_str_bytes+default-devel}"
SRC_URI[x86_64_v2_rust-os_str_bytes+default-devel.sha256sum] = "79b27663a9aeb3e195050ba851fc2ac8b3bf131d46d9a06ca5a5a0f60e9f99fa"

URI_x86_64_v2_rust-os_str_bytes+memchr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_str_bytes+memchr-devel-6.6.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_str_bytes+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_str_bytes+memchr-devel}"
SRC_URI[x86_64_v2_rust-os_str_bytes+memchr-devel.sha256sum] = "27df7cdaa56fc1242eceff88e792da4c9192cca21772ab3d1fff77c80d416000"

URI_x86_64_v2_rust-os_str_bytes+print_bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_str_bytes+print_bytes-devel-6.6.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_str_bytes+print_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_str_bytes+print_bytes-devel}"
SRC_URI[x86_64_v2_rust-os_str_bytes+print_bytes-devel.sha256sum] = "779b3d995ab3c16a51f94b3fc999d882bd9f19674dcad75d282024be071c774d"

URI_x86_64_v2_rust-os_str_bytes+raw_os_str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_str_bytes+raw_os_str-devel-6.6.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_str_bytes+raw_os_str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_str_bytes+raw_os_str-devel}"
SRC_URI[x86_64_v2_rust-os_str_bytes+raw_os_str-devel.sha256sum] = "25b740c998409a2cca6d55160d7286211c914351b87d32c4ad5b100a73abe828"

URI_x86_64_v2_rust-os_str_bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_str_bytes-devel-6.6.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_str_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_str_bytes-devel}"
SRC_URI[x86_64_v2_rust-os_str_bytes-devel.sha256sum] = "f6af55e08dcd5e62a3823809e8b2aa9fba32f23da6ce249589bdfa03cbe5814f"

URI_aarch64_rust-os_str_bytes+checked_conversions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_str_bytes+checked_conversions-devel-6.6.1-3.el10_0.noarch.rpm;name=aarch64_rust-os_str_bytes+checked_conversions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_str_bytes+checked_conversions-devel}"
SRC_URI[aarch64_rust-os_str_bytes+checked_conversions-devel.sha256sum] = "5b8e3e60888905f4a42c72bea1eed4ad42de31edd140b6f046baaa4aa0569907"

URI_aarch64_rust-os_str_bytes+conversions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_str_bytes+conversions-devel-6.6.1-3.el10_0.noarch.rpm;name=aarch64_rust-os_str_bytes+conversions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_str_bytes+conversions-devel}"
SRC_URI[aarch64_rust-os_str_bytes+conversions-devel.sha256sum] = "accb6fa293ebc4f50cf4203892283c255aa5556e5b1c01edbfa031897a468438"

URI_aarch64_rust-os_str_bytes+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_str_bytes+default-devel-6.6.1-3.el10_0.noarch.rpm;name=aarch64_rust-os_str_bytes+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_str_bytes+default-devel}"
SRC_URI[aarch64_rust-os_str_bytes+default-devel.sha256sum] = "7e75a6f40594101220f46c4792364d81ac1c1e99d697235b6fbac6e205bb9eef"

URI_aarch64_rust-os_str_bytes+memchr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_str_bytes+memchr-devel-6.6.1-3.el10_0.noarch.rpm;name=aarch64_rust-os_str_bytes+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_str_bytes+memchr-devel}"
SRC_URI[aarch64_rust-os_str_bytes+memchr-devel.sha256sum] = "036f7215fa887c23f56b7d5d93cf96660ad68badc760f0e22b5af44f930b0ac7"

URI_aarch64_rust-os_str_bytes+print_bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_str_bytes+print_bytes-devel-6.6.1-3.el10_0.noarch.rpm;name=aarch64_rust-os_str_bytes+print_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_str_bytes+print_bytes-devel}"
SRC_URI[aarch64_rust-os_str_bytes+print_bytes-devel.sha256sum] = "2330b0046b3783e0b7049e94c91bc6cb67c5c1f6ecda5cbcbcb1a8bfa06f3fd9"

URI_aarch64_rust-os_str_bytes+raw_os_str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_str_bytes+raw_os_str-devel-6.6.1-3.el10_0.noarch.rpm;name=aarch64_rust-os_str_bytes+raw_os_str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_str_bytes+raw_os_str-devel}"
SRC_URI[aarch64_rust-os_str_bytes+raw_os_str-devel.sha256sum] = "b39f2efd56947cdc0df0c2bab5e64d466d11ed5fc80c9574057ce76dd378b908"

URI_aarch64_rust-os_str_bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_str_bytes-devel-6.6.1-3.el10_0.noarch.rpm;name=aarch64_rust-os_str_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_str_bytes-devel}"
SRC_URI[aarch64_rust-os_str_bytes-devel.sha256sum] = "0bfa85750a833b9e59f134c08b426db9ceb979c95b9a51340ed9df37f5a951f0"

RDEPENDS:rust-os_str_bytes+checked_conversions-devel = " \
 cargo \
 rust-os_str_bytes+conversions-devel \
 rust-os_str_bytes-devel \
 "
RDEPENDS:rust-os_str_bytes+conversions-devel = " \
 cargo \
 rust-os_str_bytes-devel \
 "
RDEPENDS:rust-os_str_bytes+default-devel = " \
 cargo \
 rust-os_str_bytes+memchr-devel \
 rust-os_str_bytes+raw_os_str-devel \
 rust-os_str_bytes-devel \
 "
RDEPENDS:rust-os_str_bytes+memchr-devel = " \
 cargo \
 rust-memchr+default-devel \
 rust-os_str_bytes-devel \
 "
RDEPENDS:rust-os_str_bytes+print_bytes-devel = " \
 cargo \
 rust-os_str_bytes-devel \
 rust-print_bytes+default-devel \
 "
RDEPENDS:rust-os_str_bytes+raw_os_str-devel = " \
 cargo \
 rust-os_str_bytes-devel \
 "
RDEPENDS:rust-os_str_bytes-devel = " \
 cargo \
 rust \
 "
