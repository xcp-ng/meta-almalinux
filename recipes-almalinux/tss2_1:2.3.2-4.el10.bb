# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tss2"
PE = "1"
PV = "2.3.2"
PR = "4.el10"
PACKAGES:x86_64_v2 = " \
 tss2 \
 tss2-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/tss2-2.3.2-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "204d598f9035536ae4309b6147bb8641277574a8d4b111772afac7c617733fb3"

URI_x86_64_v2_tss2 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tss2-2.3.2-4.el10.x86_64_v2.rpm;name=x86_64_v2_tss2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tss2}"
SRC_URI[x86_64_v2_tss2.sha256sum] = "3b7c08898424125e35f12b0ec21315ae15c427e7ff44b3b352a5875a082d1405"

URI_x86_64_v2_tss2-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/tss2-devel-2.3.2-4.el10.x86_64_v2.rpm;name=x86_64_v2_tss2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tss2-devel}"
SRC_URI[x86_64_v2_tss2-devel.sha256sum] = "040e6532de4503f9d5038ebe9dad84117b4cae009b29d66c7c91295ed9425c37"

RDEPENDS:tss2 = " \
 glibc \
 openssl \
 openssl-libs \
 "
RDEPENDS:tss2-devel = " \
 tss2 \
 "
