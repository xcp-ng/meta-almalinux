# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kweathercore"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kweathercore \
 kweathercore-devel \
 kweathercore-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kweathercore-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50c2212f282a37e35d87bc1da59d0fdf2bc9c648c6a3e7124b35a2e2582cb8b2"

URI_x86_64_v2_kweathercore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kweathercore-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kweathercore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kweathercore}"
SRC_URI[x86_64_v2_kweathercore.sha256sum] = "dcfdce92c8cdd28b16e67950e0e979e6188ea57ef9c892d8598cd3b0bc5e5bba"

URI_x86_64_v2_kweathercore-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kweathercore-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kweathercore-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kweathercore-devel}"
SRC_URI[x86_64_v2_kweathercore-devel.sha256sum] = "1de08be5cdc1e8558a3773411492d58b2a1ceca37c3e03f70a3c0a89ea399bec"

URI_x86_64_v2_kweathercore-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kweathercore-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kweathercore-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kweathercore-doc}"
SRC_URI[x86_64_v2_kweathercore-doc.sha256sum] = "1282c5f819da97c15586d11368838a6f5244c2d9f079703e2fd9e63b09282dd2"

URI_aarch64_kweathercore = "${EPEL_MIRROR}/aarch64/Packages/k/kweathercore-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kweathercore;unpack=0"
SRC_URI:append = " ${URI_aarch64_kweathercore}"
SRC_URI[aarch64_kweathercore.sha256sum] = "362ad16ee2f7772f6969487c53e438b62c750b3d8bda3e81534b6a5aeccbd683"

URI_aarch64_kweathercore-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kweathercore-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kweathercore-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kweathercore-devel}"
SRC_URI[aarch64_kweathercore-devel.sha256sum] = "bad77acb5a83fa8f4ad02fb8b4d7330920dddb783458cdfac4e9b5251d1f9a7b"

URI_aarch64_kweathercore-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kweathercore-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_kweathercore-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kweathercore-doc}"
SRC_URI[aarch64_kweathercore-doc.sha256sum] = "1a2568ddc0a3d37efbd1d56894e86527c7aecb8b1944db7e1cbf6aaa46636c80"

RDEPENDS:kweathercore = " \
 glibc \
 kf6-kholidays \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 qt6-qtpositioning \
 "
RDEPENDS:kweathercore-devel = " \
 cmake-filesystem \
 kweathercore \
 "
RDEPENDS:kweathercore-doc = " \
 "
