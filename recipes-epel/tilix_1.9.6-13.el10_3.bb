# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tilix"
PV = "1.9.6"
PR = "13.el10_3"
PACKAGES = " \
 tilix \
 tilix-nautilus \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tilix-1.9.6-13.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5be5cf007ed66e8f9b56d277cf78cf7e7fb52a60031daf940fe1edfcb6174278"

URI_x86_64_v2_tilix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tilix-1.9.6-13.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tilix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tilix}"
SRC_URI[x86_64_v2_tilix.sha256sum] = "2b8a7e483f3b14dcbfb415d2a5b23bb1099383d231ffbf4eea4622b28f92b9f8"

URI_x86_64_v2_tilix-nautilus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tilix-nautilus-1.9.6-13.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tilix-nautilus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tilix-nautilus}"
SRC_URI[x86_64_v2_tilix-nautilus.sha256sum] = "a79d50b001f2a4a3afac4f9de329b7dc6cb11fdafb6d5ba2fe62274bda2b9c84"

URI_aarch64_tilix = "${EPEL_MIRROR}/aarch64/Packages/t/tilix-1.9.6-13.el10_3.aarch64.rpm;name=aarch64_tilix;unpack=0"
SRC_URI:append = " ${URI_aarch64_tilix}"
SRC_URI[aarch64_tilix.sha256sum] = "5d89a94779f29e72863ae364517ef3080505632a147de8f45ff7a8a51f243217"

URI_aarch64_tilix-nautilus = "${EPEL_MIRROR}/aarch64/Packages/t/tilix-nautilus-1.9.6-13.el10_3.aarch64.rpm;name=aarch64_tilix-nautilus;unpack=0"
SRC_URI:append = " ${URI_aarch64_tilix-nautilus}"
SRC_URI[aarch64_tilix-nautilus.sha256sum] = "3997aab957135496a4e993f5d1d32fffc88a1474cd7802a3688e37c84c2021dd"

RDEPENDS:tilix = " \
 bash \
 dbus \
 glibc \
 gtkd \
 hicolor-icon-theme \
 ldc-libs \
 libX11 \
 libgcc \
 "
RDEPENDS:tilix-nautilus = " \
 nautilus-python \
 tilix \
 "
