# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-Harness"
PE = "1"
PV = "3.48"
PR = "512.el10"
PACKAGES = " \
 perl-Test-Harness \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Test-Harness-3.48-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "346be9b2d1c68f06cc9a59d82bbb1c0f95c2bf6272a0de8537ac6c0302db2fac"

URI_x86_64_v2_perl-Test-Harness = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Test-Harness-3.48-512.el10.noarch.rpm;name=x86_64_v2_perl-Test-Harness;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-Harness}"
SRC_URI[x86_64_v2_perl-Test-Harness.sha256sum] = "4f95d7364a0d07a80da4d923104c661dee34ac09ec600bd4ce092569a36049fd"

URI_aarch64_perl-Test-Harness = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Test-Harness-3.48-512.el10.noarch.rpm;name=aarch64_perl-Test-Harness;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-Harness}"
SRC_URI[aarch64_perl-Test-Harness.sha256sum] = "4f95d7364a0d07a80da4d923104c661dee34ac09ec600bd4ce092569a36049fd"

RDEPENDS:perl-Test-Harness = " \
 perl-Benchmark \
 perl-Carp \
 perl-Errno \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Find \
 perl-File-Path \
 perl-Getopt-Long \
 perl-IO \
 perl-POSIX \
 perl-PathTools \
 perl-Test-Harness \
 perl-Text-ParseWords \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-libs \
 "
