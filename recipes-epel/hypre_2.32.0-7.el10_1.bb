# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hypre"
PV = "2.32.0"
PR = "7.el10_1"
PACKAGES = " \
 hypre \
 hypre-devel \
 hypre-doc \
 hypre-mpich \
 hypre-mpich-devel \
 hypre-openmpi \
 hypre-openmpi-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/hypre-2.32.0-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cbc6db9d2d1e7daa543391b24f2b168549fa3518f61611584e1a3d5d28a90440"

URI_x86_64_v2_hypre = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hypre-2.32.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hypre;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hypre}"
SRC_URI[x86_64_v2_hypre.sha256sum] = "6b4552b4461f89cc5f174662c76cf4f2d6d2b5e49de532e7b10c0bd9ca2a3ee5"

URI_x86_64_v2_hypre-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hypre-devel-2.32.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hypre-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hypre-devel}"
SRC_URI[x86_64_v2_hypre-devel.sha256sum] = "02051065cc85c3986c2c36bfc30e3e99981a9a88a4f4bcf9d5ca032adec74863"

URI_x86_64_v2_hypre-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hypre-doc-2.32.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_hypre-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hypre-doc}"
SRC_URI[x86_64_v2_hypre-doc.sha256sum] = "ae5053f46716caf57abc7a6bb25bbc314299a1ad37f8fb634c03ffd2f4313b65"

URI_x86_64_v2_hypre-mpich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hypre-mpich-2.32.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hypre-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hypre-mpich}"
SRC_URI[x86_64_v2_hypre-mpich.sha256sum] = "b268fb6e91acc9fe19da08ed1401df4f66c4ee81b3ceef716f25b0bae55d11ff"

URI_x86_64_v2_hypre-mpich-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hypre-mpich-devel-2.32.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hypre-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hypre-mpich-devel}"
SRC_URI[x86_64_v2_hypre-mpich-devel.sha256sum] = "323cc64ad8d6567eef0105638bb099336b9838f90a1dd948478b75074759f75a"

URI_x86_64_v2_hypre-openmpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hypre-openmpi-2.32.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hypre-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hypre-openmpi}"
SRC_URI[x86_64_v2_hypre-openmpi.sha256sum] = "d13152253fd4bb151c739fe23491693c0f8716475a6bf73dd500bd90adee8523"

URI_x86_64_v2_hypre-openmpi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hypre-openmpi-devel-2.32.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hypre-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hypre-openmpi-devel}"
SRC_URI[x86_64_v2_hypre-openmpi-devel.sha256sum] = "8496b6959bd6645280f76534784f6d220ef9ca6325e825537989946ecf6cef15"

URI_aarch64_hypre = "${EPEL_MIRROR}/aarch64/Packages/h/hypre-2.32.0-7.el10_1.aarch64.rpm;name=aarch64_hypre;unpack=0"
SRC_URI:append = " ${URI_aarch64_hypre}"
SRC_URI[aarch64_hypre.sha256sum] = "10777e94cc1d576fdecd5bf99beb96ebcb75c49f8d92511890b2d939f1a65d70"

URI_aarch64_hypre-devel = "${EPEL_MIRROR}/aarch64/Packages/h/hypre-devel-2.32.0-7.el10_1.aarch64.rpm;name=aarch64_hypre-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_hypre-devel}"
SRC_URI[aarch64_hypre-devel.sha256sum] = "5ce8c59519a6d81f0ee45beee552ead9b141b9e212ca7eaa04f07af0853b59ff"

URI_aarch64_hypre-doc = "${EPEL_MIRROR}/aarch64/Packages/h/hypre-doc-2.32.0-7.el10_1.noarch.rpm;name=aarch64_hypre-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_hypre-doc}"
SRC_URI[aarch64_hypre-doc.sha256sum] = "b1157535e28cf5bdf363bcd6556343991caee237184300de8d83307d2646c77c"

URI_aarch64_hypre-mpich = "${EPEL_MIRROR}/aarch64/Packages/h/hypre-mpich-2.32.0-7.el10_1.aarch64.rpm;name=aarch64_hypre-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_hypre-mpich}"
SRC_URI[aarch64_hypre-mpich.sha256sum] = "242d686ebb32862d390ded91747f9b0d80e31f89adb2ea23f82ff5fc8f189612"

URI_aarch64_hypre-mpich-devel = "${EPEL_MIRROR}/aarch64/Packages/h/hypre-mpich-devel-2.32.0-7.el10_1.aarch64.rpm;name=aarch64_hypre-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_hypre-mpich-devel}"
SRC_URI[aarch64_hypre-mpich-devel.sha256sum] = "b20fb8e17f9ac47da6cf1f6345b5e5025817e94ae14b7067d274ac20872f0fc0"

URI_aarch64_hypre-openmpi = "${EPEL_MIRROR}/aarch64/Packages/h/hypre-openmpi-2.32.0-7.el10_1.aarch64.rpm;name=aarch64_hypre-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_hypre-openmpi}"
SRC_URI[aarch64_hypre-openmpi.sha256sum] = "f944b29d184459992281a46df477b4d00bc105b4449a3732c5b5e4d390a2c3c5"

URI_aarch64_hypre-openmpi-devel = "${EPEL_MIRROR}/aarch64/Packages/h/hypre-openmpi-devel-2.32.0-7.el10_1.aarch64.rpm;name=aarch64_hypre-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_hypre-openmpi-devel}"
SRC_URI[aarch64_hypre-openmpi-devel.sha256sum] = "1f408e9cdc17f2a6e0b49d8806f3a8851c24de61a9c854c088c1bcd7081916ba"

RDEPENDS:hypre = " \
 glibc \
 libgcc \
 libgomp \
 "
RDEPENDS:hypre-devel = " \
 SuperLU-devel \
 cmake-filesystem \
 flexiblas-devel \
 hypre \
 "
RDEPENDS:hypre-doc = " \
 "
RDEPENDS:hypre-mpich = " \
 glibc \
 libgcc \
 libgomp \
 mpich \
 "
RDEPENDS:hypre-mpich-devel = " \
 flexiblas-devel \
 hypre-mpich \
 mpich-devel \
 ptscotch-mpich-devel \
 superlu_dist-mpich-devel \
 "
RDEPENDS:hypre-openmpi = " \
 glibc \
 libgcc \
 libgomp \
 openmpi \
 "
RDEPENDS:hypre-openmpi-devel = " \
 flexiblas-devel \
 hypre-openmpi \
 openmpi-devel \
 ptscotch-openmpi-devel \
 superlu_dist-openmpi-devel \
 "
