# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libsqlite3-sys"
PV = "0.28.0"
PR = "3.el10_0"
PACKAGES = " \
 rust-libsqlite3-sys+buildtime_bindgen-devel \
 rust-libsqlite3-sys+default-devel \
 rust-libsqlite3-sys+min_sqlite_version_3_14_0-devel \
 rust-libsqlite3-sys+preupdate_hook-devel \
 rust-libsqlite3-sys+session-devel \
 rust-libsqlite3-sys+unlock_notify-devel \
 rust-libsqlite3-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libsqlite3-sys-0.28.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb873766b29abfed1abe580ad7b9fee0599f6af5d1241cc50d66b555cdd82c2c"

URI_x86_64_v2_rust-libsqlite3-sys+buildtime_bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libsqlite3-sys+buildtime_bindgen-devel-0.28.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libsqlite3-sys+buildtime_bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libsqlite3-sys+buildtime_bindgen-devel}"
SRC_URI[x86_64_v2_rust-libsqlite3-sys+buildtime_bindgen-devel.sha256sum] = "7cca1a24fe2f9f044ca72a6f303b31139e933ec54b64e58ad8b2781aa1a9b5cc"

URI_x86_64_v2_rust-libsqlite3-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libsqlite3-sys+default-devel-0.28.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libsqlite3-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libsqlite3-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libsqlite3-sys+default-devel.sha256sum] = "bbb6147089fca130f4b6eb2ed9eee3b08ee33125a11f32a7db2e19575f3aa9ed"

URI_x86_64_v2_rust-libsqlite3-sys+min_sqlite_version_3_14_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libsqlite3-sys+min_sqlite_version_3_14_0-devel-0.28.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libsqlite3-sys+min_sqlite_version_3_14_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libsqlite3-sys+min_sqlite_version_3_14_0-devel}"
SRC_URI[x86_64_v2_rust-libsqlite3-sys+min_sqlite_version_3_14_0-devel.sha256sum] = "fecade782b66154654cc38e70c50f5edaade000cf1be4cd59e3f75dcde4d2c88"

URI_x86_64_v2_rust-libsqlite3-sys+preupdate_hook-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libsqlite3-sys+preupdate_hook-devel-0.28.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libsqlite3-sys+preupdate_hook-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libsqlite3-sys+preupdate_hook-devel}"
SRC_URI[x86_64_v2_rust-libsqlite3-sys+preupdate_hook-devel.sha256sum] = "c13354312b1c144e8720343906a49dac3c006b5e410ed82e3bb421f221e72eb1"

URI_x86_64_v2_rust-libsqlite3-sys+session-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libsqlite3-sys+session-devel-0.28.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libsqlite3-sys+session-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libsqlite3-sys+session-devel}"
SRC_URI[x86_64_v2_rust-libsqlite3-sys+session-devel.sha256sum] = "074f09fcd2f9755eb141c29ff56f4d7262d945e6dd97293eb225c95acd0768d9"

URI_x86_64_v2_rust-libsqlite3-sys+unlock_notify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libsqlite3-sys+unlock_notify-devel-0.28.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libsqlite3-sys+unlock_notify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libsqlite3-sys+unlock_notify-devel}"
SRC_URI[x86_64_v2_rust-libsqlite3-sys+unlock_notify-devel.sha256sum] = "d995f0c551517b5b5e9ea576d800e9d85603faf5e736975d8c97baf8904e5650"

URI_x86_64_v2_rust-libsqlite3-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libsqlite3-sys-devel-0.28.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libsqlite3-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libsqlite3-sys-devel}"
SRC_URI[x86_64_v2_rust-libsqlite3-sys-devel.sha256sum] = "c3e762c43051ce135ee6e2575c69099acc483f26f89075928bddee8ac10992bf"

URI_aarch64_rust-libsqlite3-sys+buildtime_bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libsqlite3-sys+buildtime_bindgen-devel-0.28.0-3.el10_0.noarch.rpm;name=aarch64_rust-libsqlite3-sys+buildtime_bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libsqlite3-sys+buildtime_bindgen-devel}"
SRC_URI[aarch64_rust-libsqlite3-sys+buildtime_bindgen-devel.sha256sum] = "b7c4bb5536d5bc63cccb556e5ab883102c0e4d5a6b0e2dc4c61d88232b946fb3"

URI_aarch64_rust-libsqlite3-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libsqlite3-sys+default-devel-0.28.0-3.el10_0.noarch.rpm;name=aarch64_rust-libsqlite3-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libsqlite3-sys+default-devel}"
SRC_URI[aarch64_rust-libsqlite3-sys+default-devel.sha256sum] = "42f8a1ffbbb9711ec64300bf5bae62cec9abadba5d632f1952c72c2d097bcfe7"

URI_aarch64_rust-libsqlite3-sys+min_sqlite_version_3_14_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libsqlite3-sys+min_sqlite_version_3_14_0-devel-0.28.0-3.el10_0.noarch.rpm;name=aarch64_rust-libsqlite3-sys+min_sqlite_version_3_14_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libsqlite3-sys+min_sqlite_version_3_14_0-devel}"
SRC_URI[aarch64_rust-libsqlite3-sys+min_sqlite_version_3_14_0-devel.sha256sum] = "3d250a6e98970a003269805db2607a30ce239c2d37daef935e8eec690bf20950"

URI_aarch64_rust-libsqlite3-sys+preupdate_hook-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libsqlite3-sys+preupdate_hook-devel-0.28.0-3.el10_0.noarch.rpm;name=aarch64_rust-libsqlite3-sys+preupdate_hook-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libsqlite3-sys+preupdate_hook-devel}"
SRC_URI[aarch64_rust-libsqlite3-sys+preupdate_hook-devel.sha256sum] = "c3d455a0f3b3ce4316378f4b3914769daaa998f92df8b09f3af419df7651b409"

URI_aarch64_rust-libsqlite3-sys+session-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libsqlite3-sys+session-devel-0.28.0-3.el10_0.noarch.rpm;name=aarch64_rust-libsqlite3-sys+session-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libsqlite3-sys+session-devel}"
SRC_URI[aarch64_rust-libsqlite3-sys+session-devel.sha256sum] = "a4a69c7307919967698b7630da4f8dac7c24aebd6de9eff7acabc48b4b0ff264"

URI_aarch64_rust-libsqlite3-sys+unlock_notify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libsqlite3-sys+unlock_notify-devel-0.28.0-3.el10_0.noarch.rpm;name=aarch64_rust-libsqlite3-sys+unlock_notify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libsqlite3-sys+unlock_notify-devel}"
SRC_URI[aarch64_rust-libsqlite3-sys+unlock_notify-devel.sha256sum] = "6e88fc876e434566129408826bf0cf5562b3d8e718e0e02a7c967d6cac57909c"

URI_aarch64_rust-libsqlite3-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libsqlite3-sys-devel-0.28.0-3.el10_0.noarch.rpm;name=aarch64_rust-libsqlite3-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libsqlite3-sys-devel}"
SRC_URI[aarch64_rust-libsqlite3-sys-devel.sha256sum] = "5b0730f1e97472aabba97f642cbd01df1e7be9522fe3857431fe9dc4336046f3"

RDEPENDS:rust-libsqlite3-sys+buildtime_bindgen-devel = " \
 cargo \
 rust-libsqlite3-sys-devel \
 "
RDEPENDS:rust-libsqlite3-sys+default-devel = " \
 cargo \
 rust-libsqlite3-sys+min_sqlite_version_3_14_0-devel \
 rust-libsqlite3-sys-devel \
 "
RDEPENDS:rust-libsqlite3-sys+min_sqlite_version_3_14_0-devel = " \
 cargo \
 rust-libsqlite3-sys-devel \
 "
RDEPENDS:rust-libsqlite3-sys+preupdate_hook-devel = " \
 cargo \
 rust-libsqlite3-sys+buildtime_bindgen-devel \
 rust-libsqlite3-sys-devel \
 "
RDEPENDS:rust-libsqlite3-sys+session-devel = " \
 cargo \
 rust-libsqlite3-sys+buildtime_bindgen-devel \
 rust-libsqlite3-sys+preupdate_hook-devel \
 rust-libsqlite3-sys-devel \
 "
RDEPENDS:rust-libsqlite3-sys+unlock_notify-devel = " \
 cargo \
 rust-libsqlite3-sys-devel \
 "
RDEPENDS:rust-libsqlite3-sys-devel = " \
 cargo \
 rust-bindgen0.69+runtime-devel \
 rust-bindgen0.69-devel \
 rust-pkg-config+default-devel \
 sqlite-devel \
 "
