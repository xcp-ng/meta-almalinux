# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "easymock"
PV = "4.3"
PR = "9.el10"
PACKAGES = " \
 easymock \
 easymock-javadoc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/easymock-4.3-9.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a53c189ceb2f4f63c8e2ecada61741fd8a5c8ff8799dcb3b5c064c59999b3fdd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/easymock-4.3-9.el10.noarch.rpm;name=x86_64_v2_easymock;unpack=0"
SRC_URI[x86_64_v2_easymock.sha256sum] = "ed2b852213e10b0af11f72dbda492352bcafc710b51ec6feef365ac5ec4566a5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/easymock-javadoc-4.3-9.el10.noarch.rpm;name=x86_64_v2_easymock-javadoc;unpack=0"
SRC_URI[x86_64_v2_easymock-javadoc.sha256sum] = "0e4d6e5f0a9ebfa4541c14b8d96efc9df6c4d49b44a49bb221e0011141a4f601"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/easymock-4.3-9.el10.noarch.rpm;name=aarch64_easymock;unpack=0"
SRC_URI[aarch64_easymock.sha256sum] = "ed2b852213e10b0af11f72dbda492352bcafc710b51ec6feef365ac5ec4566a5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/easymock-javadoc-4.3-9.el10.noarch.rpm;name=aarch64_easymock-javadoc;unpack=0"
SRC_URI[aarch64_easymock-javadoc.sha256sum] = "0e4d6e5f0a9ebfa4541c14b8d96efc9df6c4d49b44a49bb221e0011141a4f601"

RDEPENDS:easymock = " \
 cglib \
 javapackages-filesystem \
 objectweb-asm \
 objenesis \
 "
RDEPENDS:easymock-javadoc = " \
 javapackages-filesystem \
 "
