# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "calindori"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 calindori \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/calindori-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "37937506bf4aaf62c056a99bd2617db025f7015fef89f019c001cb07894b60e4"

URI_x86_64_v2_calindori = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/calindori-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_calindori;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_calindori}"
SRC_URI[x86_64_v2_calindori.sha256sum] = "05853717bd65acd007ada5798a9bf742538455974428d22ab26c0f091e958359"

URI_aarch64_calindori = "${EPEL_MIRROR}/aarch64/Packages/c/calindori-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_calindori;unpack=0"
SRC_URI:append = " ${URI_aarch64_calindori}"
SRC_URI[aarch64_calindori.sha256sum] = "526cec379504cabf44c80a2d7be21885905cb718289d77002a7578ce0a0e12ba"

RDEPENDS:calindori = " \
 glibc \
 hicolor-icon-theme \
 kf6-kcalendarcore \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-knotifications \
 kf6-kpeople \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwayland \
 "
