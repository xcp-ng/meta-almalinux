# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-statsmodels"
PV = "0.14.1"
PR = "6.el10_0"
PACKAGES = " \
 python3-statsmodels \
 python3-statsmodels-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-statsmodels-0.14.1-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ea6f693d8055d5e74acd96ce624fdd2be5432dee70288e9e1403df3578d1692"

URI_x86_64_v2_python3-statsmodels = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-statsmodels-0.14.1-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-statsmodels;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-statsmodels}"
SRC_URI[x86_64_v2_python3-statsmodels.sha256sum] = "c88c443ce48a1355ed75faec8975077900555461b2db48377ba5d536fd623397"

URI_x86_64_v2_python3-statsmodels-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-statsmodels-doc-0.14.1-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-statsmodels-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-statsmodels-doc}"
SRC_URI[x86_64_v2_python3-statsmodels-doc.sha256sum] = "1988439b0a56ae6f31a7a24cc9a8815845dea21244d5e0993e39ffd7a8debbfc"

URI_aarch64_python3-statsmodels = "${EPEL_MIRROR}/aarch64/Packages/p/python3-statsmodels-0.14.1-6.el10_0.aarch64.rpm;name=aarch64_python3-statsmodels;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-statsmodels}"
SRC_URI[aarch64_python3-statsmodels.sha256sum] = "81ebd806c4eb5347dee9dd6da7c0b4c4224994a6fe93383e8441cc6ca7f892eb"

URI_aarch64_python3-statsmodels-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python3-statsmodels-doc-0.14.1-6.el10_0.noarch.rpm;name=aarch64_python3-statsmodels-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-statsmodels-doc}"
SRC_URI[aarch64_python3-statsmodels-doc.sha256sum] = "1d2ccb3d1e5d43bb1647d66a77d9740ab6d3b3163d9d72ece923d74b7bf6ad95"

RDEPENDS:python3-statsmodels = " \
 glibc \
 python3 \
 python3-numpy \
 python3-packaging \
 python3-pandas \
 python3-patsy \
 python3-scipy \
 "
RDEPENDS:python3-statsmodels-doc = " \
 "
