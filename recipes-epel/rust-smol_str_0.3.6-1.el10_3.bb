# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-smol_str"
PV = "0.3.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-smol_str+arbitrary-devel \
 rust-smol_str+default-devel \
 rust-smol_str+serde-devel \
 rust-smol_str+std-devel \
 rust-smol_str-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-smol_str-0.3.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a1ea1765fa66b892b1d1e03626c348bdc7778fabafd565c6b5360e214e853cfa"

URI_x86_64_v2_rust-smol_str+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smol_str+arbitrary-devel-0.3.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smol_str+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smol_str+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-smol_str+arbitrary-devel.sha256sum] = "896a7be3b0b2c41fcb9e5365de5e9c29b2919491c014f1a8cfc606622430eeb0"

URI_x86_64_v2_rust-smol_str+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smol_str+default-devel-0.3.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smol_str+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smol_str+default-devel}"
SRC_URI[x86_64_v2_rust-smol_str+default-devel.sha256sum] = "0c431fccb6a172df3a937ccba6e2f39cc5012fa1476b083b0139a97550bf45a1"

URI_x86_64_v2_rust-smol_str+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smol_str+serde-devel-0.3.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smol_str+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smol_str+serde-devel}"
SRC_URI[x86_64_v2_rust-smol_str+serde-devel.sha256sum] = "d3d9e1c9d17f5f48f22ebe22dd5a55afb3b392c801a418f0b275ad868b1acd8c"

URI_x86_64_v2_rust-smol_str+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smol_str+std-devel-0.3.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smol_str+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smol_str+std-devel}"
SRC_URI[x86_64_v2_rust-smol_str+std-devel.sha256sum] = "599d145750aeb8068f0ecd94186ccff8108d3684a7c9c57716238edf45fa4d1c"

URI_x86_64_v2_rust-smol_str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smol_str-devel-0.3.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smol_str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smol_str-devel}"
SRC_URI[x86_64_v2_rust-smol_str-devel.sha256sum] = "93f460f055188498aed533331a615d4e1c8ec4f7693177d8b49961d6bc38aaf2"

URI_aarch64_rust-smol_str+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smol_str+arbitrary-devel-0.3.6-1.el10_3.noarch.rpm;name=aarch64_rust-smol_str+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smol_str+arbitrary-devel}"
SRC_URI[aarch64_rust-smol_str+arbitrary-devel.sha256sum] = "94f49669dfc3664f1d41cb7998027ef27fdfd0a772aa9e6db7abe817ca476f8f"

URI_aarch64_rust-smol_str+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smol_str+default-devel-0.3.6-1.el10_3.noarch.rpm;name=aarch64_rust-smol_str+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smol_str+default-devel}"
SRC_URI[aarch64_rust-smol_str+default-devel.sha256sum] = "a2365e3d48f33c14436cfabb3ab153d1ac65d6a15f40d445cc1ad4f32c8d886e"

URI_aarch64_rust-smol_str+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smol_str+serde-devel-0.3.6-1.el10_3.noarch.rpm;name=aarch64_rust-smol_str+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smol_str+serde-devel}"
SRC_URI[aarch64_rust-smol_str+serde-devel.sha256sum] = "a0750d32294722a7516815cfbf75e7eacf2452b73cab6330f6fa960fa8cce089"

URI_aarch64_rust-smol_str+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smol_str+std-devel-0.3.6-1.el10_3.noarch.rpm;name=aarch64_rust-smol_str+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smol_str+std-devel}"
SRC_URI[aarch64_rust-smol_str+std-devel.sha256sum] = "a774af372b27c862ed06f69220ddd4a767766c566ccdcde3bb49e1e76e4163fa"

URI_aarch64_rust-smol_str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smol_str-devel-0.3.6-1.el10_3.noarch.rpm;name=aarch64_rust-smol_str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smol_str-devel}"
SRC_URI[aarch64_rust-smol_str-devel.sha256sum] = "32c776a109a7484daac6cd88fa1426dd48e14699f38f36dfd2e9fea414f6c840"

RDEPENDS:rust-smol_str+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-smol_str-devel \
 "
RDEPENDS:rust-smol_str+default-devel = " \
 cargo \
 rust-smol_str+std-devel \
 rust-smol_str-devel \
 "
RDEPENDS:rust-smol_str+serde-devel = " \
 cargo \
 rust-serde_core-devel \
 rust-smol_str-devel \
 "
RDEPENDS:rust-smol_str+std-devel = " \
 cargo \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 rust-smol_str-devel \
 "
RDEPENDS:rust-smol_str-devel = " \
 cargo \
 rust \
 "
