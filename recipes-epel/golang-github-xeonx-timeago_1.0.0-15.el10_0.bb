# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-xeonx-timeago"
PV = "1.0.0"
PR = "15.el10_0"
PACKAGES = " \
 golang-github-xeonx-timeago-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-xeonx-timeago-1.0.0-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "094dcc418130a8bd7ca71ac3d28fc3e43c4cefc266350a716bc2880a1d60e214"

URI_x86_64_v2_golang-github-xeonx-timeago-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-xeonx-timeago-devel-1.0.0-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-xeonx-timeago-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-xeonx-timeago-devel}"
SRC_URI[x86_64_v2_golang-github-xeonx-timeago-devel.sha256sum] = "105f8b7e9eb0f8d9eafeaf35e2a5af3d72d83b56ef2485eca2c3d2705e94b631"

URI_aarch64_golang-github-xeonx-timeago-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-xeonx-timeago-devel-1.0.0-15.el10_0.noarch.rpm;name=aarch64_golang-github-xeonx-timeago-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-xeonx-timeago-devel}"
SRC_URI[aarch64_golang-github-xeonx-timeago-devel.sha256sum] = "2c3fbf7c1f2289e4ba5e0f3221804f51bb7de8a27ba51b4505b047ae1ff76816"

RDEPENDS:golang-github-xeonx-timeago-devel = " \
 go-filesystem \
 "
