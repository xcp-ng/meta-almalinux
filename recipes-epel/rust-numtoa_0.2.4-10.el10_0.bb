# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-numtoa"
PV = "0.2.4"
PR = "10.el10_0"
PACKAGES = " \
 rust-numtoa+default-devel \
 rust-numtoa-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-numtoa-0.2.4-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0827ccdd27644d083eea4a4c29d152a2695eee3df2964ac65bc4f40c7d83d86f"

URI_x86_64_v2_rust-numtoa+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-numtoa+default-devel-0.2.4-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-numtoa+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-numtoa+default-devel}"
SRC_URI[x86_64_v2_rust-numtoa+default-devel.sha256sum] = "fd2ec2ca3b0f2fa366ff56de626897311b26715c7373635fc96bdae20bf2299f"

URI_x86_64_v2_rust-numtoa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-numtoa-devel-0.2.4-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-numtoa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-numtoa-devel}"
SRC_URI[x86_64_v2_rust-numtoa-devel.sha256sum] = "3b291622a6b79d42630810b53182de9ab8678b289a7b77e0b553055d7fb32c7f"

URI_aarch64_rust-numtoa+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-numtoa+default-devel-0.2.4-10.el10_0.noarch.rpm;name=aarch64_rust-numtoa+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-numtoa+default-devel}"
SRC_URI[aarch64_rust-numtoa+default-devel.sha256sum] = "815048f545740e8281c1bbc386b99ea776f3cf86d8310c306fb704398f012264"

URI_aarch64_rust-numtoa-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-numtoa-devel-0.2.4-10.el10_0.noarch.rpm;name=aarch64_rust-numtoa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-numtoa-devel}"
SRC_URI[aarch64_rust-numtoa-devel.sha256sum] = "97ea6c462f9e1bd614840d8f9b691c8723e02ed64133550a1151cd2e050905ad"

RDEPENDS:rust-numtoa+default-devel = " \
 cargo \
 rust-numtoa-devel \
 "
RDEPENDS:rust-numtoa-devel = " \
 cargo \
 "
