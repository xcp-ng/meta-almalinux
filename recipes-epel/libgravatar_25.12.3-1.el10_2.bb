# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgravatar"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 libgravatar \
 libgravatar-devel \
 libgravatar-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libgravatar-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "73b6a602802fb41a8be5e537a1fd450c53971e00211c7ec25ae7f84b92585f97"

URI_x86_64_v2_libgravatar = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgravatar-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgravatar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgravatar}"
SRC_URI[x86_64_v2_libgravatar.sha256sum] = "a1fd288294b3714c928ac0a7da15fc2c461307bb73e2661763f439132946d0bf"

URI_x86_64_v2_libgravatar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgravatar-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgravatar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgravatar-devel}"
SRC_URI[x86_64_v2_libgravatar-devel.sha256sum] = "8e2666fb7f5385211f966f1e5600ad434d5129e53a68ed35c4defbef455db5f7"

URI_x86_64_v2_libgravatar-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgravatar-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_libgravatar-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgravatar-doc}"
SRC_URI[x86_64_v2_libgravatar-doc.sha256sum] = "0e7940eefaa3a5818a6ff6b31d36ad80e83daf77cc41982f7994265590f67c2b"

URI_aarch64_libgravatar = "${EPEL_MIRROR}/aarch64/Packages/l/libgravatar-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_libgravatar;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgravatar}"
SRC_URI[aarch64_libgravatar.sha256sum] = "5792e8a7a802434151fa44d8f365c257655c8c01fc41ff976c42976e033c50f8"

URI_aarch64_libgravatar-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libgravatar-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_libgravatar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgravatar-devel}"
SRC_URI[aarch64_libgravatar-devel.sha256sum] = "ef7517dbfed7f80d10b8d4fd330ad39ff2377b0276560e85e2171222e39d987f"

URI_aarch64_libgravatar-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libgravatar-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_libgravatar-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgravatar-doc}"
SRC_URI[aarch64_libgravatar-doc.sha256sum] = "cf618088390196f4c385b54013a32842a404a5bf16b669fd2e9e08486061aaf0"

RDEPENDS:libgravatar = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libgravatar-devel = " \
 cmake-filesystem \
 libgravatar \
 "
RDEPENDS:libgravatar-doc = " \
 "
