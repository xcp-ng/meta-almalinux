# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-smallvec"
PV = "1.15.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-smallvec+arbitrary-devel \
 rust-smallvec+const_generics-devel \
 rust-smallvec+const_new-devel \
 rust-smallvec+debugger_visualizer-devel \
 rust-smallvec+default-devel \
 rust-smallvec+drain_filter-devel \
 rust-smallvec+drain_keep_rest-devel \
 rust-smallvec+may_dangle-devel \
 rust-smallvec+serde-devel \
 rust-smallvec+specialization-devel \
 rust-smallvec+union-devel \
 rust-smallvec+write-devel \
 rust-smallvec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-smallvec-1.15.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "08418df0ac89ee8e93940d38cc4c7d4e8e140ea2526d5c2d278c73aaba990a27"

URI_x86_64_v2_rust-smallvec+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+arbitrary-devel-1.15.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smallvec+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-smallvec+arbitrary-devel.sha256sum] = "dada2115bf481f7f51febb419d30ade92f1e470596af0ebc30bb45b3fa938272"

URI_x86_64_v2_rust-smallvec+const_generics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+const_generics-devel-1.15.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+const_generics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smallvec+const_generics-devel}"
SRC_URI[x86_64_v2_rust-smallvec+const_generics-devel.sha256sum] = "3661e8cc73b935b752d201eee20dc00bacd5b62d31c8ff198b2ba1c3323b991d"

URI_x86_64_v2_rust-smallvec+const_new-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+const_new-devel-1.15.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+const_new-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smallvec+const_new-devel}"
SRC_URI[x86_64_v2_rust-smallvec+const_new-devel.sha256sum] = "013c6dcff6636ffd2d76b63ec60e4e2bd250b2df17b403654f80b0650c78b9fd"

URI_x86_64_v2_rust-smallvec+debugger_visualizer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+debugger_visualizer-devel-1.15.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+debugger_visualizer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smallvec+debugger_visualizer-devel}"
SRC_URI[x86_64_v2_rust-smallvec+debugger_visualizer-devel.sha256sum] = "5a015820f6dbaa8f2f1d4389802eeb06256b3d42aff0c0f8ad6819939bd4aa57"

URI_x86_64_v2_rust-smallvec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+default-devel-1.15.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smallvec+default-devel}"
SRC_URI[x86_64_v2_rust-smallvec+default-devel.sha256sum] = "edb90f7441b960c6f2ca3c70cc7c9bcfff35ac39929c96212f1a20af9cda0959"

URI_x86_64_v2_rust-smallvec+drain_filter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+drain_filter-devel-1.15.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+drain_filter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smallvec+drain_filter-devel}"
SRC_URI[x86_64_v2_rust-smallvec+drain_filter-devel.sha256sum] = "95afe1866405f083d242643c26b2aa26f87dbc90d24280c654e07651af75adee"

URI_x86_64_v2_rust-smallvec+drain_keep_rest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+drain_keep_rest-devel-1.15.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+drain_keep_rest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smallvec+drain_keep_rest-devel}"
SRC_URI[x86_64_v2_rust-smallvec+drain_keep_rest-devel.sha256sum] = "fce64661446e7f2b8809178fa2ec57850eb992bda1ad7fe16d29f30c4e9a4c88"

URI_x86_64_v2_rust-smallvec+may_dangle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+may_dangle-devel-1.15.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+may_dangle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smallvec+may_dangle-devel}"
SRC_URI[x86_64_v2_rust-smallvec+may_dangle-devel.sha256sum] = "5b47afb06c9165871e49b76c22a34716e622ce2a6ff53b9cc3fbdb9ebd1a7bed"

URI_x86_64_v2_rust-smallvec+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+serde-devel-1.15.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smallvec+serde-devel}"
SRC_URI[x86_64_v2_rust-smallvec+serde-devel.sha256sum] = "f15b04c15e455a50159b35b77824f06a8fdaac9ebf5d24d18ef33d593e9b6bb5"

URI_x86_64_v2_rust-smallvec+specialization-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+specialization-devel-1.15.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+specialization-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smallvec+specialization-devel}"
SRC_URI[x86_64_v2_rust-smallvec+specialization-devel.sha256sum] = "4b82b28604930d5d2c7f344026b11a60b6130aacc0e6088de17a229520d05c38"

URI_x86_64_v2_rust-smallvec+union-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+union-devel-1.15.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+union-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smallvec+union-devel}"
SRC_URI[x86_64_v2_rust-smallvec+union-devel.sha256sum] = "4e6175ead84e47791c1e156ef947339b1fe7fe93cdbe8e50e5eb8f468dab0d92"

URI_x86_64_v2_rust-smallvec+write-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+write-devel-1.15.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+write-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smallvec+write-devel}"
SRC_URI[x86_64_v2_rust-smallvec+write-devel.sha256sum] = "e24a36c7c6674d2cd4345b179b7032f72b891db1543417cc1d4bdb86092e65f0"

URI_x86_64_v2_rust-smallvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec-devel-1.15.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smallvec-devel}"
SRC_URI[x86_64_v2_rust-smallvec-devel.sha256sum] = "04ce416519060125f7984c9863eeab9b9e9e1d54e2f48d3160f18749ef6beb50"

URI_aarch64_rust-smallvec+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+arbitrary-devel-1.15.1-1.el10_1.noarch.rpm;name=aarch64_rust-smallvec+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smallvec+arbitrary-devel}"
SRC_URI[aarch64_rust-smallvec+arbitrary-devel.sha256sum] = "19ae7019be58ec5864de88a91bc5b5d581a3f9806c2b8c90836f467d0371471d"

URI_aarch64_rust-smallvec+const_generics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+const_generics-devel-1.15.1-1.el10_1.noarch.rpm;name=aarch64_rust-smallvec+const_generics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smallvec+const_generics-devel}"
SRC_URI[aarch64_rust-smallvec+const_generics-devel.sha256sum] = "99695ad9d2cb540f06305955f230e96f2d49b7820e5357813802317d38fe7399"

URI_aarch64_rust-smallvec+const_new-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+const_new-devel-1.15.1-1.el10_1.noarch.rpm;name=aarch64_rust-smallvec+const_new-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smallvec+const_new-devel}"
SRC_URI[aarch64_rust-smallvec+const_new-devel.sha256sum] = "077c82257d07664a59265492a2abccd5f35a4ff67ba0d8ced0866ba3ac325784"

URI_aarch64_rust-smallvec+debugger_visualizer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+debugger_visualizer-devel-1.15.1-1.el10_1.noarch.rpm;name=aarch64_rust-smallvec+debugger_visualizer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smallvec+debugger_visualizer-devel}"
SRC_URI[aarch64_rust-smallvec+debugger_visualizer-devel.sha256sum] = "934c61a211c10a20a11bdf4d65be7f3ed3ad196098fee1884e5b0ec64c48d885"

URI_aarch64_rust-smallvec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+default-devel-1.15.1-1.el10_1.noarch.rpm;name=aarch64_rust-smallvec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smallvec+default-devel}"
SRC_URI[aarch64_rust-smallvec+default-devel.sha256sum] = "beb3ed3ed245e8b719fca028abfca83769a004ee1e690daae769afc0a243a2c8"

URI_aarch64_rust-smallvec+drain_filter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+drain_filter-devel-1.15.1-1.el10_1.noarch.rpm;name=aarch64_rust-smallvec+drain_filter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smallvec+drain_filter-devel}"
SRC_URI[aarch64_rust-smallvec+drain_filter-devel.sha256sum] = "922e3bf4f18afc1689e0d5f210e8c54fb8d1a17738a20efb125fb710c4f86fc0"

URI_aarch64_rust-smallvec+drain_keep_rest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+drain_keep_rest-devel-1.15.1-1.el10_1.noarch.rpm;name=aarch64_rust-smallvec+drain_keep_rest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smallvec+drain_keep_rest-devel}"
SRC_URI[aarch64_rust-smallvec+drain_keep_rest-devel.sha256sum] = "a9d2969ec485103dbdefb4d8b724edaa1b515615f7cb500d0d4258e61069e9a2"

URI_aarch64_rust-smallvec+may_dangle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+may_dangle-devel-1.15.1-1.el10_1.noarch.rpm;name=aarch64_rust-smallvec+may_dangle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smallvec+may_dangle-devel}"
SRC_URI[aarch64_rust-smallvec+may_dangle-devel.sha256sum] = "2c0379f54e2dfec90227b9d54017db22534e4356c7d91e5bd480f967ca7edfac"

URI_aarch64_rust-smallvec+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+serde-devel-1.15.1-1.el10_1.noarch.rpm;name=aarch64_rust-smallvec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smallvec+serde-devel}"
SRC_URI[aarch64_rust-smallvec+serde-devel.sha256sum] = "df9ac916095761e149cdea4c01d841eb09430f105b3fe26973c7de6a24234aee"

URI_aarch64_rust-smallvec+specialization-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+specialization-devel-1.15.1-1.el10_1.noarch.rpm;name=aarch64_rust-smallvec+specialization-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smallvec+specialization-devel}"
SRC_URI[aarch64_rust-smallvec+specialization-devel.sha256sum] = "2512ce7204c218bf67f14b120e5fbc79149ddb66e1b37ecabec0da5fb79d7042"

URI_aarch64_rust-smallvec+union-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+union-devel-1.15.1-1.el10_1.noarch.rpm;name=aarch64_rust-smallvec+union-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smallvec+union-devel}"
SRC_URI[aarch64_rust-smallvec+union-devel.sha256sum] = "b673941783f4d7f85c7a1b95cbaf8121bd3cadaeb53e3a8fa9eb5f960280ae0d"

URI_aarch64_rust-smallvec+write-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+write-devel-1.15.1-1.el10_1.noarch.rpm;name=aarch64_rust-smallvec+write-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smallvec+write-devel}"
SRC_URI[aarch64_rust-smallvec+write-devel.sha256sum] = "1e3e12764ef62edd40289166163ddbf87ff679c6d3b9ef883a25b3f9d7ae655f"

URI_aarch64_rust-smallvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec-devel-1.15.1-1.el10_1.noarch.rpm;name=aarch64_rust-smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smallvec-devel}"
SRC_URI[aarch64_rust-smallvec-devel.sha256sum] = "443de348ea73727e23f9ff91578ba8d7956ee4956ff007e111eec003341fbf8d"

RDEPENDS:rust-smallvec+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+const_generics-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+const_new-devel = " \
 cargo \
 rust-smallvec+const_generics-devel \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+debugger_visualizer-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+default-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+drain_filter-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+drain_keep_rest-devel = " \
 cargo \
 rust-smallvec+drain_filter-devel \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+may_dangle-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+serde-devel = " \
 cargo \
 rust-serde-devel \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+specialization-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+union-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+write-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec-devel = " \
 cargo \
 "
