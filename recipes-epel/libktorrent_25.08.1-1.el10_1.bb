# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libktorrent"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 libktorrent \
 libktorrent-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libktorrent-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6dfc41e99cc6f4616c6f7e476695b71c7e4303e7b10ce35cfc750ec63d0ff5ab"

URI_x86_64_v2_libktorrent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libktorrent-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libktorrent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libktorrent}"
SRC_URI[x86_64_v2_libktorrent.sha256sum] = "ba79f8a029be79d63f652d17516f621b8f0bcf26f9f8068f12e3f39e4c45a8da"

URI_x86_64_v2_libktorrent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libktorrent-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libktorrent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libktorrent-devel}"
SRC_URI[x86_64_v2_libktorrent-devel.sha256sum] = "86505502c4882bb2cf3543fb52dcc5026dc5a55b57ccbfabc23d95a3807fdaa3"

URI_aarch64_libktorrent = "${EPEL_MIRROR}/aarch64/Packages/l/libktorrent-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_libktorrent;unpack=0"
SRC_URI:append = " ${URI_aarch64_libktorrent}"
SRC_URI[aarch64_libktorrent.sha256sum] = "a88f3492c67daf500fe3ba9818a6bca437bcb9db67d8082ec4d54a516eabf1b0"

URI_aarch64_libktorrent-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libktorrent-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_libktorrent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libktorrent-devel}"
SRC_URI[aarch64_libktorrent-devel.sha256sum] = "fb9a8834bcb7e06b9513ea9a745524acc8a535c0da701fd46380712e58d98978"

RDEPENDS:libktorrent = " \
 glibc \
 gmp \
 kf6-karchive \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 libgcc \
 libgcrypt \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:libktorrent-devel = " \
 boost-devel \
 cmake-filesystem \
 gmp-devel \
 kf6-karchive-devel \
 kf6-kconfig-devel \
 kf6-kio-devel \
 libgcrypt-devel \
 libktorrent \
 qt6-qtbase-devel \
 "
