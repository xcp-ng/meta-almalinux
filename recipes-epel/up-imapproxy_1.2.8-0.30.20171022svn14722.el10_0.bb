# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "up-imapproxy"
PV = "1.2.8"
PR = "0.30.20171022svn14722.el10_0"
PACKAGES = " \
 up-imapproxy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/up-imapproxy-1.2.8-0.30.20171022svn14722.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a2b98fa408d3a61e6a901426c8dc2542d33c5b43a8966bf9c1757c13c0b515d"

URI_x86_64_v2_up-imapproxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/up-imapproxy-1.2.8-0.30.20171022svn14722.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_up-imapproxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_up-imapproxy}"
SRC_URI[x86_64_v2_up-imapproxy.sha256sum] = "eeadc0967a2affb328317e9ae781cf2cee01a745841f58cbcf7bfdc7fb0e5f6e"

URI_aarch64_up-imapproxy = "${EPEL_MIRROR}/aarch64/Packages/u/up-imapproxy-1.2.8-0.30.20171022svn14722.el10_0.aarch64.rpm;name=aarch64_up-imapproxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_up-imapproxy}"
SRC_URI[aarch64_up-imapproxy.sha256sum] = "7b99750b721102896b1effe8bc654870569847865f8e42dacd43d6dc2de5ae6d"

RDEPENDS:up-imapproxy = " \
 bash \
 glibc \
 ncurses-libs \
 openssl-libs \
 shadow-utils \
 systemd \
 "
