# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "epstool"
PV = "3.08"
PR = "33.el10_2"
PACKAGES = " \
 epstool \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/epstool-3.08-33.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91caffa5c8f394d7909576b41f41b3bdad3fd21c2430df102600e92b1aef3e22"

URI_x86_64_v2_epstool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/epstool-3.08-33.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_epstool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_epstool}"
SRC_URI[x86_64_v2_epstool.sha256sum] = "1bb485af775e307d12930d5c9c3953766b3a29180fc730c07cd5326a48c4295f"

URI_aarch64_epstool = "${EPEL_MIRROR}/aarch64/Packages/e/epstool-3.08-33.el10_2.aarch64.rpm;name=aarch64_epstool;unpack=0"
SRC_URI:append = " ${URI_aarch64_epstool}"
SRC_URI[aarch64_epstool.sha256sum] = "2f6cf19c3536049bc6d273f5852fe9ce77b210476e6bbae9d948357d85bd9229"

RDEPENDS:epstool = " \
 glibc \
 "
