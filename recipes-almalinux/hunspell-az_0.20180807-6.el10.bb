# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-az"
PV = "0.20180807"
PR = "6.el10"
PACKAGES = " \
 hunspell-az \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-az-0.20180807-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "13dc8aa03f28e1b2d0fb089e7ea9b32e51d4454aa2c18e1e270658814945437e"

URI_x86_64_v2_hunspell-az = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-az-0.20180807-6.el10.noarch.rpm;name=x86_64_v2_hunspell-az;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-az}"
SRC_URI[x86_64_v2_hunspell-az.sha256sum] = "4689ca5cc8c84d80cf56264278046d119e98df7dc1e2886d9319787d27fdbd50"

URI_aarch64_hunspell-az = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-az-0.20180807-6.el10.noarch.rpm;name=aarch64_hunspell-az;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-az}"
SRC_URI[aarch64_hunspell-az.sha256sum] = "4689ca5cc8c84d80cf56264278046d119e98df7dc1e2886d9319787d27fdbd50"

RDEPENDS:hunspell-az = " \
 hunspell-filesystem \
 "
