# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-assert_cmd"
PV = "2.1.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-assert_cmd+color-auto-devel \
 rust-assert_cmd+color-devel \
 rust-assert_cmd+default-devel \
 rust-assert_cmd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-assert_cmd-2.1.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9520763d454b9d868c44dd79112ca9f61c95cd995231dd334e46d35e09f65cde"

URI_x86_64_v2_rust-assert_cmd+color-auto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_cmd+color-auto-devel-2.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_cmd+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_cmd+color-auto-devel}"
SRC_URI[x86_64_v2_rust-assert_cmd+color-auto-devel.sha256sum] = "8d202ea88a24e8139fd48c843db76093c442a1e8105fac3874ad764a9293c1b4"

URI_x86_64_v2_rust-assert_cmd+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_cmd+color-devel-2.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_cmd+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_cmd+color-devel}"
SRC_URI[x86_64_v2_rust-assert_cmd+color-devel.sha256sum] = "ee211c810dd9f5682c3bafdfaf89758d1ab005b2f3491fd8972902a6ae4e8c45"

URI_x86_64_v2_rust-assert_cmd+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_cmd+default-devel-2.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_cmd+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_cmd+default-devel}"
SRC_URI[x86_64_v2_rust-assert_cmd+default-devel.sha256sum] = "7458668ca6d37fbf9de82156dcdd121dee56077eeb4cf2863226b880f9a32b97"

URI_x86_64_v2_rust-assert_cmd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_cmd-devel-2.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_cmd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_cmd-devel}"
SRC_URI[x86_64_v2_rust-assert_cmd-devel.sha256sum] = "b1a235196e19dbcf200f9e734ac8151c8e365bc0807f02958d651aed5aef576c"

URI_aarch64_rust-assert_cmd+color-auto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_cmd+color-auto-devel-2.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-assert_cmd+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_cmd+color-auto-devel}"
SRC_URI[aarch64_rust-assert_cmd+color-auto-devel.sha256sum] = "abe5727eca94fab8d00b9079e14ad5632c318a7522b0bc65e757f6dafea061cb"

URI_aarch64_rust-assert_cmd+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_cmd+color-devel-2.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-assert_cmd+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_cmd+color-devel}"
SRC_URI[aarch64_rust-assert_cmd+color-devel.sha256sum] = "1210280ec5c18892491a86977a9f06e0320b6b13d35f7810e0f3008d9f39b412"

URI_aarch64_rust-assert_cmd+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_cmd+default-devel-2.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-assert_cmd+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_cmd+default-devel}"
SRC_URI[aarch64_rust-assert_cmd+default-devel.sha256sum] = "29f185cc936b02e7e3185bfdb81078f5765ea3705cdb9071948f41d85ef20c32"

URI_aarch64_rust-assert_cmd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_cmd-devel-2.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-assert_cmd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_cmd-devel}"
SRC_URI[aarch64_rust-assert_cmd-devel.sha256sum] = "1f7b4920e5a0524b6615b1c0907c7d4db0117b7f53c6b0b10287a607e61874c8"

RDEPENDS:rust-assert_cmd+color-auto-devel = " \
 cargo \
 rust-assert_cmd+color-devel \
 rust-assert_cmd-devel \
 "
RDEPENDS:rust-assert_cmd+color-devel = " \
 cargo \
 rust-anstream+default-devel \
 rust-assert_cmd-devel \
 rust-predicates+color-devel \
 "
RDEPENDS:rust-assert_cmd+default-devel = " \
 cargo \
 rust-assert_cmd-devel \
 "
RDEPENDS:rust-assert_cmd-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-bstr+default-devel \
 rust-libc+default-devel \
 rust-predicates+diff-devel \
 rust-predicates-core+default-devel \
 rust-predicates-devel \
 rust-predicates-tree+default-devel \
 rust-wait-timeout+default-devel \
 "
