# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-toml-span"
PV = "0.7.1"
PR = "2.el10_3"
PACKAGES = " \
 rust-toml-span+default-devel \
 rust-toml-span+reporting-devel \
 rust-toml-span+serde-devel \
 rust-toml-span-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-toml-span-0.7.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "453a9e4b174cbfee13f5233acfcf2c8df84186a90a5f58228f5c1511920f7e06"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml-span+default-devel-0.7.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml-span+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-toml-span+default-devel.sha256sum] = "171d11b5923f621ac6ddbe5a03a424f88bee8e70c0ae07106c10e57595036a57"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml-span+reporting-devel-0.7.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml-span+reporting-devel;unpack=0"
SRC_URI[x86_64_v2_rust-toml-span+reporting-devel.sha256sum] = "c17ea43c04a0c15445449e348ed8c94ae4559e5dcf5033d4f390da37085b5982"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml-span+serde-devel-0.7.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml-span+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-toml-span+serde-devel.sha256sum] = "ec9a6ebdcfe49ce83d242f9c5860a4edcda0d97cb9bb3fb15849fbcaff2de82e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml-span-devel-0.7.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml-span-devel;unpack=0"
SRC_URI[x86_64_v2_rust-toml-span-devel.sha256sum] = "2d0f156d7b6b225ac8ed3146c67845e4daeac13d4303dcb6e9a6e0aa48ba8d1e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-toml-span+default-devel-0.7.1-2.el10_3.noarch.rpm;name=aarch64_rust-toml-span+default-devel;unpack=0"
SRC_URI[aarch64_rust-toml-span+default-devel.sha256sum] = "b2ce884da2cf26565c9b70dc33a4525636f1f2d04ea7c4c325e220faeba67d94"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-toml-span+reporting-devel-0.7.1-2.el10_3.noarch.rpm;name=aarch64_rust-toml-span+reporting-devel;unpack=0"
SRC_URI[aarch64_rust-toml-span+reporting-devel.sha256sum] = "c3b7485fee1efca337153493165e42b28f17390c811eeaa643396a4cf541af66"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-toml-span+serde-devel-0.7.1-2.el10_3.noarch.rpm;name=aarch64_rust-toml-span+serde-devel;unpack=0"
SRC_URI[aarch64_rust-toml-span+serde-devel.sha256sum] = "10d41d97cdecfc9850ceebb2b08da710147af468c578e7f63e38e545ab1a5738"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-toml-span-devel-0.7.1-2.el10_3.noarch.rpm;name=aarch64_rust-toml-span-devel;unpack=0"
SRC_URI[aarch64_rust-toml-span-devel.sha256sum] = "96e042b205e7f2f2a51d78d897dcf56feeffc213acc6847c18eb83cb3a8c4602"

RDEPENDS:rust-toml-span+default-devel = " \
 cargo \
 rust-toml-span-devel \
 "
RDEPENDS:rust-toml-span+reporting-devel = " \
 cargo \
 rust-codespan-reporting+default-devel \
 rust-toml-span-devel \
 "
RDEPENDS:rust-toml-span+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-toml-span-devel \
 "
RDEPENDS:rust-toml-span-devel = " \
 cargo \
 rust \
 rust-smallvec+default-devel \
 "
