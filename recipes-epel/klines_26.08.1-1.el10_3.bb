# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "klines"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 klines \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/klines-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6d9459d6fb40280fca0a8943c5bc2494d02f84160977a4cd5c47e2dc61512b61"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/klines-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_klines;unpack=0"
SRC_URI[x86_64_v2_klines.sha256sum] = "88f30b71c7cddf16129292766e0948e6071d459ed399788f476c1f10d124214b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/klines-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_klines;unpack=0"
SRC_URI[aarch64_klines.sha256sum] = "6d69d622df700cb59ceddc96c5cbdc9b8f29fdbaf9df99083396f615c23579a7"

RDEPENDS:klines = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
