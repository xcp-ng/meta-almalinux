# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kdnssd"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kdnssd \
 kf6-kdnssd-devel \
 kf6-kdnssd-doc \
 kf6-kdnssd-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kdnssd-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04cfa3671065487a7db69ed8077d3869ec615970c6ad3ebd8f1828377db1503b"

URI_x86_64_v2_kf6-kdnssd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdnssd-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdnssd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdnssd}"
SRC_URI[x86_64_v2_kf6-kdnssd.sha256sum] = "6451ecc9f54b48d13b82f03fb2638dc6fb86c5115caaed26f19690cf2777dcf6"

URI_x86_64_v2_kf6-kdnssd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdnssd-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdnssd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdnssd-devel}"
SRC_URI[x86_64_v2_kf6-kdnssd-devel.sha256sum] = "610ed95986bb42ec88a3372388a040433c6d6a8d9b8bb4b867f52600e4916e47"

URI_x86_64_v2_kf6-kdnssd-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdnssd-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdnssd-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdnssd-doc}"
SRC_URI[x86_64_v2_kf6-kdnssd-doc.sha256sum] = "c64278ca1cba0d8c41211162048678feada627eb7fe3eb4e6a947e770b8376df"

URI_x86_64_v2_kf6-kdnssd-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdnssd-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdnssd-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdnssd-html}"
SRC_URI[x86_64_v2_kf6-kdnssd-html.sha256sum] = "489b58265f14d2622f90d61b98b8315d91963e8852ecbb97f7aa0e5e5fda6fee"

URI_aarch64_kf6-kdnssd = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdnssd-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kdnssd;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdnssd}"
SRC_URI[aarch64_kf6-kdnssd.sha256sum] = "9842fa2a5e93841d2f8883779e519bf9522cde974ae64fae5493960eb3776cbe"

URI_aarch64_kf6-kdnssd-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdnssd-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kdnssd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdnssd-devel}"
SRC_URI[aarch64_kf6-kdnssd-devel.sha256sum] = "01999d14891115c9f81e503727dc5fba25579eb39b0ad7fb71ae78dd3c488719"

URI_aarch64_kf6-kdnssd-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdnssd-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kdnssd-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdnssd-doc}"
SRC_URI[aarch64_kf6-kdnssd-doc.sha256sum] = "d81a33dbabd9aed132e5bc998464c478a010d924de367b46ee6990eb2843f167"

URI_aarch64_kf6-kdnssd-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdnssd-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kdnssd-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdnssd-html}"
SRC_URI[aarch64_kf6-kdnssd-html.sha256sum] = "4d93271c4b757b3f7f7f30a5842325163134d96cd4f50f762187e4cba7578cab"

RDEPENDS:kf6-kdnssd = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 nss-mdns \
 qt6-qtbase \
 "
RDEPENDS:kf6-kdnssd-devel = " \
 cmake-filesystem \
 kf6-kdnssd \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kdnssd-doc = " \
 "
RDEPENDS:kf6-kdnssd-html = " \
 "
