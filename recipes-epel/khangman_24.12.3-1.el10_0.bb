# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "khangman"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 khangman \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/khangman-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "77b958e5351f7417c2f93360a78a5377cc130f35b59764b0fee2b0676cbd22ea"

URI_x86_64_v2_khangman = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/khangman-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_khangman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_khangman}"
SRC_URI[x86_64_v2_khangman.sha256sum] = "cd388022fd57e175843ef36bac808dc7ef6330d52c21f0ac5179cdda857ecd5f"

URI_aarch64_khangman = "${EPEL_MIRROR}/aarch64/Packages/k/khangman-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_khangman;unpack=0"
SRC_URI:append = " ${URI_aarch64_khangman}"
SRC_URI[aarch64_khangman.sha256sum] = "04e6398303c5b26091dbf1c841329aeda7e9b1ff22bee22b6525b91bfefd9ebd"

RDEPENDS:khangman = " \
 dustin-domestic-manners-fonts \
 dustin-dustismo-roman-fonts \
 glibc \
 kdeedu-data \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-knewstuff \
 libkeduvocdocument \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
