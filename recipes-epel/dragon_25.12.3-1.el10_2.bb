# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dragon"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 dragon \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dragon-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ceadd058ffdf8f81d8dc2547ead692886c1408dd7b3f67eb84f74cad1ecd4ee5"

URI_x86_64_v2_dragon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dragon-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dragon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dragon}"
SRC_URI[x86_64_v2_dragon.sha256sum] = "58e4100c22fd46f710dd0f87a2a07c72037f04d49cc64f474ec3c4e83f01e98c"

URI_aarch64_dragon = "${EPEL_MIRROR}/aarch64/Packages/d/dragon-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_dragon;unpack=0"
SRC_URI:append = " ${URI_aarch64_dragon}"
SRC_URI[aarch64_dragon.sha256sum] = "c500d1357a3685462b547b0ce70fc830d1bb9dc0827878be14e35802de43ff0c"

RDEPENDS:dragon = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kservice \
 kf6-kwindowsystem \
 libavcodec-free \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
