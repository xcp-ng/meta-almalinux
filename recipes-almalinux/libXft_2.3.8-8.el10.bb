# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libXft"
PV = "2.3.8"
PR = "8.el10"
PACKAGES = " \
 libXft \
 libXft-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libXft-2.3.8-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "23015788c68a31b9529038c1c809348ea421cc096ec25100a208910dceaba930"

URI_x86_64_v2_libXft = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libXft-2.3.8-8.el10.x86_64_v2.rpm;name=x86_64_v2_libXft;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXft}"
SRC_URI[x86_64_v2_libXft.sha256sum] = "6c700a52a9c51c8f01e8f87c1a3734a25bd807d82223ade53ac2e46da071bf27"

URI_x86_64_v2_libXft-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libXft-devel-2.3.8-8.el10.x86_64_v2.rpm;name=x86_64_v2_libXft-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXft-devel}"
SRC_URI[x86_64_v2_libXft-devel.sha256sum] = "db4b4ce94ec3745f107e618deee3436df1031eed1bd95d47c869e003c8fb827e"

URI_aarch64_libXft = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libXft-2.3.8-8.el10.aarch64.rpm;name=aarch64_libXft;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXft}"
SRC_URI[aarch64_libXft.sha256sum] = "7d8e41689743dbd6034652095998e4dca984f95949ae97a026c8ef1d6cdc4448"

URI_aarch64_libXft-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libXft-devel-2.3.8-8.el10.aarch64.rpm;name=aarch64_libXft-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXft-devel}"
SRC_URI[aarch64_libXft-devel.sha256sum] = "6491859b925d453245c8ba89f1b2d113aa12259adb51f882b8ea37a7efa67962"

RDEPENDS:libXft = " \
 fontconfig \
 freetype \
 glibc \
 libX11 \
 libXrender \
 "
RDEPENDS:libXft-devel = " \
 fontconfig-devel \
 freetype-devel \
 libXft \
 libXrender-devel \
 pkgconf-pkg-config \
 xorg-x11-proto-devel \
 "
