# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fdupes"
PE = "1"
PV = "2.3.2"
PR = "2.el10_0"
PACKAGES = " \
 fdupes \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fdupes-2.3.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7922100e90e60441457fd33a0227d68adfee97b555aba8d93dc28e720ab16063"

URI_x86_64_v2_fdupes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fdupes-2.3.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fdupes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fdupes}"
SRC_URI[x86_64_v2_fdupes.sha256sum] = "b64048996087bebca0a006be7c51c31e4f364576bf1dec789ab54380e60b537d"

URI_aarch64_fdupes = "${EPEL_MIRROR}/aarch64/Packages/f/fdupes-2.3.2-2.el10_0.aarch64.rpm;name=aarch64_fdupes;unpack=0"
SRC_URI:append = " ${URI_aarch64_fdupes}"
SRC_URI[aarch64_fdupes.sha256sum] = "7878cafc028aaeb60a34d551669bf2054415579e07deb53115efec55ca2ca453"

RDEPENDS:fdupes = " \
 glibc \
 ncurses-libs \
 pcre2-utf32 \
 sqlite-libs \
 "
