# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "minicom"
PV = "2.9"
PR = "4.el10"
PACKAGES = " \
 minicom \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/minicom-2.9-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec4dbf3c20b3f4f64f722309728c1226db082eea3d90b7abdbaef2686fffd625"

URI_x86_64_v2_minicom = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/minicom-2.9-4.el10.x86_64_v2.rpm;name=x86_64_v2_minicom;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_minicom}"
SRC_URI[x86_64_v2_minicom.sha256sum] = "4bdced5f60f71a20075bc9b5aacb1bab35fffbe0acfbb4ec019a4ebe0a3114f9"

URI_aarch64_minicom = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/minicom-2.9-4.el10.aarch64.rpm;name=aarch64_minicom;unpack=0"
SRC_URI:append = " ${URI_aarch64_minicom}"
SRC_URI[aarch64_minicom.sha256sum] = "0f02de6bf4ace56d408c9c0c677e3c9cb28bb1609e9a266007bb5c900a4ae53d"

RDEPENDS:minicom = " \
 bash \
 glibc \
 lockdev \
 lrzsz \
 ncurses-libs \
 "
