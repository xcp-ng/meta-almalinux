# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-workspace-wallpapers"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 plasma-workspace-wallpapers \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-workspace-wallpapers-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80050feb9de195121a8ae18e94ffb5b8d996c2d9396b6dd6b8d4894a882de032"

URI_x86_64_v2_plasma-workspace-wallpapers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-workspace-wallpapers-6.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-workspace-wallpapers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-workspace-wallpapers}"
SRC_URI[x86_64_v2_plasma-workspace-wallpapers.sha256sum] = "c6e68b2ea89d92f5d39cf85412db2ef888123203a68d3b3b811efec210668d77"

URI_aarch64_plasma-workspace-wallpapers = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-workspace-wallpapers-6.7.3-1.el10_3.noarch.rpm;name=aarch64_plasma-workspace-wallpapers;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-workspace-wallpapers}"
SRC_URI[aarch64_plasma-workspace-wallpapers.sha256sum] = "69333ff2e8204632274f2f8854fa85bf2ad40f86e07e42c4cc13a921c96844b5"

RDEPENDS:plasma-workspace-wallpapers = " \
 kde-filesystem \
 "
