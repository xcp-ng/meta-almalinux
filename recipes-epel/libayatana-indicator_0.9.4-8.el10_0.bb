# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libayatana-indicator"
PV = "0.9.4"
PR = "8.el10_0"
PACKAGES = " \
 libayatana-indicator-gtk3 \
 libayatana-indicator-gtk3-devel \
 libayatana-indicator-tools-gtk3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libayatana-indicator-0.9.4-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "499f7d786cec49277208d9d0266bf4889834bb276b20ddc6e6c10be5e3aa3147"

URI_x86_64_v2_libayatana-indicator-gtk3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libayatana-indicator-gtk3-0.9.4-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libayatana-indicator-gtk3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libayatana-indicator-gtk3}"
SRC_URI[x86_64_v2_libayatana-indicator-gtk3.sha256sum] = "7b0bc4ecb467476b9e20419f4307f29549c32b63cc634e639b33267b35f29eae"

URI_x86_64_v2_libayatana-indicator-gtk3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libayatana-indicator-gtk3-devel-0.9.4-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libayatana-indicator-gtk3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libayatana-indicator-gtk3-devel}"
SRC_URI[x86_64_v2_libayatana-indicator-gtk3-devel.sha256sum] = "152157725bfde81ef84684de8ab8b06d37ff159a265a1851485b114d1aeffc66"

URI_x86_64_v2_libayatana-indicator-tools-gtk3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libayatana-indicator-tools-gtk3-0.9.4-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libayatana-indicator-tools-gtk3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libayatana-indicator-tools-gtk3}"
SRC_URI[x86_64_v2_libayatana-indicator-tools-gtk3.sha256sum] = "d0ef5dd0dfc58b74124eeb20c69dbf01f8f6443bc40486f617b12c83b45086ba"

URI_aarch64_libayatana-indicator-gtk3 = "${EPEL_MIRROR}/aarch64/Packages/l/libayatana-indicator-gtk3-0.9.4-8.el10_0.aarch64.rpm;name=aarch64_libayatana-indicator-gtk3;unpack=0"
SRC_URI:append = " ${URI_aarch64_libayatana-indicator-gtk3}"
SRC_URI[aarch64_libayatana-indicator-gtk3.sha256sum] = "1886ecee646a5a4d3f36cca3536852ebc1c2ec22dae832661f5841ebe4271118"

URI_aarch64_libayatana-indicator-gtk3-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libayatana-indicator-gtk3-devel-0.9.4-8.el10_0.aarch64.rpm;name=aarch64_libayatana-indicator-gtk3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libayatana-indicator-gtk3-devel}"
SRC_URI[aarch64_libayatana-indicator-gtk3-devel.sha256sum] = "7a62db078be13c844985ff0f7c67ff496a8c1f368dac64d05444c0fead5866e4"

URI_aarch64_libayatana-indicator-tools-gtk3 = "${EPEL_MIRROR}/aarch64/Packages/l/libayatana-indicator-tools-gtk3-0.9.4-8.el10_0.aarch64.rpm;name=aarch64_libayatana-indicator-tools-gtk3;unpack=0"
SRC_URI:append = " ${URI_aarch64_libayatana-indicator-tools-gtk3}"
SRC_URI[aarch64_libayatana-indicator-tools-gtk3.sha256sum] = "e750dc3c6d6ea30e75b9575014eb5015a195c4067c345dbf1033fa97b625a6e8"

RDEPENDS:libayatana-indicator-gtk3 = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 libayatana-ido-gtk3 \
 "
RDEPENDS:libayatana-indicator-gtk3-devel = " \
 gtk3-devel \
 libayatana-ido-gtk3-devel \
 libayatana-indicator-gtk3 \
 pkgconf-pkg-config \
 "
RDEPENDS:libayatana-indicator-tools-gtk3 = " \
 libayatana-indicator-gtk3 \
 "
