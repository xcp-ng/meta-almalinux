# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crc-fast"
PV = "1.10.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-crc-fast+alloc-devel \
 rust-crc-fast+cache-devel \
 rust-crc-fast+cli-devel \
 rust-crc-fast+default-devel \
 rust-crc-fast+digest-devel \
 rust-crc-fast+ffi-devel \
 rust-crc-fast+hashbrown-devel \
 rust-crc-fast+optimize_crc32_auto-devel \
 rust-crc-fast+optimize_crc32_avx512_v4s3x3-devel \
 rust-crc-fast+optimize_crc32_avx512_vpclmulqdq_v3x2-devel \
 rust-crc-fast+optimize_crc32_neon_blended-devel \
 rust-crc-fast+optimize_crc32_neon_eor3_v9s3x2e_s3-devel \
 rust-crc-fast+optimize_crc32_neon_v12e_v1-devel \
 rust-crc-fast+optimize_crc32_neon_v3s4x2e_v2-devel \
 rust-crc-fast+optimize_crc32_sse_v4s3x3-devel \
 rust-crc-fast+panic-handler-devel \
 rust-crc-fast+spin-devel \
 rust-crc-fast+std-devel \
 rust-crc-fast+vpclmulqdq-devel \
 rust-crc-fast-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crc-fast-1.10.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f26e213c30b2e6df5dab1e74d3ea3b8a9b33822bf392ced79f07f240e97fb38e"

URI_x86_64_v2_rust-crc-fast+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc-fast+alloc-devel-1.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc-fast+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc-fast+alloc-devel}"
SRC_URI[x86_64_v2_rust-crc-fast+alloc-devel.sha256sum] = "9f58b20696b4769873a4457c0192df3794c1d661fa805552012d9adbc9345332"

URI_x86_64_v2_rust-crc-fast+cache-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc-fast+cache-devel-1.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc-fast+cache-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc-fast+cache-devel}"
SRC_URI[x86_64_v2_rust-crc-fast+cache-devel.sha256sum] = "67ca8608fd941064897d546f4fc7c82600304da59c5a22ee21323f71caf3bb1f"

URI_x86_64_v2_rust-crc-fast+cli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc-fast+cli-devel-1.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc-fast+cli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc-fast+cli-devel}"
SRC_URI[x86_64_v2_rust-crc-fast+cli-devel.sha256sum] = "ea8daf922c91decd7c058613e7cfacae2ffe86ee2b71c8139a57affdb45ea5f4"

URI_x86_64_v2_rust-crc-fast+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc-fast+default-devel-1.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc-fast+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc-fast+default-devel}"
SRC_URI[x86_64_v2_rust-crc-fast+default-devel.sha256sum] = "0bc315031358a9d4144a4ac0f72a7073f92a983eefd2796aaa1cb595e70b0476"

URI_x86_64_v2_rust-crc-fast+digest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc-fast+digest-devel-1.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc-fast+digest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc-fast+digest-devel}"
SRC_URI[x86_64_v2_rust-crc-fast+digest-devel.sha256sum] = "577e6a4ee932f90862f103a52b86c0a4174fab7b6fc0fd6b1309baae5dcc5628"

URI_x86_64_v2_rust-crc-fast+ffi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc-fast+ffi-devel-1.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc-fast+ffi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc-fast+ffi-devel}"
SRC_URI[x86_64_v2_rust-crc-fast+ffi-devel.sha256sum] = "e0b5adc6a8049e7f832d891e8a55f0b83769ecac2a574bd449a88118ee497376"

URI_x86_64_v2_rust-crc-fast+hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc-fast+hashbrown-devel-1.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc-fast+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc-fast+hashbrown-devel}"
SRC_URI[x86_64_v2_rust-crc-fast+hashbrown-devel.sha256sum] = "8b48b01047290900f64bbb57a0fc34e18a535c907dddab533cbce29100a9f14e"

URI_x86_64_v2_rust-crc-fast+optimize_crc32_auto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc-fast+optimize_crc32_auto-devel-1.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc-fast+optimize_crc32_auto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc-fast+optimize_crc32_auto-devel}"
SRC_URI[x86_64_v2_rust-crc-fast+optimize_crc32_auto-devel.sha256sum] = "e4ee0a277e572aae5ea6c539f33abb0ec18f94d69521f36a8f73ee6bca8b6f75"

URI_x86_64_v2_rust-crc-fast+optimize_crc32_avx512_v4s3x3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc-fast+optimize_crc32_avx512_v4s3x3-devel-1.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc-fast+optimize_crc32_avx512_v4s3x3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc-fast+optimize_crc32_avx512_v4s3x3-devel}"
SRC_URI[x86_64_v2_rust-crc-fast+optimize_crc32_avx512_v4s3x3-devel.sha256sum] = "b61472774ef4cb46b2722c8ff28be199571425f40599e7aaa4638a470dce1f9d"

URI_x86_64_v2_rust-crc-fast+optimize_crc32_avx512_vpclmulqdq_v3x2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc-fast+optimize_crc32_avx512_vpclmulqdq_v3x2-devel-1.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc-fast+optimize_crc32_avx512_vpclmulqdq_v3x2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc-fast+optimize_crc32_avx512_vpclmulqdq_v3x2-devel}"
SRC_URI[x86_64_v2_rust-crc-fast+optimize_crc32_avx512_vpclmulqdq_v3x2-devel.sha256sum] = "39ff08ed17442aafacf0bb377e27b9189a9c8c44973d22c72951d42a1f926bde"

URI_x86_64_v2_rust-crc-fast+optimize_crc32_neon_blended-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc-fast+optimize_crc32_neon_blended-devel-1.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc-fast+optimize_crc32_neon_blended-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc-fast+optimize_crc32_neon_blended-devel}"
SRC_URI[x86_64_v2_rust-crc-fast+optimize_crc32_neon_blended-devel.sha256sum] = "c035a243d163e9ede0ddb16c365acd6ed62536011b148c2087193094ca6b2708"

URI_x86_64_v2_rust-crc-fast+optimize_crc32_neon_eor3_v9s3x2e_s3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc-fast+optimize_crc32_neon_eor3_v9s3x2e_s3-devel-1.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc-fast+optimize_crc32_neon_eor3_v9s3x2e_s3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc-fast+optimize_crc32_neon_eor3_v9s3x2e_s3-devel}"
SRC_URI[x86_64_v2_rust-crc-fast+optimize_crc32_neon_eor3_v9s3x2e_s3-devel.sha256sum] = "913917bb35dde993fec0e9fe12ce78543edd020b934bd6bd82ba859bc51c36a9"

URI_x86_64_v2_rust-crc-fast+optimize_crc32_neon_v12e_v1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc-fast+optimize_crc32_neon_v12e_v1-devel-1.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc-fast+optimize_crc32_neon_v12e_v1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc-fast+optimize_crc32_neon_v12e_v1-devel}"
SRC_URI[x86_64_v2_rust-crc-fast+optimize_crc32_neon_v12e_v1-devel.sha256sum] = "20630ea1db9985b3337bfe6b6cfe60a04d539ba2bbebc0cff7764be48d81a547"

URI_x86_64_v2_rust-crc-fast+optimize_crc32_neon_v3s4x2e_v2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc-fast+optimize_crc32_neon_v3s4x2e_v2-devel-1.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc-fast+optimize_crc32_neon_v3s4x2e_v2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc-fast+optimize_crc32_neon_v3s4x2e_v2-devel}"
SRC_URI[x86_64_v2_rust-crc-fast+optimize_crc32_neon_v3s4x2e_v2-devel.sha256sum] = "c3c83e144511486e90f9b78a72ac43e099446bc845e4cf035996016908df980f"

URI_x86_64_v2_rust-crc-fast+optimize_crc32_sse_v4s3x3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc-fast+optimize_crc32_sse_v4s3x3-devel-1.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc-fast+optimize_crc32_sse_v4s3x3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc-fast+optimize_crc32_sse_v4s3x3-devel}"
SRC_URI[x86_64_v2_rust-crc-fast+optimize_crc32_sse_v4s3x3-devel.sha256sum] = "b84a401d898f0ffb409fa07a797203843a3a5c9f47e61541943a4e6ba1b9dca7"

URI_x86_64_v2_rust-crc-fast+panic-handler-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc-fast+panic-handler-devel-1.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc-fast+panic-handler-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc-fast+panic-handler-devel}"
SRC_URI[x86_64_v2_rust-crc-fast+panic-handler-devel.sha256sum] = "0b02efd60371820c9a672674953a436e690170fc4c911bf0be185e41431e86b2"

URI_x86_64_v2_rust-crc-fast+spin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc-fast+spin-devel-1.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc-fast+spin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc-fast+spin-devel}"
SRC_URI[x86_64_v2_rust-crc-fast+spin-devel.sha256sum] = "32d9304b129ac6da598ce6362801dc8e9450ea547ee58b920587856940051607"

URI_x86_64_v2_rust-crc-fast+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc-fast+std-devel-1.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc-fast+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc-fast+std-devel}"
SRC_URI[x86_64_v2_rust-crc-fast+std-devel.sha256sum] = "907f687b91c88a23508b54d3d8a94dd20be9588dc5d80a28d37ccb37dc47e0a0"

URI_x86_64_v2_rust-crc-fast+vpclmulqdq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc-fast+vpclmulqdq-devel-1.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc-fast+vpclmulqdq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc-fast+vpclmulqdq-devel}"
SRC_URI[x86_64_v2_rust-crc-fast+vpclmulqdq-devel.sha256sum] = "aa9194bc2692895e403778dac9cf0cbab70c59b6d2ecb052aa3cd5e9cdd44550"

URI_x86_64_v2_rust-crc-fast-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc-fast-devel-1.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc-fast-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc-fast-devel}"
SRC_URI[x86_64_v2_rust-crc-fast-devel.sha256sum] = "5e7705457ed37ae62e4821163fa40197a49c7ec38646069a61041d12abc9ceb1"

URI_aarch64_rust-crc-fast+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc-fast+alloc-devel-1.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-crc-fast+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc-fast+alloc-devel}"
SRC_URI[aarch64_rust-crc-fast+alloc-devel.sha256sum] = "e9373d17b46892eabef8616e7828495af53a1f5f43dd7de8f1df9cff51ebd55a"

URI_aarch64_rust-crc-fast+cache-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc-fast+cache-devel-1.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-crc-fast+cache-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc-fast+cache-devel}"
SRC_URI[aarch64_rust-crc-fast+cache-devel.sha256sum] = "d0825b54597b6841579bc3b85dc66c7f9a60045a02667dca8be150eb8c0a57dd"

URI_aarch64_rust-crc-fast+cli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc-fast+cli-devel-1.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-crc-fast+cli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc-fast+cli-devel}"
SRC_URI[aarch64_rust-crc-fast+cli-devel.sha256sum] = "db24e4c2b6161b63bc53522814e6dff8ecdc75f7a3f8a77c958ae1c30fee33a0"

URI_aarch64_rust-crc-fast+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc-fast+default-devel-1.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-crc-fast+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc-fast+default-devel}"
SRC_URI[aarch64_rust-crc-fast+default-devel.sha256sum] = "5b3931a4a30d69684787bc45865f815db8c83b40ae72a196bf26df8ea736eea9"

URI_aarch64_rust-crc-fast+digest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc-fast+digest-devel-1.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-crc-fast+digest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc-fast+digest-devel}"
SRC_URI[aarch64_rust-crc-fast+digest-devel.sha256sum] = "d39719288eb87347f05d9e6982c30b930303a09125a1e1da1e199ae5682b2877"

URI_aarch64_rust-crc-fast+ffi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc-fast+ffi-devel-1.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-crc-fast+ffi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc-fast+ffi-devel}"
SRC_URI[aarch64_rust-crc-fast+ffi-devel.sha256sum] = "cb4da17dd0908eca79c26f66280ee567ae996378140c82579c98e67c955418cc"

URI_aarch64_rust-crc-fast+hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc-fast+hashbrown-devel-1.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-crc-fast+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc-fast+hashbrown-devel}"
SRC_URI[aarch64_rust-crc-fast+hashbrown-devel.sha256sum] = "166d182a8b810018e8df33fa41e94b3b85e7d1b0d5377db8c25f864d4aca6436"

URI_aarch64_rust-crc-fast+optimize_crc32_auto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc-fast+optimize_crc32_auto-devel-1.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-crc-fast+optimize_crc32_auto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc-fast+optimize_crc32_auto-devel}"
SRC_URI[aarch64_rust-crc-fast+optimize_crc32_auto-devel.sha256sum] = "a34259f1eb88f1695227942c71eee821f6bdbfec4cbaba02a0d1f5f3edbe1f7e"

URI_aarch64_rust-crc-fast+optimize_crc32_avx512_v4s3x3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc-fast+optimize_crc32_avx512_v4s3x3-devel-1.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-crc-fast+optimize_crc32_avx512_v4s3x3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc-fast+optimize_crc32_avx512_v4s3x3-devel}"
SRC_URI[aarch64_rust-crc-fast+optimize_crc32_avx512_v4s3x3-devel.sha256sum] = "9e76b217f82f3e4100673d8422e49ef231ba9c466e718da24403611265366c48"

URI_aarch64_rust-crc-fast+optimize_crc32_avx512_vpclmulqdq_v3x2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc-fast+optimize_crc32_avx512_vpclmulqdq_v3x2-devel-1.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-crc-fast+optimize_crc32_avx512_vpclmulqdq_v3x2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc-fast+optimize_crc32_avx512_vpclmulqdq_v3x2-devel}"
SRC_URI[aarch64_rust-crc-fast+optimize_crc32_avx512_vpclmulqdq_v3x2-devel.sha256sum] = "fa4e7aef0c729e2037c462d2460e77e4b57f4e55c466c2293acfcd46f04280b8"

URI_aarch64_rust-crc-fast+optimize_crc32_neon_blended-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc-fast+optimize_crc32_neon_blended-devel-1.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-crc-fast+optimize_crc32_neon_blended-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc-fast+optimize_crc32_neon_blended-devel}"
SRC_URI[aarch64_rust-crc-fast+optimize_crc32_neon_blended-devel.sha256sum] = "6c11a557d3c2627d1f645bc7723469f5355bb38bab77be151bf21fa37d5ecefd"

URI_aarch64_rust-crc-fast+optimize_crc32_neon_eor3_v9s3x2e_s3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc-fast+optimize_crc32_neon_eor3_v9s3x2e_s3-devel-1.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-crc-fast+optimize_crc32_neon_eor3_v9s3x2e_s3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc-fast+optimize_crc32_neon_eor3_v9s3x2e_s3-devel}"
SRC_URI[aarch64_rust-crc-fast+optimize_crc32_neon_eor3_v9s3x2e_s3-devel.sha256sum] = "e7ecc5aaad3b6493901f344914b292cce2afe9ca432704b7b329518a82cb52b7"

URI_aarch64_rust-crc-fast+optimize_crc32_neon_v12e_v1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc-fast+optimize_crc32_neon_v12e_v1-devel-1.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-crc-fast+optimize_crc32_neon_v12e_v1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc-fast+optimize_crc32_neon_v12e_v1-devel}"
SRC_URI[aarch64_rust-crc-fast+optimize_crc32_neon_v12e_v1-devel.sha256sum] = "19c87dbae6fde839299d84c9b41636b59af6f0526cd0c6cc12049ff742f6f3a5"

URI_aarch64_rust-crc-fast+optimize_crc32_neon_v3s4x2e_v2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc-fast+optimize_crc32_neon_v3s4x2e_v2-devel-1.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-crc-fast+optimize_crc32_neon_v3s4x2e_v2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc-fast+optimize_crc32_neon_v3s4x2e_v2-devel}"
SRC_URI[aarch64_rust-crc-fast+optimize_crc32_neon_v3s4x2e_v2-devel.sha256sum] = "a5f3b008dcb8f9efbb0bbd1ade204c09490e31aab264af6739db5cf7fda8c7b6"

URI_aarch64_rust-crc-fast+optimize_crc32_sse_v4s3x3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc-fast+optimize_crc32_sse_v4s3x3-devel-1.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-crc-fast+optimize_crc32_sse_v4s3x3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc-fast+optimize_crc32_sse_v4s3x3-devel}"
SRC_URI[aarch64_rust-crc-fast+optimize_crc32_sse_v4s3x3-devel.sha256sum] = "bbf5d9bd6941baf862fbaefee57c47f075ff304d46150492c236571bd3d78953"

URI_aarch64_rust-crc-fast+panic-handler-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc-fast+panic-handler-devel-1.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-crc-fast+panic-handler-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc-fast+panic-handler-devel}"
SRC_URI[aarch64_rust-crc-fast+panic-handler-devel.sha256sum] = "ac637feeeda57053328eb9726dd7866eba400002464a0c9f5a2a12b92ce9d8d8"

URI_aarch64_rust-crc-fast+spin-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc-fast+spin-devel-1.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-crc-fast+spin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc-fast+spin-devel}"
SRC_URI[aarch64_rust-crc-fast+spin-devel.sha256sum] = "c2904b5c769d9fe17668034a92b80a656bfad7801e6fd7a0131fea31347238c6"

URI_aarch64_rust-crc-fast+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc-fast+std-devel-1.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-crc-fast+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc-fast+std-devel}"
SRC_URI[aarch64_rust-crc-fast+std-devel.sha256sum] = "288f66ced0b75cf891ee555f60cc69baeba8f3a31b3de28b686755a3195778ad"

URI_aarch64_rust-crc-fast+vpclmulqdq-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc-fast+vpclmulqdq-devel-1.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-crc-fast+vpclmulqdq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc-fast+vpclmulqdq-devel}"
SRC_URI[aarch64_rust-crc-fast+vpclmulqdq-devel.sha256sum] = "c6a2e5821f92776a2107500b5b377a6ea1d0b551bb70c6c36ae33d1f7bf7b40d"

URI_aarch64_rust-crc-fast-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc-fast-devel-1.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-crc-fast-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc-fast-devel}"
SRC_URI[aarch64_rust-crc-fast-devel.sha256sum] = "8974bb8c64b05a9c51482498d294d6e11c7a1750d43e0688adda388d7edbac36"

RDEPENDS:rust-crc-fast+alloc-devel = " \
 cargo \
 rust-crc-fast+digest-devel \
 rust-crc-fast-devel \
 "
RDEPENDS:rust-crc-fast+cache-devel = " \
 cargo \
 rust-crc-fast+alloc-devel \
 rust-crc-fast+hashbrown-devel \
 rust-crc-fast+spin-devel \
 rust-crc-fast-devel \
 "
RDEPENDS:rust-crc-fast+cli-devel = " \
 cargo \
 rust-crc-fast+std-devel \
 rust-crc-fast-devel \
 "
RDEPENDS:rust-crc-fast+default-devel = " \
 cargo \
 rust-crc-fast+ffi-devel \
 rust-crc-fast+panic-handler-devel \
 rust-crc-fast+std-devel \
 rust-crc-fast-devel \
 "
RDEPENDS:rust-crc-fast+digest-devel = " \
 cargo \
 rust-crc-fast-devel \
 rust-digest0.10+alloc-devel \
 rust-digest0.10-devel \
 "
RDEPENDS:rust-crc-fast+ffi-devel = " \
 cargo \
 rust-crc-fast-devel \
 "
RDEPENDS:rust-crc-fast+hashbrown-devel = " \
 cargo \
 rust-crc-fast-devel \
 rust-hashbrown0.16+default-devel \
 "
RDEPENDS:rust-crc-fast+optimize_crc32_auto-devel = " \
 cargo \
 rust-crc-fast-devel \
 "
RDEPENDS:rust-crc-fast+optimize_crc32_avx512_v4s3x3-devel = " \
 cargo \
 rust-crc-fast-devel \
 "
RDEPENDS:rust-crc-fast+optimize_crc32_avx512_vpclmulqdq_v3x2-devel = " \
 cargo \
 rust-crc-fast-devel \
 "
RDEPENDS:rust-crc-fast+optimize_crc32_neon_blended-devel = " \
 cargo \
 rust-crc-fast-devel \
 "
RDEPENDS:rust-crc-fast+optimize_crc32_neon_eor3_v9s3x2e_s3-devel = " \
 cargo \
 rust-crc-fast-devel \
 "
RDEPENDS:rust-crc-fast+optimize_crc32_neon_v12e_v1-devel = " \
 cargo \
 rust-crc-fast-devel \
 "
RDEPENDS:rust-crc-fast+optimize_crc32_neon_v3s4x2e_v2-devel = " \
 cargo \
 rust-crc-fast-devel \
 "
RDEPENDS:rust-crc-fast+optimize_crc32_sse_v4s3x3-devel = " \
 cargo \
 rust-crc-fast-devel \
 "
RDEPENDS:rust-crc-fast+panic-handler-devel = " \
 cargo \
 rust-crc-fast-devel \
 "
RDEPENDS:rust-crc-fast+spin-devel = " \
 cargo \
 rust-crc-fast-devel \
 rust-spin0.10+mutex-devel \
 rust-spin0.10+once-devel \
 rust-spin0.10+rwlock-devel \
 rust-spin0.10+spin_mutex-devel \
 rust-spin0.10-devel \
 "
RDEPENDS:rust-crc-fast+std-devel = " \
 cargo \
 rust-crc-fast+alloc-devel \
 rust-crc-fast-devel \
 "
RDEPENDS:rust-crc-fast+vpclmulqdq-devel = " \
 cargo \
 rust-crc-fast-devel \
 "
RDEPENDS:rust-crc-fast-devel = " \
 cargo \
 rust \
 rust-spin0.10+mutex-devel \
 rust-spin0.10+once-devel \
 rust-spin0.10+rwlock-devel \
 rust-spin0.10+spin_mutex-devel \
 rust-spin0.10-devel \
 "
