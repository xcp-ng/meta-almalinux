# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fuse-overlayfs"
PV = "1.14"
PR = "2.el10"
PACKAGES = " \
 fuse-overlayfs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/fuse-overlayfs-1.14-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b6d2aed76c1b5a42bc8fb65d4e467464143417ed860e72911e3169c4138f7a16"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fuse-overlayfs-1.14-2.el10.x86_64_v2.rpm;name=x86_64_v2_fuse-overlayfs;unpack=0"
SRC_URI[x86_64_v2_fuse-overlayfs.sha256sum] = "7dfec70e8df428d8442b9939f2616f0877b68eeee2f8ac8f89fd107da0b8e2ea"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fuse-overlayfs-1.14-2.el10.aarch64.rpm;name=aarch64_fuse-overlayfs;unpack=0"
SRC_URI[aarch64_fuse-overlayfs.sha256sum] = "abce003e5e62906e047b3452d096e456872e7c5834cf73cbe3a280c1caf11a39"

RDEPENDS:fuse-overlayfs = " \
 bash \
 fuse3 \
 fuse3-libs \
 glibc \
 kmod \
 libgcc \
 "
