# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-thin-vec"
PV = "0.2.19"
PR = "1.el10_3"
PACKAGES = " \
 rust-thin-vec+const_new-devel \
 rust-thin-vec+default-devel \
 rust-thin-vec+gecko-ffi-devel \
 rust-thin-vec+serde-devel \
 rust-thin-vec+std-devel \
 rust-thin-vec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-thin-vec-0.2.19-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28acc6313f377f487b8807d6e2ef5e69e815233eb7cf3ee34057f29ef7cf3624"

URI_x86_64_v2_rust-thin-vec+const_new-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thin-vec+const_new-devel-0.2.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thin-vec+const_new-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thin-vec+const_new-devel}"
SRC_URI[x86_64_v2_rust-thin-vec+const_new-devel.sha256sum] = "71a1647891ee9191143cee74a2746834a594d0aa4c0478a70455e4a295586f8a"

URI_x86_64_v2_rust-thin-vec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thin-vec+default-devel-0.2.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thin-vec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thin-vec+default-devel}"
SRC_URI[x86_64_v2_rust-thin-vec+default-devel.sha256sum] = "4f67c7158aabed4756710174a70dc943a842af1944fab53e5b520b2543b49e9a"

URI_x86_64_v2_rust-thin-vec+gecko-ffi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thin-vec+gecko-ffi-devel-0.2.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thin-vec+gecko-ffi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thin-vec+gecko-ffi-devel}"
SRC_URI[x86_64_v2_rust-thin-vec+gecko-ffi-devel.sha256sum] = "3eea66261ead77c88786324672f601ed98ce900bb6dec85131d85a22cee03d5a"

URI_x86_64_v2_rust-thin-vec+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thin-vec+serde-devel-0.2.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thin-vec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thin-vec+serde-devel}"
SRC_URI[x86_64_v2_rust-thin-vec+serde-devel.sha256sum] = "fca98c56a7dfe72a501fcffe1725bf33c093d3b346f4767ec1fa2636eb73736c"

URI_x86_64_v2_rust-thin-vec+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thin-vec+std-devel-0.2.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thin-vec+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thin-vec+std-devel}"
SRC_URI[x86_64_v2_rust-thin-vec+std-devel.sha256sum] = "02c4b3a404c4b9585d92d87609fcd85d1a9c2746a8231aef36d0c92f8a77417a"

URI_x86_64_v2_rust-thin-vec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thin-vec-devel-0.2.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thin-vec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thin-vec-devel}"
SRC_URI[x86_64_v2_rust-thin-vec-devel.sha256sum] = "1807bfa9e48c9bfc8a74035d1969f89e68365cc23ecdc7b024084cd4dc495041"

URI_aarch64_rust-thin-vec+const_new-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thin-vec+const_new-devel-0.2.19-1.el10_3.noarch.rpm;name=aarch64_rust-thin-vec+const_new-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thin-vec+const_new-devel}"
SRC_URI[aarch64_rust-thin-vec+const_new-devel.sha256sum] = "b82d3c301debae25d6bc564ce2e4369b1330e9d476c6bbcc08e1461a067fb020"

URI_aarch64_rust-thin-vec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thin-vec+default-devel-0.2.19-1.el10_3.noarch.rpm;name=aarch64_rust-thin-vec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thin-vec+default-devel}"
SRC_URI[aarch64_rust-thin-vec+default-devel.sha256sum] = "ecbc929a527d7fe4b849b6b694e9fe76b69710f6f3a50192780ff4108549af7d"

URI_aarch64_rust-thin-vec+gecko-ffi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thin-vec+gecko-ffi-devel-0.2.19-1.el10_3.noarch.rpm;name=aarch64_rust-thin-vec+gecko-ffi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thin-vec+gecko-ffi-devel}"
SRC_URI[aarch64_rust-thin-vec+gecko-ffi-devel.sha256sum] = "04fc75e36266727d30574e8ddc0dcc6ed5cc596831b81a3edec1b97d414342ca"

URI_aarch64_rust-thin-vec+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thin-vec+serde-devel-0.2.19-1.el10_3.noarch.rpm;name=aarch64_rust-thin-vec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thin-vec+serde-devel}"
SRC_URI[aarch64_rust-thin-vec+serde-devel.sha256sum] = "228cab5e1c0777e8345697023459f862e9d6c1014df2eaa26735b8baf031cd9e"

URI_aarch64_rust-thin-vec+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thin-vec+std-devel-0.2.19-1.el10_3.noarch.rpm;name=aarch64_rust-thin-vec+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thin-vec+std-devel}"
SRC_URI[aarch64_rust-thin-vec+std-devel.sha256sum] = "77f45cc07ad2f547044ecef824daeef5bc2199d90d85855046c365f0fb5b5fa0"

URI_aarch64_rust-thin-vec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thin-vec-devel-0.2.19-1.el10_3.noarch.rpm;name=aarch64_rust-thin-vec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thin-vec-devel}"
SRC_URI[aarch64_rust-thin-vec-devel.sha256sum] = "d3a21b88bedcd5abfaef24391af4009d385d34473043f3102f4ef0d8bd5ca13d"

RDEPENDS:rust-thin-vec+const_new-devel = " \
 cargo \
 rust-thin-vec-devel \
 "
RDEPENDS:rust-thin-vec+default-devel = " \
 cargo \
 rust-thin-vec+std-devel \
 rust-thin-vec-devel \
 "
RDEPENDS:rust-thin-vec+gecko-ffi-devel = " \
 cargo \
 rust-thin-vec-devel \
 "
RDEPENDS:rust-thin-vec+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-thin-vec-devel \
 "
RDEPENDS:rust-thin-vec+std-devel = " \
 cargo \
 rust-thin-vec-devel \
 "
RDEPENDS:rust-thin-vec-devel = " \
 cargo \
 rust \
 "
