# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua-event"
PV = "0.4.6"
PR = "15.el10_0"
PACKAGES = " \
 lua-event \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lua-event-0.4.6-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f331e70b2ed69b59e6d8ef119572ef7b9664d88cd2793b83c226fde56d9fdb2"

URI_x86_64_v2_lua-event = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua-event-0.4.6-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lua-event;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-event}"
SRC_URI[x86_64_v2_lua-event.sha256sum] = "11236c13d49c1fd8a13c17636e77a9c99899f5fd4ccc76856974777c37578883"

URI_aarch64_lua-event = "${EPEL_MIRROR}/aarch64/Packages/l/lua-event-0.4.6-15.el10_0.aarch64.rpm;name=aarch64_lua-event;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-event}"
SRC_URI[aarch64_lua-event.sha256sum] = "80490e874f7b7a581198f1b33c801f2ec9f4f748870e5576c4b07134e574f33b"

RDEPENDS:lua-event = " \
 glibc \
 libevent \
 lua-libs \
 lua-socket \
 "
