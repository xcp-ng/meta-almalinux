# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-submodule"
PV = "0.17.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-submodule+default-devel \
 rust-gix-submodule-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-submodule-0.17.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6771b2e4ce4db66a62e4779aea58757b93bbaefde24e4beb11249b9fa13dc95"

URI_x86_64_v2_rust-gix-submodule+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-submodule+default-devel-0.17.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-submodule+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-submodule+default-devel}"
SRC_URI[x86_64_v2_rust-gix-submodule+default-devel.sha256sum] = "fe4c47778b98502e26bdc10c7ffc8bbc1f6a1a516b8ec89b45e8e62f658a0b48"

URI_x86_64_v2_rust-gix-submodule-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-submodule-devel-0.17.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-submodule-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-submodule-devel}"
SRC_URI[x86_64_v2_rust-gix-submodule-devel.sha256sum] = "e330eccda80b1962d75777287e1c163aaa740131bf365cdc108aa6795c70637d"

URI_aarch64_rust-gix-submodule+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-submodule+default-devel-0.17.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-submodule+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-submodule+default-devel}"
SRC_URI[aarch64_rust-gix-submodule+default-devel.sha256sum] = "7cbfc1d17deec95662836f06dfd1f76bf73c5b561681f9e403c90df2a7c4e8e6"

URI_aarch64_rust-gix-submodule-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-submodule-devel-0.17.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-submodule-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-submodule-devel}"
SRC_URI[aarch64_rust-gix-submodule-devel.sha256sum] = "1badcedc75df5730745a79f3764f4e44e92fb25184e20b30a2dea3980f848fa7"

RDEPENDS:rust-gix-submodule+default-devel = " \
 cargo \
 rust-gix-submodule-devel \
 "
RDEPENDS:rust-gix-submodule-devel = " \
 cargo \
 rust \
 rust-bstr-devel \
 rust-gix-config+default-devel \
 rust-gix-path+default-devel \
 rust-gix-pathspec+default-devel \
 rust-gix-refspec+default-devel \
 rust-gix-url+default-devel \
 rust-thiserror+default-devel \
 "
