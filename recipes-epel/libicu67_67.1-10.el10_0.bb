# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libicu67"
PV = "67.1"
PR = "10.el10_0"
PACKAGES = " \
 libicu67 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libicu67-67.1-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e625bb5371892b6d9748efb43dc98864e695c0fb9f14248b569600ea3805c46"

URI_x86_64_v2_libicu67 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libicu67-67.1-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libicu67;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libicu67}"
SRC_URI[x86_64_v2_libicu67.sha256sum] = "4b7a3701c3053462f07e55195c8e34e95abbcc9f8e13e568d4191db71c9273a3"

URI_aarch64_libicu67 = "${EPEL_MIRROR}/aarch64/Packages/l/libicu67-67.1-10.el10_0.aarch64.rpm;name=aarch64_libicu67;unpack=0"
SRC_URI:append = " ${URI_aarch64_libicu67}"
SRC_URI[aarch64_libicu67.sha256sum] = "b73032be947f82fc15171ffe3047eeabfcad1ce5dad601cb027e0edb82b44d6c"

RDEPENDS:libicu67 = " \
 glibc \
 libgcc \
 libstdc++ \
 "
