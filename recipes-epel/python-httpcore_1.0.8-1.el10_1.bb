# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-httpcore"
PV = "1.0.8"
PR = "1.el10_1"
PACKAGES = " \
 python3-httpcore \
 python3-httpcore+http2 \
 python3-httpcore+socks \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-httpcore-1.0.8-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff8a2132d435031bb7bc01a098fb7bcfc883cbf72b26b6c84a01cba3892e9d24"

URI_x86_64_v2_python3-httpcore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-httpcore-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-httpcore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-httpcore}"
SRC_URI[x86_64_v2_python3-httpcore.sha256sum] = "5bdd47defcef5f84969aa14c0e0e59e091a2b8fd16eddb117ce0c662db7e1b71"

URI_x86_64_v2_python3-httpcore+http2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-httpcore+http2-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-httpcore+http2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-httpcore+http2}"
SRC_URI[x86_64_v2_python3-httpcore+http2.sha256sum] = "8bf7323db6e933074bfd7540d0fe931679f31dbf9e334d3c1136f69b0f91c4b0"

URI_x86_64_v2_python3-httpcore+socks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-httpcore+socks-1.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-httpcore+socks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-httpcore+socks}"
SRC_URI[x86_64_v2_python3-httpcore+socks.sha256sum] = "576fdd038bf3f7b0d7f3b21972c8cc40e1757d1ec0211da8f60c5d86e29cad17"

URI_aarch64_python3-httpcore = "${EPEL_MIRROR}/aarch64/Packages/p/python3-httpcore-1.0.8-1.el10_1.noarch.rpm;name=aarch64_python3-httpcore;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-httpcore}"
SRC_URI[aarch64_python3-httpcore.sha256sum] = "eeb91e0c2ca2f76a1dc5c9d32c4d2ac596e50a37525cb19dc05b8a29d74fde15"

URI_aarch64_python3-httpcore+http2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-httpcore+http2-1.0.8-1.el10_1.noarch.rpm;name=aarch64_python3-httpcore+http2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-httpcore+http2}"
SRC_URI[aarch64_python3-httpcore+http2.sha256sum] = "3691fe7971ed577ce5941af2f8d2847c6cf3651846ccd00a960b4002b7548bcb"

URI_aarch64_python3-httpcore+socks = "${EPEL_MIRROR}/aarch64/Packages/p/python3-httpcore+socks-1.0.8-1.el10_1.noarch.rpm;name=aarch64_python3-httpcore+socks;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-httpcore+socks}"
SRC_URI[aarch64_python3-httpcore+socks.sha256sum] = "88ec387181af28c8fc1cd57ad910f376ebd9d8dd948254814d6d0d2e6e8a9e34"

RDEPENDS:python3-httpcore = " \
 python3 \
 python3-certifi \
 python3-h11 \
 "
RDEPENDS:python3-httpcore+http2 = " \
 python3 \
 python3-h2 \
 python3-httpcore \
 "
RDEPENDS:python3-httpcore+socks = " \
 python3 \
 python3-httpcore \
 python3-socksio \
 "
