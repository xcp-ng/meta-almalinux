# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ttfautohint-py"
PV = "0.5.1"
PR = "2.el10_1"
PACKAGES = " \
 python3-ttfautohint-py \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-ttfautohint-py-0.5.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "db89f522a05bc8a112f40792dbf09d4563bb13cc4f0872342fe3fcb09fcc79b7"

URI_x86_64_v2_python3-ttfautohint-py = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ttfautohint-py-0.5.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ttfautohint-py;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ttfautohint-py}"
SRC_URI[x86_64_v2_python3-ttfautohint-py.sha256sum] = "092a6f17680557904ccefbeb6864fed97f562a8b904a7b4a9535d526efebfb26"

URI_aarch64_python3-ttfautohint-py = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ttfautohint-py-0.5.1-2.el10_1.noarch.rpm;name=aarch64_python3-ttfautohint-py;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ttfautohint-py}"
SRC_URI[aarch64_python3-ttfautohint-py.sha256sum] = "d1d62171a1859d99bb5c62a9d945bc10193a06a57b392950105e1eba5dfacbcb"

RDEPENDS:python3-ttfautohint-py = " \
 python3 \
 ttfautohint-libs \
 "
