# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-ffi"
PV = "0.25.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-pyo3-ffi+abi3-devel \
 rust-pyo3-ffi+abi3-py310-devel \
 rust-pyo3-ffi+abi3-py311-devel \
 rust-pyo3-ffi+abi3-py312-devel \
 rust-pyo3-ffi+abi3-py313-devel \
 rust-pyo3-ffi+abi3-py314-devel \
 rust-pyo3-ffi+abi3-py37-devel \
 rust-pyo3-ffi+abi3-py38-devel \
 rust-pyo3-ffi+abi3-py39-devel \
 rust-pyo3-ffi+default-devel \
 rust-pyo3-ffi+extension-module-devel \
 rust-pyo3-ffi-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-ffi-0.25.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ac72ce822d14257deb126095cc409d2ec57aa4ba2176828a2dd04ed5645f40ed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-devel.sha256sum] = "6554afbfadd85e5416419a393e5bc8f7d879e4eeacb4e34e57c896dbf90a834f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-py310-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-py310-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-py310-devel.sha256sum] = "4bd94876458cfe0a104d3bcc39891c8ce420a88911801f537e53fd387c29daf8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-py311-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-py311-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-py311-devel.sha256sum] = "38afd6aedcbb481dfec95fa7b47299e90f3164d78e9a509be09b072439b4b9bd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-py312-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-py312-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-py312-devel.sha256sum] = "bf1e47456400528a35ec309fc49d2d9b467490ccdd1da40267f9e91f7473c97a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-py313-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-py313-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-py313-devel.sha256sum] = "6b3c0798836977a9c826c3cd12eef3b0d81810e3219ccc3c90a435fc2f3caef9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-py314-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-py314-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-py314-devel.sha256sum] = "1c85b394fcc0354b50ba92228e7c21ea7b55209ef871fd2d95d55078872854a2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-py37-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-py37-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-py37-devel.sha256sum] = "60de817530ab689b31382f8dd19c2d74309a072661864a36a9fad8c5aaa85ab3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-py38-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-py38-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-py38-devel.sha256sum] = "e1fd4d5606f0daa74ef7ffa020e085f1bc21a41375fccb9ab8fd9f288cfc87e6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-py39-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-py39-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-py39-devel.sha256sum] = "6b05fed2b9e61fc20e69461791a224e53811f1f67221741d64d6ca8c2c5f0b37"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+default-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3-ffi+default-devel.sha256sum] = "7f41c66815b05787e10e872cce410062ea17cb7c1c86c4a2480f5e6da403ee3f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+extension-module-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+extension-module-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3-ffi+extension-module-devel.sha256sum] = "b4534a6114cc8f42c6e64babfa1e9face78f76c2256ac23ba66149c38f61a5b3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3-ffi-devel.sha256sum] = "1ef13558b3845d5ef98430986387a408d9bd1a0038652d207916bf47aa14488c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-devel.sha256sum] = "2e7256bea78fa4cfd3a77326d2a00b654b8bce64c005d3f4f2b838acb156f1ef"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-py310-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-py310-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-py310-devel.sha256sum] = "78887bf600764e95373f422b980d98c472af5fffe0236995a69d4336df29d129"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-py311-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-py311-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-py311-devel.sha256sum] = "624f94419bd8caf01e1f4e01c6b27097fee04a9c23fb694e8188ce6de2385caf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-py312-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-py312-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-py312-devel.sha256sum] = "1a8d50a8289f9081a2f9bda2d7d6fa4f9f8422b75e6a00d3df026ae0de011657"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-py313-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-py313-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-py313-devel.sha256sum] = "a7a9262591402a0e97c3feddb9525cc797506d8fc0e9b30091658669fe4b33e0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-py314-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-py314-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-py314-devel.sha256sum] = "03d26c719fb907275f2990ae5daeb310ecb5e43f49b66dd56df647e37e118a73"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-py37-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-py37-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-py37-devel.sha256sum] = "bd91e3b3cf16e824bffb86c80a87727267eba6edc80927f64ce6db6db5ce7912"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-py38-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-py38-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-py38-devel.sha256sum] = "dcdc7917c2abcefd0319fe5b8c873800b799e8ce4a64721dd712fe4a730c63f9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-py39-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-py39-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-py39-devel.sha256sum] = "af6de402334e8fa650b514a03a4b1c67b6de57a4ab3886aadc73873b1bb50171"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+default-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-ffi+default-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3-ffi+default-devel.sha256sum] = "cf8215342ea5d9bde11d2993c64a430ffc17d4c878672b5c20b93280053f041d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+extension-module-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-ffi+extension-module-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3-ffi+extension-module-devel.sha256sum] = "d64f9116c5b8a1e31d1273a96ee90b5652d05fad595aaf7fdc32334465efebe9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-ffi-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3-ffi-devel.sha256sum] = "ebbab4142f6c5474b6a211ed99e427f66f0aaa952f9bb9a03ba4f64e9289c2ca"

RDEPENDS:rust-pyo3-ffi+abi3-devel = " \
 cargo \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+abi3-py310-devel = " \
 cargo \
 rust-pyo3-ffi+abi3-py311-devel \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+abi3-py311-devel = " \
 cargo \
 rust-pyo3-ffi+abi3-py312-devel \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+abi3-py312-devel = " \
 cargo \
 rust-pyo3-ffi+abi3-py313-devel \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+abi3-py313-devel = " \
 cargo \
 rust-pyo3-ffi+abi3-py314-devel \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+abi3-py314-devel = " \
 cargo \
 rust-pyo3-ffi+abi3-devel \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+abi3-py37-devel = " \
 cargo \
 rust-pyo3-ffi+abi3-py38-devel \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+abi3-py38-devel = " \
 cargo \
 rust-pyo3-ffi+abi3-py39-devel \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+abi3-py39-devel = " \
 cargo \
 rust-pyo3-ffi+abi3-py310-devel \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+default-devel = " \
 cargo \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+extension-module-devel = " \
 cargo \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi-devel = " \
 cargo \
 python3-devel \
 rust \
 rust-libc+default-devel \
 rust-pyo3-build-config+default-devel \
 rust-pyo3-build-config+resolve-config-devel \
 "
