# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "arm-none-eabi-gcc-cs"
PE = "1"
PV = "14.1.0"
PR = "2.el10_1"
PACKAGES = " \
 arm-none-eabi-gcc-cs \
 arm-none-eabi-gcc-cs-c++ \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/arm-none-eabi-gcc-cs-14.1.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "456dee81f9e56bcfb8ace81bcf5e94cc4d1dedb1072c026ce74fc6bfd5077ea6"

URI_x86_64_v2_arm-none-eabi-gcc-cs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/arm-none-eabi-gcc-cs-14.1.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_arm-none-eabi-gcc-cs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_arm-none-eabi-gcc-cs}"
SRC_URI[x86_64_v2_arm-none-eabi-gcc-cs.sha256sum] = "a7583a7c62922b02c2164014c9f9be1a6655157dd2cdd234727845ae410fc600"

URI_x86_64_v2_arm-none-eabi-gcc-cs-c++ = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/arm-none-eabi-gcc-cs-c++-14.1.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_arm-none-eabi-gcc-cs-c++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_arm-none-eabi-gcc-cs-c++}"
SRC_URI[x86_64_v2_arm-none-eabi-gcc-cs-c++.sha256sum] = "13d8e219c069e8f4b4b6928c740f6ac844df0d996fe86ec3183023bf75e6d9fd"

URI_aarch64_arm-none-eabi-gcc-cs = "${EPEL_MIRROR}/aarch64/Packages/a/arm-none-eabi-gcc-cs-14.1.0-2.el10_1.aarch64.rpm;name=aarch64_arm-none-eabi-gcc-cs;unpack=0"
SRC_URI:append = " ${URI_aarch64_arm-none-eabi-gcc-cs}"
SRC_URI[aarch64_arm-none-eabi-gcc-cs.sha256sum] = "5592d367ca8ac2cc31069cfd44a3df60159af386dfbb44f31c1c1a5ee4fd329f"

URI_aarch64_arm-none-eabi-gcc-cs-c++ = "${EPEL_MIRROR}/aarch64/Packages/a/arm-none-eabi-gcc-cs-c++-14.1.0-2.el10_1.aarch64.rpm;name=aarch64_arm-none-eabi-gcc-cs-c++;unpack=0"
SRC_URI:append = " ${URI_aarch64_arm-none-eabi-gcc-cs-c++}"
SRC_URI[aarch64_arm-none-eabi-gcc-cs-c++.sha256sum] = "3d1afc4fc589f119af081cacaf309cbf23f491bbef620dcbc7f924dedf523885"

RDEPENDS:arm-none-eabi-gcc-cs = " \
 arm-none-eabi-binutils-cs \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:arm-none-eabi-gcc-cs-c++ = " \
 arm-none-eabi-gcc-cs \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 mpfr \
 zlib-ng-compat \
 "
