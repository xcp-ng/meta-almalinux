# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "netsniff-ng"
PV = "0.6.9"
PR = "2.el10_1"
PACKAGES = " \
 netsniff-ng \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/n/netsniff-ng-0.6.9-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e8093431acbda0e629a6e28b140f7f9c8337c7d886e0bddfa0682c19db199f20"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netsniff-ng-0.6.9-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netsniff-ng;unpack=0"
SRC_URI[x86_64_v2_netsniff-ng.sha256sum] = "5dba18a0b63ce6f2f77e7480017d7d7f02684b779a072e6f28919ab2170e2707"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/netsniff-ng-0.6.9-2.el10_1.aarch64.rpm;name=aarch64_netsniff-ng;unpack=0"
SRC_URI[aarch64_netsniff-ng.sha256sum] = "ee4c0509aa53d5f28921d9e01e1498a39277c2e943f992ed5847f006352a9284"

RDEPENDS:netsniff-ng = " \
 glibc \
 libcli \
 libgcc \
 libnet \
 libnetfilter_conntrack \
 libnl3 \
 libpcap \
 libsodium \
 ncurses-libs \
 userspace-rcu \
 "
