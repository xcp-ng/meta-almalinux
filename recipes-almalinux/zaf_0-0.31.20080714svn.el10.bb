# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zaf"
PV = "0"
PR = "0.31.20080714svn.el10"
PACKAGES = " \
 hyphen-af \
 hyphen-zu \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/zaf-0-0.31.20080714svn.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7bf6d88d3a1fddda144e0ce2eeeea0f875fa74eb866a1e6b84b39a658e86207"

URI_x86_64_v2_hyphen-af = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-af-0-0.31.20080714svn.el10.noarch.rpm;name=x86_64_v2_hyphen-af;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyphen-af}"
SRC_URI[x86_64_v2_hyphen-af.sha256sum] = "2ccddc357a2c58ac663b3d133053a3bd8c55fe71f05df125628beb017236241a"

URI_x86_64_v2_hyphen-zu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-zu-0-0.31.20080714svn.el10.noarch.rpm;name=x86_64_v2_hyphen-zu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyphen-zu}"
SRC_URI[x86_64_v2_hyphen-zu.sha256sum] = "bade7ff0adbe36d4c949c121a7a4a5af351e9ca23d05292ff548ade99a000b53"

URI_aarch64_hyphen-af = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-af-0-0.31.20080714svn.el10.noarch.rpm;name=aarch64_hyphen-af;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyphen-af}"
SRC_URI[aarch64_hyphen-af.sha256sum] = "2ccddc357a2c58ac663b3d133053a3bd8c55fe71f05df125628beb017236241a"

URI_aarch64_hyphen-zu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-zu-0-0.31.20080714svn.el10.noarch.rpm;name=aarch64_hyphen-zu;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyphen-zu}"
SRC_URI[aarch64_hyphen-zu.sha256sum] = "bade7ff0adbe36d4c949c121a7a4a5af351e9ca23d05292ff548ade99a000b53"

RDEPENDS:hyphen-af = " \
 hyphen \
 "
RDEPENDS:hyphen-zu = " \
 hyphen \
 "
