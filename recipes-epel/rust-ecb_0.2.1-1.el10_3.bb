# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ecb"
PV = "0.2.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-ecb+alloc-devel \
 rust-ecb+block-padding-devel \
 rust-ecb+default-devel \
 rust-ecb+zeroize-devel \
 rust-ecb-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-ecb-0.2.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "60330db1a444dd91870a892fb18058302904164d52227fae47dc673820318815"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecb+alloc-devel-0.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecb+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ecb+alloc-devel.sha256sum] = "bfcca82baa8f6aa0a11ea97e2e4daf8a5162003efa101188bd2af5f79687b4af"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecb+block-padding-devel-0.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecb+block-padding-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ecb+block-padding-devel.sha256sum] = "18e28d1d22f71254424e480b004ebcd53ecead66cc298579f366905c793d165a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecb+default-devel-0.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecb+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ecb+default-devel.sha256sum] = "4bc108a253b5dbc018563084c173604ab11301649a67c2c01df954f53e9d7c44"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecb+zeroize-devel-0.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecb+zeroize-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ecb+zeroize-devel.sha256sum] = "565099ff4cd9c5bcee11a44c6df91115907e780a6d7bc6cded462fd998efdb47"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecb-devel-0.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecb-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ecb-devel.sha256sum] = "478b1e17fb55d71223a1b49f5e68d720a536b20d1437fc98b611a5acc112b2a4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ecb+alloc-devel-0.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-ecb+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-ecb+alloc-devel.sha256sum] = "d56a8b4ce7bbbe32599fa147e327bbf97e195f2691cbd35561f30547ec6a17d8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ecb+block-padding-devel-0.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-ecb+block-padding-devel;unpack=0"
SRC_URI[aarch64_rust-ecb+block-padding-devel.sha256sum] = "37abc3ac3f83093de9f772bd0186db7e8b9c2a921811d807de6c2f87d5798a0a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ecb+default-devel-0.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-ecb+default-devel;unpack=0"
SRC_URI[aarch64_rust-ecb+default-devel.sha256sum] = "8b0a6d0dfeb44009d2c185d17f46c87a5d8b8a5800d07fc8f08521ab0094969c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ecb+zeroize-devel-0.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-ecb+zeroize-devel;unpack=0"
SRC_URI[aarch64_rust-ecb+zeroize-devel.sha256sum] = "51c494ac024ec1954f131653970a310575d9fb1d0a203314eccac382d27080f4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ecb-devel-0.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-ecb-devel;unpack=0"
SRC_URI[aarch64_rust-ecb-devel.sha256sum] = "86cc351933ac1c6606440c607344269f309d082902812bc5cdae3b19d40a7e4c"

RDEPENDS:rust-ecb+alloc-devel = " \
 cargo \
 rust-cipher+alloc-devel \
 rust-ecb-devel \
 "
RDEPENDS:rust-ecb+block-padding-devel = " \
 cargo \
 rust-cipher+block-padding-devel \
 rust-ecb-devel \
 "
RDEPENDS:rust-ecb+default-devel = " \
 cargo \
 rust-ecb+block-padding-devel \
 rust-ecb-devel \
 "
RDEPENDS:rust-ecb+zeroize-devel = " \
 cargo \
 rust-cipher+zeroize-devel \
 rust-ecb-devel \
 "
RDEPENDS:rust-ecb-devel = " \
 cargo \
 rust \
 rust-cipher+default-devel \
 "
