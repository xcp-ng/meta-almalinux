# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcalendarcore"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kcalendarcore \
 kf6-kcalendarcore-devel \
 kf6-kcalendarcore-doc \
 kf6-kcalendarcore-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kcalendarcore-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ae44e6947052ecb9dbd61af77d7c135132a22e0f47526d4bcb77cef3092e136"

URI_x86_64_v2_kf6-kcalendarcore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcalendarcore-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcalendarcore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcalendarcore}"
SRC_URI[x86_64_v2_kf6-kcalendarcore.sha256sum] = "e4f39f7442f2413dfdbeafb05cb09393cbdf8f7cf825b26539ac459e6acb3003"

URI_x86_64_v2_kf6-kcalendarcore-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcalendarcore-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcalendarcore-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcalendarcore-devel}"
SRC_URI[x86_64_v2_kf6-kcalendarcore-devel.sha256sum] = "a927ce110fbfa194620c00e629711f6929d9afd0bce48c3cfe883002a65a2c96"

URI_x86_64_v2_kf6-kcalendarcore-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcalendarcore-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcalendarcore-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcalendarcore-doc}"
SRC_URI[x86_64_v2_kf6-kcalendarcore-doc.sha256sum] = "d626c9283b16e94f6ca17aafc5dbc0b97279c34e503a07afde72357c2bb92b5d"

URI_x86_64_v2_kf6-kcalendarcore-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcalendarcore-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcalendarcore-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcalendarcore-html}"
SRC_URI[x86_64_v2_kf6-kcalendarcore-html.sha256sum] = "64aeff8618669b0bc6022c36e394ea1c41c1ecdc16d85fe4850ba90b9398c714"

URI_aarch64_kf6-kcalendarcore = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcalendarcore-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kcalendarcore;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcalendarcore}"
SRC_URI[aarch64_kf6-kcalendarcore.sha256sum] = "816f08c95a64dad522d163d4e020294019ef07230a62613a203c34cb132099f2"

URI_aarch64_kf6-kcalendarcore-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcalendarcore-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kcalendarcore-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcalendarcore-devel}"
SRC_URI[aarch64_kf6-kcalendarcore-devel.sha256sum] = "d1ab2dfe6c131b5425a9b1adee92273e62778f648a2b8a88e27e98af26e1c505"

URI_aarch64_kf6-kcalendarcore-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcalendarcore-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kcalendarcore-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcalendarcore-doc}"
SRC_URI[aarch64_kf6-kcalendarcore-doc.sha256sum] = "b66384fd7221e7eb9b6204409d726a5acf8cd7db15f6aa0bd8eb737de4ba5ab8"

URI_aarch64_kf6-kcalendarcore-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcalendarcore-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kcalendarcore-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcalendarcore-html}"
SRC_URI[aarch64_kf6-kcalendarcore-html.sha256sum] = "eb31d073dba4e0d41d4797c323902cbc5f03f9f6f41dd7ca56dba4a77d60544b"

RDEPENDS:kf6-kcalendarcore = " \
 glibc \
 libical \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kcalendarcore-devel = " \
 cmake-filesystem \
 kf6-kcalendarcore \
 libical-devel \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kcalendarcore-doc = " \
 "
RDEPENDS:kf6-kcalendarcore-html = " \
 "
