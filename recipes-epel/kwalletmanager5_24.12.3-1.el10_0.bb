# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kwalletmanager5"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kwalletmanager5 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kwalletmanager5-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7de8075d8b06849e4d8bc94b60ca202f035f782aa41f8bff620deda4b712809a"

URI_x86_64_v2_kwalletmanager5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwalletmanager5-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwalletmanager5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwalletmanager5}"
SRC_URI[x86_64_v2_kwalletmanager5.sha256sum] = "3c2f0cfdb765bec97ffcf71ff6fe2ec77a60ea3c2509e42206b66a195e4012ab"

URI_aarch64_kwalletmanager5 = "${EPEL_MIRROR}/aarch64/Packages/k/kwalletmanager5-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kwalletmanager5;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwalletmanager5}"
SRC_URI[aarch64_kwalletmanager5.sha256sum] = "9e6491c40e3817aaec5d9b27f5dae020ed17fd00475f572b79573c4fe8e7a46f"

RDEPENDS:kwalletmanager5 = " \
 glibc \
 kf6-karchive \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kitemviews \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
