# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-th-compat"
PV = "0.1.5"
PR = "1.el10_0"
PACKAGES = " \
 ghc-th-compat \
 ghc-th-compat-devel \
 ghc-th-compat-doc \
 ghc-th-compat-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-th-compat-0.1.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a32dee14c71db478c2b18bd8284b95115373e2a8f294cd6f7ad02fc5bbef9c4"

URI_x86_64_v2_ghc-th-compat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-th-compat-0.1.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-th-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-th-compat}"
SRC_URI[x86_64_v2_ghc-th-compat.sha256sum] = "2e585d893131b7ab7c8060b3394b336b6352afe3f6cf78b7d046325edca869b9"

URI_x86_64_v2_ghc-th-compat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-th-compat-devel-0.1.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-th-compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-th-compat-devel}"
SRC_URI[x86_64_v2_ghc-th-compat-devel.sha256sum] = "015d4bab95fea143ba184b1e0b2cd077a9528c6b1380628a842bab2e9e48192e"

URI_x86_64_v2_ghc-th-compat-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-th-compat-doc-0.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-th-compat-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-th-compat-doc}"
SRC_URI[x86_64_v2_ghc-th-compat-doc.sha256sum] = "82e74650d11d461b50c53a0e5f0a574e10290ef99d6be7c7399f7c568e8a1839"

URI_x86_64_v2_ghc-th-compat-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-th-compat-prof-0.1.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-th-compat-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-th-compat-prof}"
SRC_URI[x86_64_v2_ghc-th-compat-prof.sha256sum] = "878832560b938c4446ce715bb02963e6afcef9b28ce2ad5b5bcd23017e6aee91"

URI_aarch64_ghc-th-compat = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-th-compat-0.1.5-1.el10_0.aarch64.rpm;name=aarch64_ghc-th-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-th-compat}"
SRC_URI[aarch64_ghc-th-compat.sha256sum] = "33da0a81d7f01f874fab08f7877a9459a791b46fa4cf44a925eddb10a1b19a01"

URI_aarch64_ghc-th-compat-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-th-compat-devel-0.1.5-1.el10_0.aarch64.rpm;name=aarch64_ghc-th-compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-th-compat-devel}"
SRC_URI[aarch64_ghc-th-compat-devel.sha256sum] = "4b7b4231004437f6cf19990344c5ed5eb821412993c58a7182db5425039e3ead"

URI_aarch64_ghc-th-compat-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-th-compat-doc-0.1.5-1.el10_0.noarch.rpm;name=aarch64_ghc-th-compat-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-th-compat-doc}"
SRC_URI[aarch64_ghc-th-compat-doc.sha256sum] = "f592ab641b20ce5e97e80cd5449bf0e1bc35be137046b67f51fae047c83c85a1"

URI_aarch64_ghc-th-compat-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-th-compat-prof-0.1.5-1.el10_0.aarch64.rpm;name=aarch64_ghc-th-compat-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-th-compat-prof}"
SRC_URI[aarch64_ghc-th-compat-prof.sha256sum] = "d4bc5014618e1467b6a55b041826125236dd2e5eb08f6d60ee2ba38789ecaceb"

RDEPENDS:ghc-th-compat = " \
 ghc-array \
 ghc-base \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-th-compat-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-template-haskell-devel \
 ghc-th-compat \
 "
RDEPENDS:ghc-th-compat-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-th-compat-prof = " \
 ghc-base-prof \
 ghc-template-haskell-prof \
 ghc-th-compat-devel \
 "
