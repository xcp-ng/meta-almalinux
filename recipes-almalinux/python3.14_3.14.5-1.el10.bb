# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.14"
PV = "3.14.5"
PR = "1.el10"
PACKAGES = " \
 python3.14 \
 python3.14-debug \
 python3.14-devel \
 python3.14-freethreading \
 python3.14-freethreading-debug \
 python3.14-freethreading-devel \
 python3.14-freethreading-idle \
 python3.14-freethreading-libs \
 python3.14-freethreading-test \
 python3.14-freethreading-tkinter \
 python3.14-idle \
 python3.14-libs \
 python3.14-test \
 python3.14-tkinter \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python3.14-3.14.5-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "314ebac2432d8b322ab05431aeff018fa9a2a74df7c446bf24c0d4940bf679ef"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - python3.14-freethreading-test: (python3.14-wheel-wheel if python3.14-setuptools-wheel < 71)
# - python3.14-test: (python3.14-wheel-wheel if python3.14-setuptools-wheel < 71)

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - python3.14-freethreading-test: (python3.14-wheel-wheel if python3.14-setuptools-wheel < 71)
# - python3.14-test: (python3.14-wheel-wheel if python3.14-setuptools-wheel < 71)

URI_x86_64_v2_python3.14 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-3.14.5-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14}"
SRC_URI[x86_64_v2_python3.14.sha256sum] = "368941eb600123a96fae8eeca2607ed6882cc0cc32eb54b2d7a72289d3c27e2c"

URI_x86_64_v2_python3.14-debug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-debug-3.14.5-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-debug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-debug}"
SRC_URI[x86_64_v2_python3.14-debug.sha256sum] = "0ecf5bcfa167d07de3ec67f5012245bdc40b5f67544a8810e02bab1b71438ea5"

URI_x86_64_v2_python3.14-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-devel-3.14.5-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-devel}"
SRC_URI[x86_64_v2_python3.14-devel.sha256sum] = "174c58562f1d48085ac3a55e24e7506976f24cf6078008a3568fb94d6685f81c"

URI_x86_64_v2_python3.14-freethreading = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-freethreading-3.14.5-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-freethreading;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-freethreading}"
SRC_URI[x86_64_v2_python3.14-freethreading.sha256sum] = "4d770f2f63caacec3b8f0dd7eca0bb79bafcfd5a0be8d9e5098ecc9c0536aa90"

URI_x86_64_v2_python3.14-freethreading-debug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-freethreading-debug-3.14.5-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-freethreading-debug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-freethreading-debug}"
SRC_URI[x86_64_v2_python3.14-freethreading-debug.sha256sum] = "f480209911de1ecd7763bb2e8072c878ecc48b81fff8090ea9fd3589d48623eb"

URI_x86_64_v2_python3.14-freethreading-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-freethreading-devel-3.14.5-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-freethreading-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-freethreading-devel}"
SRC_URI[x86_64_v2_python3.14-freethreading-devel.sha256sum] = "09d5ac60edc65ed89e7428824d2ff19c5ec8bf9fc20ef289cea6907ad9e275d4"

URI_x86_64_v2_python3.14-freethreading-idle = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-freethreading-idle-3.14.5-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-freethreading-idle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-freethreading-idle}"
SRC_URI[x86_64_v2_python3.14-freethreading-idle.sha256sum] = "aa3896dea42a2a7bb253756edee202271527f63590c120a108ff196a43f04a97"

URI_x86_64_v2_python3.14-freethreading-libs = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-freethreading-libs-3.14.5-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-freethreading-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-freethreading-libs}"
SRC_URI[x86_64_v2_python3.14-freethreading-libs.sha256sum] = "1d8c46b00a015394184bfbcd33b73e3a7fa5bfb4c07a8038f078a14e63f8ab13"

URI_x86_64_v2_python3.14-freethreading-test = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-freethreading-test-3.14.5-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-freethreading-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-freethreading-test}"
SRC_URI[x86_64_v2_python3.14-freethreading-test.sha256sum] = "25716812138eb5091736d0e08973957102d912dfa4a974ac765236a932b8c4b7"

URI_x86_64_v2_python3.14-freethreading-tkinter = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-freethreading-tkinter-3.14.5-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-freethreading-tkinter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-freethreading-tkinter}"
SRC_URI[x86_64_v2_python3.14-freethreading-tkinter.sha256sum] = "ffdaa6e03e43d5d74f863e48d13a3bb2050103b177b5b100faa03e18c7a355c1"

URI_x86_64_v2_python3.14-idle = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-idle-3.14.5-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-idle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-idle}"
SRC_URI[x86_64_v2_python3.14-idle.sha256sum] = "a5839ee8e8bce48a223eec047c224fd0974681b12bd44d07549e0595db7781cc"

URI_x86_64_v2_python3.14-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-libs-3.14.5-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-libs}"
SRC_URI[x86_64_v2_python3.14-libs.sha256sum] = "856ae2ab6c527903b7971fd3c48f8e90fcb78d3713b7b853fbab3e899e3593e5"

URI_x86_64_v2_python3.14-test = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-test-3.14.5-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-test}"
SRC_URI[x86_64_v2_python3.14-test.sha256sum] = "84f8eea5a9920bdec6c7c538a880ac20b88ba10c6a416cbe165de631577130bc"

URI_x86_64_v2_python3.14-tkinter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-tkinter-3.14.5-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-tkinter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-tkinter}"
SRC_URI[x86_64_v2_python3.14-tkinter.sha256sum] = "c981615f79c06d473fb0dc3cfa01cbb9ebf4182ea493cbf44f006ea23cc0a1bf"

URI_aarch64_python3.14 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-3.14.5-1.el10.aarch64.rpm;name=aarch64_python3.14;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14}"
SRC_URI[aarch64_python3.14.sha256sum] = "5eb09feae06d8cab50988777626cc03e1d29518af924064d78ecc1e1f1a83d82"

URI_aarch64_python3.14-debug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-debug-3.14.5-1.el10.aarch64.rpm;name=aarch64_python3.14-debug;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-debug}"
SRC_URI[aarch64_python3.14-debug.sha256sum] = "5fcab7d7b4db06e651f33c3e46621aa7c1c7367aeaf19905a5f37c7097d774f8"

URI_aarch64_python3.14-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-devel-3.14.5-1.el10.aarch64.rpm;name=aarch64_python3.14-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-devel}"
SRC_URI[aarch64_python3.14-devel.sha256sum] = "1251ec2c36335fadd13bc9322f99e760ad3348e7de56c69c96855838081714df"

URI_aarch64_python3.14-freethreading = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-freethreading-3.14.5-1.el10.aarch64.rpm;name=aarch64_python3.14-freethreading;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-freethreading}"
SRC_URI[aarch64_python3.14-freethreading.sha256sum] = "64aa461d982e938256e8f949659c88970f93d79b92bef7bf6265575e9e6e8979"

URI_aarch64_python3.14-freethreading-debug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-freethreading-debug-3.14.5-1.el10.aarch64.rpm;name=aarch64_python3.14-freethreading-debug;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-freethreading-debug}"
SRC_URI[aarch64_python3.14-freethreading-debug.sha256sum] = "e1211abf330e765d9d5116c28a75f313c9ce1104c6525b4d4618b10283b57b93"

URI_aarch64_python3.14-freethreading-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-freethreading-devel-3.14.5-1.el10.aarch64.rpm;name=aarch64_python3.14-freethreading-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-freethreading-devel}"
SRC_URI[aarch64_python3.14-freethreading-devel.sha256sum] = "11fdb35abf3c8d3871315d16611b41db7f7e90a239a158087b122778f76a03b7"

URI_aarch64_python3.14-freethreading-idle = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-freethreading-idle-3.14.5-1.el10.aarch64.rpm;name=aarch64_python3.14-freethreading-idle;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-freethreading-idle}"
SRC_URI[aarch64_python3.14-freethreading-idle.sha256sum] = "1ea383a2ddd0765919621c831fcf5e3f87a28d15bc9f942ea2244440eb8aa98f"

URI_aarch64_python3.14-freethreading-libs = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-freethreading-libs-3.14.5-1.el10.aarch64.rpm;name=aarch64_python3.14-freethreading-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-freethreading-libs}"
SRC_URI[aarch64_python3.14-freethreading-libs.sha256sum] = "2f907b167bd3f9942cab32f4b6f3283978c097c373a99ecda1a30e5803828b6b"

URI_aarch64_python3.14-freethreading-test = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-freethreading-test-3.14.5-1.el10.aarch64.rpm;name=aarch64_python3.14-freethreading-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-freethreading-test}"
SRC_URI[aarch64_python3.14-freethreading-test.sha256sum] = "c78aa57bb495e8b41a0c1bf8290cce7e8b622d61f8347368a2e6061d98318848"

URI_aarch64_python3.14-freethreading-tkinter = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-freethreading-tkinter-3.14.5-1.el10.aarch64.rpm;name=aarch64_python3.14-freethreading-tkinter;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-freethreading-tkinter}"
SRC_URI[aarch64_python3.14-freethreading-tkinter.sha256sum] = "866c22de9351569a5f3a2b09aa20276ec8c22a00d1083162831708e2e12c40ac"

URI_aarch64_python3.14-idle = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-idle-3.14.5-1.el10.aarch64.rpm;name=aarch64_python3.14-idle;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-idle}"
SRC_URI[aarch64_python3.14-idle.sha256sum] = "d6ab406ef9659fe30131e015c4fef24a29845e8e0ac1162fda6ba57dcb5370b1"

URI_aarch64_python3.14-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-libs-3.14.5-1.el10.aarch64.rpm;name=aarch64_python3.14-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-libs}"
SRC_URI[aarch64_python3.14-libs.sha256sum] = "412f81c2e2afd398217ded2ce6c1003db7141813b82427cda21fd4d71246b86f"

URI_aarch64_python3.14-test = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-test-3.14.5-1.el10.aarch64.rpm;name=aarch64_python3.14-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-test}"
SRC_URI[aarch64_python3.14-test.sha256sum] = "3681d6de944e28633f8463a3ed2e2de6cc182eac2b7af2e0aee090bd0e5b1d26"

URI_aarch64_python3.14-tkinter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-tkinter-3.14.5-1.el10.aarch64.rpm;name=aarch64_python3.14-tkinter;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-tkinter}"
SRC_URI[aarch64_python3.14-tkinter.sha256sum] = "827b1316d798a94018642ce87ca2e419fce23ea4e47e2cd2e56825cbcc414569"

RDEPENDS:python3.14 = " \
 glibc \
 python3.14-libs \
 "
RDEPENDS:python3.14-debug = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libgcc \
 libuuid \
 libzstd \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 pkgconf-pkg-config \
 python3.14 \
 python3.14-devel \
 python3.14-idle \
 python3.14-libs \
 python3.14-test \
 python3.14-tkinter \
 readline \
 sqlite-libs \
 tcl \
 tk \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3.14-devel = " \
 bash \
 pkgconf-pkg-config \
 python-rpm-macros \
 python3-rpm-generators \
 python3-rpm-macros \
 python3.14 \
 python3.14-libs \
 "
RDEPENDS:python3.14-freethreading = " \
 glibc \
 python3.14-freethreading-libs \
 "
RDEPENDS:python3.14-freethreading-debug = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libgcc \
 libuuid \
 libzstd \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 pkgconf-pkg-config \
 python3.14-freethreading \
 python3.14-freethreading-devel \
 python3.14-freethreading-idle \
 python3.14-freethreading-libs \
 python3.14-freethreading-test \
 python3.14-freethreading-tkinter \
 readline \
 sqlite-libs \
 tcl \
 tk \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3.14-freethreading-devel = " \
 bash \
 pkgconf-pkg-config \
 python3.14-freethreading \
 python3.14-freethreading-libs \
 "
RDEPENDS:python3.14-freethreading-idle = " \
 python3.14-freethreading \
 python3.14-freethreading-tkinter \
 "
RDEPENDS:python3.14-freethreading-libs = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libuuid \
 libzstd \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 python3.14-pip-wheel \
 readline \
 sqlite-libs \
 tzdata \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3.14-freethreading-test = " \
 bash \
 glibc \
 libgcc \
 python3.14-freethreading \
 python3.14-freethreading-libs \
 python3.14-setuptools-wheel \
 "
RDEPENDS:python3.14-freethreading-tkinter = " \
 glibc \
 python3.14-freethreading \
 tcl \
 tk \
 "
RDEPENDS:python3.14-idle = " \
 python3.14 \
 python3.14-tkinter \
 "
RDEPENDS:python3.14-libs = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libuuid \
 libzstd \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 python3.14-pip-wheel \
 readline \
 sqlite-libs \
 tzdata \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3.14-test = " \
 bash \
 glibc \
 libgcc \
 python3.14 \
 python3.14-libs \
 python3.14-setuptools-wheel \
 "
RDEPENDS:python3.14-tkinter = " \
 glibc \
 python3.14 \
 tcl \
 tk \
 "
