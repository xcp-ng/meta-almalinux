# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tripwire"
PV = "2.4.3.7"
PR = "20.el10_2"
PACKAGES = " \
 tripwire \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tripwire-2.4.3.7-20.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a2048ee3e90ea61cffd5d913921f1a7d4e5d3d2b882bb623e49c6b4f3519b9a2"

URI_x86_64_v2_tripwire = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tripwire-2.4.3.7-20.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tripwire;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tripwire}"
SRC_URI[x86_64_v2_tripwire.sha256sum] = "6780d6bae1ccc1b714ed5de565a6b6ef1977bc299ec2dec7ce520124b960a750"

URI_aarch64_tripwire = "${EPEL_MIRROR}/aarch64/Packages/t/tripwire-2.4.3.7-20.el10_2.aarch64.rpm;name=aarch64_tripwire;unpack=0"
SRC_URI:append = " ${URI_aarch64_tripwire}"
SRC_URI[aarch64_tripwire.sha256sum] = "ae312e2477878a9e63e2b578eae488ec29fa08c1f7731bf4b64cf6dea62a0330"

RDEPENDS:tripwire = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 sed \
 "
