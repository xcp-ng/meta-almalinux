# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mingw-crt"
PV = "12.0.0"
PR = "4.el10"
PACKAGES = " \
 mingw32-crt \
 mingw64-crt \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/mingw-crt-12.0.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "717d8fde6a0385aa0290acfa5dda40a57dc464b028cfd71bf7eef428de81089c"

URI_x86_64_v2_mingw32-crt = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw32-crt-12.0.0-4.el10.noarch.rpm;name=x86_64_v2_mingw32-crt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-crt}"
SRC_URI[x86_64_v2_mingw32-crt.sha256sum] = "8e66c10a87573d753507215101ae3b058da48663a86122e1e156f619794bba3e"

URI_x86_64_v2_mingw64-crt = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw64-crt-12.0.0-4.el10.noarch.rpm;name=x86_64_v2_mingw64-crt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-crt}"
SRC_URI[x86_64_v2_mingw64-crt.sha256sum] = "8cdfb928028d9db26d56e08fd8767bf519f4c8306e2e3be73d570cf6f6e080e9"

URI_aarch64_mingw32-crt = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw32-crt-12.0.0-4.el10.noarch.rpm;name=aarch64_mingw32-crt;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw32-crt}"
SRC_URI[aarch64_mingw32-crt.sha256sum] = "8e66c10a87573d753507215101ae3b058da48663a86122e1e156f619794bba3e"

URI_aarch64_mingw64-crt = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw64-crt-12.0.0-4.el10.noarch.rpm;name=aarch64_mingw64-crt;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw64-crt}"
SRC_URI[aarch64_mingw64-crt.sha256sum] = "8cdfb928028d9db26d56e08fd8767bf519f4c8306e2e3be73d570cf6f6e080e9"

RDEPENDS:mingw32-crt = " \
 mingw32-filesystem \
 "
RDEPENDS:mingw64-crt = " \
 mingw64-filesystem \
 "
