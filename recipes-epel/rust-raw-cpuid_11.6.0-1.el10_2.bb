# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-raw-cpuid"
PV = "11.6.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-raw-cpuid+default-devel \
 rust-raw-cpuid+serde-devel \
 rust-raw-cpuid+serde_derive-devel \
 rust-raw-cpuid+serde_json-devel \
 rust-raw-cpuid+serialize-devel \
 rust-raw-cpuid+std-devel \
 rust-raw-cpuid-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-raw-cpuid-11.6.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "631b8774f7660c85481e52970784a659eb74c58a5647257820a48f6ec9ab84e8"

URI_x86_64_v2_rust-raw-cpuid+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-raw-cpuid+default-devel-11.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-raw-cpuid+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-raw-cpuid+default-devel}"
SRC_URI[x86_64_v2_rust-raw-cpuid+default-devel.sha256sum] = "29de35faaa62de54271645e8f60948958164d18376de0d74bc64dae9afce93d5"

URI_x86_64_v2_rust-raw-cpuid+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-raw-cpuid+serde-devel-11.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-raw-cpuid+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-raw-cpuid+serde-devel}"
SRC_URI[x86_64_v2_rust-raw-cpuid+serde-devel.sha256sum] = "88ba96c2dc4a693431bc3c84f58f6d023f892b8962a5fad08c40baf1a937c890"

URI_x86_64_v2_rust-raw-cpuid+serde_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-raw-cpuid+serde_derive-devel-11.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-raw-cpuid+serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-raw-cpuid+serde_derive-devel}"
SRC_URI[x86_64_v2_rust-raw-cpuid+serde_derive-devel.sha256sum] = "1f36f12b99743f4d693ae71f73405a84155265d71a1070b989ce049102b03c7f"

URI_x86_64_v2_rust-raw-cpuid+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-raw-cpuid+serde_json-devel-11.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-raw-cpuid+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-raw-cpuid+serde_json-devel}"
SRC_URI[x86_64_v2_rust-raw-cpuid+serde_json-devel.sha256sum] = "875f4d773e32530598dffc19d578bce42e289cea727f33a6e2b85d1c8c121ca8"

URI_x86_64_v2_rust-raw-cpuid+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-raw-cpuid+serialize-devel-11.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-raw-cpuid+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-raw-cpuid+serialize-devel}"
SRC_URI[x86_64_v2_rust-raw-cpuid+serialize-devel.sha256sum] = "f2872e6da21cf8a6e6707e3251f5ea301ac222d5f8b0f3d99491c7eabdc6e5f8"

URI_x86_64_v2_rust-raw-cpuid+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-raw-cpuid+std-devel-11.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-raw-cpuid+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-raw-cpuid+std-devel}"
SRC_URI[x86_64_v2_rust-raw-cpuid+std-devel.sha256sum] = "b941fba2ba5cabf126ec9792013da8a64db9204a3bc1cc0a70938b7d6d015a94"

URI_x86_64_v2_rust-raw-cpuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-raw-cpuid-devel-11.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-raw-cpuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-raw-cpuid-devel}"
SRC_URI[x86_64_v2_rust-raw-cpuid-devel.sha256sum] = "dfe563997f91a365ed91f72363746ce33e5566506e522ba4ff2d1ff02b64ad96"

URI_aarch64_rust-raw-cpuid+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-raw-cpuid+default-devel-11.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-raw-cpuid+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-raw-cpuid+default-devel}"
SRC_URI[aarch64_rust-raw-cpuid+default-devel.sha256sum] = "a4d5268c4be36ae22da31feabd09a5ac250cb833c35e818c2084a86c36f1c73a"

URI_aarch64_rust-raw-cpuid+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-raw-cpuid+serde-devel-11.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-raw-cpuid+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-raw-cpuid+serde-devel}"
SRC_URI[aarch64_rust-raw-cpuid+serde-devel.sha256sum] = "2f2ec2f3e041471c027d0fb97426c0075bca81acc4fb96bb0afcdb4ba32d4082"

URI_aarch64_rust-raw-cpuid+serde_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-raw-cpuid+serde_derive-devel-11.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-raw-cpuid+serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-raw-cpuid+serde_derive-devel}"
SRC_URI[aarch64_rust-raw-cpuid+serde_derive-devel.sha256sum] = "7615ce717a9176b9b069e21a7d7d6aee290d79f125d99292c824d6de5e6e6638"

URI_aarch64_rust-raw-cpuid+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-raw-cpuid+serde_json-devel-11.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-raw-cpuid+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-raw-cpuid+serde_json-devel}"
SRC_URI[aarch64_rust-raw-cpuid+serde_json-devel.sha256sum] = "9391b37c28dc3f2b2ea95c34ebee478b4b218e440b6020951e178d8f2a9fe7f3"

URI_aarch64_rust-raw-cpuid+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-raw-cpuid+serialize-devel-11.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-raw-cpuid+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-raw-cpuid+serialize-devel}"
SRC_URI[aarch64_rust-raw-cpuid+serialize-devel.sha256sum] = "1b6e375918d00a91ff305d157a2527dd48c61d9050defb30205966bd144bbf0e"

URI_aarch64_rust-raw-cpuid+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-raw-cpuid+std-devel-11.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-raw-cpuid+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-raw-cpuid+std-devel}"
SRC_URI[aarch64_rust-raw-cpuid+std-devel.sha256sum] = "ab7cc5f5fa02d94c5959643e30bc265217da11e19e320d945fadff26f162e4a1"

URI_aarch64_rust-raw-cpuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-raw-cpuid-devel-11.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-raw-cpuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-raw-cpuid-devel}"
SRC_URI[aarch64_rust-raw-cpuid-devel.sha256sum] = "c5f575cfe3b48b2ba5d3a0f30c304cab58c6272b556182642a4c629b5febe8c3"

RDEPENDS:rust-raw-cpuid+default-devel = " \
 cargo \
 rust-raw-cpuid-devel \
 "
RDEPENDS:rust-raw-cpuid+serde-devel = " \
 cargo \
 rust-raw-cpuid-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-raw-cpuid+serde_derive-devel = " \
 cargo \
 rust-raw-cpuid-devel \
 rust-serde_derive+default-devel \
 "
RDEPENDS:rust-raw-cpuid+serde_json-devel = " \
 cargo \
 rust-raw-cpuid-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-raw-cpuid+serialize-devel = " \
 cargo \
 rust-raw-cpuid+serde-devel \
 rust-raw-cpuid+serde_derive-devel \
 rust-raw-cpuid-devel \
 "
RDEPENDS:rust-raw-cpuid+std-devel = " \
 cargo \
 rust-raw-cpuid-devel \
 "
RDEPENDS:rust-raw-cpuid-devel = " \
 cargo \
 rust-bitflags+default-devel \
 "
