# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-settings"
PV = "25.02.0"
PR = "1.el10_0"
PACKAGES = " \
 plasma-settings \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-settings-25.02.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af0e79220df1db4a9a5c5ec48d62225918c14fa5e0311e953004f8b1dcc0d132"

URI_x86_64_v2_plasma-settings = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-settings-25.02.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-settings;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-settings}"
SRC_URI[x86_64_v2_plasma-settings.sha256sum] = "7bf60a119e5a88ff52d29b212ed3d491fe72eb79ed8d002b65b4ffcdacfe889a"

URI_aarch64_plasma-settings = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-settings-25.02.0-1.el10_0.aarch64.rpm;name=aarch64_plasma-settings;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-settings}"
SRC_URI[aarch64_plasma-settings.sha256sum] = "e66dffce2b57d89830be90755a0fb3c944fca4a782717c78b4c8d0929748b32d"

RDEPENDS:plasma-settings = " \
 accountsservice \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kitemmodels \
 kf6-kitemviews \
 kf6-kservice \
 libstdc++ \
 polkit-kde \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 sound-theme-freedesktop \
 "
