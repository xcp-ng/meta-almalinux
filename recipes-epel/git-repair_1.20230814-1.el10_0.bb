# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "git-repair"
PV = "1.20230814"
PR = "1.el10_0"
PACKAGES = " \
 git-repair \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/git-repair-1.20230814-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5fc9ffd1186e9c4128f624b430759b396dcbe533edb9e81447c706d94d95121d"

URI_x86_64_v2_git-repair = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/git-repair-1.20230814-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_git-repair;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-repair}"
SRC_URI[x86_64_v2_git-repair.sha256sum] = "9e1deb161aadba68b4ef74ba8469cd63c5ce0a8949a634d5cc3eac6c7af868de"

URI_aarch64_git-repair = "${EPEL_MIRROR}/aarch64/Packages/g/git-repair-1.20230814-1.el10_0.aarch64.rpm;name=aarch64_git-repair;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-repair}"
SRC_URI[aarch64_git-repair.sha256sum] = "40e2634245e3510825db070ba66751b47612ba6a167a9536eca875dd2abdc39f"

RDEPENDS:git-repair = " \
 git-core \
 glibc \
 gmp \
 libffi \
 "
