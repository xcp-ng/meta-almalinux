# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opendbx"
PV = "1.4.6"
PR = "40.el10_1"
PACKAGES = " \
 opendbx \
 opendbx-devel \
 opendbx-mssql \
 opendbx-mysql \
 opendbx-postgresql \
 opendbx-sqlite \
 opendbx-sybase \
 opendbx-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/opendbx-1.4.6-40.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5cb6ca6527855e6487717a023f3bc124943be2d3be474679f6f91069aa3075b5"

URI_x86_64_v2_opendbx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opendbx-1.4.6-40.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opendbx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opendbx}"
SRC_URI[x86_64_v2_opendbx.sha256sum] = "b631c71a1d704c700fdd0b9aa48f063250309cf42e071608ab85e3642b184dfb"

URI_x86_64_v2_opendbx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opendbx-devel-1.4.6-40.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opendbx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opendbx-devel}"
SRC_URI[x86_64_v2_opendbx-devel.sha256sum] = "e6c9ee1ea26f442271fb7496035929b57ed6b7641532716cfdff1512356f73f8"

URI_x86_64_v2_opendbx-mssql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opendbx-mssql-1.4.6-40.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opendbx-mssql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opendbx-mssql}"
SRC_URI[x86_64_v2_opendbx-mssql.sha256sum] = "ea19a332ef643c23ed33dd1afce88bd4aad3765a67a8dee4a14d3f827d69d15d"

URI_x86_64_v2_opendbx-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opendbx-mysql-1.4.6-40.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opendbx-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opendbx-mysql}"
SRC_URI[x86_64_v2_opendbx-mysql.sha256sum] = "6f74a85fe6a37b12b249cc1c8bdf8926706c7b6ec52807617c9238e26a49f40c"

URI_x86_64_v2_opendbx-postgresql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opendbx-postgresql-1.4.6-40.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opendbx-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opendbx-postgresql}"
SRC_URI[x86_64_v2_opendbx-postgresql.sha256sum] = "c64b2846f32c62f80dc6c8cd815791d67f5a4e064126cb808c773b745deb662b"

URI_x86_64_v2_opendbx-sqlite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opendbx-sqlite-1.4.6-40.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opendbx-sqlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opendbx-sqlite}"
SRC_URI[x86_64_v2_opendbx-sqlite.sha256sum] = "7e4305fe75412bedc207df9b773d5b8abf21b9cef2ad76bffbcb299c1de0531d"

URI_x86_64_v2_opendbx-sybase = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opendbx-sybase-1.4.6-40.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opendbx-sybase;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opendbx-sybase}"
SRC_URI[x86_64_v2_opendbx-sybase.sha256sum] = "45b62519385ab263cf547641ba3921ee379f6b9158b520a5c544c0c839f84123"

URI_x86_64_v2_opendbx-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opendbx-utils-1.4.6-40.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opendbx-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opendbx-utils}"
SRC_URI[x86_64_v2_opendbx-utils.sha256sum] = "ed023433933d438b258cf459719c4dc164d12dcea3970737dbb959dec18fc5e5"

URI_aarch64_opendbx = "${EPEL_MIRROR}/aarch64/Packages/o/opendbx-1.4.6-40.el10_1.aarch64.rpm;name=aarch64_opendbx;unpack=0"
SRC_URI:append = " ${URI_aarch64_opendbx}"
SRC_URI[aarch64_opendbx.sha256sum] = "3e494df22199db567c0f951a1030321f9e6b9ef813083768e9ef966f2dafdca7"

URI_aarch64_opendbx-devel = "${EPEL_MIRROR}/aarch64/Packages/o/opendbx-devel-1.4.6-40.el10_1.aarch64.rpm;name=aarch64_opendbx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_opendbx-devel}"
SRC_URI[aarch64_opendbx-devel.sha256sum] = "be7424a28e63cccde77072192189d34b6c909498a798144bdf8efe41a0cbb438"

URI_aarch64_opendbx-mssql = "${EPEL_MIRROR}/aarch64/Packages/o/opendbx-mssql-1.4.6-40.el10_1.aarch64.rpm;name=aarch64_opendbx-mssql;unpack=0"
SRC_URI:append = " ${URI_aarch64_opendbx-mssql}"
SRC_URI[aarch64_opendbx-mssql.sha256sum] = "c59fd57a02b7cbab916217d115b7688b3b9f4bc72f336537c6726cfae87ffe8c"

URI_aarch64_opendbx-mysql = "${EPEL_MIRROR}/aarch64/Packages/o/opendbx-mysql-1.4.6-40.el10_1.aarch64.rpm;name=aarch64_opendbx-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_opendbx-mysql}"
SRC_URI[aarch64_opendbx-mysql.sha256sum] = "1f6a1d86650e8cd6fa4ae34902d2b14d89f1b702ad8e1daa2106d855a96f4858"

URI_aarch64_opendbx-postgresql = "${EPEL_MIRROR}/aarch64/Packages/o/opendbx-postgresql-1.4.6-40.el10_1.aarch64.rpm;name=aarch64_opendbx-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_opendbx-postgresql}"
SRC_URI[aarch64_opendbx-postgresql.sha256sum] = "790ca98162df1738e87f41504875485207879d5308151ff1dd78498c5b8d0c98"

URI_aarch64_opendbx-sqlite = "${EPEL_MIRROR}/aarch64/Packages/o/opendbx-sqlite-1.4.6-40.el10_1.aarch64.rpm;name=aarch64_opendbx-sqlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_opendbx-sqlite}"
SRC_URI[aarch64_opendbx-sqlite.sha256sum] = "e431fbfc0e16563c4f3d6b87aeb8ff4999953f0f9bd6c2d5963a89cdc7ba896f"

URI_aarch64_opendbx-sybase = "${EPEL_MIRROR}/aarch64/Packages/o/opendbx-sybase-1.4.6-40.el10_1.aarch64.rpm;name=aarch64_opendbx-sybase;unpack=0"
SRC_URI:append = " ${URI_aarch64_opendbx-sybase}"
SRC_URI[aarch64_opendbx-sybase.sha256sum] = "084e5cd920136f7263f2b511604dc25e1b40f8da05f09762a99fd5b002a1cc08"

URI_aarch64_opendbx-utils = "${EPEL_MIRROR}/aarch64/Packages/o/opendbx-utils-1.4.6-40.el10_1.aarch64.rpm;name=aarch64_opendbx-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_opendbx-utils}"
SRC_URI[aarch64_opendbx-utils.sha256sum] = "58aedb398d51ee3092aa3a107f3bf58f9dc4b8bd557d40a9dcea9757c8c56f12"

RDEPENDS:opendbx = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:opendbx-devel = " \
 opendbx \
 pkgconf-pkg-config \
 "
RDEPENDS:opendbx-mssql = " \
 opendbx \
 "
RDEPENDS:opendbx-mysql = " \
 opendbx \
 "
RDEPENDS:opendbx-postgresql = " \
 opendbx \
 "
RDEPENDS:opendbx-sqlite = " \
 opendbx \
 "
RDEPENDS:opendbx-sybase = " \
 opendbx \
 "
RDEPENDS:opendbx-utils = " \
 glibc \
 libgcc \
 libstdc++ \
 ncurses-libs \
 opendbx \
 readline \
 "
