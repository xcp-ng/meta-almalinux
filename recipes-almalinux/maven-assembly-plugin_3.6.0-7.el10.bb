# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "maven-assembly-plugin"
PV = "3.6.0"
PR = "7.el10"
PACKAGES = " \
 maven-assembly-plugin \
 maven-assembly-plugin-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/maven-assembly-plugin-3.6.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "20ceca42f947f66c711c2e489acea038d8ab3a9275343dbdfc249ecd2dcd6f27"

URI_x86_64_v2_maven-assembly-plugin = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-assembly-plugin-3.6.0-7.el10.noarch.rpm;name=x86_64_v2_maven-assembly-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-assembly-plugin}"
SRC_URI[x86_64_v2_maven-assembly-plugin.sha256sum] = "a9ae34081e20a2c3dc7414ff531858ad815cb3a2be6dc37ec054ecb538cfedc7"

URI_x86_64_v2_maven-assembly-plugin-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-assembly-plugin-javadoc-3.6.0-7.el10.noarch.rpm;name=x86_64_v2_maven-assembly-plugin-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-assembly-plugin-javadoc}"
SRC_URI[x86_64_v2_maven-assembly-plugin-javadoc.sha256sum] = "7ab57b45ae2c9779a3ae53fda6eaee033f265cc51af7401f60cfcd808d58b7fb"

URI_aarch64_maven-assembly-plugin = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-assembly-plugin-3.6.0-7.el10.noarch.rpm;name=aarch64_maven-assembly-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-assembly-plugin}"
SRC_URI[aarch64_maven-assembly-plugin.sha256sum] = "a9ae34081e20a2c3dc7414ff531858ad815cb3a2be6dc37ec054ecb538cfedc7"

URI_aarch64_maven-assembly-plugin-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-assembly-plugin-javadoc-3.6.0-7.el10.noarch.rpm;name=aarch64_maven-assembly-plugin-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-assembly-plugin-javadoc}"
SRC_URI[aarch64_maven-assembly-plugin-javadoc.sha256sum] = "7ab57b45ae2c9779a3ae53fda6eaee033f265cc51af7401f60cfcd808d58b7fb"

RDEPENDS:maven-assembly-plugin = " \
 apache-commons-io \
 javapackages-filesystem \
 maven-archiver \
 maven-common-artifact-filters \
 maven-filtering \
 plexus-archiver \
 plexus-interpolation \
 plexus-io \
 plexus-utils \
 "
RDEPENDS:maven-assembly-plugin-javadoc = " \
 javapackages-filesystem \
 "
