# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libnfs"
PV = "5.0.3"
PR = "3.el10_2"
PACKAGES = " \
 libnfs \
 libnfs-devel \
 libnfs-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libnfs-5.0.3-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bdd55cc1d6eed255b12bd7e7fc5e1ab2d30eaa2fc3d0ee461e3ae57534c0268d"

URI_x86_64_v2_libnfs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libnfs-5.0.3-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libnfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnfs}"
SRC_URI[x86_64_v2_libnfs.sha256sum] = "288a56c0f1d5689fc630d7529a5d0cc801124e88a5cb88bd9a7699838c2fc5be"

URI_x86_64_v2_libnfs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libnfs-devel-5.0.3-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libnfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnfs-devel}"
SRC_URI[x86_64_v2_libnfs-devel.sha256sum] = "5b8e633003231b4aa72b943814177ce4e6e032e170aefa9dc1079ccbaab820b1"

URI_x86_64_v2_libnfs-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libnfs-utils-5.0.3-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libnfs-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnfs-utils}"
SRC_URI[x86_64_v2_libnfs-utils.sha256sum] = "07f9441dbeed703dc4ecd1646afc21bffa8f80c7776fc15dc22949b5ce2ffb1c"

URI_aarch64_libnfs = "${EPEL_MIRROR}/aarch64/Packages/l/libnfs-5.0.3-3.el10_2.aarch64.rpm;name=aarch64_libnfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnfs}"
SRC_URI[aarch64_libnfs.sha256sum] = "cef0250e2abc791cc70cd0e38fb998ccac4d70bf3accd723eea0165ddf2a3acd"

URI_aarch64_libnfs-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libnfs-devel-5.0.3-3.el10_2.aarch64.rpm;name=aarch64_libnfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnfs-devel}"
SRC_URI[aarch64_libnfs-devel.sha256sum] = "73dc770208f6a5b588286e5841e777832c58bcaeb44229936b7353a6ca5c702f"

URI_aarch64_libnfs-utils = "${EPEL_MIRROR}/aarch64/Packages/l/libnfs-utils-5.0.3-3.el10_2.aarch64.rpm;name=aarch64_libnfs-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnfs-utils}"
SRC_URI[aarch64_libnfs-utils.sha256sum] = "f75ddb4a5872f7ee7aea62a9495cb94bd754848b7dc4a9e36cd25f6c2860e3d6"

RDEPENDS:libnfs = " \
 glibc \
 "
RDEPENDS:libnfs-devel = " \
 libnfs \
 pkgconf-pkg-config \
 "
RDEPENDS:libnfs-utils = " \
 glibc \
 libnfs \
 "
