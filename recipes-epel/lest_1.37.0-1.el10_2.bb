# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lest"
PV = "1.37.0"
PR = "1.el10_2"
PACKAGES = " \
 lest-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lest-1.37.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ce650c81c3253b4986a85053d3bbbf814ffe83b787b6976eb28e00bec0dec9d"

URI_x86_64_v2_lest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lest-devel-1.37.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_lest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lest-devel}"
SRC_URI[x86_64_v2_lest-devel.sha256sum] = "5e33bd7386092259b621a0a44717c4be6bd169be749a6132028f458511ee9b46"

URI_aarch64_lest-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lest-devel-1.37.0-1.el10_2.noarch.rpm;name=aarch64_lest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lest-devel}"
SRC_URI[aarch64_lest-devel.sha256sum] = "a3be2ddcdaa1b43388aec6b655258cf935e3ff0aec7523289a0662dda14e3c39"

RDEPENDS:lest-devel = " \
 "
