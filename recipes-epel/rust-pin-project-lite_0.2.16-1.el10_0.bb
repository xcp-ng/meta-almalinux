# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pin-project-lite"
PV = "0.2.16"
PR = "1.el10_0"
PACKAGES = " \
 rust-pin-project-lite+default-devel \
 rust-pin-project-lite-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pin-project-lite-0.2.16-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a740a46844c4f254faac758bbfdcfbe65ca4d80105a8e305657f17d728692e0a"

URI_x86_64_v2_rust-pin-project-lite+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pin-project-lite+default-devel-0.2.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pin-project-lite+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pin-project-lite+default-devel}"
SRC_URI[x86_64_v2_rust-pin-project-lite+default-devel.sha256sum] = "d04a737b119b570c64d3706d50336c710022e75ba448606eac78664118430b7c"

URI_x86_64_v2_rust-pin-project-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pin-project-lite-devel-0.2.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pin-project-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pin-project-lite-devel}"
SRC_URI[x86_64_v2_rust-pin-project-lite-devel.sha256sum] = "8ef986a010603e726023fce6d5e0b2f9cd6cd85b25dad333b13d93e1f61f3a7c"

URI_aarch64_rust-pin-project-lite+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pin-project-lite+default-devel-0.2.16-1.el10_0.noarch.rpm;name=aarch64_rust-pin-project-lite+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pin-project-lite+default-devel}"
SRC_URI[aarch64_rust-pin-project-lite+default-devel.sha256sum] = "36818127cce1c3d042e70056adb770704fb3ee7acdb95792437e039a2396dab5"

URI_aarch64_rust-pin-project-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pin-project-lite-devel-0.2.16-1.el10_0.noarch.rpm;name=aarch64_rust-pin-project-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pin-project-lite-devel}"
SRC_URI[aarch64_rust-pin-project-lite-devel.sha256sum] = "3488925a5a2ba05bdbf7b8e264e61d82f5e494e8cf82df266a1dcc1f130e68bb"

RDEPENDS:rust-pin-project-lite+default-devel = " \
 cargo \
 rust-pin-project-lite-devel \
 "
RDEPENDS:rust-pin-project-lite-devel = " \
 cargo \
 rust \
 "
