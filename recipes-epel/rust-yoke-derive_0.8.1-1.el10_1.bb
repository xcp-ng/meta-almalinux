# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-yoke-derive"
PV = "0.8.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-yoke-derive+default-devel \
 rust-yoke-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-yoke-derive-0.8.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "199647a7aeae906b0d0dc9714653045349e1cf0b5571a53a98f297910d810e6a"

URI_x86_64_v2_rust-yoke-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yoke-derive+default-devel-0.8.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yoke-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yoke-derive+default-devel}"
SRC_URI[x86_64_v2_rust-yoke-derive+default-devel.sha256sum] = "82412de6a2559c19eb4310ac22c84c3d95c76f50aaed0971fae2d37069c9c4c0"

URI_x86_64_v2_rust-yoke-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yoke-derive-devel-0.8.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yoke-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yoke-derive-devel}"
SRC_URI[x86_64_v2_rust-yoke-derive-devel.sha256sum] = "5ba214aebbfa2fd793da93d5e0a8116dede066c37a4f3ff61e5cecec7c208663"

URI_aarch64_rust-yoke-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yoke-derive+default-devel-0.8.1-1.el10_1.noarch.rpm;name=aarch64_rust-yoke-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yoke-derive+default-devel}"
SRC_URI[aarch64_rust-yoke-derive+default-devel.sha256sum] = "329799e7b8431721194045280dc4656c1c19ded027cf550b5318b922c8c6e5de"

URI_aarch64_rust-yoke-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yoke-derive-devel-0.8.1-1.el10_1.noarch.rpm;name=aarch64_rust-yoke-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yoke-derive-devel}"
SRC_URI[aarch64_rust-yoke-derive-devel.sha256sum] = "a94b7a3b308ce57f8afbddea3c74b49d679afc6e6b60c1a1cfdd3c7c8aa7a94a"

RDEPENDS:rust-yoke-derive+default-devel = " \
 cargo \
 rust-yoke-derive-devel \
 "
RDEPENDS:rust-yoke-derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+fold-devel \
 rust-synstructure+default-devel \
 "
