# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cldr-emoji-annotation"
PV = "46"
PR = "1.el10"
PACKAGES = " \
 cldr-emoji-annotation \
 cldr-emoji-annotation-dtd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cldr-emoji-annotation-46-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7738f713202f999eb9d87b8365dd7d1aa88d9ca435ee716b2d5acb6398ebdb17"

URI_x86_64_v2_cldr-emoji-annotation = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cldr-emoji-annotation-46-1.el10.noarch.rpm;name=x86_64_v2_cldr-emoji-annotation;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cldr-emoji-annotation}"
SRC_URI[x86_64_v2_cldr-emoji-annotation.sha256sum] = "42ce66d2c769ee686ee40835d96c2313e33b0f11e46c291586db9864f464036d"

URI_x86_64_v2_cldr-emoji-annotation-dtd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cldr-emoji-annotation-dtd-46-1.el10.noarch.rpm;name=x86_64_v2_cldr-emoji-annotation-dtd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cldr-emoji-annotation-dtd}"
SRC_URI[x86_64_v2_cldr-emoji-annotation-dtd.sha256sum] = "37ab860e7f17a6b52092be8f5ed85cffe7ec97a05a58edb8d1b307838f446370"

URI_aarch64_cldr-emoji-annotation = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cldr-emoji-annotation-46-1.el10.noarch.rpm;name=aarch64_cldr-emoji-annotation;unpack=0"
SRC_URI:append = " ${URI_aarch64_cldr-emoji-annotation}"
SRC_URI[aarch64_cldr-emoji-annotation.sha256sum] = "42ce66d2c769ee686ee40835d96c2313e33b0f11e46c291586db9864f464036d"

URI_aarch64_cldr-emoji-annotation-dtd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cldr-emoji-annotation-dtd-46-1.el10.noarch.rpm;name=aarch64_cldr-emoji-annotation-dtd;unpack=0"
SRC_URI:append = " ${URI_aarch64_cldr-emoji-annotation-dtd}"
SRC_URI[aarch64_cldr-emoji-annotation-dtd.sha256sum] = "37ab860e7f17a6b52092be8f5ed85cffe7ec97a05a58edb8d1b307838f446370"

RDEPENDS:cldr-emoji-annotation = " \
 cldr-emoji-annotation-dtd \
 "
RDEPENDS:cldr-emoji-annotation-dtd = " \
 cldr-emoji-annotation \
 "
