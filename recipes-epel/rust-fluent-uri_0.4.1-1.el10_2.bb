# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fluent-uri"
PV = "0.4.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-fluent-uri+alloc-devel \
 rust-fluent-uri+default-devel \
 rust-fluent-uri+impl-error-devel \
 rust-fluent-uri+net-devel \
 rust-fluent-uri+serde-devel \
 rust-fluent-uri+std-devel \
 rust-fluent-uri-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fluent-uri-0.4.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7333d26bce8835910700135e8d7718a21f05b8a6f07c8bded3d57db6e739fe7c"

URI_x86_64_v2_rust-fluent-uri+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fluent-uri+alloc-devel-0.4.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fluent-uri+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fluent-uri+alloc-devel}"
SRC_URI[x86_64_v2_rust-fluent-uri+alloc-devel.sha256sum] = "48a6fadc5f9e922186784a6d734ec9ae9510e9c9685f3f915d6a92e93547e8c4"

URI_x86_64_v2_rust-fluent-uri+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fluent-uri+default-devel-0.4.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fluent-uri+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fluent-uri+default-devel}"
SRC_URI[x86_64_v2_rust-fluent-uri+default-devel.sha256sum] = "f1cda3b2409e9b06ac61eef19c31b618a826ffe77ac40fa13e7e08c5352acf37"

URI_x86_64_v2_rust-fluent-uri+impl-error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fluent-uri+impl-error-devel-0.4.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fluent-uri+impl-error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fluent-uri+impl-error-devel}"
SRC_URI[x86_64_v2_rust-fluent-uri+impl-error-devel.sha256sum] = "b939a0fba622604377a6bf9fc64f51d35b41e3131db52329d14926118a0b7199"

URI_x86_64_v2_rust-fluent-uri+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fluent-uri+net-devel-0.4.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fluent-uri+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fluent-uri+net-devel}"
SRC_URI[x86_64_v2_rust-fluent-uri+net-devel.sha256sum] = "6bd366adb7254a7d3dca88854d1f83eff50da3d5f251dc24c03453e8b3e09169"

URI_x86_64_v2_rust-fluent-uri+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fluent-uri+serde-devel-0.4.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fluent-uri+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fluent-uri+serde-devel}"
SRC_URI[x86_64_v2_rust-fluent-uri+serde-devel.sha256sum] = "095bd07f3884bb4e7bc73f69fd3d89eba4e3028cff1f26647397f76e9d10d2ee"

URI_x86_64_v2_rust-fluent-uri+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fluent-uri+std-devel-0.4.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fluent-uri+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fluent-uri+std-devel}"
SRC_URI[x86_64_v2_rust-fluent-uri+std-devel.sha256sum] = "ee2d1cc0f8353a88224ffb819dd2517497ec88e7076903d74b04563194566cec"

URI_x86_64_v2_rust-fluent-uri-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fluent-uri-devel-0.4.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fluent-uri-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fluent-uri-devel}"
SRC_URI[x86_64_v2_rust-fluent-uri-devel.sha256sum] = "d7918d69187a8d746e4a5ce337400d06098ffe1937e2ced341bfd784028ea062"

URI_aarch64_rust-fluent-uri+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fluent-uri+alloc-devel-0.4.1-1.el10_2.noarch.rpm;name=aarch64_rust-fluent-uri+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fluent-uri+alloc-devel}"
SRC_URI[aarch64_rust-fluent-uri+alloc-devel.sha256sum] = "dd09a87c114007f1afc777684cd8140e65ade2fc72c6f50e3bc631234231062b"

URI_aarch64_rust-fluent-uri+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fluent-uri+default-devel-0.4.1-1.el10_2.noarch.rpm;name=aarch64_rust-fluent-uri+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fluent-uri+default-devel}"
SRC_URI[aarch64_rust-fluent-uri+default-devel.sha256sum] = "807728dd2221e2caabb17fa1da6de75021154a1bd9983a969ec1204d0a9934ca"

URI_aarch64_rust-fluent-uri+impl-error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fluent-uri+impl-error-devel-0.4.1-1.el10_2.noarch.rpm;name=aarch64_rust-fluent-uri+impl-error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fluent-uri+impl-error-devel}"
SRC_URI[aarch64_rust-fluent-uri+impl-error-devel.sha256sum] = "9e800f0cef61532a58e1094fc65273547d0af3d040c530c611b13550a7ae06ce"

URI_aarch64_rust-fluent-uri+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fluent-uri+net-devel-0.4.1-1.el10_2.noarch.rpm;name=aarch64_rust-fluent-uri+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fluent-uri+net-devel}"
SRC_URI[aarch64_rust-fluent-uri+net-devel.sha256sum] = "c8e0701a4746805cd41fabcae70fbe9a2c5556bbcb12408b7ebba72422f643f0"

URI_aarch64_rust-fluent-uri+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fluent-uri+serde-devel-0.4.1-1.el10_2.noarch.rpm;name=aarch64_rust-fluent-uri+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fluent-uri+serde-devel}"
SRC_URI[aarch64_rust-fluent-uri+serde-devel.sha256sum] = "6798c220d27480cab836a55509c3d6800b66e10ade785587ccd079434d609801"

URI_aarch64_rust-fluent-uri+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fluent-uri+std-devel-0.4.1-1.el10_2.noarch.rpm;name=aarch64_rust-fluent-uri+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fluent-uri+std-devel}"
SRC_URI[aarch64_rust-fluent-uri+std-devel.sha256sum] = "6d304ed59e8cc3b406e7be3a259974e5b9a4b332dbac76b02c8a745ffc8563fe"

URI_aarch64_rust-fluent-uri-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fluent-uri-devel-0.4.1-1.el10_2.noarch.rpm;name=aarch64_rust-fluent-uri-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fluent-uri-devel}"
SRC_URI[aarch64_rust-fluent-uri-devel.sha256sum] = "383c894b7ff433a039ac92a708ba8a7db27004a61d96cb7786dcb2fc5f3f186f"

RDEPENDS:rust-fluent-uri+alloc-devel = " \
 cargo \
 rust-borrow-or-share+alloc-devel \
 rust-fluent-uri-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-fluent-uri+default-devel = " \
 cargo \
 rust-fluent-uri+std-devel \
 rust-fluent-uri-devel \
 "
RDEPENDS:rust-fluent-uri+impl-error-devel = " \
 cargo \
 rust-fluent-uri-devel \
 "
RDEPENDS:rust-fluent-uri+net-devel = " \
 cargo \
 rust-fluent-uri-devel \
 "
RDEPENDS:rust-fluent-uri+serde-devel = " \
 cargo \
 rust-fluent-uri-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-fluent-uri+std-devel = " \
 cargo \
 rust-fluent-uri+alloc-devel \
 rust-fluent-uri+impl-error-devel \
 rust-fluent-uri-devel \
 "
RDEPENDS:rust-fluent-uri-devel = " \
 cargo \
 rust \
 rust-borrow-or-share-devel \
 rust-ref-cast+default-devel \
 "
