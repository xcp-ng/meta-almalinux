# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-racksec-srslog"
PV = "0"
PR = "0.15.20190627gita4725f0.el10_0"
PACKAGES = " \
 golang-github-racksec-srslog-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-racksec-srslog-0-0.15.20190627gita4725f0.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cbea392f88732b51f15919f951cec8aeb8a26a1cbdd292725d67841cf056bbc6"

URI_aarch64_golang-github-racksec-srslog-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-racksec-srslog-devel-0-0.15.20190627gita4725f0.el10_0.noarch.rpm;name=aarch64_golang-github-racksec-srslog-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-racksec-srslog-devel}"
SRC_URI[aarch64_golang-github-racksec-srslog-devel.sha256sum] = "539fc570d0b5e42dc8f6fd90d94a6413b1d3eb25929a8be4b0985967823fea6f"

RDEPENDS:golang-github-racksec-srslog-devel = " \
 go-filesystem \
 "
