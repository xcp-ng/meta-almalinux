# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lest"
PV = "1.37.0"
PR = "1.el10_1"
PACKAGES = " \
 lest-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lest-1.37.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e6b2fa15fa79ab65327f2d9d273ad154c5b7098a5b067556a61e1f51e0a0fe4"

URI_x86_64_v2_lest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lest-devel-1.37.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lest-devel}"
SRC_URI[x86_64_v2_lest-devel.sha256sum] = "52ad1d419db578c74cd83b227803734f528d0a6161a3cde6233d1f97e0e836c2"

URI_aarch64_lest-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lest-devel-1.37.0-1.el10_1.noarch.rpm;name=aarch64_lest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lest-devel}"
SRC_URI[aarch64_lest-devel.sha256sum] = "879addb0c94fea1aef48dff3037cc13fe18bfeebd363a599ad9503d1879e28cc"

RDEPENDS:lest-devel = " \
 "
