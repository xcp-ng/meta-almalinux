# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-global-executor"
PV = "3.1.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-async-global-executor+async-io-devel \
 rust-async-global-executor+default-devel \
 rust-async-global-executor+tokio-devel \
 rust-async-global-executor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-global-executor-3.1.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bcee01714a6f9f237bc3b66a7988c348a3747ea17a1f9348852f162bf437ebd8"

URI_x86_64_v2_rust-async-global-executor+async-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-global-executor+async-io-devel-3.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-global-executor+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-global-executor+async-io-devel}"
SRC_URI[x86_64_v2_rust-async-global-executor+async-io-devel.sha256sum] = "9b934cbbec18f0b52e268bf61d5b47b8de9943c69df590b456a9660a6184ced3"

URI_x86_64_v2_rust-async-global-executor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-global-executor+default-devel-3.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-global-executor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-global-executor+default-devel}"
SRC_URI[x86_64_v2_rust-async-global-executor+default-devel.sha256sum] = "493d5145b8e03fb2a823971302c6fcabbe0e998737a8e7e64691f7632afab90e"

URI_x86_64_v2_rust-async-global-executor+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-global-executor+tokio-devel-3.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-global-executor+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-global-executor+tokio-devel}"
SRC_URI[x86_64_v2_rust-async-global-executor+tokio-devel.sha256sum] = "3162c8ace4f709b4eb42c8ed447a5deff28fcda52be8ca14bbff9db080151147"

URI_x86_64_v2_rust-async-global-executor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-global-executor-devel-3.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-global-executor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-global-executor-devel}"
SRC_URI[x86_64_v2_rust-async-global-executor-devel.sha256sum] = "d8e18e1e5d884bf53740fec5c0c5202815131932fb19e57fa090cb545fe8d215"

URI_aarch64_rust-async-global-executor+async-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-global-executor+async-io-devel-3.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-async-global-executor+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-global-executor+async-io-devel}"
SRC_URI[aarch64_rust-async-global-executor+async-io-devel.sha256sum] = "56322076453ea0c4f37e6930e1479f671e839af8db36744e5fc9a6ac01a8b0a0"

URI_aarch64_rust-async-global-executor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-global-executor+default-devel-3.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-async-global-executor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-global-executor+default-devel}"
SRC_URI[aarch64_rust-async-global-executor+default-devel.sha256sum] = "35f0c9ca5fe53c8896f528dabf66b35651c6e0b26a18ab57083fa8e015711618"

URI_aarch64_rust-async-global-executor+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-global-executor+tokio-devel-3.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-async-global-executor+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-global-executor+tokio-devel}"
SRC_URI[aarch64_rust-async-global-executor+tokio-devel.sha256sum] = "ca934e91a510b3d01976392fb953fb55cda0ccf296a7067fbea4c851805e8f29"

URI_aarch64_rust-async-global-executor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-global-executor-devel-3.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-async-global-executor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-global-executor-devel}"
SRC_URI[aarch64_rust-async-global-executor-devel.sha256sum] = "518ee56c920b04b9b91eed7c6ef4f3df53cb8470779be3f1189f4cc87025eed1"

RDEPENDS:rust-async-global-executor+async-io-devel = " \
 cargo \
 rust-async-global-executor-devel \
 rust-async-io+default-devel \
 "
RDEPENDS:rust-async-global-executor+default-devel = " \
 cargo \
 rust-async-global-executor+async-io-devel \
 rust-async-global-executor-devel \
 "
RDEPENDS:rust-async-global-executor+tokio-devel = " \
 cargo \
 rust-async-global-executor-devel \
 rust-tokio+rt-devel \
 rust-tokio+rt-multi-thread-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-async-global-executor-devel = " \
 cargo \
 rust \
 rust-async-channel+default-devel \
 rust-async-executor+default-devel \
 rust-async-executor+static-devel \
 rust-async-lock+default-devel \
 rust-blocking+default-devel \
 rust-futures-lite+default-devel \
 "
