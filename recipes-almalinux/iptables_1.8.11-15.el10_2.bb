# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iptables"
PV = "1.8.11"
PR = "15.el10_2"
PACKAGES = " \
 iptables-devel \
 iptables-libs \
 iptables-nft \
 iptables-nft-services \
 iptables-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/iptables-1.8.11-15.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "356b58eebb4ba531daeb963a384607d1990caf88d9f34169d58210a41a25e7fb"

URI_x86_64_v2_iptables-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/iptables-devel-1.8.11-15.el10_2.x86_64_v2.rpm;name=x86_64_v2_iptables-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iptables-devel}"
SRC_URI[x86_64_v2_iptables-devel.sha256sum] = "e1c9e2c1032bca03c5bf7cd221bd8f7187947af2d029086fd570cb8e4b3ca8ab"

URI_x86_64_v2_iptables-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iptables-libs-1.8.11-15.el10_2.x86_64_v2.rpm;name=x86_64_v2_iptables-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iptables-libs}"
SRC_URI[x86_64_v2_iptables-libs.sha256sum] = "e9d9f698a0c9457c672c9319af5cd138bcc09b993b11902c446071c3ed703c98"

URI_x86_64_v2_iptables-nft = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/iptables-nft-1.8.11-15.el10_2.x86_64_v2.rpm;name=x86_64_v2_iptables-nft;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iptables-nft}"
SRC_URI[x86_64_v2_iptables-nft.sha256sum] = "903186a19ab27c005369e0826880c1bff5e55b95cbb5e42b895331644bd9d209"

URI_x86_64_v2_iptables-nft-services = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/iptables-nft-services-1.8.11-15.el10_2.noarch.rpm;name=x86_64_v2_iptables-nft-services;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iptables-nft-services}"
SRC_URI[x86_64_v2_iptables-nft-services.sha256sum] = "2c9277f6a46781fe213bf801349c91e0ad8f35977789b0dc8c938545e26af077"

URI_x86_64_v2_iptables-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/iptables-utils-1.8.11-15.el10_2.x86_64_v2.rpm;name=x86_64_v2_iptables-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iptables-utils}"
SRC_URI[x86_64_v2_iptables-utils.sha256sum] = "291cc860fb7fb7136413fd69885962f8e53b3f35df2744ee19733e32229e4ada"

URI_aarch64_iptables-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/iptables-devel-1.8.11-15.el10_2.aarch64.rpm;name=aarch64_iptables-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_iptables-devel}"
SRC_URI[aarch64_iptables-devel.sha256sum] = "98906ddaf381b5d1245f7b2f2ecf2ce3404051af639080f2a2ee062692ee9057"

URI_aarch64_iptables-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iptables-libs-1.8.11-15.el10_2.aarch64.rpm;name=aarch64_iptables-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_iptables-libs}"
SRC_URI[aarch64_iptables-libs.sha256sum] = "1f7aa313123724c41b7ef09e1b279b842a10f51bc64d59de26c5ede9fd60957f"

URI_aarch64_iptables-nft = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/iptables-nft-1.8.11-15.el10_2.aarch64.rpm;name=aarch64_iptables-nft;unpack=0"
SRC_URI:append = " ${URI_aarch64_iptables-nft}"
SRC_URI[aarch64_iptables-nft.sha256sum] = "0e103711aef632ebcfe252dc92bc19e6cb5f308bc75dd51c9a7925c7bd63b59a"

URI_aarch64_iptables-nft-services = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/iptables-nft-services-1.8.11-15.el10_2.noarch.rpm;name=aarch64_iptables-nft-services;unpack=0"
SRC_URI:append = " ${URI_aarch64_iptables-nft-services}"
SRC_URI[aarch64_iptables-nft-services.sha256sum] = "2c9277f6a46781fe213bf801349c91e0ad8f35977789b0dc8c938545e26af077"

URI_aarch64_iptables-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/iptables-utils-1.8.11-15.el10_2.aarch64.rpm;name=aarch64_iptables-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_iptables-utils}"
SRC_URI[aarch64_iptables-utils.sha256sum] = "931f3d76c5e523e3ae7b85130773779623826927740b19b54366263d7044a5ad"

RDEPENDS:iptables-devel = " \
 iptables-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:iptables-libs = " \
 glibc \
 libnetfilter_conntrack \
 "
RDEPENDS:iptables-nft = " \
 alternatives \
 bash \
 glibc \
 iptables-libs \
 libmnl \
 libnftnl \
 virtual//usr/bin/readlink \
 "
RDEPENDS:iptables-nft-services = " \
 bash \
 iptables-nft \
 "
RDEPENDS:iptables-utils = " \
 bash \
 glibc \
 iptables-nft \
 libnfnetlink \
 libpcap \
 "
