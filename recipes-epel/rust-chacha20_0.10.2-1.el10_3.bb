# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-chacha20"
PV = "0.10.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-chacha20+cipher-devel \
 rust-chacha20+default-devel \
 rust-chacha20+legacy-devel \
 rust-chacha20+rng-devel \
 rust-chacha20+xchacha-devel \
 rust-chacha20+zeroize-devel \
 rust-chacha20-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-chacha20-0.10.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "acd92ac828b703a4812931ad9f627c9ba6539b230316e4582e9122f0e623bf5e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chacha20+cipher-devel-0.10.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chacha20+cipher-devel;unpack=0"
SRC_URI[x86_64_v2_rust-chacha20+cipher-devel.sha256sum] = "e507461514ef20983e91535307f08b8b50eff1d8be9bb1c75070094997c716d1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chacha20+default-devel-0.10.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chacha20+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-chacha20+default-devel.sha256sum] = "f79fbeb0e084ba2763ce94443da97cecf77cc33059d49fa8ec02fa0cb3c3286e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chacha20+legacy-devel-0.10.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chacha20+legacy-devel;unpack=0"
SRC_URI[x86_64_v2_rust-chacha20+legacy-devel.sha256sum] = "7790741a83ae70e077e0c3476405508c2485a925eabecc2e5ba3574cb9e222a0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chacha20+rng-devel-0.10.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chacha20+rng-devel;unpack=0"
SRC_URI[x86_64_v2_rust-chacha20+rng-devel.sha256sum] = "806480723d806d4fb5975b3109772436e801beb861873ec9d8af0b9b7e93e23c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chacha20+xchacha-devel-0.10.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chacha20+xchacha-devel;unpack=0"
SRC_URI[x86_64_v2_rust-chacha20+xchacha-devel.sha256sum] = "823471031f863b03a596d1ba34d5733436c44ef3ecdc9b361935ff3dd8603c76"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chacha20+zeroize-devel-0.10.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chacha20+zeroize-devel;unpack=0"
SRC_URI[x86_64_v2_rust-chacha20+zeroize-devel.sha256sum] = "e23624d484d6cb8f0b9ec8027864d6a953c5e94e42dd852556aed5e8bfc7366f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chacha20-devel-0.10.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chacha20-devel;unpack=0"
SRC_URI[x86_64_v2_rust-chacha20-devel.sha256sum] = "440ef135e2a19a2c64c91c515bc64dbc703116c10e2a3420cd7e2ea7cb0094c2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-chacha20+cipher-devel-0.10.2-1.el10_3.noarch.rpm;name=aarch64_rust-chacha20+cipher-devel;unpack=0"
SRC_URI[aarch64_rust-chacha20+cipher-devel.sha256sum] = "8fa6352b1b49e67205433d7e53be2b613b89756057f19a292e6c54ca8ff41029"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-chacha20+default-devel-0.10.2-1.el10_3.noarch.rpm;name=aarch64_rust-chacha20+default-devel;unpack=0"
SRC_URI[aarch64_rust-chacha20+default-devel.sha256sum] = "223e0edd8279eedaef4f4b78bdd8b7119821ae5c8932783f1944434d6236c060"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-chacha20+legacy-devel-0.10.2-1.el10_3.noarch.rpm;name=aarch64_rust-chacha20+legacy-devel;unpack=0"
SRC_URI[aarch64_rust-chacha20+legacy-devel.sha256sum] = "ab121acf4ca32e0aa0a95b36bc64786333192e11d8c83157198e6c1688bea704"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-chacha20+rng-devel-0.10.2-1.el10_3.noarch.rpm;name=aarch64_rust-chacha20+rng-devel;unpack=0"
SRC_URI[aarch64_rust-chacha20+rng-devel.sha256sum] = "ea5d9bb3421212350f8d15b626e0a66414830240d3280ac54b3e252815911086"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-chacha20+xchacha-devel-0.10.2-1.el10_3.noarch.rpm;name=aarch64_rust-chacha20+xchacha-devel;unpack=0"
SRC_URI[aarch64_rust-chacha20+xchacha-devel.sha256sum] = "b5ffbdf202e6f46bc690e58491d31476cf8f634c01fc7e4f6a34ad68c237cbe8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-chacha20+zeroize-devel-0.10.2-1.el10_3.noarch.rpm;name=aarch64_rust-chacha20+zeroize-devel;unpack=0"
SRC_URI[aarch64_rust-chacha20+zeroize-devel.sha256sum] = "cba8e0b337e6fa07b8b45d36eca15efe350ec5c3875d428baae887fb2b4dba22"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-chacha20-devel-0.10.2-1.el10_3.noarch.rpm;name=aarch64_rust-chacha20-devel;unpack=0"
SRC_URI[aarch64_rust-chacha20-devel.sha256sum] = "364f18324324744ee9b53de808889465e9fbfecb10d8e421afcd3064509f051a"

RDEPENDS:rust-chacha20+cipher-devel = " \
 cargo \
 rust-chacha20-devel \
 rust-cipher+default-devel \
 rust-cipher+stream-wrapper-devel \
 "
RDEPENDS:rust-chacha20+default-devel = " \
 cargo \
 rust-chacha20+cipher-devel \
 rust-chacha20-devel \
 "
RDEPENDS:rust-chacha20+legacy-devel = " \
 cargo \
 rust-chacha20+cipher-devel \
 rust-chacha20-devel \
 "
RDEPENDS:rust-chacha20+rng-devel = " \
 cargo \
 rust-chacha20-devel \
 rust-rand_core-devel \
 "
RDEPENDS:rust-chacha20+xchacha-devel = " \
 cargo \
 rust-chacha20+cipher-devel \
 rust-chacha20-devel \
 "
RDEPENDS:rust-chacha20+zeroize-devel = " \
 cargo \
 rust-chacha20-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-chacha20-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-cpufeatures+default-devel \
 "
