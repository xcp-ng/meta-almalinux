# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "httpcomponents-project"
PV = "13"
PR = "7.el10"
PACKAGES = " \
 httpcomponents-project \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/httpcomponents-project-13-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6926cd3966eca6fbcd23c8057a9f11762d06286100338e716e9488393c8eaa51"

URI_x86_64_v2_httpcomponents-project = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/httpcomponents-project-13-7.el10.noarch.rpm;name=x86_64_v2_httpcomponents-project;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_httpcomponents-project}"
SRC_URI[x86_64_v2_httpcomponents-project.sha256sum] = "cb4c7079f36f6a24fe18c5414b6185e938224588a11ab19d4f706199618e2e5d"

URI_aarch64_httpcomponents-project = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/httpcomponents-project-13-7.el10.noarch.rpm;name=aarch64_httpcomponents-project;unpack=0"
SRC_URI:append = " ${URI_aarch64_httpcomponents-project}"
SRC_URI[aarch64_httpcomponents-project.sha256sum] = "cb4c7079f36f6a24fe18c5414b6185e938224588a11ab19d4f706199618e2e5d"

RDEPENDS:httpcomponents-project = " \
 apache-parent \
 javapackages-filesystem \
 maven-jar-plugin \
 "
