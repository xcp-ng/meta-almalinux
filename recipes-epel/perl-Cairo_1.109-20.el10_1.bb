# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Cairo"
PV = "1.109"
PR = "20.el10_1"
PACKAGES = " \
 perl-Cairo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Cairo-1.109-20.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1a1c30b73e4b029420129c586a165a8ab3ffe1845e2471dfe343a45c4419b98a"

URI_x86_64_v2_perl-Cairo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Cairo-1.109-20.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Cairo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Cairo}"
SRC_URI[x86_64_v2_perl-Cairo.sha256sum] = "3d4595f95990f5cff9b727966fbb157f7bf2b8b7af4d28f9de6f93893a867583"

URI_aarch64_perl-Cairo = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Cairo-1.109-20.el10_1.aarch64.rpm;name=aarch64_perl-Cairo;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Cairo}"
SRC_URI[aarch64_perl-Cairo.sha256sum] = "359cf71954b47c082c4d0a6feeacfd79dab1c6c732eaf3ead2824150b9ff58a7"

RDEPENDS:perl-Cairo = " \
 cairo \
 glibc \
 perl-DynaLoader \
 perl-libs \
 "
