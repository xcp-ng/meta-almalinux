# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sslh"
PV = "2.3.1"
PR = "4.el10_2"
PACKAGES = " \
 sslh \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sslh-2.3.1-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "feea89b79c069d85603d983b21c85a2df1882287655cdd4923deb94a9c1f84fa"

URI_x86_64_v2_sslh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sslh-2.3.1-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sslh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sslh}"
SRC_URI[x86_64_v2_sslh.sha256sum] = "273feb4eb65854d47fe95f4204231b0ae74736ab3cc8d2f58bb88e5c27b2dc07"

URI_aarch64_sslh = "${EPEL_MIRROR}/aarch64/Packages/s/sslh-2.3.1-4.el10_2.aarch64.rpm;name=aarch64_sslh;unpack=0"
SRC_URI:append = " ${URI_aarch64_sslh}"
SRC_URI[aarch64_sslh.sha256sum] = "57529fac842413393b71a2c69be6223e002c5a014e5e1fe143afdb9a3265663f"

RDEPENDS:sslh = " \
 bash \
 glibc \
 libbsd \
 libcap \
 libconfig \
 libev \
 pcre2 \
 systemd-libs \
 "
