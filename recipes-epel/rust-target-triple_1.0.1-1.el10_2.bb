# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-target-triple"
PV = "1.0.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-target-triple+default-devel \
 rust-target-triple-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-target-triple-1.0.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad9e651e8b40867f94c370d5389681a474cd7a2da78d4c5d4229a43639e77f5c"

URI_x86_64_v2_rust-target-triple+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-triple+default-devel-1.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-triple+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-triple+default-devel}"
SRC_URI[x86_64_v2_rust-target-triple+default-devel.sha256sum] = "ff31bd4cc2b8fb9dbdc9c7de2c2eadd69c48f1379f2254674c5e11ace46a4b82"

URI_x86_64_v2_rust-target-triple-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-triple-devel-1.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-triple-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-triple-devel}"
SRC_URI[x86_64_v2_rust-target-triple-devel.sha256sum] = "af6d2d9b795f1f6f3090b62439d513075647875df96d29242b7012afdfb62483"

URI_aarch64_rust-target-triple+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-triple+default-devel-1.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-target-triple+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-triple+default-devel}"
SRC_URI[aarch64_rust-target-triple+default-devel.sha256sum] = "8ed20eede813e13156c09cb162035e257d02d93d8a9bb7f46b60797c595a7da8"

URI_aarch64_rust-target-triple-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-triple-devel-1.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-target-triple-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-triple-devel}"
SRC_URI[aarch64_rust-target-triple-devel.sha256sum] = "3b5fb1547a71154848ead1a9e1a56f3751cfe89d2c6194fd3f8490478dad2c6b"

RDEPENDS:rust-target-triple+default-devel = " \
 cargo \
 rust-target-triple-devel \
 "
RDEPENDS:rust-target-triple-devel = " \
 cargo \
 rust \
 "
