# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pyproject-rpm-macros"
PV = "1.18.5"
PR = "1.el10"
PACKAGES = " \
 pyproject-rpm-macros \
 pyproject-srpm-macros \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pyproject-rpm-macros-1.18.5-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "157da0e5ff0268853308480a15623817e4ddc1135415ca0b8999836321da3e8b"

URI_x86_64_v2_pyproject-rpm-macros = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/pyproject-rpm-macros-1.18.5-1.el10.noarch.rpm;name=x86_64_v2_pyproject-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pyproject-rpm-macros}"
SRC_URI[x86_64_v2_pyproject-rpm-macros.sha256sum] = "2e98caa45a3069b33f5abf060a214600e8995a40ae190a181991629469fe274e"

URI_x86_64_v2_pyproject-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pyproject-srpm-macros-1.18.5-1.el10.noarch.rpm;name=x86_64_v2_pyproject-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pyproject-srpm-macros}"
SRC_URI[x86_64_v2_pyproject-srpm-macros.sha256sum] = "a49c7fa2508c5f52795148b1c90a50523a47d6a585318c78acb4ecc59b49ef67"

URI_aarch64_pyproject-rpm-macros = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/pyproject-rpm-macros-1.18.5-1.el10.noarch.rpm;name=aarch64_pyproject-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_pyproject-rpm-macros}"
SRC_URI[aarch64_pyproject-rpm-macros.sha256sum] = "2e98caa45a3069b33f5abf060a214600e8995a40ae190a181991629469fe274e"

URI_aarch64_pyproject-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pyproject-srpm-macros-1.18.5-1.el10.noarch.rpm;name=aarch64_pyproject-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_pyproject-srpm-macros}"
SRC_URI[aarch64_pyproject-srpm-macros.sha256sum] = "a49c7fa2508c5f52795148b1c90a50523a47d6a585318c78acb4ecc59b49ef67"

RDEPENDS:pyproject-rpm-macros = " \
 findutils \
 pyproject-srpm-macros \
 python-rpm-macros \
 python-srpm-macros \
 python3-rpm-macros \
 rpm-build \
 sed \
 "
RDEPENDS:pyproject-srpm-macros = " \
 pyproject-rpm-macros \
 rpm-build \
 "
