# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossbeam-channel"
PV = "0.5.17"
PR = "1.el10_2"
PACKAGES = " \
 rust-crossbeam-channel+default-devel \
 rust-crossbeam-channel+std-devel \
 rust-crossbeam-channel-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-crossbeam-channel-0.5.17-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d2508bf9bf6df5bce8fea18162b3eec507d1e17c1aa9d4820f0c21ce16151180"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-channel+default-devel-0.5.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-channel+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-channel+default-devel.sha256sum] = "f726f1f93c90a062f5997e2fd9ca6df16310e446f436f30b2986748beb7af92c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-channel+std-devel-0.5.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-channel+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-channel+std-devel.sha256sum] = "9249cfcd6e7573e5896981aab34e42dc369f253c96d3e25f96687a9c17c5d4fe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-channel-devel-0.5.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-channel-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-channel-devel.sha256sum] = "53e5d5ed954525500ed339057d96cf5e810403b93e5233479618d815842aaf97"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-channel+default-devel-0.5.17-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-channel+default-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-channel+default-devel.sha256sum] = "ab4a9b2ef95fed76217fc36f46905825534a7ea27ac3779b34cc4fafef07730d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-channel+std-devel-0.5.17-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-channel+std-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-channel+std-devel.sha256sum] = "e101b97fff09ca0fe6f3e25797b2b975594b5e5b65a31508821bb1a960f3c01b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-channel-devel-0.5.17-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-channel-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-channel-devel.sha256sum] = "d8a2a5f5a476695b22673a16e5952fb15eb8e0eaa3e7cc7fe12489a653b58f30"

RDEPENDS:rust-crossbeam-channel+default-devel = " \
 cargo \
 rust-crossbeam-channel+std-devel \
 rust-crossbeam-channel-devel \
 "
RDEPENDS:rust-crossbeam-channel+std-devel = " \
 cargo \
 rust-crossbeam-channel-devel \
 rust-crossbeam-utils+std-devel \
 "
RDEPENDS:rust-crossbeam-channel-devel = " \
 cargo \
 rust \
 rust-crossbeam-utils-devel \
 "
