# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bzip3"
PV = "1.5.3"
PR = "1.el10_0"
PACKAGES = " \
 bzip3 \
 bzip3-devel \
 bzip3-grep \
 bzip3-less \
 bzip3-libs \
 bzip3-more \
 bzip3-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bzip3-1.5.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b30f99673a7ff072df1adbff0b3cf22ad7a34be1b9021d279c3c56422e96b8e9"

URI_x86_64_v2_bzip3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bzip3-1.5.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bzip3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bzip3}"
SRC_URI[x86_64_v2_bzip3.sha256sum] = "dfe09e95ee0019ebddb9b2e5813ee51f0a6ea654b7b6ea94ac1ae0ccc299a653"

URI_x86_64_v2_bzip3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bzip3-devel-1.5.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bzip3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bzip3-devel}"
SRC_URI[x86_64_v2_bzip3-devel.sha256sum] = "e5f6f90bc7517934cdee785d1c45612a805d4e092e46b4eedd595df6d42acdbc"

URI_x86_64_v2_bzip3-grep = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bzip3-grep-1.5.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_bzip3-grep;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bzip3-grep}"
SRC_URI[x86_64_v2_bzip3-grep.sha256sum] = "66adbf179ece4fcd613a9f6e108c3befe5cf9b3272d2f176db8f6b635f1d3234"

URI_x86_64_v2_bzip3-less = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bzip3-less-1.5.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_bzip3-less;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bzip3-less}"
SRC_URI[x86_64_v2_bzip3-less.sha256sum] = "6c14112698009b568a339158c75c0af15067dd5ce166aa0279af5d45b34c9650"

URI_x86_64_v2_bzip3-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bzip3-libs-1.5.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bzip3-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bzip3-libs}"
SRC_URI[x86_64_v2_bzip3-libs.sha256sum] = "592fc33d976ec5bbe91abce8b3d96c9802363c5088e47075b7df401f647c5111"

URI_x86_64_v2_bzip3-more = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bzip3-more-1.5.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_bzip3-more;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bzip3-more}"
SRC_URI[x86_64_v2_bzip3-more.sha256sum] = "85abb2b60c13900bedfc4af8c7d55d0b2616d5ca41a5fe7be7f48ef0ca118fbc"

URI_x86_64_v2_bzip3-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bzip3-tools-1.5.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bzip3-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bzip3-tools}"
SRC_URI[x86_64_v2_bzip3-tools.sha256sum] = "7376ab87c7039765d47b11e8ad2af05e0af6b9a8e115556f01af67cde5388242"

URI_aarch64_bzip3 = "${EPEL_MIRROR}/aarch64/Packages/b/bzip3-1.5.3-1.el10_0.aarch64.rpm;name=aarch64_bzip3;unpack=0"
SRC_URI:append = " ${URI_aarch64_bzip3}"
SRC_URI[aarch64_bzip3.sha256sum] = "53b116c3f0b17f96f1bace4097656667e3903b28017acb808d1f5c7e53f8c015"

URI_aarch64_bzip3-devel = "${EPEL_MIRROR}/aarch64/Packages/b/bzip3-devel-1.5.3-1.el10_0.aarch64.rpm;name=aarch64_bzip3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_bzip3-devel}"
SRC_URI[aarch64_bzip3-devel.sha256sum] = "97168e7eb41512317b34bc47733446e9994bd445f3fa0a698b2079643a32fb3b"

URI_aarch64_bzip3-grep = "${EPEL_MIRROR}/aarch64/Packages/b/bzip3-grep-1.5.3-1.el10_0.noarch.rpm;name=aarch64_bzip3-grep;unpack=0"
SRC_URI:append = " ${URI_aarch64_bzip3-grep}"
SRC_URI[aarch64_bzip3-grep.sha256sum] = "1ca8055456e922cb9dc0d6ef1536d4a91aeb9f34d3641a42fda5898432244e29"

URI_aarch64_bzip3-less = "${EPEL_MIRROR}/aarch64/Packages/b/bzip3-less-1.5.3-1.el10_0.noarch.rpm;name=aarch64_bzip3-less;unpack=0"
SRC_URI:append = " ${URI_aarch64_bzip3-less}"
SRC_URI[aarch64_bzip3-less.sha256sum] = "3ba77c7eb959fc2a7dec1229409a7d767785614a07989937c13ad89559dd835f"

URI_aarch64_bzip3-libs = "${EPEL_MIRROR}/aarch64/Packages/b/bzip3-libs-1.5.3-1.el10_0.aarch64.rpm;name=aarch64_bzip3-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_bzip3-libs}"
SRC_URI[aarch64_bzip3-libs.sha256sum] = "e2e14ae30af8ee9482a5e90d28c99ecfd77e81f43c2ef59e9b9ef9bf60e0094a"

URI_aarch64_bzip3-more = "${EPEL_MIRROR}/aarch64/Packages/b/bzip3-more-1.5.3-1.el10_0.noarch.rpm;name=aarch64_bzip3-more;unpack=0"
SRC_URI:append = " ${URI_aarch64_bzip3-more}"
SRC_URI[aarch64_bzip3-more.sha256sum] = "df8de9e799f849dffe4153ed2c3019a42f1ec682fa1502898aadbe7342505652"

URI_aarch64_bzip3-tools = "${EPEL_MIRROR}/aarch64/Packages/b/bzip3-tools-1.5.3-1.el10_0.aarch64.rpm;name=aarch64_bzip3-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_bzip3-tools}"
SRC_URI[aarch64_bzip3-tools.sha256sum] = "761cbbfd61f61de08e3384d879445e5e51ac474a3be3db45f0eb41b454b74a45"

RDEPENDS:bzip3 = " \
 bzip3-grep \
 bzip3-less \
 bzip3-more \
 bzip3-tools \
 "
RDEPENDS:bzip3-devel = " \
 bzip3-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:bzip3-grep = " \
 bash \
 bzip3-tools \
 grep \
 "
RDEPENDS:bzip3-less = " \
 bash \
 bzip3-tools \
 less \
 "
RDEPENDS:bzip3-libs = " \
 glibc \
 "
RDEPENDS:bzip3-more = " \
 bash \
 bzip3-tools \
 util-linux-core \
 "
RDEPENDS:bzip3-tools = " \
 bash \
 bzip3-libs \
 glibc \
 "
