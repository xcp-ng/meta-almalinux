# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-ignore"
PV = "0.16.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-ignore+default-devel \
 rust-gix-ignore+document-features-devel \
 rust-gix-ignore+serde-devel \
 rust-gix-ignore-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-ignore-0.16.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "301b212b52d90939bd2a330e8a6a945048f3df2f4ec65a7f5eb98e0902f3a5a7"

URI_x86_64_v2_rust-gix-ignore+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ignore+default-devel-0.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ignore+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-ignore+default-devel}"
SRC_URI[x86_64_v2_rust-gix-ignore+default-devel.sha256sum] = "2f97228e5fba8cf6a425ce99813a297ff4a648fd126d7bfce294f597255a90cd"

URI_x86_64_v2_rust-gix-ignore+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ignore+document-features-devel-0.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ignore+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-ignore+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-ignore+document-features-devel.sha256sum] = "fafbef64effaa0fc9838ebeae07d8b8423a6650ea6cdd237be051a8cd6ee3a6e"

URI_x86_64_v2_rust-gix-ignore+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ignore+serde-devel-0.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ignore+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-ignore+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-ignore+serde-devel.sha256sum] = "50d034e67d7765c2c80123b529e7fc151a9b4bb92ec7f40be2222bc5a5fdeed1"

URI_x86_64_v2_rust-gix-ignore-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ignore-devel-0.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ignore-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-ignore-devel}"
SRC_URI[x86_64_v2_rust-gix-ignore-devel.sha256sum] = "b162af16e1157c54bb87c831bb6992d5e3a3c3fc4042b7715625f19cad01a8e5"

URI_aarch64_rust-gix-ignore+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ignore+default-devel-0.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-ignore+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-ignore+default-devel}"
SRC_URI[aarch64_rust-gix-ignore+default-devel.sha256sum] = "32691cc719681dc34636e25d6570965ce4a8e2b53407ea115fb65e1dea2a2e4c"

URI_aarch64_rust-gix-ignore+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ignore+document-features-devel-0.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-ignore+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-ignore+document-features-devel}"
SRC_URI[aarch64_rust-gix-ignore+document-features-devel.sha256sum] = "f4cf4871f1e843a2b69296151841ecc4bd07fcfa0ce0cc4576e9da6bad274519"

URI_aarch64_rust-gix-ignore+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ignore+serde-devel-0.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-ignore+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-ignore+serde-devel}"
SRC_URI[aarch64_rust-gix-ignore+serde-devel.sha256sum] = "1c50ffcaa087c1855568fc5ca4531346259693c21ea23c260e764e2213cc5662"

URI_aarch64_rust-gix-ignore-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ignore-devel-0.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-ignore-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-ignore-devel}"
SRC_URI[aarch64_rust-gix-ignore-devel.sha256sum] = "cf97b5966938058a95b3c0d04adc88056ad377f22e6a57796f7c266f52fb9faa"

RDEPENDS:rust-gix-ignore+default-devel = " \
 cargo \
 rust-gix-ignore-devel \
 "
RDEPENDS:rust-gix-ignore+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-ignore-devel \
 "
RDEPENDS:rust-gix-ignore+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-glob+serde-devel \
 rust-gix-ignore-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-ignore-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-glob+default-devel \
 rust-gix-path+default-devel \
 rust-gix-trace+default-devel \
 rust-unicode-bom+default-devel \
 "
