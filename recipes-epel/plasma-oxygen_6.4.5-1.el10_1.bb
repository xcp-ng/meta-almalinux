# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-oxygen"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 oxygen-cursor-themes \
 plasma-oxygen \
 plasma-oxygen-qt6 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-oxygen-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "68de3fe4a8cd0e6c06ca23e3627dd6c1c1bb077af84eb486e03aeeac06d2a6d9"

URI_x86_64_v2_oxygen-cursor-themes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oxygen-cursor-themes-6.4.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_oxygen-cursor-themes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oxygen-cursor-themes}"
SRC_URI[x86_64_v2_oxygen-cursor-themes.sha256sum] = "b94d67d5dd5f4efd239f10079d03bb20483db567bc9bfa84fd465c6700d6e11f"

URI_x86_64_v2_plasma-oxygen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-oxygen-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-oxygen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-oxygen}"
SRC_URI[x86_64_v2_plasma-oxygen.sha256sum] = "10e3817a08d0af85f6f9edfb75b8d78e491d05b24a9b05d0bfb2190f8c6fa7d5"

URI_x86_64_v2_plasma-oxygen-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-oxygen-qt6-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-oxygen-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-oxygen-qt6}"
SRC_URI[x86_64_v2_plasma-oxygen-qt6.sha256sum] = "4050fada492c1da5cd942c6c6c042e87e9cae06cc25b64cdfb42f8e8f87d03dc"

URI_aarch64_oxygen-cursor-themes = "${EPEL_MIRROR}/aarch64/Packages/o/oxygen-cursor-themes-6.4.5-1.el10_1.noarch.rpm;name=aarch64_oxygen-cursor-themes;unpack=0"
SRC_URI:append = " ${URI_aarch64_oxygen-cursor-themes}"
SRC_URI[aarch64_oxygen-cursor-themes.sha256sum] = "a8eb50811fc8f2e4c75735d8b4d428bbde485e9eeaf3b5e3ca59bd5f4d9e11c9"

URI_aarch64_plasma-oxygen = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-oxygen-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_plasma-oxygen;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-oxygen}"
SRC_URI[aarch64_plasma-oxygen.sha256sum] = "2a0a1a334713aca3037fed132006234ec1d7c03c1d2a6f5ea82303f6008b0b61"

URI_aarch64_plasma-oxygen-qt6 = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-oxygen-qt6-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_plasma-oxygen-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-oxygen-qt6}"
SRC_URI[aarch64_plasma-oxygen-qt6.sha256sum] = "a3fe59790aa8a31b24dc2ac1556339a8d23338f4c762872304183f70b8c78ea6"

RDEPENDS:oxygen-cursor-themes = " \
 "
RDEPENDS:plasma-oxygen = " \
 glibc \
 kdecoration \
 kf6-filesystem \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kwindowsystem \
 libstdc++ \
 libxcb \
 oxygen-cursor-themes \
 oxygen-icon-theme \
 oxygen-sounds \
 plasma-oxygen-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-oxygen-qt6 = " \
 glibc \
 kf6-frameworkintegration-libs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libstdc++ \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
