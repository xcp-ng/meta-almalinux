# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mimedefang"
PV = "3.6"
PR = "1.el10_1"
PACKAGES = " \
 mimedefang \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mimedefang-3.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c8c5bdc32b1e7bde12604c33b50ae35a0fe48002ba02373ed0e1d714ef53141"

URI_x86_64_v2_mimedefang = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mimedefang-3.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mimedefang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mimedefang}"
SRC_URI[x86_64_v2_mimedefang.sha256sum] = "99628eb3b670c12a652a7feb488d4278261fa1ed5db161bdfdfcb754359b08a1"

URI_aarch64_mimedefang = "${EPEL_MIRROR}/aarch64/Packages/m/mimedefang-3.6-1.el10_1.aarch64.rpm;name=aarch64_mimedefang;unpack=0"
SRC_URI:append = " ${URI_aarch64_mimedefang}"
SRC_URI[aarch64_mimedefang.sha256sum] = "be9873d39916c73f52355516fc2dbb462d63f9b306ec25c30f53ac3ff4ca55e3"

RDEPENDS:mimedefang = " \
 bash \
 glibc \
 mimedefang \
 perl-Carp \
 perl-Data-Dumper \
 perl-Digest-SHA \
 perl-Errno \
 perl-Exporter \
 perl-File-Temp \
 perl-FindBin \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-IO \
 perl-IO-Socket-SSL \
 perl-MIME-tools \
 perl-Mail-DKIM \
 perl-Mail-SPF \
 perl-Net-DNS \
 perl-PathTools \
 perl-Pod-Usage \
 perl-Socket \
 perl-Sys-Hostname \
 perl-Time-Local \
 perl-constant \
 perl-interpreter \
 perl-lib \
 perl-libs \
 sendmail-milter \
 shadow-utils \
 systemd \
 "
