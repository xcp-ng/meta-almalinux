# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ruzstd"
PV = "0.8.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-ruzstd+default-devel \
 rust-ruzstd+dict_builder-devel \
 rust-ruzstd+hash-devel \
 rust-ruzstd+std-devel \
 rust-ruzstd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ruzstd-0.8.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2b6277f123713d8b7295514f13ba9ba440be54d60b632e25eb7abab8cd672ed0"

URI_x86_64_v2_rust-ruzstd+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ruzstd+default-devel-0.8.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ruzstd+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ruzstd+default-devel}"
SRC_URI[x86_64_v2_rust-ruzstd+default-devel.sha256sum] = "ee82e42f4b959e214d0a26fff3a83fa0716ae146b2d333f1f4458601812d23e5"

URI_x86_64_v2_rust-ruzstd+dict_builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ruzstd+dict_builder-devel-0.8.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ruzstd+dict_builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ruzstd+dict_builder-devel}"
SRC_URI[x86_64_v2_rust-ruzstd+dict_builder-devel.sha256sum] = "2e793731ba3768a225fe4168cf378bc14dec10d383c7d89f873cad4d44c78fc5"

URI_x86_64_v2_rust-ruzstd+hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ruzstd+hash-devel-0.8.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ruzstd+hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ruzstd+hash-devel}"
SRC_URI[x86_64_v2_rust-ruzstd+hash-devel.sha256sum] = "963d59603a047113c375dfcf5f63fde811167d0179fe2063cd13ba0dd73e6c72"

URI_x86_64_v2_rust-ruzstd+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ruzstd+std-devel-0.8.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ruzstd+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ruzstd+std-devel}"
SRC_URI[x86_64_v2_rust-ruzstd+std-devel.sha256sum] = "74760d6b4f288de8a533acf639b665aac240e97f100a2ed69061e5f4c1c778ad"

URI_x86_64_v2_rust-ruzstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ruzstd-devel-0.8.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ruzstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ruzstd-devel}"
SRC_URI[x86_64_v2_rust-ruzstd-devel.sha256sum] = "cedfd162fcc4e7246e545c32f7669ebfe498b86fad114637515b67d79837f504"

URI_aarch64_rust-ruzstd+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ruzstd+default-devel-0.8.2-1.el10_2.noarch.rpm;name=aarch64_rust-ruzstd+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ruzstd+default-devel}"
SRC_URI[aarch64_rust-ruzstd+default-devel.sha256sum] = "5091488835690389c87f07a525b2cd2b816f01eb4d980f293923009c6c88fc3c"

URI_aarch64_rust-ruzstd+dict_builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ruzstd+dict_builder-devel-0.8.2-1.el10_2.noarch.rpm;name=aarch64_rust-ruzstd+dict_builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ruzstd+dict_builder-devel}"
SRC_URI[aarch64_rust-ruzstd+dict_builder-devel.sha256sum] = "e55add2d812edca11716aa65c15c2ee360d5a62aa58f5fc8d3f4bb1bdaa0cd40"

URI_aarch64_rust-ruzstd+hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ruzstd+hash-devel-0.8.2-1.el10_2.noarch.rpm;name=aarch64_rust-ruzstd+hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ruzstd+hash-devel}"
SRC_URI[aarch64_rust-ruzstd+hash-devel.sha256sum] = "acced3d404f38babf1b5649eb6a8d637e8ceae345a1053b65053f1d2ab5e001e"

URI_aarch64_rust-ruzstd+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ruzstd+std-devel-0.8.2-1.el10_2.noarch.rpm;name=aarch64_rust-ruzstd+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ruzstd+std-devel}"
SRC_URI[aarch64_rust-ruzstd+std-devel.sha256sum] = "3e7478352f6161d3e5566cbe322b945da7d60c223d751f034e11336dd2c0fffa"

URI_aarch64_rust-ruzstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ruzstd-devel-0.8.2-1.el10_2.noarch.rpm;name=aarch64_rust-ruzstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ruzstd-devel}"
SRC_URI[aarch64_rust-ruzstd-devel.sha256sum] = "ba342f2b789321f72dfc94baf8a2695a7514117719f198dbd3cb0add1fd8cab1"

RDEPENDS:rust-ruzstd+default-devel = " \
 cargo \
 rust-ruzstd+hash-devel \
 rust-ruzstd+std-devel \
 rust-ruzstd-devel \
 "
RDEPENDS:rust-ruzstd+dict_builder-devel = " \
 cargo \
 rust-fastrand+default-devel \
 rust-ruzstd+std-devel \
 rust-ruzstd-devel \
 "
RDEPENDS:rust-ruzstd+hash-devel = " \
 cargo \
 rust-ruzstd-devel \
 rust-twox-hash+xxhash64-devel \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-ruzstd+std-devel = " \
 cargo \
 rust-ruzstd-devel \
 "
RDEPENDS:rust-ruzstd-devel = " \
 cargo \
 "
