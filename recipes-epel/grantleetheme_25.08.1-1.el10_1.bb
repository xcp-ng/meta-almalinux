# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grantleetheme"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 grantleetheme \
 grantleetheme-devel \
 grantleetheme-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/grantleetheme-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09636b0f3de79bcb81099a3d6721078ac0c5b49cc766d303011616e4b8913e36"

URI_x86_64_v2_grantleetheme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grantleetheme-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grantleetheme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grantleetheme}"
SRC_URI[x86_64_v2_grantleetheme.sha256sum] = "bac19292f18a02e1f260de0b08fc04fcc7c9ec59c60551a6cda0d27c4283840f"

URI_x86_64_v2_grantleetheme-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grantleetheme-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grantleetheme-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grantleetheme-devel}"
SRC_URI[x86_64_v2_grantleetheme-devel.sha256sum] = "1a8db61732a9cd2c58fef02a7a18bda6ca0ddee324d04b59f4b6642f5bc9d930"

URI_x86_64_v2_grantleetheme-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grantleetheme-doc-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_grantleetheme-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grantleetheme-doc}"
SRC_URI[x86_64_v2_grantleetheme-doc.sha256sum] = "7a0c149408652dda6324c293f648d090c98d330e9898a2898e380151339e3865"

URI_aarch64_grantleetheme = "${EPEL_MIRROR}/aarch64/Packages/g/grantleetheme-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_grantleetheme;unpack=0"
SRC_URI:append = " ${URI_aarch64_grantleetheme}"
SRC_URI[aarch64_grantleetheme.sha256sum] = "9aa5611f374644303cf4b6f05b07924508c44f49a2b5c9b8b33baca3779201af"

URI_aarch64_grantleetheme-devel = "${EPEL_MIRROR}/aarch64/Packages/g/grantleetheme-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_grantleetheme-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_grantleetheme-devel}"
SRC_URI[aarch64_grantleetheme-devel.sha256sum] = "65e2a9d821d4a7bf2b86c28558ed3e59da63d9385ec5fa070fd09286ad42a08e"

URI_aarch64_grantleetheme-doc = "${EPEL_MIRROR}/aarch64/Packages/g/grantleetheme-doc-25.08.1-1.el10_1.noarch.rpm;name=aarch64_grantleetheme-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_grantleetheme-doc}"
SRC_URI[aarch64_grantleetheme-doc.sha256sum] = "76e34a4eb2535f07b75b1d3f709ee1135c6334852bfca2d2a87983a2b1156a8a"

RDEPENDS:grantleetheme = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-knewstuff \
 kf6-ktexttemplate \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:grantleetheme-devel = " \
 cmake-filesystem \
 grantleetheme \
 kf6-ktexttemplate-devel \
 "
RDEPENDS:grantleetheme-doc = " \
 "
