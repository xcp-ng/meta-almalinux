# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jsonnet"
PV = "0.20.0"
PR = "10.el10_0"
PACKAGES = " \
 jsonnet \
 jsonnet-devel \
 jsonnet-doc \
 jsonnet-libs \
 python3-jsonnet \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/jsonnet-0.20.0-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d490ce2729fe072ad2b9596d3c60fbd533319a55220583482f5032821fb73845"

URI_x86_64_v2_jsonnet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jsonnet-0.20.0-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_jsonnet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jsonnet}"
SRC_URI[x86_64_v2_jsonnet.sha256sum] = "1a751ec581dd1c8993011286e38f7f7b9d20f3d1ca5c0862df679e64093ca0a7"

URI_x86_64_v2_jsonnet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jsonnet-devel-0.20.0-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_jsonnet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jsonnet-devel}"
SRC_URI[x86_64_v2_jsonnet-devel.sha256sum] = "b4f62ecdc13b905e608d3ec97bff3ea6aa0da3fb2dbfe112782fcc3a53599245"

URI_x86_64_v2_jsonnet-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jsonnet-doc-0.20.0-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_jsonnet-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jsonnet-doc}"
SRC_URI[x86_64_v2_jsonnet-doc.sha256sum] = "30b5f274bbfc9be1e036eb7b1cca240141aef16785db04c81540bc77a848f00c"

URI_x86_64_v2_jsonnet-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jsonnet-libs-0.20.0-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_jsonnet-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jsonnet-libs}"
SRC_URI[x86_64_v2_jsonnet-libs.sha256sum] = "414673634c54f2c9655eff320226b8eae7faabc3e31baf706aabc14e535d8194"

URI_x86_64_v2_python3-jsonnet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jsonnet-0.20.0-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-jsonnet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jsonnet}"
SRC_URI[x86_64_v2_python3-jsonnet.sha256sum] = "4bfb430fd150e45d63f31484e219f9270f3c7737949a865e9989e70922bc2b82"

URI_aarch64_jsonnet = "${EPEL_MIRROR}/aarch64/Packages/j/jsonnet-0.20.0-10.el10_0.aarch64.rpm;name=aarch64_jsonnet;unpack=0"
SRC_URI:append = " ${URI_aarch64_jsonnet}"
SRC_URI[aarch64_jsonnet.sha256sum] = "7b04c194a053df2e8a7be774d59c04181df74501e5d27aef93cb2e1d4ab35c16"

URI_aarch64_jsonnet-devel = "${EPEL_MIRROR}/aarch64/Packages/j/jsonnet-devel-0.20.0-10.el10_0.aarch64.rpm;name=aarch64_jsonnet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_jsonnet-devel}"
SRC_URI[aarch64_jsonnet-devel.sha256sum] = "90aeb4e57760c0c53e36f5447523bbe01c86957cc5d01060e3b198b22156c6bd"

URI_aarch64_jsonnet-doc = "${EPEL_MIRROR}/aarch64/Packages/j/jsonnet-doc-0.20.0-10.el10_0.noarch.rpm;name=aarch64_jsonnet-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_jsonnet-doc}"
SRC_URI[aarch64_jsonnet-doc.sha256sum] = "0acee6e572c551a5c338e58124a571e5e3a4f8c39d7bd3cea7b2945f6617aad1"

URI_aarch64_jsonnet-libs = "${EPEL_MIRROR}/aarch64/Packages/j/jsonnet-libs-0.20.0-10.el10_0.aarch64.rpm;name=aarch64_jsonnet-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_jsonnet-libs}"
SRC_URI[aarch64_jsonnet-libs.sha256sum] = "15041270bb0f9cffb925d637bf04a96248615c53f83539e85b8f97318e5f90f8"

URI_aarch64_python3-jsonnet = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jsonnet-0.20.0-10.el10_0.aarch64.rpm;name=aarch64_python3-jsonnet;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jsonnet}"
SRC_URI[aarch64_python3-jsonnet.sha256sum] = "5fc2c8add8a42ce17bab8e90e37f606d46cc8f98fc758ebea98930021adec9f3"

RDEPENDS:jsonnet = " \
 glibc \
 jsonnet-libs \
 libgcc \
 libstdc++ \
 "
RDEPENDS:jsonnet-devel = " \
 jsonnet-libs \
 "
RDEPENDS:jsonnet-doc = " \
 "
RDEPENDS:jsonnet-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 rapidyaml \
 "
RDEPENDS:python3-jsonnet = " \
 glibc \
 jsonnet-libs \
 python3 \
 "
