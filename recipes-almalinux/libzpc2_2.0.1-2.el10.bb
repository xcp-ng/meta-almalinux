# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libzpc2"
PV = "2.0.1"
PR = "2.el10"
PACKAGES = " \
 libzpc-tools \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libzpc2-2.0.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ed5e335533690b1cab87b6729ff587e9e7f301f5fcbbcce523ccbffcd02c6247"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libzpc-tools-2.0.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_libzpc-tools;unpack=0"
SRC_URI[x86_64_v2_libzpc-tools.sha256sum] = "285cc4955c5215ff3cdfe883b54a91d3c236e840a6d4c8c4fd15bec02e7a808e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libzpc-tools-2.0.1-2.el10.aarch64.rpm;name=aarch64_libzpc-tools;unpack=0"
SRC_URI[aarch64_libzpc-tools.sha256sum] = "a014da4e38498b35f22d9d69ab2951299481995e6d4a24be56733471c262d20c"

RDEPENDS:libzpc-tools = " \
 glibc \
 openssl-libs \
 "
