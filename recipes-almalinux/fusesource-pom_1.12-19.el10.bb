# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fusesource-pom"
PV = "1.12"
PR = "19.el10"
PACKAGES = " \
 fusesource-pom \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/fusesource-pom-1.12-19.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3d1542d7207ed5eb4f9e168ce81e9b3beb7d22f781650a33b2b82893152aa9fe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/fusesource-pom-1.12-19.el10.noarch.rpm;name=x86_64_v2_fusesource-pom;unpack=0"
SRC_URI[x86_64_v2_fusesource-pom.sha256sum] = "5b703870b602033b34126e394e51dc59ad2bfd5939023133808f9e062d07c073"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/fusesource-pom-1.12-19.el10.noarch.rpm;name=aarch64_fusesource-pom;unpack=0"
SRC_URI[aarch64_fusesource-pom.sha256sum] = "5b703870b602033b34126e394e51dc59ad2bfd5939023133808f9e062d07c073"

RDEPENDS:fusesource-pom = " \
 javapackages-filesystem \
 "
