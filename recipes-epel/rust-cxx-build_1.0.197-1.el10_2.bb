# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cxx-build"
PV = "1.0.197"
PR = "1.el10_2"
PACKAGES = " \
 rust-cxx-build+default-devel \
 rust-cxx-build+parallel-devel \
 rust-cxx-build-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cxx-build-1.0.197-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce67160ae737a9555ec60eddc33323e1036a505c21e80d633cc3d10677d7782f"

URI_x86_64_v2_rust-cxx-build+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx-build+default-devel-1.0.197-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx-build+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx-build+default-devel}"
SRC_URI[x86_64_v2_rust-cxx-build+default-devel.sha256sum] = "c6677806752f8f630947ce90a8ae0cfec0fec70ee88f15d3b0c25b55bbb385f7"

URI_x86_64_v2_rust-cxx-build+parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx-build+parallel-devel-1.0.197-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx-build+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx-build+parallel-devel}"
SRC_URI[x86_64_v2_rust-cxx-build+parallel-devel.sha256sum] = "04ddc2c1ec53329a32e735c2ec5d5c0f9663dd12b0eec3a03bbfcc858c635e65"

URI_x86_64_v2_rust-cxx-build-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx-build-devel-1.0.197-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx-build-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx-build-devel}"
SRC_URI[x86_64_v2_rust-cxx-build-devel.sha256sum] = "6fd215238b9b22bd30004cbf61dc14b510675258bd25fa462a1b84b822e30b3f"

URI_aarch64_rust-cxx-build+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx-build+default-devel-1.0.197-1.el10_2.noarch.rpm;name=aarch64_rust-cxx-build+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx-build+default-devel}"
SRC_URI[aarch64_rust-cxx-build+default-devel.sha256sum] = "83366a72faeccf15704df8f2c5282f209736f356a3d36322acdef463d6bb74c8"

URI_aarch64_rust-cxx-build+parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx-build+parallel-devel-1.0.197-1.el10_2.noarch.rpm;name=aarch64_rust-cxx-build+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx-build+parallel-devel}"
SRC_URI[aarch64_rust-cxx-build+parallel-devel.sha256sum] = "b39137e691ec394ef57b7e3a904d3583abe34ca8b2dc484171ba9edc15f62cd1"

URI_aarch64_rust-cxx-build-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx-build-devel-1.0.197-1.el10_2.noarch.rpm;name=aarch64_rust-cxx-build-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx-build-devel}"
SRC_URI[aarch64_rust-cxx-build-devel.sha256sum] = "2d754ef218532005b4e44741551a6fa71f8d2688a842645c2f0b1d0a17b361cd"

RDEPENDS:rust-cxx-build+default-devel = " \
 cargo \
 rust-cxx-build-devel \
 "
RDEPENDS:rust-cxx-build+parallel-devel = " \
 cargo \
 rust-cc+parallel-devel \
 rust-cxx-build-devel \
 "
RDEPENDS:rust-cxx-build-devel = " \
 cargo \
 rust \
 rust-cc+default-devel \
 rust-codespan-reporting+default-devel \
 rust-indexmap+default-devel \
 rust-proc-macro2+span-locations-devel \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-scratch+default-devel \
 rust-syn+clone-impls-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn-devel \
 "
