# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-generic-array"
PV = "0.14.9"
PR = "1.el10_0"
PACKAGES = " \
 rust-generic-array+default-devel \
 rust-generic-array+more_lengths-devel \
 rust-generic-array+serde-devel \
 rust-generic-array+zeroize-devel \
 rust-generic-array-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-generic-array-0.14.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bf20ab01abd2c15444389c204560bcabbca21ade54eae760b4b8784bcf077877"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-generic-array+default-devel-0.14.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-generic-array+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-generic-array+default-devel.sha256sum] = "ee0a5531cae373a5efe03f5cd403da96cc8df7170c46b30ffe979472eb47c6ed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-generic-array+more_lengths-devel-0.14.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-generic-array+more_lengths-devel;unpack=0"
SRC_URI[x86_64_v2_rust-generic-array+more_lengths-devel.sha256sum] = "c92aaa4b4dbe90502c9b581764d5ae475506d74ae0ff394839b62d8d4cb6ff3c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-generic-array+serde-devel-0.14.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-generic-array+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-generic-array+serde-devel.sha256sum] = "1d74761343b52eefc2d5a9702ed05ccc58aa64c5fb61286457a1da2855cb94cd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-generic-array+zeroize-devel-0.14.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-generic-array+zeroize-devel;unpack=0"
SRC_URI[x86_64_v2_rust-generic-array+zeroize-devel.sha256sum] = "94998de5972158a73aa1d46c3496ac7d88177d309ac58ff293c717b3b9035598"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-generic-array-devel-0.14.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-generic-array-devel;unpack=0"
SRC_URI[x86_64_v2_rust-generic-array-devel.sha256sum] = "dab15c613c546160987b0198eaae67ea3550d1657865a40d262d8c82a043c98f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-generic-array+default-devel-0.14.9-1.el10_0.noarch.rpm;name=aarch64_rust-generic-array+default-devel;unpack=0"
SRC_URI[aarch64_rust-generic-array+default-devel.sha256sum] = "a8ad6ba6cf215e0341fec98aa5bc63c34b3d4c1f7c1f474fa8a2715d85c10992"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-generic-array+more_lengths-devel-0.14.9-1.el10_0.noarch.rpm;name=aarch64_rust-generic-array+more_lengths-devel;unpack=0"
SRC_URI[aarch64_rust-generic-array+more_lengths-devel.sha256sum] = "ef4ce513a8c1118a6c091875e69bb3fc11287e8fd0f518b56227e6bfccc92900"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-generic-array+serde-devel-0.14.9-1.el10_0.noarch.rpm;name=aarch64_rust-generic-array+serde-devel;unpack=0"
SRC_URI[aarch64_rust-generic-array+serde-devel.sha256sum] = "a53f23f73c876dcf16a9a6b230e21d9abab53f4cd434cef125ad6fce28966bbf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-generic-array+zeroize-devel-0.14.9-1.el10_0.noarch.rpm;name=aarch64_rust-generic-array+zeroize-devel;unpack=0"
SRC_URI[aarch64_rust-generic-array+zeroize-devel.sha256sum] = "b51af6d528910ab78d4b9d161ba62da317e6a56ff2a27dd9d8c1d92b69e123d8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-generic-array-devel-0.14.9-1.el10_0.noarch.rpm;name=aarch64_rust-generic-array-devel;unpack=0"
SRC_URI[aarch64_rust-generic-array-devel.sha256sum] = "aaebe2e584fedc594d44f48cd4d21a82834aebd88755655e263528595dcf6c4c"

RDEPENDS:rust-generic-array+default-devel = " \
 cargo \
 rust-generic-array-devel \
 "
RDEPENDS:rust-generic-array+more_lengths-devel = " \
 cargo \
 rust-generic-array-devel \
 "
RDEPENDS:rust-generic-array+serde-devel = " \
 cargo \
 rust-generic-array-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-generic-array+zeroize-devel = " \
 cargo \
 rust-generic-array-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-generic-array-devel = " \
 cargo \
 rust-typenum+default-devel \
 rust-version_check+default-devel \
 "
