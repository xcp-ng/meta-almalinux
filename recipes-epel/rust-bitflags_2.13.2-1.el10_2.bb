# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bitflags"
PV = "2.13.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-bitflags+arbitrary-devel \
 rust-bitflags+bytemuck-devel \
 rust-bitflags+default-devel \
 rust-bitflags+example_generated-devel \
 rust-bitflags+serde-devel \
 rust-bitflags+serde_core-devel \
 rust-bitflags+std-devel \
 rust-bitflags-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-bitflags-2.13.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d24363d7c81ab6ac4dde76c291f78f929af4eff300520ecb34552744371cfa32"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+arbitrary-devel-2.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+arbitrary-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bitflags+arbitrary-devel.sha256sum] = "a2a63b5cd076869fe47c20fe60efc15f3c497ad4036de69acecc5104e04b7452"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+bytemuck-devel-2.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+bytemuck-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bitflags+bytemuck-devel.sha256sum] = "9f614989a07f0d2ed5e1597a23abfbe0640af2da1dc2288edbcc85ab7d5a3a7d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+default-devel-2.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bitflags+default-devel.sha256sum] = "aae8b10f4b1a756f847ea3033e59d6a53320a91b3474a517e854b62bb1bedffd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+example_generated-devel-2.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+example_generated-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bitflags+example_generated-devel.sha256sum] = "b4f820b5bae00030ac14ff5e351c08f4e07f4c425aaabf6020056af1eb529488"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+serde-devel-2.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bitflags+serde-devel.sha256sum] = "39e18617634d3df5a6b75e17ecd2f1c0fcfd1d4af2d9e0e2df5781fb396c4025"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+serde_core-devel-2.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+serde_core-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bitflags+serde_core-devel.sha256sum] = "b30eee8012b1c55670803b0f9b35fab4e6ab8538b3eb2fc49569bf39c517ac70"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+std-devel-2.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bitflags+std-devel.sha256sum] = "a41ee3f4a8fcc2d34ad53d1f71a7c7e9f0b6045337a7b634bd5412d55fbdfcc6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags-devel-2.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bitflags-devel.sha256sum] = "1bcf97f6add48976b3664a9039dafcf8494997d95a092d22e1a9827faf82f34b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+arbitrary-devel-2.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-bitflags+arbitrary-devel;unpack=0"
SRC_URI[aarch64_rust-bitflags+arbitrary-devel.sha256sum] = "655405a0167450b10979ee382f0556f8c9956beaff4f2c8d33c0a4fb95ae5ac9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+bytemuck-devel-2.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-bitflags+bytemuck-devel;unpack=0"
SRC_URI[aarch64_rust-bitflags+bytemuck-devel.sha256sum] = "dc3823df27cebd5816f9742efef4fbfb6d957c51578fec99afb417e9564c41ff"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+default-devel-2.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-bitflags+default-devel;unpack=0"
SRC_URI[aarch64_rust-bitflags+default-devel.sha256sum] = "e1bdd1435f53ffca3c6c8b393b8fe3975e442293d3ee0babe5c4f7cd00fafd25"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+example_generated-devel-2.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-bitflags+example_generated-devel;unpack=0"
SRC_URI[aarch64_rust-bitflags+example_generated-devel.sha256sum] = "5140c537691ddeb63abdc754c19d1e78012fb6f43d38682d9e160cf9404d4bba"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+serde-devel-2.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-bitflags+serde-devel;unpack=0"
SRC_URI[aarch64_rust-bitflags+serde-devel.sha256sum] = "484bcece49d95043913dd5777797c59b4b00eebb35a8680ded90576af6d7b3bc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+serde_core-devel-2.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-bitflags+serde_core-devel;unpack=0"
SRC_URI[aarch64_rust-bitflags+serde_core-devel.sha256sum] = "5a77c4adc793f3d0d572b63aa8b399321f1901e0909ff528c62d42eb6aabc742"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+std-devel-2.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-bitflags+std-devel;unpack=0"
SRC_URI[aarch64_rust-bitflags+std-devel.sha256sum] = "bf58cd6ace9c5217a7638891ba17987d16157fe9799e4412fed69f2fe0e50f7e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags-devel-2.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-bitflags-devel;unpack=0"
SRC_URI[aarch64_rust-bitflags-devel.sha256sum] = "6bf04e1464a82958bd947814eaf18f7d43a3d515a965004b4561fed362902f5e"

RDEPENDS:rust-bitflags+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-bitflags-devel \
 "
RDEPENDS:rust-bitflags+bytemuck-devel = " \
 cargo \
 rust-bitflags-devel \
 rust-bytemuck+default-devel \
 "
RDEPENDS:rust-bitflags+default-devel = " \
 cargo \
 rust-bitflags-devel \
 "
RDEPENDS:rust-bitflags+example_generated-devel = " \
 cargo \
 rust-bitflags-devel \
 "
RDEPENDS:rust-bitflags+serde-devel = " \
 cargo \
 rust-bitflags+serde_core-devel \
 rust-bitflags-devel \
 "
RDEPENDS:rust-bitflags+serde_core-devel = " \
 cargo \
 rust-bitflags-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-bitflags+std-devel = " \
 cargo \
 rust-bitflags-devel \
 "
RDEPENDS:rust-bitflags-devel = " \
 cargo \
 rust \
 "
