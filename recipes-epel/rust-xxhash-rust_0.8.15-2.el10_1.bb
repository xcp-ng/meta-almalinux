# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-xxhash-rust"
PV = "0.8.15"
PR = "2.el10_1"
PACKAGES = " \
 rust-xxhash-rust+const_xxh3-devel \
 rust-xxhash-rust+const_xxh32-devel \
 rust-xxhash-rust+const_xxh64-devel \
 rust-xxhash-rust+default-devel \
 rust-xxhash-rust+std-devel \
 rust-xxhash-rust+xxh3-devel \
 rust-xxhash-rust+xxh32-devel \
 rust-xxhash-rust+xxh64-devel \
 rust-xxhash-rust-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-xxhash-rust-0.8.15-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30691b4373defc9833eeec67a5a4c8a4ca9e60703c41080c8999a5f3ffb5ebae"

URI_x86_64_v2_rust-xxhash-rust+const_xxh3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xxhash-rust+const_xxh3-devel-0.8.15-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xxhash-rust+const_xxh3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xxhash-rust+const_xxh3-devel}"
SRC_URI[x86_64_v2_rust-xxhash-rust+const_xxh3-devel.sha256sum] = "8795be9860cb05e78844c5d8cdb516425a922d7532b1a9bbdb0a91f2aebcf032"

URI_x86_64_v2_rust-xxhash-rust+const_xxh32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xxhash-rust+const_xxh32-devel-0.8.15-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xxhash-rust+const_xxh32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xxhash-rust+const_xxh32-devel}"
SRC_URI[x86_64_v2_rust-xxhash-rust+const_xxh32-devel.sha256sum] = "17db167dfb7693c89260586f4931f39971605b75b0658cb0089a7b6524620402"

URI_x86_64_v2_rust-xxhash-rust+const_xxh64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xxhash-rust+const_xxh64-devel-0.8.15-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xxhash-rust+const_xxh64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xxhash-rust+const_xxh64-devel}"
SRC_URI[x86_64_v2_rust-xxhash-rust+const_xxh64-devel.sha256sum] = "e4c0a51920346d7aa45b7da4678009195dc63bd9a768b0eb433e322b60d52c0f"

URI_x86_64_v2_rust-xxhash-rust+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xxhash-rust+default-devel-0.8.15-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xxhash-rust+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xxhash-rust+default-devel}"
SRC_URI[x86_64_v2_rust-xxhash-rust+default-devel.sha256sum] = "6aae6bbb578874d1c0a481f21a27b2fd2c209e9d58bb6aab808ad79bd0f5bca8"

URI_x86_64_v2_rust-xxhash-rust+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xxhash-rust+std-devel-0.8.15-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xxhash-rust+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xxhash-rust+std-devel}"
SRC_URI[x86_64_v2_rust-xxhash-rust+std-devel.sha256sum] = "6fed2b0ec6e8e901410dcdad685621c6f2b9176ff2d1db3903159d6eb757e808"

URI_x86_64_v2_rust-xxhash-rust+xxh3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xxhash-rust+xxh3-devel-0.8.15-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xxhash-rust+xxh3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xxhash-rust+xxh3-devel}"
SRC_URI[x86_64_v2_rust-xxhash-rust+xxh3-devel.sha256sum] = "c3693475a059167eef77240f0f0fa3f0baff7496f3af71fbed3a4ca05f2047e1"

URI_x86_64_v2_rust-xxhash-rust+xxh32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xxhash-rust+xxh32-devel-0.8.15-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xxhash-rust+xxh32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xxhash-rust+xxh32-devel}"
SRC_URI[x86_64_v2_rust-xxhash-rust+xxh32-devel.sha256sum] = "27f543dad073d661b3e828cfa3cd299cdaace4ffbc91af8a7ed29046fed9d6d9"

URI_x86_64_v2_rust-xxhash-rust+xxh64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xxhash-rust+xxh64-devel-0.8.15-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xxhash-rust+xxh64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xxhash-rust+xxh64-devel}"
SRC_URI[x86_64_v2_rust-xxhash-rust+xxh64-devel.sha256sum] = "d4ae0917db2660a40d90b2eaded8ab47a319fa1bcf9dd5baf8a0026a2611b406"

URI_x86_64_v2_rust-xxhash-rust-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xxhash-rust-devel-0.8.15-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xxhash-rust-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xxhash-rust-devel}"
SRC_URI[x86_64_v2_rust-xxhash-rust-devel.sha256sum] = "8ceed60d31b6d6eef145a6473d20b6e1bb22340f8b07bf86462e59419d09c909"

URI_aarch64_rust-xxhash-rust+const_xxh3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xxhash-rust+const_xxh3-devel-0.8.15-2.el10_1.noarch.rpm;name=aarch64_rust-xxhash-rust+const_xxh3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xxhash-rust+const_xxh3-devel}"
SRC_URI[aarch64_rust-xxhash-rust+const_xxh3-devel.sha256sum] = "c987c974ac4fa7ed11f650f1fdbe0b4dc66b9826edb823a31d69bf5de3fc00f0"

URI_aarch64_rust-xxhash-rust+const_xxh32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xxhash-rust+const_xxh32-devel-0.8.15-2.el10_1.noarch.rpm;name=aarch64_rust-xxhash-rust+const_xxh32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xxhash-rust+const_xxh32-devel}"
SRC_URI[aarch64_rust-xxhash-rust+const_xxh32-devel.sha256sum] = "f6cc5ae21fb5f9afa39764c15778e51296cfb26c3985f07e20ad083327382137"

URI_aarch64_rust-xxhash-rust+const_xxh64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xxhash-rust+const_xxh64-devel-0.8.15-2.el10_1.noarch.rpm;name=aarch64_rust-xxhash-rust+const_xxh64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xxhash-rust+const_xxh64-devel}"
SRC_URI[aarch64_rust-xxhash-rust+const_xxh64-devel.sha256sum] = "605cb351ddca79a109b8899b88880fe837672f518c53b3e335df1fe239d94c0d"

URI_aarch64_rust-xxhash-rust+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xxhash-rust+default-devel-0.8.15-2.el10_1.noarch.rpm;name=aarch64_rust-xxhash-rust+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xxhash-rust+default-devel}"
SRC_URI[aarch64_rust-xxhash-rust+default-devel.sha256sum] = "534b8db62045e6c2e984914a06285dd0adaa6501545a018559c4cb97f3ce2ea8"

URI_aarch64_rust-xxhash-rust+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xxhash-rust+std-devel-0.8.15-2.el10_1.noarch.rpm;name=aarch64_rust-xxhash-rust+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xxhash-rust+std-devel}"
SRC_URI[aarch64_rust-xxhash-rust+std-devel.sha256sum] = "bfbb751e1ba2c0de9e0f0f2fb98c2c18791536d53c60942804440472564011eb"

URI_aarch64_rust-xxhash-rust+xxh3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xxhash-rust+xxh3-devel-0.8.15-2.el10_1.noarch.rpm;name=aarch64_rust-xxhash-rust+xxh3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xxhash-rust+xxh3-devel}"
SRC_URI[aarch64_rust-xxhash-rust+xxh3-devel.sha256sum] = "7cc1f2e5689c5285a9c4995db1200f5293248e25807e4700cf8ac08920d757ba"

URI_aarch64_rust-xxhash-rust+xxh32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xxhash-rust+xxh32-devel-0.8.15-2.el10_1.noarch.rpm;name=aarch64_rust-xxhash-rust+xxh32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xxhash-rust+xxh32-devel}"
SRC_URI[aarch64_rust-xxhash-rust+xxh32-devel.sha256sum] = "8ae30a228879539acd43328cc86323831ea4ae4b956daaf775b4b0757c381d0b"

URI_aarch64_rust-xxhash-rust+xxh64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xxhash-rust+xxh64-devel-0.8.15-2.el10_1.noarch.rpm;name=aarch64_rust-xxhash-rust+xxh64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xxhash-rust+xxh64-devel}"
SRC_URI[aarch64_rust-xxhash-rust+xxh64-devel.sha256sum] = "a136f0b5bb0e5f6aacc1c64660ee1867209bf2d31a2e8f3545a35640e3f439fb"

URI_aarch64_rust-xxhash-rust-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xxhash-rust-devel-0.8.15-2.el10_1.noarch.rpm;name=aarch64_rust-xxhash-rust-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xxhash-rust-devel}"
SRC_URI[aarch64_rust-xxhash-rust-devel.sha256sum] = "bbecc5c3595d5fc84a271f53a7d9115476b57b893260d370870466b8ba4e91eb"

RDEPENDS:rust-xxhash-rust+const_xxh3-devel = " \
 cargo \
 rust-xxhash-rust-devel \
 "
RDEPENDS:rust-xxhash-rust+const_xxh32-devel = " \
 cargo \
 rust-xxhash-rust-devel \
 "
RDEPENDS:rust-xxhash-rust+const_xxh64-devel = " \
 cargo \
 rust-xxhash-rust-devel \
 "
RDEPENDS:rust-xxhash-rust+default-devel = " \
 cargo \
 rust-xxhash-rust-devel \
 "
RDEPENDS:rust-xxhash-rust+std-devel = " \
 cargo \
 rust-xxhash-rust-devel \
 "
RDEPENDS:rust-xxhash-rust+xxh3-devel = " \
 cargo \
 rust-xxhash-rust-devel \
 "
RDEPENDS:rust-xxhash-rust+xxh32-devel = " \
 cargo \
 rust-xxhash-rust-devel \
 "
RDEPENDS:rust-xxhash-rust+xxh64-devel = " \
 cargo \
 rust-xxhash-rust-devel \
 "
RDEPENDS:rust-xxhash-rust-devel = " \
 cargo \
 "
