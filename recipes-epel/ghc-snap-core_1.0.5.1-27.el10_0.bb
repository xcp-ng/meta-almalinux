# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-snap-core"
PV = "1.0.5.1"
PR = "27.el10_0"
PACKAGES = " \
 ghc-readable \
 ghc-readable-devel \
 ghc-readable-doc \
 ghc-readable-prof \
 ghc-snap-core \
 ghc-snap-core-devel \
 ghc-snap-core-doc \
 ghc-snap-core-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-snap-core-1.0.5.1-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d25c7d573b0cbb44b44bb86a86668b22aa3027982b98a3ec20edeb2b6f8b80a4"

URI_x86_64_v2_ghc-readable = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-readable-0.3.1-27.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-readable;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-readable}"
SRC_URI[x86_64_v2_ghc-readable.sha256sum] = "e433e96d2f3b70c7c30f4391d96c1bf9310d5e077e2f66886522d609115e3d61"

URI_x86_64_v2_ghc-readable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-readable-devel-0.3.1-27.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-readable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-readable-devel}"
SRC_URI[x86_64_v2_ghc-readable-devel.sha256sum] = "9a40c9c58837f1bf3947da363a72909be77422f4a167044e19139d592c0e704c"

URI_x86_64_v2_ghc-readable-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-readable-doc-0.3.1-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-readable-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-readable-doc}"
SRC_URI[x86_64_v2_ghc-readable-doc.sha256sum] = "e6a3de273b88245af9e9c6d3583e77a7c40b9e4d6a762bd403d2fd44c261b70f"

URI_x86_64_v2_ghc-readable-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-readable-prof-0.3.1-27.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-readable-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-readable-prof}"
SRC_URI[x86_64_v2_ghc-readable-prof.sha256sum] = "c1feea07a64cb61ea0269075c642e6141eee3cc3281bff4e168f84ad1c39e718"

URI_x86_64_v2_ghc-snap-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-snap-core-1.0.5.1-27.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-snap-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-snap-core}"
SRC_URI[x86_64_v2_ghc-snap-core.sha256sum] = "249ef7e66810654692dde6d038bf7ee28101e081996d416a7720a955d1f5cd66"

URI_x86_64_v2_ghc-snap-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-snap-core-devel-1.0.5.1-27.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-snap-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-snap-core-devel}"
SRC_URI[x86_64_v2_ghc-snap-core-devel.sha256sum] = "3087fba713814d2563f6c5f1e87630edb9bc574bf09c41cd04ed9af4c1dbbe25"

URI_x86_64_v2_ghc-snap-core-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-snap-core-doc-1.0.5.1-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-snap-core-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-snap-core-doc}"
SRC_URI[x86_64_v2_ghc-snap-core-doc.sha256sum] = "2eee0c256bc19ffef4b3dcbb5b6b50698f709d14f95400bb9f483d0b02eb56fb"

URI_x86_64_v2_ghc-snap-core-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-snap-core-prof-1.0.5.1-27.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-snap-core-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-snap-core-prof}"
SRC_URI[x86_64_v2_ghc-snap-core-prof.sha256sum] = "d5ad6e7b58ec66d76d58bf059d836cba227d859f608af5970a222f435204adce"

URI_aarch64_ghc-readable = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-readable-0.3.1-27.el10_0.aarch64.rpm;name=aarch64_ghc-readable;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-readable}"
SRC_URI[aarch64_ghc-readable.sha256sum] = "8c639d4ba164f6027803de0971659863edf5599c8f1923c96acc421b64fa5241"

URI_aarch64_ghc-readable-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-readable-devel-0.3.1-27.el10_0.aarch64.rpm;name=aarch64_ghc-readable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-readable-devel}"
SRC_URI[aarch64_ghc-readable-devel.sha256sum] = "70b804732e52fa4b961da1a1ed68b803ebe904f4983f88666569ba18549fcfff"

URI_aarch64_ghc-readable-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-readable-doc-0.3.1-27.el10_0.noarch.rpm;name=aarch64_ghc-readable-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-readable-doc}"
SRC_URI[aarch64_ghc-readable-doc.sha256sum] = "eaf90e0cb7e97140bcaca84f0cb14e4e4052dfdf56ff8ca993c3d98a01d7cc4f"

URI_aarch64_ghc-readable-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-readable-prof-0.3.1-27.el10_0.aarch64.rpm;name=aarch64_ghc-readable-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-readable-prof}"
SRC_URI[aarch64_ghc-readable-prof.sha256sum] = "bd9178872b201fd30b2f11865d5d1fce1d8ec8d47d6e8c6133ccd279a554bb31"

URI_aarch64_ghc-snap-core = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-snap-core-1.0.5.1-27.el10_0.aarch64.rpm;name=aarch64_ghc-snap-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-snap-core}"
SRC_URI[aarch64_ghc-snap-core.sha256sum] = "85d376119c5f9db8a3763e8659e501e90bfc2a8dc3e9bbd77c626d8d6ecfe1f9"

URI_aarch64_ghc-snap-core-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-snap-core-devel-1.0.5.1-27.el10_0.aarch64.rpm;name=aarch64_ghc-snap-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-snap-core-devel}"
SRC_URI[aarch64_ghc-snap-core-devel.sha256sum] = "cb854702902c0a61f1cfaf2b103e88f30aaac46bf6c611e231a6ec8a50aa5a55"

URI_aarch64_ghc-snap-core-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-snap-core-doc-1.0.5.1-27.el10_0.noarch.rpm;name=aarch64_ghc-snap-core-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-snap-core-doc}"
SRC_URI[aarch64_ghc-snap-core-doc.sha256sum] = "50e522b8546d6677dc57c38f5be14ad35b10846feda0f9cc90f4d173998aac9f"

URI_aarch64_ghc-snap-core-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-snap-core-prof-1.0.5.1-27.el10_0.aarch64.rpm;name=aarch64_ghc-snap-core-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-snap-core-prof}"
SRC_URI[aarch64_ghc-snap-core-prof.sha256sum] = "d3c0c9474515e4a39281cf774f9608dbd26eb9b8398e5f407139d1480cacec7a"

RDEPENDS:ghc-readable = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 glibc \
 gmp \
 "
RDEPENDS:ghc-readable-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-readable \
 ghc-text-devel \
 "
RDEPENDS:ghc-readable-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-readable-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-readable-devel \
 ghc-text-prof \
 "
RDEPENDS:ghc-snap-core = " \
 ghc-HUnit \
 ghc-array \
 ghc-attoparsec \
 ghc-base \
 ghc-base-orphans \
 ghc-binary \
 ghc-bytestring \
 ghc-call-stack \
 ghc-case-insensitive \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-integer-logarithms \
 ghc-io-streams \
 ghc-lifted-base \
 ghc-monad-control \
 ghc-mtl \
 ghc-network \
 ghc-network-uri \
 ghc-os-string \
 ghc-parsec \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-readable \
 ghc-regex-base \
 ghc-regex-posix \
 ghc-scientific \
 ghc-splitmix \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-th-compat \
 ghc-time \
 ghc-time-locale-compat \
 ghc-transformers \
 ghc-transformers-base \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unix-compat \
 ghc-unordered-containers \
 ghc-vector \
 ghc-vector-stream \
 ghc-zlib \
 ghc-zlib-bindings \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-snap-core-devel = " \
 ghc-HUnit-devel \
 ghc-attoparsec-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-case-insensitive-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-directory-devel \
 ghc-filepath-devel \
 ghc-hashable-devel \
 ghc-io-streams-devel \
 ghc-lifted-base-devel \
 ghc-monad-control-devel \
 ghc-mtl-devel \
 ghc-network-devel \
 ghc-network-uri-devel \
 ghc-random-devel \
 ghc-readable-devel \
 ghc-regex-posix-devel \
 ghc-snap-core \
 ghc-text-devel \
 ghc-time-devel \
 ghc-time-locale-compat-devel \
 ghc-transformers-base-devel \
 ghc-transformers-devel \
 ghc-unix-compat-devel \
 ghc-unordered-containers-devel \
 ghc-vector-devel \
 "
RDEPENDS:ghc-snap-core-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-snap-core-prof = " \
 ghc-HUnit-prof \
 ghc-attoparsec-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-case-insensitive-prof \
 ghc-containers-prof \
 ghc-directory-prof \
 ghc-filepath-prof \
 ghc-hashable-prof \
 ghc-io-streams-prof \
 ghc-lifted-base-prof \
 ghc-monad-control-prof \
 ghc-mtl-prof \
 ghc-network-prof \
 ghc-network-uri-prof \
 ghc-random-prof \
 ghc-readable-prof \
 ghc-regex-posix-prof \
 ghc-snap-core-devel \
 ghc-text-prof \
 ghc-time-locale-compat-prof \
 ghc-time-prof \
 ghc-transformers-base-prof \
 ghc-transformers-prof \
 ghc-unix-compat-prof \
 ghc-unordered-containers-prof \
 ghc-vector-prof \
 "
