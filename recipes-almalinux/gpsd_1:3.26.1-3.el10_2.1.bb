# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gpsd"
PE = "1"
PV = "3.26.1"
PR = "3.el10_2.1"
PACKAGES = " \
 gpsd \
 gpsd-clients \
 python3-gpsd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gpsd-3.26.1-3.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e329276d4ee4b6494da90e9429dbe0ff7e9803d7ab09dd089422dbd01c37daf"

URI_x86_64_v2_gpsd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gpsd-3.26.1-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_gpsd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpsd}"
SRC_URI[x86_64_v2_gpsd.sha256sum] = "06fa2318248abf28ee5125eca2060a4bb276f8c6aaf18857b3bf0f33ac155a0e"

URI_x86_64_v2_gpsd-clients = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gpsd-clients-3.26.1-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_gpsd-clients;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpsd-clients}"
SRC_URI[x86_64_v2_gpsd-clients.sha256sum] = "be82ec41f3e03a23f7a03f4e73ed3e4222e023ecd9c22e69651234aef302a854"

URI_x86_64_v2_python3-gpsd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-gpsd-3.26.1-3.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_python3-gpsd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gpsd}"
SRC_URI[x86_64_v2_python3-gpsd.sha256sum] = "b149b421ecf9b8c86eae1006f11438c101c00744637a146eb61f139ceae8543f"

URI_aarch64_gpsd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gpsd-3.26.1-3.el10_2.1.aarch64.rpm;name=aarch64_gpsd;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpsd}"
SRC_URI[aarch64_gpsd.sha256sum] = "fb7d4a5fc6886a60aa27551712459da9e4849597e684775ba97e28c30f121ba7"

URI_aarch64_gpsd-clients = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gpsd-clients-3.26.1-3.el10_2.1.aarch64.rpm;name=aarch64_gpsd-clients;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpsd-clients}"
SRC_URI[aarch64_gpsd-clients.sha256sum] = "f1748b1318ac95cc99e0f387ebaeb9233ba86d43c5f93b3b56a74529862c1d45"

URI_aarch64_python3-gpsd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-gpsd-3.26.1-3.el10_2.1.aarch64.rpm;name=aarch64_python3-gpsd;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gpsd}"
SRC_URI[aarch64_python3-gpsd.sha256sum] = "a03f1defb4c9fa792746544a307b11f0d3ad5cabdde1fdeb9ed9b44e0958f2fd"

RDEPENDS:gpsd = " \
 bash \
 bluez-libs \
 dbus-libs \
 glibc \
 libusb1 \
 ncurses-libs \
 systemd \
 systemd-udev \
 "
RDEPENDS:gpsd-clients = " \
 bash \
 bluez-libs \
 dbus-libs \
 glibc \
 libusb1 \
 ncurses-libs \
 python3 \
 python3-gpsd \
 "
RDEPENDS:python3-gpsd = " \
 glibc \
 python3 \
 python3-pyserial \
 "
