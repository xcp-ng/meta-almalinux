# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-compact_str"
PV = "0.9.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-compact_str+arbitrary-devel \
 rust-compact_str+bytes-devel \
 rust-compact_str+default-devel \
 rust-compact_str+proptest-devel \
 rust-compact_str+quickcheck-devel \
 rust-compact_str+rkyv-devel \
 rust-compact_str+serde-devel \
 rust-compact_str+smallvec-devel \
 rust-compact_str+std-devel \
 rust-compact_str+zeroize-devel \
 rust-compact_str-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-compact_str-0.9.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "134fd95039c61d3c503982c727b57526e30e58fdf8cfad63ffead498cc4e4f3b"

URI_x86_64_v2_rust-compact_str+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+arbitrary-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-compact_str+arbitrary-devel.sha256sum] = "9ee8fdf84b53d74d206475df8d8726fdf9b0441fe4a436625bb21c8353931e91"

URI_x86_64_v2_rust-compact_str+bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+bytes-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+bytes-devel}"
SRC_URI[x86_64_v2_rust-compact_str+bytes-devel.sha256sum] = "11a0642a23c658ea9581ffbf5205f3b8983d17a4811271e1d2430a3ae55b6f72"

URI_x86_64_v2_rust-compact_str+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+default-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+default-devel}"
SRC_URI[x86_64_v2_rust-compact_str+default-devel.sha256sum] = "bd422c8271f81b0f4eb3b44a2f76cc2f87647e73eb3e9e2c49c1aac0000d8c3a"

URI_x86_64_v2_rust-compact_str+proptest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+proptest-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+proptest-devel}"
SRC_URI[x86_64_v2_rust-compact_str+proptest-devel.sha256sum] = "64c7a3f86b737bcd07f0c699a48c28d4c10b85dfbeb8e2fe1dab87d72eddedc9"

URI_x86_64_v2_rust-compact_str+quickcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+quickcheck-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+quickcheck-devel}"
SRC_URI[x86_64_v2_rust-compact_str+quickcheck-devel.sha256sum] = "64294b50e1cb65d7494c34f650301feb0edde3b4c90a71f26f2d53fbb2fa73b3"

URI_x86_64_v2_rust-compact_str+rkyv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+rkyv-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+rkyv-devel}"
SRC_URI[x86_64_v2_rust-compact_str+rkyv-devel.sha256sum] = "aecd998e05a1ed1166392ac912af3049d957aa32bef3c64ec6bf7340fec0a39c"

URI_x86_64_v2_rust-compact_str+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+serde-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+serde-devel}"
SRC_URI[x86_64_v2_rust-compact_str+serde-devel.sha256sum] = "7230422f0088d058aae2cf48e55b1ed699bc281fc4989608a1bf96fb54369ab8"

URI_x86_64_v2_rust-compact_str+smallvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+smallvec-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+smallvec-devel}"
SRC_URI[x86_64_v2_rust-compact_str+smallvec-devel.sha256sum] = "6556060179d146b728f72468fc245fbc7791f0382a059ad811a189e873bc0240"

URI_x86_64_v2_rust-compact_str+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+std-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+std-devel}"
SRC_URI[x86_64_v2_rust-compact_str+std-devel.sha256sum] = "ecbf1582b65dedba84f38f211222fbab216c581d62f4109eb2890d11aa20f50a"

URI_x86_64_v2_rust-compact_str+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+zeroize-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+zeroize-devel}"
SRC_URI[x86_64_v2_rust-compact_str+zeroize-devel.sha256sum] = "9fcee19cb133d3a24aa77bd6c1d7ef0755addf36e1a98bc9b55c5f3bcef413df"

URI_x86_64_v2_rust-compact_str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str-devel}"
SRC_URI[x86_64_v2_rust-compact_str-devel.sha256sum] = "a5636214e7a02c1b9603562582621ee5651b1c2e2980e92421906b3d92606999"

URI_aarch64_rust-compact_str+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+arbitrary-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-compact_str+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+arbitrary-devel}"
SRC_URI[aarch64_rust-compact_str+arbitrary-devel.sha256sum] = "98448c4f1d22a63ca1564276921af607f6ccc2dde2882c78cac5ab43e74055c0"

URI_aarch64_rust-compact_str+bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+bytes-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-compact_str+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+bytes-devel}"
SRC_URI[aarch64_rust-compact_str+bytes-devel.sha256sum] = "c5fb3b37e6345e3521b791a3af0d5194c93b3fa7ba43fd35a64c3400974ec21a"

URI_aarch64_rust-compact_str+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+default-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-compact_str+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+default-devel}"
SRC_URI[aarch64_rust-compact_str+default-devel.sha256sum] = "271b7a7a639c1611cc01844bbac82e5fa43c5c233385b3ae31ea3bcbde5956ad"

URI_aarch64_rust-compact_str+proptest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+proptest-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-compact_str+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+proptest-devel}"
SRC_URI[aarch64_rust-compact_str+proptest-devel.sha256sum] = "fdb7572c3d64f97a53f3366a464f44384ae0e008a781272eedeb21faff851826"

URI_aarch64_rust-compact_str+quickcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+quickcheck-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-compact_str+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+quickcheck-devel}"
SRC_URI[aarch64_rust-compact_str+quickcheck-devel.sha256sum] = "979a8cc674ac0679e962f34f23b081575d38d4e2038639a13868be80f290d3e7"

URI_aarch64_rust-compact_str+rkyv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+rkyv-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-compact_str+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+rkyv-devel}"
SRC_URI[aarch64_rust-compact_str+rkyv-devel.sha256sum] = "02412631a1cda3402abaab32503d1471d35d705b40da49048e1a5076b1ee379d"

URI_aarch64_rust-compact_str+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+serde-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-compact_str+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+serde-devel}"
SRC_URI[aarch64_rust-compact_str+serde-devel.sha256sum] = "b82f0ad23229bddca3f9c06a7f426bafba752442f61b5297b2c051605029ed20"

URI_aarch64_rust-compact_str+smallvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+smallvec-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-compact_str+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+smallvec-devel}"
SRC_URI[aarch64_rust-compact_str+smallvec-devel.sha256sum] = "6223bbf9a35329623f8504b77aff14350788691b6be864244f1baeec3a639e18"

URI_aarch64_rust-compact_str+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+std-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-compact_str+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+std-devel}"
SRC_URI[aarch64_rust-compact_str+std-devel.sha256sum] = "5f2b6df79f6302f9d293bb21b0c7c66ca47c3daff558d0447c28cd12e7fefcf7"

URI_aarch64_rust-compact_str+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+zeroize-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-compact_str+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+zeroize-devel}"
SRC_URI[aarch64_rust-compact_str+zeroize-devel.sha256sum] = "c87f8da8bb05063afd50fd341d38a10c2bd0f99e97dc99b4df6bd8ac0d2d5ed0"

URI_aarch64_rust-compact_str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-compact_str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str-devel}"
SRC_URI[aarch64_rust-compact_str-devel.sha256sum] = "99030b888eff9551526f1fb85208c4a2aa0fde1c7830f45ea1721872fe302224"

RDEPENDS:rust-compact_str+arbitrary-devel = " \
 cargo \
 rust-arbitrary-devel \
 rust-compact_str-devel \
 "
RDEPENDS:rust-compact_str+bytes-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-compact_str-devel \
 "
RDEPENDS:rust-compact_str+default-devel = " \
 cargo \
 rust-compact_str+std-devel \
 rust-compact_str-devel \
 "
RDEPENDS:rust-compact_str+proptest-devel = " \
 cargo \
 rust-compact_str-devel \
 rust-proptest+std-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-compact_str+quickcheck-devel = " \
 cargo \
 rust-compact_str-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-compact_str+rkyv-devel = " \
 cargo \
 rust-compact_str-devel \
 rust-rkyv-devel \
 "
RDEPENDS:rust-compact_str+serde-devel = " \
 cargo \
 rust-compact_str-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-compact_str+smallvec-devel = " \
 cargo \
 rust-compact_str-devel \
 rust-smallvec+default-devel \
 rust-smallvec+union-devel \
 "
RDEPENDS:rust-compact_str+std-devel = " \
 cargo \
 rust-compact_str-devel \
 "
RDEPENDS:rust-compact_str+zeroize-devel = " \
 cargo \
 rust-compact_str-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-compact_str-devel = " \
 cargo \
 rust-castaway+alloc-devel \
 rust-castaway-devel \
 rust-cfg-if+default-devel \
 rust-itoa+default-devel \
 rust-rustversion+default-devel \
 rust-ryu+default-devel \
 rust-static_assertions+default-devel \
 "
