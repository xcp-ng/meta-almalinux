# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.12"
PV = "3.12.14"
PR = "1.el10"
PACKAGES = " \
 python-unversioned-command \
 python3 \
 python3-debug \
 python3-devel \
 python3-idle \
 python3-libs \
 python3-test \
 python3-tkinter \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python3.12-3.12.14-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b712ab28f2084e19eb04d943da78748a0d72f092ee0eeb787a63e843c65949e9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python-unversioned-command-3.12.14-1.el10.noarch.rpm;name=x86_64_v2_python-unversioned-command;unpack=0"
SRC_URI[x86_64_v2_python-unversioned-command.sha256sum] = "c5ddcb1f9b27a41f03b26f131379e7f5f20b8eb6c801c0f52a5b43a574f86208"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-3.12.14-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3;unpack=0"
SRC_URI[x86_64_v2_python3.sha256sum] = "4803a7c7aa19bde19060248dc08f4844785285cdfbc92e03edcb3805a2dc6aa1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-debug-3.12.14-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-debug;unpack=0"
SRC_URI[x86_64_v2_python3-debug.sha256sum] = "2100bb293a9273551ec086c31a26e15dfd45e5c43af862e2e7f4ddb6c2496743"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-devel-3.12.14-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-devel;unpack=0"
SRC_URI[x86_64_v2_python3-devel.sha256sum] = "34b8fc9acd2f9edf8fb9aae7d3be93f1cb3e5768ea68d19cddd8f597baa30ba1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-idle-3.12.14-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-idle;unpack=0"
SRC_URI[x86_64_v2_python3-idle.sha256sum] = "58537764220ca14c2fb44131658b77b983ef0bc539e947ada06536876fd330de"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-libs-3.12.14-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libs;unpack=0"
SRC_URI[x86_64_v2_python3-libs.sha256sum] = "45ecfd838851ba527b62c248751d1e5e0835fda356407c66ca7c6f64b3a5931b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-test-3.12.14-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-test;unpack=0"
SRC_URI[x86_64_v2_python3-test.sha256sum] = "5e3d8616fcf7f5fe46b70ab3e86c8daf0e2b347ecff22b2690f04b8110d0699c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-tkinter-3.12.14-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-tkinter;unpack=0"
SRC_URI[x86_64_v2_python3-tkinter.sha256sum] = "2f0d03d96dbdfb064dd969cec42c761f4d6dfb640161f3ddb52a7a16651c149f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python-unversioned-command-3.12.14-1.el10.noarch.rpm;name=aarch64_python-unversioned-command;unpack=0"
SRC_URI[aarch64_python-unversioned-command.sha256sum] = "c5ddcb1f9b27a41f03b26f131379e7f5f20b8eb6c801c0f52a5b43a574f86208"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-3.12.14-1.el10.aarch64.rpm;name=aarch64_python3;unpack=0"
SRC_URI[aarch64_python3.sha256sum] = "366842ff28360a4e65dfb7646639aad887d9a66d9c99d77a467bd44687f24657"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-debug-3.12.14-1.el10.aarch64.rpm;name=aarch64_python3-debug;unpack=0"
SRC_URI[aarch64_python3-debug.sha256sum] = "4df7ec677de514e62a3740c807cb7bd43239535182d055f5b55dab146486a61b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-devel-3.12.14-1.el10.aarch64.rpm;name=aarch64_python3-devel;unpack=0"
SRC_URI[aarch64_python3-devel.sha256sum] = "e698b422b474133593271c4081c0c2e0f8b557363a6119b0fad4d7ee35b8803b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-idle-3.12.14-1.el10.aarch64.rpm;name=aarch64_python3-idle;unpack=0"
SRC_URI[aarch64_python3-idle.sha256sum] = "52dedfd2691faa0789d38703640d2e889c23f8eb4a43d4b5335c35aa4233a5bb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-libs-3.12.14-1.el10.aarch64.rpm;name=aarch64_python3-libs;unpack=0"
SRC_URI[aarch64_python3-libs.sha256sum] = "8d51f48e8a4ec4dd5565b6dd69a464245fdb47390729d43b386cf499ad1cfba3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-test-3.12.14-1.el10.aarch64.rpm;name=aarch64_python3-test;unpack=0"
SRC_URI[aarch64_python3-test.sha256sum] = "88dfa3d937575b16c059a1a471d0763c010aa2cb38201d1194cbc9dfa1854470"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-tkinter-3.12.14-1.el10.aarch64.rpm;name=aarch64_python3-tkinter;unpack=0"
SRC_URI[aarch64_python3-tkinter.sha256sum] = "00bcc9dfdcee7a22e34609962044d133660782905b1d334f2230872db560044e"

RDEPENDS:python-unversioned-command = " \
 python3 \
 "
RDEPENDS:python3 = " \
 glibc \
 python3-libs \
 "
RDEPENDS:python3-debug = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libuuid \
 libxcrypt \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 pkgconf-pkg-config \
 python3 \
 python3-devel \
 python3-idle \
 python3-libs \
 python3-test \
 python3-tkinter \
 readline \
 sqlite-libs \
 tcl \
 tk \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3-devel = " \
 bash \
 pkgconf-pkg-config \
 python-rpm-macros \
 python3 \
 python3-libs \
 python3-rpm-generators \
 python3-rpm-macros \
 "
RDEPENDS:python3-idle = " \
 python3 \
 python3-tkinter \
 "
RDEPENDS:python3-libs = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libuuid \
 libxcrypt \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 python3-pip-wheel \
 readline \
 sqlite-libs \
 tzdata \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3-test = " \
 bash \
 glibc \
 python3 \
 python3-libs \
 python3-setuptools-wheel \
 python3-wheel-wheel \
 "
RDEPENDS:python3-tkinter = " \
 glibc \
 python3 \
 tcl \
 tk \
 "
