# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-asn1-parse"
PV = "0.9.5"
PR = "19.el10_0"
PACKAGES = " \
 ghc-asn1-parse \
 ghc-asn1-parse-devel \
 ghc-asn1-parse-doc \
 ghc-asn1-parse-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-asn1-parse-0.9.5-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "763a4ddd321837f025b3eb2b232b65d7904a22420190bbb5db3d181bf45256e1"

URI_x86_64_v2_ghc-asn1-parse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-asn1-parse-0.9.5-19.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-asn1-parse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-asn1-parse}"
SRC_URI[x86_64_v2_ghc-asn1-parse.sha256sum] = "8fe6041d4eb624b90a64202b16ee968cd81e070b2e730f4bfabe10b19db144b2"

URI_x86_64_v2_ghc-asn1-parse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-asn1-parse-devel-0.9.5-19.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-asn1-parse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-asn1-parse-devel}"
SRC_URI[x86_64_v2_ghc-asn1-parse-devel.sha256sum] = "134c47e5421c3081fb86406bdf81dc2623803d0552b77df19f0b6ab347c3fde7"

URI_x86_64_v2_ghc-asn1-parse-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-asn1-parse-doc-0.9.5-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-asn1-parse-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-asn1-parse-doc}"
SRC_URI[x86_64_v2_ghc-asn1-parse-doc.sha256sum] = "b212488b032650e26b40cc4cae9fb5f5df3d7ecdfab6a62b841a3ddb63919e42"

URI_x86_64_v2_ghc-asn1-parse-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-asn1-parse-prof-0.9.5-19.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-asn1-parse-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-asn1-parse-prof}"
SRC_URI[x86_64_v2_ghc-asn1-parse-prof.sha256sum] = "7495117769cb432e77fca4d794708adc821bf9368ac33aa35c76a513be438277"

URI_aarch64_ghc-asn1-parse = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-asn1-parse-0.9.5-19.el10_0.aarch64.rpm;name=aarch64_ghc-asn1-parse;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-asn1-parse}"
SRC_URI[aarch64_ghc-asn1-parse.sha256sum] = "197de55f135622c2f9a3437f02cce7a6eac876df9a505b9e27b030351035584d"

URI_aarch64_ghc-asn1-parse-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-asn1-parse-devel-0.9.5-19.el10_0.aarch64.rpm;name=aarch64_ghc-asn1-parse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-asn1-parse-devel}"
SRC_URI[aarch64_ghc-asn1-parse-devel.sha256sum] = "e67367ea9d538091838d4ee07cd1f59f468dbe6142c371c5eb8dca25758d8561"

URI_aarch64_ghc-asn1-parse-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-asn1-parse-doc-0.9.5-19.el10_0.noarch.rpm;name=aarch64_ghc-asn1-parse-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-asn1-parse-doc}"
SRC_URI[aarch64_ghc-asn1-parse-doc.sha256sum] = "ee9611ece5394748b72423608461c218de1aac6edec5ec66b650ef1839dd2636"

URI_aarch64_ghc-asn1-parse-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-asn1-parse-prof-0.9.5-19.el10_0.aarch64.rpm;name=aarch64_ghc-asn1-parse-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-asn1-parse-prof}"
SRC_URI[aarch64_ghc-asn1-parse-prof.sha256sum] = "bd0b494c3158e612a6b32729ebb0e026c7234b80010ea7bd41ea15b002222561"

RDEPENDS:ghc-asn1-parse = " \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-types \
 ghc-base \
 ghc-basement \
 ghc-bytestring \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hourglass \
 ghc-memory \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-asn1-parse-devel = " \
 ghc-asn1-encoding-devel \
 ghc-asn1-parse \
 ghc-asn1-types-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 "
RDEPENDS:ghc-asn1-parse-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-asn1-parse-prof = " \
 ghc-asn1-encoding-prof \
 ghc-asn1-parse-devel \
 ghc-asn1-types-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 "
