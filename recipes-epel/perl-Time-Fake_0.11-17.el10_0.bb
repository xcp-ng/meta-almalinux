# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Time-Fake"
PV = "0.11"
PR = "17.el10_0"
PACKAGES = " \
 perl-Time-Fake \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Time-Fake-0.11-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd7372c83ce1a9c7f1cddddb7832e7bc9978486fb93a0d20acc6c926d53e94d8"

URI_x86_64_v2_perl-Time-Fake = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Time-Fake-0.11-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Time-Fake;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Time-Fake}"
SRC_URI[x86_64_v2_perl-Time-Fake.sha256sum] = "6931331ec81f8a6366ef204dda60c5da58e456a77f18ade4edd18f52831cc278"

URI_aarch64_perl-Time-Fake = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Time-Fake-0.11-17.el10_0.noarch.rpm;name=aarch64_perl-Time-Fake;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Time-Fake}"
SRC_URI[aarch64_perl-Time-Fake.sha256sum] = "3656faea0f9e47fa266159b9e8493b8febd3a130e0050ad9c6c1cbb552592387"

RDEPENDS:perl-Time-Fake = " \
 perl-Carp \
 perl-libs \
 perl-vars \
 "
