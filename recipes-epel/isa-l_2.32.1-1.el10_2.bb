# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "isa-l"
PV = "2.32.1"
PR = "1.el10_2"
PACKAGES = " \
 isa-l \
 isa-l-devel \
 isa-l-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/isa-l-2.32.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "75532c39fa4f790568aee4cc90c92aca22a4d03c3feb57d0a5ef4b55b545f523"

URI_x86_64_v2_isa-l = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/isa-l-2.32.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_isa-l;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_isa-l}"
SRC_URI[x86_64_v2_isa-l.sha256sum] = "e6189fec89c9cdc082b58802ec0e2198bd5fbf8a7e1ade9fb01c7083ea590335"

URI_x86_64_v2_isa-l-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/isa-l-devel-2.32.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_isa-l-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_isa-l-devel}"
SRC_URI[x86_64_v2_isa-l-devel.sha256sum] = "682fd8c9f4378df762f26e9b64a244ecdc3c06ebd996ff50a8eaac1add336858"

URI_x86_64_v2_isa-l-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/isa-l-tools-2.32.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_isa-l-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_isa-l-tools}"
SRC_URI[x86_64_v2_isa-l-tools.sha256sum] = "8a893a5d72d73fb09b3a2a8816f3db3509f88600f51c942164ccdedb0d3b7ef8"

URI_aarch64_isa-l = "${EPEL_MIRROR}/aarch64/Packages/i/isa-l-2.32.1-1.el10_2.aarch64.rpm;name=aarch64_isa-l;unpack=0"
SRC_URI:append = " ${URI_aarch64_isa-l}"
SRC_URI[aarch64_isa-l.sha256sum] = "e16b4f184de3e058b1654aef89b131b507a2d78f9de2556cee8a176126938a6b"

URI_aarch64_isa-l-devel = "${EPEL_MIRROR}/aarch64/Packages/i/isa-l-devel-2.32.1-1.el10_2.aarch64.rpm;name=aarch64_isa-l-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_isa-l-devel}"
SRC_URI[aarch64_isa-l-devel.sha256sum] = "68490b3d97a6b4dd5bee3fe7c63c1dc7d72ab3608654fb8194848c361b62f6ad"

URI_aarch64_isa-l-tools = "${EPEL_MIRROR}/aarch64/Packages/i/isa-l-tools-2.32.1-1.el10_2.aarch64.rpm;name=aarch64_isa-l-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_isa-l-tools}"
SRC_URI[aarch64_isa-l-tools.sha256sum] = "e7ba653df5046b3288f0b304b89c2f62dabeb431f1dfa458be5961f8d67f907e"

RDEPENDS:isa-l = " \
 glibc \
 "
RDEPENDS:isa-l-devel = " \
 isa-l \
 pkgconf-pkg-config \
 "
RDEPENDS:isa-l-tools = " \
 glibc \
 isa-l \
 "
