# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-precomputed-hash"
PV = "0.1.1"
PR = "16.el10_0"
PACKAGES = " \
 rust-precomputed-hash+default-devel \
 rust-precomputed-hash-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-precomputed-hash-0.1.1-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e94b4420f0ea668c5642605defb4639a5a9951d1c16600030bdd13467c6955a2"

URI_x86_64_v2_rust-precomputed-hash+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-precomputed-hash+default-devel-0.1.1-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-precomputed-hash+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-precomputed-hash+default-devel}"
SRC_URI[x86_64_v2_rust-precomputed-hash+default-devel.sha256sum] = "363e6dc3bea8c8dffddb2c59a51788a7eb3ba28a3744f58848c70e3feb558a95"

URI_x86_64_v2_rust-precomputed-hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-precomputed-hash-devel-0.1.1-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-precomputed-hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-precomputed-hash-devel}"
SRC_URI[x86_64_v2_rust-precomputed-hash-devel.sha256sum] = "d2b3ae5d88a3ba80832538be07004c74491b88ff243d2cea550738fbc13cb401"

URI_aarch64_rust-precomputed-hash+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-precomputed-hash+default-devel-0.1.1-16.el10_0.noarch.rpm;name=aarch64_rust-precomputed-hash+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-precomputed-hash+default-devel}"
SRC_URI[aarch64_rust-precomputed-hash+default-devel.sha256sum] = "1c791ed002e4a9a0b08fdefc6fff2e2f93e1a8afcb3ae958d26d0ce6331fa901"

URI_aarch64_rust-precomputed-hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-precomputed-hash-devel-0.1.1-16.el10_0.noarch.rpm;name=aarch64_rust-precomputed-hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-precomputed-hash-devel}"
SRC_URI[aarch64_rust-precomputed-hash-devel.sha256sum] = "363b0751a191743897f39280010f07d86def3ab5d32c40245096c17d55624172"

RDEPENDS:rust-precomputed-hash+default-devel = " \
 cargo \
 rust-precomputed-hash-devel \
 "
RDEPENDS:rust-precomputed-hash-devel = " \
 cargo \
 "
