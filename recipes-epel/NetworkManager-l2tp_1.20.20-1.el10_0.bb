# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "NetworkManager-l2tp"
PV = "1.20.20"
PR = "1.el10_0"
PACKAGES = " \
 NetworkManager-l2tp \
 NetworkManager-l2tp-gnome \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/NetworkManager-l2tp-1.20.20-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a08feb73eb6e99dda99fe13255849d66f7e29621078af7dd5e5edf36246d63fa"

URI_x86_64_v2_NetworkManager-l2tp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/NetworkManager-l2tp-1.20.20-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-l2tp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-l2tp}"
SRC_URI[x86_64_v2_NetworkManager-l2tp.sha256sum] = "d684548045489c3ab860e448fc063808f1814622abb3279f53f6059d81feff53"

URI_x86_64_v2_NetworkManager-l2tp-gnome = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/NetworkManager-l2tp-gnome-1.20.20-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-l2tp-gnome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-l2tp-gnome}"
SRC_URI[x86_64_v2_NetworkManager-l2tp-gnome.sha256sum] = "ee08eb290ca76ef67793aa0314fc94b271c7764e0bedae76d323364607dbf3c5"

URI_aarch64_NetworkManager-l2tp = "${EPEL_MIRROR}/aarch64/Packages/n/NetworkManager-l2tp-1.20.20-1.el10_0.aarch64.rpm;name=aarch64_NetworkManager-l2tp;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-l2tp}"
SRC_URI[aarch64_NetworkManager-l2tp.sha256sum] = "93483b86d8ebc285c18e0f40d85d38e8b64f830ae5ec3cfb352e7fcad774a2d2"

URI_aarch64_NetworkManager-l2tp-gnome = "${EPEL_MIRROR}/aarch64/Packages/n/NetworkManager-l2tp-gnome-1.20.20-1.el10_0.aarch64.rpm;name=aarch64_NetworkManager-l2tp-gnome;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-l2tp-gnome}"
SRC_URI[aarch64_NetworkManager-l2tp-gnome.sha256sum] = "f657c8ea4b293d789ae4b9a246fdfd6c8e9a5795488ebae6d265b4597738573c"

RDEPENDS:NetworkManager-l2tp = " \
 NetworkManager \
 NetworkManager-libnm \
 bash \
 dbus-common \
 glib2 \
 glibc \
 libgcc \
 nspr \
 nss \
 openssl-libs \
 ppp \
 xl2tpd \
 "
RDEPENDS:NetworkManager-l2tp-gnome = " \
 NetworkManager-l2tp \
 NetworkManager-libnm \
 atk \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 graphene \
 gtk3 \
 gtk4 \
 harfbuzz \
 libgcc \
 libnma \
 libnma-gtk4 \
 libsecret \
 openssl-libs \
 pango \
 vulkan-loader \
 "
