# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-hcl"
PV = "1.1.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-tree-sitter-hcl+default-devel \
 rust-tree-sitter-hcl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-hcl-1.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd2dcd22b55e8a704a317a02bf66d8ca2233c5d73b44df36fdda1b6e407b324d"

URI_x86_64_v2_rust-tree-sitter-hcl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-hcl+default-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-hcl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-hcl+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-hcl+default-devel.sha256sum] = "fb46eeeec920199f0db40e0e50e3cb8c60bccc40c808a97103a8839a70d3f773"

URI_x86_64_v2_rust-tree-sitter-hcl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-hcl-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-hcl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-hcl-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-hcl-devel.sha256sum] = "3ae3176cf9b1933cec6f7e5ccac5fed0721272350c229891405da79d41293d69"

URI_aarch64_rust-tree-sitter-hcl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-hcl+default-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-hcl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-hcl+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-hcl+default-devel.sha256sum] = "0b8c14c52dbbe8daccacd579c21ac337fea97381d23f698ce7718fdd49b511cd"

URI_aarch64_rust-tree-sitter-hcl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-hcl-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-hcl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-hcl-devel}"
SRC_URI[aarch64_rust-tree-sitter-hcl-devel.sha256sum] = "245ebec242078e08e80c52cf635b1195cd49bcff3f3eb61fbca554411fcda700"

RDEPENDS:rust-tree-sitter-hcl+default-devel = " \
 cargo \
 rust-tree-sitter-hcl-devel \
 "
RDEPENDS:rust-tree-sitter-hcl-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
