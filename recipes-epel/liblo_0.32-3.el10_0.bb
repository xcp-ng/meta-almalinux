# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "liblo"
PV = "0.32"
PR = "3.el10_0"
PACKAGES = " \
 liblo \
 liblo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/liblo-0.32-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d23a79e32e7fd4359227f55e98ab6179d46e2ca2718e217c9d1cbc1ffb50334c"

URI_x86_64_v2_liblo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liblo-0.32-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liblo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liblo}"
SRC_URI[x86_64_v2_liblo.sha256sum] = "cac7a9f326dc75550fcd1f6e3c1fd8992225926b7ab5a3b0559c2f92987a38b6"

URI_x86_64_v2_liblo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liblo-devel-0.32-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liblo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liblo-devel}"
SRC_URI[x86_64_v2_liblo-devel.sha256sum] = "873b42307d92781172d1bf83be4b6a582205d517cec7bff489de1e24f8f5119e"

URI_aarch64_liblo = "${EPEL_MIRROR}/aarch64/Packages/l/liblo-0.32-3.el10_0.aarch64.rpm;name=aarch64_liblo;unpack=0"
SRC_URI:append = " ${URI_aarch64_liblo}"
SRC_URI[aarch64_liblo.sha256sum] = "b40b38ede2cec84d6e76fb8b948a21cce3937bd7a9993ddbe33c85980cdb5297"

URI_aarch64_liblo-devel = "${EPEL_MIRROR}/aarch64/Packages/l/liblo-devel-0.32-3.el10_0.aarch64.rpm;name=aarch64_liblo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_liblo-devel}"
SRC_URI[aarch64_liblo-devel.sha256sum] = "f34a86ac54171b8d45d2b379fc44018d101ccb72b77270170b6617fd7191b934"

RDEPENDS:liblo = " \
 glibc \
 "
RDEPENDS:liblo-devel = " \
 liblo \
 pkgconf-pkg-config \
 "
