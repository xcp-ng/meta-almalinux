# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sphinx-autobuild"
PV = "2024.10.03"
PR = "2.el10_1"
PACKAGES = " \
 python-sphinx-autobuild-doc \
 python3-sphinx-autobuild \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-sphinx-autobuild-2024.10.03-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "17d299d5e4d8052ca9a549b794afadf0a2c51cc4f654c4507557d055864c4d63"

URI_x86_64_v2_python-sphinx-autobuild-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-sphinx-autobuild-doc-2024.10.03-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-sphinx-autobuild-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-sphinx-autobuild-doc}"
SRC_URI[x86_64_v2_python-sphinx-autobuild-doc.sha256sum] = "c1fd0c24864874cb5f69d2009d51b69d70a4f42e31a7f256bf65b82e690ab66a"

URI_x86_64_v2_python3-sphinx-autobuild = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sphinx-autobuild-2024.10.03-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sphinx-autobuild;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sphinx-autobuild}"
SRC_URI[x86_64_v2_python3-sphinx-autobuild.sha256sum] = "4a2043a5fc9da8377a53adf3bd640096da6b22c9c9737b93c0a83fcd4cd6dc19"

URI_aarch64_python-sphinx-autobuild-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-sphinx-autobuild-doc-2024.10.03-2.el10_1.noarch.rpm;name=aarch64_python-sphinx-autobuild-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-sphinx-autobuild-doc}"
SRC_URI[aarch64_python-sphinx-autobuild-doc.sha256sum] = "5e27649cc4a9f1cc07011051bf421414f67ea330e677d247d1810037d945630f"

URI_aarch64_python3-sphinx-autobuild = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sphinx-autobuild-2024.10.03-2.el10_1.noarch.rpm;name=aarch64_python3-sphinx-autobuild;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sphinx-autobuild}"
SRC_URI[aarch64_python3-sphinx-autobuild.sha256sum] = "9f2ecd8a0de4aab3016bdaf6d68cf4e84f1ac829844eea326be94942cbdf1d30"

RDEPENDS:python-sphinx-autobuild-doc = " \
 "
RDEPENDS:python3-sphinx-autobuild = " \
 python3 \
 python3-colorama \
 python3-sphinx \
 python3-starlette \
 python3-uvicorn \
 python3-watchfiles \
 python3-websockets \
 "
