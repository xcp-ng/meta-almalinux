# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nwipe"
PV = "0.40"
PR = "4.el10_3"
PACKAGES = " \
 nwipe \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nwipe-0.40-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d602ec44d62e40f0dc98bbc42649c3809c4d3e86de33154a93a007d862af1cdf"

URI_x86_64_v2_nwipe = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nwipe-0.40-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nwipe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nwipe}"
SRC_URI[x86_64_v2_nwipe.sha256sum] = "2baa26e2196cb9a25f8e6e77c95df52a4002d41650e9e631ee84fb834640ba31"

URI_aarch64_nwipe = "${EPEL_MIRROR}/aarch64/Packages/n/nwipe-0.40-4.el10_3.aarch64.rpm;name=aarch64_nwipe;unpack=0"
SRC_URI:append = " ${URI_aarch64_nwipe}"
SRC_URI[aarch64_nwipe.sha256sum] = "bb873717db0fd36976a145cd30563760edeb04b54d66c1eff01e19cb578d0609"

RDEPENDS:nwipe = " \
 dmidecode \
 glibc \
 hdparm \
 kmod \
 libconfig \
 ncurses-libs \
 parted \
 smartmontools \
 virtual//usr/bin/readlink \
 "
