# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-netlink-packet-utils"
PV = "0.5.2"
PR = "8.el10_0"
PACKAGES = " \
 rust-netlink-packet-utils+default-devel \
 rust-netlink-packet-utils-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-netlink-packet-utils-0.5.2-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cacec52a82bef92126d2951350903ec135400425d461d835f241dd5bde702ec6"

URI_x86_64_v2_rust-netlink-packet-utils+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netlink-packet-utils+default-devel-0.5.2-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netlink-packet-utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netlink-packet-utils+default-devel}"
SRC_URI[x86_64_v2_rust-netlink-packet-utils+default-devel.sha256sum] = "23347ef08a412c3ee51e68a8a93635c81648c3587354b420243fe973332aa13d"

URI_x86_64_v2_rust-netlink-packet-utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netlink-packet-utils-devel-0.5.2-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netlink-packet-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netlink-packet-utils-devel}"
SRC_URI[x86_64_v2_rust-netlink-packet-utils-devel.sha256sum] = "5bfb1abf9d8b718fb8b143f5ef6400301921c1a088b1c84a6bcc98626bc50802"

URI_aarch64_rust-netlink-packet-utils+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netlink-packet-utils+default-devel-0.5.2-8.el10_0.noarch.rpm;name=aarch64_rust-netlink-packet-utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netlink-packet-utils+default-devel}"
SRC_URI[aarch64_rust-netlink-packet-utils+default-devel.sha256sum] = "aebeaee036d72bfe972160c7a9676eb576168bf170c8748037c5bb39a192b995"

URI_aarch64_rust-netlink-packet-utils-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netlink-packet-utils-devel-0.5.2-8.el10_0.noarch.rpm;name=aarch64_rust-netlink-packet-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netlink-packet-utils-devel}"
SRC_URI[aarch64_rust-netlink-packet-utils-devel.sha256sum] = "ae0b2ebdf91cce46a99c07c6311bfd71e7b4ca1c0889551f057e135c6877ee07"

RDEPENDS:rust-netlink-packet-utils+default-devel = " \
 cargo \
 rust-netlink-packet-utils-devel \
 "
RDEPENDS:rust-netlink-packet-utils-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-byteorder+default-devel \
 rust-paste+default-devel \
 rust-thiserror1+default-devel \
 "
