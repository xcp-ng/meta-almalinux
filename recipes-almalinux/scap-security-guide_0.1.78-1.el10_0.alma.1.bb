# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "scap-security-guide"
PV = "0.1.78"
PR = "1.el10_0.alma.1"
PACKAGES = " \
 scap-security-guide \
 scap-security-guide-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/scap-security-guide-0.1.78-1.el10_0.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ce34bbf57570157c4b6780a1e1bff8b40b9f2b58879765fe896cf5cc49bd476"

URI_x86_64_v2_scap-security-guide = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/scap-security-guide-0.1.78-1.el10_0.alma.1.noarch.rpm;name=x86_64_v2_scap-security-guide;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scap-security-guide}"
SRC_URI[x86_64_v2_scap-security-guide.sha256sum] = "17aee309303d08f76fd5a2a70d99a54278e2b7fb38e6e79cced490f94eefbe4d"

URI_x86_64_v2_scap-security-guide-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/scap-security-guide-doc-0.1.78-1.el10_0.alma.1.noarch.rpm;name=x86_64_v2_scap-security-guide-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scap-security-guide-doc}"
SRC_URI[x86_64_v2_scap-security-guide-doc.sha256sum] = "91ce9f8f18ec786e860d440d2684fbca9eeb9090339ccec5f36321a955b9a5a1"

URI_aarch64_scap-security-guide = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/scap-security-guide-0.1.78-1.el10_0.alma.1.noarch.rpm;name=aarch64_scap-security-guide;unpack=0"
SRC_URI:append = " ${URI_aarch64_scap-security-guide}"
SRC_URI[aarch64_scap-security-guide.sha256sum] = "17aee309303d08f76fd5a2a70d99a54278e2b7fb38e6e79cced490f94eefbe4d"

URI_aarch64_scap-security-guide-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/scap-security-guide-doc-0.1.78-1.el10_0.alma.1.noarch.rpm;name=aarch64_scap-security-guide-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_scap-security-guide-doc}"
SRC_URI[aarch64_scap-security-guide-doc.sha256sum] = "91ce9f8f18ec786e860d440d2684fbca9eeb9090339ccec5f36321a955b9a5a1"

RDEPENDS:scap-security-guide = " \
 openscap-scanner \
 xml-common \
 "
RDEPENDS:scap-security-guide-doc = " \
 scap-security-guide \
 "
