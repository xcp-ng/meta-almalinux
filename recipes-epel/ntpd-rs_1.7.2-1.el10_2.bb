# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ntpd-rs"
PV = "1.7.2"
PR = "1.el10_2"
PACKAGES = " \
 ntpd-rs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/ntpd-rs-1.7.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3e6fbfd5bf1aba49afe1ec56c435e0c799c703d6cf6575072de02789f1b9b1b"

URI_x86_64_v2_ntpd-rs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ntpd-rs-1.7.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ntpd-rs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ntpd-rs}"
SRC_URI[x86_64_v2_ntpd-rs.sha256sum] = "a255cc1164e2c87a667ee4f10c10006c6216019ab48fbd8373a722d13debdc3c"

URI_aarch64_ntpd-rs = "${EPEL_MIRROR}/aarch64/Packages/n/ntpd-rs-1.7.2-1.el10_2.aarch64.rpm;name=aarch64_ntpd-rs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ntpd-rs}"
SRC_URI[aarch64_ntpd-rs.sha256sum] = "0b4c240e4112d2efadfa3b174f0747f06205de913c21f1877d985b0c868a26b5"

RDEPENDS:ntpd-rs = " \
 bash \
 glibc \
 libgcc \
 systemd \
 "
