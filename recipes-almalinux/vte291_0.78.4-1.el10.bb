# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vte291"
PV = "0.78.4"
PR = "1.el10"
PACKAGES = " \
 vte-profile \
 vte291 \
 vte291-devel \
 vte291-gtk4 \
 vte291-gtk4-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/vte291-0.78.4-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b352a013dba563f467b4ffa3d8cdd30a8195644db9a94b3e64a034a16bef043"

URI_x86_64_v2_vte-profile = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vte-profile-0.78.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_vte-profile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vte-profile}"
SRC_URI[x86_64_v2_vte-profile.sha256sum] = "aca268303b04568f15043cb9f27e37a53a93fffa3356599bba0ce8eeb5a6cf0b"

URI_x86_64_v2_vte291 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vte291-0.78.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_vte291;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vte291}"
SRC_URI[x86_64_v2_vte291.sha256sum] = "3384e7ddb72bb90eb44fb0f228352bcc98d2e8a4f124e34b860b0a432237d491"

URI_x86_64_v2_vte291-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/vte291-devel-0.78.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_vte291-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vte291-devel}"
SRC_URI[x86_64_v2_vte291-devel.sha256sum] = "f0a6f028fb6918d1aad1ba4582f7eb0ca15baafc82c6625f790598f586a74067"

URI_x86_64_v2_vte291-gtk4 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vte291-gtk4-0.78.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_vte291-gtk4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vte291-gtk4}"
SRC_URI[x86_64_v2_vte291-gtk4.sha256sum] = "d22ddc0be8ec4dbdda0e8e49f5f3be9e5240778b72e2ec8772b1d649ebb9c60e"

URI_x86_64_v2_vte291-gtk4-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/vte291-gtk4-devel-0.78.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_vte291-gtk4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vte291-gtk4-devel}"
SRC_URI[x86_64_v2_vte291-gtk4-devel.sha256sum] = "aef45e3c2da80a10ca33cf538b1c68bc213062dc177c345681dcd90a4807e921"

URI_aarch64_vte-profile = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vte-profile-0.78.4-1.el10.aarch64.rpm;name=aarch64_vte-profile;unpack=0"
SRC_URI:append = " ${URI_aarch64_vte-profile}"
SRC_URI[aarch64_vte-profile.sha256sum] = "881e3bfe12a275b8cdb438f55ccaf5551004fe81c10f6a8ac609e23f9755fb90"

URI_aarch64_vte291 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vte291-0.78.4-1.el10.aarch64.rpm;name=aarch64_vte291;unpack=0"
SRC_URI:append = " ${URI_aarch64_vte291}"
SRC_URI[aarch64_vte291.sha256sum] = "78ef16b0aedd6b1704c2b3bff9e6288f9218abcfcd83a88c3390b72befaf79e8"

URI_aarch64_vte291-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/vte291-devel-0.78.4-1.el10.aarch64.rpm;name=aarch64_vte291-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vte291-devel}"
SRC_URI[aarch64_vte291-devel.sha256sum] = "849f48d751e0f47a58bd868fb10fcb39916f5571ec10fbfcb08d303aa766e6b0"

URI_aarch64_vte291-gtk4 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vte291-gtk4-0.78.4-1.el10.aarch64.rpm;name=aarch64_vte291-gtk4;unpack=0"
SRC_URI:append = " ${URI_aarch64_vte291-gtk4}"
SRC_URI[aarch64_vte291-gtk4.sha256sum] = "ac4ed01b7a79814290a4b0311299fa2ca9fd61de79c46480a13434670a55fe7f"

URI_aarch64_vte291-gtk4-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/vte291-gtk4-devel-0.78.4-1.el10.aarch64.rpm;name=aarch64_vte291-gtk4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vte291-gtk4-devel}"
SRC_URI[aarch64_vte291-gtk4-devel.sha256sum] = "76b5ff1cfc510c8fad5a73467f8780c679e1a176acf2013de0627276c01cb5e0"

RDEPENDS:vte-profile = " \
 glibc \
 "
RDEPENDS:vte291 = " \
 atk \
 cairo \
 cairo-gobject \
 fribidi \
 glib2 \
 glibc \
 gnutls \
 gtk3 \
 libgcc \
 libicu \
 libstdc++ \
 lz4-libs \
 pango \
 pcre2 \
 systemd-libs \
 vte-profile \
 "
RDEPENDS:vte291-devel = " \
 cairo \
 cairo-devel \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glib2-devel \
 glibc \
 gtk3 \
 gtk3-devel \
 libgcc \
 libstdc++ \
 pango \
 pango-devel \
 pkgconf-pkg-config \
 vte291 \
 "
RDEPENDS:vte291-gtk4 = " \
 cairo \
 cairo-gobject \
 fribidi \
 glib2 \
 glibc \
 gnutls \
 graphene \
 gtk4 \
 libgcc \
 libicu \
 libstdc++ \
 lz4-libs \
 pango \
 pcre2 \
 systemd-libs \
 vte291 \
 "
RDEPENDS:vte291-gtk4-devel = " \
 cairo \
 cairo-devel \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glib2-devel \
 glibc \
 gtk4 \
 gtk4-devel \
 libgcc \
 libstdc++ \
 pango \
 pango-devel \
 pkgconf-pkg-config \
 vte291-devel \
 vte291-gtk4 \
 "
