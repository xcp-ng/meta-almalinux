# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "os-prober"
PV = "1.81"
PR = "9.el10"
PACKAGES = " \
 os-prober \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/os-prober-1.81-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ba0ef05f338d7661a576902e0b93f410f6ab4b5cc9a015518f933d3f31e79b5c"

URI_x86_64_v2_os-prober = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/os-prober-1.81-9.el10.x86_64_v2.rpm;name=x86_64_v2_os-prober;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_os-prober}"
SRC_URI[x86_64_v2_os-prober.sha256sum] = "16de85db2f120376264313cbbf96315796157d6333a75b536dab554507b343bb"

URI_aarch64_os-prober = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/os-prober-1.81-9.el10.aarch64.rpm;name=aarch64_os-prober;unpack=0"
SRC_URI:append = " ${URI_aarch64_os-prober}"
SRC_URI[aarch64_os-prober.sha256sum] = "d113f2397b3f34f78c6043060e16dedb980b74904e04b75e0ea56a51c07a959f"

RDEPENDS:os-prober = " \
 bash \
 glibc \
 grep \
 grub2-tools-minimal \
 kmod \
 sed \
 systemd-udev \
 util-linux \
 virtual/coreutils \
 "
