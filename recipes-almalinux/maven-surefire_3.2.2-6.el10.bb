# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "maven-surefire"
PV = "3.2.2"
PR = "6.el10"
PACKAGES = " \
 maven-failsafe-plugin \
 maven-surefire \
 maven-surefire-javadoc \
 maven-surefire-plugin \
 maven-surefire-provider-junit \
 maven-surefire-provider-junit5 \
 maven-surefire-provider-testng \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/maven-surefire-3.2.2-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4153b4261c2cd9ca509c6ef65aafba01886d7be7413431dc99f049af0cebc9d0"

URI_x86_64_v2_maven-failsafe-plugin = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-failsafe-plugin-3.2.2-6.el10.noarch.rpm;name=x86_64_v2_maven-failsafe-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-failsafe-plugin}"
SRC_URI[x86_64_v2_maven-failsafe-plugin.sha256sum] = "6bc4ae9069da52ca99110fd8c535aee58fe3c3b74d9c68685e5cb13be70339b4"

URI_x86_64_v2_maven-surefire = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-surefire-3.2.2-6.el10.noarch.rpm;name=x86_64_v2_maven-surefire;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-surefire}"
SRC_URI[x86_64_v2_maven-surefire.sha256sum] = "a1f3e00a7aa6565cb43de073afd1c4aa66e1b647206421b3980a5d605ab13f6d"

URI_x86_64_v2_maven-surefire-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-surefire-javadoc-3.2.2-6.el10.noarch.rpm;name=x86_64_v2_maven-surefire-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-surefire-javadoc}"
SRC_URI[x86_64_v2_maven-surefire-javadoc.sha256sum] = "25715927aa8862be3e44fd9b80f4113b4037363b85eaa006564f79b11830beab"

URI_x86_64_v2_maven-surefire-plugin = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-surefire-plugin-3.2.2-6.el10.noarch.rpm;name=x86_64_v2_maven-surefire-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-surefire-plugin}"
SRC_URI[x86_64_v2_maven-surefire-plugin.sha256sum] = "25cf1e0911e637251330fb0c44d05d7b7a485da364b178d1a22d0e3227476a43"

URI_x86_64_v2_maven-surefire-provider-junit = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-surefire-provider-junit-3.2.2-6.el10.noarch.rpm;name=x86_64_v2_maven-surefire-provider-junit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-surefire-provider-junit}"
SRC_URI[x86_64_v2_maven-surefire-provider-junit.sha256sum] = "77e77a420b13ca33f160d7dcd66e559c6606d18326708e8e9231a52f1513fd5f"

URI_x86_64_v2_maven-surefire-provider-junit5 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-surefire-provider-junit5-3.2.2-6.el10.noarch.rpm;name=x86_64_v2_maven-surefire-provider-junit5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-surefire-provider-junit5}"
SRC_URI[x86_64_v2_maven-surefire-provider-junit5.sha256sum] = "ed075f11f73218cd4f61819d2ad203ae1525ae13dd008067aa55348656959d46"

URI_x86_64_v2_maven-surefire-provider-testng = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-surefire-provider-testng-3.2.2-6.el10.noarch.rpm;name=x86_64_v2_maven-surefire-provider-testng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-surefire-provider-testng}"
SRC_URI[x86_64_v2_maven-surefire-provider-testng.sha256sum] = "aa9d4e19c51dc3db226abac9086c07647d3acc6b5446450f20d90b77cc1cfb20"

URI_aarch64_maven-failsafe-plugin = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-failsafe-plugin-3.2.2-6.el10.noarch.rpm;name=aarch64_maven-failsafe-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-failsafe-plugin}"
SRC_URI[aarch64_maven-failsafe-plugin.sha256sum] = "6bc4ae9069da52ca99110fd8c535aee58fe3c3b74d9c68685e5cb13be70339b4"

URI_aarch64_maven-surefire = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-surefire-3.2.2-6.el10.noarch.rpm;name=aarch64_maven-surefire;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-surefire}"
SRC_URI[aarch64_maven-surefire.sha256sum] = "a1f3e00a7aa6565cb43de073afd1c4aa66e1b647206421b3980a5d605ab13f6d"

URI_aarch64_maven-surefire-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-surefire-javadoc-3.2.2-6.el10.noarch.rpm;name=aarch64_maven-surefire-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-surefire-javadoc}"
SRC_URI[aarch64_maven-surefire-javadoc.sha256sum] = "25715927aa8862be3e44fd9b80f4113b4037363b85eaa006564f79b11830beab"

URI_aarch64_maven-surefire-plugin = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-surefire-plugin-3.2.2-6.el10.noarch.rpm;name=aarch64_maven-surefire-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-surefire-plugin}"
SRC_URI[aarch64_maven-surefire-plugin.sha256sum] = "25cf1e0911e637251330fb0c44d05d7b7a485da364b178d1a22d0e3227476a43"

URI_aarch64_maven-surefire-provider-junit = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-surefire-provider-junit-3.2.2-6.el10.noarch.rpm;name=aarch64_maven-surefire-provider-junit;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-surefire-provider-junit}"
SRC_URI[aarch64_maven-surefire-provider-junit.sha256sum] = "77e77a420b13ca33f160d7dcd66e559c6606d18326708e8e9231a52f1513fd5f"

URI_aarch64_maven-surefire-provider-junit5 = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-surefire-provider-junit5-3.2.2-6.el10.noarch.rpm;name=aarch64_maven-surefire-provider-junit5;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-surefire-provider-junit5}"
SRC_URI[aarch64_maven-surefire-provider-junit5.sha256sum] = "ed075f11f73218cd4f61819d2ad203ae1525ae13dd008067aa55348656959d46"

URI_aarch64_maven-surefire-provider-testng = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-surefire-provider-testng-3.2.2-6.el10.noarch.rpm;name=aarch64_maven-surefire-provider-testng;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-surefire-provider-testng}"
SRC_URI[aarch64_maven-surefire-provider-testng.sha256sum] = "aa9d4e19c51dc3db226abac9086c07647d3acc6b5446450f20d90b77cc1cfb20"

RDEPENDS:maven-failsafe-plugin = " \
 javapackages-filesystem \
 maven-surefire \
 "
RDEPENDS:maven-surefire = " \
 apache-commons-compress \
 apache-commons-io \
 apache-commons-lang3 \
 javapackages-filesystem \
 maven-common-artifact-filters \
 maven-resolver \
 maven-shared-utils \
 plexus-languages \
 procps-ng \
 "
RDEPENDS:maven-surefire-javadoc = " \
 javapackages-filesystem \
 "
RDEPENDS:maven-surefire-plugin = " \
 javapackages-filesystem \
 maven-surefire \
 maven-surefire-provider-junit \
 maven-surefire-provider-junit5 \
 maven-surefire-provider-testng \
 "
RDEPENDS:maven-surefire-provider-junit = " \
 javapackages-filesystem \
 maven-surefire \
 "
RDEPENDS:maven-surefire-provider-junit5 = " \
 javapackages-filesystem \
 junit5 \
 maven-surefire \
 "
RDEPENDS:maven-surefire-provider-testng = " \
 javapackages-filesystem \
 maven-surefire \
 "
