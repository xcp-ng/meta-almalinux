# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdwarf"
PE = "1"
PV = "0.11.1"
PR = "2.el10_0"
PACKAGES = " \
 libdwarf \
 libdwarf-devel \
 libdwarf-static \
 libdwarf-tools \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libdwarf-0.11.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4467d42ea0370032a6e34f4256255138cb5c2139d6280ccf542271cb77448bec"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdwarf-0.11.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdwarf;unpack=0"
SRC_URI[x86_64_v2_libdwarf.sha256sum] = "c3e6ef04f5704e5664c3e4cb666f0eea9cd84e32a101788f701ab090149f61e1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdwarf-devel-0.11.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdwarf-devel;unpack=0"
SRC_URI[x86_64_v2_libdwarf-devel.sha256sum] = "ae5992de639915815a889eace921157168e3434b72f81ca47ce833cfc9f2b7f3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdwarf-static-0.11.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdwarf-static;unpack=0"
SRC_URI[x86_64_v2_libdwarf-static.sha256sum] = "6823a1fd0a2ffff5ec6ca9df540b714122f3674644076614a6d95512e6732c53"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdwarf-tools-0.11.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdwarf-tools;unpack=0"
SRC_URI[x86_64_v2_libdwarf-tools.sha256sum] = "288d34dafc969616e26f7ea36340eb7b06d117ae3fcd85bc1d189fce9877e298"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libdwarf-0.11.1-2.el10_0.aarch64.rpm;name=aarch64_libdwarf;unpack=0"
SRC_URI[aarch64_libdwarf.sha256sum] = "36564984c259d4a8477a8e4d8cf99eb763cfccc43b18aeec1eae198323fe464c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libdwarf-devel-0.11.1-2.el10_0.aarch64.rpm;name=aarch64_libdwarf-devel;unpack=0"
SRC_URI[aarch64_libdwarf-devel.sha256sum] = "66f9edbd89e3a2091b30c9a987026caf6c15f551efdd54411b9b424f677593bc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libdwarf-static-0.11.1-2.el10_0.aarch64.rpm;name=aarch64_libdwarf-static;unpack=0"
SRC_URI[aarch64_libdwarf-static.sha256sum] = "b4b938969a7e4147bbd03af6a3790c2a1e5691b301426948e8e355ad96c496d2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libdwarf-tools-0.11.1-2.el10_0.aarch64.rpm;name=aarch64_libdwarf-tools;unpack=0"
SRC_URI[aarch64_libdwarf-tools.sha256sum] = "c68ba4c08a4b91fa6f03dbacbf3bd84dd079a755abc75f9b646c18eee6ba9eb5"

RDEPENDS:libdwarf = " \
 glibc \
 "
RDEPENDS:libdwarf-devel = " \
 libdwarf \
 libzstd-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libdwarf-static = " \
 libdwarf-devel \
 "
RDEPENDS:libdwarf-tools = " \
 glibc \
 libdwarf \
 libgcc \
 libstdc++ \
 "
