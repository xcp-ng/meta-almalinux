# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-protocols-wlr"
PV = "0.3.12"
PR = "1.el10_3"
PACKAGES = " \
 rust-wayland-protocols-wlr+client-devel \
 rust-wayland-protocols-wlr+default-devel \
 rust-wayland-protocols-wlr+server-devel \
 rust-wayland-protocols-wlr+wayland-client-devel \
 rust-wayland-protocols-wlr+wayland-server-devel \
 rust-wayland-protocols-wlr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-protocols-wlr-0.3.12-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30cb9cd0aba7e003c2b630d757f36e0c9b32e43fe4d6e25a2636eec06ccfaa5e"

URI_x86_64_v2_rust-wayland-protocols-wlr+client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols-wlr+client-devel-0.3.12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols-wlr+client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols-wlr+client-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols-wlr+client-devel.sha256sum] = "3250cefec5d9c6eac69c4a416f1cebb7df85f9623933ae7509974329f6da3875"

URI_x86_64_v2_rust-wayland-protocols-wlr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols-wlr+default-devel-0.3.12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols-wlr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols-wlr+default-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols-wlr+default-devel.sha256sum] = "eebf359c59a6ae5f781664b36dd1eb59957b58dcc67c169a1c61f3ca678fa90b"

URI_x86_64_v2_rust-wayland-protocols-wlr+server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols-wlr+server-devel-0.3.12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols-wlr+server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols-wlr+server-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols-wlr+server-devel.sha256sum] = "04bb693bf3999df1ddaaed9a7dec6e6f72903fbd95a5ddc7774fed532a4ad39e"

URI_x86_64_v2_rust-wayland-protocols-wlr+wayland-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols-wlr+wayland-client-devel-0.3.12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols-wlr+wayland-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols-wlr+wayland-client-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols-wlr+wayland-client-devel.sha256sum] = "054b6a5991c3f0393690a764bef27e3ba9de345817acaf28a920563f9e1b78b2"

URI_x86_64_v2_rust-wayland-protocols-wlr+wayland-server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols-wlr+wayland-server-devel-0.3.12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols-wlr+wayland-server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols-wlr+wayland-server-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols-wlr+wayland-server-devel.sha256sum] = "59bc48be6bf17382e24b30a314f8ac8735bec89b860723ab1b7a99ad5b8d1e60"

URI_x86_64_v2_rust-wayland-protocols-wlr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols-wlr-devel-0.3.12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols-wlr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols-wlr-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols-wlr-devel.sha256sum] = "a1ed6c4d968762f77617214fd79f3bb9dcf580ec5262b281a895002fd1f2b130"

URI_aarch64_rust-wayland-protocols-wlr+client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols-wlr+client-devel-0.3.12-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-protocols-wlr+client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols-wlr+client-devel}"
SRC_URI[aarch64_rust-wayland-protocols-wlr+client-devel.sha256sum] = "c58e2f1598f5129a98c31c2769c48cd851bbbccbd941074ad9cd00c582a00dfb"

URI_aarch64_rust-wayland-protocols-wlr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols-wlr+default-devel-0.3.12-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-protocols-wlr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols-wlr+default-devel}"
SRC_URI[aarch64_rust-wayland-protocols-wlr+default-devel.sha256sum] = "0a1c23aa5516f8d32216e95a6f37e98c795872cd7eaebdd92a468a7bfdb7f995"

URI_aarch64_rust-wayland-protocols-wlr+server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols-wlr+server-devel-0.3.12-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-protocols-wlr+server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols-wlr+server-devel}"
SRC_URI[aarch64_rust-wayland-protocols-wlr+server-devel.sha256sum] = "e4ead4587fb126dd1aed89e7d05abe1795b82409ba93f055b34f2c3a5f8b9d93"

URI_aarch64_rust-wayland-protocols-wlr+wayland-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols-wlr+wayland-client-devel-0.3.12-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-protocols-wlr+wayland-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols-wlr+wayland-client-devel}"
SRC_URI[aarch64_rust-wayland-protocols-wlr+wayland-client-devel.sha256sum] = "53e8f9fa2978888830bd60271d676718d7824cbf1b74e916bca98b6d35853e31"

URI_aarch64_rust-wayland-protocols-wlr+wayland-server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols-wlr+wayland-server-devel-0.3.12-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-protocols-wlr+wayland-server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols-wlr+wayland-server-devel}"
SRC_URI[aarch64_rust-wayland-protocols-wlr+wayland-server-devel.sha256sum] = "3aa9471c760b7ceababcb2a294b26a9f4d79ede1f60bd2378a98899301933410"

URI_aarch64_rust-wayland-protocols-wlr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols-wlr-devel-0.3.12-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-protocols-wlr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols-wlr-devel}"
SRC_URI[aarch64_rust-wayland-protocols-wlr-devel.sha256sum] = "cc07b92ebe98e3fd5752adb7a73172d8faa880e79ced601820e922194f801cfa"

RDEPENDS:rust-wayland-protocols-wlr+client-devel = " \
 cargo \
 rust-wayland-protocols+client-devel \
 rust-wayland-protocols-wlr+wayland-client-devel \
 rust-wayland-protocols-wlr-devel \
 "
RDEPENDS:rust-wayland-protocols-wlr+default-devel = " \
 cargo \
 rust-wayland-protocols-wlr-devel \
 "
RDEPENDS:rust-wayland-protocols-wlr+server-devel = " \
 cargo \
 rust-wayland-protocols+server-devel \
 rust-wayland-protocols-wlr+wayland-server-devel \
 rust-wayland-protocols-wlr-devel \
 "
RDEPENDS:rust-wayland-protocols-wlr+wayland-client-devel = " \
 cargo \
 rust-wayland-client+default-devel \
 rust-wayland-protocols-wlr-devel \
 "
RDEPENDS:rust-wayland-protocols-wlr+wayland-server-devel = " \
 cargo \
 rust-wayland-protocols-wlr-devel \
 rust-wayland-server+default-devel \
 "
RDEPENDS:rust-wayland-protocols-wlr-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-wayland-backend+default-devel \
 rust-wayland-protocols+default-devel \
 rust-wayland-scanner+default-devel \
 "
