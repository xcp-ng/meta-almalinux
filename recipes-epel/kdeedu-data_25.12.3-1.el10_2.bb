# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdeedu-data"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kdeedu-data \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdeedu-data-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80391beca789b561ce0fe362d23753543d529a9ae5f05cc2d34299a2e89067c9"

URI_x86_64_v2_kdeedu-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdeedu-data-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kdeedu-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdeedu-data}"
SRC_URI[x86_64_v2_kdeedu-data.sha256sum] = "17b9f19f1b3a5ab2d52a502194da4f3b44148b460640aef7cf73c5b488eca079"

URI_aarch64_kdeedu-data = "${EPEL_MIRROR}/aarch64/Packages/k/kdeedu-data-25.12.3-1.el10_2.noarch.rpm;name=aarch64_kdeedu-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdeedu-data}"
SRC_URI[aarch64_kdeedu-data.sha256sum] = "80795f0ef71c89bc85044d02ff7bd55fc61a25fc8eee9d879fec75f01da70bf0"

RDEPENDS:kdeedu-data = " \
 hicolor-icon-theme \
 "
