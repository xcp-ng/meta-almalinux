# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Config-IniFiles"
PV = "3.001000"
PR = "1.el10_3"
PACKAGES = " \
 perl-Config-IniFiles \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Config-IniFiles-3.001000-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2464d1d69a49757a818b247fad58f483cdf02b9dc4d66a46a1587ff2d961ee3c"

URI_x86_64_v2_perl-Config-IniFiles = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Config-IniFiles-3.001000-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Config-IniFiles;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Config-IniFiles}"
SRC_URI[x86_64_v2_perl-Config-IniFiles.sha256sum] = "dd54eb4a4d6170e3313c4f1b1083f132df186dd6e869c2940ae54b58a8b94c65"

URI_aarch64_perl-Config-IniFiles = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Config-IniFiles-3.001000-1.el10_3.noarch.rpm;name=aarch64_perl-Config-IniFiles;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Config-IniFiles}"
SRC_URI[aarch64_perl-Config-IniFiles.sha256sum] = "dfd6718add0ecd07f28c372a48962ed50dbb8e66f45ebf41fb76a6bb54a33531"

RDEPENDS:perl-Config-IniFiles = " \
 perl-Carp \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Temp \
 perl-IO-stringy \
 perl-Scalar-List-Utils \
 perl-Symbol \
 perl-libs \
 perl-vars \
 "
