# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-godbus-dbus"
PV = "5.1.0"
PR = "6.el10_0"
PACKAGES = " \
 compat-golang-github-godbus-dbus-5-devel \
 golang-github-godbus-dbus-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-godbus-dbus-5.1.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c235b3e27cad34e311f15321a42f564d69d58aaf5acd785195ccfcbc614e18f5"

URI_x86_64_v2_compat-golang-github-godbus-dbus-5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/compat-golang-github-godbus-dbus-5-devel-5.1.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_compat-golang-github-godbus-dbus-5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_compat-golang-github-godbus-dbus-5-devel}"
SRC_URI[x86_64_v2_compat-golang-github-godbus-dbus-5-devel.sha256sum] = "f5da66260a10ece6bdef8cfe4c3fcefb3e33dfbc6b3e66616e37935c3721c1e7"

URI_x86_64_v2_golang-github-godbus-dbus-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-godbus-dbus-devel-5.1.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-godbus-dbus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-godbus-dbus-devel}"
SRC_URI[x86_64_v2_golang-github-godbus-dbus-devel.sha256sum] = "aee2e388fc706eacce6c65cee6082e9f6862d5070db7e8ecc54b86a51d51ace6"

URI_aarch64_compat-golang-github-godbus-dbus-5-devel = "${EPEL_MIRROR}/aarch64/Packages/c/compat-golang-github-godbus-dbus-5-devel-5.1.0-6.el10_0.noarch.rpm;name=aarch64_compat-golang-github-godbus-dbus-5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_compat-golang-github-godbus-dbus-5-devel}"
SRC_URI[aarch64_compat-golang-github-godbus-dbus-5-devel.sha256sum] = "d385728d4168d33f496ab74c7e8c2e207014790e8c4e46027ef8454288532229"

URI_aarch64_golang-github-godbus-dbus-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-godbus-dbus-devel-5.1.0-6.el10_0.noarch.rpm;name=aarch64_golang-github-godbus-dbus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-godbus-dbus-devel}"
SRC_URI[aarch64_golang-github-godbus-dbus-devel.sha256sum] = "c4356a7121fdc12583c7afbc9cea547436fc6de0be3984f4ec516948d9757b50"

RDEPENDS:compat-golang-github-godbus-dbus-5-devel = " \
 go-filesystem \
 golang-github-godbus-dbus-devel \
 "
RDEPENDS:golang-github-godbus-dbus-devel = " \
 go-filesystem \
 "
