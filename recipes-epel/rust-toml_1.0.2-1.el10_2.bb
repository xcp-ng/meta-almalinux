# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-toml"
PV = "1.0.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-toml+debug-devel \
 rust-toml+default-devel \
 rust-toml+display-devel \
 rust-toml+fast_hash-devel \
 rust-toml+parse-devel \
 rust-toml+preserve_order-devel \
 rust-toml+serde-devel \
 rust-toml+std-devel \
 rust-toml+unbounded-devel \
 rust-toml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-toml-1.0.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "76ce438adf3530e3cc1767d66b4b19904672d66421b87fc045e0fa5b078854ba"

URI_x86_64_v2_rust-toml+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+debug-devel-1.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml+debug-devel}"
SRC_URI[x86_64_v2_rust-toml+debug-devel.sha256sum] = "399072546188360003045df6b0df9f6a3be49a90d9bdc3b32f052a85191f72bb"

URI_x86_64_v2_rust-toml+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+default-devel-1.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml+default-devel}"
SRC_URI[x86_64_v2_rust-toml+default-devel.sha256sum] = "4465a59cb17eca55428e639655ad674f87ec5512a37d10b526048bd4f44f7850"

URI_x86_64_v2_rust-toml+display-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+display-devel-1.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+display-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml+display-devel}"
SRC_URI[x86_64_v2_rust-toml+display-devel.sha256sum] = "7c4ea7b49381cb284c989e0d72a2a21757831da1ccdc167591ead78dedee3bb2"

URI_x86_64_v2_rust-toml+fast_hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+fast_hash-devel-1.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+fast_hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml+fast_hash-devel}"
SRC_URI[x86_64_v2_rust-toml+fast_hash-devel.sha256sum] = "ae30b8d9fb57b31a159de80a18ab83505d3f28dc0f151b8f62e40064ffc29b0a"

URI_x86_64_v2_rust-toml+parse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+parse-devel-1.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+parse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml+parse-devel}"
SRC_URI[x86_64_v2_rust-toml+parse-devel.sha256sum] = "f72aaf732f836a6dbc4a9cc712e4aa8c3fb295e165c53efe872f97d18ff1e595"

URI_x86_64_v2_rust-toml+preserve_order-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+preserve_order-devel-1.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml+preserve_order-devel}"
SRC_URI[x86_64_v2_rust-toml+preserve_order-devel.sha256sum] = "197ad0b981bbdcb610f269c17d651886d7eff6b6ede05060249b139fcbdd0881"

URI_x86_64_v2_rust-toml+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+serde-devel-1.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml+serde-devel}"
SRC_URI[x86_64_v2_rust-toml+serde-devel.sha256sum] = "7aa0e57e60499551a5dddd5b81753035b574dff786882ce6274f00ef3d9bbec3"

URI_x86_64_v2_rust-toml+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+std-devel-1.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml+std-devel}"
SRC_URI[x86_64_v2_rust-toml+std-devel.sha256sum] = "d0191d22d4a34fd00ee0d973d28497038b1377d488bf7f10b61b09ded7c00a03"

URI_x86_64_v2_rust-toml+unbounded-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+unbounded-devel-1.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+unbounded-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml+unbounded-devel}"
SRC_URI[x86_64_v2_rust-toml+unbounded-devel.sha256sum] = "3df4964123706cbd5d1e3cd594132d5f0dcce1c2a9758160f08bd2aeae60c414"

URI_x86_64_v2_rust-toml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml-devel-1.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml-devel}"
SRC_URI[x86_64_v2_rust-toml-devel.sha256sum] = "15ebdd87da8a3bb88a8322011a999b35061af212a68f2c5f76686935b423a5ab"

URI_aarch64_rust-toml+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+debug-devel-1.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-toml+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml+debug-devel}"
SRC_URI[aarch64_rust-toml+debug-devel.sha256sum] = "af596a0db3f4c23fd3aac5937b15d40ff1e016bb0544c624dc523ff3225dbb94"

URI_aarch64_rust-toml+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+default-devel-1.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-toml+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml+default-devel}"
SRC_URI[aarch64_rust-toml+default-devel.sha256sum] = "18c588043b0b47c694ea36d8a701acd33035ec5e80a6fec33bb2fb51c6c64cad"

URI_aarch64_rust-toml+display-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+display-devel-1.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-toml+display-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml+display-devel}"
SRC_URI[aarch64_rust-toml+display-devel.sha256sum] = "4a1fe38f60560caf0493cf181d97e530e88e243ee25464984822a645c21c1549"

URI_aarch64_rust-toml+fast_hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+fast_hash-devel-1.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-toml+fast_hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml+fast_hash-devel}"
SRC_URI[aarch64_rust-toml+fast_hash-devel.sha256sum] = "da49ac5473eaf56f224862b11adb5e9d8ffb97f8cf42de658c4ef9fc32582c5f"

URI_aarch64_rust-toml+parse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+parse-devel-1.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-toml+parse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml+parse-devel}"
SRC_URI[aarch64_rust-toml+parse-devel.sha256sum] = "448b0a0af2c15dd32f14c30ba5efb7f510630f1f5079111896a4d68aaa9a4fbe"

URI_aarch64_rust-toml+preserve_order-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+preserve_order-devel-1.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-toml+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml+preserve_order-devel}"
SRC_URI[aarch64_rust-toml+preserve_order-devel.sha256sum] = "0ef74115c9dcea20b20138363fda16bf4e5c5e4a20dfe9e46429dd93a120aa76"

URI_aarch64_rust-toml+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+serde-devel-1.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-toml+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml+serde-devel}"
SRC_URI[aarch64_rust-toml+serde-devel.sha256sum] = "9c9ec777c9b132875de0ac86e0b672203f3eda18c0abdab00e4ebd27fd98f652"

URI_aarch64_rust-toml+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+std-devel-1.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-toml+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml+std-devel}"
SRC_URI[aarch64_rust-toml+std-devel.sha256sum] = "399b92d36b6fb7ac1ad7192f588d00f4e035b4c9dd035283eafc679a589e2383"

URI_aarch64_rust-toml+unbounded-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+unbounded-devel-1.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-toml+unbounded-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml+unbounded-devel}"
SRC_URI[aarch64_rust-toml+unbounded-devel.sha256sum] = "327271f184ad11ea07b677ad09b79dd902d97ff6746e72b86c81de3fd57efbd4"

URI_aarch64_rust-toml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml-devel-1.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-toml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml-devel}"
SRC_URI[aarch64_rust-toml-devel.sha256sum] = "fafe4349d09a71a31ba1f2984c165fe0231c456d9d14bcd0248219505c486907"

RDEPENDS:rust-toml+debug-devel = " \
 cargo \
 rust-anstream0.6+default-devel \
 rust-anstyle+default-devel \
 rust-toml+std-devel \
 rust-toml-devel \
 rust-toml_parser+alloc-devel \
 rust-toml_parser+debug-devel \
 rust-toml_parser-devel \
 "
RDEPENDS:rust-toml+default-devel = " \
 cargo \
 rust-toml+display-devel \
 rust-toml+parse-devel \
 rust-toml+serde-devel \
 rust-toml+std-devel \
 rust-toml-devel \
 "
RDEPENDS:rust-toml+display-devel = " \
 cargo \
 rust-toml-devel \
 rust-toml_writer+alloc-devel \
 rust-toml_writer-devel \
 "
RDEPENDS:rust-toml+fast_hash-devel = " \
 cargo \
 rust-foldhash-devel \
 rust-toml+preserve_order-devel \
 rust-toml-devel \
 "
RDEPENDS:rust-toml+parse-devel = " \
 cargo \
 rust-toml-devel \
 rust-toml_parser+alloc-devel \
 rust-toml_parser-devel \
 rust-winnow-devel \
 "
RDEPENDS:rust-toml+preserve_order-devel = " \
 cargo \
 rust-indexmap-devel \
 rust-toml+std-devel \
 rust-toml-devel \
 "
RDEPENDS:rust-toml+serde-devel = " \
 cargo \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 rust-serde_spanned+serde-devel \
 rust-toml-devel \
 rust-toml_datetime+serde-devel \
 "
RDEPENDS:rust-toml+std-devel = " \
 cargo \
 rust-indexmap+std-devel \
 rust-indexmap-devel \
 rust-serde_core+alloc-devel \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 rust-serde_spanned+std-devel \
 rust-toml-devel \
 rust-toml_datetime+std-devel \
 rust-toml_parser+alloc-devel \
 rust-toml_parser+std-devel \
 rust-toml_parser-devel \
 rust-toml_writer+alloc-devel \
 rust-toml_writer+std-devel \
 rust-toml_writer-devel \
 "
RDEPENDS:rust-toml+unbounded-devel = " \
 cargo \
 rust-toml-devel \
 "
RDEPENDS:rust-toml-devel = " \
 cargo \
 rust \
 rust-serde_spanned+alloc-devel \
 rust-serde_spanned-devel \
 rust-toml_datetime+alloc-devel \
 rust-toml_datetime-devel \
 "
