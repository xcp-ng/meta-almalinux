# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-openstackdocstheme"
PV = "3.5.0"
PR = "1.el10_3"
PACKAGES = " \
 python-openstackdocstheme-doc \
 python3-openstackdocstheme \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-openstackdocstheme-3.5.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "03e0fb5dc8c05034e9cfe52b6c511e1b1fda4adb6d27561be98e9ff0ae194cc6"

URI_x86_64_v2_python-openstackdocstheme-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-openstackdocstheme-doc-3.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-openstackdocstheme-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-openstackdocstheme-doc}"
SRC_URI[x86_64_v2_python-openstackdocstheme-doc.sha256sum] = "63fd5efb8de91bc086321408b93fd0601b1575417e0ca0535d0bf4084ba1bf92"

URI_x86_64_v2_python3-openstackdocstheme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-openstackdocstheme-3.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-openstackdocstheme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-openstackdocstheme}"
SRC_URI[x86_64_v2_python3-openstackdocstheme.sha256sum] = "0ccdb7d0867b7f13a046d65a3ba54fd8061f06684cc2b570795135ff47a3416b"

URI_aarch64_python-openstackdocstheme-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-openstackdocstheme-doc-3.5.0-1.el10_3.noarch.rpm;name=aarch64_python-openstackdocstheme-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-openstackdocstheme-doc}"
SRC_URI[aarch64_python-openstackdocstheme-doc.sha256sum] = "9b562d5676352f489460cdf5fc93a9fe4b27e3f97497db7ed63908599e414060"

URI_aarch64_python3-openstackdocstheme = "${EPEL_MIRROR}/aarch64/Packages/p/python3-openstackdocstheme-3.5.0-1.el10_3.noarch.rpm;name=aarch64_python3-openstackdocstheme;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-openstackdocstheme}"
SRC_URI[aarch64_python3-openstackdocstheme.sha256sum] = "c1df1d720af701f9354c4e85486830cc6834898cfa011fcaa3f3a889ae2bcf36"

RDEPENDS:python-openstackdocstheme-doc = " \
 "
RDEPENDS:python3-openstackdocstheme = " \
 bash \
 python3 \
 python3-babel \
 python3-dulwich \
 python3-pbr \
 python3-sphinx \
 "
