# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "radcli"
PV = "1.4.0"
PR = "3.el10_0"
PACKAGES = " \
 radcli \
 radcli-compat-devel \
 radcli-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/radcli-1.4.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee68f9a8a0c3b3fa1a95a0e21e77ab2b01d47364e38f3c44ac2f67a6da700211"

URI_x86_64_v2_radcli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radcli-1.4.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_radcli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_radcli}"
SRC_URI[x86_64_v2_radcli.sha256sum] = "b2ac0ba9f17956c5079e08b56b6ef42288b08d98096682d29775c7a94ae7ace5"

URI_x86_64_v2_radcli-compat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radcli-compat-devel-1.4.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_radcli-compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_radcli-compat-devel}"
SRC_URI[x86_64_v2_radcli-compat-devel.sha256sum] = "2e91b7a231b74167fb5f60ae3ca1013b45b40a1814c75f8e3823c5b7cdf2ef32"

URI_x86_64_v2_radcli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radcli-devel-1.4.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_radcli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_radcli-devel}"
SRC_URI[x86_64_v2_radcli-devel.sha256sum] = "fa4a21cc5409745825e908fddbd775b862c4bb84a877fcee75f97615dcc147cd"

URI_aarch64_radcli = "${EPEL_MIRROR}/aarch64/Packages/r/radcli-1.4.0-3.el10_0.aarch64.rpm;name=aarch64_radcli;unpack=0"
SRC_URI:append = " ${URI_aarch64_radcli}"
SRC_URI[aarch64_radcli.sha256sum] = "a6474d57815a778c9e76527eea059ee07deb51f4bb5aebb179dfaf8b05ad079c"

URI_aarch64_radcli-compat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/radcli-compat-devel-1.4.0-3.el10_0.aarch64.rpm;name=aarch64_radcli-compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_radcli-compat-devel}"
SRC_URI[aarch64_radcli-compat-devel.sha256sum] = "1afef46cc5165a16ee80086d9535a00a786dfbd0940cde9712ea6734322651f4"

URI_aarch64_radcli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/radcli-devel-1.4.0-3.el10_0.aarch64.rpm;name=aarch64_radcli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_radcli-devel}"
SRC_URI[aarch64_radcli-devel.sha256sum] = "a3af26d6988833a8e3b9742da528f351c04389ad060cd256e65b3228f3d40926"

RDEPENDS:radcli = " \
 glibc \
 gnutls \
 nettle \
 "
RDEPENDS:radcli-compat-devel = " \
 radcli-devel \
 "
RDEPENDS:radcli-devel = " \
 gnutls-devel \
 nettle-devel \
 pkgconf-pkg-config \
 radcli \
 "
