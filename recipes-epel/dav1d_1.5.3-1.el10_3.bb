# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dav1d"
PV = "1.5.3"
PR = "1.el10_3"
PACKAGES = " \
 dav1d \
 libdav1d \
 libdav1d-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dav1d-1.5.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c69fc400b9e85ed49a3aadc6389b812a5c7eefe55dbb716526b3127e275fb731"

URI_x86_64_v2_dav1d = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dav1d-1.5.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dav1d;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dav1d}"
SRC_URI[x86_64_v2_dav1d.sha256sum] = "5278edd0b2e3c3a22ab141e8d0e43107445cb4d106ac192100d7b6f4857ac0a9"

URI_x86_64_v2_libdav1d = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdav1d-1.5.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdav1d;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdav1d}"
SRC_URI[x86_64_v2_libdav1d.sha256sum] = "9567624fae8bc1605c39f810d66a12261d9e4bbddc468464b66293cf03cd17d2"

URI_x86_64_v2_libdav1d-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdav1d-devel-1.5.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdav1d-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdav1d-devel}"
SRC_URI[x86_64_v2_libdav1d-devel.sha256sum] = "ba6f99de126275ae94769a1bf636b1d63642356715c77391d22a66a179e9c9b5"

URI_aarch64_dav1d = "${EPEL_MIRROR}/aarch64/Packages/d/dav1d-1.5.3-1.el10_3.aarch64.rpm;name=aarch64_dav1d;unpack=0"
SRC_URI:append = " ${URI_aarch64_dav1d}"
SRC_URI[aarch64_dav1d.sha256sum] = "0ac32abf288d92b1b0c368ceeda4ed58cced7f1888bf660517ae5513bf874ca9"

URI_aarch64_libdav1d = "${EPEL_MIRROR}/aarch64/Packages/l/libdav1d-1.5.3-1.el10_3.aarch64.rpm;name=aarch64_libdav1d;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdav1d}"
SRC_URI[aarch64_libdav1d.sha256sum] = "aeffced9da7f792fab2ce366b538864add7874297968ae4ca2ea784f3df9dc8d"

URI_aarch64_libdav1d-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libdav1d-devel-1.5.3-1.el10_3.aarch64.rpm;name=aarch64_libdav1d-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdav1d-devel}"
SRC_URI[aarch64_libdav1d-devel.sha256sum] = "5bd2fb8b2c49ecf18089bd6be8ca0564d34040cd082b3038b00fee76d29f167f"

RDEPENDS:dav1d = " \
 glibc \
 libdav1d \
 "
RDEPENDS:libdav1d = " \
 glibc \
 "
RDEPENDS:libdav1d-devel = " \
 libdav1d \
 pkgconf-pkg-config \
 "
