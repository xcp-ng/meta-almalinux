# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-charset"
PV = "0.1.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-charset+default-devel \
 rust-charset+serde-devel \
 rust-charset-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-charset-0.1.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9279ba2a4817471986c7d9ac6eb68ad9d5e37bdcd2778b806969c9bc4d0a28ed"

URI_x86_64_v2_rust-charset+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-charset+default-devel-0.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-charset+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-charset+default-devel}"
SRC_URI[x86_64_v2_rust-charset+default-devel.sha256sum] = "078a1ea79e64ab52672f50f7d4f460fafa19735efbc0d8df2d059c126f111ce1"

URI_x86_64_v2_rust-charset+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-charset+serde-devel-0.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-charset+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-charset+serde-devel}"
SRC_URI[x86_64_v2_rust-charset+serde-devel.sha256sum] = "7feb10820a0e9df34dc05a098389c824ec2c3f23e5a358042c701fa6629b350e"

URI_x86_64_v2_rust-charset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-charset-devel-0.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-charset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-charset-devel}"
SRC_URI[x86_64_v2_rust-charset-devel.sha256sum] = "77b0d7761c3e563d4f34a9675ce81028332a3d827144fc749080099a5040a7e7"

URI_aarch64_rust-charset+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-charset+default-devel-0.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-charset+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-charset+default-devel}"
SRC_URI[aarch64_rust-charset+default-devel.sha256sum] = "6564c56d6c36fdd9cf3ef83dd99045526cd58590fa76b126e6a14f2051fb9363"

URI_aarch64_rust-charset+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-charset+serde-devel-0.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-charset+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-charset+serde-devel}"
SRC_URI[aarch64_rust-charset+serde-devel.sha256sum] = "b4b11c5fa7fc3949521d00cadcea6e110c56b0c4b807af7797812b2c8d5853b8"

URI_aarch64_rust-charset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-charset-devel-0.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-charset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-charset-devel}"
SRC_URI[aarch64_rust-charset-devel.sha256sum] = "5ea806ab06c1fb3fb46eaad72cb4552f055acd3e47763989fc128cad1552e847"

RDEPENDS:rust-charset+default-devel = " \
 cargo \
 rust-charset-devel \
 "
RDEPENDS:rust-charset+serde-devel = " \
 cargo \
 rust-charset-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-charset-devel = " \
 cargo \
 rust \
 rust-base64-devel \
 rust-encoding_rs+default-devel \
 "
