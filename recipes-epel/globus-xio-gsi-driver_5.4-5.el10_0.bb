# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-xio-gsi-driver"
PV = "5.4"
PR = "5.el10_0"
PACKAGES = " \
 globus-xio-gsi-driver \
 globus-xio-gsi-driver-devel \
 globus-xio-gsi-driver-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-xio-gsi-driver-5.4-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b85d5df89b1b4dce16818847421aa171f766ff503c739c027c99aa0dbb984f14"

URI_x86_64_v2_globus-xio-gsi-driver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-xio-gsi-driver-5.4-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-xio-gsi-driver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-xio-gsi-driver}"
SRC_URI[x86_64_v2_globus-xio-gsi-driver.sha256sum] = "7fe7bc99670519482e9479105522594f35f3d603c897768e9405f494196fd53a"

URI_x86_64_v2_globus-xio-gsi-driver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-xio-gsi-driver-devel-5.4-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-xio-gsi-driver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-xio-gsi-driver-devel}"
SRC_URI[x86_64_v2_globus-xio-gsi-driver-devel.sha256sum] = "4391a0a12476215d06618f5805422a1686a1e8fada4b055e36de3e1dd91a5e42"

URI_x86_64_v2_globus-xio-gsi-driver-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-xio-gsi-driver-doc-5.4-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-xio-gsi-driver-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-xio-gsi-driver-doc}"
SRC_URI[x86_64_v2_globus-xio-gsi-driver-doc.sha256sum] = "2d3db2d70eb88ec91e00c8d0a13517fc6edf02baf9d671a7ec5c099378407a52"

URI_aarch64_globus-xio-gsi-driver = "${EPEL_MIRROR}/aarch64/Packages/g/globus-xio-gsi-driver-5.4-5.el10_0.aarch64.rpm;name=aarch64_globus-xio-gsi-driver;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-xio-gsi-driver}"
SRC_URI[aarch64_globus-xio-gsi-driver.sha256sum] = "740d9ab245f751c2829b1cfceb8baa2a9df9f00dab1e35f4c7d3529468453e49"

URI_aarch64_globus-xio-gsi-driver-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-xio-gsi-driver-devel-5.4-5.el10_0.aarch64.rpm;name=aarch64_globus-xio-gsi-driver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-xio-gsi-driver-devel}"
SRC_URI[aarch64_globus-xio-gsi-driver-devel.sha256sum] = "610c70ee2c24647bee0a0308bd6e58dacc12cf5bbb16c0d4327dc6043c520943"

URI_aarch64_globus-xio-gsi-driver-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-xio-gsi-driver-doc-5.4-5.el10_0.noarch.rpm;name=aarch64_globus-xio-gsi-driver-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-xio-gsi-driver-doc}"
SRC_URI[aarch64_globus-xio-gsi-driver-doc.sha256sum] = "eeeee971671cf3e1a7290e8701180f8e844ca8032b5490102ec0732b6fdc2d2c"

RDEPENDS:globus-xio-gsi-driver = " \
 glibc \
 globus-common \
 globus-gss-assist \
 globus-gssapi-error \
 globus-gssapi-gsi \
 globus-xio \
 "
RDEPENDS:globus-xio-gsi-driver-devel = " \
 globus-common-devel \
 globus-gss-assist-devel \
 globus-gssapi-error-devel \
 globus-gssapi-gsi-devel \
 globus-xio-devel \
 globus-xio-gsi-driver \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-xio-gsi-driver-doc = " \
 "
