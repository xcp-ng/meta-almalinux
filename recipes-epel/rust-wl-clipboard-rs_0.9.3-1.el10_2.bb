# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wl-clipboard-rs"
PV = "0.9.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-wl-clipboard-rs+default-devel \
 rust-wl-clipboard-rs+dlopen-devel \
 rust-wl-clipboard-rs+native_lib-devel \
 rust-wl-clipboard-rs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wl-clipboard-rs-0.9.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1902150d4ddac5c2feba0d385978b999673f7c39ba03c90638b1b20f7b4f234b"

URI_x86_64_v2_rust-wl-clipboard-rs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wl-clipboard-rs+default-devel-0.9.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wl-clipboard-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wl-clipboard-rs+default-devel}"
SRC_URI[x86_64_v2_rust-wl-clipboard-rs+default-devel.sha256sum] = "7276121f64abba4b8f89490516db5e9ef877806abfa1b9e156104df7532392f8"

URI_x86_64_v2_rust-wl-clipboard-rs+dlopen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wl-clipboard-rs+dlopen-devel-0.9.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wl-clipboard-rs+dlopen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wl-clipboard-rs+dlopen-devel}"
SRC_URI[x86_64_v2_rust-wl-clipboard-rs+dlopen-devel.sha256sum] = "d3cfbaa60a75a87adb67c4577fee192f2e4dd2b3df519c88f69cb259a4900922"

URI_x86_64_v2_rust-wl-clipboard-rs+native_lib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wl-clipboard-rs+native_lib-devel-0.9.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wl-clipboard-rs+native_lib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wl-clipboard-rs+native_lib-devel}"
SRC_URI[x86_64_v2_rust-wl-clipboard-rs+native_lib-devel.sha256sum] = "57e0b8929329f43130ed6eb31069b462838a9e5119e6228922f179ff4f15478d"

URI_x86_64_v2_rust-wl-clipboard-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wl-clipboard-rs-devel-0.9.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wl-clipboard-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wl-clipboard-rs-devel}"
SRC_URI[x86_64_v2_rust-wl-clipboard-rs-devel.sha256sum] = "a9353e681d584d103cd0ab644a6238b544e6d7bcde29de28fbf242a2437a1998"

URI_aarch64_rust-wl-clipboard-rs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wl-clipboard-rs+default-devel-0.9.3-1.el10_2.noarch.rpm;name=aarch64_rust-wl-clipboard-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wl-clipboard-rs+default-devel}"
SRC_URI[aarch64_rust-wl-clipboard-rs+default-devel.sha256sum] = "3fbe8d4c8d5bcdfe15c9acad55429c87819166f3afa5758c51bddeb0534a7491"

URI_aarch64_rust-wl-clipboard-rs+dlopen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wl-clipboard-rs+dlopen-devel-0.9.3-1.el10_2.noarch.rpm;name=aarch64_rust-wl-clipboard-rs+dlopen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wl-clipboard-rs+dlopen-devel}"
SRC_URI[aarch64_rust-wl-clipboard-rs+dlopen-devel.sha256sum] = "0cf354690e5f05cab799646f315df77b56e56fd96283a05da0c414faa16f83b1"

URI_aarch64_rust-wl-clipboard-rs+native_lib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wl-clipboard-rs+native_lib-devel-0.9.3-1.el10_2.noarch.rpm;name=aarch64_rust-wl-clipboard-rs+native_lib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wl-clipboard-rs+native_lib-devel}"
SRC_URI[aarch64_rust-wl-clipboard-rs+native_lib-devel.sha256sum] = "b334c85070c3cfe7cb4541951c40e2e2915e8e51d5725624ae9f9393dcf26617"

URI_aarch64_rust-wl-clipboard-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wl-clipboard-rs-devel-0.9.3-1.el10_2.noarch.rpm;name=aarch64_rust-wl-clipboard-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wl-clipboard-rs-devel}"
SRC_URI[aarch64_rust-wl-clipboard-rs-devel.sha256sum] = "a98715fec3f75e9df3baef33c81239659fce42854715664c2a5edbc47cb03bff"

RDEPENDS:rust-wl-clipboard-rs+default-devel = " \
 cargo \
 rust-wl-clipboard-rs-devel \
 "
RDEPENDS:rust-wl-clipboard-rs+dlopen-devel = " \
 cargo \
 rust-wayland-backend+dlopen-devel \
 rust-wl-clipboard-rs+native_lib-devel \
 rust-wl-clipboard-rs-devel \
 "
RDEPENDS:rust-wl-clipboard-rs+native_lib-devel = " \
 cargo \
 rust-wayland-backend+client_system-devel \
 rust-wayland-backend+server_system-devel \
 rust-wl-clipboard-rs-devel \
 "
RDEPENDS:rust-wl-clipboard-rs-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-log+default-devel \
 rust-os_pipe+default-devel \
 rust-os_pipe+io_safety-devel \
 rust-rustix+default-devel \
 rust-rustix+event-devel \
 rust-rustix+fs-devel \
 rust-thiserror+default-devel \
 rust-tree_magic_mini+default-devel \
 rust-wayland-backend+default-devel \
 rust-wayland-client+default-devel \
 rust-wayland-protocols+client-devel \
 rust-wayland-protocols+default-devel \
 rust-wayland-protocols+staging-devel \
 rust-wayland-protocols-wlr+client-devel \
 rust-wayland-protocols-wlr+default-devel \
 "
