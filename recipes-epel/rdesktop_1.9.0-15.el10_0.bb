# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rdesktop"
PV = "1.9.0"
PR = "15.el10_0"
PACKAGES = " \
 rdesktop \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rdesktop-1.9.0-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "310ec2bfaed4140f0f8f1ac550bc3ce724ca9040dd1ff966698b04a526ebf079"

URI_x86_64_v2_rdesktop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rdesktop-1.9.0-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rdesktop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rdesktop}"
SRC_URI[x86_64_v2_rdesktop.sha256sum] = "71c9098fafe7b0607c54aae84503b836af135c3f3cac359eccda4a25b52def81"

URI_aarch64_rdesktop = "${EPEL_MIRROR}/aarch64/Packages/r/rdesktop-1.9.0-15.el10_0.aarch64.rpm;name=aarch64_rdesktop;unpack=0"
SRC_URI:append = " ${URI_aarch64_rdesktop}"
SRC_URI[aarch64_rdesktop.sha256sum] = "5120ba80c37aabbaa85f3b2efa07e196f7b3a413c64611b54ab353be0728a762"

RDEPENDS:rdesktop = " \
 glibc \
 gmp \
 gnutls \
 krb5-libs \
 libX11 \
 libXcursor \
 libXrandr \
 libtasn1 \
 nettle \
 pcsc-lite-libs \
 pulseaudio-libs \
 "
