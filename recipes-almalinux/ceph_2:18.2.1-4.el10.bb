# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ceph"
PE = "2"
PV = "18.2.1"
PR = "4.el10"
PACKAGES = " \
 librados-devel \
 librados2 \
 libradospp-devel \
 librbd-devel \
 librbd1 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ceph-18.2.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "773a66bb491ddb52699240fa315a18e8e9cfe12538e88d35285b7cafcd89b8bd"

URI_x86_64_v2_librados-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/librados-devel-18.2.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_librados-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librados-devel}"
SRC_URI[x86_64_v2_librados-devel.sha256sum] = "8622b2d06ddade2e3abbb40ca731c01f7005928a47f253e42d5cb0c011920de4"

URI_x86_64_v2_librados2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/librados2-18.2.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_librados2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librados2}"
SRC_URI[x86_64_v2_librados2.sha256sum] = "34aa1ba4b11bff010eb691ae9c72b379f60d3bc03ab5c9d3bc2a60a940323cb0"

URI_x86_64_v2_libradospp-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libradospp-devel-18.2.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_libradospp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libradospp-devel}"
SRC_URI[x86_64_v2_libradospp-devel.sha256sum] = "6088e721342c8fbcc9698237e6520f9b9686efc920c50bcb3181fc9b7da5aaef"

URI_x86_64_v2_librbd-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/librbd-devel-18.2.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_librbd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librbd-devel}"
SRC_URI[x86_64_v2_librbd-devel.sha256sum] = "a6dbf94d0794ebd5ba5afb0fc46878b1b6aeead3f5900cb2520ecb5613a1937a"

URI_x86_64_v2_librbd1 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/librbd1-18.2.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_librbd1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librbd1}"
SRC_URI[x86_64_v2_librbd1.sha256sum] = "ec049fa004352e9b26360e783b3368dd8cbc80e16ff57daa3aefa582dc740b2d"

URI_aarch64_librados-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/librados-devel-18.2.1-4.el10.aarch64.rpm;name=aarch64_librados-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_librados-devel}"
SRC_URI[aarch64_librados-devel.sha256sum] = "9dba381db49c0fefb99eb519c82fd96bb3be11046ca8211a405c770357fe7490"

URI_aarch64_librados2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/librados2-18.2.1-4.el10.aarch64.rpm;name=aarch64_librados2;unpack=0"
SRC_URI:append = " ${URI_aarch64_librados2}"
SRC_URI[aarch64_librados2.sha256sum] = "d8573ab49ca28101c78b03669c56e3974494d3eea9d5daf7fa594698614f3a96"

URI_aarch64_libradospp-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libradospp-devel-18.2.1-4.el10.aarch64.rpm;name=aarch64_libradospp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libradospp-devel}"
SRC_URI[aarch64_libradospp-devel.sha256sum] = "95241d2ecdd28e8ed921714a6d0558b6843dfa71bbeb07aa4bb891b7a3e650b6"

URI_aarch64_librbd-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/librbd-devel-18.2.1-4.el10.aarch64.rpm;name=aarch64_librbd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_librbd-devel}"
SRC_URI[aarch64_librbd-devel.sha256sum] = "e771033e59878d423493f9283bdb2baa49af5cac8caf3add5ce6147491fbae2d"

URI_aarch64_librbd1 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/librbd1-18.2.1-4.el10.aarch64.rpm;name=aarch64_librbd1;unpack=0"
SRC_URI:append = " ${URI_aarch64_librbd1}"
SRC_URI[aarch64_librbd1.sha256sum] = "40c1a765ca62d4fd2d6bbb9e0b3a46184e2589e246fc3d19dc63c7ce68634709"

RDEPENDS:librados-devel = " \
 glibc \
 libgcc \
 librados2 \
 libstdc++ \
 "
RDEPENDS:librados2 = " \
 glibc \
 libblkid \
 libgcc \
 libibverbs \
 librdmacm \
 libstdc++ \
 openssl-libs \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:libradospp-devel = " \
 librados-devel \
 librados2 \
 "
RDEPENDS:librbd-devel = " \
 librados-devel \
 libradospp-devel \
 librbd1 \
 "
RDEPENDS:librbd1 = " \
 cryptsetup-libs \
 glibc \
 libgcc \
 librados2 \
 libstdc++ \
 openssl-libs \
 "
