# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-typetag-impl"
PV = "0.2.21"
PR = "1.el10_2"
PACKAGES = " \
 rust-typetag-impl+default-devel \
 rust-typetag-impl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-typetag-impl-0.2.21-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f5b64d88a263f5c2151b7c6d5ab8e1a95fa2f0960582ecae9bba3b6d1854754"

URI_x86_64_v2_rust-typetag-impl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typetag-impl+default-devel-0.2.21-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typetag-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typetag-impl+default-devel}"
SRC_URI[x86_64_v2_rust-typetag-impl+default-devel.sha256sum] = "c7b723adf29126c18147adcc5306c759ddc019da46f6f3b18c27d510b3405925"

URI_x86_64_v2_rust-typetag-impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typetag-impl-devel-0.2.21-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typetag-impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typetag-impl-devel}"
SRC_URI[x86_64_v2_rust-typetag-impl-devel.sha256sum] = "d6c93097da906911468dea7b70de4b33940fc9f9b914892a440eb25658b28212"

URI_aarch64_rust-typetag-impl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typetag-impl+default-devel-0.2.21-1.el10_2.noarch.rpm;name=aarch64_rust-typetag-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typetag-impl+default-devel}"
SRC_URI[aarch64_rust-typetag-impl+default-devel.sha256sum] = "617f4aa2a910275e33009d010b6214b883e4bbbf73a65b88ab2fdd225db90f00"

URI_aarch64_rust-typetag-impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typetag-impl-devel-0.2.21-1.el10_2.noarch.rpm;name=aarch64_rust-typetag-impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typetag-impl-devel}"
SRC_URI[aarch64_rust-typetag-impl-devel.sha256sum] = "81e8c2dcaae1b897dd6ae8328dc8cbc016f2023ee3e0366006ef1b06f2062d1d"

RDEPENDS:rust-typetag-impl+default-devel = " \
 cargo \
 rust-typetag-impl-devel \
 "
RDEPENDS:rust-typetag-impl-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
