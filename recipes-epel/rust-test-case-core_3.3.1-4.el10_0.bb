# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-test-case-core"
PV = "3.3.1"
PR = "4.el10_0"
PACKAGES = " \
 rust-test-case-core+default-devel \
 rust-test-case-core+with-regex-devel \
 rust-test-case-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-test-case-core-3.3.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "97b18ada205af6325ea21bbdc6fc23d30b4ac04eaaec2d2f60bd9dbcf1378fd4"

URI_x86_64_v2_rust-test-case-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-case-core+default-devel-3.3.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-case-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-case-core+default-devel}"
SRC_URI[x86_64_v2_rust-test-case-core+default-devel.sha256sum] = "f4a35e95202d1dbf0fed595c7383539a631b331801eed07366d85cd11d0f4f8d"

URI_x86_64_v2_rust-test-case-core+with-regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-case-core+with-regex-devel-3.3.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-case-core+with-regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-case-core+with-regex-devel}"
SRC_URI[x86_64_v2_rust-test-case-core+with-regex-devel.sha256sum] = "ed733a3e0684dccc5150a5a018afb5e4736e7ef8d040b3418524586a5765e364"

URI_x86_64_v2_rust-test-case-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-case-core-devel-3.3.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-case-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-case-core-devel}"
SRC_URI[x86_64_v2_rust-test-case-core-devel.sha256sum] = "7576d70ea97e339f285d8bce19ad08ad4fcb78e5794bea2546d7511d9c6c8f85"

URI_aarch64_rust-test-case-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-case-core+default-devel-3.3.1-4.el10_0.noarch.rpm;name=aarch64_rust-test-case-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-case-core+default-devel}"
SRC_URI[aarch64_rust-test-case-core+default-devel.sha256sum] = "746d70d86cc2453fd58852b74a12b7d386dfd2bfe7beb2d57606a71a3d994f3c"

URI_aarch64_rust-test-case-core+with-regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-case-core+with-regex-devel-3.3.1-4.el10_0.noarch.rpm;name=aarch64_rust-test-case-core+with-regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-case-core+with-regex-devel}"
SRC_URI[aarch64_rust-test-case-core+with-regex-devel.sha256sum] = "fb7ca3de7f1c356eb15122ca7015d4e686fc0a74065ef1f7ffda18e25f7adffd"

URI_aarch64_rust-test-case-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-case-core-devel-3.3.1-4.el10_0.noarch.rpm;name=aarch64_rust-test-case-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-case-core-devel}"
SRC_URI[aarch64_rust-test-case-core-devel.sha256sum] = "67efa65047d02f8bf7f1ac10b217bf16ad0a8f6c8a7b96e39f6905581fc8fcf6"

RDEPENDS:rust-test-case-core+default-devel = " \
 cargo \
 rust-test-case-core-devel \
 "
RDEPENDS:rust-test-case-core+with-regex-devel = " \
 cargo \
 rust-test-case-core-devel \
 "
RDEPENDS:rust-test-case-core-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+full-devel \
 "
