# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap-num"
PV = "1.2.0"
PR = "2.el10_2"
PACKAGES = " \
 rust-clap-num+default-devel \
 rust-clap-num-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap-num-1.2.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a1c111b9b5435ffc007b3ef8042aba3053d08683097e2922b930b4fa5467c674"

URI_x86_64_v2_rust-clap-num+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap-num+default-devel-1.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap-num+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap-num+default-devel}"
SRC_URI[x86_64_v2_rust-clap-num+default-devel.sha256sum] = "c1c78ebacfef789117fb02012f8d44948095258358bd43fc4032862b90f22aa2"

URI_x86_64_v2_rust-clap-num-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap-num-devel-1.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap-num-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap-num-devel}"
SRC_URI[x86_64_v2_rust-clap-num-devel.sha256sum] = "ea8ebcb1a47c1e30f7efddcb7b67cc6ed1ef2fdd45fef864b9458dc8825622cf"

URI_aarch64_rust-clap-num+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap-num+default-devel-1.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-clap-num+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap-num+default-devel}"
SRC_URI[aarch64_rust-clap-num+default-devel.sha256sum] = "3e41ec57c2cc85fd5cbbf636509bff749bc9b212149f766a081cc672ee2c48f7"

URI_aarch64_rust-clap-num-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap-num-devel-1.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-clap-num-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap-num-devel}"
SRC_URI[aarch64_rust-clap-num-devel.sha256sum] = "64a17b08b7e5fd562a047621fc2b06afc3de169e43fa2da84755c078fc01372e"

RDEPENDS:rust-clap-num+default-devel = " \
 cargo \
 rust-clap-num-devel \
 "
RDEPENDS:rust-clap-num-devel = " \
 cargo \
 rust-num-traits+default-devel \
 "
