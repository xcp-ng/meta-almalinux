# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-shell-escape"
PV = "0.1.5"
PR = "12.el10_0"
PACKAGES = " \
 rust-shell-escape+default-devel \
 rust-shell-escape-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-shell-escape-0.1.5-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d863b5f84fd962a368d3fd0673a2593750e573ee4a5debd6d4d0862d3c7936e4"

URI_x86_64_v2_rust-shell-escape+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shell-escape+default-devel-0.1.5-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shell-escape+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shell-escape+default-devel}"
SRC_URI[x86_64_v2_rust-shell-escape+default-devel.sha256sum] = "0bc8e14fa956ef5064e1067e2210b4041fa2f73c9c3353046888d4ab3deeecf6"

URI_x86_64_v2_rust-shell-escape-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shell-escape-devel-0.1.5-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shell-escape-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shell-escape-devel}"
SRC_URI[x86_64_v2_rust-shell-escape-devel.sha256sum] = "94ec70f6ce317eff4bb773282f0f9c6a1f7c159ac84b65179104109c8c40ab53"

URI_aarch64_rust-shell-escape+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shell-escape+default-devel-0.1.5-12.el10_0.noarch.rpm;name=aarch64_rust-shell-escape+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shell-escape+default-devel}"
SRC_URI[aarch64_rust-shell-escape+default-devel.sha256sum] = "fbc6ab0980ce145e82de662d2e9658bfaca2d2209c520f130dd60dae921ea3ea"

URI_aarch64_rust-shell-escape-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shell-escape-devel-0.1.5-12.el10_0.noarch.rpm;name=aarch64_rust-shell-escape-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shell-escape-devel}"
SRC_URI[aarch64_rust-shell-escape-devel.sha256sum] = "3eba37dcde1cb13c55c68dca2c8589d40b02def78101c40e9163067df9755fa5"

RDEPENDS:rust-shell-escape+default-devel = " \
 cargo \
 rust-shell-escape-devel \
 "
RDEPENDS:rust-shell-escape-devel = " \
 cargo \
 "
