# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "suricata"
PV = "8.0.5"
PR = "1.el10_2"
PACKAGES = " \
 suricata \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/suricata-8.0.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c3fd40c2438950021ef397e5c09ee0320ae44e49553a20911cae7a159c67dcc"

URI_x86_64_v2_suricata = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/suricata-8.0.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_suricata;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_suricata}"
SRC_URI[x86_64_v2_suricata.sha256sum] = "77bdc0b99d1924a3367489660b238b57c549f5fddc58162261fab3260c4ca790"

URI_aarch64_suricata = "${EPEL_MIRROR}/aarch64/Packages/s/suricata-8.0.5-1.el10_2.aarch64.rpm;name=aarch64_suricata;unpack=0"
SRC_URI:append = " ${URI_aarch64_suricata}"
SRC_URI[aarch64_suricata.sha256sum] = "0d5dd284c7c8f5c8eb120e99f64a17da1a2a300bc10aaaaaca421ebc50d62604"

RDEPENDS:suricata:x86_64_v2 = " \
 bash \
 file-libs \
 glibc \
 hiredis \
 jansson \
 libcap-ng \
 libevent \
 libgcc \
 libmaxminddb \
 libnet \
 libnetfilter_queue \
 libnfnetlink \
 libpcap \
 libyaml \
 lz4-libs \
 pcre2 \
 python3 \
 python3-pyyaml \
 shadow-utils \
 systemd \
 vectorscan \
 zlib-ng-compat \
"
RDEPENDS:suricata:aarch64 = " \
 bash \
 file-libs \
 glibc \
 hiredis \
 jansson \
 libcap-ng \
 libevent \
 libgcc \
 libmaxminddb \
 libnet \
 libnetfilter_queue \
 libnfnetlink \
 libpcap \
 libyaml \
 lz4-libs \
 pcre2 \
 python3 \
 python3-pyyaml \
 shadow-utils \
 systemd \
 zlib-ng-compat \
"
