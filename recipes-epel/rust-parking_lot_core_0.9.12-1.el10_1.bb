# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-parking_lot_core"
PV = "0.9.12"
PR = "1.el10_1"
PACKAGES = " \
 rust-parking_lot_core+backtrace-devel \
 rust-parking_lot_core+deadlock_detection-devel \
 rust-parking_lot_core+default-devel \
 rust-parking_lot_core+nightly-devel \
 rust-parking_lot_core+petgraph-devel \
 rust-parking_lot_core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-parking_lot_core-0.9.12-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dbb6fb59f23d9e15354c6d8def8b52531465dec9873f750e9ed7d048a07cf528"

URI_x86_64_v2_rust-parking_lot_core+backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot_core+backtrace-devel-0.9.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot_core+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot_core+backtrace-devel}"
SRC_URI[x86_64_v2_rust-parking_lot_core+backtrace-devel.sha256sum] = "b8bdfba1e64cd915266d5037f74fb7482865c84090cca023a99f5d0c685677df"

URI_x86_64_v2_rust-parking_lot_core+deadlock_detection-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot_core+deadlock_detection-devel-0.9.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot_core+deadlock_detection-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot_core+deadlock_detection-devel}"
SRC_URI[x86_64_v2_rust-parking_lot_core+deadlock_detection-devel.sha256sum] = "357009cbae7f8a439220708e729cb6ceeac9ae35414d29d2da14cd5533cfcb84"

URI_x86_64_v2_rust-parking_lot_core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot_core+default-devel-0.9.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot_core+default-devel}"
SRC_URI[x86_64_v2_rust-parking_lot_core+default-devel.sha256sum] = "1e2d47a9422772fe53018d2e4b1caac54802cc47aa0db8ac9717889ca47f139f"

URI_x86_64_v2_rust-parking_lot_core+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot_core+nightly-devel-0.9.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot_core+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot_core+nightly-devel}"
SRC_URI[x86_64_v2_rust-parking_lot_core+nightly-devel.sha256sum] = "e3130c93c849fe9ac9ea6f2d3faae9ec75c615228fc86dc083e215f2e7a1729e"

URI_x86_64_v2_rust-parking_lot_core+petgraph-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot_core+petgraph-devel-0.9.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot_core+petgraph-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot_core+petgraph-devel}"
SRC_URI[x86_64_v2_rust-parking_lot_core+petgraph-devel.sha256sum] = "cefa33bb8f03361a0991d65079654b51113264b9bc6f4cbcefe5b3d5f9dbaa17"

URI_x86_64_v2_rust-parking_lot_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot_core-devel-0.9.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot_core-devel}"
SRC_URI[x86_64_v2_rust-parking_lot_core-devel.sha256sum] = "527c6d344575d4f206a17e595f9d95d4fc3e046c5d2820de47691813e7604555"

URI_aarch64_rust-parking_lot_core+backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot_core+backtrace-devel-0.9.12-1.el10_1.noarch.rpm;name=aarch64_rust-parking_lot_core+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot_core+backtrace-devel}"
SRC_URI[aarch64_rust-parking_lot_core+backtrace-devel.sha256sum] = "0c7dba267817bd0cea96c97bec9abb66707ba5ad5d9f630e542ccf143156c587"

URI_aarch64_rust-parking_lot_core+deadlock_detection-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot_core+deadlock_detection-devel-0.9.12-1.el10_1.noarch.rpm;name=aarch64_rust-parking_lot_core+deadlock_detection-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot_core+deadlock_detection-devel}"
SRC_URI[aarch64_rust-parking_lot_core+deadlock_detection-devel.sha256sum] = "8396d71bc622086dd7f795d6d4481c2cac9e1d01dd50c83a0eec059a1d5cbc3c"

URI_aarch64_rust-parking_lot_core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot_core+default-devel-0.9.12-1.el10_1.noarch.rpm;name=aarch64_rust-parking_lot_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot_core+default-devel}"
SRC_URI[aarch64_rust-parking_lot_core+default-devel.sha256sum] = "d32173e9ec8f4ae856a2ae1acd87e1e7a131cb08fbd47e4c0c65be515985066a"

URI_aarch64_rust-parking_lot_core+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot_core+nightly-devel-0.9.12-1.el10_1.noarch.rpm;name=aarch64_rust-parking_lot_core+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot_core+nightly-devel}"
SRC_URI[aarch64_rust-parking_lot_core+nightly-devel.sha256sum] = "4eb46c5dfec6e5c81f48e8e158d58d2dab116f919a661aed0107f5abf89dca27"

URI_aarch64_rust-parking_lot_core+petgraph-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot_core+petgraph-devel-0.9.12-1.el10_1.noarch.rpm;name=aarch64_rust-parking_lot_core+petgraph-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot_core+petgraph-devel}"
SRC_URI[aarch64_rust-parking_lot_core+petgraph-devel.sha256sum] = "572e8b13ab9a3668e2f196653576f7e0865376af3a4e1875cc67b14ec9398813"

URI_aarch64_rust-parking_lot_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot_core-devel-0.9.12-1.el10_1.noarch.rpm;name=aarch64_rust-parking_lot_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot_core-devel}"
SRC_URI[aarch64_rust-parking_lot_core-devel.sha256sum] = "3ad804825d01d9fc8af20d8b7f9a51dd6ade56d37e5f0e879b13968518352695"

RDEPENDS:rust-parking_lot_core+backtrace-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-parking_lot_core-devel \
 "
RDEPENDS:rust-parking_lot_core+deadlock_detection-devel = " \
 cargo \
 rust-parking_lot_core+backtrace-devel \
 rust-parking_lot_core+petgraph-devel \
 rust-parking_lot_core-devel \
 "
RDEPENDS:rust-parking_lot_core+default-devel = " \
 cargo \
 rust-parking_lot_core-devel \
 "
RDEPENDS:rust-parking_lot_core+nightly-devel = " \
 cargo \
 rust-parking_lot_core-devel \
 "
RDEPENDS:rust-parking_lot_core+petgraph-devel = " \
 cargo \
 rust-parking_lot_core-devel \
 rust-petgraph0.6+default-devel \
 "
RDEPENDS:rust-parking_lot_core-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 rust-smallvec+default-devel \
 "
