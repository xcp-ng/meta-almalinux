# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-imagequant-sys"
PV = "4.0.3"
PR = "5.el10_0"
PACKAGES = " \
 libimagequant \
 libimagequant-devel \
 rust-imagequant-sys+capi-devel \
 rust-imagequant-sys+default-devel \
 rust-imagequant-sys+threads-devel \
 rust-imagequant-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-imagequant-sys-4.0.3-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "14a1d57459d591753a6208dd5d736ffc960645845f78501d2a988cdacb0f9dd1"

URI_x86_64_v2_libimagequant = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libimagequant-4.0.3-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libimagequant;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libimagequant}"
SRC_URI[x86_64_v2_libimagequant.sha256sum] = "ce830c3618ebc5a152c2c4a5584bf2592ec0aeed8f70fa680fdb8272fd6a38c6"

URI_x86_64_v2_libimagequant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libimagequant-devel-4.0.3-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libimagequant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libimagequant-devel}"
SRC_URI[x86_64_v2_libimagequant-devel.sha256sum] = "e637e06529887732719cdee731db078851bf47c0d1c6ea860a745968c7b16ac4"

URI_x86_64_v2_rust-imagequant-sys+capi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imagequant-sys+capi-devel-4.0.3-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imagequant-sys+capi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-imagequant-sys+capi-devel}"
SRC_URI[x86_64_v2_rust-imagequant-sys+capi-devel.sha256sum] = "4d0ced804ecc7efa5c8978577fa6ba05120a87df570c1b466876e376368ec225"

URI_x86_64_v2_rust-imagequant-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imagequant-sys+default-devel-4.0.3-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imagequant-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-imagequant-sys+default-devel}"
SRC_URI[x86_64_v2_rust-imagequant-sys+default-devel.sha256sum] = "cf90aba445d1fd7d66b6d3995b3ba03295abbd9b3fef1d4ebc32bf1ba40920b0"

URI_x86_64_v2_rust-imagequant-sys+threads-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imagequant-sys+threads-devel-4.0.3-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imagequant-sys+threads-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-imagequant-sys+threads-devel}"
SRC_URI[x86_64_v2_rust-imagequant-sys+threads-devel.sha256sum] = "6bffca213e05dea4e6fb1c9ce5a109b5fed6113ee5193117ea33448903bb9635"

URI_x86_64_v2_rust-imagequant-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imagequant-sys-devel-4.0.3-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imagequant-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-imagequant-sys-devel}"
SRC_URI[x86_64_v2_rust-imagequant-sys-devel.sha256sum] = "28e4018ef801ad59a2e159774d337f9f8ec80e9c87d669b62206765689c0c51c"

URI_aarch64_libimagequant = "${EPEL_MIRROR}/aarch64/Packages/l/libimagequant-4.0.3-5.el10_0.aarch64.rpm;name=aarch64_libimagequant;unpack=0"
SRC_URI:append = " ${URI_aarch64_libimagequant}"
SRC_URI[aarch64_libimagequant.sha256sum] = "b349dbbfe7659ff300b4e22ac99e1d31d75e931e563298616b08229597ea1725"

URI_aarch64_libimagequant-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libimagequant-devel-4.0.3-5.el10_0.aarch64.rpm;name=aarch64_libimagequant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libimagequant-devel}"
SRC_URI[aarch64_libimagequant-devel.sha256sum] = "18cf81be43247f1acc21a1fe379b7bd53d77493b1c29358bcc10da88b901a816"

URI_aarch64_rust-imagequant-sys+capi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-imagequant-sys+capi-devel-4.0.3-5.el10_0.noarch.rpm;name=aarch64_rust-imagequant-sys+capi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-imagequant-sys+capi-devel}"
SRC_URI[aarch64_rust-imagequant-sys+capi-devel.sha256sum] = "173b04211cb01b00e157da96c8c72dda8ca789a5432b8d0c53d2f087fecbf0e8"

URI_aarch64_rust-imagequant-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-imagequant-sys+default-devel-4.0.3-5.el10_0.noarch.rpm;name=aarch64_rust-imagequant-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-imagequant-sys+default-devel}"
SRC_URI[aarch64_rust-imagequant-sys+default-devel.sha256sum] = "563df03610cd89af06084d4fc9735142b89a01bb229e87bb56a6b99be383d466"

URI_aarch64_rust-imagequant-sys+threads-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-imagequant-sys+threads-devel-4.0.3-5.el10_0.noarch.rpm;name=aarch64_rust-imagequant-sys+threads-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-imagequant-sys+threads-devel}"
SRC_URI[aarch64_rust-imagequant-sys+threads-devel.sha256sum] = "3c6f0ca607c13bc295d309750dc129200986137c56ba1027740f1ab6f5368713"

URI_aarch64_rust-imagequant-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-imagequant-sys-devel-4.0.3-5.el10_0.noarch.rpm;name=aarch64_rust-imagequant-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-imagequant-sys-devel}"
SRC_URI[aarch64_rust-imagequant-sys-devel.sha256sum] = "626d439905076a40658aa743db2540bc694d9e8cd335d97aa5225108021f4834"

RDEPENDS:libimagequant = " \
 glibc \
 libgcc \
 "
RDEPENDS:libimagequant-devel = " \
 libimagequant \
 pkgconf-pkg-config \
 "
RDEPENDS:rust-imagequant-sys+capi-devel = " \
 cargo \
 rust-imagequant-sys-devel \
 "
RDEPENDS:rust-imagequant-sys+default-devel = " \
 cargo \
 rust-imagequant+default-devel \
 rust-imagequant-sys-devel \
 "
RDEPENDS:rust-imagequant-sys+threads-devel = " \
 cargo \
 rust-imagequant+threads-devel \
 rust-imagequant-sys-devel \
 "
RDEPENDS:rust-imagequant-sys-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-imagequant+_internal_c_ffi-devel \
 rust-imagequant-devel \
 rust-libc+default-devel \
 "
