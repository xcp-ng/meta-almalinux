# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-float-ord"
PV = "0.3.2"
PR = "10.el10_2"
PACKAGES = " \
 rust-float-ord+default-devel \
 rust-float-ord-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-float-ord-0.3.2-10.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a92efc10c53e0b2d7b8cfd8a9a4e4cf958816b8ccfa684c809321a9f10332541"

URI_x86_64_v2_rust-float-ord+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-float-ord+default-devel-0.3.2-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-float-ord+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-float-ord+default-devel}"
SRC_URI[x86_64_v2_rust-float-ord+default-devel.sha256sum] = "082b91096ef1baae9c27b568d883db057e9343c2a16f1ca14dca31383eb6d674"

URI_x86_64_v2_rust-float-ord-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-float-ord-devel-0.3.2-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-float-ord-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-float-ord-devel}"
SRC_URI[x86_64_v2_rust-float-ord-devel.sha256sum] = "04a45a4adf509603ae499de5ffdd6aeec7fb857c898d6a99750de1a8737d74e5"

URI_aarch64_rust-float-ord+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-float-ord+default-devel-0.3.2-10.el10_2.noarch.rpm;name=aarch64_rust-float-ord+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-float-ord+default-devel}"
SRC_URI[aarch64_rust-float-ord+default-devel.sha256sum] = "b66291122ff7cce11162029ea7800db33a7e1cc3054e0d1b0cf9ce634ff42c6a"

URI_aarch64_rust-float-ord-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-float-ord-devel-0.3.2-10.el10_2.noarch.rpm;name=aarch64_rust-float-ord-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-float-ord-devel}"
SRC_URI[aarch64_rust-float-ord-devel.sha256sum] = "724da55feb57ddb96fb21563fdc46b20167e65c178ccfdad4a868d90d6345fc0"

RDEPENDS:rust-float-ord+default-devel = " \
 cargo \
 rust-float-ord-devel \
 "
RDEPENDS:rust-float-ord-devel = " \
 cargo \
 "
