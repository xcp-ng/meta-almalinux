# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-detone"
PV = "1.0.1"
PR = "2.el10_1"
PACKAGES = " \
 rust-detone+default-devel \
 rust-detone-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-detone-1.0.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d80665eb53e806f54d871f1d201c9fc235b573d83e02dfeecac6cbda90bb3fda"

URI_x86_64_v2_rust-detone+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-detone+default-devel-1.0.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-detone+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-detone+default-devel}"
SRC_URI[x86_64_v2_rust-detone+default-devel.sha256sum] = "16349394ba82ba8bed15689cc9325cd8bd038976fa1278baa305c04644ef3743"

URI_x86_64_v2_rust-detone-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-detone-devel-1.0.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-detone-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-detone-devel}"
SRC_URI[x86_64_v2_rust-detone-devel.sha256sum] = "7bd1f2476f2d28098bef2c97757b53ffb78652ea1705e844e6496b2ae709e4be"

URI_aarch64_rust-detone+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-detone+default-devel-1.0.1-2.el10_1.noarch.rpm;name=aarch64_rust-detone+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-detone+default-devel}"
SRC_URI[aarch64_rust-detone+default-devel.sha256sum] = "e786237870f55128b69260a44bc672bb93c63f60c23cbb54cd98f11517bfb87f"

URI_aarch64_rust-detone-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-detone-devel-1.0.1-2.el10_1.noarch.rpm;name=aarch64_rust-detone-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-detone-devel}"
SRC_URI[aarch64_rust-detone-devel.sha256sum] = "8f233874add8d4527e7e62f2f88949f7603fca63df68103b2338de13ef989b78"

RDEPENDS:rust-detone+default-devel = " \
 cargo \
 rust-detone-devel \
 "
RDEPENDS:rust-detone-devel = " \
 cargo \
 rust \
 "
