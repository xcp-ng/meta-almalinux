# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "containers-common"
PE = "6"
PV = "6.0"
PR = "3.el10"
PACKAGES = " \
 containers-common \
 containers-common-extra \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/containers-common-6.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7d5b0ed41e8cc69c3111d0f5439fafef82fbb1856360a96570010f7cfc8298ab"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/containers-common-6.0-3.el10.noarch.rpm;name=x86_64_v2_containers-common;unpack=0"
SRC_URI[x86_64_v2_containers-common.sha256sum] = "e5b103a92b3170f0012cade29dd22bc55e335620ff467716e9edd0f8925e1ad8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/containers-common-extra-6.0-3.el10.noarch.rpm;name=x86_64_v2_containers-common-extra;unpack=0"
SRC_URI[x86_64_v2_containers-common-extra.sha256sum] = "36efa5184e10f2069ba83abeac22c59b9ef75bff62a844c74c2ece96a36e80a3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/containers-common-6.0-3.el10.noarch.rpm;name=aarch64_containers-common;unpack=0"
SRC_URI[aarch64_containers-common.sha256sum] = "e5b103a92b3170f0012cade29dd22bc55e335620ff467716e9edd0f8925e1ad8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/containers-common-extra-6.0-3.el10.noarch.rpm;name=aarch64_containers-common-extra;unpack=0"
SRC_URI[aarch64_containers-common-extra.sha256sum] = "36efa5184e10f2069ba83abeac22c59b9ef75bff62a844c74c2ece96a36e80a3"

RDEPENDS:containers-common = " \
 bash \
 container-selinux \
 netavark \
 "
RDEPENDS:containers-common-extra = " \
 containers-common \
 netavark \
 nftables \
 passt \
 virtual/oci-runtime \
 "
