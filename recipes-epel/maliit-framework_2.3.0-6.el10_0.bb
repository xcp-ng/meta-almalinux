# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "maliit-framework"
PV = "2.3.0"
PR = "6.el10_0"
PACKAGES = " \
 maliit-framework \
 maliit-framework-devel \
 maliit-framework-docs \
 maliit-framework-examples \
 maliit-framework-qt5 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/maliit-framework-2.3.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a80d02f7556eb282df80352b6f9ad08fea59efe329139cb8cb37d7322f72beaf"

URI_x86_64_v2_maliit-framework = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/maliit-framework-2.3.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_maliit-framework;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maliit-framework}"
SRC_URI[x86_64_v2_maliit-framework.sha256sum] = "9f00d312ab8f799ae5b1cc04759666ab5b65b8d569a5068d67299c6c4656287c"

URI_x86_64_v2_maliit-framework-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/maliit-framework-devel-2.3.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_maliit-framework-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maliit-framework-devel}"
SRC_URI[x86_64_v2_maliit-framework-devel.sha256sum] = "46779a9028f70c5d523ca84144ac55a5183a25ca0d45b314e95e5716564516a9"

URI_x86_64_v2_maliit-framework-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/maliit-framework-docs-2.3.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_maliit-framework-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maliit-framework-docs}"
SRC_URI[x86_64_v2_maliit-framework-docs.sha256sum] = "050cf0c4fbe817df5283d79ce40334a2426b4ad5bad063c4d9b88e18499654d6"

URI_x86_64_v2_maliit-framework-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/maliit-framework-examples-2.3.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_maliit-framework-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maliit-framework-examples}"
SRC_URI[x86_64_v2_maliit-framework-examples.sha256sum] = "6e7b75d170d4d2347c9a5d2fff9089133443c20dc951cc83ffad82328e313fa2"

URI_x86_64_v2_maliit-framework-qt5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/maliit-framework-qt5-2.3.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_maliit-framework-qt5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maliit-framework-qt5}"
SRC_URI[x86_64_v2_maliit-framework-qt5.sha256sum] = "8a83e4ea6c387a55d28daf1b59263343ced7381d9882a658c0728d5a06f43f8d"

URI_aarch64_maliit-framework = "${EPEL_MIRROR}/aarch64/Packages/m/maliit-framework-2.3.0-6.el10_0.aarch64.rpm;name=aarch64_maliit-framework;unpack=0"
SRC_URI:append = " ${URI_aarch64_maliit-framework}"
SRC_URI[aarch64_maliit-framework.sha256sum] = "f8645214bca1602ada5d18610dc397a12a174ec679ab1230c0af8a49aded9357"

URI_aarch64_maliit-framework-devel = "${EPEL_MIRROR}/aarch64/Packages/m/maliit-framework-devel-2.3.0-6.el10_0.aarch64.rpm;name=aarch64_maliit-framework-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_maliit-framework-devel}"
SRC_URI[aarch64_maliit-framework-devel.sha256sum] = "b565a9eda33a9380b4b0ff6d4edf32db2dc38c015e9358637079d1d97e5be581"

URI_aarch64_maliit-framework-docs = "${EPEL_MIRROR}/aarch64/Packages/m/maliit-framework-docs-2.3.0-6.el10_0.aarch64.rpm;name=aarch64_maliit-framework-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_maliit-framework-docs}"
SRC_URI[aarch64_maliit-framework-docs.sha256sum] = "a2e63302c6085f07c1908d548215dfdd8f2c339776fc467bf3306480f6f2e923"

URI_aarch64_maliit-framework-examples = "${EPEL_MIRROR}/aarch64/Packages/m/maliit-framework-examples-2.3.0-6.el10_0.aarch64.rpm;name=aarch64_maliit-framework-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_maliit-framework-examples}"
SRC_URI[aarch64_maliit-framework-examples.sha256sum] = "c4da773732041de4cc05cc600c90f2b7bb33df73504bd54bf9541325867bc38c"

URI_aarch64_maliit-framework-qt5 = "${EPEL_MIRROR}/aarch64/Packages/m/maliit-framework-qt5-2.3.0-6.el10_0.aarch64.rpm;name=aarch64_maliit-framework-qt5;unpack=0"
SRC_URI:append = " ${URI_aarch64_maliit-framework-qt5}"
SRC_URI[aarch64_maliit-framework-qt5.sha256sum] = "2797fe1620a31da3108ce43b388d9e2d5fb29ff52d8f68f122ac69089bc7c362"

RDEPENDS:maliit-framework = " \
 glib2 \
 glibc \
 libgcc \
 libstdc++ \
 maliit-framework-qt5 \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
RDEPENDS:maliit-framework-devel = " \
 cmake-filesystem \
 glib2-devel \
 maliit-framework \
 maliit-framework-devel \
 maliit-framework-qt5 \
 pkgconf-pkg-config \
 "
RDEPENDS:maliit-framework-docs = " \
 "
RDEPENDS:maliit-framework-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 maliit-framework \
 maliit-framework-qt5 \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
RDEPENDS:maliit-framework-qt5 = " \
 glibc \
 libgcc \
 libstdc++ \
 libwayland-client \
 libxcb \
 maliit-framework \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtwayland \
 systemd-libs \
 "
