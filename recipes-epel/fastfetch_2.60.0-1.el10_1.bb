# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fastfetch"
PV = "2.60.0"
PR = "1.el10_1"
PACKAGES = " \
 fastfetch \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fastfetch-2.60.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "79d734eceeda9fe11d9ad1f5f9ec0a4f308898f7bcfc908c1df37830326d130d"

URI_x86_64_v2_fastfetch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fastfetch-2.60.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fastfetch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fastfetch}"
SRC_URI[x86_64_v2_fastfetch.sha256sum] = "6b731af84c1ae14e0604b807982890b16f7db71501cc96cbd38190e212ba1358"

URI_aarch64_fastfetch = "${EPEL_MIRROR}/aarch64/Packages/f/fastfetch-2.60.0-1.el10_1.aarch64.rpm;name=aarch64_fastfetch;unpack=0"
SRC_URI:append = " ${URI_aarch64_fastfetch}"
SRC_URI[aarch64_fastfetch.sha256sum] = "d7e647142d3b0680fdc042e72cec79e79dbb295542150a123ec068ec63fd24a8"

RDEPENDS:fastfetch = " \
 glibc \
 libgcc \
 yyjson \
 "
