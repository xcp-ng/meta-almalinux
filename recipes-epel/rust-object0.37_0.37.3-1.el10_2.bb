# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-object0.37"
PV = "0.37.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-object0.37+all-devel \
 rust-object0.37+archive-devel \
 rust-object0.37+build-devel \
 rust-object0.37+build_core-devel \
 rust-object0.37+cargo-all-devel \
 rust-object0.37+coff-devel \
 rust-object0.37+compression-devel \
 rust-object0.37+default-devel \
 rust-object0.37+doc-devel \
 rust-object0.37+elf-devel \
 rust-object0.37+macho-devel \
 rust-object0.37+pe-devel \
 rust-object0.37+read-devel \
 rust-object0.37+read_core-devel \
 rust-object0.37+std-devel \
 rust-object0.37+unaligned-devel \
 rust-object0.37+unstable-all-devel \
 rust-object0.37+unstable-devel \
 rust-object0.37+write-devel \
 rust-object0.37+write_core-devel \
 rust-object0.37+write_std-devel \
 rust-object0.37+xcoff-devel \
 rust-object0.37-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-object0.37-0.37.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27e0ab15cf58fa55d943e165373456f2d3006f5df579afdca8c27f09a5cb912a"

URI_x86_64_v2_rust-object0.37+all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.37+all-devel-0.37.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.37+all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.37+all-devel}"
SRC_URI[x86_64_v2_rust-object0.37+all-devel.sha256sum] = "cfaf72110286a6f72d38a278b80a9a2e431a3b9e7ad3999d642c910695b994c3"

URI_x86_64_v2_rust-object0.37+archive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.37+archive-devel-0.37.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.37+archive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.37+archive-devel}"
SRC_URI[x86_64_v2_rust-object0.37+archive-devel.sha256sum] = "11f5a83193a0f2de5fee7f067c7d98105694be384b3767a76ed05859a5af46cc"

URI_x86_64_v2_rust-object0.37+build-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.37+build-devel-0.37.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.37+build-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.37+build-devel}"
SRC_URI[x86_64_v2_rust-object0.37+build-devel.sha256sum] = "d34311d678f824eb5db9a049b15724fc475dd42da991265608c2ca3ef4b01f1a"
RPROVIDES:rust-object0.37+build-devel:x86_64_v2 = "virtual/crate_object/build__ge_0.35.0_with_crate_object/build__lt_0.39.0~"

URI_x86_64_v2_rust-object0.37+build_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.37+build_core-devel-0.37.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.37+build_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.37+build_core-devel}"
SRC_URI[x86_64_v2_rust-object0.37+build_core-devel.sha256sum] = "522dea6d52568d1130e1f2087341ea93114490e6d9bc762f700e20278c164bcd"

URI_x86_64_v2_rust-object0.37+cargo-all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.37+cargo-all-devel-0.37.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.37+cargo-all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.37+cargo-all-devel}"
SRC_URI[x86_64_v2_rust-object0.37+cargo-all-devel.sha256sum] = "bb1fd332aa6b50e8efe978712c2f1ff04893bde65a11ea23bfd3c1fcd14ac2a8"

URI_x86_64_v2_rust-object0.37+coff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.37+coff-devel-0.37.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.37+coff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.37+coff-devel}"
SRC_URI[x86_64_v2_rust-object0.37+coff-devel.sha256sum] = "9409536aaa72e1141e8aabdae3a586684ee6686a2ea3b73c999834bc03fc6069"

URI_x86_64_v2_rust-object0.37+compression-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.37+compression-devel-0.37.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.37+compression-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.37+compression-devel}"
SRC_URI[x86_64_v2_rust-object0.37+compression-devel.sha256sum] = "2b1c8e8b883d4a567d3f6cabeb1c1da335ac7d18de662c8dbed0955bee4aa850"

URI_x86_64_v2_rust-object0.37+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.37+default-devel-0.37.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.37+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.37+default-devel}"
SRC_URI[x86_64_v2_rust-object0.37+default-devel.sha256sum] = "cf7e795ea0695c416594d5b5661c4f4d6c88a3c7d1b90216f53f1f1c42c0dc16"

URI_x86_64_v2_rust-object0.37+doc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.37+doc-devel-0.37.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.37+doc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.37+doc-devel}"
SRC_URI[x86_64_v2_rust-object0.37+doc-devel.sha256sum] = "181fd2fd3f71d0570b983ad749df3c511e6bf558477ee0e82dac0fe366fb44a9"

URI_x86_64_v2_rust-object0.37+elf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.37+elf-devel-0.37.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.37+elf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.37+elf-devel}"
SRC_URI[x86_64_v2_rust-object0.37+elf-devel.sha256sum] = "f353bfd2381dc1cdc4129e590b94b8ba6917c81bfe4fbee45f3104be08ac95fa"
RPROVIDES:rust-object0.37+elf-devel:x86_64_v2 = "virtual/crate_object/elf__ge_0.35.0_with_crate_object/elf__lt_0.39.0~"

URI_x86_64_v2_rust-object0.37+macho-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.37+macho-devel-0.37.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.37+macho-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.37+macho-devel}"
SRC_URI[x86_64_v2_rust-object0.37+macho-devel.sha256sum] = "4172906f2ef6f39973267271a140ff4e5673a5ebbdfc54b13a09319896d56c63"

URI_x86_64_v2_rust-object0.37+pe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.37+pe-devel-0.37.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.37+pe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.37+pe-devel}"
SRC_URI[x86_64_v2_rust-object0.37+pe-devel.sha256sum] = "35a5632af8e7491318213d5582c7c6cd2eed584bef31a07cac7a93af3945cb56"

URI_x86_64_v2_rust-object0.37+read-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.37+read-devel-0.37.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.37+read-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.37+read-devel}"
SRC_URI[x86_64_v2_rust-object0.37+read-devel.sha256sum] = "7c72843b1c55fd0be9ffe583f2b7181434f1a59ff2e2d618ad6b2604b4a9fb3f"

URI_x86_64_v2_rust-object0.37+read_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.37+read_core-devel-0.37.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.37+read_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.37+read_core-devel}"
SRC_URI[x86_64_v2_rust-object0.37+read_core-devel.sha256sum] = "edb78b626ffd02aacaa47f668db94f1ddc8e103ce9d00c545199b88d7566f9c7"

URI_x86_64_v2_rust-object0.37+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.37+std-devel-0.37.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.37+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.37+std-devel}"
SRC_URI[x86_64_v2_rust-object0.37+std-devel.sha256sum] = "796f87463c52c958b051038a23d2d563300879d01ae6491fa24df4cbbcad267d"

URI_x86_64_v2_rust-object0.37+unaligned-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.37+unaligned-devel-0.37.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.37+unaligned-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.37+unaligned-devel}"
SRC_URI[x86_64_v2_rust-object0.37+unaligned-devel.sha256sum] = "b0a96bb197a053b1d5a71b655fae26ed50bc23252fb4d8591dd2980ffe59bb3d"

URI_x86_64_v2_rust-object0.37+unstable-all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.37+unstable-all-devel-0.37.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.37+unstable-all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.37+unstable-all-devel}"
SRC_URI[x86_64_v2_rust-object0.37+unstable-all-devel.sha256sum] = "e506ca8b96162a313be9e68a429b7d6cb3cb2bfd16944fcfcbf4c7c51b29db14"

URI_x86_64_v2_rust-object0.37+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.37+unstable-devel-0.37.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.37+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.37+unstable-devel}"
SRC_URI[x86_64_v2_rust-object0.37+unstable-devel.sha256sum] = "aa1d1f23a6de36f5f235b8fda55cd86bb3d5610b66c7c19dcfb3e36e72fa6ef3"

URI_x86_64_v2_rust-object0.37+write-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.37+write-devel-0.37.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.37+write-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.37+write-devel}"
SRC_URI[x86_64_v2_rust-object0.37+write-devel.sha256sum] = "e051a6997554c3e3b715c9658491681aa353b01e275ee97b369e0c9a07d83025"

URI_x86_64_v2_rust-object0.37+write_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.37+write_core-devel-0.37.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.37+write_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.37+write_core-devel}"
SRC_URI[x86_64_v2_rust-object0.37+write_core-devel.sha256sum] = "eae6c73863186b2972f714f758ac2bb18a66eea60affccc023131c9272cec65d"

URI_x86_64_v2_rust-object0.37+write_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.37+write_std-devel-0.37.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.37+write_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.37+write_std-devel}"
SRC_URI[x86_64_v2_rust-object0.37+write_std-devel.sha256sum] = "0380ff679c67982d9f2a69a2637db41f1f122bfeba3f8d2514b1d4014eb6caf0"

URI_x86_64_v2_rust-object0.37+xcoff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.37+xcoff-devel-0.37.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.37+xcoff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.37+xcoff-devel}"
SRC_URI[x86_64_v2_rust-object0.37+xcoff-devel.sha256sum] = "e0be108cf3a124d3e3dc707bd8016d8c62869d2bfa8e303232fdb4f7caffb88e"

URI_x86_64_v2_rust-object0.37-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.37-devel-0.37.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.37-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.37-devel}"
SRC_URI[x86_64_v2_rust-object0.37-devel.sha256sum] = "c24db128c275b99ce4b3702f3a6faf4009a6bb49478bfd486f3e79802809aa7e"
RPROVIDES:rust-object0.37-devel:x86_64_v2 = "virtual/crate_object__ge_0.35.0_with_crate_object__lt_0.39.0~"

URI_aarch64_rust-object0.37+all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.37+all-devel-0.37.3-1.el10_2.noarch.rpm;name=aarch64_rust-object0.37+all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.37+all-devel}"
SRC_URI[aarch64_rust-object0.37+all-devel.sha256sum] = "97b8989c362dac191f1620131ae0ec333245f635078df386818450701487ae10"

URI_aarch64_rust-object0.37+archive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.37+archive-devel-0.37.3-1.el10_2.noarch.rpm;name=aarch64_rust-object0.37+archive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.37+archive-devel}"
SRC_URI[aarch64_rust-object0.37+archive-devel.sha256sum] = "6fb5c77171b3b1f92a1a24580c5189d797f282b8906460c92f80737c5be4cf5e"

URI_aarch64_rust-object0.37+build-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.37+build-devel-0.37.3-1.el10_2.noarch.rpm;name=aarch64_rust-object0.37+build-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.37+build-devel}"
SRC_URI[aarch64_rust-object0.37+build-devel.sha256sum] = "756648becd75bcefc37dfef4c7bc6e4560ef0a2099f626a021fe7fb656346abe"
RPROVIDES:rust-object0.37+build-devel:aarch64 = "virtual/crate_object/build__ge_0.35.0_with_crate_object/build__lt_0.39.0~"

URI_aarch64_rust-object0.37+build_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.37+build_core-devel-0.37.3-1.el10_2.noarch.rpm;name=aarch64_rust-object0.37+build_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.37+build_core-devel}"
SRC_URI[aarch64_rust-object0.37+build_core-devel.sha256sum] = "931c1dd71554e711530c30304102e4c7379774c70589575893d8d70157607de7"

URI_aarch64_rust-object0.37+cargo-all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.37+cargo-all-devel-0.37.3-1.el10_2.noarch.rpm;name=aarch64_rust-object0.37+cargo-all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.37+cargo-all-devel}"
SRC_URI[aarch64_rust-object0.37+cargo-all-devel.sha256sum] = "22004cca3867f8ae75fb8bc0847d62528abc6efba634eb365e80ac27273e9c8b"

URI_aarch64_rust-object0.37+coff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.37+coff-devel-0.37.3-1.el10_2.noarch.rpm;name=aarch64_rust-object0.37+coff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.37+coff-devel}"
SRC_URI[aarch64_rust-object0.37+coff-devel.sha256sum] = "c70ee84d0532824889d28b48707ad78cc400dec2701782515d6236d028ac44ab"

URI_aarch64_rust-object0.37+compression-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.37+compression-devel-0.37.3-1.el10_2.noarch.rpm;name=aarch64_rust-object0.37+compression-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.37+compression-devel}"
SRC_URI[aarch64_rust-object0.37+compression-devel.sha256sum] = "b0e67858c58dfe6e96b6def6ca9c8602f023c12efdfb2c5a1bcb700966d933b5"

URI_aarch64_rust-object0.37+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.37+default-devel-0.37.3-1.el10_2.noarch.rpm;name=aarch64_rust-object0.37+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.37+default-devel}"
SRC_URI[aarch64_rust-object0.37+default-devel.sha256sum] = "7beed31257bc1bd8f252fa872ab31043e6ea4f4d9350f1162f5d043a7ad66a9c"

URI_aarch64_rust-object0.37+doc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.37+doc-devel-0.37.3-1.el10_2.noarch.rpm;name=aarch64_rust-object0.37+doc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.37+doc-devel}"
SRC_URI[aarch64_rust-object0.37+doc-devel.sha256sum] = "a24f0d59a788f92947d5cbd1e7642a36f9e4de74e1241033395dfd8b3b302083"

URI_aarch64_rust-object0.37+elf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.37+elf-devel-0.37.3-1.el10_2.noarch.rpm;name=aarch64_rust-object0.37+elf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.37+elf-devel}"
SRC_URI[aarch64_rust-object0.37+elf-devel.sha256sum] = "ab3bd01a7b1dacd6d39e85bb4fec8410e85b944aa925a37c5655374932f83191"
RPROVIDES:rust-object0.37+elf-devel:aarch64 = "virtual/crate_object/elf__ge_0.35.0_with_crate_object/elf__lt_0.39.0~"

URI_aarch64_rust-object0.37+macho-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.37+macho-devel-0.37.3-1.el10_2.noarch.rpm;name=aarch64_rust-object0.37+macho-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.37+macho-devel}"
SRC_URI[aarch64_rust-object0.37+macho-devel.sha256sum] = "9d98791cc4411e68a7508ce783902341e1162462f10a1d2aecc3336e2811554a"

URI_aarch64_rust-object0.37+pe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.37+pe-devel-0.37.3-1.el10_2.noarch.rpm;name=aarch64_rust-object0.37+pe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.37+pe-devel}"
SRC_URI[aarch64_rust-object0.37+pe-devel.sha256sum] = "96ecc53f5455d7555aae1e840721e4bb501df366d2e76b0776312b9b4601314f"

URI_aarch64_rust-object0.37+read-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.37+read-devel-0.37.3-1.el10_2.noarch.rpm;name=aarch64_rust-object0.37+read-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.37+read-devel}"
SRC_URI[aarch64_rust-object0.37+read-devel.sha256sum] = "ae158091ab5dfbedb72a6fbe9018c0d36f1ecefb12b2e972fdce98c18ed28fee"

URI_aarch64_rust-object0.37+read_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.37+read_core-devel-0.37.3-1.el10_2.noarch.rpm;name=aarch64_rust-object0.37+read_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.37+read_core-devel}"
SRC_URI[aarch64_rust-object0.37+read_core-devel.sha256sum] = "9fd2dce4b5a991a34878dc5f50ae210056e661c0677baeefe41e4bd4ea543c5c"

URI_aarch64_rust-object0.37+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.37+std-devel-0.37.3-1.el10_2.noarch.rpm;name=aarch64_rust-object0.37+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.37+std-devel}"
SRC_URI[aarch64_rust-object0.37+std-devel.sha256sum] = "223931797e8c9346f41c368e6db48ba544d96a769089e597353094c6b68b0341"

URI_aarch64_rust-object0.37+unaligned-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.37+unaligned-devel-0.37.3-1.el10_2.noarch.rpm;name=aarch64_rust-object0.37+unaligned-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.37+unaligned-devel}"
SRC_URI[aarch64_rust-object0.37+unaligned-devel.sha256sum] = "d2942b3023da5136773f1d7687e5bc0b7285ece9a8ea19d62b35c57f902860e0"

URI_aarch64_rust-object0.37+unstable-all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.37+unstable-all-devel-0.37.3-1.el10_2.noarch.rpm;name=aarch64_rust-object0.37+unstable-all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.37+unstable-all-devel}"
SRC_URI[aarch64_rust-object0.37+unstable-all-devel.sha256sum] = "cfa9cf784e0c3002b8f4b04b6970c1b77f25dda5d13927444e7047f8e357d46f"

URI_aarch64_rust-object0.37+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.37+unstable-devel-0.37.3-1.el10_2.noarch.rpm;name=aarch64_rust-object0.37+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.37+unstable-devel}"
SRC_URI[aarch64_rust-object0.37+unstable-devel.sha256sum] = "e9a9288b0f7d98f849587448f35c5587557c518af3a5f45b850efcee018294be"

URI_aarch64_rust-object0.37+write-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.37+write-devel-0.37.3-1.el10_2.noarch.rpm;name=aarch64_rust-object0.37+write-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.37+write-devel}"
SRC_URI[aarch64_rust-object0.37+write-devel.sha256sum] = "fef21e5f479eb7ef9de93c15adf73d380bfe25e84d4dd6a674e05d7281d3cc47"

URI_aarch64_rust-object0.37+write_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.37+write_core-devel-0.37.3-1.el10_2.noarch.rpm;name=aarch64_rust-object0.37+write_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.37+write_core-devel}"
SRC_URI[aarch64_rust-object0.37+write_core-devel.sha256sum] = "bcf52ffbe43538365213dc4656b6ca2583e99777151a5945affdc4e81138bd4d"

URI_aarch64_rust-object0.37+write_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.37+write_std-devel-0.37.3-1.el10_2.noarch.rpm;name=aarch64_rust-object0.37+write_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.37+write_std-devel}"
SRC_URI[aarch64_rust-object0.37+write_std-devel.sha256sum] = "3cc45b5fcbd44f2fe060ad417af0241f114f2bf153c8f95d385ba5d64b50e537"

URI_aarch64_rust-object0.37+xcoff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.37+xcoff-devel-0.37.3-1.el10_2.noarch.rpm;name=aarch64_rust-object0.37+xcoff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.37+xcoff-devel}"
SRC_URI[aarch64_rust-object0.37+xcoff-devel.sha256sum] = "676ded6a1437b2f09b58714d700739fa24da67846b835b610ef4111e97fd526e"

URI_aarch64_rust-object0.37-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.37-devel-0.37.3-1.el10_2.noarch.rpm;name=aarch64_rust-object0.37-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.37-devel}"
SRC_URI[aarch64_rust-object0.37-devel.sha256sum] = "ff228faac3fbf3583c1854a788856326335a2e3f13a86f52ccc2dcd7719081df"
RPROVIDES:rust-object0.37-devel:aarch64 = "virtual/crate_object__ge_0.35.0_with_crate_object__lt_0.39.0~"

RDEPENDS:rust-object0.37+all-devel = " \
 cargo \
 rust-object0.37+build-devel \
 rust-object0.37+compression-devel \
 rust-object0.37+read-devel \
 rust-object0.37+std-devel \
 rust-object0.37+write-devel \
 rust-object0.37-devel \
 "
RDEPENDS:rust-object0.37+archive-devel = " \
 cargo \
 rust-object0.37-devel \
 "
RDEPENDS:rust-object0.37+build-devel = " \
 cargo \
 rust-object0.37+build_core-devel \
 rust-object0.37+elf-devel \
 rust-object0.37+write_std-devel \
 rust-object0.37-devel \
 "
RDEPENDS:rust-object0.37+build_core-devel = " \
 cargo \
 rust-object0.37+read_core-devel \
 rust-object0.37+write_core-devel \
 rust-object0.37-devel \
 "
RDEPENDS:rust-object0.37+cargo-all-devel = " \
 cargo \
 rust-object0.37-devel \
 "
RDEPENDS:rust-object0.37+coff-devel = " \
 cargo \
 rust-object0.37-devel \
 "
RDEPENDS:rust-object0.37+compression-devel = " \
 cargo \
 rust-flate2+default-devel \
 rust-object0.37+std-devel \
 rust-object0.37-devel \
 rust-ruzstd+default-devel \
 "
RDEPENDS:rust-object0.37+default-devel = " \
 cargo \
 rust-object0.37+compression-devel \
 rust-object0.37+read-devel \
 rust-object0.37-devel \
 "
RDEPENDS:rust-object0.37+doc-devel = " \
 cargo \
 rust-object0.37+archive-devel \
 rust-object0.37+build_core-devel \
 rust-object0.37+coff-devel \
 rust-object0.37+compression-devel \
 rust-object0.37+elf-devel \
 rust-object0.37+macho-devel \
 rust-object0.37+pe-devel \
 rust-object0.37+read_core-devel \
 rust-object0.37+std-devel \
 rust-object0.37+write_std-devel \
 rust-object0.37+xcoff-devel \
 rust-object0.37-devel \
 "
RDEPENDS:rust-object0.37+elf-devel = " \
 cargo \
 rust-object0.37-devel \
 "
RDEPENDS:rust-object0.37+macho-devel = " \
 cargo \
 rust-object0.37-devel \
 "
RDEPENDS:rust-object0.37+pe-devel = " \
 cargo \
 rust-object0.37+coff-devel \
 rust-object0.37-devel \
 "
RDEPENDS:rust-object0.37+read-devel = " \
 cargo \
 rust-object0.37+archive-devel \
 rust-object0.37+coff-devel \
 rust-object0.37+elf-devel \
 rust-object0.37+macho-devel \
 rust-object0.37+pe-devel \
 rust-object0.37+read_core-devel \
 rust-object0.37+unaligned-devel \
 rust-object0.37+xcoff-devel \
 rust-object0.37-devel \
 "
RDEPENDS:rust-object0.37+read_core-devel = " \
 cargo \
 rust-object0.37-devel \
 "
RDEPENDS:rust-object0.37+std-devel = " \
 cargo \
 rust-memchr+std-devel \
 rust-object0.37-devel \
 "
RDEPENDS:rust-object0.37+unaligned-devel = " \
 cargo \
 rust-object0.37-devel \
 "
RDEPENDS:rust-object0.37+unstable-all-devel = " \
 cargo \
 rust-object0.37+all-devel \
 rust-object0.37+unstable-devel \
 rust-object0.37-devel \
 "
RDEPENDS:rust-object0.37+unstable-devel = " \
 cargo \
 rust-object0.37-devel \
 "
RDEPENDS:rust-object0.37+write-devel = " \
 cargo \
 rust-object0.37+coff-devel \
 rust-object0.37+elf-devel \
 rust-object0.37+macho-devel \
 rust-object0.37+pe-devel \
 rust-object0.37+write_std-devel \
 rust-object0.37+xcoff-devel \
 rust-object0.37-devel \
 "
RDEPENDS:rust-object0.37+write_core-devel = " \
 cargo \
 rust-crc32fast-devel \
 rust-hashbrown0.15+default-hasher-devel \
 rust-hashbrown0.15-devel \
 rust-indexmap-devel \
 rust-object0.37-devel \
 "
RDEPENDS:rust-object0.37+write_std-devel = " \
 cargo \
 rust-crc32fast+std-devel \
 rust-crc32fast-devel \
 rust-indexmap+std-devel \
 rust-indexmap-devel \
 rust-object0.37+std-devel \
 rust-object0.37+write_core-devel \
 rust-object0.37-devel \
 "
RDEPENDS:rust-object0.37+xcoff-devel = " \
 cargo \
 rust-object0.37-devel \
 "
RDEPENDS:rust-object0.37-devel = " \
 cargo \
 rust \
 rust-memchr-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_object/build__ge_0.35.0_with_crate_object/build__lt_0.39.0~ rpm/virtual/crate_object/elf__ge_0.35.0_with_crate_object/elf__lt_0.39.0~ rpm/virtual/crate_object__ge_0.35.0_with_crate_object__lt_0.39.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_object/build__ge_0.35.0_with_crate_object/build__lt_0.39.0~ rpm/virtual/crate_object/elf__ge_0.35.0_with_crate_object/elf__lt_0.39.0~ rpm/virtual/crate_object__ge_0.35.0_with_crate_object__lt_0.39.0~"
