# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jbigkit"
PV = "2.1"
PR = "31.el10"
PACKAGES = " \
 jbigkit \
 jbigkit-devel \
 jbigkit-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/jbigkit-2.1-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d963c42b56d9b6115161317988d560b450e7f4ebe46e74fd6c7c95e5a2eb69a"

URI_x86_64_v2_jbigkit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/jbigkit-2.1-31.el10.x86_64_v2.rpm;name=x86_64_v2_jbigkit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jbigkit}"
SRC_URI[x86_64_v2_jbigkit.sha256sum] = "8dab98ac1bb815b5d36421cef4aa9d8537096cadcf7787cca4b0a81c90decbe7"

URI_x86_64_v2_jbigkit-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jbigkit-devel-2.1-31.el10.x86_64_v2.rpm;name=x86_64_v2_jbigkit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jbigkit-devel}"
SRC_URI[x86_64_v2_jbigkit-devel.sha256sum] = "684f269a6cd5c6103d362c56afd1a97a6484f1b920d77b054c1569b14b7ac328"

URI_x86_64_v2_jbigkit-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/jbigkit-libs-2.1-31.el10.x86_64_v2.rpm;name=x86_64_v2_jbigkit-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jbigkit-libs}"
SRC_URI[x86_64_v2_jbigkit-libs.sha256sum] = "fdec2d6e1688a59aea26026b39e70bffc84bc9e81f91ffdff80107ba7a49acaa"

URI_aarch64_jbigkit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/jbigkit-2.1-31.el10.aarch64.rpm;name=aarch64_jbigkit;unpack=0"
SRC_URI:append = " ${URI_aarch64_jbigkit}"
SRC_URI[aarch64_jbigkit.sha256sum] = "032b0a5874935beccfe51f40c03d01dfea5131a530917b2ef24512c76290297d"

URI_aarch64_jbigkit-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jbigkit-devel-2.1-31.el10.aarch64.rpm;name=aarch64_jbigkit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_jbigkit-devel}"
SRC_URI[aarch64_jbigkit-devel.sha256sum] = "7efacd41f6861f9f4af259b2bac08611e78bb68e632c6f27a75289fcc4751122"

URI_aarch64_jbigkit-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/jbigkit-libs-2.1-31.el10.aarch64.rpm;name=aarch64_jbigkit-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_jbigkit-libs}"
SRC_URI[aarch64_jbigkit-libs.sha256sum] = "b58402c34983a5efae3baa6dcb93279ce1547ad307803fffc6fa94d4a0e213ee"

RDEPENDS:jbigkit = " \
 glibc \
 jbigkit-libs \
 "
RDEPENDS:jbigkit-devel = " \
 jbigkit-libs \
 "
RDEPENDS:jbigkit-libs = " \
 glibc \
 "
