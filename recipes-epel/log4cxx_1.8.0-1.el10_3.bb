# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "log4cxx"
PV = "1.8.0"
PR = "1.el10_3"
PACKAGES = " \
 log4cxx \
 log4cxx-devel \
 log4cxx-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/log4cxx-1.8.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "51f99ac1caecc4e260dafc449d6be0adbf9cb95fc26c40ab1489108929b82c85"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/log4cxx-1.8.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_log4cxx;unpack=0"
SRC_URI[x86_64_v2_log4cxx.sha256sum] = "ddc4eeb746ebca93aadbe82b3d8d55007eb0079aaafe53ab65ddddae800f6f48"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/log4cxx-devel-1.8.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_log4cxx-devel;unpack=0"
SRC_URI[x86_64_v2_log4cxx-devel.sha256sum] = "08ba621b66b089ca611ebbd8402c9905882218fa88c83d5aa03f5fa48f7fb46d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/log4cxx-doc-1.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_log4cxx-doc;unpack=0"
SRC_URI[x86_64_v2_log4cxx-doc.sha256sum] = "0c8feea3f3a34235b60dac33e2ae6770fd214f6b911e45388290ca68e29c57ce"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/log4cxx-1.8.0-1.el10_3.aarch64.rpm;name=aarch64_log4cxx;unpack=0"
SRC_URI[aarch64_log4cxx.sha256sum] = "39ee94b156e4b9a1399e7b195b94795691cd0ff3c3886dca0daf1fd3f880d802"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/log4cxx-devel-1.8.0-1.el10_3.aarch64.rpm;name=aarch64_log4cxx-devel;unpack=0"
SRC_URI[aarch64_log4cxx-devel.sha256sum] = "9fed97e9167f6aebc15b6af645bbb5383f351c79ef218296903fbfbd3607f145"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/log4cxx-doc-1.8.0-1.el10_3.noarch.rpm;name=aarch64_log4cxx-doc;unpack=0"
SRC_URI[aarch64_log4cxx-doc.sha256sum] = "70b401ea5733e75aa86fa1c5911a97ea4c068c27d6f310fbc18e178e0c18491d"

RDEPENDS:log4cxx = " \
 apr \
 apr-util \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:log4cxx-devel = " \
 apr-devel \
 apr-util-devel \
 cmake-filesystem \
 log4cxx \
 pkgconf-pkg-config \
 "
RDEPENDS:log4cxx-doc = " \
 "
