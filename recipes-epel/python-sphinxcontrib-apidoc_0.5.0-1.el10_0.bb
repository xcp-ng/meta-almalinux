# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sphinxcontrib-apidoc"
PV = "0.5.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-sphinxcontrib-apidoc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-sphinxcontrib-apidoc-0.5.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2eae39652bd65c2532b32d7ba314a3b3a5a7ed5808dc325376f26881c29a2f83"

URI_x86_64_v2_python3-sphinxcontrib-apidoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sphinxcontrib-apidoc-0.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sphinxcontrib-apidoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sphinxcontrib-apidoc}"
SRC_URI[x86_64_v2_python3-sphinxcontrib-apidoc.sha256sum] = "386ebc196961c81f2162e189c683133740b0f31c4ae310d03e40c99e0413e776"

URI_aarch64_python3-sphinxcontrib-apidoc = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sphinxcontrib-apidoc-0.5.0-1.el10_0.noarch.rpm;name=aarch64_python3-sphinxcontrib-apidoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sphinxcontrib-apidoc}"
SRC_URI[aarch64_python3-sphinxcontrib-apidoc.sha256sum] = "627fec68a739499a2992304958d4d6df533c0c1a3b57cab7cef310080f6a771f"

RDEPENDS:python3-sphinxcontrib-apidoc = " \
 python3 \
 python3-pbr \
 python3-sphinx \
 "
