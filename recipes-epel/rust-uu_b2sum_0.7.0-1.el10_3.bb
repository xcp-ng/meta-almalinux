# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_b2sum"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_b2sum+default-devel \
 rust-uu_b2sum-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_b2sum-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8379a9361f8419166d5cca142feabe03a52a0beee9ea8d0b9a52ae2834e2e1a1"

URI_x86_64_v2_rust-uu_b2sum+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_b2sum+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_b2sum+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_b2sum+default-devel}"
SRC_URI[x86_64_v2_rust-uu_b2sum+default-devel.sha256sum] = "3c22c87f5f3cc3264f482dac7b9a8f24c5e59e59dc1eb0eebf499fba046e7712"

URI_x86_64_v2_rust-uu_b2sum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_b2sum-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_b2sum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_b2sum-devel}"
SRC_URI[x86_64_v2_rust-uu_b2sum-devel.sha256sum] = "6e0f099285dd326a17d130223b5c58f5ef4678e6a2c2dad4808e1233f03d83b3"

URI_aarch64_rust-uu_b2sum+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_b2sum+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_b2sum+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_b2sum+default-devel}"
SRC_URI[aarch64_rust-uu_b2sum+default-devel.sha256sum] = "b79f3b32e48011f9f68f3fd2766656a9a2b3d28330d64824e09b312b95f9bda3"

URI_aarch64_rust-uu_b2sum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_b2sum-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_b2sum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_b2sum-devel}"
SRC_URI[aarch64_rust-uu_b2sum-devel.sha256sum] = "e0f0f9338d0d00a1d9a3e5965d49e88da2d55693d5d9bebb1fcebdab1d8e57f6"

RDEPENDS:rust-uu_b2sum+default-devel = " \
 cargo \
 rust-uu_b2sum-devel \
 "
RDEPENDS:rust-uu_b2sum-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uu_checksum_common+default-devel \
 rust-uucore+checksum-devel \
 rust-uucore+default-devel \
 rust-uucore+encoding-devel \
 rust-uucore+hardware-devel \
 rust-uucore+sum-devel \
 "
