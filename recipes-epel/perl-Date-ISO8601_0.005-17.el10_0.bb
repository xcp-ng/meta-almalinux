# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Date-ISO8601"
PV = "0.005"
PR = "17.el10_0"
PACKAGES = " \
 perl-Date-ISO8601 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Date-ISO8601-0.005-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec9662d8ade7bfea2f7ff2f3e570e4317b46bab9e6312abef718bb7b71c3c665"

URI_x86_64_v2_perl-Date-ISO8601 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Date-ISO8601-0.005-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Date-ISO8601;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Date-ISO8601}"
SRC_URI[x86_64_v2_perl-Date-ISO8601.sha256sum] = "c582d58ceca9e0a1433acb9441702ef2713175ca994f9f8d44d5df753bf9a79b"

URI_aarch64_perl-Date-ISO8601 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Date-ISO8601-0.005-17.el10_0.noarch.rpm;name=aarch64_perl-Date-ISO8601;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Date-ISO8601}"
SRC_URI[aarch64_perl-Date-ISO8601.sha256sum] = "7020227bd04656fe9e2e713b5f693fd2311ef513c59a0db8175f789bc2a7a90b"

RDEPENDS:perl-Date-ISO8601 = " \
 perl-Carp \
 perl-Exporter \
 perl-constant \
 perl-libs \
 perl-parent \
 "
