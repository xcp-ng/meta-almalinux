# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdump-utils"
PV = "1.0.54"
PR = "7.el10"
PACKAGES = " \
 kdump-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/kdump-utils-1.0.54-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a9b9e4d4fa6cc954ea206932886612978b5d00c4790f89fd42785d90a4408b5"

URI_x86_64_v2_kdump-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kdump-utils-1.0.54-7.el10.x86_64_v2.rpm;name=x86_64_v2_kdump-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdump-utils}"
SRC_URI[x86_64_v2_kdump-utils.sha256sum] = "83658cc7c8649e0b506e682ca14701938b9e6707f56e41c8c432096413edae79"

URI_aarch64_kdump-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kdump-utils-1.0.54-7.el10.aarch64.rpm;name=aarch64_kdump-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdump-utils}"
SRC_URI[aarch64_kdump-utils.sha256sum] = "247d27252f3cadc3e64aa3ae94c3248fa622fac98f565b39443505c5e15c1ac5"

RDEPENDS:kdump-utils = " \
 bash \
 dracut \
 dracut-network \
 dracut-squash \
 ethtool \
 kexec-tools \
 makedumpfile \
 sed \
 systemd-udev \
 util-linux \
 virtual/coreutils \
 "
