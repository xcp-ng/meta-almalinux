# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-notification"
PV = "0.3.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-colcon-notification \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-notification-0.3.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0938b145a2f40a986491ffd988e406db89992b053af646af7294cfcf0df3133a"

URI_x86_64_v2_python3-colcon-notification = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-notification-0.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-notification;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-notification}"
SRC_URI[x86_64_v2_python3-colcon-notification.sha256sum] = "5074606caa6acb346f5b41d91ea779b1d85ee67900051fb32970f7c9a2caf18f"

URI_aarch64_python3-colcon-notification = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-notification-0.3.0-1.el10_1.noarch.rpm;name=aarch64_python3-colcon-notification;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-notification}"
SRC_URI[aarch64_python3-colcon-notification.sha256sum] = "6e75f1cdb9d7bf84cecbc3f27a1a8bd04fccb0fb8899b8f9a5c8505a14a9faab"

RDEPENDS:python3-colcon-notification = " \
 python3 \
 python3-colcon-core \
 python3-notify2 \
 "
