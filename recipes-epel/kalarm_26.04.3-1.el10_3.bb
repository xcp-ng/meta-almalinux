# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kalarm"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kalarm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kalarm-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8bb67a10adb2435cab955f24b1aeca98269afbd2c4a4470ca4119fff449bb214"

URI_x86_64_v2_kalarm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kalarm-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kalarm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kalarm}"
SRC_URI[x86_64_v2_kalarm.sha256sum] = "55106d0cb0ecedf8824b80f73849ac6351f93a21e7efc0a58173af4468139578"

URI_aarch64_kalarm = "${EPEL_MIRROR}/aarch64/Packages/k/kalarm-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kalarm;unpack=0"
SRC_URI:append = " ${URI_aarch64_kalarm}"
SRC_URI[aarch64_kalarm.sha256sum] = "5c300c5653abf40166b210f615f4b69a2b8a66c65745a3d2efbdcb2aab4886f2"

RDEPENDS:kalarm = " \
 akonadi-contacts \
 akonadi-mime \
 akonadi-server \
 glibc \
 kcalutils \
 kf6-kauth \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kstatusnotifieritem \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kidentitymanagement \
 kmailtransport \
 kmime \
 libgcc \
 libstdc++ \
 mpv-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 vlc-libs \
 "
