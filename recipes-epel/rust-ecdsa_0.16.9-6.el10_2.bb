# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ecdsa"
PV = "0.16.9"
PR = "6.el10_2"
PACKAGES = " \
 rust-ecdsa+alloc-devel \
 rust-ecdsa+arithmetic-devel \
 rust-ecdsa+default-devel \
 rust-ecdsa+der-devel \
 rust-ecdsa+dev-devel \
 rust-ecdsa+digest-devel \
 rust-ecdsa+hazmat-devel \
 rust-ecdsa+pem-devel \
 rust-ecdsa+pkcs8-devel \
 rust-ecdsa+rfc6979-devel \
 rust-ecdsa+serde-devel \
 rust-ecdsa+serdect-devel \
 rust-ecdsa+sha2-devel \
 rust-ecdsa+signing-devel \
 rust-ecdsa+spki-devel \
 rust-ecdsa+std-devel \
 rust-ecdsa+verifying-devel \
 rust-ecdsa-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ecdsa-0.16.9-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4ffa5a58115fefda87417bb04d61d2fafbcb5efd45fd4db0ee65b2587b577c9"

URI_x86_64_v2_rust-ecdsa+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+alloc-devel-0.16.9-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+alloc-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+alloc-devel.sha256sum] = "fbed043ca27bca4a2d9784c11eb7b549fa03cb94537660153857f12897be1f20"

URI_x86_64_v2_rust-ecdsa+arithmetic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+arithmetic-devel-0.16.9-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+arithmetic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+arithmetic-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+arithmetic-devel.sha256sum] = "bc1bd1c9ad484b46c7b720f7749add20e8426992d7396848947205eb4d2574cc"

URI_x86_64_v2_rust-ecdsa+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+default-devel-0.16.9-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+default-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+default-devel.sha256sum] = "9603c3ff796394809f5095100818601289d1cf1812ac30ee9f8accdffcfd715a"

URI_x86_64_v2_rust-ecdsa+der-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+der-devel-0.16.9-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+der-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+der-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+der-devel.sha256sum] = "d31f5b3fcccd4103ed3600f9b73c0429941d0b79732001bc76c73bf2de4b5889"

URI_x86_64_v2_rust-ecdsa+dev-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+dev-devel-0.16.9-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+dev-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+dev-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+dev-devel.sha256sum] = "74e1fe0a9eaa2a5fbd429ffe8cdd2b6837c43be52ecc1d363bdce7eacb2d4746"

URI_x86_64_v2_rust-ecdsa+digest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+digest-devel-0.16.9-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+digest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+digest-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+digest-devel.sha256sum] = "596c07ef77717c3a4ef339dbbb6e62dd0f44fbc79a3331dac6e81843a94b5c5d"

URI_x86_64_v2_rust-ecdsa+hazmat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+hazmat-devel-0.16.9-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+hazmat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+hazmat-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+hazmat-devel.sha256sum] = "2815f7024b07d40274df355e0921551e1ade086fd3ecaddd6211c7c5eaa396b3"

URI_x86_64_v2_rust-ecdsa+pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+pem-devel-0.16.9-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+pem-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+pem-devel.sha256sum] = "f6a72ebbc2a2fceac2b43a1bb3a8cca940b5881504baddd25d0b700ea30417b6"

URI_x86_64_v2_rust-ecdsa+pkcs8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+pkcs8-devel-0.16.9-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+pkcs8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+pkcs8-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+pkcs8-devel.sha256sum] = "d405a3ec318ea6ce765caaff5dabf46555e32ae8097e126b048f2ebbe7c6cace"

URI_x86_64_v2_rust-ecdsa+rfc6979-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+rfc6979-devel-0.16.9-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+rfc6979-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+rfc6979-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+rfc6979-devel.sha256sum] = "9ba1c527c62463c9d34a57ad09131b4cc7e33ba7ca35d7f8c388995e36887d96"

URI_x86_64_v2_rust-ecdsa+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+serde-devel-0.16.9-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+serde-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+serde-devel.sha256sum] = "20fcd15bf628175783a67f843d8cdbbc737f980a84f3e27a82e9c5681d573cf3"

URI_x86_64_v2_rust-ecdsa+serdect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+serdect-devel-0.16.9-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+serdect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+serdect-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+serdect-devel.sha256sum] = "e01cdf28b999c6ea2130bfa206adb505e787e7ef6bdf37c8066ac5f10123df78"

URI_x86_64_v2_rust-ecdsa+sha2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+sha2-devel-0.16.9-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+sha2-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+sha2-devel.sha256sum] = "c4fedb5976385dd857ebc791320cacbdfee5b376198d87e5804c1a59f521cda3"

URI_x86_64_v2_rust-ecdsa+signing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+signing-devel-0.16.9-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+signing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+signing-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+signing-devel.sha256sum] = "5dd281041a6546f052c61d270777bf633ac15d05d826b4da9bd581ea79dd60b6"

URI_x86_64_v2_rust-ecdsa+spki-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+spki-devel-0.16.9-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+spki-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+spki-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+spki-devel.sha256sum] = "351ecdf0b3cd48c6d79ec80061df04514f10515ebd7132ed8b1153c6aed142cf"

URI_x86_64_v2_rust-ecdsa+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+std-devel-0.16.9-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+std-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+std-devel.sha256sum] = "cbb427d35374c4858aff9079fed6bbb7c9ec50d87acc590c0e2aea04745729b5"

URI_x86_64_v2_rust-ecdsa+verifying-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa+verifying-devel-0.16.9-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa+verifying-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa+verifying-devel}"
SRC_URI[x86_64_v2_rust-ecdsa+verifying-devel.sha256sum] = "2d0d03890c01f7d9e48461bbdbc44af609eed70ac9571468df84ebb7b2b04df2"

URI_x86_64_v2_rust-ecdsa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecdsa-devel-0.16.9-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecdsa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecdsa-devel}"
SRC_URI[x86_64_v2_rust-ecdsa-devel.sha256sum] = "1a22a21fbf19c7266d807a043c46ac6b88a75c66ba881cc53733d70982caf39b"

URI_aarch64_rust-ecdsa+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+alloc-devel-0.16.9-6.el10_2.noarch.rpm;name=aarch64_rust-ecdsa+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+alloc-devel}"
SRC_URI[aarch64_rust-ecdsa+alloc-devel.sha256sum] = "133572b9402bbae33f9176bb38554250258a1444696e458a345cf0a8d426a972"

URI_aarch64_rust-ecdsa+arithmetic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+arithmetic-devel-0.16.9-6.el10_2.noarch.rpm;name=aarch64_rust-ecdsa+arithmetic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+arithmetic-devel}"
SRC_URI[aarch64_rust-ecdsa+arithmetic-devel.sha256sum] = "76dbba25cf39c5d3fd22ab8b7ecb023a710d844c2d40d3f5dca5268ba769dd6b"

URI_aarch64_rust-ecdsa+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+default-devel-0.16.9-6.el10_2.noarch.rpm;name=aarch64_rust-ecdsa+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+default-devel}"
SRC_URI[aarch64_rust-ecdsa+default-devel.sha256sum] = "64043345f8ab588fcf42c975db4b091f8a3869964b466a7b53d71c66e12a18b6"

URI_aarch64_rust-ecdsa+der-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+der-devel-0.16.9-6.el10_2.noarch.rpm;name=aarch64_rust-ecdsa+der-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+der-devel}"
SRC_URI[aarch64_rust-ecdsa+der-devel.sha256sum] = "b8c02a8ec4510057e5b17baa7c29e5bb7ead7e515f9e5ab6b946d39220d4be91"

URI_aarch64_rust-ecdsa+dev-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+dev-devel-0.16.9-6.el10_2.noarch.rpm;name=aarch64_rust-ecdsa+dev-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+dev-devel}"
SRC_URI[aarch64_rust-ecdsa+dev-devel.sha256sum] = "41dc15fb953ea33a02ea4b52fc5475f20981a5335e85752a14940883d08e3c9a"

URI_aarch64_rust-ecdsa+digest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+digest-devel-0.16.9-6.el10_2.noarch.rpm;name=aarch64_rust-ecdsa+digest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+digest-devel}"
SRC_URI[aarch64_rust-ecdsa+digest-devel.sha256sum] = "8af962aa17daa6b677313926650a4a797903f37686d1e96b3b47e361e09d03bb"

URI_aarch64_rust-ecdsa+hazmat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+hazmat-devel-0.16.9-6.el10_2.noarch.rpm;name=aarch64_rust-ecdsa+hazmat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+hazmat-devel}"
SRC_URI[aarch64_rust-ecdsa+hazmat-devel.sha256sum] = "6de3a1db9131c3a3af54f0d3b6538f96eaa65a05d1bd96c37609e9def1eff4a3"

URI_aarch64_rust-ecdsa+pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+pem-devel-0.16.9-6.el10_2.noarch.rpm;name=aarch64_rust-ecdsa+pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+pem-devel}"
SRC_URI[aarch64_rust-ecdsa+pem-devel.sha256sum] = "0fd5b8f8561010a7bc4a4afaf0e78535389970d1381890af8803e2d19d25f99f"

URI_aarch64_rust-ecdsa+pkcs8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+pkcs8-devel-0.16.9-6.el10_2.noarch.rpm;name=aarch64_rust-ecdsa+pkcs8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+pkcs8-devel}"
SRC_URI[aarch64_rust-ecdsa+pkcs8-devel.sha256sum] = "716f6d1468080a4651542ccdec6c7ad3e6b345006d074f4f8674ec404bbcb91d"

URI_aarch64_rust-ecdsa+rfc6979-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+rfc6979-devel-0.16.9-6.el10_2.noarch.rpm;name=aarch64_rust-ecdsa+rfc6979-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+rfc6979-devel}"
SRC_URI[aarch64_rust-ecdsa+rfc6979-devel.sha256sum] = "064921e22716ef1c79bb2da29d0f6860f60d860ade736eace612d3927d25114a"

URI_aarch64_rust-ecdsa+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+serde-devel-0.16.9-6.el10_2.noarch.rpm;name=aarch64_rust-ecdsa+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+serde-devel}"
SRC_URI[aarch64_rust-ecdsa+serde-devel.sha256sum] = "5f11449056a92a650f4f2d2f3c0b73f6c0402ca34a5d26652707cb4f998c3b77"

URI_aarch64_rust-ecdsa+serdect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+serdect-devel-0.16.9-6.el10_2.noarch.rpm;name=aarch64_rust-ecdsa+serdect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+serdect-devel}"
SRC_URI[aarch64_rust-ecdsa+serdect-devel.sha256sum] = "92bea64e5be4130dc8dfca19ef30d2c367fb21e90fe256a175f66400ecdb70c0"

URI_aarch64_rust-ecdsa+sha2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+sha2-devel-0.16.9-6.el10_2.noarch.rpm;name=aarch64_rust-ecdsa+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+sha2-devel}"
SRC_URI[aarch64_rust-ecdsa+sha2-devel.sha256sum] = "8f85191e75fefeacf6a1c2463ee9f6582ed214b03e425af5136d70cf9caf6279"

URI_aarch64_rust-ecdsa+signing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+signing-devel-0.16.9-6.el10_2.noarch.rpm;name=aarch64_rust-ecdsa+signing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+signing-devel}"
SRC_URI[aarch64_rust-ecdsa+signing-devel.sha256sum] = "8a7fb9b4ace3dabcd79565b36520e6658b5ec2d0e4b4bb3cd082235748b198a4"

URI_aarch64_rust-ecdsa+spki-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+spki-devel-0.16.9-6.el10_2.noarch.rpm;name=aarch64_rust-ecdsa+spki-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+spki-devel}"
SRC_URI[aarch64_rust-ecdsa+spki-devel.sha256sum] = "2d6654039f0e02f8c169a45e569aab4808b36bfd37e98df9e0647d650c98c3c8"

URI_aarch64_rust-ecdsa+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+std-devel-0.16.9-6.el10_2.noarch.rpm;name=aarch64_rust-ecdsa+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+std-devel}"
SRC_URI[aarch64_rust-ecdsa+std-devel.sha256sum] = "dceb5aef6a434e1f3d428262e5d857de004551ec6dd22bd5fc8d794d780ba42e"

URI_aarch64_rust-ecdsa+verifying-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa+verifying-devel-0.16.9-6.el10_2.noarch.rpm;name=aarch64_rust-ecdsa+verifying-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa+verifying-devel}"
SRC_URI[aarch64_rust-ecdsa+verifying-devel.sha256sum] = "2bcc4b2f94912bd7f89de25b2ae0ccf84323a56ff67b3b067bd1cd1550754cc2"

URI_aarch64_rust-ecdsa-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecdsa-devel-0.16.9-6.el10_2.noarch.rpm;name=aarch64_rust-ecdsa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecdsa-devel}"
SRC_URI[aarch64_rust-ecdsa-devel.sha256sum] = "ac0aa72643ff5acebbe74fdc5f837fcd5fd7d3c918ac9c85419bcafcad665ee0"

RDEPENDS:rust-ecdsa+alloc-devel = " \
 cargo \
 rust-ecdsa-devel \
 rust-elliptic-curve+alloc-devel \
 rust-signature+alloc-devel \
 rust-spki0.7+alloc-devel \
 rust-spki0.7-devel \
 "
RDEPENDS:rust-ecdsa+arithmetic-devel = " \
 cargo \
 rust-ecdsa-devel \
 rust-elliptic-curve+arithmetic-devel \
 "
RDEPENDS:rust-ecdsa+default-devel = " \
 cargo \
 rust-ecdsa+digest-devel \
 rust-ecdsa-devel \
 "
RDEPENDS:rust-ecdsa+der-devel = " \
 cargo \
 rust-der0.7+default-devel \
 rust-ecdsa-devel \
 "
RDEPENDS:rust-ecdsa+dev-devel = " \
 cargo \
 rust-ecdsa+arithmetic-devel \
 rust-ecdsa+digest-devel \
 rust-ecdsa+hazmat-devel \
 rust-ecdsa-devel \
 rust-elliptic-curve+dev-devel \
 "
RDEPENDS:rust-ecdsa+digest-devel = " \
 cargo \
 rust-digest0.10+oid-devel \
 rust-digest0.10-devel \
 rust-ecdsa-devel \
 rust-signature+digest-devel \
 "
RDEPENDS:rust-ecdsa+hazmat-devel = " \
 cargo \
 rust-ecdsa-devel \
 "
RDEPENDS:rust-ecdsa+pem-devel = " \
 cargo \
 rust-ecdsa+pkcs8-devel \
 rust-ecdsa-devel \
 rust-elliptic-curve+pem-devel \
 "
RDEPENDS:rust-ecdsa+pkcs8-devel = " \
 cargo \
 rust-ecdsa+der-devel \
 rust-ecdsa+digest-devel \
 rust-ecdsa-devel \
 rust-elliptic-curve+pkcs8-devel \
 "
RDEPENDS:rust-ecdsa+rfc6979-devel = " \
 cargo \
 rust-ecdsa-devel \
 rust-rfc6979+default-devel \
 "
RDEPENDS:rust-ecdsa+serde-devel = " \
 cargo \
 rust-ecdsa+serdect-devel \
 rust-ecdsa-devel \
 rust-elliptic-curve+serde-devel \
 "
RDEPENDS:rust-ecdsa+serdect-devel = " \
 cargo \
 rust-ecdsa-devel \
 rust-serdect0.2+alloc-devel \
 rust-serdect0.2-devel \
 "
RDEPENDS:rust-ecdsa+sha2-devel = " \
 cargo \
 rust-ecdsa-devel \
 rust-sha2_0.10+oid-devel \
 rust-sha2_0.10-devel \
 "
RDEPENDS:rust-ecdsa+signing-devel = " \
 cargo \
 rust-ecdsa+arithmetic-devel \
 rust-ecdsa+digest-devel \
 rust-ecdsa+hazmat-devel \
 rust-ecdsa+rfc6979-devel \
 rust-ecdsa-devel \
 "
RDEPENDS:rust-ecdsa+spki-devel = " \
 cargo \
 rust-ecdsa-devel \
 rust-spki0.7-devel \
 "
RDEPENDS:rust-ecdsa+std-devel = " \
 cargo \
 rust-ecdsa+alloc-devel \
 rust-ecdsa-devel \
 rust-elliptic-curve+std-devel \
 rust-signature+std-devel \
 "
RDEPENDS:rust-ecdsa+verifying-devel = " \
 cargo \
 rust-ecdsa+arithmetic-devel \
 rust-ecdsa+digest-devel \
 rust-ecdsa+hazmat-devel \
 rust-ecdsa-devel \
 "
RDEPENDS:rust-ecdsa-devel = " \
 cargo \
 rust \
 rust-elliptic-curve+digest-devel \
 rust-elliptic-curve+sec1-devel \
 rust-elliptic-curve-devel \
 rust-signature+rand_core-devel \
 rust-signature-devel \
 "
