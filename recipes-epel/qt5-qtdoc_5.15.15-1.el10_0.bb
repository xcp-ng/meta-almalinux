# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtdoc"
PV = "5.15.15"
PR = "1.el10_0"
PACKAGES = " \
 qt5-qtdoc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtdoc-5.15.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9bcb514afbdf8fec4cea52770bbda03689568835f43f31e46b3e835461c53a61"

URI_x86_64_v2_qt5-qtdoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtdoc-5.15.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtdoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtdoc}"
SRC_URI[x86_64_v2_qt5-qtdoc.sha256sum] = "bdf2d89cc1dbc01d93ae8d48415a7d675a242a1ec7cb6dd30fcf245ddd557959"

URI_aarch64_qt5-qtdoc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtdoc-5.15.15-1.el10_0.noarch.rpm;name=aarch64_qt5-qtdoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtdoc}"
SRC_URI[aarch64_qt5-qtdoc.sha256sum] = "b50cde8affc67d8225ae164827fa0b955fa6ba15e31b7494f4332020fc73182a"

RDEPENDS:qt5-qtdoc = " \
 "
