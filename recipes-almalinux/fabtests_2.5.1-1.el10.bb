# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fabtests"
PV = "2.5.1"
PR = "1.el10"
PACKAGES = " \
 fabtests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/fabtests-2.5.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d39b80a51757729e5c155aab5453fb103f819218aa706f80418c7069a822c076"

URI_x86_64_v2_fabtests = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/fabtests-2.5.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_fabtests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fabtests}"
SRC_URI[x86_64_v2_fabtests.sha256sum] = "40e368d6bb717a8498eaeef2a8ffbcb33ea96a75702f4d47b2a5094e183054c5"

URI_aarch64_fabtests = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/fabtests-2.5.1-1.el10.aarch64.rpm;name=aarch64_fabtests;unpack=0"
SRC_URI:append = " ${URI_aarch64_fabtests}"
SRC_URI[aarch64_fabtests.sha256sum] = "37b5f957d331b3be1f0d8451ddd561b821969cb6499ac9f77bd8370a9c568bd0"

RDEPENDS:fabtests = " \
 bash \
 glibc \
 libfabric \
 python3 \
 python3-pytest \
 ruby \
 "
