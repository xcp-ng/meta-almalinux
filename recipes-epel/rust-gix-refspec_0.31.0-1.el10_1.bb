# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-refspec"
PV = "0.31.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-refspec+default-devel \
 rust-gix-refspec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-refspec-0.31.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b233852ee65920ea7ed960a0b6fa2ecde27c9847aa8a3722a2ab0f1b709f6c03"

URI_x86_64_v2_rust-gix-refspec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-refspec+default-devel-0.31.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-refspec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-refspec+default-devel}"
SRC_URI[x86_64_v2_rust-gix-refspec+default-devel.sha256sum] = "e889ed7b5298f152ff8fb4f935ab4ff71e01dd8e6061547c65fed15a2d374095"

URI_x86_64_v2_rust-gix-refspec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-refspec-devel-0.31.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-refspec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-refspec-devel}"
SRC_URI[x86_64_v2_rust-gix-refspec-devel.sha256sum] = "7e58894b8042ef2c3c1d267b00f53a57764d149102a26f96714dfad25bb91dbb"

URI_aarch64_rust-gix-refspec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-refspec+default-devel-0.31.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-refspec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-refspec+default-devel}"
SRC_URI[aarch64_rust-gix-refspec+default-devel.sha256sum] = "3b40834a2ed7f3ff18e7df9805b3abeb0661e6d96fbf41974a7fb864064417e7"

URI_aarch64_rust-gix-refspec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-refspec-devel-0.31.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-refspec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-refspec-devel}"
SRC_URI[aarch64_rust-gix-refspec-devel.sha256sum] = "58fbcc0ee9a811202569709a79ec0c19840d549fbfbda0f61e36b46a30426b4b"

RDEPENDS:rust-gix-refspec+default-devel = " \
 cargo \
 rust-gix-refspec-devel \
 "
RDEPENDS:rust-gix-refspec-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-hash+default-devel \
 rust-gix-revision-devel \
 rust-gix-validate+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 "
