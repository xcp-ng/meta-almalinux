# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_with_macros"
PV = "3.12.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-serde_with_macros+default-devel \
 rust-serde_with_macros+schemars_0_8-devel \
 rust-serde_with_macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_with_macros-3.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7863f1d93921e1dd15e86fc2dcf522e53e9e696d246fed80179bb7ca337c9306"

URI_x86_64_v2_rust-serde_with_macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with_macros+default-devel-3.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with_macros+default-devel}"
SRC_URI[x86_64_v2_rust-serde_with_macros+default-devel.sha256sum] = "6fafee41b6eb0b379359050e67d6bfb04c57a0a25bbffe2d36002b34775c20f5"

URI_x86_64_v2_rust-serde_with_macros+schemars_0_8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with_macros+schemars_0_8-devel-3.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with_macros+schemars_0_8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with_macros+schemars_0_8-devel}"
SRC_URI[x86_64_v2_rust-serde_with_macros+schemars_0_8-devel.sha256sum] = "e99e7e81450b688fa8828b239ed4d519c70865654d323d718d3e54335097bc30"

URI_x86_64_v2_rust-serde_with_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with_macros-devel-3.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with_macros-devel}"
SRC_URI[x86_64_v2_rust-serde_with_macros-devel.sha256sum] = "b843145ba9e0800d6ec2832a0225a2b25e2bb398ee52640b994058ee50c2d0c7"

URI_aarch64_rust-serde_with_macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with_macros+default-devel-3.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-serde_with_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with_macros+default-devel}"
SRC_URI[aarch64_rust-serde_with_macros+default-devel.sha256sum] = "31deaa0d18296b14e0d75b313afe0aa73c415bdf1667dca587afca1b2364f8d3"

URI_aarch64_rust-serde_with_macros+schemars_0_8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with_macros+schemars_0_8-devel-3.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-serde_with_macros+schemars_0_8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with_macros+schemars_0_8-devel}"
SRC_URI[aarch64_rust-serde_with_macros+schemars_0_8-devel.sha256sum] = "cededd6df315dc6013d147b772ed83f80c0f663f10f9abb0c5c23e98b32fdcf1"

URI_aarch64_rust-serde_with_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with_macros-devel-3.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-serde_with_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with_macros-devel}"
SRC_URI[aarch64_rust-serde_with_macros-devel.sha256sum] = "e95a0cafb8fe27dc21818540630b44ba3b5e2437d6b3e82ed7313c90351f5c3b"

RDEPENDS:rust-serde_with_macros+default-devel = " \
 cargo \
 rust-serde_with_macros-devel \
 "
RDEPENDS:rust-serde_with_macros+schemars_0_8-devel = " \
 cargo \
 rust-serde_with_macros-devel \
 "
RDEPENDS:rust-serde_with_macros-devel = " \
 cargo \
 rust \
 rust-darling+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 "
