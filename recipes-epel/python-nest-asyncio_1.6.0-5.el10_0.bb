# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-nest-asyncio"
PV = "1.6.0"
PR = "5.el10_0"
PACKAGES = " \
 python3-nest-asyncio \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-nest-asyncio-1.6.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "18bae927afdf7e31e08c78e7a86f2edaa2c3844f55024d5ca55b26388a512b88"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-nest-asyncio-1.6.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-nest-asyncio;unpack=0"
SRC_URI[x86_64_v2_python3-nest-asyncio.sha256sum] = "785e1f49a19a940e03bb7014819654d0b1da4f329a971e9ee02f9d1473331548"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-nest-asyncio-1.6.0-5.el10_0.noarch.rpm;name=aarch64_python3-nest-asyncio;unpack=0"
SRC_URI[aarch64_python3-nest-asyncio.sha256sum] = "eab9a77a3680eae589e7fece02de40e8c02328a7bb647ca0d2bddb05a48f914d"

RDEPENDS:python3-nest-asyncio = " \
 python3 \
 "
