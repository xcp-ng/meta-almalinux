# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-attributes"
PV = "0.33.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-attributes+default-devel \
 rust-gix-attributes+document-features-devel \
 rust-gix-attributes+serde-devel \
 rust-gix-attributes-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-attributes-0.33.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e16c63830c975c83f600a185a863dff399fe648cd5e48e9efb9990e8b3a33b6"

URI_x86_64_v2_rust-gix-attributes+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-attributes+default-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-attributes+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-attributes+default-devel}"
SRC_URI[x86_64_v2_rust-gix-attributes+default-devel.sha256sum] = "e4ccc54df5520f5c625e26007c03a880b0f64ba88fe7b99daf27858e64ca7733"

URI_x86_64_v2_rust-gix-attributes+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-attributes+document-features-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-attributes+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-attributes+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-attributes+document-features-devel.sha256sum] = "260253af8bc7f245dee3a7a5b2ad15d9198722071e93df23a9a35e6856fa8735"

URI_x86_64_v2_rust-gix-attributes+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-attributes+serde-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-attributes+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-attributes+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-attributes+serde-devel.sha256sum] = "3c4e4b17a6e78e1f5121d7c87fdee1c9e8510d3756e8e11f1f28b440c3377bf4"

URI_x86_64_v2_rust-gix-attributes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-attributes-devel-0.33.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-attributes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-attributes-devel}"
SRC_URI[x86_64_v2_rust-gix-attributes-devel.sha256sum] = "98f86fdf98faa5750087b992a94e73ff8f414a31d3fe6a8836f7a9e6a37e1585"

URI_aarch64_rust-gix-attributes+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-attributes+default-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-attributes+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-attributes+default-devel}"
SRC_URI[aarch64_rust-gix-attributes+default-devel.sha256sum] = "c45b63e58dc8c57c68bb6bf57f2b2e27d29c8a22479bf9590b59ffc123e40613"

URI_aarch64_rust-gix-attributes+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-attributes+document-features-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-attributes+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-attributes+document-features-devel}"
SRC_URI[aarch64_rust-gix-attributes+document-features-devel.sha256sum] = "4df33ff702df678854c4bf0e218d1eb1ae2ea6b24308748f5ab91c2551e5d19b"

URI_aarch64_rust-gix-attributes+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-attributes+serde-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-attributes+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-attributes+serde-devel}"
SRC_URI[aarch64_rust-gix-attributes+serde-devel.sha256sum] = "7ad8a2c481ecd384fa63d0f18e6b3fbcebe59a94b3e6202c255b2e123380cf21"

URI_aarch64_rust-gix-attributes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-attributes-devel-0.33.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-attributes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-attributes-devel}"
SRC_URI[aarch64_rust-gix-attributes-devel.sha256sum] = "38a79b313faa77c68fd0b1945c9f38142446340f9d726c214cb5ca1f015c1f4d"

RDEPENDS:rust-gix-attributes+default-devel = " \
 cargo \
 rust-gix-attributes-devel \
 "
RDEPENDS:rust-gix-attributes+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-attributes-devel \
 "
RDEPENDS:rust-gix-attributes+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-attributes-devel \
 rust-gix-glob+serde-devel \
 rust-kstring+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-attributes-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-glob+default-devel \
 rust-gix-path+default-devel \
 rust-gix-quote+default-devel \
 rust-gix-trace+default-devel \
 rust-kstring+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 rust-unicode-bom+default-devel \
 "
