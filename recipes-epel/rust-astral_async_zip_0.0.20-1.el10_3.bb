# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-astral_async_zip"
PV = "0.0.20"
PR = "1.el10_3"
PACKAGES = " \
 rust-astral_async_zip+async-compression-devel \
 rust-astral_async_zip+bzip2-devel \
 rust-astral_async_zip+default-devel \
 rust-astral_async_zip+deflate-devel \
 rust-astral_async_zip+deflate64-devel \
 rust-astral_async_zip+full-devel \
 rust-astral_async_zip+jiff-devel \
 rust-astral_async_zip+lzma-devel \
 rust-astral_async_zip+tokio-devel \
 rust-astral_async_zip+tokio-fs-devel \
 rust-astral_async_zip+tokio-util-devel \
 rust-astral_async_zip+xz-devel \
 rust-astral_async_zip+zstd-devel \
 rust-astral_async_zip-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-astral_async_zip-0.0.20-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8fd6397d22d1f1a3e83bba3ce1b2f843fa89a4586f29b9daeea8858940da5d4e"

URI_x86_64_v2_rust-astral_async_zip+async-compression-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral_async_zip+async-compression-devel-0.0.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral_async_zip+async-compression-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral_async_zip+async-compression-devel}"
SRC_URI[x86_64_v2_rust-astral_async_zip+async-compression-devel.sha256sum] = "72165737e0129506dd1ec976e55f30d024a5a02deff4411b5d9c88191500d880"

URI_x86_64_v2_rust-astral_async_zip+bzip2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral_async_zip+bzip2-devel-0.0.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral_async_zip+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral_async_zip+bzip2-devel}"
SRC_URI[x86_64_v2_rust-astral_async_zip+bzip2-devel.sha256sum] = "bed2b3a66f83ab5eacb70e3b0e3e4d358d1c07167093983ca61cbd8af29a8a2a"

URI_x86_64_v2_rust-astral_async_zip+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral_async_zip+default-devel-0.0.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral_async_zip+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral_async_zip+default-devel}"
SRC_URI[x86_64_v2_rust-astral_async_zip+default-devel.sha256sum] = "c80716292f4d5e7aac8625a9bfe109761eb39b8eca480ebe72e76466ffb3f9d6"

URI_x86_64_v2_rust-astral_async_zip+deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral_async_zip+deflate-devel-0.0.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral_async_zip+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral_async_zip+deflate-devel}"
SRC_URI[x86_64_v2_rust-astral_async_zip+deflate-devel.sha256sum] = "63269cd4395217a760f5a2e2ff68ee52e89a83779eb906153bd90d649530644c"

URI_x86_64_v2_rust-astral_async_zip+deflate64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral_async_zip+deflate64-devel-0.0.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral_async_zip+deflate64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral_async_zip+deflate64-devel}"
SRC_URI[x86_64_v2_rust-astral_async_zip+deflate64-devel.sha256sum] = "5182898e576dced44a317a19e28bdc5a1a54ef2e4124614fefa1ad39aed4a236"

URI_x86_64_v2_rust-astral_async_zip+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral_async_zip+full-devel-0.0.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral_async_zip+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral_async_zip+full-devel}"
SRC_URI[x86_64_v2_rust-astral_async_zip+full-devel.sha256sum] = "c906ff07e74328af11768dbcb1f9c5e61822fb4a5f8f493731ff67dfa6c42dbf"

URI_x86_64_v2_rust-astral_async_zip+jiff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral_async_zip+jiff-devel-0.0.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral_async_zip+jiff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral_async_zip+jiff-devel}"
SRC_URI[x86_64_v2_rust-astral_async_zip+jiff-devel.sha256sum] = "7eddbf58b3c45b25269d68a44ae0ffed9855310054f1c68daa1cf8f871c97ff0"

URI_x86_64_v2_rust-astral_async_zip+lzma-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral_async_zip+lzma-devel-0.0.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral_async_zip+lzma-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral_async_zip+lzma-devel}"
SRC_URI[x86_64_v2_rust-astral_async_zip+lzma-devel.sha256sum] = "7370a49b88349f53cfc6e76c80e56d3d3165d84f8cf88c37dcf431d4428a57d1"

URI_x86_64_v2_rust-astral_async_zip+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral_async_zip+tokio-devel-0.0.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral_async_zip+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral_async_zip+tokio-devel}"
SRC_URI[x86_64_v2_rust-astral_async_zip+tokio-devel.sha256sum] = "df5bc43d2407d6f574202dcabcee141536e3fbc745498e0d7156e702f99858ec"

URI_x86_64_v2_rust-astral_async_zip+tokio-fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral_async_zip+tokio-fs-devel-0.0.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral_async_zip+tokio-fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral_async_zip+tokio-fs-devel}"
SRC_URI[x86_64_v2_rust-astral_async_zip+tokio-fs-devel.sha256sum] = "435ae1ba6b616c931ef9c4a7669929ab65f35274b880cdc5cd741ff150e32cb3"

URI_x86_64_v2_rust-astral_async_zip+tokio-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral_async_zip+tokio-util-devel-0.0.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral_async_zip+tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral_async_zip+tokio-util-devel}"
SRC_URI[x86_64_v2_rust-astral_async_zip+tokio-util-devel.sha256sum] = "edacb85ba2d3f66f0bced0aafa093684f54d190d104ef484f47bcb31cb89dbb5"

URI_x86_64_v2_rust-astral_async_zip+xz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral_async_zip+xz-devel-0.0.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral_async_zip+xz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral_async_zip+xz-devel}"
SRC_URI[x86_64_v2_rust-astral_async_zip+xz-devel.sha256sum] = "7970e40dcdd2dcf0e96b0fdd1328c9b83838426da6a0ff33d717deb03080d92d"

URI_x86_64_v2_rust-astral_async_zip+zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral_async_zip+zstd-devel-0.0.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral_async_zip+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral_async_zip+zstd-devel}"
SRC_URI[x86_64_v2_rust-astral_async_zip+zstd-devel.sha256sum] = "8284a0476f5c594b318e8b9958de58a41aeeb6785aebbf6611940aea6d0860f0"

URI_x86_64_v2_rust-astral_async_zip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral_async_zip-devel-0.0.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral_async_zip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral_async_zip-devel}"
SRC_URI[x86_64_v2_rust-astral_async_zip-devel.sha256sum] = "dc8b4eb3e3eadb09de4833f3ad896854b911aa4b283aef93f9b5f946e33ee86b"

URI_aarch64_rust-astral_async_zip+async-compression-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral_async_zip+async-compression-devel-0.0.20-1.el10_3.noarch.rpm;name=aarch64_rust-astral_async_zip+async-compression-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral_async_zip+async-compression-devel}"
SRC_URI[aarch64_rust-astral_async_zip+async-compression-devel.sha256sum] = "5dabc5a00bf21e4b405e8c184815b36859e31da98e9bc2e81c9d4f1b953420ff"

URI_aarch64_rust-astral_async_zip+bzip2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral_async_zip+bzip2-devel-0.0.20-1.el10_3.noarch.rpm;name=aarch64_rust-astral_async_zip+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral_async_zip+bzip2-devel}"
SRC_URI[aarch64_rust-astral_async_zip+bzip2-devel.sha256sum] = "af6e70b280774c0419152c300bcb46d50937f45bfdb123bad487cbeac806f287"

URI_aarch64_rust-astral_async_zip+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral_async_zip+default-devel-0.0.20-1.el10_3.noarch.rpm;name=aarch64_rust-astral_async_zip+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral_async_zip+default-devel}"
SRC_URI[aarch64_rust-astral_async_zip+default-devel.sha256sum] = "8eb3266148fc37e233e7d22ed7a7295e03943d9d34c9763bba901e1c000ce6f2"

URI_aarch64_rust-astral_async_zip+deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral_async_zip+deflate-devel-0.0.20-1.el10_3.noarch.rpm;name=aarch64_rust-astral_async_zip+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral_async_zip+deflate-devel}"
SRC_URI[aarch64_rust-astral_async_zip+deflate-devel.sha256sum] = "6b51e7f87ab8ed3c1e958915fd8b6cb297034fd220551edb60b45adb96c30d4c"

URI_aarch64_rust-astral_async_zip+deflate64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral_async_zip+deflate64-devel-0.0.20-1.el10_3.noarch.rpm;name=aarch64_rust-astral_async_zip+deflate64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral_async_zip+deflate64-devel}"
SRC_URI[aarch64_rust-astral_async_zip+deflate64-devel.sha256sum] = "eea6715e0d31d9fa253caf067b97dafa3705d11854ba418026d86cfa58d00108"

URI_aarch64_rust-astral_async_zip+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral_async_zip+full-devel-0.0.20-1.el10_3.noarch.rpm;name=aarch64_rust-astral_async_zip+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral_async_zip+full-devel}"
SRC_URI[aarch64_rust-astral_async_zip+full-devel.sha256sum] = "e2588df3b3057fb5ff134f6f93774bc60d2d0ef4668fbff2c70944c7a34f8448"

URI_aarch64_rust-astral_async_zip+jiff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral_async_zip+jiff-devel-0.0.20-1.el10_3.noarch.rpm;name=aarch64_rust-astral_async_zip+jiff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral_async_zip+jiff-devel}"
SRC_URI[aarch64_rust-astral_async_zip+jiff-devel.sha256sum] = "e5271ce3c90b6041ed032e58c0847cebc8cf939218228d4e3c7d16feee671af7"

URI_aarch64_rust-astral_async_zip+lzma-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral_async_zip+lzma-devel-0.0.20-1.el10_3.noarch.rpm;name=aarch64_rust-astral_async_zip+lzma-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral_async_zip+lzma-devel}"
SRC_URI[aarch64_rust-astral_async_zip+lzma-devel.sha256sum] = "68a25cd8e0db1fa0430b1042513dab73c91a5e9eea12d94fcc20f51fc6617768"

URI_aarch64_rust-astral_async_zip+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral_async_zip+tokio-devel-0.0.20-1.el10_3.noarch.rpm;name=aarch64_rust-astral_async_zip+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral_async_zip+tokio-devel}"
SRC_URI[aarch64_rust-astral_async_zip+tokio-devel.sha256sum] = "d5dca0498b0ce1e28b8471cee84054d4bede981fce58b089890a6f0eb5917b49"

URI_aarch64_rust-astral_async_zip+tokio-fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral_async_zip+tokio-fs-devel-0.0.20-1.el10_3.noarch.rpm;name=aarch64_rust-astral_async_zip+tokio-fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral_async_zip+tokio-fs-devel}"
SRC_URI[aarch64_rust-astral_async_zip+tokio-fs-devel.sha256sum] = "e3a71bfa529681150690a5e130135559d03e532f2487e6db7824036178d205d3"

URI_aarch64_rust-astral_async_zip+tokio-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral_async_zip+tokio-util-devel-0.0.20-1.el10_3.noarch.rpm;name=aarch64_rust-astral_async_zip+tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral_async_zip+tokio-util-devel}"
SRC_URI[aarch64_rust-astral_async_zip+tokio-util-devel.sha256sum] = "d290e07502ac87f0a87c8073f20b11c3b9f94051eca3ba4f79520cf8b8bf19fb"

URI_aarch64_rust-astral_async_zip+xz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral_async_zip+xz-devel-0.0.20-1.el10_3.noarch.rpm;name=aarch64_rust-astral_async_zip+xz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral_async_zip+xz-devel}"
SRC_URI[aarch64_rust-astral_async_zip+xz-devel.sha256sum] = "6047fc1f5ba618c989499e226fa645e0854014521be67774e452804e8c2b63fa"

URI_aarch64_rust-astral_async_zip+zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral_async_zip+zstd-devel-0.0.20-1.el10_3.noarch.rpm;name=aarch64_rust-astral_async_zip+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral_async_zip+zstd-devel}"
SRC_URI[aarch64_rust-astral_async_zip+zstd-devel.sha256sum] = "0750ef5dcafef420956ab3440c14d66e1cfa7f07923e72cbe1273edf7b63d0d6"

URI_aarch64_rust-astral_async_zip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral_async_zip-devel-0.0.20-1.el10_3.noarch.rpm;name=aarch64_rust-astral_async_zip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral_async_zip-devel}"
SRC_URI[aarch64_rust-astral_async_zip-devel.sha256sum] = "8f1cd83f42e11d1b2ec7a97874629c8f62120ff90c7405b24fcc58c57b6fd6f5"

RDEPENDS:rust-astral_async_zip+async-compression-devel = " \
 cargo \
 rust-astral_async_zip-devel \
 rust-async-compression+futures-io-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-astral_async_zip+bzip2-devel = " \
 cargo \
 rust-astral_async_zip-devel \
 rust-async-compression+bzip2-devel \
 rust-async-compression+futures-io-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-astral_async_zip+default-devel = " \
 cargo \
 rust-astral_async_zip-devel \
 "
RDEPENDS:rust-astral_async_zip+deflate-devel = " \
 cargo \
 rust-astral_async_zip-devel \
 rust-async-compression+deflate-devel \
 rust-async-compression+futures-io-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-astral_async_zip+deflate64-devel = " \
 cargo \
 rust-astral_async_zip-devel \
 rust-async-compression+deflate64-devel \
 rust-async-compression+futures-io-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-astral_async_zip+full-devel = " \
 cargo \
 rust-astral_async_zip+bzip2-devel \
 rust-astral_async_zip+deflate-devel \
 rust-astral_async_zip+deflate64-devel \
 rust-astral_async_zip+jiff-devel \
 rust-astral_async_zip+lzma-devel \
 rust-astral_async_zip+tokio-fs-devel \
 rust-astral_async_zip+xz-devel \
 rust-astral_async_zip+zstd-devel \
 rust-astral_async_zip-devel \
 "
RDEPENDS:rust-astral_async_zip+jiff-devel = " \
 cargo \
 rust-astral_async_zip-devel \
 rust-jiff+std-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-astral_async_zip+lzma-devel = " \
 cargo \
 rust-astral_async_zip-devel \
 rust-async-compression+futures-io-devel \
 rust-async-compression+lzma-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-astral_async_zip+tokio-devel = " \
 cargo \
 rust-astral_async_zip+tokio-util-devel \
 rust-astral_async_zip-devel \
 rust-tokio+io-util-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-astral_async_zip+tokio-fs-devel = " \
 cargo \
 rust-astral_async_zip-devel \
 rust-tokio+fs-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-astral_async_zip+tokio-util-devel = " \
 cargo \
 rust-astral_async_zip-devel \
 rust-tokio-util+compat-devel \
 rust-tokio-util+default-devel \
 "
RDEPENDS:rust-astral_async_zip+xz-devel = " \
 cargo \
 rust-astral_async_zip-devel \
 rust-async-compression+futures-io-devel \
 rust-async-compression+xz-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-astral_async_zip+zstd-devel = " \
 cargo \
 rust-astral_async_zip-devel \
 rust-async-compression+futures-io-devel \
 rust-async-compression+zstd-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-astral_async_zip-devel = " \
 cargo \
 rust-crc32fast+default-devel \
 rust-futures-lite+std-devel \
 rust-futures-lite-devel \
 rust-pin-project+default-devel \
 rust-thiserror+default-devel \
 "
