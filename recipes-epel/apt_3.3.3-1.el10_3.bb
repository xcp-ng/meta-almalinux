# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apt"
PV = "3.3.3"
PR = "1.el10_3"
PACKAGES = " \
 apt \
 apt-apidoc \
 apt-devel \
 apt-doc \
 apt-libs \
 apt-utils \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/apt-3.3.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "346f93d049e78eec342c351ad8a38d67f696eb6a69dd264c57d4c38d83bd3d5b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apt-3.3.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apt;unpack=0"
SRC_URI[x86_64_v2_apt.sha256sum] = "a000afd7b84b6bd412062e92d7b19ef031716b03f00da0a414722ade1d4ec55f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apt-apidoc-3.3.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_apt-apidoc;unpack=0"
SRC_URI[x86_64_v2_apt-apidoc.sha256sum] = "e055e76724ddb43c5bb811d88e030c7f4979f47ba0ab6d416c2dccbb102981b2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apt-devel-3.3.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apt-devel;unpack=0"
SRC_URI[x86_64_v2_apt-devel.sha256sum] = "68564587eee093d467470e66e2355cfd6a6222d3695b8c4780ca0b4976e591ef"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apt-doc-3.3.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_apt-doc;unpack=0"
SRC_URI[x86_64_v2_apt-doc.sha256sum] = "4be021adbee8e40e31e52e9279373b17faf4cb24c7ac3db06e801522ce149623"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apt-libs-3.3.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apt-libs;unpack=0"
SRC_URI[x86_64_v2_apt-libs.sha256sum] = "4ae77037f4dfedd9b576c9842d8c3ca9eeb6445ca33f2db991ed9066ca75fe40"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apt-utils-3.3.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apt-utils;unpack=0"
SRC_URI[x86_64_v2_apt-utils.sha256sum] = "e256b4b4b21be214a1b97e0de4a934719fd8638c9ccbccc9a0736b17d66b8f1d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/apt-3.3.3-1.el10_3.aarch64.rpm;name=aarch64_apt;unpack=0"
SRC_URI[aarch64_apt.sha256sum] = "18d6796a0d1ba15fb5e53342ed1b043bba0fbdfd425a7eea1fb782833841ae0b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/apt-apidoc-3.3.3-1.el10_3.noarch.rpm;name=aarch64_apt-apidoc;unpack=0"
SRC_URI[aarch64_apt-apidoc.sha256sum] = "51a6773b98dfe9bd5d4784a243116d10c3b6a25086f23006de2a02c46908b14a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/apt-devel-3.3.3-1.el10_3.aarch64.rpm;name=aarch64_apt-devel;unpack=0"
SRC_URI[aarch64_apt-devel.sha256sum] = "2ed5b09f8bcf5a4a8c516d1d617f1e1dee63e06a85ea8c135747b4d1f4c8b083"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/apt-doc-3.3.3-1.el10_3.noarch.rpm;name=aarch64_apt-doc;unpack=0"
SRC_URI[aarch64_apt-doc.sha256sum] = "61cd6d9d31ffcbadda25a16b0dd5b76540af11c24fd6fea64095f0a645c80c89"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/apt-libs-3.3.3-1.el10_3.aarch64.rpm;name=aarch64_apt-libs;unpack=0"
SRC_URI[aarch64_apt-libs.sha256sum] = "de8ba9bb7a2072d606df0ca64025e2463888f28f39279dcf8e951ddf4b6f71d3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/apt-utils-3.3.3-1.el10_3.aarch64.rpm;name=aarch64_apt-utils;unpack=0"
SRC_URI[aarch64_apt-utils.sha256sum] = "8670db3624c3f9584407ba1849db73c41b512370d1b6b198bc6f230a56ce4324"

RDEPENDS:apt = " \
 apt-libs \
 bash \
 dpkg \
 glibc \
 libgcc \
 libseccomp \
 libstdc++ \
 openssl-libs \
 systemd-libs \
 "
RDEPENDS:apt-apidoc = " \
 "
RDEPENDS:apt-devel = " \
 apt-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:apt-doc = " \
 "
RDEPENDS:apt-libs = " \
 bzip2-libs \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 lz4-libs \
 openssl-libs \
 systemd-libs \
 xxhash-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:apt-utils = " \
 apt \
 apt-libs \
 glibc \
 libdb \
 libgcc \
 libstdc++ \
 "
