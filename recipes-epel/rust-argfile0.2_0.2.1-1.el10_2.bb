# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-argfile0.2"
PV = "0.2.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-argfile0.2+default-devel \
 rust-argfile0.2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-argfile0.2-0.2.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a3f4c03fc48688c107c652dcf2a8c6711804d6ec3f4d00f7f18810c10fde1c78"

URI_x86_64_v2_rust-argfile0.2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argfile0.2+default-devel-0.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argfile0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argfile0.2+default-devel}"
SRC_URI[x86_64_v2_rust-argfile0.2+default-devel.sha256sum] = "eb7a7ede92798e92f37d2cae617efa5767ac4c330ce7ec7140b1f67d22162087"

URI_x86_64_v2_rust-argfile0.2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argfile0.2-devel-0.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argfile0.2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argfile0.2-devel}"
SRC_URI[x86_64_v2_rust-argfile0.2-devel.sha256sum] = "ac7078259172924918a78aac0fd12589dc100c9dca396b514256c7800f61284c"

URI_aarch64_rust-argfile0.2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argfile0.2+default-devel-0.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-argfile0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argfile0.2+default-devel}"
SRC_URI[aarch64_rust-argfile0.2+default-devel.sha256sum] = "7b1fe4b2a35ef4f24da2e3c35b16eea3e243549c1bc4b48941ae0c1b041ac924"

URI_aarch64_rust-argfile0.2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argfile0.2-devel-0.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-argfile0.2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argfile0.2-devel}"
SRC_URI[aarch64_rust-argfile0.2-devel.sha256sum] = "4ea719f2132ced16675f49acb4342e1f0b5e0be428ed270cd286e9dbe3aa2df3"

RDEPENDS:rust-argfile0.2+default-devel = " \
 cargo \
 rust-argfile0.2-devel \
 "
RDEPENDS:rust-argfile0.2-devel = " \
 cargo \
 rust \
 rust-fs-err2+default-devel \
 rust-os_str_bytes+default-devel \
 "
