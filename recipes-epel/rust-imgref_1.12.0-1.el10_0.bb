# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-imgref"
PV = "1.12.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-imgref+default-devel \
 rust-imgref+deprecated-devel \
 rust-imgref-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-imgref-1.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c39f44055371db82956de44c36f8da660a19d36aa4aca48c96af59dfdb62151b"

URI_x86_64_v2_rust-imgref+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imgref+default-devel-1.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imgref+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-imgref+default-devel}"
SRC_URI[x86_64_v2_rust-imgref+default-devel.sha256sum] = "b7260f9de612d4c178169663c9bab995c6e9974d8e3ce7611f66645b1e496653"

URI_x86_64_v2_rust-imgref+deprecated-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imgref+deprecated-devel-1.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imgref+deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-imgref+deprecated-devel}"
SRC_URI[x86_64_v2_rust-imgref+deprecated-devel.sha256sum] = "5aa55bd8f738fa43c135d6e98357dd8c533dc7f0598aa43548381978657a880b"

URI_x86_64_v2_rust-imgref-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imgref-devel-1.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imgref-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-imgref-devel}"
SRC_URI[x86_64_v2_rust-imgref-devel.sha256sum] = "05583df7ba2adfc7fc26b3b6f0d170f0545c749c10002fea26ac1e3543f08313"

URI_aarch64_rust-imgref+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-imgref+default-devel-1.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-imgref+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-imgref+default-devel}"
SRC_URI[aarch64_rust-imgref+default-devel.sha256sum] = "cd5fd2df35cfc115eea0053c2f2007fac425c2cc4a47e0e5854e1b8be699d158"

URI_aarch64_rust-imgref+deprecated-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-imgref+deprecated-devel-1.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-imgref+deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-imgref+deprecated-devel}"
SRC_URI[aarch64_rust-imgref+deprecated-devel.sha256sum] = "05db266520b4f12b9dddb4dd9dd10c78e4bdec3f1e8de6eff11992e7c7b92dbb"

URI_aarch64_rust-imgref-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-imgref-devel-1.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-imgref-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-imgref-devel}"
SRC_URI[aarch64_rust-imgref-devel.sha256sum] = "19393494e06f6af2535d05ea61d741c936739d6f670b8549d03c7578c9714c01"

RDEPENDS:rust-imgref+default-devel = " \
 cargo \
 rust-imgref+deprecated-devel \
 rust-imgref-devel \
 "
RDEPENDS:rust-imgref+deprecated-devel = " \
 cargo \
 rust-imgref-devel \
 "
RDEPENDS:rust-imgref-devel = " \
 cargo \
 rust \
 "
