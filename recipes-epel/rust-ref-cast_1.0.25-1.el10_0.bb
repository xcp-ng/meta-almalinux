# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ref-cast"
PV = "1.0.25"
PR = "1.el10_0"
PACKAGES = " \
 rust-ref-cast+default-devel \
 rust-ref-cast-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ref-cast-1.0.25-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4935987dc254f8286a1cb3193e0bbae6639de7d2a156a6253782804591f40f7f"

URI_x86_64_v2_rust-ref-cast+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ref-cast+default-devel-1.0.25-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ref-cast+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ref-cast+default-devel}"
SRC_URI[x86_64_v2_rust-ref-cast+default-devel.sha256sum] = "9a0f7e543ec87375bc489df95e5b544117f81fe431b597d9efa7655feaee2eb0"

URI_x86_64_v2_rust-ref-cast-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ref-cast-devel-1.0.25-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ref-cast-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ref-cast-devel}"
SRC_URI[x86_64_v2_rust-ref-cast-devel.sha256sum] = "b35b2762e9efc7091e4646e32f365892608f40725249ce55096d84a689b871e2"

URI_aarch64_rust-ref-cast+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ref-cast+default-devel-1.0.25-1.el10_0.noarch.rpm;name=aarch64_rust-ref-cast+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ref-cast+default-devel}"
SRC_URI[aarch64_rust-ref-cast+default-devel.sha256sum] = "deee8404f7457e9878ca9c92f8a5743aeda473529e688232ee5ed9218286debe"

URI_aarch64_rust-ref-cast-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ref-cast-devel-1.0.25-1.el10_0.noarch.rpm;name=aarch64_rust-ref-cast-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ref-cast-devel}"
SRC_URI[aarch64_rust-ref-cast-devel.sha256sum] = "f756c9bd2e465021965f6f429c038cf3206c8475c9ddbfea163b20ec03fbb076"

RDEPENDS:rust-ref-cast+default-devel = " \
 cargo \
 rust-ref-cast-devel \
 "
RDEPENDS:rust-ref-cast-devel = " \
 cargo \
 rust \
 rust-ref-cast-impl+default-devel \
 "
