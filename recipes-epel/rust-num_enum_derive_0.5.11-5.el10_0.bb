# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num_enum_derive"
PV = "0.5.11"
PR = "5.el10_0"
PACKAGES = " \
 rust-num_enum_derive+complex-expressions-devel \
 rust-num_enum_derive+default-devel \
 rust-num_enum_derive+external_doc-devel \
 rust-num_enum_derive+proc-macro-crate-devel \
 rust-num_enum_derive+std-devel \
 rust-num_enum_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-num_enum_derive-0.5.11-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd32068c88ca457e676eaf23be9cb9c1442020f4d6b867c831036dec069027da"

URI_x86_64_v2_rust-num_enum_derive+complex-expressions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num_enum_derive+complex-expressions-devel-0.5.11-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num_enum_derive+complex-expressions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num_enum_derive+complex-expressions-devel}"
SRC_URI[x86_64_v2_rust-num_enum_derive+complex-expressions-devel.sha256sum] = "240c7c37efa669723e461e5bf03f474eee4dc034bb907e6de49a24f966f26434"

URI_x86_64_v2_rust-num_enum_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num_enum_derive+default-devel-0.5.11-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num_enum_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num_enum_derive+default-devel}"
SRC_URI[x86_64_v2_rust-num_enum_derive+default-devel.sha256sum] = "1d02db678dacbdc5d908008dd7f378f7da2dd0627d6454469560edb0e742d32e"

URI_x86_64_v2_rust-num_enum_derive+external_doc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num_enum_derive+external_doc-devel-0.5.11-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num_enum_derive+external_doc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num_enum_derive+external_doc-devel}"
SRC_URI[x86_64_v2_rust-num_enum_derive+external_doc-devel.sha256sum] = "1672ee353690bb415e19302d8edc0a7805f818aee998fae38eec5a1e5cbc144c"

URI_x86_64_v2_rust-num_enum_derive+proc-macro-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num_enum_derive+proc-macro-crate-devel-0.5.11-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num_enum_derive+proc-macro-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num_enum_derive+proc-macro-crate-devel}"
SRC_URI[x86_64_v2_rust-num_enum_derive+proc-macro-crate-devel.sha256sum] = "944a1812c7535b310fa4f800c68134a3816a5de9421ce022474725f64c019db5"

URI_x86_64_v2_rust-num_enum_derive+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num_enum_derive+std-devel-0.5.11-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num_enum_derive+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num_enum_derive+std-devel}"
SRC_URI[x86_64_v2_rust-num_enum_derive+std-devel.sha256sum] = "eec45094511685660bfb8d69f59979056e2d208bfd8113425eb9ef2a7677c918"

URI_x86_64_v2_rust-num_enum_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num_enum_derive-devel-0.5.11-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num_enum_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num_enum_derive-devel}"
SRC_URI[x86_64_v2_rust-num_enum_derive-devel.sha256sum] = "ed9d57ba9063db463b2136628eb01de2e394733cf9649d49678332f8a078d423"

URI_aarch64_rust-num_enum_derive+complex-expressions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num_enum_derive+complex-expressions-devel-0.5.11-5.el10_0.noarch.rpm;name=aarch64_rust-num_enum_derive+complex-expressions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num_enum_derive+complex-expressions-devel}"
SRC_URI[aarch64_rust-num_enum_derive+complex-expressions-devel.sha256sum] = "59d76bdb14677081c591fc0d1d0261a7d5c7411f3e793d043b51eee501807417"

URI_aarch64_rust-num_enum_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num_enum_derive+default-devel-0.5.11-5.el10_0.noarch.rpm;name=aarch64_rust-num_enum_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num_enum_derive+default-devel}"
SRC_URI[aarch64_rust-num_enum_derive+default-devel.sha256sum] = "7439c6fe87a7c45b6694b33f783cbe6c99ac50a05fef7176f091584aed21a7c6"

URI_aarch64_rust-num_enum_derive+external_doc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num_enum_derive+external_doc-devel-0.5.11-5.el10_0.noarch.rpm;name=aarch64_rust-num_enum_derive+external_doc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num_enum_derive+external_doc-devel}"
SRC_URI[aarch64_rust-num_enum_derive+external_doc-devel.sha256sum] = "8886d18d9b10c4e1012f22748ba6756cee863d36def3bda0df149268ee66d71a"

URI_aarch64_rust-num_enum_derive+proc-macro-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num_enum_derive+proc-macro-crate-devel-0.5.11-5.el10_0.noarch.rpm;name=aarch64_rust-num_enum_derive+proc-macro-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num_enum_derive+proc-macro-crate-devel}"
SRC_URI[aarch64_rust-num_enum_derive+proc-macro-crate-devel.sha256sum] = "117bab2c0611a2f213fb09cf283188510338c4ad88f1acd42fc2fc4f45c265ed"

URI_aarch64_rust-num_enum_derive+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num_enum_derive+std-devel-0.5.11-5.el10_0.noarch.rpm;name=aarch64_rust-num_enum_derive+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num_enum_derive+std-devel}"
SRC_URI[aarch64_rust-num_enum_derive+std-devel.sha256sum] = "ad03dd6a873d9013d94683510cce85f96cc5e4408c32b568dde487031f07aee2"

URI_aarch64_rust-num_enum_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num_enum_derive-devel-0.5.11-5.el10_0.noarch.rpm;name=aarch64_rust-num_enum_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num_enum_derive-devel}"
SRC_URI[aarch64_rust-num_enum_derive-devel.sha256sum] = "c6d651fbbdda1c3c4cf55dc2eccd2f7c6d2ca0c39d72d073ef87e568ac1ab3c8"

RDEPENDS:rust-num_enum_derive+complex-expressions-devel = " \
 cargo \
 rust-num_enum_derive-devel \
 rust-syn1+full-devel \
 "
RDEPENDS:rust-num_enum_derive+default-devel = " \
 cargo \
 rust-num_enum_derive+std-devel \
 rust-num_enum_derive-devel \
 "
RDEPENDS:rust-num_enum_derive+external_doc-devel = " \
 cargo \
 rust-num_enum_derive-devel \
 "
RDEPENDS:rust-num_enum_derive+proc-macro-crate-devel = " \
 cargo \
 rust-num_enum_derive-devel \
 rust-proc-macro-crate+default-devel \
 "
RDEPENDS:rust-num_enum_derive+std-devel = " \
 cargo \
 rust-num_enum_derive+proc-macro-crate-devel \
 rust-num_enum_derive-devel \
 "
RDEPENDS:rust-num_enum_derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn1+default-devel \
 rust-syn1+parsing-devel \
 "
