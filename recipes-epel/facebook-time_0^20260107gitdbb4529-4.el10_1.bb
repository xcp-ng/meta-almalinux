# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "facebook-time"
PV = "0^20260107gitdbb4529"
PR = "4.el10_1"
PACKAGES = " \
 calnex \
 facebook-time-vendor-licenses \
 fbclock \
 ntpcheck \
 ntpresponder \
 pshark \
 ptp4u \
 ptpcheck \
 sptp \
 ziffy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/facebook-time-0^20260107gitdbb4529-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb4f6aae7cd7f2c3f96973f997e986546eb5ff7db4a33087a84122fd8d03b1f5"

URI_x86_64_v2_calnex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/calnex-0^20260107gitdbb4529-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_calnex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_calnex}"
SRC_URI[x86_64_v2_calnex.sha256sum] = "fd8a4a69f9ac22bdab2529cf6610e37b143d766468966bed318a9793026e0d1b"

URI_x86_64_v2_facebook-time-vendor-licenses = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/facebook-time-vendor-licenses-0^20260107gitdbb4529-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_facebook-time-vendor-licenses;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_facebook-time-vendor-licenses}"
SRC_URI[x86_64_v2_facebook-time-vendor-licenses.sha256sum] = "c5c93090e9e9372bb663ff07372ff7d862237e22ea8fd4004c6f45575d3cef32"

URI_x86_64_v2_fbclock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fbclock-0^20260107gitdbb4529-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fbclock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fbclock}"
SRC_URI[x86_64_v2_fbclock.sha256sum] = "2c78d042975c3e32c2f43551eb0fd73172d8c3e7d33a7499fcf71ec1e8625b51"

URI_x86_64_v2_ntpcheck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ntpcheck-0^20260107gitdbb4529-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ntpcheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ntpcheck}"
SRC_URI[x86_64_v2_ntpcheck.sha256sum] = "f4c33021dde6a9ac6ddbc208198f20374f0d48ebd3792106925ecee6f6b5e4b0"

URI_x86_64_v2_ntpresponder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ntpresponder-0^20260107gitdbb4529-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ntpresponder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ntpresponder}"
SRC_URI[x86_64_v2_ntpresponder.sha256sum] = "e24af020368ec802736f2d9577355cf0f1fb70300801731c064859729269d48d"

URI_x86_64_v2_pshark = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pshark-0^20260107gitdbb4529-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pshark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pshark}"
SRC_URI[x86_64_v2_pshark.sha256sum] = "d600a1079e269e63ba87e4b7708a50844cbeb904c1d3851965710a5f0967ea0f"

URI_x86_64_v2_ptp4u = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ptp4u-0^20260107gitdbb4529-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ptp4u;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ptp4u}"
SRC_URI[x86_64_v2_ptp4u.sha256sum] = "bd5d818d65bfc153a21ea48a4ddc0be888663cfeba416ccab44e1c665c328986"

URI_x86_64_v2_ptpcheck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ptpcheck-0^20260107gitdbb4529-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ptpcheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ptpcheck}"
SRC_URI[x86_64_v2_ptpcheck.sha256sum] = "497184550560b591ce10b2f5f406628de70ac08f6eb309c8433f0d901f1abf97"

URI_x86_64_v2_sptp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sptp-0^20260107gitdbb4529-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sptp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sptp}"
SRC_URI[x86_64_v2_sptp.sha256sum] = "9b9c52c1789a1e9a6b37e9c112f8a852e3999121f2fbdb6ada97e16d1185cba5"

URI_x86_64_v2_ziffy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ziffy-0^20260107gitdbb4529-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ziffy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ziffy}"
SRC_URI[x86_64_v2_ziffy.sha256sum] = "dc792a98ab2c3671c1df9d8334d0580f863be3ece3d79dd4c8f87519653a8458"

URI_aarch64_calnex = "${EPEL_MIRROR}/aarch64/Packages/c/calnex-0^20260107gitdbb4529-4.el10_1.aarch64.rpm;name=aarch64_calnex;unpack=0"
SRC_URI:append = " ${URI_aarch64_calnex}"
SRC_URI[aarch64_calnex.sha256sum] = "56422a31ab701b0a46d3a5a7d0eb6b531263a3e15135dbff9946f0614efa32de"

URI_aarch64_facebook-time-vendor-licenses = "${EPEL_MIRROR}/aarch64/Packages/f/facebook-time-vendor-licenses-0^20260107gitdbb4529-4.el10_1.noarch.rpm;name=aarch64_facebook-time-vendor-licenses;unpack=0"
SRC_URI:append = " ${URI_aarch64_facebook-time-vendor-licenses}"
SRC_URI[aarch64_facebook-time-vendor-licenses.sha256sum] = "e8a09f6867e79b585d9d129a34a9b32b235b9c0ede003955687d9bf48f2554db"

URI_aarch64_fbclock = "${EPEL_MIRROR}/aarch64/Packages/f/fbclock-0^20260107gitdbb4529-4.el10_1.aarch64.rpm;name=aarch64_fbclock;unpack=0"
SRC_URI:append = " ${URI_aarch64_fbclock}"
SRC_URI[aarch64_fbclock.sha256sum] = "f871f1454dec590a2f7636539c1c2f6c9519bb286f596ee38e5a177a6f5ac997"

URI_aarch64_ntpcheck = "${EPEL_MIRROR}/aarch64/Packages/n/ntpcheck-0^20260107gitdbb4529-4.el10_1.aarch64.rpm;name=aarch64_ntpcheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_ntpcheck}"
SRC_URI[aarch64_ntpcheck.sha256sum] = "2f977fae3b2a98b37e34f742cd39c1958f4956b0fe90d60b77a9f44adec55429"

URI_aarch64_ntpresponder = "${EPEL_MIRROR}/aarch64/Packages/n/ntpresponder-0^20260107gitdbb4529-4.el10_1.aarch64.rpm;name=aarch64_ntpresponder;unpack=0"
SRC_URI:append = " ${URI_aarch64_ntpresponder}"
SRC_URI[aarch64_ntpresponder.sha256sum] = "1b913e8c82a8006ec812b102a514942aff04b6d904998db4a7b6598504303382"

URI_aarch64_pshark = "${EPEL_MIRROR}/aarch64/Packages/p/pshark-0^20260107gitdbb4529-4.el10_1.aarch64.rpm;name=aarch64_pshark;unpack=0"
SRC_URI:append = " ${URI_aarch64_pshark}"
SRC_URI[aarch64_pshark.sha256sum] = "d076cbcd9a844fa8fab6735509908565232a562d4202815e6627683274ea64ad"

URI_aarch64_ptp4u = "${EPEL_MIRROR}/aarch64/Packages/p/ptp4u-0^20260107gitdbb4529-4.el10_1.aarch64.rpm;name=aarch64_ptp4u;unpack=0"
SRC_URI:append = " ${URI_aarch64_ptp4u}"
SRC_URI[aarch64_ptp4u.sha256sum] = "f6d906a849f6b83744c4ffa7349b52150f8ae00ea31237f6c016f1210bc3cfb8"

URI_aarch64_ptpcheck = "${EPEL_MIRROR}/aarch64/Packages/p/ptpcheck-0^20260107gitdbb4529-4.el10_1.aarch64.rpm;name=aarch64_ptpcheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_ptpcheck}"
SRC_URI[aarch64_ptpcheck.sha256sum] = "fc75ccbbc6a3e9956a67baea6090851a094b906b03db5c3ba9e4666a4c44675a"

URI_aarch64_sptp = "${EPEL_MIRROR}/aarch64/Packages/s/sptp-0^20260107gitdbb4529-4.el10_1.aarch64.rpm;name=aarch64_sptp;unpack=0"
SRC_URI:append = " ${URI_aarch64_sptp}"
SRC_URI[aarch64_sptp.sha256sum] = "294702cd72ff1480badfefa4857c3714ae416b5eab00fe1c5430959a48edae11"

URI_aarch64_ziffy = "${EPEL_MIRROR}/aarch64/Packages/z/ziffy-0^20260107gitdbb4529-4.el10_1.aarch64.rpm;name=aarch64_ziffy;unpack=0"
SRC_URI:append = " ${URI_aarch64_ziffy}"
SRC_URI[aarch64_ziffy.sha256sum] = "2faaedeed6408ad2b8301e4b9b9a91bfbca681aa257be3a6654c62627e6eae09"

RDEPENDS:calnex = " \
 facebook-time-vendor-licenses \
 glibc \
 "
RDEPENDS:facebook-time-vendor-licenses = " \
 "
RDEPENDS:fbclock = " \
 facebook-time-vendor-licenses \
 glibc \
 "
RDEPENDS:ntpcheck = " \
 facebook-time-vendor-licenses \
 glibc \
 "
RDEPENDS:ntpresponder = " \
 facebook-time-vendor-licenses \
 glibc \
 "
RDEPENDS:pshark = " \
 facebook-time-vendor-licenses \
 glibc \
 "
RDEPENDS:ptp4u = " \
 facebook-time-vendor-licenses \
 glibc \
 "
RDEPENDS:ptpcheck = " \
 facebook-time-vendor-licenses \
 glibc \
 "
RDEPENDS:sptp = " \
 facebook-time-vendor-licenses \
 glibc \
 "
RDEPENDS:ziffy = " \
 facebook-time-vendor-licenses \
 glibc \
 libpcap \
 "
