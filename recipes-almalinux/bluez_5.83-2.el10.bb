# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bluez"
PV = "5.83"
PR = "2.el10"
PACKAGES = " \
 bluez \
 bluez-cups \
 bluez-libs \
 bluez-libs-devel \
 bluez-obexd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/bluez-5.83-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d7f9c102f5411fb7fdc343de363303c095bb71a5bbde187354c1a1dbeae1db9"

URI_x86_64_v2_bluez = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/bluez-5.83-2.el10.x86_64_v2.rpm;name=x86_64_v2_bluez;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluez}"
SRC_URI[x86_64_v2_bluez.sha256sum] = "2fccbc2d98428e9eb50a0ba8d38ba11639b9553c26c3757c53368e442e46220f"

URI_x86_64_v2_bluez-cups = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bluez-cups-5.83-2.el10.x86_64_v2.rpm;name=x86_64_v2_bluez-cups;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluez-cups}"
SRC_URI[x86_64_v2_bluez-cups.sha256sum] = "6be80bda1bfb65183bc49d49031ed17c3516c5ac7a564bc3d0268463f4cd2077"

URI_x86_64_v2_bluez-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/bluez-libs-5.83-2.el10.x86_64_v2.rpm;name=x86_64_v2_bluez-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluez-libs}"
SRC_URI[x86_64_v2_bluez-libs.sha256sum] = "0df93bd0926576f53b0fd25f2cd036a066e1889d10054a1955d975a27d7ab911"

URI_x86_64_v2_bluez-libs-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/bluez-libs-devel-5.83-2.el10.x86_64_v2.rpm;name=x86_64_v2_bluez-libs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluez-libs-devel}"
SRC_URI[x86_64_v2_bluez-libs-devel.sha256sum] = "2b11b5aabe77554c8982e8d9d888bcb8b0cbe6b446ede29f389156c01b8ea444"

URI_x86_64_v2_bluez-obexd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bluez-obexd-5.83-2.el10.x86_64_v2.rpm;name=x86_64_v2_bluez-obexd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluez-obexd}"
SRC_URI[x86_64_v2_bluez-obexd.sha256sum] = "30e89572a501016eb4e460d4435c336fd1d89653adc8a83b50bbb971f0ff94f7"

URI_aarch64_bluez = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/bluez-5.83-2.el10.aarch64.rpm;name=aarch64_bluez;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluez}"
SRC_URI[aarch64_bluez.sha256sum] = "8016355e9f37b1e36442dc23a9ec1b3b6a8b10c6d2fcdaafc361a8b682885e9c"

URI_aarch64_bluez-cups = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bluez-cups-5.83-2.el10.aarch64.rpm;name=aarch64_bluez-cups;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluez-cups}"
SRC_URI[aarch64_bluez-cups.sha256sum] = "fd4c62847ecf5e7acde5699dcea6d26ec078d78890f8e61773c7c07b767cc886"

URI_aarch64_bluez-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/bluez-libs-5.83-2.el10.aarch64.rpm;name=aarch64_bluez-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluez-libs}"
SRC_URI[aarch64_bluez-libs.sha256sum] = "f5c45cab4040b4f72d2b4582d9ccda0708da04e18444db80efe11a696b7f597b"

URI_aarch64_bluez-libs-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/bluez-libs-devel-5.83-2.el10.aarch64.rpm;name=aarch64_bluez-libs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluez-libs-devel}"
SRC_URI[aarch64_bluez-libs-devel.sha256sum] = "a1ad8e87c11b33ef253bf75657eb054272d33244c4fa0432133ace5e3c5f374a"

URI_aarch64_bluez-obexd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bluez-obexd-5.83-2.el10.aarch64.rpm;name=aarch64_bluez-obexd;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluez-obexd}"
SRC_URI[aarch64_bluez-obexd.sha256sum] = "5fc40926bc4d7162d2d0d84f94d4f6e4ba38707a9d2324a40e8ae1cde45998c8"

RDEPENDS:bluez = " \
 bash \
 dbus \
 dbus-libs \
 glib2 \
 glibc \
 readline \
 systemd \
 systemd-libs \
 "
RDEPENDS:bluez-cups = " \
 bluez \
 cups \
 dbus-libs \
 glib2 \
 glibc \
 "
RDEPENDS:bluez-libs = " \
 glibc \
 "
RDEPENDS:bluez-libs-devel = " \
 bluez-libs \
 glibc \
 pkgconf-pkg-config \
 "
RDEPENDS:bluez-obexd = " \
 bash \
 bluez \
 bluez-libs \
 dbus-libs \
 glib2 \
 glibc \
 libical \
 systemd-libs \
 "
