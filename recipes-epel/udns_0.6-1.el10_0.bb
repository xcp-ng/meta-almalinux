# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "udns"
PV = "0.6"
PR = "1.el10_0"
PACKAGES = " \
 udns \
 udns-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/udns-0.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2585a6bababaae5eb7a89880553201bfa2411e602a25dda96aabef366094e18d"

URI_x86_64_v2_udns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/udns-0.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_udns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_udns}"
SRC_URI[x86_64_v2_udns.sha256sum] = "4083e6bcc99c7c7f6233c40927fc3cf14e85c09ba16d3710d1001e7929b0458c"

URI_x86_64_v2_udns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/udns-devel-0.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_udns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_udns-devel}"
SRC_URI[x86_64_v2_udns-devel.sha256sum] = "7c6c484c2f50f9ea86b486866b7355e22e1d2b6cab0208327839145504a80d26"

URI_aarch64_udns = "${EPEL_MIRROR}/aarch64/Packages/u/udns-0.6-1.el10_0.aarch64.rpm;name=aarch64_udns;unpack=0"
SRC_URI:append = " ${URI_aarch64_udns}"
SRC_URI[aarch64_udns.sha256sum] = "8d589e1fbafc9d939b8b1cdd064fddd14b6c9af42495148f1ad6ac0d463fa91d"

URI_aarch64_udns-devel = "${EPEL_MIRROR}/aarch64/Packages/u/udns-devel-0.6-1.el10_0.aarch64.rpm;name=aarch64_udns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_udns-devel}"
SRC_URI[aarch64_udns-devel.sha256sum] = "0da1082f77e3b6f75187a71c393b7d1d032875c5a62c1ae185f0a892f261e7b0"

RDEPENDS:udns = " \
 glibc \
 "
RDEPENDS:udns-devel = " \
 udns \
 "
