# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Convert-Base32"
PV = "0.06"
PR = "20.el10_0"
PACKAGES = " \
 perl-Convert-Base32 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Convert-Base32-0.06-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "51fb10e03d2fc6dfdcef0d47867896e5bd272c789ab6fc5045672e6acd66e54c"

URI_x86_64_v2_perl-Convert-Base32 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Convert-Base32-0.06-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Convert-Base32;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Convert-Base32}"
SRC_URI[x86_64_v2_perl-Convert-Base32.sha256sum] = "2c421a888d52f43b48a10a306e9effaa129caaa4011116e9c2258c4fde6fe45b"

URI_aarch64_perl-Convert-Base32 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Convert-Base32-0.06-20.el10_0.noarch.rpm;name=aarch64_perl-Convert-Base32;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Convert-Base32}"
SRC_URI[aarch64_perl-Convert-Base32.sha256sum] = "79d3499eb7c7e6f907d8f0e6c8879bf2f36cfd7c621e5e69f320b6e3e276f7a3"

RDEPENDS:perl-Convert-Base32 = " \
 perl-Carp \
 perl-Exporter \
 perl-Test-Exception \
 perl-Test-Simple \
 perl-libs \
 perl-vars \
 "
