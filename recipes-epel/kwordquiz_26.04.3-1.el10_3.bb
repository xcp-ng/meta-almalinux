# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kwordquiz"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kwordquiz \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kwordquiz-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2baafd6579e1c9ec1aaab7dd41b4ae190fd64c17801f439811f4d614b399732f"

URI_x86_64_v2_kwordquiz = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwordquiz-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwordquiz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwordquiz}"
SRC_URI[x86_64_v2_kwordquiz.sha256sum] = "dfa47d2aea714c3d8d1e344638efe956b513cf451be42f162d48440a3654451f"

URI_aarch64_kwordquiz = "${EPEL_MIRROR}/aarch64/Packages/k/kwordquiz-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kwordquiz;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwordquiz}"
SRC_URI[aarch64_kwordquiz.sha256sum] = "00b1438788ae3eb0860931ba08e31f2585275482cf472b20554019dd387739ee"

RDEPENDS:kwordquiz = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-knewstuff \
 libkeduvocdocument \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
