# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-linkify-it-py"
PV = "2.0.3"
PR = "3.el10_0"
PACKAGES = " \
 python3-linkify-it-py \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-linkify-it-py-2.0.3-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "612c4227ab51951bc97a494af1cc5d0af7e26e85b03f7f9fdf5c66e24c381afc"

URI_x86_64_v2_python3-linkify-it-py = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-linkify-it-py-2.0.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-linkify-it-py;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-linkify-it-py}"
SRC_URI[x86_64_v2_python3-linkify-it-py.sha256sum] = "d3405fcd9a30da3f987018c209850166cb3c7d7d2a22e1ad74ab0c205b8470ed"

URI_aarch64_python3-linkify-it-py = "${EPEL_MIRROR}/aarch64/Packages/p/python3-linkify-it-py-2.0.3-3.el10_0.noarch.rpm;name=aarch64_python3-linkify-it-py;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-linkify-it-py}"
SRC_URI[aarch64_python3-linkify-it-py.sha256sum] = "a2bb854eb4a7fa7dd77aade84f3d13d1eb9f9d685520c03d03fe1cc3c63fba8f"

RDEPENDS:python3-linkify-it-py = " \
 python3 \
 python3-uc-micro-py \
 "
