# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gstreamer1-plugins-base"
PV = "1.26.7"
PR = "2.el10"
PACKAGES = " \
 gstreamer1-plugins-base \
 gstreamer1-plugins-base-devel \
 gstreamer1-plugins-base-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gstreamer1-plugins-base-1.26.7-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d822f606c7ca20496e968a6413081372f9ae8e41e5a5ad1c666727d82df9f51"

URI_x86_64_v2_gstreamer1-plugins-base = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-base-1.26.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-base}"
SRC_URI[x86_64_v2_gstreamer1-plugins-base.sha256sum] = "fbcc50e2e8d585d3893dcf83ed5dcba03911b69003c836930565b327ef0cdbeb"

URI_x86_64_v2_gstreamer1-plugins-base-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-base-devel-1.26.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-base-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-base-devel}"
SRC_URI[x86_64_v2_gstreamer1-plugins-base-devel.sha256sum] = "ca0185854f10765b69c3ecb02e370e381d074ed546133afdb68f0cee56459ad1"

URI_x86_64_v2_gstreamer1-plugins-base-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-base-tools-1.26.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-base-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-base-tools}"
SRC_URI[x86_64_v2_gstreamer1-plugins-base-tools.sha256sum] = "8158b99615eb5403f4921ff703bd1e962be422ac3d1f3c5166d05373b702cc34"

URI_aarch64_gstreamer1-plugins-base = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-base-1.26.7-2.el10.aarch64.rpm;name=aarch64_gstreamer1-plugins-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-base}"
SRC_URI[aarch64_gstreamer1-plugins-base.sha256sum] = "4c16ddb985f9c2ece471f0fa3f1b4d8929ccf29fb58e670a9de571ec2165c752"

URI_aarch64_gstreamer1-plugins-base-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-base-devel-1.26.7-2.el10.aarch64.rpm;name=aarch64_gstreamer1-plugins-base-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-base-devel}"
SRC_URI[aarch64_gstreamer1-plugins-base-devel.sha256sum] = "a116e54dfd7c2594f1ad2a9eadfa17551865f4e5dff9ef1524214b4dcf9672af"

URI_aarch64_gstreamer1-plugins-base-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-base-tools-1.26.7-2.el10.aarch64.rpm;name=aarch64_gstreamer1-plugins-base-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-base-tools}"
SRC_URI[aarch64_gstreamer1-plugins-base-tools.sha256sum] = "361055b016eabf69f289f100a95e493e667831051ac07c63f8af0f08861f2b70"

RDEPENDS:gstreamer1-plugins-base = " \
 alsa-lib \
 cairo \
 glib2 \
 glibc \
 graphene \
 gstreamer1 \
 iso-codes \
 libX11 \
 libX11-xcb \
 libXext \
 libXi \
 libXv \
 libdrm \
 libglvnd-egl \
 libglvnd-glx \
 libgudev \
 libjpeg-turbo \
 libogg \
 libpng \
 libtheora \
 libvorbis \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 libxcb \
 mesa-libgbm \
 opus \
 orc \
 pango \
 zlib-ng-compat \
 "
RDEPENDS:gstreamer1-plugins-base-devel = " \
 glib2-devel \
 gstreamer1-devel \
 gstreamer1-plugins-base \
 gstreamer1-plugins-base-devel \
 libX11-devel \
 libdrm-devel \
 libglvnd-devel \
 libgudev-devel \
 mesa-libgbm-devel \
 orc-devel \
 pkgconf-pkg-config \
 wayland-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:gstreamer1-plugins-base-tools = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 "
