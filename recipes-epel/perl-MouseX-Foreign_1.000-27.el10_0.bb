# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-MouseX-Foreign"
PV = "1.000"
PR = "27.el10_0"
PACKAGES = " \
 perl-MouseX-Foreign \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-MouseX-Foreign-1.000-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d284615f3aa20e07c5d65a652e53227e3a0d756bbefa6c788e8a2984b26f254"

URI_x86_64_v2_perl-MouseX-Foreign = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-MouseX-Foreign-1.000-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-MouseX-Foreign;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-MouseX-Foreign}"
SRC_URI[x86_64_v2_perl-MouseX-Foreign.sha256sum] = "06e0eaa93b53ca208ad2338d3b1f8bff69e48ee2d26ad75b2c8b82c4421f7c0e"

URI_aarch64_perl-MouseX-Foreign = "${EPEL_MIRROR}/aarch64/Packages/p/perl-MouseX-Foreign-1.000-27.el10_0.noarch.rpm;name=aarch64_perl-MouseX-Foreign;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-MouseX-Foreign}"
SRC_URI[aarch64_perl-MouseX-Foreign.sha256sum] = "ba2d59f6b78ad07d37570041f0d0c02c981357fe6e8f9cfb21f1ad49c67f9485"

RDEPENDS:perl-MouseX-Foreign = " \
 perl-Carp \
 perl-Mouse \
 perl-libs \
 "
