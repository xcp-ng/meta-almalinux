# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-BGP"
PV = "0.18"
PR = "9.el10_0"
PACKAGES = " \
 perl-Net-BGP \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-BGP-0.18-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f7ef34af6e3b452cd2a91bc2d37ef561f0c3761c6f20177ff89eed7ed4a25ee"

URI_x86_64_v2_perl-Net-BGP = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-BGP-0.18-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-BGP;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-BGP}"
SRC_URI[x86_64_v2_perl-Net-BGP.sha256sum] = "5dd26be5896d994418d92d41d62b36c199dda9d06ba6a1ba004b042ff666e068"

URI_aarch64_perl-Net-BGP = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-BGP-0.18-9.el10_0.noarch.rpm;name=aarch64_perl-Net-BGP;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-BGP}"
SRC_URI[aarch64_perl-Net-BGP.sha256sum] = "a273df2e320cba0d6763f6d719a14686f68c4530b77c034ff7cf6ad66797a416"

RDEPENDS:perl-Net-BGP = " \
 perl-Carp \
 perl-Errno \
 perl-Exporter \
 perl-IO \
 perl-Net-BGP \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-overload \
 perl-vars \
 "
