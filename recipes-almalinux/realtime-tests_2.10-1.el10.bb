# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "realtime-tests"
PV = "2.10"
PR = "1.el10"
PACKAGES = " \
 realtime-tests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/realtime-tests-2.10-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "620eae12016217e27edd59c1e37077175ecdc6523f14cf6732f7cede0f18ce88"

URI_x86_64_v2_realtime-tests = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/realtime-tests-2.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_realtime-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_realtime-tests}"
SRC_URI[x86_64_v2_realtime-tests.sha256sum] = "1e8fddc52f6d4a318524a79a631f470685a3b7d0b1c9a8cd78155213c28cfe79"

URI_aarch64_realtime-tests = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/realtime-tests-2.10-1.el10.aarch64.rpm;name=aarch64_realtime-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_realtime-tests}"
SRC_URI[aarch64_realtime-tests.sha256sum] = "4c757e02848147023fc224e82563285340268cfca56634df80b6c0a42d668286"

RDEPENDS:realtime-tests = " \
 bash \
 bc \
 glibc \
 kernel-tools-libs \
 numactl-libs \
 python3 \
 "
