# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-cloud-google-compute-metadata"
PV = "0.3.0"
PR = "2.el10_0"
PACKAGES = " \
 golang-cloud-google-compute-metadata-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-cloud-google-compute-metadata-0.3.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "977f6608be56f7b48155608bb536c5c0ed3f2ad9d5df82e71488061fa39774b9"

URI_x86_64_v2_golang-cloud-google-compute-metadata-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-cloud-google-compute-metadata-devel-0.3.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-cloud-google-compute-metadata-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-cloud-google-compute-metadata-devel}"
SRC_URI[x86_64_v2_golang-cloud-google-compute-metadata-devel.sha256sum] = "7659ffce3d27ae93cd323ae44338dfc731b487e241b4ba4f9467ecc292128e61"

URI_aarch64_golang-cloud-google-compute-metadata-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-cloud-google-compute-metadata-devel-0.3.0-2.el10_0.noarch.rpm;name=aarch64_golang-cloud-google-compute-metadata-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-cloud-google-compute-metadata-devel}"
SRC_URI[aarch64_golang-cloud-google-compute-metadata-devel.sha256sum] = "55b23a8ffac81849a34be7b994331ef2a02d401d37525789e219c11e6ac23689"

RDEPENDS:golang-cloud-google-compute-metadata-devel = " \
 go-filesystem \
 "
