# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-md5-asm"
PV = "0.5.2"
PR = "2.el10_0"
PACKAGES = " \
 rust-md5-asm+default-devel \
 rust-md5-asm-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-md5-asm-0.5.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "83104555959b917f256af84bd1ec0d51484a8ca427f5e6f74d43a5e09364a9f6"

URI_x86_64_v2_rust-md5-asm+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-md5-asm+default-devel-0.5.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-md5-asm+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-md5-asm+default-devel}"
SRC_URI[x86_64_v2_rust-md5-asm+default-devel.sha256sum] = "a744fa83e06efc40bf94c49eaeac69419a630d9f120aaeb4f5dfc1708488c771"

URI_x86_64_v2_rust-md5-asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-md5-asm-devel-0.5.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-md5-asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-md5-asm-devel}"
SRC_URI[x86_64_v2_rust-md5-asm-devel.sha256sum] = "e9f376ea9ac17039be54fc2bfea84cd4a54cb6d2b11c4bf0c5b2d0cea557fc77"

URI_aarch64_rust-md5-asm+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-md5-asm+default-devel-0.5.2-2.el10_0.noarch.rpm;name=aarch64_rust-md5-asm+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-md5-asm+default-devel}"
SRC_URI[aarch64_rust-md5-asm+default-devel.sha256sum] = "f03593f78c5dbb9d112dbfaa6f30ee5f64fe89800689c730a8887138368ac326"

URI_aarch64_rust-md5-asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-md5-asm-devel-0.5.2-2.el10_0.noarch.rpm;name=aarch64_rust-md5-asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-md5-asm-devel}"
SRC_URI[aarch64_rust-md5-asm-devel.sha256sum] = "b660f7b48a70df4ae2b105c7c94853c5a0bfcdf1eec1b007f72d2550f5538121"

RDEPENDS:rust-md5-asm+default-devel = " \
 cargo \
 rust-md5-asm-devel \
 "
RDEPENDS:rust-md5-asm-devel = " \
 cargo \
 rust-cc+default-devel \
 "
