# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ordered-multimap"
PV = "0.7.3"
PR = "2.el10_1"
PACKAGES = " \
 rust-ordered-multimap+default-devel \
 rust-ordered-multimap+serde-devel \
 rust-ordered-multimap+std-devel \
 rust-ordered-multimap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ordered-multimap-0.7.3-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb3bc5ebe4aad2dac4cbe01f663cf07a4074f8bc867daecd1ad9096bed344a6e"

URI_x86_64_v2_rust-ordered-multimap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-multimap+default-devel-0.7.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-multimap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-multimap+default-devel}"
SRC_URI[x86_64_v2_rust-ordered-multimap+default-devel.sha256sum] = "a7317085cf4482a65db584217b10328938f7bbceaf7d5a16a87441c03c765218"

URI_x86_64_v2_rust-ordered-multimap+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-multimap+serde-devel-0.7.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-multimap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-multimap+serde-devel}"
SRC_URI[x86_64_v2_rust-ordered-multimap+serde-devel.sha256sum] = "40f8defedf61f75dc1f1b031e5626d15100a40140eddc9c0d5df8e5458e32017"

URI_x86_64_v2_rust-ordered-multimap+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-multimap+std-devel-0.7.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-multimap+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-multimap+std-devel}"
SRC_URI[x86_64_v2_rust-ordered-multimap+std-devel.sha256sum] = "02d8a4c8d427559407c84b14dd46035895bf060e273afe35761bc7b148b3334c"

URI_x86_64_v2_rust-ordered-multimap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-multimap-devel-0.7.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-multimap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-multimap-devel}"
SRC_URI[x86_64_v2_rust-ordered-multimap-devel.sha256sum] = "c50eb155d6101de650634a9a7a3345226437b43633463c8eeed37dd794c6e382"

URI_aarch64_rust-ordered-multimap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-multimap+default-devel-0.7.3-2.el10_1.noarch.rpm;name=aarch64_rust-ordered-multimap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-multimap+default-devel}"
SRC_URI[aarch64_rust-ordered-multimap+default-devel.sha256sum] = "14d3ad992c26f836e4d48a598b107a2f44b257112e1f205da3f00f352db48de2"

URI_aarch64_rust-ordered-multimap+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-multimap+serde-devel-0.7.3-2.el10_1.noarch.rpm;name=aarch64_rust-ordered-multimap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-multimap+serde-devel}"
SRC_URI[aarch64_rust-ordered-multimap+serde-devel.sha256sum] = "c55102bd93b5184f36403f9f18dd00bf9bd00af4975fc4e3be54d86d5a0bc14e"

URI_aarch64_rust-ordered-multimap+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-multimap+std-devel-0.7.3-2.el10_1.noarch.rpm;name=aarch64_rust-ordered-multimap+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-multimap+std-devel}"
SRC_URI[aarch64_rust-ordered-multimap+std-devel.sha256sum] = "2785991c183707b731a0eb9b1682c7ab2b9e8d43803959f4fbda7c28333c5812"

URI_aarch64_rust-ordered-multimap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-multimap-devel-0.7.3-2.el10_1.noarch.rpm;name=aarch64_rust-ordered-multimap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-multimap-devel}"
SRC_URI[aarch64_rust-ordered-multimap-devel.sha256sum] = "d48c3bf1fb9cb0bcee01221b72e83e8e46329dfb41d48123b4019d32ab1fe4d2"

RDEPENDS:rust-ordered-multimap+default-devel = " \
 cargo \
 rust-ordered-multimap+std-devel \
 rust-ordered-multimap-devel \
 "
RDEPENDS:rust-ordered-multimap+serde-devel = " \
 cargo \
 rust-ordered-multimap-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-ordered-multimap+std-devel = " \
 cargo \
 rust-dlv-list+std-devel \
 rust-ordered-multimap-devel \
 "
RDEPENDS:rust-ordered-multimap-devel = " \
 cargo \
 rust \
 rust-dlv-list-devel \
 rust-hashbrown0.14-devel \
 "
