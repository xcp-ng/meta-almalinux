# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-sq"
PV = "1.6.4"
PR = "30.el10"
PACKAGES = " \
 hunspell-sq \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-sq-1.6.4-30.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c6b6935875725a0c84cfa135765affc96d59a7f2a52155801980e3e4d7379ad"

URI_x86_64_v2_hunspell-sq = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-sq-1.6.4-30.el10.noarch.rpm;name=x86_64_v2_hunspell-sq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-sq}"
SRC_URI[x86_64_v2_hunspell-sq.sha256sum] = "75cacc1fe48206eb8fe5c54c16d01fc6d29988233b24cf49c1334d702fff4eac"

URI_aarch64_hunspell-sq = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-sq-1.6.4-30.el10.noarch.rpm;name=aarch64_hunspell-sq;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-sq}"
SRC_URI[aarch64_hunspell-sq.sha256sum] = "75cacc1fe48206eb8fe5c54c16d01fc6d29988233b24cf49c1334d702fff4eac"

RDEPENDS:hunspell-sq = " \
 hunspell \
 "
