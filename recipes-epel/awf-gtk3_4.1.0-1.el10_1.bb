# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "awf-gtk3"
PV = "4.1.0"
PR = "1.el10_1"
PACKAGES = " \
 awf-gtk3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/awf-gtk3-4.1.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15f47dab2e11b174dfaf3b0f3d399de44bf5f8dce9dd0351ae37f1ab6feb5f91"

URI_x86_64_v2_awf-gtk3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/awf-gtk3-4.1.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_awf-gtk3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_awf-gtk3}"
SRC_URI[x86_64_v2_awf-gtk3.sha256sum] = "2b128b299b9e14994c0da5ca152973c12825f8bda8296d0f70b0c6e9abfe854b"

URI_aarch64_awf-gtk3 = "${EPEL_MIRROR}/aarch64/Packages/a/awf-gtk3-4.1.0-1.el10_1.aarch64.rpm;name=aarch64_awf-gtk3;unpack=0"
SRC_URI:append = " ${URI_aarch64_awf-gtk3}"
SRC_URI[aarch64_awf-gtk3.sha256sum] = "82ec53c5aa5b486ae23af2843e2d4fdbc1d1a8f53bb2fcadbc0db9bb2654bc68"

RDEPENDS:awf-gtk3 = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 hicolor-icon-theme \
 libnotify \
 pango \
 "
