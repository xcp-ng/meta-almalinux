# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-filtrable"
PV = "0.1.6.0"
PR = "9.el10_0"
PACKAGES = " \
 ghc-filtrable \
 ghc-filtrable-devel \
 ghc-filtrable-doc \
 ghc-filtrable-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-filtrable-0.1.6.0-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "525caa4c262855ee7ec2837a2a2c98ed1751991a592ab4e2986ecbaacc31579e"

URI_x86_64_v2_ghc-filtrable = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-filtrable-0.1.6.0-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-filtrable;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-filtrable}"
SRC_URI[x86_64_v2_ghc-filtrable.sha256sum] = "eb7e3c7d4f4c30749a631a0c143ba1a7c229001213cc9d9d676614b54d423afc"

URI_x86_64_v2_ghc-filtrable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-filtrable-devel-0.1.6.0-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-filtrable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-filtrable-devel}"
SRC_URI[x86_64_v2_ghc-filtrable-devel.sha256sum] = "a20975a58e5ff439b8d2381ceea6e122a5fbd1718ecb9cecf88d2fc03b8fd61a"

URI_x86_64_v2_ghc-filtrable-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-filtrable-doc-0.1.6.0-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-filtrable-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-filtrable-doc}"
SRC_URI[x86_64_v2_ghc-filtrable-doc.sha256sum] = "2e3d9a3ffdc4bdb4f05fb80b4e9e01291410bcad81a469a01d4a4e06220175b5"

URI_x86_64_v2_ghc-filtrable-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-filtrable-prof-0.1.6.0-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-filtrable-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-filtrable-prof}"
SRC_URI[x86_64_v2_ghc-filtrable-prof.sha256sum] = "13e3c7dbb282a24d67db3514584880c0a83b27cc297d10f12bcb45f57219ead6"

URI_aarch64_ghc-filtrable = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-filtrable-0.1.6.0-9.el10_0.aarch64.rpm;name=aarch64_ghc-filtrable;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-filtrable}"
SRC_URI[aarch64_ghc-filtrable.sha256sum] = "4927e141b03efcae4cf89d99eb9d82d74478be3836b84cef9303b0abdad5a583"

URI_aarch64_ghc-filtrable-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-filtrable-devel-0.1.6.0-9.el10_0.aarch64.rpm;name=aarch64_ghc-filtrable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-filtrable-devel}"
SRC_URI[aarch64_ghc-filtrable-devel.sha256sum] = "2bb31747e50bac704da9d9360abbae0a0dc6ccdb9f4b01f1e6cb16874e5df70f"

URI_aarch64_ghc-filtrable-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-filtrable-doc-0.1.6.0-9.el10_0.noarch.rpm;name=aarch64_ghc-filtrable-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-filtrable-doc}"
SRC_URI[aarch64_ghc-filtrable-doc.sha256sum] = "1379a247f54e72f252fe5a75e8df4e3b7ad9c8fd4598724c875e29bdceed6026"

URI_aarch64_ghc-filtrable-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-filtrable-prof-0.1.6.0-9.el10_0.aarch64.rpm;name=aarch64_ghc-filtrable-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-filtrable-prof}"
SRC_URI[aarch64_ghc-filtrable-prof.sha256sum] = "0a0294c247e437b792dbd3192fd4d64080eac31d669a319991f9587009165023"

RDEPENDS:ghc-filtrable = " \
 ghc-array \
 ghc-base \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-filtrable-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-filtrable \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-filtrable-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-filtrable-prof = " \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-filtrable-devel \
 ghc-transformers-prof \
 "
