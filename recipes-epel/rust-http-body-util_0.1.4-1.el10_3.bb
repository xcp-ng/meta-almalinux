# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-http-body-util"
PV = "0.1.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-http-body-util+channel-devel \
 rust-http-body-util+default-devel \
 rust-http-body-util+full-devel \
 rust-http-body-util-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-http-body-util-0.1.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b786182516c6ef669a590e49e3cda09fca8cb76dfb56dc551a4d9fb04a914bd2"

URI_x86_64_v2_rust-http-body-util+channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-body-util+channel-devel-0.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-body-util+channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-body-util+channel-devel}"
SRC_URI[x86_64_v2_rust-http-body-util+channel-devel.sha256sum] = "d71ab6555bb5bfa8353aa197340257990e2a0d00dff78a7467230e8b0251c812"

URI_x86_64_v2_rust-http-body-util+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-body-util+default-devel-0.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-body-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-body-util+default-devel}"
SRC_URI[x86_64_v2_rust-http-body-util+default-devel.sha256sum] = "846e0ae1332a3beab9e578452e5c6a7ab95512d2af5003ed294a29b2c804e097"

URI_x86_64_v2_rust-http-body-util+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-body-util+full-devel-0.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-body-util+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-body-util+full-devel}"
SRC_URI[x86_64_v2_rust-http-body-util+full-devel.sha256sum] = "3245303e3a5aebca75ac579c2f40bb88dc9103cd27a056151f67a3f539f6f16f"

URI_x86_64_v2_rust-http-body-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-body-util-devel-0.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-body-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-body-util-devel}"
SRC_URI[x86_64_v2_rust-http-body-util-devel.sha256sum] = "701d441dda7941a859329cb17da14b7b931bbfc03e0458b281d91b0dd8896d05"

URI_aarch64_rust-http-body-util+channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-body-util+channel-devel-0.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-http-body-util+channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-body-util+channel-devel}"
SRC_URI[aarch64_rust-http-body-util+channel-devel.sha256sum] = "073d10d75b13bb0763eb5dcddce1b97ee120101ece086913e3081f0c6edff178"

URI_aarch64_rust-http-body-util+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-body-util+default-devel-0.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-http-body-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-body-util+default-devel}"
SRC_URI[aarch64_rust-http-body-util+default-devel.sha256sum] = "b1ce4dd78ad3e00278e3841f1513911e59063af5e1d1892b9f877d342bbf40fc"

URI_aarch64_rust-http-body-util+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-body-util+full-devel-0.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-http-body-util+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-body-util+full-devel}"
SRC_URI[aarch64_rust-http-body-util+full-devel.sha256sum] = "95e867c06b70c4715707a3479305ed575a01faf33b97afd40bef6c34497ffafd"

URI_aarch64_rust-http-body-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-body-util-devel-0.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-http-body-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-body-util-devel}"
SRC_URI[aarch64_rust-http-body-util-devel.sha256sum] = "fb5a819766987ed459a6614b84e4f0590657f866076864be3d8f54a6e881bbf0"

RDEPENDS:rust-http-body-util+channel-devel = " \
 cargo \
 rust-http-body-util-devel \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 "
RDEPENDS:rust-http-body-util+default-devel = " \
 cargo \
 rust-http-body-util-devel \
 "
RDEPENDS:rust-http-body-util+full-devel = " \
 cargo \
 rust-http-body-util+channel-devel \
 rust-http-body-util-devel \
 "
RDEPENDS:rust-http-body-util-devel = " \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-futures-core-devel \
 rust-http+default-devel \
 rust-http-body+default-devel \
 rust-pin-project-lite+default-devel \
 "
