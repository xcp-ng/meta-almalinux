# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "elisa-player"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 elisa-player \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/e/elisa-player-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cd30614a28b723c1cb3350a4a25a2a77e57d0d26c8feddf93259c385679432df"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/elisa-player-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_elisa-player;unpack=0"
SRC_URI[x86_64_v2_elisa-player.sha256sum] = "103d249e88117266a65bc6aa1402c6a57e126296a5215bf711bc30658d1adc32"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/e/elisa-player-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_elisa-player;unpack=0"
SRC_URI[aarch64_elisa-player.sha256sum] = "55e5f0b851fdd556d49cc713c57364d86f731b780f2bccf471e3ac13395ff167"

RDEPENDS:elisa-player = " \
 dbus-common \
 glibc \
 hicolor-icon-theme \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kitemviews \
 kf6-kxmlgui \
 kf6-qqc2-desktop-style \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
