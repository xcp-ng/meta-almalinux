# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "steam-devices"
PV = "1.0.0.101^git20260123.39e7bd0"
PR = "8.el10_1"
PACKAGES = " \
 steam-devices \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/steam-devices-1.0.0.101^git20260123.39e7bd0-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b9100bdf0b900a4647f8d3b902eb1fd02cecd8fc2d4cc5068761bb2f8f70e29"

URI_x86_64_v2_steam-devices = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/steam-devices-1.0.0.101^git20260123.39e7bd0-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_steam-devices;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_steam-devices}"
SRC_URI[x86_64_v2_steam-devices.sha256sum] = "e98877b1944450ccd5f6672ce32908ac36ae373f64fe6cc7d44a67c0c4467359"

URI_aarch64_steam-devices = "${EPEL_MIRROR}/aarch64/Packages/s/steam-devices-1.0.0.101^git20260123.39e7bd0-8.el10_1.noarch.rpm;name=aarch64_steam-devices;unpack=0"
SRC_URI:append = " ${URI_aarch64_steam-devices}"
SRC_URI[aarch64_steam-devices.sha256sum] = "0c638dcf3a6a5455cd59824a5125c9a09cb35ad5de3caa8a921b04e7702ec69f"

RDEPENDS:steam-devices = " \
 "
