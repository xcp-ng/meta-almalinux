# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clazy"
PV = "1.16"
PR = "2.el10_1"
PACKAGES = " \
 clazy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/clazy-1.16-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d1a9df4d66a40fa1bbe2d0b0a7e0b10b8cea8e475aa42a209d42caf2e0b6ecc1"

URI_x86_64_v2_clazy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clazy-1.16-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clazy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clazy}"
SRC_URI[x86_64_v2_clazy.sha256sum] = "b58be299b257071f7c78584dc8f1c67ece3fbe09d93c7dbe8d9eb45350767394"

URI_aarch64_clazy = "${EPEL_MIRROR}/aarch64/Packages/c/clazy-1.16-2.el10_1.aarch64.rpm;name=aarch64_clazy;unpack=0"
SRC_URI:append = " ${URI_aarch64_clazy}"
SRC_URI[aarch64_clazy.sha256sum] = "1f74243ea666c65f1b34623b0952e4666a2e340701d54d281f07dd99dba373d9"

RDEPENDS:clazy = " \
 bash \
 clang \
 clang-libs \
 clang-tools-extra \
 glibc \
 libstdc++ \
 llvm-libs \
 "
