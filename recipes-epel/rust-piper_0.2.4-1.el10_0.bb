# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-piper"
PV = "0.2.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-piper+default-devel \
 rust-piper+futures-io-devel \
 rust-piper+portable-atomic-devel \
 rust-piper+portable-atomic-util-devel \
 rust-piper+portable_atomic_crate-devel \
 rust-piper+std-devel \
 rust-piper-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-piper-0.2.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e4c059cfbba6349bed66aa20fcb3418d08072e9c8b62f8683877373af85de386"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-piper+default-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-piper+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-piper+default-devel.sha256sum] = "890f964a0ff27749cdc7f7fb0fc41b0c559dd7bba583727d1ce35fc2f31cac17"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-piper+futures-io-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-piper+futures-io-devel;unpack=0"
SRC_URI[x86_64_v2_rust-piper+futures-io-devel.sha256sum] = "f219c928375c55da1699ba8c0681bf5cb7c72a15a76715d743926edc341f98dc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-piper+portable-atomic-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-piper+portable-atomic-devel;unpack=0"
SRC_URI[x86_64_v2_rust-piper+portable-atomic-devel.sha256sum] = "fe56f8a7bc85fe8250749157d460cbb15a928e3afd9db42165308f5e7c728f90"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-piper+portable-atomic-util-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-piper+portable-atomic-util-devel;unpack=0"
SRC_URI[x86_64_v2_rust-piper+portable-atomic-util-devel.sha256sum] = "3d185bd1d1f9ffb089c306fcdec801decbb816a981104060aee26cac0cc5658b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-piper+portable_atomic_crate-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-piper+portable_atomic_crate-devel;unpack=0"
SRC_URI[x86_64_v2_rust-piper+portable_atomic_crate-devel.sha256sum] = "eaf6c54d3dcabdf16b30795c7d64f0ae049300fdf63f9b56a39bc74320027f25"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-piper+std-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-piper+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-piper+std-devel.sha256sum] = "a21cf8a5429fcdc2afa93116b19c67537344f149cc7b6b5a47ba0e65a343f60c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-piper-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-piper-devel;unpack=0"
SRC_URI[x86_64_v2_rust-piper-devel.sha256sum] = "513f71d41ecc6a0f091d6671b2bd146dec631456ea74c5343a88798f1a9bdbd2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-piper+default-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-piper+default-devel;unpack=0"
SRC_URI[aarch64_rust-piper+default-devel.sha256sum] = "66627f4337f14b8c8daf861f48b81e988340a9a1dbe2b65f5d8da8e4da24d5e7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-piper+futures-io-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-piper+futures-io-devel;unpack=0"
SRC_URI[aarch64_rust-piper+futures-io-devel.sha256sum] = "3efd16b636cfb4fa59104aabb795b114c6cceb7bed86f36c8bb3bc4e2e714d1f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-piper+portable-atomic-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-piper+portable-atomic-devel;unpack=0"
SRC_URI[aarch64_rust-piper+portable-atomic-devel.sha256sum] = "16bd6944261e30232472cad134ded78c952b3e18ba62a8a6b3e9a5de8805dab9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-piper+portable-atomic-util-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-piper+portable-atomic-util-devel;unpack=0"
SRC_URI[aarch64_rust-piper+portable-atomic-util-devel.sha256sum] = "9a21942e95dc8959ebeea204da565512a66fe09115126359c1501fc44b73a3f1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-piper+portable_atomic_crate-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-piper+portable_atomic_crate-devel;unpack=0"
SRC_URI[aarch64_rust-piper+portable_atomic_crate-devel.sha256sum] = "ca2378cac195c3c1f2abce196f861be3b86a13c25ec9ccfb8afc6a5cc51b3966"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-piper+std-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-piper+std-devel;unpack=0"
SRC_URI[aarch64_rust-piper+std-devel.sha256sum] = "fc52d2bc3cc48fbb0549f427344afaa6c71da57b57ce34f648f689b8a5a52ff0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-piper-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-piper-devel;unpack=0"
SRC_URI[aarch64_rust-piper-devel.sha256sum] = "24673b5d35a4081c35dd1da113143ae89adf7fbafd649418c5089cffe0cd9313"

RDEPENDS:rust-piper+default-devel = " \
 cargo \
 rust-piper+std-devel \
 rust-piper-devel \
 "
RDEPENDS:rust-piper+futures-io-devel = " \
 cargo \
 rust-futures-io+default-devel \
 rust-piper-devel \
 "
RDEPENDS:rust-piper+portable-atomic-devel = " \
 cargo \
 rust-atomic-waker+portable-atomic-devel \
 rust-piper+portable-atomic-util-devel \
 rust-piper+portable_atomic_crate-devel \
 rust-piper-devel \
 "
RDEPENDS:rust-piper+portable-atomic-util-devel = " \
 cargo \
 rust-piper-devel \
 rust-portable-atomic-util+alloc-devel \
 rust-portable-atomic-util+default-devel \
 "
RDEPENDS:rust-piper+portable_atomic_crate-devel = " \
 cargo \
 rust-piper-devel \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-piper+std-devel = " \
 cargo \
 rust-fastrand+std-devel \
 rust-piper+futures-io-devel \
 rust-piper-devel \
 "
RDEPENDS:rust-piper-devel = " \
 cargo \
 rust \
 rust-atomic-waker+default-devel \
 rust-fastrand-devel \
 "
