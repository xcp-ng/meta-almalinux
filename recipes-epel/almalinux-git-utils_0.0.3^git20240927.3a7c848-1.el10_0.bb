# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "almalinux-git-utils"
PV = "0.0.3^git20240927.3a7c848"
PR = "1.el10_0"
PACKAGES = " \
 almalinux-git-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/almalinux-git-utils-0.0.3^git20240927.3a7c848-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9a7584d36534379cf2951c9235ccebde0331325710c9293e1da2130a1f451f34"

URI_x86_64_v2_almalinux-git-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/almalinux-git-utils-0.0.3^git20240927.3a7c848-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_almalinux-git-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_almalinux-git-utils}"
SRC_URI[x86_64_v2_almalinux-git-utils.sha256sum] = "7064a4ba2f950281e73e8797ff6a0806aaa5f9b21065b81e87fa8d188ebf2784"

URI_aarch64_almalinux-git-utils = "${EPEL_MIRROR}/aarch64/Packages/a/almalinux-git-utils-0.0.3^git20240927.3a7c848-1.el10_0.noarch.rpm;name=aarch64_almalinux-git-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_almalinux-git-utils}"
SRC_URI[aarch64_almalinux-git-utils.sha256sum] = "cb39231c8102bd7f20bf7b6aca3c198bdd356156b03764801747915bd736e298"

RDEPENDS:almalinux-git-utils = " \
 python3 \
 python3-boto3 \
 python3-requests \
 "
