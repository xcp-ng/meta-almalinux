# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "flatpak-kcm"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 flatpak-kcm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/flatpak-kcm-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c5d6621a4c1defca58c54bdcf31f4ff0918cce30ac7dfd6ee1be1da6fce736ac"

URI_x86_64_v2_flatpak-kcm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flatpak-kcm-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_flatpak-kcm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flatpak-kcm}"
SRC_URI[x86_64_v2_flatpak-kcm.sha256sum] = "8f47163d5e4467e5d011d0e3223a705d171feb6d1c0906c4f721ea979fa34f3f"

URI_aarch64_flatpak-kcm = "${EPEL_MIRROR}/aarch64/Packages/f/flatpak-kcm-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_flatpak-kcm;unpack=0"
SRC_URI:append = " ${URI_aarch64_flatpak-kcm}"
SRC_URI[aarch64_flatpak-kcm.sha256sum] = "32193d879d77787d801dbff3a391c392c2e1fa39d97f4f7754b340adfa3f55d3"

RDEPENDS:flatpak-kcm = " \
 flatpak-libs \
 glib2 \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
