# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-logos-codegen"
PV = "0.14.4"
PR = "4.el10_3"
PACKAGES = " \
 rust-logos-codegen+debug-devel \
 rust-logos-codegen+default-devel \
 rust-logos-codegen+forbid_unsafe-devel \
 rust-logos-codegen+fuzzing-devel \
 rust-logos-codegen-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-logos-codegen-0.14.4-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92df9d66dc9877d4f5ee955908019755bc3a776893d5c18f4b0508ebc5d8089b"

URI_x86_64_v2_rust-logos-codegen+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-logos-codegen+debug-devel-0.14.4-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-logos-codegen+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-logos-codegen+debug-devel}"
SRC_URI[x86_64_v2_rust-logos-codegen+debug-devel.sha256sum] = "29f99e75470a7c670db7795aefe1fab2fabef905c2b0fbd185530c662a500085"

URI_x86_64_v2_rust-logos-codegen+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-logos-codegen+default-devel-0.14.4-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-logos-codegen+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-logos-codegen+default-devel}"
SRC_URI[x86_64_v2_rust-logos-codegen+default-devel.sha256sum] = "97356d48feea426d60aa0070fd60cd3e1252fd36f5a02a3196ffdd718f5eaf51"

URI_x86_64_v2_rust-logos-codegen+forbid_unsafe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-logos-codegen+forbid_unsafe-devel-0.14.4-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-logos-codegen+forbid_unsafe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-logos-codegen+forbid_unsafe-devel}"
SRC_URI[x86_64_v2_rust-logos-codegen+forbid_unsafe-devel.sha256sum] = "42fa9d7fd4f5795a4c2859bd014b5d7408a8b45cc3cf9600a46d471c0277dde5"

URI_x86_64_v2_rust-logos-codegen+fuzzing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-logos-codegen+fuzzing-devel-0.14.4-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-logos-codegen+fuzzing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-logos-codegen+fuzzing-devel}"
SRC_URI[x86_64_v2_rust-logos-codegen+fuzzing-devel.sha256sum] = "834b75ac91c576f443133f7d7818393e97e6ae5f3664e35b885c864a7a0c8785"

URI_x86_64_v2_rust-logos-codegen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-logos-codegen-devel-0.14.4-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-logos-codegen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-logos-codegen-devel}"
SRC_URI[x86_64_v2_rust-logos-codegen-devel.sha256sum] = "55c073d2916c778f2533088136943a9e433f6d6cf42ff8e19f5e5a967091ba1b"

URI_aarch64_rust-logos-codegen+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-logos-codegen+debug-devel-0.14.4-4.el10_3.noarch.rpm;name=aarch64_rust-logos-codegen+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-logos-codegen+debug-devel}"
SRC_URI[aarch64_rust-logos-codegen+debug-devel.sha256sum] = "88b30397f66725e314621e116710f816ec56d493dfb854897e37b2ac9909f2d9"

URI_aarch64_rust-logos-codegen+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-logos-codegen+default-devel-0.14.4-4.el10_3.noarch.rpm;name=aarch64_rust-logos-codegen+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-logos-codegen+default-devel}"
SRC_URI[aarch64_rust-logos-codegen+default-devel.sha256sum] = "cd958ceb280ddab880783ebe1b4e86c045776f70b49251527b6632253c37cca8"

URI_aarch64_rust-logos-codegen+forbid_unsafe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-logos-codegen+forbid_unsafe-devel-0.14.4-4.el10_3.noarch.rpm;name=aarch64_rust-logos-codegen+forbid_unsafe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-logos-codegen+forbid_unsafe-devel}"
SRC_URI[aarch64_rust-logos-codegen+forbid_unsafe-devel.sha256sum] = "e2da44ad7f5af8bc6cbd5b506e9d85ba360de3ce1585850a8cc8cb2ec5187a49"

URI_aarch64_rust-logos-codegen+fuzzing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-logos-codegen+fuzzing-devel-0.14.4-4.el10_3.noarch.rpm;name=aarch64_rust-logos-codegen+fuzzing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-logos-codegen+fuzzing-devel}"
SRC_URI[aarch64_rust-logos-codegen+fuzzing-devel.sha256sum] = "179a04bfd0b2268b6c9f7b90a546af53dc750d499493eef7632c4c9ac0079775"

URI_aarch64_rust-logos-codegen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-logos-codegen-devel-0.14.4-4.el10_3.noarch.rpm;name=aarch64_rust-logos-codegen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-logos-codegen-devel}"
SRC_URI[aarch64_rust-logos-codegen-devel.sha256sum] = "b6f579bc85b648260c4416c9a5979db6a5738d8adff34ae4e91653ff1c9b512e"

RDEPENDS:rust-logos-codegen+debug-devel = " \
 cargo \
 rust-logos-codegen-devel \
 "
RDEPENDS:rust-logos-codegen+default-devel = " \
 cargo \
 rust-logos-codegen-devel \
 "
RDEPENDS:rust-logos-codegen+forbid_unsafe-devel = " \
 cargo \
 rust-logos-codegen-devel \
 "
RDEPENDS:rust-logos-codegen+fuzzing-devel = " \
 cargo \
 rust-logos-codegen-devel \
 "
RDEPENDS:rust-logos-codegen-devel = " \
 cargo \
 rust \
 rust-beef+default-devel \
 rust-fnv+default-devel \
 rust-lazy_static+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-regex-syntax+default-devel \
 rust-syn2+default-devel \
 rust-syn2+full-devel \
 "
