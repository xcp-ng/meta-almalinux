# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bindgen-cli"
PV = "0.69.5"
PR = "1.el10_0"
PACKAGES = " \
 bindgen-cli \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bindgen-cli-0.69.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7fd53f3aa7c5743a2d78e466999aaf9e435bdab33e2596372ce4a6faf183864"

URI_x86_64_v2_bindgen-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bindgen-cli-0.69.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bindgen-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bindgen-cli}"
SRC_URI[x86_64_v2_bindgen-cli.sha256sum] = "34aa3ad5f15688207689e3ecc2895028ca646d99af8f6c2b512166aec7cefee3"

URI_aarch64_bindgen-cli = "${EPEL_MIRROR}/aarch64/Packages/b/bindgen-cli-0.69.5-1.el10_0.aarch64.rpm;name=aarch64_bindgen-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_bindgen-cli}"
SRC_URI[aarch64_bindgen-cli.sha256sum] = "d1769012221e5d5f3c05909df3857f9fdf9d59b44fa9b8b5e7fbfed508f2e501"

RDEPENDS:bindgen-cli = " \
 clang-libs \
 glibc \
 libgcc \
 "
