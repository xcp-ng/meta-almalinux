# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-displaydoc"
PV = "0.2.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-displaydoc+default-devel \
 rust-displaydoc+std-devel \
 rust-displaydoc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-displaydoc-0.2.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bcc40fee816b5a4799f9495a65470558ac17fc458dd80bccd0424e980ce6e00f"

URI_x86_64_v2_rust-displaydoc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-displaydoc+default-devel-0.2.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-displaydoc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-displaydoc+default-devel}"
SRC_URI[x86_64_v2_rust-displaydoc+default-devel.sha256sum] = "4626cb2f94123a39b6b5187019c9c128bdce15de15c47639351cd72b761ba809"

URI_x86_64_v2_rust-displaydoc+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-displaydoc+std-devel-0.2.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-displaydoc+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-displaydoc+std-devel}"
SRC_URI[x86_64_v2_rust-displaydoc+std-devel.sha256sum] = "b1d86b59fd486da8c2b0704869ecf992684869164517bf79eb8462a1cd9ac33e"

URI_x86_64_v2_rust-displaydoc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-displaydoc-devel-0.2.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-displaydoc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-displaydoc-devel}"
SRC_URI[x86_64_v2_rust-displaydoc-devel.sha256sum] = "1870110dcbc77091adfe694d4a0e85734f9325048eeec76dab3cbaab63aa404c"

URI_aarch64_rust-displaydoc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-displaydoc+default-devel-0.2.6-1.el10_3.noarch.rpm;name=aarch64_rust-displaydoc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-displaydoc+default-devel}"
SRC_URI[aarch64_rust-displaydoc+default-devel.sha256sum] = "8ef0545bc2d4fdc3f4262e35b1cd69f11fb5b66d42b5f726f8ee33117ed4da2d"

URI_aarch64_rust-displaydoc+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-displaydoc+std-devel-0.2.6-1.el10_3.noarch.rpm;name=aarch64_rust-displaydoc+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-displaydoc+std-devel}"
SRC_URI[aarch64_rust-displaydoc+std-devel.sha256sum] = "08a9559b0c22236e6c1ad6a4cf6aedbf8cecf52d648d1c1bdbb3a8033e2f0018"

URI_aarch64_rust-displaydoc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-displaydoc-devel-0.2.6-1.el10_3.noarch.rpm;name=aarch64_rust-displaydoc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-displaydoc-devel}"
SRC_URI[aarch64_rust-displaydoc-devel.sha256sum] = "f5c315f3f4cdfc1a6401fc70b8d192d52bf2a9cbe84b6d01600df9363216fbeb"

RDEPENDS:rust-displaydoc+default-devel = " \
 cargo \
 rust-displaydoc+std-devel \
 rust-displaydoc-devel \
 "
RDEPENDS:rust-displaydoc+std-devel = " \
 cargo \
 rust-displaydoc-devel \
 "
RDEPENDS:rust-displaydoc-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 "
