# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-json-iterator"
PV = "1.1.12"
PR = "8.el10_0"
PACKAGES = " \
 golang-github-json-iterator-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-json-iterator-1.1.12-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2114561ba658d5aa172d80329587c5608651c29ae9906ddb0623aab44a526b78"

URI_x86_64_v2_golang-github-json-iterator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-json-iterator-devel-1.1.12-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-json-iterator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-json-iterator-devel}"
SRC_URI[x86_64_v2_golang-github-json-iterator-devel.sha256sum] = "18a0d5039849bea8f1459b170d5a82410cab0387fa7fd0c53129d05cf45cfaff"

URI_aarch64_golang-github-json-iterator-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-json-iterator-devel-1.1.12-8.el10_0.noarch.rpm;name=aarch64_golang-github-json-iterator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-json-iterator-devel}"
SRC_URI[aarch64_golang-github-json-iterator-devel.sha256sum] = "36658569c858bfc0c085334eb7cc03ec6f85b8e7d0627d9b2635e86bf6f5322d"

RDEPENDS:golang-github-json-iterator-devel = " \
 go-filesystem \
 golang-github-modern-concurrent-devel \
 golang-github-modern-reflect2-devel \
 "
