# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libvpx"
PV = "1.14.1"
PR = "3.el10_0"
PACKAGES = " \
 libvpx \
 libvpx-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libvpx-1.14.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "22e53846d7a0573575935655bc9fd6a7170cf7baa6b6ee87408cf52266f386d3"

URI_x86_64_v2_libvpx = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvpx-1.14.1-3.el10_0.x86_64_v2.rpm;name=x86_64_v2_libvpx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvpx}"
SRC_URI[x86_64_v2_libvpx.sha256sum] = "9275756c9d23101bc0dfc5616f6e662e00233224681e4ca3f0412ed208cee2f1"

URI_x86_64_v2_libvpx-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libvpx-devel-1.14.1-3.el10_0.x86_64_v2.rpm;name=x86_64_v2_libvpx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvpx-devel}"
SRC_URI[x86_64_v2_libvpx-devel.sha256sum] = "76bd2cea56481318f50bb7c3d817496138e2af39a53933ac84476d8b50b2733d"

URI_aarch64_libvpx = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvpx-1.14.1-3.el10_0.aarch64.rpm;name=aarch64_libvpx;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvpx}"
SRC_URI[aarch64_libvpx.sha256sum] = "9afd30a6e540cea0ab7a51a756ef59d6ae096068afc78a3fee2d7f868f700342"

URI_aarch64_libvpx-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libvpx-devel-1.14.1-3.el10_0.aarch64.rpm;name=aarch64_libvpx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvpx-devel}"
SRC_URI[aarch64_libvpx-devel.sha256sum] = "ca247bb0fc6ceec1d3a6b2c5445aaa8501877f07bf11882447810517cb24122e"

RDEPENDS:libvpx = " \
 glibc \
 "
RDEPENDS:libvpx-devel = " \
 libvpx \
 pkgconf-pkg-config \
 "
