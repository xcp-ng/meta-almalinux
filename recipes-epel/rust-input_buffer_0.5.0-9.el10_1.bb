# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-input_buffer"
PV = "0.5.0"
PR = "9.el10_1"
PACKAGES = " \
 rust-input_buffer+default-devel \
 rust-input_buffer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-input_buffer-0.5.0-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d226360bc9bb191fa61e6d581c9ae86801ac192f94317717f9c575b81cac0172"

URI_x86_64_v2_rust-input_buffer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-input_buffer+default-devel-0.5.0-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-input_buffer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-input_buffer+default-devel}"
SRC_URI[x86_64_v2_rust-input_buffer+default-devel.sha256sum] = "84565728727e6b7353efee6268ae9fa23c718f0ff0aa95ae7a5dbb95524920d3"

URI_x86_64_v2_rust-input_buffer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-input_buffer-devel-0.5.0-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-input_buffer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-input_buffer-devel}"
SRC_URI[x86_64_v2_rust-input_buffer-devel.sha256sum] = "311e1e695e02ed766d3bc4bb4755e1dbdd486aa2cf25b909a4788b704b6203a9"

URI_aarch64_rust-input_buffer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-input_buffer+default-devel-0.5.0-9.el10_1.noarch.rpm;name=aarch64_rust-input_buffer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-input_buffer+default-devel}"
SRC_URI[aarch64_rust-input_buffer+default-devel.sha256sum] = "56b5bd69029daddc959d84840afec962b8cae75c33761807e811285a4fd27d83"

URI_aarch64_rust-input_buffer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-input_buffer-devel-0.5.0-9.el10_1.noarch.rpm;name=aarch64_rust-input_buffer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-input_buffer-devel}"
SRC_URI[aarch64_rust-input_buffer-devel.sha256sum] = "9e767edcc0a307fc323dce60300c1157094b15b5d9b044c10c966ec3d816d6e0"

RDEPENDS:rust-input_buffer+default-devel = " \
 cargo \
 rust-input_buffer-devel \
 "
RDEPENDS:rust-input_buffer-devel = " \
 cargo \
 rust-bytes+default-devel \
 "
