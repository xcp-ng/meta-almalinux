# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sqlx-sqlite"
PV = "0.8.6"
PR = "4.el10_3"
PACKAGES = " \
 rust-sqlx-sqlite+any-devel \
 rust-sqlx-sqlite+chrono-devel \
 rust-sqlx-sqlite+default-devel \
 rust-sqlx-sqlite+json-devel \
 rust-sqlx-sqlite+migrate-devel \
 rust-sqlx-sqlite+offline-devel \
 rust-sqlx-sqlite+preupdate-hook-devel \
 rust-sqlx-sqlite+regexp-devel \
 rust-sqlx-sqlite+serde-devel \
 rust-sqlx-sqlite+time-devel \
 rust-sqlx-sqlite+unbundled-devel \
 rust-sqlx-sqlite+uuid-devel \
 rust-sqlx-sqlite-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sqlx-sqlite-0.8.6-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "948953df4393a491474392d7a51fde349009a34103c4e0cf5b81e49bfa4ba08b"

URI_x86_64_v2_rust-sqlx-sqlite+any-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-sqlite+any-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-sqlite+any-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-sqlite+any-devel}"
SRC_URI[x86_64_v2_rust-sqlx-sqlite+any-devel.sha256sum] = "14d83802c933d93c47a10adfdc07669b13a15c32b7b95c268e9c503ba7783acf"

URI_x86_64_v2_rust-sqlx-sqlite+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-sqlite+chrono-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-sqlite+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-sqlite+chrono-devel}"
SRC_URI[x86_64_v2_rust-sqlx-sqlite+chrono-devel.sha256sum] = "6e08e85391f07a5fcea265f977c1862390b9fdb36e563c545c5a62e7431d3986"

URI_x86_64_v2_rust-sqlx-sqlite+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-sqlite+default-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-sqlite+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-sqlite+default-devel}"
SRC_URI[x86_64_v2_rust-sqlx-sqlite+default-devel.sha256sum] = "bb0b0ec98d0919d275123f33585920ac36f2d1b8c80bbd6070f14e83bac9d9c7"

URI_x86_64_v2_rust-sqlx-sqlite+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-sqlite+json-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-sqlite+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-sqlite+json-devel}"
SRC_URI[x86_64_v2_rust-sqlx-sqlite+json-devel.sha256sum] = "364c88e05cc9cbe6377b1a42758b6582f70dd470ea46bcb9c1f4b174c88069fa"

URI_x86_64_v2_rust-sqlx-sqlite+migrate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-sqlite+migrate-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-sqlite+migrate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-sqlite+migrate-devel}"
SRC_URI[x86_64_v2_rust-sqlx-sqlite+migrate-devel.sha256sum] = "580edd09d9599cd48f691372ec819c6016af94aeb8cc6e519676e6a603d449f3"

URI_x86_64_v2_rust-sqlx-sqlite+offline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-sqlite+offline-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-sqlite+offline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-sqlite+offline-devel}"
SRC_URI[x86_64_v2_rust-sqlx-sqlite+offline-devel.sha256sum] = "960c9a0cb0e4ae11f1fa9207dfd6955d681f783d5e3e1eddb908f92283c62e13"

URI_x86_64_v2_rust-sqlx-sqlite+preupdate-hook-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-sqlite+preupdate-hook-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-sqlite+preupdate-hook-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-sqlite+preupdate-hook-devel}"
SRC_URI[x86_64_v2_rust-sqlx-sqlite+preupdate-hook-devel.sha256sum] = "ce86013792a4b1888038f2a8f542827a17fcc5782acd46a242ef34905a0721f0"

URI_x86_64_v2_rust-sqlx-sqlite+regexp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-sqlite+regexp-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-sqlite+regexp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-sqlite+regexp-devel}"
SRC_URI[x86_64_v2_rust-sqlx-sqlite+regexp-devel.sha256sum] = "fc19884f2cf678bf7040f0e316a1af9e46c341b4a927ba9e38fcfc02cd00825e"

URI_x86_64_v2_rust-sqlx-sqlite+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-sqlite+serde-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-sqlite+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-sqlite+serde-devel}"
SRC_URI[x86_64_v2_rust-sqlx-sqlite+serde-devel.sha256sum] = "21dbb9841f16559afdce8ca23708ac85e4dec98b5d5ca828da8d40a02dc9285b"

URI_x86_64_v2_rust-sqlx-sqlite+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-sqlite+time-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-sqlite+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-sqlite+time-devel}"
SRC_URI[x86_64_v2_rust-sqlx-sqlite+time-devel.sha256sum] = "138a46c92551e0365931e81a75bde149801bf15ed4c28e68782298d41a0ef5ed"

URI_x86_64_v2_rust-sqlx-sqlite+unbundled-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-sqlite+unbundled-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-sqlite+unbundled-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-sqlite+unbundled-devel}"
SRC_URI[x86_64_v2_rust-sqlx-sqlite+unbundled-devel.sha256sum] = "21d60f3b790013124bdb29a9fd2fb6a841a7c174ae1c0893492f85e344917965"

URI_x86_64_v2_rust-sqlx-sqlite+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-sqlite+uuid-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-sqlite+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-sqlite+uuid-devel}"
SRC_URI[x86_64_v2_rust-sqlx-sqlite+uuid-devel.sha256sum] = "951b16324099f2e8cafca598f8f8d4c4715548d26ed4d6594fa621f24c72c61a"

URI_x86_64_v2_rust-sqlx-sqlite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-sqlite-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-sqlite-devel}"
SRC_URI[x86_64_v2_rust-sqlx-sqlite-devel.sha256sum] = "422d41e54e210690ccc4854ad97b4531479f03e1b1dece56c44aecbb4e6662ac"

URI_aarch64_rust-sqlx-sqlite+any-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-sqlite+any-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-sqlite+any-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-sqlite+any-devel}"
SRC_URI[aarch64_rust-sqlx-sqlite+any-devel.sha256sum] = "03d8573726b79e26224e5ce00cb5b8bf96b0b0997ea64c595206fe3dae805397"

URI_aarch64_rust-sqlx-sqlite+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-sqlite+chrono-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-sqlite+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-sqlite+chrono-devel}"
SRC_URI[aarch64_rust-sqlx-sqlite+chrono-devel.sha256sum] = "16c04c3cebdc9db1fd81cefd18bf3f8ff0ae2e00ad77c6523d806a833f3951ff"

URI_aarch64_rust-sqlx-sqlite+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-sqlite+default-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-sqlite+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-sqlite+default-devel}"
SRC_URI[aarch64_rust-sqlx-sqlite+default-devel.sha256sum] = "a4d8b09bfb7aadfad424700e71b9d5397aa5cff40a4ff6720b5516b4624531e4"

URI_aarch64_rust-sqlx-sqlite+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-sqlite+json-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-sqlite+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-sqlite+json-devel}"
SRC_URI[aarch64_rust-sqlx-sqlite+json-devel.sha256sum] = "a1a03a21277d9dd974bdc87e554404888b2957243f27cfc70f4358e85f2680ed"

URI_aarch64_rust-sqlx-sqlite+migrate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-sqlite+migrate-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-sqlite+migrate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-sqlite+migrate-devel}"
SRC_URI[aarch64_rust-sqlx-sqlite+migrate-devel.sha256sum] = "faeb9008d22949f46f13774e5944546516e955ed31a34349c8f0778d80a31547"

URI_aarch64_rust-sqlx-sqlite+offline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-sqlite+offline-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-sqlite+offline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-sqlite+offline-devel}"
SRC_URI[aarch64_rust-sqlx-sqlite+offline-devel.sha256sum] = "f7d38c83ae6ce0d8e36fc224fb9a009bb2a3c25458a9842cb311b078ebeca3fc"

URI_aarch64_rust-sqlx-sqlite+preupdate-hook-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-sqlite+preupdate-hook-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-sqlite+preupdate-hook-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-sqlite+preupdate-hook-devel}"
SRC_URI[aarch64_rust-sqlx-sqlite+preupdate-hook-devel.sha256sum] = "06c626129e3f37669ddfd24f57764692fd1618a760e6d57fea3cd4d9f745e76a"

URI_aarch64_rust-sqlx-sqlite+regexp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-sqlite+regexp-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-sqlite+regexp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-sqlite+regexp-devel}"
SRC_URI[aarch64_rust-sqlx-sqlite+regexp-devel.sha256sum] = "7951627f4fc06a24a74132a01331d906a3bd40818567b3bff9f16834bf798ebb"

URI_aarch64_rust-sqlx-sqlite+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-sqlite+serde-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-sqlite+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-sqlite+serde-devel}"
SRC_URI[aarch64_rust-sqlx-sqlite+serde-devel.sha256sum] = "992887d8a00590237a55332a5edd94978b9a91737c92d4b08495d5e231b0dbae"

URI_aarch64_rust-sqlx-sqlite+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-sqlite+time-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-sqlite+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-sqlite+time-devel}"
SRC_URI[aarch64_rust-sqlx-sqlite+time-devel.sha256sum] = "70b57e83f4693953eddf4074379f00fcc3946bc6bfc020f9eae4bd8c020329cb"

URI_aarch64_rust-sqlx-sqlite+unbundled-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-sqlite+unbundled-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-sqlite+unbundled-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-sqlite+unbundled-devel}"
SRC_URI[aarch64_rust-sqlx-sqlite+unbundled-devel.sha256sum] = "d2418ba1230ac1d19f4583b70cdb40f368f973f29ad70ec13cb36d47887f48b8"

URI_aarch64_rust-sqlx-sqlite+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-sqlite+uuid-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-sqlite+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-sqlite+uuid-devel}"
SRC_URI[aarch64_rust-sqlx-sqlite+uuid-devel.sha256sum] = "2405c5994988b29e7377c461cb3fab05d8a2cd874f534f0f2faa021e6536e563"

URI_aarch64_rust-sqlx-sqlite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-sqlite-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-sqlite-devel}"
SRC_URI[aarch64_rust-sqlx-sqlite-devel.sha256sum] = "f3cf9a3ff7e917dba0abdc7c5d96ddd5e7ec7f4d408736d0613e44fafa1769b5"

RDEPENDS:rust-sqlx-sqlite+any-devel = " \
 cargo \
 rust-sqlx-core+any-devel \
 rust-sqlx-sqlite-devel \
 "
RDEPENDS:rust-sqlx-sqlite+chrono-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono+std-devel \
 rust-chrono-devel \
 rust-sqlx-core+chrono-devel \
 rust-sqlx-sqlite-devel \
 "
RDEPENDS:rust-sqlx-sqlite+default-devel = " \
 cargo \
 rust-sqlx-sqlite-devel \
 "
RDEPENDS:rust-sqlx-sqlite+json-devel = " \
 cargo \
 rust-sqlx-core+json-devel \
 rust-sqlx-sqlite+serde-devel \
 rust-sqlx-sqlite-devel \
 "
RDEPENDS:rust-sqlx-sqlite+migrate-devel = " \
 cargo \
 rust-sqlx-core+migrate-devel \
 rust-sqlx-sqlite-devel \
 "
RDEPENDS:rust-sqlx-sqlite+offline-devel = " \
 cargo \
 rust-sqlx-core+offline-devel \
 rust-sqlx-sqlite+serde-devel \
 rust-sqlx-sqlite-devel \
 "
RDEPENDS:rust-sqlx-sqlite+preupdate-hook-devel = " \
 cargo \
 rust-libsqlite3-sys0.28+preupdate_hook-devel \
 rust-sqlx-sqlite-devel \
 "
RDEPENDS:rust-sqlx-sqlite+regexp-devel = " \
 cargo \
 rust-regex+default-devel \
 rust-sqlx-sqlite-devel \
 "
RDEPENDS:rust-sqlx-sqlite+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-sqlx-sqlite-devel \
 "
RDEPENDS:rust-sqlx-sqlite+time-devel = " \
 cargo \
 rust-sqlx-core+time-devel \
 rust-sqlx-sqlite-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+macros-devel \
 rust-time+parsing-devel \
 "
RDEPENDS:rust-sqlx-sqlite+unbundled-devel = " \
 cargo \
 rust-libsqlite3-sys0.28+buildtime_bindgen-devel \
 rust-sqlx-sqlite-devel \
 "
RDEPENDS:rust-sqlx-sqlite+uuid-devel = " \
 cargo \
 rust-sqlx-core+uuid-devel \
 rust-sqlx-sqlite-devel \
 rust-uuid+default-devel \
 "
RDEPENDS:rust-sqlx-sqlite-devel = " \
 cargo \
 rust-atoi+default-devel \
 rust-flume+async-devel \
 rust-flume-devel \
 rust-futures-channel+alloc-devel \
 rust-futures-channel+sink-devel \
 rust-futures-channel+std-devel \
 rust-futures-channel-devel \
 rust-futures-core-devel \
 rust-futures-executor+default-devel \
 rust-futures-intrusive+default-devel \
 rust-futures-util+alloc-devel \
 rust-futures-util+sink-devel \
 rust-futures-util-devel \
 rust-libsqlite3-sys0.28+unlock_notify-devel \
 rust-libsqlite3-sys0.28-devel \
 rust-log+default-devel \
 rust-percent-encoding+default-devel \
 rust-serde_urlencoded+default-devel \
 rust-sqlx-core+default-devel \
 rust-thiserror+default-devel \
 rust-tracing+default-devel \
 rust-tracing+log-devel \
 rust-url+default-devel \
 "
