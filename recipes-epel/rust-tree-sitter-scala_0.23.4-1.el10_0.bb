# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-scala"
PV = "0.23.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-tree-sitter-scala+default-devel \
 rust-tree-sitter-scala-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-scala-0.23.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "311800ebbdf195d08643a34ac7194e781de5de3cf3d93abcb38fd9cc82ab26ba"

URI_x86_64_v2_rust-tree-sitter-scala+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-scala+default-devel-0.23.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-scala+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-scala+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-scala+default-devel.sha256sum] = "c82406d018ea7a8caafd5506bd808ffd1701274fb51889978c731efc9c54fc44"

URI_x86_64_v2_rust-tree-sitter-scala-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-scala-devel-0.23.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-scala-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-scala-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-scala-devel.sha256sum] = "82492767c91b2cff662623672faf302443b2fcd9d6b4188e01151f871abb7a59"

URI_aarch64_rust-tree-sitter-scala+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-scala+default-devel-0.23.4-1.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-scala+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-scala+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-scala+default-devel.sha256sum] = "7265af50a696a0797126696a5f909b618fce73c56f2eec974c3137c75c66953e"

URI_aarch64_rust-tree-sitter-scala-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-scala-devel-0.23.4-1.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-scala-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-scala-devel}"
SRC_URI[aarch64_rust-tree-sitter-scala-devel.sha256sum] = "cfe7a7e72d6f65de2e361b7d5af6d6611a2449a154734ae870be1884a3b52701"

RDEPENDS:rust-tree-sitter-scala+default-devel = " \
 cargo \
 rust-tree-sitter-scala-devel \
 "
RDEPENDS:rust-tree-sitter-scala-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
