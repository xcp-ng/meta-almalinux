# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "barman"
PV = "3.18.0"
PR = "1.el10_1"
PACKAGES = " \
 barman \
 barman-cli \
 python3-barman \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/barman-3.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c6a94d5046d6ae727bf5d3fdf0baee10b88e4201b2194c10807587ec965df79"

URI_x86_64_v2_barman = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/barman-3.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_barman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_barman}"
SRC_URI[x86_64_v2_barman.sha256sum] = "01de7902e9b26b0e23097cf8f759f55df41e8db906d8dc9e27d42a4dd6f7caac"

URI_x86_64_v2_barman-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/barman-cli-3.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_barman-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_barman-cli}"
SRC_URI[x86_64_v2_barman-cli.sha256sum] = "6804fac019841958ac28302e00b5de2cdc511856cd5f158b38f0857b4a9501e5"

URI_x86_64_v2_python3-barman = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-barman-3.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-barman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-barman}"
SRC_URI[x86_64_v2_python3-barman.sha256sum] = "245c41b64fa6e577a763908fcd20b34be11194dea0a5f701cc8f898193489000"

URI_aarch64_barman = "${EPEL_MIRROR}/aarch64/Packages/b/barman-3.18.0-1.el10_1.noarch.rpm;name=aarch64_barman;unpack=0"
SRC_URI:append = " ${URI_aarch64_barman}"
SRC_URI[aarch64_barman.sha256sum] = "79971b9dd3141e3863fd5048e9dbfd56cb9579a4ae6448c2d35560e4f9b452db"

URI_aarch64_barman-cli = "${EPEL_MIRROR}/aarch64/Packages/b/barman-cli-3.18.0-1.el10_1.noarch.rpm;name=aarch64_barman-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_barman-cli}"
SRC_URI[aarch64_barman-cli.sha256sum] = "8ce14aae7828f18f2183a49170223ccc14b2f3788339ac505ca7aa60b2062356"

URI_aarch64_python3-barman = "${EPEL_MIRROR}/aarch64/Packages/p/python3-barman-3.18.0-1.el10_1.noarch.rpm;name=aarch64_python3-barman;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-barman}"
SRC_URI[aarch64_python3-barman.sha256sum] = "24201cffa7279929e42a893ac8702adb024ccb4323cd42da98f29a114a435d12"

RDEPENDS:barman = " \
 bash \
 cronie \
 logrotate \
 python3 \
 python3-argcomplete \
 python3-barman \
 rsync \
 shadow-utils \
 "
RDEPENDS:barman-cli = " \
 python3 \
 python3-barman \
 "
RDEPENDS:python3-barman = " \
 python3 \
 python3-dateutil \
 python3-psycopg2 \
 python3-setuptools \
 "
