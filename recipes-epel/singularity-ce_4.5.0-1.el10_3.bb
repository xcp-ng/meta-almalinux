# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "singularity-ce"
PV = "4.5.0"
PR = "1.el10_3"
PACKAGES = " \
 singularity-ce \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/singularity-ce-4.5.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5b0ba6d45dece60baf0824b8cf98acc1ab20238f030bce970e9d53709d3a57b2"

URI_x86_64_v2_singularity-ce = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/singularity-ce-4.5.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_singularity-ce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_singularity-ce}"
SRC_URI[x86_64_v2_singularity-ce.sha256sum] = "811c1960d2ec5dc646f215d62a3f8ff736fc8e1d2463acc855a0e0e65ba8589c"

URI_aarch64_singularity-ce = "${EPEL_MIRROR}/aarch64/Packages/s/singularity-ce-4.5.0-1.el10_3.aarch64.rpm;name=aarch64_singularity-ce;unpack=0"
SRC_URI:append = " ${URI_aarch64_singularity-ce}"
SRC_URI[aarch64_singularity-ce.sha256sum] = "54a021e82ccd832a9f6eddb4d45171761c7bd36f8cdd33301d5b2852462319e7"

RDEPENDS:singularity-ce = " \
 bash \
 conmon \
 crun \
 cryptsetup \
 fuse \
 fuse3 \
 glibc \
 libseccomp \
 shadow-utils \
 shadow-utils-subid \
 squashfs-tools \
 squashfuse \
 "
