# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pandoc"
PV = "3.1.11.1"
PR = "31.el10_0"
PACKAGES = " \
 ghc-citeproc \
 ghc-citeproc-devel \
 ghc-citeproc-doc \
 ghc-citeproc-prof \
 ghc-commonmark \
 ghc-commonmark-devel \
 ghc-commonmark-doc \
 ghc-commonmark-extensions \
 ghc-commonmark-extensions-devel \
 ghc-commonmark-extensions-doc \
 ghc-commonmark-extensions-prof \
 ghc-commonmark-pandoc \
 ghc-commonmark-pandoc-devel \
 ghc-commonmark-pandoc-doc \
 ghc-commonmark-pandoc-prof \
 ghc-commonmark-prof \
 ghc-digits \
 ghc-digits-devel \
 ghc-digits-doc \
 ghc-digits-prof \
 ghc-gridtables \
 ghc-gridtables-devel \
 ghc-gridtables-doc \
 ghc-gridtables-prof \
 ghc-ipynb \
 ghc-ipynb-devel \
 ghc-ipynb-doc \
 ghc-ipynb-prof \
 ghc-jira-wiki-markup \
 ghc-jira-wiki-markup-devel \
 ghc-jira-wiki-markup-doc \
 ghc-jira-wiki-markup-prof \
 ghc-ordered-containers \
 ghc-ordered-containers-devel \
 ghc-ordered-containers-doc \
 ghc-ordered-containers-prof \
 ghc-pandoc \
 ghc-pandoc-devel \
 ghc-pandoc-doc \
 ghc-pandoc-prof \
 ghc-typst \
 ghc-typst-devel \
 ghc-typst-doc \
 ghc-typst-prof \
 ghc-unicode-collation \
 ghc-unicode-collation-devel \
 ghc-unicode-collation-doc \
 ghc-unicode-collation-prof \
 pandoc-common \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pandoc-3.1.11.1-31.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "39ae145ac26a0858e5d1c521f56f11531ba84afb72f1c8fb92461cb7631e17f8"

URI_x86_64_v2_ghc-citeproc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-citeproc-0.8.1.1-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-citeproc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-citeproc}"
SRC_URI[x86_64_v2_ghc-citeproc.sha256sum] = "b2eac4a8ec4d0bba73cf0da7d8b7d033a869c09c63b7afa1158d743ab3b17db9"

URI_x86_64_v2_ghc-citeproc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-citeproc-devel-0.8.1.1-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-citeproc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-citeproc-devel}"
SRC_URI[x86_64_v2_ghc-citeproc-devel.sha256sum] = "e1d45cd01a039b77ce2828d6a225c0ff9f2a62d8d64547baa29c4c4864eadbd7"

URI_x86_64_v2_ghc-citeproc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-citeproc-doc-0.8.1.1-31.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-citeproc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-citeproc-doc}"
SRC_URI[x86_64_v2_ghc-citeproc-doc.sha256sum] = "ad98b0a103d6de26cc6478812ccdd2c0f942d94bb549d2169f0694ae4ab77b7a"

URI_x86_64_v2_ghc-citeproc-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-citeproc-prof-0.8.1.1-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-citeproc-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-citeproc-prof}"
SRC_URI[x86_64_v2_ghc-citeproc-prof.sha256sum] = "eced51bb1aea5dde78357f9a19fef72ba49df0021c1fea7a93ca38b85e59aa1b"

URI_x86_64_v2_ghc-commonmark = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-commonmark-0.2.6-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-commonmark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-commonmark}"
SRC_URI[x86_64_v2_ghc-commonmark.sha256sum] = "cba92e2d07c63d93d6febf2b998da57ebd1d181358ed1261e985b5e8a2240430"

URI_x86_64_v2_ghc-commonmark-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-commonmark-devel-0.2.6-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-commonmark-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-commonmark-devel}"
SRC_URI[x86_64_v2_ghc-commonmark-devel.sha256sum] = "a8c9774bc70c40269400cb82857dc6dc63ed7b8b1c0cd0d262e7a68aac49a1a0"

URI_x86_64_v2_ghc-commonmark-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-commonmark-doc-0.2.6-31.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-commonmark-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-commonmark-doc}"
SRC_URI[x86_64_v2_ghc-commonmark-doc.sha256sum] = "ee46c6aca9130950120c7e7596be3a345695a085b9ce310b6d1dcc488b971d0f"

URI_x86_64_v2_ghc-commonmark-extensions = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-commonmark-extensions-0.2.5.5-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-commonmark-extensions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-commonmark-extensions}"
SRC_URI[x86_64_v2_ghc-commonmark-extensions.sha256sum] = "eed8e64a5270aa53cc2900418b4041f19f12ac018fedb16883da2f9ebe29059f"

URI_x86_64_v2_ghc-commonmark-extensions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-commonmark-extensions-devel-0.2.5.5-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-commonmark-extensions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-commonmark-extensions-devel}"
SRC_URI[x86_64_v2_ghc-commonmark-extensions-devel.sha256sum] = "7d1394a4a90c9e34b6b842d6363111462a4482f031b964b54bd0f5d11061c527"

URI_x86_64_v2_ghc-commonmark-extensions-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-commonmark-extensions-doc-0.2.5.5-31.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-commonmark-extensions-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-commonmark-extensions-doc}"
SRC_URI[x86_64_v2_ghc-commonmark-extensions-doc.sha256sum] = "8bf327d6eba50c7ab7c8c1cc7d1491c7974aae18ace78fe01188bbc449f3ac1a"

URI_x86_64_v2_ghc-commonmark-extensions-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-commonmark-extensions-prof-0.2.5.5-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-commonmark-extensions-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-commonmark-extensions-prof}"
SRC_URI[x86_64_v2_ghc-commonmark-extensions-prof.sha256sum] = "87da4a759a2a7c2da627bab63b75db54669d61bee2d215dcc0276012e3b56017"

URI_x86_64_v2_ghc-commonmark-pandoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-commonmark-pandoc-0.2.2.1-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-commonmark-pandoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-commonmark-pandoc}"
SRC_URI[x86_64_v2_ghc-commonmark-pandoc.sha256sum] = "a2e91bce16ce64c0c5efe4e28b8f85c63c292e51c4010a4bbb9eca4874ef555f"

URI_x86_64_v2_ghc-commonmark-pandoc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-commonmark-pandoc-devel-0.2.2.1-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-commonmark-pandoc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-commonmark-pandoc-devel}"
SRC_URI[x86_64_v2_ghc-commonmark-pandoc-devel.sha256sum] = "da2e815329c531ae8e729cb81b8eb3af760af5cd9d3545b2ebf0473276735324"

URI_x86_64_v2_ghc-commonmark-pandoc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-commonmark-pandoc-doc-0.2.2.1-31.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-commonmark-pandoc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-commonmark-pandoc-doc}"
SRC_URI[x86_64_v2_ghc-commonmark-pandoc-doc.sha256sum] = "c640a273329dc2d80fc9ffdcfab7c9c09001b997754d5130b87d08d99bac944a"

URI_x86_64_v2_ghc-commonmark-pandoc-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-commonmark-pandoc-prof-0.2.2.1-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-commonmark-pandoc-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-commonmark-pandoc-prof}"
SRC_URI[x86_64_v2_ghc-commonmark-pandoc-prof.sha256sum] = "1b4fd74c01d2f0892b958ecfc8e5ae4ac70040b58a2b9d7199342b6ca03ffe25"

URI_x86_64_v2_ghc-commonmark-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-commonmark-prof-0.2.6-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-commonmark-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-commonmark-prof}"
SRC_URI[x86_64_v2_ghc-commonmark-prof.sha256sum] = "73ac22485f4fb3bbcd90252422acf90530bbd9e41ead1b95c53508bfd3406f61"

URI_x86_64_v2_ghc-digits = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-digits-0.3.1-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-digits;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-digits}"
SRC_URI[x86_64_v2_ghc-digits.sha256sum] = "2d2b2fa70a46a0bce4155a39b19e1a51a9adc45045324a4bc0d0c33bfd4fc63a"

URI_x86_64_v2_ghc-digits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-digits-devel-0.3.1-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-digits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-digits-devel}"
SRC_URI[x86_64_v2_ghc-digits-devel.sha256sum] = "0ff436d4569fc04bda0d43b793ec359254b304912b707351b8e345132c636b7e"

URI_x86_64_v2_ghc-digits-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-digits-doc-0.3.1-31.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-digits-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-digits-doc}"
SRC_URI[x86_64_v2_ghc-digits-doc.sha256sum] = "b75138a790d25d1ffe98744fa82d5b3dc835230b82aad6437069207ce55aa665"

URI_x86_64_v2_ghc-digits-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-digits-prof-0.3.1-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-digits-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-digits-prof}"
SRC_URI[x86_64_v2_ghc-digits-prof.sha256sum] = "fe8de42d7b512ba9d08340007878a39f57079fbc7cd305a71cc8ee6880564e79"

URI_x86_64_v2_ghc-gridtables = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-gridtables-0.1.0.0-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-gridtables;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-gridtables}"
SRC_URI[x86_64_v2_ghc-gridtables.sha256sum] = "615824efdae57c795bb0bd34a750b64a327caddfb245df94df5c60d0fcb3036e"

URI_x86_64_v2_ghc-gridtables-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-gridtables-devel-0.1.0.0-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-gridtables-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-gridtables-devel}"
SRC_URI[x86_64_v2_ghc-gridtables-devel.sha256sum] = "9d08ea4536104ebb9b7fddf8d89fecac22627dd2be6f5f2a188ad21c3361be32"

URI_x86_64_v2_ghc-gridtables-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-gridtables-doc-0.1.0.0-31.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-gridtables-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-gridtables-doc}"
SRC_URI[x86_64_v2_ghc-gridtables-doc.sha256sum] = "5f226642cfe6156af4d39fdcbeefc7cdaa2a9abffceb73de04179d2335f51e21"

URI_x86_64_v2_ghc-gridtables-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-gridtables-prof-0.1.0.0-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-gridtables-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-gridtables-prof}"
SRC_URI[x86_64_v2_ghc-gridtables-prof.sha256sum] = "6cae0fe204939b88b84ad12a74eb3373a99f0f148ae999ca500e6e28b8311b34"

URI_x86_64_v2_ghc-ipynb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ipynb-0.2-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ipynb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ipynb}"
SRC_URI[x86_64_v2_ghc-ipynb.sha256sum] = "5a50e9fa6275278db85f61577c0e96a20d7baf19af985c24197ac621c4af3823"

URI_x86_64_v2_ghc-ipynb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ipynb-devel-0.2-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ipynb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ipynb-devel}"
SRC_URI[x86_64_v2_ghc-ipynb-devel.sha256sum] = "af6b01c92f2f6cef44480e8e87ddbb4ee35b80ab13385d32fa2a85def0dc8b16"

URI_x86_64_v2_ghc-ipynb-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ipynb-doc-0.2-31.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-ipynb-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ipynb-doc}"
SRC_URI[x86_64_v2_ghc-ipynb-doc.sha256sum] = "81952fdd9c94f3e072a87cefb6e1afb3d7a7812c2265150f33cea067ace5b7d6"

URI_x86_64_v2_ghc-ipynb-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ipynb-prof-0.2-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ipynb-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ipynb-prof}"
SRC_URI[x86_64_v2_ghc-ipynb-prof.sha256sum] = "15bec6fb90a95d30856cf799593fce1a1d6db272737ead60ee6e63104b447c39"

URI_x86_64_v2_ghc-jira-wiki-markup = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-jira-wiki-markup-1.5.1-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-jira-wiki-markup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-jira-wiki-markup}"
SRC_URI[x86_64_v2_ghc-jira-wiki-markup.sha256sum] = "c38f761359233305740c42afd9311fc9883f01445e151c74189543d37b086d47"

URI_x86_64_v2_ghc-jira-wiki-markup-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-jira-wiki-markup-devel-1.5.1-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-jira-wiki-markup-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-jira-wiki-markup-devel}"
SRC_URI[x86_64_v2_ghc-jira-wiki-markup-devel.sha256sum] = "07a4cac8fbd064ff4ba92cb06927f746c6073c2d79e8d21190076d086bc937b4"

URI_x86_64_v2_ghc-jira-wiki-markup-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-jira-wiki-markup-doc-1.5.1-31.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-jira-wiki-markup-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-jira-wiki-markup-doc}"
SRC_URI[x86_64_v2_ghc-jira-wiki-markup-doc.sha256sum] = "e18968822017452f45c862b820d5c7713065db3c6e53fd86d8e361dd14f46504"

URI_x86_64_v2_ghc-jira-wiki-markup-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-jira-wiki-markup-prof-1.5.1-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-jira-wiki-markup-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-jira-wiki-markup-prof}"
SRC_URI[x86_64_v2_ghc-jira-wiki-markup-prof.sha256sum] = "f92ebea478450ca60c404a4444653684a1f3c6965ff07f4c5e628199559b2a77"

URI_x86_64_v2_ghc-ordered-containers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ordered-containers-0.2.4-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ordered-containers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ordered-containers}"
SRC_URI[x86_64_v2_ghc-ordered-containers.sha256sum] = "16c1e5a11498f66cf84cd01adf58e6c009c501068ba6fbf87549c7549e922930"

URI_x86_64_v2_ghc-ordered-containers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ordered-containers-devel-0.2.4-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ordered-containers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ordered-containers-devel}"
SRC_URI[x86_64_v2_ghc-ordered-containers-devel.sha256sum] = "09ff3b2710277e29a41d701e3a46e99053b01442a128ded31438bf2695c49251"

URI_x86_64_v2_ghc-ordered-containers-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ordered-containers-doc-0.2.4-31.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-ordered-containers-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ordered-containers-doc}"
SRC_URI[x86_64_v2_ghc-ordered-containers-doc.sha256sum] = "9d67f0401c6f5ea8f2489f1f57ed28752bd791a08c95d1c732a263d13b49cc0b"

URI_x86_64_v2_ghc-ordered-containers-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ordered-containers-prof-0.2.4-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ordered-containers-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ordered-containers-prof}"
SRC_URI[x86_64_v2_ghc-ordered-containers-prof.sha256sum] = "03cac1a2f5d471ba92cbb0df18296c44f66287e5d114bb53e92d5a9031aa4eec"

URI_x86_64_v2_ghc-pandoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pandoc-3.1.11.1-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pandoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pandoc}"
SRC_URI[x86_64_v2_ghc-pandoc.sha256sum] = "4208b19f61511945c4c1895b208a332d9f2b9069d82af1842f9c64133ed97cf2"

URI_x86_64_v2_ghc-pandoc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pandoc-devel-3.1.11.1-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pandoc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pandoc-devel}"
SRC_URI[x86_64_v2_ghc-pandoc-devel.sha256sum] = "218bc009142adfe0fe228249a65465188d42c467cf6d3c67d70c6c0ff38943a5"

URI_x86_64_v2_ghc-pandoc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pandoc-doc-3.1.11.1-31.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-pandoc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pandoc-doc}"
SRC_URI[x86_64_v2_ghc-pandoc-doc.sha256sum] = "2a1de3f9a5da9fc4abdd7333625cb4263a7c745e4b7d18608a1e5a989846215d"

URI_x86_64_v2_ghc-pandoc-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pandoc-prof-3.1.11.1-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pandoc-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pandoc-prof}"
SRC_URI[x86_64_v2_ghc-pandoc-prof.sha256sum] = "ffbd2727b20bc5221cf764a50a5f9a42655de1a9662cd2a5f43ce06f22c37f9e"

URI_x86_64_v2_ghc-typst = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-typst-0.5.0.1-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-typst;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-typst}"
SRC_URI[x86_64_v2_ghc-typst.sha256sum] = "3f9556fb339018bb9e4aaaa0e91cd68e676bd57183f81d5fb849c2ecce382c78"

URI_x86_64_v2_ghc-typst-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-typst-devel-0.5.0.1-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-typst-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-typst-devel}"
SRC_URI[x86_64_v2_ghc-typst-devel.sha256sum] = "75fa8d190c149a2818ec6e064318b1c56cf9ca5557b43042984b0a95237e8a05"

URI_x86_64_v2_ghc-typst-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-typst-doc-0.5.0.1-31.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-typst-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-typst-doc}"
SRC_URI[x86_64_v2_ghc-typst-doc.sha256sum] = "ce2a7c7142208b2c2574d94092d81cd9d5576db08a5580e5937057cc76267292"

URI_x86_64_v2_ghc-typst-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-typst-prof-0.5.0.1-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-typst-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-typst-prof}"
SRC_URI[x86_64_v2_ghc-typst-prof.sha256sum] = "76c4af3ff2a4c2280e06976440d9b6d80ede8da3d781a59aa17ac1434675b8c4"

URI_x86_64_v2_ghc-unicode-collation = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-unicode-collation-0.1.3.6-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-unicode-collation;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-unicode-collation}"
SRC_URI[x86_64_v2_ghc-unicode-collation.sha256sum] = "8fa88868e4c7cd7e5991eb962cd406b96cafac173c5db01ca25241e9908cf9dd"

URI_x86_64_v2_ghc-unicode-collation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-unicode-collation-devel-0.1.3.6-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-unicode-collation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-unicode-collation-devel}"
SRC_URI[x86_64_v2_ghc-unicode-collation-devel.sha256sum] = "6a7120f0cec9bf4e45455c61a2265af98e0ef5d6a16701a3ea74416edda63f5a"

URI_x86_64_v2_ghc-unicode-collation-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-unicode-collation-doc-0.1.3.6-31.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-unicode-collation-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-unicode-collation-doc}"
SRC_URI[x86_64_v2_ghc-unicode-collation-doc.sha256sum] = "364448a3410f5bb80d68e01cd9948bc8223b8666fd6e5a8a731975f683137ee6"

URI_x86_64_v2_ghc-unicode-collation-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-unicode-collation-prof-0.1.3.6-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-unicode-collation-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-unicode-collation-prof}"
SRC_URI[x86_64_v2_ghc-unicode-collation-prof.sha256sum] = "f047d233fe422a4d29d8b7903149dc205dac1f2cf24d08b7bf349cc75b547a3a"

URI_x86_64_v2_pandoc-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pandoc-common-3.1.11.1-31.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_pandoc-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pandoc-common}"
SRC_URI[x86_64_v2_pandoc-common.sha256sum] = "cc6c2f31f208e6efb65f936e7f39616c324b430b502301a7edd5d2ed53c2c4a5"

URI_aarch64_ghc-citeproc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-citeproc-0.8.1.1-31.el10_0.aarch64.rpm;name=aarch64_ghc-citeproc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-citeproc}"
SRC_URI[aarch64_ghc-citeproc.sha256sum] = "b0cf0223310b7250b26986607127284a32e3aaed6524d665c6e5ca40f309ce84"

URI_aarch64_ghc-citeproc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-citeproc-devel-0.8.1.1-31.el10_0.aarch64.rpm;name=aarch64_ghc-citeproc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-citeproc-devel}"
SRC_URI[aarch64_ghc-citeproc-devel.sha256sum] = "5cf20710d72ebe8763af9676dcb361b24dfc671ce307ff089814821795923839"

URI_aarch64_ghc-citeproc-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-citeproc-doc-0.8.1.1-31.el10_0.noarch.rpm;name=aarch64_ghc-citeproc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-citeproc-doc}"
SRC_URI[aarch64_ghc-citeproc-doc.sha256sum] = "7707b02150b0e3c9124b38aeaa009c3fa338cc0c841c08329ec4c811038fecaf"

URI_aarch64_ghc-citeproc-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-citeproc-prof-0.8.1.1-31.el10_0.aarch64.rpm;name=aarch64_ghc-citeproc-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-citeproc-prof}"
SRC_URI[aarch64_ghc-citeproc-prof.sha256sum] = "2a30c867d701a5a8315198b7f54b733ce3731746cbca4826740d69dde2a71cfc"

URI_aarch64_ghc-commonmark = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-commonmark-0.2.6-31.el10_0.aarch64.rpm;name=aarch64_ghc-commonmark;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-commonmark}"
SRC_URI[aarch64_ghc-commonmark.sha256sum] = "5a01e7595739564d3fe34cde5adcdf054b833dd7061bca4a124e003082a02d12"

URI_aarch64_ghc-commonmark-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-commonmark-devel-0.2.6-31.el10_0.aarch64.rpm;name=aarch64_ghc-commonmark-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-commonmark-devel}"
SRC_URI[aarch64_ghc-commonmark-devel.sha256sum] = "cb130add9a9cd18b37dd7bfa014ed0bfd0b0649a5b640688c47762639c73a700"

URI_aarch64_ghc-commonmark-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-commonmark-doc-0.2.6-31.el10_0.noarch.rpm;name=aarch64_ghc-commonmark-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-commonmark-doc}"
SRC_URI[aarch64_ghc-commonmark-doc.sha256sum] = "dc004b7704bd325a99e40f6969e6259ccaf3b33c1c2fd0915c920957d02eff7e"

URI_aarch64_ghc-commonmark-extensions = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-commonmark-extensions-0.2.5.5-31.el10_0.aarch64.rpm;name=aarch64_ghc-commonmark-extensions;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-commonmark-extensions}"
SRC_URI[aarch64_ghc-commonmark-extensions.sha256sum] = "8e5fb59171fab003e05668b1c1359e46d7742c2521bbb9fc6741e671d42c2aea"

URI_aarch64_ghc-commonmark-extensions-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-commonmark-extensions-devel-0.2.5.5-31.el10_0.aarch64.rpm;name=aarch64_ghc-commonmark-extensions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-commonmark-extensions-devel}"
SRC_URI[aarch64_ghc-commonmark-extensions-devel.sha256sum] = "2d69e827882124f5b7eeb59eda0459f0c569cc64d1cbd3e2446dec00de83320b"

URI_aarch64_ghc-commonmark-extensions-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-commonmark-extensions-doc-0.2.5.5-31.el10_0.noarch.rpm;name=aarch64_ghc-commonmark-extensions-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-commonmark-extensions-doc}"
SRC_URI[aarch64_ghc-commonmark-extensions-doc.sha256sum] = "c07363644c6c79fe666642ac34d131f61c2b2bd25bc4a2e7529c8bc0e1d4e394"

URI_aarch64_ghc-commonmark-extensions-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-commonmark-extensions-prof-0.2.5.5-31.el10_0.aarch64.rpm;name=aarch64_ghc-commonmark-extensions-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-commonmark-extensions-prof}"
SRC_URI[aarch64_ghc-commonmark-extensions-prof.sha256sum] = "ba45c46ca321ba0bdb1dfcb69bb7e146983efa27bf9f9d8e3c095c77cc0c7499"

URI_aarch64_ghc-commonmark-pandoc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-commonmark-pandoc-0.2.2.1-31.el10_0.aarch64.rpm;name=aarch64_ghc-commonmark-pandoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-commonmark-pandoc}"
SRC_URI[aarch64_ghc-commonmark-pandoc.sha256sum] = "7934064def175ec2b9f834f39ae42d7727a79302558e23f0b7236091fb8e67a4"

URI_aarch64_ghc-commonmark-pandoc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-commonmark-pandoc-devel-0.2.2.1-31.el10_0.aarch64.rpm;name=aarch64_ghc-commonmark-pandoc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-commonmark-pandoc-devel}"
SRC_URI[aarch64_ghc-commonmark-pandoc-devel.sha256sum] = "97a9e061ec5bb0a59a7e5f42d9046fbc522c416e9714c505eefe3535865541dc"

URI_aarch64_ghc-commonmark-pandoc-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-commonmark-pandoc-doc-0.2.2.1-31.el10_0.noarch.rpm;name=aarch64_ghc-commonmark-pandoc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-commonmark-pandoc-doc}"
SRC_URI[aarch64_ghc-commonmark-pandoc-doc.sha256sum] = "2023c40bebfbc8f1d333000ab7e69798a7678dfe40c52596a0c4fe1ca16f1160"

URI_aarch64_ghc-commonmark-pandoc-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-commonmark-pandoc-prof-0.2.2.1-31.el10_0.aarch64.rpm;name=aarch64_ghc-commonmark-pandoc-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-commonmark-pandoc-prof}"
SRC_URI[aarch64_ghc-commonmark-pandoc-prof.sha256sum] = "fab26a672ea25e79555d034e3173500318ff492a66b5f3632c91f0404dcd3e79"

URI_aarch64_ghc-commonmark-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-commonmark-prof-0.2.6-31.el10_0.aarch64.rpm;name=aarch64_ghc-commonmark-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-commonmark-prof}"
SRC_URI[aarch64_ghc-commonmark-prof.sha256sum] = "424d256256c4fe45c4270187e18d078d8b653c7797cf180c85f6ea746a2a7fab"

URI_aarch64_ghc-digits = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-digits-0.3.1-31.el10_0.aarch64.rpm;name=aarch64_ghc-digits;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-digits}"
SRC_URI[aarch64_ghc-digits.sha256sum] = "18987703646467d4f7c6b0acf7b332fe51cc1993aef73f0b62988791f5c8f4c4"

URI_aarch64_ghc-digits-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-digits-devel-0.3.1-31.el10_0.aarch64.rpm;name=aarch64_ghc-digits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-digits-devel}"
SRC_URI[aarch64_ghc-digits-devel.sha256sum] = "b2ed6422b8830b44f37ad0c0085aa3530cc20d03d27cc1d8bd17c66fcc3d398b"

URI_aarch64_ghc-digits-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-digits-doc-0.3.1-31.el10_0.noarch.rpm;name=aarch64_ghc-digits-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-digits-doc}"
SRC_URI[aarch64_ghc-digits-doc.sha256sum] = "4ad371c0db7ad47552f1258c664e4474bff3206b07508c75caa79e8155f3b004"

URI_aarch64_ghc-digits-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-digits-prof-0.3.1-31.el10_0.aarch64.rpm;name=aarch64_ghc-digits-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-digits-prof}"
SRC_URI[aarch64_ghc-digits-prof.sha256sum] = "89ec36d418bdbb418abbb9ce016552213a0e11cea636a4d858377d600b3627a8"

URI_aarch64_ghc-gridtables = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-gridtables-0.1.0.0-31.el10_0.aarch64.rpm;name=aarch64_ghc-gridtables;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-gridtables}"
SRC_URI[aarch64_ghc-gridtables.sha256sum] = "9f3629340108f5c7a4606c0e8e85fb530a1b37190a08939676e31cde3ba7e0af"

URI_aarch64_ghc-gridtables-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-gridtables-devel-0.1.0.0-31.el10_0.aarch64.rpm;name=aarch64_ghc-gridtables-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-gridtables-devel}"
SRC_URI[aarch64_ghc-gridtables-devel.sha256sum] = "48d30f3f0fe65d423a13ad1f1018ae49d6ea08131b50dc15736bab3cbfd512b1"

URI_aarch64_ghc-gridtables-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-gridtables-doc-0.1.0.0-31.el10_0.noarch.rpm;name=aarch64_ghc-gridtables-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-gridtables-doc}"
SRC_URI[aarch64_ghc-gridtables-doc.sha256sum] = "9ee61336bd526d8e3f8cfcfb40b2a0c8f4b8203e5cb478d161321fc491882b19"

URI_aarch64_ghc-gridtables-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-gridtables-prof-0.1.0.0-31.el10_0.aarch64.rpm;name=aarch64_ghc-gridtables-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-gridtables-prof}"
SRC_URI[aarch64_ghc-gridtables-prof.sha256sum] = "afa234be550cd5e8fd1fd2331a30be4ce9f207d65d885c6d147bf3fd4ca908ff"

URI_aarch64_ghc-ipynb = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ipynb-0.2-31.el10_0.aarch64.rpm;name=aarch64_ghc-ipynb;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ipynb}"
SRC_URI[aarch64_ghc-ipynb.sha256sum] = "cd8fc7adb2a0106b638e5d211416f7fdde11b4867af03d7f3b53dd492377cd8f"

URI_aarch64_ghc-ipynb-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ipynb-devel-0.2-31.el10_0.aarch64.rpm;name=aarch64_ghc-ipynb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ipynb-devel}"
SRC_URI[aarch64_ghc-ipynb-devel.sha256sum] = "b4bf168690c703fd62d654214bc1b2512ce5c01dcdbeebc4b456295556f05f2f"

URI_aarch64_ghc-ipynb-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ipynb-doc-0.2-31.el10_0.noarch.rpm;name=aarch64_ghc-ipynb-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ipynb-doc}"
SRC_URI[aarch64_ghc-ipynb-doc.sha256sum] = "b9f55ff047fcb298491f3faeef550715045d90ff09f3ce5da3a6ee58a3becf26"

URI_aarch64_ghc-ipynb-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ipynb-prof-0.2-31.el10_0.aarch64.rpm;name=aarch64_ghc-ipynb-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ipynb-prof}"
SRC_URI[aarch64_ghc-ipynb-prof.sha256sum] = "ecfa184d171caf36f431a066a70f213755b20fffa753fa503802ef5e3f5267d2"

URI_aarch64_ghc-jira-wiki-markup = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-jira-wiki-markup-1.5.1-31.el10_0.aarch64.rpm;name=aarch64_ghc-jira-wiki-markup;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-jira-wiki-markup}"
SRC_URI[aarch64_ghc-jira-wiki-markup.sha256sum] = "78bdeb482cda7b798c5b27ee7cf61ab36a4d372fc7ef46cafe08f83e7e39a8e5"

URI_aarch64_ghc-jira-wiki-markup-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-jira-wiki-markup-devel-1.5.1-31.el10_0.aarch64.rpm;name=aarch64_ghc-jira-wiki-markup-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-jira-wiki-markup-devel}"
SRC_URI[aarch64_ghc-jira-wiki-markup-devel.sha256sum] = "e7145ac7039c74009c2ce232bdd72397fc0733c87e5e6a22cae9eebded6b173e"

URI_aarch64_ghc-jira-wiki-markup-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-jira-wiki-markup-doc-1.5.1-31.el10_0.noarch.rpm;name=aarch64_ghc-jira-wiki-markup-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-jira-wiki-markup-doc}"
SRC_URI[aarch64_ghc-jira-wiki-markup-doc.sha256sum] = "2e4140bdaf341cbde285e154aa8675ead8bc1ee3998405694df15dc7bd5b2931"

URI_aarch64_ghc-jira-wiki-markup-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-jira-wiki-markup-prof-1.5.1-31.el10_0.aarch64.rpm;name=aarch64_ghc-jira-wiki-markup-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-jira-wiki-markup-prof}"
SRC_URI[aarch64_ghc-jira-wiki-markup-prof.sha256sum] = "9a5414e75e6fba4a6edfe6bb503b1dac18a1b9cfcac2f887d316a9aeb52a6dd7"

URI_aarch64_ghc-ordered-containers = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ordered-containers-0.2.4-31.el10_0.aarch64.rpm;name=aarch64_ghc-ordered-containers;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ordered-containers}"
SRC_URI[aarch64_ghc-ordered-containers.sha256sum] = "980f92a44e5f53c6affa5336b39e6799f0224632e504b94b182808ec5df54328"

URI_aarch64_ghc-ordered-containers-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ordered-containers-devel-0.2.4-31.el10_0.aarch64.rpm;name=aarch64_ghc-ordered-containers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ordered-containers-devel}"
SRC_URI[aarch64_ghc-ordered-containers-devel.sha256sum] = "53f2d3607dd26a5003ff2336c2a80064a1ab1945444d4dcad04ed815ea5654e4"

URI_aarch64_ghc-ordered-containers-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ordered-containers-doc-0.2.4-31.el10_0.noarch.rpm;name=aarch64_ghc-ordered-containers-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ordered-containers-doc}"
SRC_URI[aarch64_ghc-ordered-containers-doc.sha256sum] = "fe510590d2d6a4220edeb490d62ac6848dc765c585bbb92144cfc1d1725b4570"

URI_aarch64_ghc-ordered-containers-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ordered-containers-prof-0.2.4-31.el10_0.aarch64.rpm;name=aarch64_ghc-ordered-containers-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ordered-containers-prof}"
SRC_URI[aarch64_ghc-ordered-containers-prof.sha256sum] = "4ec4f5bfe99e8a09a062ab3cd2cccd54b41c68507bef7a27983ac9e880a1dd1c"

URI_aarch64_ghc-pandoc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pandoc-3.1.11.1-31.el10_0.aarch64.rpm;name=aarch64_ghc-pandoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pandoc}"
SRC_URI[aarch64_ghc-pandoc.sha256sum] = "c38e7e29b75dc2cbc0f0eabd2ad5cf15ba331a405e83d3d6dfe96afc86874ffd"

URI_aarch64_ghc-pandoc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pandoc-devel-3.1.11.1-31.el10_0.aarch64.rpm;name=aarch64_ghc-pandoc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pandoc-devel}"
SRC_URI[aarch64_ghc-pandoc-devel.sha256sum] = "d2a6fc199328d4ba9fc34e3b2c992f9043637e3dc5df8da2a87017998f1df76d"

URI_aarch64_ghc-pandoc-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pandoc-doc-3.1.11.1-31.el10_0.noarch.rpm;name=aarch64_ghc-pandoc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pandoc-doc}"
SRC_URI[aarch64_ghc-pandoc-doc.sha256sum] = "bd784bc54b8de15bcc5b5a071711209c105b2614e6005aeb363b2f311eed4579"

URI_aarch64_ghc-pandoc-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pandoc-prof-3.1.11.1-31.el10_0.aarch64.rpm;name=aarch64_ghc-pandoc-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pandoc-prof}"
SRC_URI[aarch64_ghc-pandoc-prof.sha256sum] = "682ffd0cefe56535db0777abf1fc6e978613653eadf42bff3d4fc2616b2f5e1d"

URI_aarch64_ghc-typst = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-typst-0.5.0.1-31.el10_0.aarch64.rpm;name=aarch64_ghc-typst;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-typst}"
SRC_URI[aarch64_ghc-typst.sha256sum] = "b7b49de5ca17ee7a07014382e35e909935f56f408f9fea1bc94908fdb235bd69"

URI_aarch64_ghc-typst-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-typst-devel-0.5.0.1-31.el10_0.aarch64.rpm;name=aarch64_ghc-typst-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-typst-devel}"
SRC_URI[aarch64_ghc-typst-devel.sha256sum] = "dd9c8de9bc4102924c58b7192c5e013876e89290be7266e2657fc4bdd5af8362"

URI_aarch64_ghc-typst-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-typst-doc-0.5.0.1-31.el10_0.noarch.rpm;name=aarch64_ghc-typst-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-typst-doc}"
SRC_URI[aarch64_ghc-typst-doc.sha256sum] = "b496b3f3afbb65e5d0c253654b35b158dc0392351d77ec5c95b2df119fe55aba"

URI_aarch64_ghc-typst-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-typst-prof-0.5.0.1-31.el10_0.aarch64.rpm;name=aarch64_ghc-typst-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-typst-prof}"
SRC_URI[aarch64_ghc-typst-prof.sha256sum] = "cd5258d57b4e50ece1473480ae5c517743c3662b5d6fde33f38ca29151ae7b59"

URI_aarch64_ghc-unicode-collation = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-unicode-collation-0.1.3.6-31.el10_0.aarch64.rpm;name=aarch64_ghc-unicode-collation;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-unicode-collation}"
SRC_URI[aarch64_ghc-unicode-collation.sha256sum] = "a17ec974814ff39d43dcb16724a978337bf47a76ce88ce45f2af0ba25701514e"

URI_aarch64_ghc-unicode-collation-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-unicode-collation-devel-0.1.3.6-31.el10_0.aarch64.rpm;name=aarch64_ghc-unicode-collation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-unicode-collation-devel}"
SRC_URI[aarch64_ghc-unicode-collation-devel.sha256sum] = "39f616974bcf7aa2e7da4ebf29536373e5889fe246b01fd7c03c739fd16d9285"

URI_aarch64_ghc-unicode-collation-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-unicode-collation-doc-0.1.3.6-31.el10_0.noarch.rpm;name=aarch64_ghc-unicode-collation-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-unicode-collation-doc}"
SRC_URI[aarch64_ghc-unicode-collation-doc.sha256sum] = "7afc04a4c2df0a358eb4578d2daa54ed6e5a67b269ba7aa3f93dbcc0a7748902"

URI_aarch64_ghc-unicode-collation-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-unicode-collation-prof-0.1.3.6-31.el10_0.aarch64.rpm;name=aarch64_ghc-unicode-collation-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-unicode-collation-prof}"
SRC_URI[aarch64_ghc-unicode-collation-prof.sha256sum] = "144b34b5b63bf16a2c56cc783f28645d3f6d3180a34f3cdcab4a27545cf92c6d"

URI_aarch64_pandoc-common = "${EPEL_MIRROR}/aarch64/Packages/p/pandoc-common-3.1.11.1-31.el10_0.noarch.rpm;name=aarch64_pandoc-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_pandoc-common}"
SRC_URI[aarch64_pandoc-common.sha256sum] = "9309dbc54cb94bb29b64904aedd672f54547b405f3086c5a103226e744368b96"

RDEPENDS:ghc-citeproc = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-array \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-data-default \
 ghc-data-default-class \
 ghc-data-default-instances-containers \
 ghc-data-default-instances-dlist \
 ghc-data-default-instances-old-locale \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-file-embed \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-old-locale \
 ghc-os-string \
 ghc-pandoc-types \
 ghc-parsec \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-resourcet \
 ghc-safe \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-syb \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-lift \
 ghc-th-lift-instances \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-unicode-collation \
 ghc-uniplate \
 ghc-unix \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-witherable \
 ghc-xml-conduit \
 ghc-xml-types \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-citeproc-devel = " \
 ghc-aeson-devel \
 ghc-attoparsec-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-case-insensitive-devel \
 ghc-citeproc \
 ghc-compiler \
 ghc-containers-devel \
 ghc-data-default-devel \
 ghc-file-embed-devel \
 ghc-filepath-devel \
 ghc-pandoc-types-devel \
 ghc-safe-devel \
 ghc-scientific-devel \
 ghc-text-devel \
 ghc-transformers-devel \
 ghc-unicode-collation-devel \
 ghc-uniplate-devel \
 ghc-vector-devel \
 ghc-xml-conduit-devel \
 "
RDEPENDS:ghc-citeproc-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-citeproc-prof = " \
 ghc-aeson-prof \
 ghc-attoparsec-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-case-insensitive-prof \
 ghc-citeproc-devel \
 ghc-containers-prof \
 ghc-data-default-prof \
 ghc-file-embed-prof \
 ghc-filepath-prof \
 ghc-pandoc-types-prof \
 ghc-safe-prof \
 ghc-scientific-prof \
 ghc-text-prof \
 ghc-transformers-prof \
 ghc-unicode-collation-prof \
 ghc-uniplate-prof \
 ghc-vector-prof \
 ghc-xml-conduit-prof \
 "
RDEPENDS:ghc-commonmark = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-parsec \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 ghc-unicode-data \
 ghc-unicode-transforms \
 glibc \
 gmp \
 "
RDEPENDS:ghc-commonmark-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-commonmark \
 ghc-compiler \
 ghc-containers-devel \
 ghc-parsec-devel \
 ghc-text-devel \
 ghc-transformers-devel \
 ghc-unicode-data-devel \
 ghc-unicode-transforms-devel \
 "
RDEPENDS:ghc-commonmark-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-commonmark-extensions = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-commonmark \
 ghc-containers \
 ghc-deepseq \
 ghc-emojis \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-network-uri \
 ghc-parsec \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-th-compat \
 ghc-transformers \
 ghc-unicode-data \
 ghc-unicode-transforms \
 glibc \
 gmp \
 "
RDEPENDS:ghc-commonmark-extensions-devel = " \
 ghc-base-devel \
 ghc-commonmark-devel \
 ghc-commonmark-extensions \
 ghc-compiler \
 ghc-containers-devel \
 ghc-emojis-devel \
 ghc-filepath-devel \
 ghc-network-uri-devel \
 ghc-parsec-devel \
 ghc-text-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-commonmark-extensions-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-commonmark-extensions-prof = " \
 ghc-base-prof \
 ghc-commonmark-extensions-devel \
 ghc-commonmark-prof \
 ghc-containers-prof \
 ghc-emojis-prof \
 ghc-filepath-prof \
 ghc-network-uri-prof \
 ghc-parsec-prof \
 ghc-text-prof \
 ghc-transformers-prof \
 "
RDEPENDS:ghc-commonmark-pandoc = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-array \
 ghc-assoc \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-bifunctors \
 ghc-binary \
 ghc-bytestring \
 ghc-commonmark \
 ghc-commonmark-extensions \
 ghc-comonad \
 ghc-containers \
 ghc-contravariant \
 ghc-data-fix \
 ghc-deepseq \
 ghc-distributive \
 ghc-dlist \
 ghc-emojis \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-mtl \
 ghc-network-uri \
 ghc-os-string \
 ghc-pandoc-types \
 ghc-parsec \
 ghc-pretty \
 ghc-primitive \
 ghc-random \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-splitmix \
 ghc-stm \
 ghc-strict \
 ghc-syb \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-compat \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unicode-data \
 ghc-unicode-transforms \
 ghc-unix \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-stream \
 ghc-witherable \
 glibc \
 gmp \
 "
RDEPENDS:ghc-commonmark-pandoc-devel = " \
 ghc-base-devel \
 ghc-commonmark-devel \
 ghc-commonmark-extensions-devel \
 ghc-commonmark-pandoc \
 ghc-compiler \
 ghc-pandoc-types-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-commonmark-pandoc-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-commonmark-pandoc-prof = " \
 ghc-base-prof \
 ghc-commonmark-extensions-prof \
 ghc-commonmark-pandoc-devel \
 ghc-commonmark-prof \
 ghc-pandoc-types-prof \
 ghc-text-prof \
 "
RDEPENDS:ghc-commonmark-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-commonmark-devel \
 ghc-containers-prof \
 ghc-parsec-prof \
 ghc-text-prof \
 ghc-transformers-prof \
 ghc-unicode-data-prof \
 ghc-unicode-transforms-prof \
 "
RDEPENDS:ghc-digits = " \
 ghc-QuickCheck \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-random \
 ghc-splitmix \
 ghc-template-haskell \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-digits-devel = " \
 ghc-QuickCheck-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-digits \
 "
RDEPENDS:ghc-digits-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-digits-prof = " \
 ghc-QuickCheck-prof \
 ghc-base-prof \
 ghc-digits-devel \
 "
RDEPENDS:ghc-gridtables = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-doclayout \
 ghc-emojis \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-parsec \
 ghc-pretty \
 ghc-safe \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-gridtables-devel = " \
 ghc-array-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-doclayout-devel \
 ghc-gridtables \
 ghc-parsec-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-gridtables-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-gridtables-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-doclayout-prof \
 ghc-gridtables-devel \
 ghc-parsec-prof \
 ghc-text-prof \
 "
RDEPENDS:ghc-ipynb = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-array \
 ghc-assoc \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-bifunctors \
 ghc-binary \
 ghc-bytestring \
 ghc-comonad \
 ghc-containers \
 ghc-contravariant \
 ghc-data-fix \
 ghc-deepseq \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-random \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-splitmix \
 ghc-stm \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-stream \
 ghc-witherable \
 glibc \
 gmp \
 "
RDEPENDS:ghc-ipynb-devel = " \
 ghc-aeson-devel \
 ghc-base-devel \
 ghc-base64-bytestring-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-ipynb \
 ghc-text-devel \
 ghc-unordered-containers-devel \
 "
RDEPENDS:ghc-ipynb-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-ipynb-prof = " \
 ghc-aeson-prof \
 ghc-base-prof \
 ghc-base64-bytestring-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-ipynb-devel \
 ghc-text-prof \
 ghc-unordered-containers-prof \
 "
RDEPENDS:ghc-jira-wiki-markup = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-parsec \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc-jira-wiki-markup-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-jira-wiki-markup \
 ghc-mtl-devel \
 ghc-parsec-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-jira-wiki-markup-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-jira-wiki-markup-prof = " \
 ghc-base-prof \
 ghc-jira-wiki-markup-devel \
 ghc-mtl-prof \
 ghc-parsec-prof \
 ghc-text-prof \
 "
RDEPENDS:ghc-ordered-containers = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-ordered-containers-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-hashable-devel \
 ghc-ordered-containers \
 "
RDEPENDS:ghc-ordered-containers-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-ordered-containers-prof = " \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-hashable-prof \
 ghc-ordered-containers-devel \
 "
RDEPENDS:ghc-pandoc = " \
 ghc-Glob \
 ghc-JuicyPixels \
 ghc-OneTuple \
 ghc-Only \
 ghc-QuickCheck \
 ghc-SHA \
 ghc-StateVar \
 ghc-aeson \
 ghc-aeson-pretty \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-appar \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base16-bytestring \
 ghc-base64-bytestring \
 ghc-basement \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-byteorder \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-cassava \
 ghc-cereal \
 ghc-citeproc \
 ghc-colour \
 ghc-commonmark \
 ghc-commonmark-extensions \
 ghc-commonmark-pandoc \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-crypton \
 ghc-crypton-connection \
 ghc-crypton-x509 \
 ghc-crypton-x509-store \
 ghc-crypton-x509-system \
 ghc-crypton-x509-validation \
 ghc-data-default \
 ghc-data-default-class \
 ghc-data-default-instances-containers \
 ghc-data-default-instances-dlist \
 ghc-data-default-instances-old-locale \
 ghc-data-fix \
 ghc-deepseq \
 ghc-digest \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-doclayout \
 ghc-doctemplates \
 ghc-emojis \
 ghc-exceptions \
 ghc-file-embed \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-gridtables \
 ghc-haddock-library \
 ghc-hashable \
 ghc-haskell-lexer \
 ghc-hourglass \
 ghc-http-client \
 ghc-http-client-tls \
 ghc-http-types \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-iproute \
 ghc-ipynb \
 ghc-jira-wiki-markup \
 ghc-libyaml \
 ghc-memory \
 ghc-mime-types \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-network-uri \
 ghc-old-locale \
 ghc-old-time \
 ghc-ordered-containers \
 ghc-os-string \
 ghc-pandoc-types \
 ghc-parsec \
 ghc-pem \
 ghc-pretty \
 ghc-pretty-show \
 ghc-prettyprinter \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-regex-base \
 ghc-regex-tdfa \
 ghc-resourcet \
 ghc-safe \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-skylighting \
 ghc-skylighting-core \
 ghc-skylighting-format-ansi \
 ghc-skylighting-format-blaze-html \
 ghc-skylighting-format-context \
 ghc-skylighting-format-latex \
 ghc-socks \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-syb \
 ghc-tagged \
 ghc-tagsoup \
 ghc-template-haskell \
 ghc-temporary \
 ghc-texmath \
 ghc-text \
 ghc-text-conversions \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-compat \
 ghc-th-lift \
 ghc-th-lift-instances \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-tls \
 ghc-toml-parser \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-typst \
 ghc-typst-symbols \
 ghc-unicode-collation \
 ghc-unicode-data \
 ghc-unicode-transforms \
 ghc-uniplate \
 ghc-unix \
 ghc-unix-time \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-utf8-string \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-witherable \
 ghc-xml \
 ghc-xml-conduit \
 ghc-xml-types \
 ghc-yaml \
 ghc-zip-archive \
 ghc-zlib \
 glibc \
 gmp \
 libyaml \
 pandoc-common \
 zlib-ng-compat \
 "
RDEPENDS:ghc-pandoc-devel = " \
 ghc-Glob-devel \
 ghc-JuicyPixels-devel \
 ghc-SHA-devel \
 ghc-aeson-devel \
 ghc-aeson-pretty-devel \
 ghc-array-devel \
 ghc-attoparsec-devel \
 ghc-base-devel \
 ghc-base64-bytestring-devel \
 ghc-binary-devel \
 ghc-blaze-html-devel \
 ghc-blaze-markup-devel \
 ghc-bytestring-devel \
 ghc-case-insensitive-devel \
 ghc-citeproc-devel \
 ghc-commonmark-devel \
 ghc-commonmark-extensions-devel \
 ghc-commonmark-pandoc-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-crypton-connection-devel \
 ghc-data-default-devel \
 ghc-deepseq-devel \
 ghc-directory-devel \
 ghc-doclayout-devel \
 ghc-doctemplates-devel \
 ghc-emojis-devel \
 ghc-exceptions-devel \
 ghc-file-embed-devel \
 ghc-filepath-devel \
 ghc-gridtables-devel \
 ghc-haddock-library-devel \
 ghc-http-client-devel \
 ghc-http-client-tls-devel \
 ghc-http-types-devel \
 ghc-ipynb-devel \
 ghc-jira-wiki-markup-devel \
 ghc-mime-types-devel \
 ghc-mtl-devel \
 ghc-network-devel \
 ghc-network-uri-devel \
 ghc-pandoc \
 ghc-pandoc-types-devel \
 ghc-parsec-devel \
 ghc-pretty-devel \
 ghc-pretty-show-devel \
 ghc-process-devel \
 ghc-random-devel \
 ghc-safe-devel \
 ghc-scientific-devel \
 ghc-skylighting-core-devel \
 ghc-skylighting-devel \
 ghc-split-devel \
 ghc-syb-devel \
 ghc-tagsoup-devel \
 ghc-temporary-devel \
 ghc-texmath-devel \
 ghc-text-conversions-devel \
 ghc-text-devel \
 ghc-time-devel \
 ghc-typst-devel \
 ghc-unicode-collation-devel \
 ghc-unicode-transforms-devel \
 ghc-unix-devel \
 ghc-vector-devel \
 ghc-xml-conduit-devel \
 ghc-xml-devel \
 ghc-xml-types-devel \
 ghc-yaml-devel \
 ghc-zip-archive-devel \
 ghc-zlib-devel \
 "
RDEPENDS:ghc-pandoc-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-pandoc-prof = " \
 ghc-Glob-prof \
 ghc-JuicyPixels-prof \
 ghc-SHA-prof \
 ghc-aeson-pretty-prof \
 ghc-aeson-prof \
 ghc-array-prof \
 ghc-attoparsec-prof \
 ghc-base-prof \
 ghc-base64-bytestring-prof \
 ghc-binary-prof \
 ghc-blaze-html-prof \
 ghc-blaze-markup-prof \
 ghc-bytestring-prof \
 ghc-case-insensitive-prof \
 ghc-citeproc-prof \
 ghc-commonmark-extensions-prof \
 ghc-commonmark-pandoc-prof \
 ghc-commonmark-prof \
 ghc-containers-prof \
 ghc-crypton-connection-prof \
 ghc-data-default-prof \
 ghc-deepseq-prof \
 ghc-directory-prof \
 ghc-doclayout-prof \
 ghc-doctemplates-prof \
 ghc-emojis-prof \
 ghc-exceptions-prof \
 ghc-file-embed-prof \
 ghc-filepath-prof \
 ghc-gridtables-prof \
 ghc-haddock-library-prof \
 ghc-http-client-prof \
 ghc-http-client-tls-prof \
 ghc-http-types-prof \
 ghc-ipynb-prof \
 ghc-jira-wiki-markup-prof \
 ghc-mime-types-prof \
 ghc-mtl-prof \
 ghc-network-prof \
 ghc-network-uri-prof \
 ghc-pandoc-devel \
 ghc-pandoc-types-prof \
 ghc-parsec-prof \
 ghc-pretty-prof \
 ghc-pretty-show-prof \
 ghc-process-prof \
 ghc-random-prof \
 ghc-safe-prof \
 ghc-scientific-prof \
 ghc-skylighting-core-prof \
 ghc-skylighting-prof \
 ghc-split-prof \
 ghc-syb-prof \
 ghc-tagsoup-prof \
 ghc-temporary-prof \
 ghc-texmath-prof \
 ghc-text-conversions-prof \
 ghc-text-prof \
 ghc-time-prof \
 ghc-typst-prof \
 ghc-unicode-collation-prof \
 ghc-unicode-transforms-prof \
 ghc-unix-prof \
 ghc-vector-prof \
 ghc-xml-conduit-prof \
 ghc-xml-prof \
 ghc-xml-types-prof \
 ghc-yaml-prof \
 ghc-zip-archive-prof \
 ghc-zlib-prof \
 "
RDEPENDS:ghc-typst = " \
 ghc-OneTuple \
 ghc-Only \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-array \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-bytestring \
 ghc-cassava \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-libyaml \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-ordered-containers \
 ghc-os-string \
 ghc-parsec \
 ghc-pretty \
 ghc-prettyprinter \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-regex-base \
 ghc-regex-tdfa \
 ghc-resourcet \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-toml-parser \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-typst-symbols \
 ghc-unix \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-witherable \
 ghc-xml-conduit \
 ghc-xml-types \
 ghc-yaml \
 ghc-zlib \
 glibc \
 gmp \
 libyaml \
 zlib-ng-compat \
 "
RDEPENDS:ghc-typst-devel = " \
 ghc-aeson-devel \
 ghc-array-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-cassava-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-directory-devel \
 ghc-filepath-devel \
 ghc-mtl-devel \
 ghc-ordered-containers-devel \
 ghc-parsec-devel \
 ghc-pretty-devel \
 ghc-regex-tdfa-devel \
 ghc-scientific-devel \
 ghc-text-devel \
 ghc-time-devel \
 ghc-toml-parser-devel \
 ghc-typst \
 ghc-typst-symbols-devel \
 ghc-vector-devel \
 ghc-xml-conduit-devel \
 ghc-yaml-devel \
 "
RDEPENDS:ghc-typst-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-typst-prof = " \
 ghc-aeson-prof \
 ghc-array-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-cassava-prof \
 ghc-containers-prof \
 ghc-directory-prof \
 ghc-filepath-prof \
 ghc-mtl-prof \
 ghc-ordered-containers-prof \
 ghc-parsec-prof \
 ghc-pretty-prof \
 ghc-regex-tdfa-prof \
 ghc-scientific-prof \
 ghc-text-prof \
 ghc-time-prof \
 ghc-toml-parser-prof \
 ghc-typst-devel \
 ghc-typst-symbols-prof \
 ghc-vector-prof \
 ghc-xml-conduit-prof \
 ghc-yaml-prof \
 "
RDEPENDS:ghc-unicode-collation = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-parsec \
 ghc-pretty \
 ghc-primitive \
 ghc-template-haskell \
 ghc-text \
 ghc-th-abstraction \
 ghc-th-lift \
 ghc-th-lift-instances \
 ghc-transformers \
 ghc-vector \
 ghc-vector-stream \
 glibc \
 gmp \
 "
RDEPENDS:ghc-unicode-collation-devel = " \
 ghc-base-devel \
 ghc-binary-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-parsec-devel \
 ghc-template-haskell-devel \
 ghc-text-devel \
 ghc-th-lift-instances-devel \
 ghc-unicode-collation \
 "
RDEPENDS:ghc-unicode-collation-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-unicode-collation-prof = " \
 ghc-base-prof \
 ghc-binary-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-parsec-prof \
 ghc-template-haskell-prof \
 ghc-text-prof \
 ghc-th-lift-instances-prof \
 ghc-unicode-collation-devel \
 "
RDEPENDS:pandoc-common = " \
 "
