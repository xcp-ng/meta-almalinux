# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-trustfall_core"
PV = "0.8.1"
PR = "2.el10_3"
PACKAGES = " \
 rust-trustfall_core+default-devel \
 rust-trustfall_core-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-trustfall_core-0.8.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "20a53cd4670971a79317635c6d939d47f908c05696934e3d75e4b90d3ceaf41f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trustfall_core+default-devel-0.8.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trustfall_core+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trustfall_core+default-devel.sha256sum] = "868c0bfe95c4ea82096654e39ced3cb2c04b1e28ba6bea42fa0521d787092a88"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trustfall_core-devel-0.8.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trustfall_core-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trustfall_core-devel.sha256sum] = "b05a9cd3e40674ac7e8b0d1cf7b15f6550404a33800ffeb17349597b0de1de32"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trustfall_core+default-devel-0.8.1-2.el10_3.noarch.rpm;name=aarch64_rust-trustfall_core+default-devel;unpack=0"
SRC_URI[aarch64_rust-trustfall_core+default-devel.sha256sum] = "aaba28e9c235ae328e9b162c334e5ad960c4116f0309c7b7be9106fbeec37254"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trustfall_core-devel-0.8.1-2.el10_3.noarch.rpm;name=aarch64_rust-trustfall_core-devel;unpack=0"
SRC_URI[aarch64_rust-trustfall_core-devel.sha256sum] = "22d0d10fe6c61aa4c803097811b4d0aab3720a68f0f692e0346ad991246d7e15"

RDEPENDS:rust-trustfall_core+default-devel = " \
 cargo \
 rust-trustfall_core-devel \
 "
RDEPENDS:rust-trustfall_core-devel = " \
 cargo \
 rust \
 rust-async-graphql-parser+default-devel \
 rust-async-graphql-value+default-devel \
 rust-itertools0.13+default-devel \
 rust-maplit+default-devel \
 rust-regex+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-serde_json+default-devel \
 rust-smallvec+default-devel \
 rust-smallvec+serde-devel \
 rust-thiserror1+default-devel \
 "
