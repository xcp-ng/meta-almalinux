# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "intel-level-zero-gpu-raytracing"
PV = "1.2.3"
PR = "2.el10_2"
PACKAGES:x86_64_v2 = " \
 intel-level-zero-gpu-raytracing \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/i/intel-level-zero-gpu-raytracing-1.2.3-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e52a7bd8067cd6c4c9890a16f2c4c8bb44a7cef4e83be5a5dd6e97d858cd8e45"

URI_x86_64_v2_intel-level-zero-gpu-raytracing = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-level-zero-gpu-raytracing-1.2.3-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-level-zero-gpu-raytracing;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-level-zero-gpu-raytracing}"
SRC_URI[x86_64_v2_intel-level-zero-gpu-raytracing.sha256sum] = "7dd6ea21fc172d4dbc27e29a64638c6edd260dc75fa37b7a690f1692b856db74"

RDEPENDS:intel-level-zero-gpu-raytracing = " \
 glibc \
 libgcc \
 libstdc++ \
 oneapi-level-zero \
 tbb \
 "
