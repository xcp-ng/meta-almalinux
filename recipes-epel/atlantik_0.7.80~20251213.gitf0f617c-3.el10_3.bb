# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "atlantik"
PV = "0.7.80~20251213.gitf0f617c"
PR = "3.el10_3"
PACKAGES = " \
 atlantik \
 atlantik-devel \
 atlantik-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/atlantik-0.7.80~20251213.gitf0f617c-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b5e2a77d8f3966fee2056dd4054dd434c536e521ed5ce1fb3c69cc5c0ed8f141"

URI_x86_64_v2_atlantik = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/atlantik-0.7.80~20251213.gitf0f617c-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_atlantik;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_atlantik}"
SRC_URI[x86_64_v2_atlantik.sha256sum] = "e2caae98c542fc7e3953f44d13f3006c41ea2f4a1ebce4bec2126dc79ba715be"

URI_x86_64_v2_atlantik-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/atlantik-devel-0.7.80~20251213.gitf0f617c-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_atlantik-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_atlantik-devel}"
SRC_URI[x86_64_v2_atlantik-devel.sha256sum] = "6e3dee99ec53929c19ae9d495e8bd1e4e1a8ac3e965f5a13f4f05846409acba5"

URI_x86_64_v2_atlantik-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/atlantik-libs-0.7.80~20251213.gitf0f617c-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_atlantik-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_atlantik-libs}"
SRC_URI[x86_64_v2_atlantik-libs.sha256sum] = "3656bfbf8cd35d97ddc2deeba9d5a2d291cdcc65565202cce8163c41eea0a110"

URI_aarch64_atlantik = "${EPEL_MIRROR}/aarch64/Packages/a/atlantik-0.7.80~20251213.gitf0f617c-3.el10_3.aarch64.rpm;name=aarch64_atlantik;unpack=0"
SRC_URI:append = " ${URI_aarch64_atlantik}"
SRC_URI[aarch64_atlantik.sha256sum] = "e5f891c21026a78e117562d3eb064f36e4474a05e94fd74d46f9f2a23738af49"

URI_aarch64_atlantik-devel = "${EPEL_MIRROR}/aarch64/Packages/a/atlantik-devel-0.7.80~20251213.gitf0f617c-3.el10_3.aarch64.rpm;name=aarch64_atlantik-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_atlantik-devel}"
SRC_URI[aarch64_atlantik-devel.sha256sum] = "a38b733dd712a57dc50bb660531fe40e3314ebbdec41e8bb7a03f92317cac5b4"

URI_aarch64_atlantik-libs = "${EPEL_MIRROR}/aarch64/Packages/a/atlantik-libs-0.7.80~20251213.gitf0f617c-3.el10_3.aarch64.rpm;name=aarch64_atlantik-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_atlantik-libs}"
SRC_URI[aarch64_atlantik-libs.sha256sum] = "8b1612c522156994593401a920de33a5228e167dc86f772e545f041f95ce964f"

RDEPENDS:atlantik = " \
 atlantik-libs \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:atlantik-devel = " \
 atlantik-libs \
 cmake-filesystem \
 "
RDEPENDS:atlantik-libs = " \
 glibc \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
