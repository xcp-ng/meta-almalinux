# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-tweaks"
PV = "46.1"
PR = "1.el10_0"
PACKAGES = " \
 gnome-tweaks \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gnome-tweaks-46.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf67c10d49af4c7b7967600c6dccc9b7913110403979a5be57a7c1ee5e1a2b56"

URI_x86_64_v2_gnome-tweaks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnome-tweaks-46.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gnome-tweaks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-tweaks}"
SRC_URI[x86_64_v2_gnome-tweaks.sha256sum] = "ab28d1b8a246b20193e40617dddf3f450a3d1de59a392eb7af257a9a6f092495"

URI_aarch64_gnome-tweaks = "${EPEL_MIRROR}/aarch64/Packages/g/gnome-tweaks-46.1-1.el10_0.noarch.rpm;name=aarch64_gnome-tweaks;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-tweaks}"
SRC_URI[aarch64_gnome-tweaks.sha256sum] = "ea43eada60c5ba2949c6b49d82397f27b2a80794c297cf1f4fd2a8bf95b89d23"

RDEPENDS:gnome-tweaks = " \
 gnome-desktop4 \
 gobject-introspection \
 gsettings-desktop-schemas \
 gtk4 \
 libadwaita \
 libgudev \
 libnotify \
 pango \
 python3 \
 python3-gobject-base \
 "
