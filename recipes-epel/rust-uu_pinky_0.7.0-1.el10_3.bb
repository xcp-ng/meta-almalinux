# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_pinky"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_pinky+default-devel \
 rust-uu_pinky+feat_systemd_logind-devel \
 rust-uu_pinky-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_pinky-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a53b208e000ed8ff9146a0b69cc393e6724d6b8c2b4700d9872a6976c8d42bc1"

URI_x86_64_v2_rust-uu_pinky+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_pinky+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_pinky+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_pinky+default-devel}"
SRC_URI[x86_64_v2_rust-uu_pinky+default-devel.sha256sum] = "61d6b8aa0f24918d1ef6105f35419bb555dc76c829914a72762fa95d897dc5ba"

URI_x86_64_v2_rust-uu_pinky+feat_systemd_logind-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_pinky+feat_systemd_logind-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_pinky+feat_systemd_logind-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_pinky+feat_systemd_logind-devel}"
SRC_URI[x86_64_v2_rust-uu_pinky+feat_systemd_logind-devel.sha256sum] = "b2de5145270403bda2a3f13e8b8028b3b8157a7bcbd1a8d27347658d97d8851b"

URI_x86_64_v2_rust-uu_pinky-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_pinky-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_pinky-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_pinky-devel}"
SRC_URI[x86_64_v2_rust-uu_pinky-devel.sha256sum] = "b8d4d63fa6c4329a3f5f757f2b08d2e6bcd269af8d261bc7abbb8092cf96f718"

URI_aarch64_rust-uu_pinky+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_pinky+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_pinky+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_pinky+default-devel}"
SRC_URI[aarch64_rust-uu_pinky+default-devel.sha256sum] = "850eaf9db4bb936d77b616e2c1fc3ec5ccc373e3fc854f46f440ba8a83641f6d"

URI_aarch64_rust-uu_pinky+feat_systemd_logind-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_pinky+feat_systemd_logind-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_pinky+feat_systemd_logind-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_pinky+feat_systemd_logind-devel}"
SRC_URI[aarch64_rust-uu_pinky+feat_systemd_logind-devel.sha256sum] = "fdb2f8d3e2fdb117a2917b583b80c72478571fd91379ed6040e923cba268ae93"

URI_aarch64_rust-uu_pinky-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_pinky-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_pinky-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_pinky-devel}"
SRC_URI[aarch64_rust-uu_pinky-devel.sha256sum] = "3f7525e5a033f8d308cd9e3e40eabc15bb8080c694b71cc6ffadab99673a8e01"

RDEPENDS:rust-uu_pinky+default-devel = " \
 cargo \
 rust-uu_pinky-devel \
 "
RDEPENDS:rust-uu_pinky+feat_systemd_logind-devel = " \
 cargo \
 rust-uu_pinky-devel \
 rust-uucore+feat_systemd_logind-devel \
 "
RDEPENDS:rust-uu_pinky-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uucore+default-devel \
 rust-uucore+entries-devel \
 rust-uucore+utmpx-devel \
 "
