# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_sha384sum"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_sha384sum+default-devel \
 rust-uu_sha384sum-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_sha384sum-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0537f63371792f39e43c8609f5218d556bc913a14ccff5b099df51cc80b99e0d"

URI_x86_64_v2_rust-uu_sha384sum+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_sha384sum+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_sha384sum+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_sha384sum+default-devel}"
SRC_URI[x86_64_v2_rust-uu_sha384sum+default-devel.sha256sum] = "c70f21e3ba36b7420785c304c9386b206ba102562e965382607a5d6365ae5d07"

URI_x86_64_v2_rust-uu_sha384sum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_sha384sum-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_sha384sum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_sha384sum-devel}"
SRC_URI[x86_64_v2_rust-uu_sha384sum-devel.sha256sum] = "7f46c216db2840f5f12076827a5c6daeb923037ea4b5e79890262792bf3dbd5c"

URI_aarch64_rust-uu_sha384sum+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_sha384sum+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_sha384sum+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_sha384sum+default-devel}"
SRC_URI[aarch64_rust-uu_sha384sum+default-devel.sha256sum] = "53ce9d715efb1f171a0abe94adceece5ff7be79b4c7f09ac9c5517b3a439a98f"

URI_aarch64_rust-uu_sha384sum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_sha384sum-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_sha384sum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_sha384sum-devel}"
SRC_URI[aarch64_rust-uu_sha384sum-devel.sha256sum] = "a3b7767199ea13d8a1051a09523b32d864ad4c14385fc933fdb63b49ae1c5aaa"

RDEPENDS:rust-uu_sha384sum+default-devel = " \
 cargo \
 rust-uu_sha384sum-devel \
 "
RDEPENDS:rust-uu_sha384sum-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uu_checksum_common+default-devel \
 rust-uucore+checksum-devel \
 rust-uucore+default-devel \
 rust-uucore+encoding-devel \
 rust-uucore+hardware-devel \
 rust-uucore+sum-devel \
 "
