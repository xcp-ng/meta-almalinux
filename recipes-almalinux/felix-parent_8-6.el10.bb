# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "felix-parent"
PV = "8"
PR = "6.el10"
PACKAGES = " \
 felix-parent \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/felix-parent-8-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de6802b72e1b65db184d624b9eed4aee38f6a0d35c4f6496ec87f72035523d71"

URI_x86_64_v2_felix-parent = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/felix-parent-8-6.el10.noarch.rpm;name=x86_64_v2_felix-parent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_felix-parent}"
SRC_URI[x86_64_v2_felix-parent.sha256sum] = "4189b42f62de438eacac42aa74b0a09d63f08834f79e692be2a60ecf14213c6c"

URI_aarch64_felix-parent = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/felix-parent-8-6.el10.noarch.rpm;name=aarch64_felix-parent;unpack=0"
SRC_URI:append = " ${URI_aarch64_felix-parent}"
SRC_URI[aarch64_felix-parent.sha256sum] = "4189b42f62de438eacac42aa74b0a09d63f08834f79e692be2a60ecf14213c6c"

RDEPENDS:felix-parent = " \
 apache-parent \
 javapackages-filesystem \
 "
