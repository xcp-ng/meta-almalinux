# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "snapper"
PV = "0.13.0"
PR = "3.el10_2"
PACKAGES = " \
 pam_snapper \
 snapper \
 snapper-backup \
 snapper-devel \
 snapper-libs \
 snapper-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/snapper-0.13.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e04357acf6374b147df82f798c9df01083e4496d683b0532cdd3309dc533626f"

URI_x86_64_v2_pam_snapper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pam_snapper-0.13.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pam_snapper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam_snapper}"
SRC_URI[x86_64_v2_pam_snapper.sha256sum] = "1a72bdfee35e38752f1f8388d73bfbb93585b3bc0918caa206affd042fd2179d"

URI_x86_64_v2_snapper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapper-0.13.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapper}"
SRC_URI[x86_64_v2_snapper.sha256sum] = "035aec9703e08196c292045b3ee75cbf8e3b9989f86b2f9df6c7e20f10defdd8"

URI_x86_64_v2_snapper-backup = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapper-backup-0.13.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapper-backup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapper-backup}"
SRC_URI[x86_64_v2_snapper-backup.sha256sum] = "cdb621b7d127f17e8d10b53949ff02ac7568d68cb6f4f941c982d1a9a898d04c"

URI_x86_64_v2_snapper-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapper-devel-0.13.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapper-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapper-devel}"
SRC_URI[x86_64_v2_snapper-devel.sha256sum] = "a322ab0795bdc9d4f40d33b0b44712cdc7cd3b5cb855584a90b0687550dc3455"

URI_x86_64_v2_snapper-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapper-libs-0.13.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapper-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapper-libs}"
SRC_URI[x86_64_v2_snapper-libs.sha256sum] = "6d5b3e676c0b191beb7937125c4760a6f700937ec16e0d5db64925f67c2c619d"

URI_x86_64_v2_snapper-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapper-tests-0.13.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapper-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapper-tests}"
SRC_URI[x86_64_v2_snapper-tests.sha256sum] = "c0d115c92084d9ab2e03cedffe1ec667a43ffa4471fc562a6962949869a467d3"

URI_aarch64_pam_snapper = "${EPEL_MIRROR}/aarch64/Packages/p/pam_snapper-0.13.0-3.el10_2.aarch64.rpm;name=aarch64_pam_snapper;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam_snapper}"
SRC_URI[aarch64_pam_snapper.sha256sum] = "4629e882bab05f0446b4880bcae125f0b5aa3f7d6bdc1d8912535433c4e77326"

URI_aarch64_snapper = "${EPEL_MIRROR}/aarch64/Packages/s/snapper-0.13.0-3.el10_2.aarch64.rpm;name=aarch64_snapper;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapper}"
SRC_URI[aarch64_snapper.sha256sum] = "7ed28345a0adbe1b2d2e3e3a934433fdbcb42f468e4f4ab09a9db77ce83b18b1"

URI_aarch64_snapper-backup = "${EPEL_MIRROR}/aarch64/Packages/s/snapper-backup-0.13.0-3.el10_2.aarch64.rpm;name=aarch64_snapper-backup;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapper-backup}"
SRC_URI[aarch64_snapper-backup.sha256sum] = "6e363ea0d70add2f1900d6cb6821ced4818f181517f735370f3ec43e9960fc10"

URI_aarch64_snapper-devel = "${EPEL_MIRROR}/aarch64/Packages/s/snapper-devel-0.13.0-3.el10_2.aarch64.rpm;name=aarch64_snapper-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapper-devel}"
SRC_URI[aarch64_snapper-devel.sha256sum] = "71a9c19bd95e032c4e76862541da23b3d63a2769c75603e0db97eecba097bbfb"

URI_aarch64_snapper-libs = "${EPEL_MIRROR}/aarch64/Packages/s/snapper-libs-0.13.0-3.el10_2.aarch64.rpm;name=aarch64_snapper-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapper-libs}"
SRC_URI[aarch64_snapper-libs.sha256sum] = "0a7f23ae970e8f70f07fb8534466f6813dfd61902916c68ea6ad2850609935a1"

URI_aarch64_snapper-tests = "${EPEL_MIRROR}/aarch64/Packages/s/snapper-tests-0.13.0-3.el10_2.aarch64.rpm;name=aarch64_snapper-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapper-tests}"
SRC_URI[aarch64_snapper-tests.sha256sum] = "2bc2b4f7ec95f076dabccbcc7a5cd9e2c392b4df18bf3a72acf76c5234c0fc94"

RDEPENDS:pam_snapper = " \
 bash \
 dbus-libs \
 glibc \
 libbtrfs \
 libselinux \
 pam-libs \
 snapper \
 "
RDEPENDS:snapper = " \
 bash \
 boost-thread \
 dbus-libs \
 diffutils \
 glibc \
 json-c \
 libgcc \
 libmount \
 libstdc++ \
 libxml2 \
 ncurses-libs \
 snapper-libs \
 "
RDEPENDS:snapper-backup = " \
 dbus-libs \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 ncurses-libs \
 snapper \
 snapper-libs \
 "
RDEPENDS:snapper-devel = " \
 boost-devel \
 btrfs-progs-devel \
 libacl-devel \
 libmount-devel \
 libstdc++-devel \
 libxml2-devel \
 snapper-libs \
 "
RDEPENDS:snapper-libs = " \
 bash \
 boost-system \
 boost-thread \
 btrfs-progs \
 glibc \
 libacl \
 libbtrfs \
 libbtrfsutil \
 libgcc \
 libmount \
 libselinux \
 libstdc++ \
 libxml2 \
 util-linux \
 zlib-ng-compat \
 "
RDEPENDS:snapper-tests = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 snapper-libs \
 "
