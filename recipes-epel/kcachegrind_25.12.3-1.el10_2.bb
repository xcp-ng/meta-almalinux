# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kcachegrind"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kcachegrind \
 kcachegrind-converters \
 qcachegrind \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kcachegrind-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9fecb9e99bd239dff4e9b7e8abc4811e8b0dddd1d70f7d0d15250e92ca5e839f"

URI_x86_64_v2_kcachegrind = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcachegrind-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcachegrind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcachegrind}"
SRC_URI[x86_64_v2_kcachegrind.sha256sum] = "b023af3557bca5d296722d5bd4e0992bcdc7348649e525a255b9d8182c654c9b"

URI_x86_64_v2_kcachegrind-converters = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcachegrind-converters-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcachegrind-converters;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcachegrind-converters}"
SRC_URI[x86_64_v2_kcachegrind-converters.sha256sum] = "3c8218394b9104cc6b0d09f22215166e0fa5511a02a22756773ffeb0652f84ee"

URI_x86_64_v2_qcachegrind = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qcachegrind-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qcachegrind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qcachegrind}"
SRC_URI[x86_64_v2_qcachegrind.sha256sum] = "87a9e855157f4dca9cb330da7efc9c7981bb1eb303696320085ba4a9d99cee3b"

URI_aarch64_kcachegrind = "${EPEL_MIRROR}/aarch64/Packages/k/kcachegrind-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kcachegrind;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcachegrind}"
SRC_URI[aarch64_kcachegrind.sha256sum] = "0bfcf462985319d842558fb180937fd8dcc12237e9d629f6c7f2bdf59b886dc0"

URI_aarch64_kcachegrind-converters = "${EPEL_MIRROR}/aarch64/Packages/k/kcachegrind-converters-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kcachegrind-converters;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcachegrind-converters}"
SRC_URI[aarch64_kcachegrind-converters.sha256sum] = "71e7bd91545b88784958dedfe7083a0b8012bfed0b136daf6b28050d93828d68"

URI_aarch64_qcachegrind = "${EPEL_MIRROR}/aarch64/Packages/q/qcachegrind-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_qcachegrind;unpack=0"
SRC_URI:append = " ${URI_aarch64_qcachegrind}"
SRC_URI[aarch64_qcachegrind.sha256sum] = "80c554efb75409b91d49a7dc88206dbcaa3135025e3f4bded2a8967289b7cbbb"

RDEPENDS:kcachegrind = " \
 glibc \
 kf6-karchive \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kcachegrind-converters = " \
 kcachegrind \
 perl-Getopt-Std \
 perl-IO \
 perl-interpreter \
 perl-libs \
 python3 \
 virtual//usr/bin/php \
 "
RDEPENDS:qcachegrind = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
