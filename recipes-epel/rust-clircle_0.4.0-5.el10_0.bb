# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clircle"
PV = "0.4.0"
PR = "5.el10_0"
PACKAGES = " \
 rust-clircle+default-devel \
 rust-clircle+serde-devel \
 rust-clircle-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clircle-0.4.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9cf02da394132549eb6b765dd990187be6e536e900a32dc79699036fc619c400"

URI_x86_64_v2_rust-clircle+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clircle+default-devel-0.4.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clircle+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clircle+default-devel}"
SRC_URI[x86_64_v2_rust-clircle+default-devel.sha256sum] = "7287d96dbb4711764caee8fba6119d16bebf0caf2c734b9ce702209d59e60eee"

URI_x86_64_v2_rust-clircle+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clircle+serde-devel-0.4.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clircle+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clircle+serde-devel}"
SRC_URI[x86_64_v2_rust-clircle+serde-devel.sha256sum] = "7bcdb4f999d63ab792811ce1394da95bf37bfd221cddd8834941447d46279990"

URI_x86_64_v2_rust-clircle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clircle-devel-0.4.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clircle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clircle-devel}"
SRC_URI[x86_64_v2_rust-clircle-devel.sha256sum] = "34cbc61718e61e26c60c055a3867fcec737919b54123cf07876c1a65477c90a8"

URI_aarch64_rust-clircle+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clircle+default-devel-0.4.0-5.el10_0.noarch.rpm;name=aarch64_rust-clircle+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clircle+default-devel}"
SRC_URI[aarch64_rust-clircle+default-devel.sha256sum] = "2a953eee3aa5dd8fd3afdbe7dd0d5b33006b7135fdf870f93c63df81fce62281"

URI_aarch64_rust-clircle+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clircle+serde-devel-0.4.0-5.el10_0.noarch.rpm;name=aarch64_rust-clircle+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clircle+serde-devel}"
SRC_URI[aarch64_rust-clircle+serde-devel.sha256sum] = "bc615096401e170940e43ad235b4e3af0ccd054cba11d0c7a74f9f2f7208fab5"

URI_aarch64_rust-clircle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clircle-devel-0.4.0-5.el10_0.noarch.rpm;name=aarch64_rust-clircle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clircle-devel}"
SRC_URI[aarch64_rust-clircle-devel.sha256sum] = "2036deb29ac9e39b770d8a7ac33cae3067f80dd3443310542ac967a7c2439760"

RDEPENDS:rust-clircle+default-devel = " \
 cargo \
 rust-clircle+serde-devel \
 rust-clircle-devel \
 "
RDEPENDS:rust-clircle+serde-devel = " \
 cargo \
 rust-clircle-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-clircle-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 "
