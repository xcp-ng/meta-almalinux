# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kgeography"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kgeography \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kgeography-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "14a90fb32bc0a9ad2e305c69ad83eaf5ab3c3bed57627044f9d2894a27f252bd"

URI_x86_64_v2_kgeography = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kgeography-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kgeography;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kgeography}"
SRC_URI[x86_64_v2_kgeography.sha256sum] = "1bc329efbb18bf44bf501b76baf170df9a461a0d8ac3fc09dd923ddd96414dd5"

URI_aarch64_kgeography = "${EPEL_MIRROR}/aarch64/Packages/k/kgeography-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kgeography;unpack=0"
SRC_URI:append = " ${URI_aarch64_kgeography}"
SRC_URI[aarch64_kgeography.sha256sum] = "37a372e48ba2d68e9f1c691555dc841675ddc322f64be7c2d01b1651847f9865"

RDEPENDS:kgeography = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kitemviews \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
