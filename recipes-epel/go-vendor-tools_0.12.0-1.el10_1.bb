# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "go-vendor-tools"
PV = "0.12.0"
PR = "1.el10_1"
PACKAGES = " \
 go-vendor-tools \
 go-vendor-tools+all \
 go-vendor-tools-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/go-vendor-tools-0.12.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dcef3637d1002fb9c6b32f0cd2c1b3a1289814e7680cbdc888838c275f0d802b"

URI_x86_64_v2_go-vendor-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/go-vendor-tools-0.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_go-vendor-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-vendor-tools}"
SRC_URI[x86_64_v2_go-vendor-tools.sha256sum] = "222985c220208ce9b6b8428ea4180ccfc74bf93e7db86c6a0a76cfab06317514"

URI_x86_64_v2_go-vendor-tools+all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/go-vendor-tools+all-0.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_go-vendor-tools+all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-vendor-tools+all}"
SRC_URI[x86_64_v2_go-vendor-tools+all.sha256sum] = "61f04ba1b09a80c4ead2c34b15a4de5f555726d3e171399e44c5aae212868d0e"

URI_x86_64_v2_go-vendor-tools-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/go-vendor-tools-doc-0.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_go-vendor-tools-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-vendor-tools-doc}"
SRC_URI[x86_64_v2_go-vendor-tools-doc.sha256sum] = "e21d3806e589bda6b78e4103042a3ac86d14e1812a561ff4e4c3ed6fdf8e6c36"

URI_aarch64_go-vendor-tools = "${EPEL_MIRROR}/aarch64/Packages/g/go-vendor-tools-0.12.0-1.el10_1.noarch.rpm;name=aarch64_go-vendor-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-vendor-tools}"
SRC_URI[aarch64_go-vendor-tools.sha256sum] = "b83c1c70837f7d3cfaca3ce496eb3ab8463e1d5f971d27b1636ef7c262ace0ab"

URI_aarch64_go-vendor-tools+all = "${EPEL_MIRROR}/aarch64/Packages/g/go-vendor-tools+all-0.12.0-1.el10_1.noarch.rpm;name=aarch64_go-vendor-tools+all;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-vendor-tools+all}"
SRC_URI[aarch64_go-vendor-tools+all.sha256sum] = "5da6867a1731f2ed1863dcc49a9f51ce7106dd6c261457ddce40e236edaba5a5"

URI_aarch64_go-vendor-tools-doc = "${EPEL_MIRROR}/aarch64/Packages/g/go-vendor-tools-doc-0.12.0-1.el10_1.noarch.rpm;name=aarch64_go-vendor-tools-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-vendor-tools-doc}"
SRC_URI[aarch64_go-vendor-tools-doc.sha256sum] = "9cd4153c899dae9755ee795090986e1e2eee86079bbd61d25a380ba2962a6732"

RDEPENDS:go-vendor-tools = " \
 python3 \
 python3-license-expression \
 "
RDEPENDS:go-vendor-tools+all = " \
 go-vendor-tools \
 python3 \
 python3-argcomplete \
 python3-specfile \
 python3-tomlkit \
 python3-zstarfile \
 "
RDEPENDS:go-vendor-tools-doc = " \
 "
