# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-kdf"
PV = "0.1.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-kdf+default-devel \
 rust-kdf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-kdf-0.1.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80f1898c71cd9fa4c8b56c7fb2654cec3176df39d716162796b7106fadabee8a"

URI_x86_64_v2_rust-kdf+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-kdf+default-devel-0.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-kdf+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-kdf+default-devel}"
SRC_URI[x86_64_v2_rust-kdf+default-devel.sha256sum] = "844dbd09aefb125d1fb17595299fa110ad100cd48ca4b78dbbbcc8a51efe248c"

URI_x86_64_v2_rust-kdf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-kdf-devel-0.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-kdf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-kdf-devel}"
SRC_URI[x86_64_v2_rust-kdf-devel.sha256sum] = "7c0b9e906e9103e7adea34660a736fc8c611f4026904cbca40b01a357dedc961"

URI_aarch64_rust-kdf+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-kdf+default-devel-0.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-kdf+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-kdf+default-devel}"
SRC_URI[aarch64_rust-kdf+default-devel.sha256sum] = "a91a06e48359fbdce6021790d86a64db24009d7a3ee077e549b190f1e5b14e8f"

URI_aarch64_rust-kdf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-kdf-devel-0.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-kdf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-kdf-devel}"
SRC_URI[aarch64_rust-kdf-devel.sha256sum] = "c499e59e6f841aaf0fea0283146e56654bc2b98e341d5aeb39961c605eca5793"

RDEPENDS:rust-kdf+default-devel = " \
 cargo \
 rust-kdf-devel \
 "
RDEPENDS:rust-kdf-devel = " \
 cargo \
 rust \
 "
