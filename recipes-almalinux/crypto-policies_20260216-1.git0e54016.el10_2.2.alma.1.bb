# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "crypto-policies"
PV = "20260216"
PR = "1.git0e54016.el10_2.2.alma.1"
PACKAGES = " \
 crypto-policies \
 crypto-policies-scripts \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/crypto-policies-20260216-1.git0e54016.el10_2.2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2315eb5d24d6e7dd356105e51d37e892bbcbb6e68fb780f89a76fa8b2818df15"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/crypto-policies-20260216-1.git0e54016.el10_2.2.alma.1.noarch.rpm;name=x86_64_v2_crypto-policies;unpack=0"
SRC_URI[x86_64_v2_crypto-policies.sha256sum] = "a261c568310cf92be13d55bf43a8de4ba6723c776251efd78f35e58935d5b3dc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/crypto-policies-scripts-20260216-1.git0e54016.el10_2.2.alma.1.noarch.rpm;name=x86_64_v2_crypto-policies-scripts;unpack=0"
SRC_URI[x86_64_v2_crypto-policies-scripts.sha256sum] = "006c9b1c500e5d773a332a36457fc36812198a8614b1b714a69710c7556ef4f7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/crypto-policies-20260216-1.git0e54016.el10_2.2.alma.1.noarch.rpm;name=aarch64_crypto-policies;unpack=0"
SRC_URI[aarch64_crypto-policies.sha256sum] = "a261c568310cf92be13d55bf43a8de4ba6723c776251efd78f35e58935d5b3dc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/crypto-policies-scripts-20260216-1.git0e54016.el10_2.2.alma.1.noarch.rpm;name=aarch64_crypto-policies-scripts;unpack=0"
SRC_URI[aarch64_crypto-policies-scripts.sha256sum] = "006c9b1c500e5d773a332a36457fc36812198a8614b1b714a69710c7556ef4f7"

RDEPENDS:crypto-policies = " \
 bash \
 "
RDEPENDS:crypto-policies-scripts = " \
 bash \
 crypto-policies \
 python3 \
 "
