# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-build-config"
PV = "0.29.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-pyo3-build-config+default-devel \
 rust-pyo3-build-config+extension-module-devel \
 rust-pyo3-build-config+resolve-config-devel \
 rust-pyo3-build-config-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-build-config-0.29.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5c26d5babb134b79e085cb68eae33035d1f7197940415b407bc0cacb2a00d655"

URI_x86_64_v2_rust-pyo3-build-config+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+default-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+default-devel.sha256sum] = "9f500416bc20f9bef34a6f79021f2a63386e42dd30435c700628ed56df50c3d2"

URI_x86_64_v2_rust-pyo3-build-config+extension-module-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+extension-module-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+extension-module-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+extension-module-devel.sha256sum] = "d786281c4f66ac890a5190aa6f0791c856485ce118a9ae76859aab63948a890f"

URI_x86_64_v2_rust-pyo3-build-config+resolve-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+resolve-config-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+resolve-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+resolve-config-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+resolve-config-devel.sha256sum] = "4943c0f3d3de5356333238e1568d5b341a173bd99255f63b291580824d0e81c4"

URI_x86_64_v2_rust-pyo3-build-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config-devel.sha256sum] = "5cd0c39d7f7cdd7c1a4cdc7e60432f6e43dfbf951aa44addc79c995973b0f89e"

URI_aarch64_rust-pyo3-build-config+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+default-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-build-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+default-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+default-devel.sha256sum] = "8c3b51053eff246353952ccf2210aaec3fd0ee45a4af58bf2e4cc7eb313fe02b"

URI_aarch64_rust-pyo3-build-config+extension-module-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+extension-module-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-build-config+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+extension-module-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+extension-module-devel.sha256sum] = "39c2f1f4a378edc861c89cf897a0413a7ba69405f46e253c505a8283bae7d69e"

URI_aarch64_rust-pyo3-build-config+resolve-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+resolve-config-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-build-config+resolve-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+resolve-config-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+resolve-config-devel.sha256sum] = "f1e0b4a5fe65290f7743296423b923e16ea204df09db7bdc12791607914018c7"

URI_aarch64_rust-pyo3-build-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-build-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config-devel}"
SRC_URI[aarch64_rust-pyo3-build-config-devel.sha256sum] = "9243a351cddce8a88541fda69a8ef8ad4b8d27726799c036f16519ff58eefbf3"

RDEPENDS:rust-pyo3-build-config+default-devel = " \
 cargo \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+extension-module-devel = " \
 cargo \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+resolve-config-devel = " \
 cargo \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config-devel = " \
 cargo \
 python3 \
 rust \
 rust-target-lexicon+default-devel \
 "
