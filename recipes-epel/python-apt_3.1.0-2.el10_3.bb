# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-apt"
PV = "3.1.0"
PR = "2.el10_3"
PACKAGES = " \
 python3-apt \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-apt-3.1.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "11935ebe9b02c3dc9e7167723aa18adec8f1b56504d5aee76c02f368bee4513d"

URI_x86_64_v2_python3-apt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-apt-3.1.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-apt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-apt}"
SRC_URI[x86_64_v2_python3-apt.sha256sum] = "2029e3547779499485ea65f05989edb2f7a3633e14fc6dad81f70363d4a35ca7"

URI_aarch64_python3-apt = "${EPEL_MIRROR}/aarch64/Packages/p/python3-apt-3.1.0-2.el10_3.aarch64.rpm;name=aarch64_python3-apt;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-apt}"
SRC_URI[aarch64_python3-apt.sha256sum] = "32bc776ca1e660fce95617d84b3949606cbc10ad83911395b7c526eccb971e4c"

RDEPENDS:python3-apt = " \
 apt-libs \
 dpkg \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
