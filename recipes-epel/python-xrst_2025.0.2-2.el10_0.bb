# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-xrst"
PV = "2025.0.2"
PR = "2.el10_0"
PACKAGES = " \
 python3-xrst \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-xrst-2025.0.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09a44d9313eb336d4ef47e0f0f407d6e2485972ffb50e0a8c53ea4a1b8343746"

URI_x86_64_v2_python3-xrst = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-xrst-2025.0.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-xrst;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-xrst}"
SRC_URI[x86_64_v2_python3-xrst.sha256sum] = "30c1ffdc28fc94870c03553f7c276e39f34b8218e4e91d91140242842f07f6bc"

URI_aarch64_python3-xrst = "${EPEL_MIRROR}/aarch64/Packages/p/python3-xrst-2025.0.2-2.el10_0.noarch.rpm;name=aarch64_python3-xrst;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-xrst}"
SRC_URI[aarch64_python3-xrst.sha256sum] = "384d5f892236377a26e16eac8c65b023c8766f62bb71f9e2857c06c28f9dd98a"

RDEPENDS:python3-xrst = " \
 python3 \
 python3-furo \
 python3-pyspellchecker \
 python3-sphinx \
 python3-sphinx-copybutton \
 python3-tomli \
 "
