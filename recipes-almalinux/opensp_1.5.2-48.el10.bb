# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opensp"
PV = "1.5.2"
PR = "48.el10"
PACKAGES = " \
 opensp \
 opensp-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/opensp-1.5.2-48.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "475489658432611249a3ff1a690078414262aac677ed988d05ea3bc1a5488b77"

URI_x86_64_v2_opensp = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/opensp-1.5.2-48.el10.x86_64_v2.rpm;name=x86_64_v2_opensp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opensp}"
SRC_URI[x86_64_v2_opensp.sha256sum] = "e7c3cf200058883dcb2ae23e5a51f1392b0e92cd7c56a16fbbcda54f28ce0766"

URI_x86_64_v2_opensp-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/opensp-devel-1.5.2-48.el10.x86_64_v2.rpm;name=x86_64_v2_opensp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opensp-devel}"
SRC_URI[x86_64_v2_opensp-devel.sha256sum] = "17d6eb373d3ce6b88627090a0c6121ce0df84ea821867a9c69d6b30ed787068d"

URI_aarch64_opensp = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/opensp-1.5.2-48.el10.aarch64.rpm;name=aarch64_opensp;unpack=0"
SRC_URI:append = " ${URI_aarch64_opensp}"
SRC_URI[aarch64_opensp.sha256sum] = "f36e4e7201888baec71bb64e8c3d27f4dae731873b2c22d02e6ef906a5116a9f"

URI_aarch64_opensp-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/opensp-devel-1.5.2-48.el10.aarch64.rpm;name=aarch64_opensp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_opensp-devel}"
SRC_URI[aarch64_opensp-devel.sha256sum] = "ca06959d0e558e595f322e5345d6f2eb49c3afa4228c0baf63e850b833adbfdf"

RDEPENDS:opensp = " \
 glibc \
 libgcc \
 libstdc++ \
 sgml-common \
 "
RDEPENDS:opensp-devel = " \
 opensp \
 "
