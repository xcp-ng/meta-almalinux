# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bpaf_derive"
PV = "0.5.17"
PR = "1.el10_1"
PACKAGES = " \
 rust-bpaf_derive+default-devel \
 rust-bpaf_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bpaf_derive-0.5.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "471ea55487f21232b947b296b763f7421eb36230fd45256765c03bf787cc7b09"

URI_x86_64_v2_rust-bpaf_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf_derive+default-devel-0.5.17-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf_derive+default-devel}"
SRC_URI[x86_64_v2_rust-bpaf_derive+default-devel.sha256sum] = "797c27703bd8af3bc2ec888d1f80c370d5b2b2eb7f68f2dd5a2212021b9fa6d3"

URI_x86_64_v2_rust-bpaf_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf_derive-devel-0.5.17-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf_derive-devel}"
SRC_URI[x86_64_v2_rust-bpaf_derive-devel.sha256sum] = "28e1ede9a62835827299b4d9e0b7a02e524098a6e241b719f4bb0647b73c95d7"

URI_aarch64_rust-bpaf_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf_derive+default-devel-0.5.17-1.el10_1.noarch.rpm;name=aarch64_rust-bpaf_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf_derive+default-devel}"
SRC_URI[aarch64_rust-bpaf_derive+default-devel.sha256sum] = "636a523f2e9cebf06631004a45eebb02b545863cd3817fed95546f2e9979b90b"

URI_aarch64_rust-bpaf_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf_derive-devel-0.5.17-1.el10_1.noarch.rpm;name=aarch64_rust-bpaf_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf_derive-devel}"
SRC_URI[aarch64_rust-bpaf_derive-devel.sha256sum] = "14c85a39e6aeaedab37532ffe3b179cc3fe8cfc0d2d6a4f41d5ce000c1ea53ac"

RDEPENDS:rust-bpaf_derive+default-devel = " \
 cargo \
 rust-bpaf_derive-devel \
 "
RDEPENDS:rust-bpaf_derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-syn+visit-mut-devel \
 "
