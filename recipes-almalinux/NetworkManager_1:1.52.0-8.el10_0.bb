# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "NetworkManager"
PE = "1"
PV = "1.52.0"
PR = "8.el10_0"
PACKAGES = " \
 NetworkManager \
 NetworkManager-adsl \
 NetworkManager-bluetooth \
 NetworkManager-cloud-setup \
 NetworkManager-config-connectivity-redhat \
 NetworkManager-config-server \
 NetworkManager-libnm \
 NetworkManager-libnm-devel \
 NetworkManager-ovs \
 NetworkManager-ppp \
 NetworkManager-tui \
 NetworkManager-wifi \
 NetworkManager-wwan \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/NetworkManager-1.52.0-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0e0341da77bea330aabf98c1627a38fd016096f81dcaeb491e4c45ccf8cc27e"

URI_x86_64_v2_NetworkManager = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-1.52.0-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_NetworkManager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager}"
SRC_URI[x86_64_v2_NetworkManager.sha256sum] = "e0c752db93cf0dc6a6ec0f98d3d468e67d8752f87edfc0187084b6483c3f7f4d"

URI_x86_64_v2_NetworkManager-adsl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-adsl-1.52.0-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-adsl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-adsl}"
SRC_URI[x86_64_v2_NetworkManager-adsl.sha256sum] = "2ebf39b2c2650696e57ae026f3409038288c1fd662cad6aad194c3d4942a2b5a"

URI_x86_64_v2_NetworkManager-bluetooth = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-bluetooth-1.52.0-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-bluetooth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-bluetooth}"
SRC_URI[x86_64_v2_NetworkManager-bluetooth.sha256sum] = "6c9835f0b555c3edd5fcf383f5de3461e9cc1fa20a35b9ac5899332bbcb1fffb"

URI_x86_64_v2_NetworkManager-cloud-setup = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/NetworkManager-cloud-setup-1.52.0-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-cloud-setup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-cloud-setup}"
SRC_URI[x86_64_v2_NetworkManager-cloud-setup.sha256sum] = "fa4666bf8ea9664ef081a6fdef5febd57bda38385b5e530b6d2175278f674870"

URI_x86_64_v2_NetworkManager-config-connectivity-redhat = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/NetworkManager-config-connectivity-redhat-1.52.0-8.el10_0.noarch.rpm;name=x86_64_v2_NetworkManager-config-connectivity-redhat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-config-connectivity-redhat}"
SRC_URI[x86_64_v2_NetworkManager-config-connectivity-redhat.sha256sum] = "425fe524670ccccbb3faef9043cdd9a37c24c28fae6217055d4900f29168deb8"

URI_x86_64_v2_NetworkManager-config-server = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-config-server-1.52.0-8.el10_0.noarch.rpm;name=x86_64_v2_NetworkManager-config-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-config-server}"
SRC_URI[x86_64_v2_NetworkManager-config-server.sha256sum] = "d8860d3a7f9b0fd79257e259bc586619a9798b9fe5da3ff124af250824230bfb"

URI_x86_64_v2_NetworkManager-libnm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-libnm-1.52.0-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-libnm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-libnm}"
SRC_URI[x86_64_v2_NetworkManager-libnm.sha256sum] = "5b32e8402c8e79b1095d22f028d1b6c6f671e2174efed516897ed27796686e15"

URI_x86_64_v2_NetworkManager-libnm-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/NetworkManager-libnm-devel-1.52.0-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-libnm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-libnm-devel}"
SRC_URI[x86_64_v2_NetworkManager-libnm-devel.sha256sum] = "3af71791895158c378b4d36f2374ec2fd4a5e7fea045b5d83a66952b221fb854"

URI_x86_64_v2_NetworkManager-ovs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/NetworkManager-ovs-1.52.0-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-ovs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-ovs}"
SRC_URI[x86_64_v2_NetworkManager-ovs.sha256sum] = "0145067bb1b783dd1f93c496d9755d8e226efe46d7e3fb1b688542a5bd8d00d4"

URI_x86_64_v2_NetworkManager-ppp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/NetworkManager-ppp-1.52.0-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-ppp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-ppp}"
SRC_URI[x86_64_v2_NetworkManager-ppp.sha256sum] = "f1b136f72eb8c39e248028faa85e73636b28185a042e00d34fb5fdb83b8abc00"

URI_x86_64_v2_NetworkManager-tui = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-tui-1.52.0-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-tui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-tui}"
SRC_URI[x86_64_v2_NetworkManager-tui.sha256sum] = "4619f234d31e447b4e8bf620a87b5afe432ad62b721f71240b815a2fab343d95"

URI_x86_64_v2_NetworkManager-wifi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-wifi-1.52.0-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-wifi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-wifi}"
SRC_URI[x86_64_v2_NetworkManager-wifi.sha256sum] = "3a1fea30232dee73620a70eca3addb5e08c2f4a61fc4a27f7475ccae1f662d9b"

URI_x86_64_v2_NetworkManager-wwan = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-wwan-1.52.0-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-wwan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-wwan}"
SRC_URI[x86_64_v2_NetworkManager-wwan.sha256sum] = "e6954811d42703ffd6fda3504cd7deb331d02dc03f39b68b62740dc2ac52b84a"

URI_aarch64_NetworkManager = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-1.52.0-8.el10_0.aarch64.rpm;name=aarch64_NetworkManager;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager}"
SRC_URI[aarch64_NetworkManager.sha256sum] = "5736fcf6f02bab608baac10240fba63fc517de11b46dc5d75e550d5fc0645d2b"

URI_aarch64_NetworkManager-adsl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-adsl-1.52.0-8.el10_0.aarch64.rpm;name=aarch64_NetworkManager-adsl;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-adsl}"
SRC_URI[aarch64_NetworkManager-adsl.sha256sum] = "ac964c7e4eee3e976523a42d969cfb9cc0d1a246f536487df95803e8234d382d"

URI_aarch64_NetworkManager-bluetooth = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-bluetooth-1.52.0-8.el10_0.aarch64.rpm;name=aarch64_NetworkManager-bluetooth;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-bluetooth}"
SRC_URI[aarch64_NetworkManager-bluetooth.sha256sum] = "e37c54e029ebf9a45fa21c9aab5f49d25c81a5affc564b64e63e5cf9d570c7f8"

URI_aarch64_NetworkManager-cloud-setup = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/NetworkManager-cloud-setup-1.52.0-8.el10_0.aarch64.rpm;name=aarch64_NetworkManager-cloud-setup;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-cloud-setup}"
SRC_URI[aarch64_NetworkManager-cloud-setup.sha256sum] = "e1b80483abf6f4223156e818262beba8f44583927d429d4eacaa2e783e7ca2ee"

URI_aarch64_NetworkManager-config-connectivity-redhat = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/NetworkManager-config-connectivity-redhat-1.52.0-8.el10_0.noarch.rpm;name=aarch64_NetworkManager-config-connectivity-redhat;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-config-connectivity-redhat}"
SRC_URI[aarch64_NetworkManager-config-connectivity-redhat.sha256sum] = "425fe524670ccccbb3faef9043cdd9a37c24c28fae6217055d4900f29168deb8"

URI_aarch64_NetworkManager-config-server = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-config-server-1.52.0-8.el10_0.noarch.rpm;name=aarch64_NetworkManager-config-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-config-server}"
SRC_URI[aarch64_NetworkManager-config-server.sha256sum] = "d8860d3a7f9b0fd79257e259bc586619a9798b9fe5da3ff124af250824230bfb"

URI_aarch64_NetworkManager-libnm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-libnm-1.52.0-8.el10_0.aarch64.rpm;name=aarch64_NetworkManager-libnm;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-libnm}"
SRC_URI[aarch64_NetworkManager-libnm.sha256sum] = "7a5f514356fb2fb6f17adcbf460503c252539846b84bf2df295fe29c1c0dc3e8"

URI_aarch64_NetworkManager-libnm-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/NetworkManager-libnm-devel-1.52.0-8.el10_0.aarch64.rpm;name=aarch64_NetworkManager-libnm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-libnm-devel}"
SRC_URI[aarch64_NetworkManager-libnm-devel.sha256sum] = "604e6ec239bb2c67c225c31957adf7a14024d122ae5f5a9c1719b0416b2b0ebb"

URI_aarch64_NetworkManager-ovs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/NetworkManager-ovs-1.52.0-8.el10_0.aarch64.rpm;name=aarch64_NetworkManager-ovs;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-ovs}"
SRC_URI[aarch64_NetworkManager-ovs.sha256sum] = "2bd3bf44c8ecac02a4f92e11058785b605c456038f9cea706d5aa5975cc6cbc6"

URI_aarch64_NetworkManager-ppp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/NetworkManager-ppp-1.52.0-8.el10_0.aarch64.rpm;name=aarch64_NetworkManager-ppp;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-ppp}"
SRC_URI[aarch64_NetworkManager-ppp.sha256sum] = "3bec34b4c913b6866a149dc0f57abd9b0baa299b68668e51ec3935d131f77ee5"

URI_aarch64_NetworkManager-tui = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-tui-1.52.0-8.el10_0.aarch64.rpm;name=aarch64_NetworkManager-tui;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-tui}"
SRC_URI[aarch64_NetworkManager-tui.sha256sum] = "5d5daffd000efa83a9f0f0b2c1ae95615ed6f7f7578a278b550c45b67181edef"

URI_aarch64_NetworkManager-wifi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-wifi-1.52.0-8.el10_0.aarch64.rpm;name=aarch64_NetworkManager-wifi;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-wifi}"
SRC_URI[aarch64_NetworkManager-wifi.sha256sum] = "ba9edcad54b86e9ae9e5cde3f69e1fda4e55841a4c42a2bdd1d8edb0f4f5604d"

URI_aarch64_NetworkManager-wwan = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-wwan-1.52.0-8.el10_0.aarch64.rpm;name=aarch64_NetworkManager-wwan;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-wwan}"
SRC_URI[aarch64_NetworkManager-wwan.sha256sum] = "ecd5b85d6449d598b54c76ffa0975e8a71b7a4d8c731d81b85a983c720581aef"

RDEPENDS:NetworkManager = " \
 NetworkManager-libnm \
 alternatives \
 audit-libs \
 bash \
 dbus \
 glib2 \
 glibc \
 gnutls \
 libgcc \
 libndp \
 libselinux \
 readline \
 systemd \
 systemd-libs \
 systemd-udev \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:NetworkManager-adsl = " \
 NetworkManager \
 glib2 \
 glibc \
 libgcc \
 "
RDEPENDS:NetworkManager-bluetooth = " \
 NetworkManager \
 NetworkManager-wwan \
 bluez \
 bluez-libs \
 glib2 \
 glibc \
 libgcc \
 "
RDEPENDS:NetworkManager-cloud-setup = " \
 NetworkManager \
 NetworkManager-libnm \
 bash \
 glib2 \
 glibc \
 jansson \
 libgcc \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:NetworkManager-config-connectivity-redhat = " \
 "
RDEPENDS:NetworkManager-config-server = " \
 "
RDEPENDS:NetworkManager-libnm = " \
 glib2 \
 glibc \
 gnutls \
 libgcc \
 systemd-libs \
 "
RDEPENDS:NetworkManager-libnm-devel = " \
 NetworkManager-libnm \
 glib2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:NetworkManager-ovs = " \
 NetworkManager \
 glib2 \
 glibc \
 jansson \
 libgcc \
 "
RDEPENDS:NetworkManager-ppp = " \
 NetworkManager \
 glib2 \
 glibc \
 libgcc \
 ppp \
 "
RDEPENDS:NetworkManager-tui = " \
 NetworkManager \
 NetworkManager-libnm \
 glib2 \
 glibc \
 libgcc \
 newt \
 "
RDEPENDS:NetworkManager-wifi = " \
 NetworkManager \
 glib2 \
 glibc \
 libgcc \
 wireless-regdb \
 wpa_supplicant \
 "
RDEPENDS:NetworkManager-wwan = " \
 ModemManager \
 ModemManager-glib \
 NetworkManager \
 glib2 \
 glibc \
 libgcc \
 systemd-libs \
 "
