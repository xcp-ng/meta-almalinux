# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-openprinting-ipp-usb"
PV = "0.9.27"
PR = "3.el10_0"
PACKAGES = " \
 ipp-usb \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/golang-github-openprinting-ipp-usb-0.9.27-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc2a7e6e1ae4918afb2a68e34bf1c4c1965a35e6e31455e40c44ae78aaa0fffe"

URI_x86_64_v2_ipp-usb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipp-usb-0.9.27-3.el10_0.x86_64_v2.rpm;name=x86_64_v2_ipp-usb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipp-usb}"
SRC_URI[x86_64_v2_ipp-usb.sha256sum] = "7af654e7b17f135e83b87519ddf465aef616559bbc83368b961e43c09b3aa6c1"

URI_aarch64_ipp-usb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipp-usb-0.9.27-3.el10_0.aarch64.rpm;name=aarch64_ipp-usb;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipp-usb}"
SRC_URI[aarch64_ipp-usb.sha256sum] = "e874793739fd4611ceb5320593622ddcb6b62ef3cbfa91189c5a09b3d642b0a3"

RDEPENDS:ipp-usb = " \
 avahi-libs \
 bash \
 glibc \
 libusb1 \
 systemd \
 systemd-udev \
 "
