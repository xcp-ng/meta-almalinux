# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "objectweb-asm"
PV = "9.6"
PR = "6.el10"
PACKAGES = " \
 objectweb-asm \
 objectweb-asm-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/objectweb-asm-9.6-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b143b76c9e0e7bb5e5cb7ee6e867d0ca549b64a5963710cb4bd4cce11f27f02b"

URI_x86_64_v2_objectweb-asm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/objectweb-asm-9.6-6.el10.noarch.rpm;name=x86_64_v2_objectweb-asm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_objectweb-asm}"
SRC_URI[x86_64_v2_objectweb-asm.sha256sum] = "8b6099b995e5773feb1bc4e8681d6e8c3b9a702f419ec45e933a11b0c7cf20c4"

URI_x86_64_v2_objectweb-asm-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/objectweb-asm-javadoc-9.6-6.el10.noarch.rpm;name=x86_64_v2_objectweb-asm-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_objectweb-asm-javadoc}"
SRC_URI[x86_64_v2_objectweb-asm-javadoc.sha256sum] = "8ff7166d1fd2efa788e572b0aaf517b13264c706c36c26908beedd0051e1b511"

URI_aarch64_objectweb-asm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/objectweb-asm-9.6-6.el10.noarch.rpm;name=aarch64_objectweb-asm;unpack=0"
SRC_URI:append = " ${URI_aarch64_objectweb-asm}"
SRC_URI[aarch64_objectweb-asm.sha256sum] = "8b6099b995e5773feb1bc4e8681d6e8c3b9a702f419ec45e933a11b0c7cf20c4"

URI_aarch64_objectweb-asm-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/objectweb-asm-javadoc-9.6-6.el10.noarch.rpm;name=aarch64_objectweb-asm-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_objectweb-asm-javadoc}"
SRC_URI[aarch64_objectweb-asm-javadoc.sha256sum] = "8ff7166d1fd2efa788e572b0aaf517b13264c706c36c26908beedd0051e1b511"

RDEPENDS:objectweb-asm = " \
 bash \
 javapackages-filesystem \
 javapackages-tools \
 "
RDEPENDS:objectweb-asm-javadoc = " \
 javapackages-filesystem \
 "
