# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bcal"
PV = "2.4"
PR = "11.el10_0"
PACKAGES = " \
 bcal \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bcal-2.4-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ba3c6ad8388d5fe5094f3d7828e17bfae542abcad71fbb3f6a36dbeaeaada247"

URI_x86_64_v2_bcal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bcal-2.4-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bcal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bcal}"
SRC_URI[x86_64_v2_bcal.sha256sum] = "a3db2bd8af9db50f3885c99e24e635f9d94206f41943e1d64dc14b7128bd1af0"

URI_aarch64_bcal = "${EPEL_MIRROR}/aarch64/Packages/b/bcal-2.4-11.el10_0.aarch64.rpm;name=aarch64_bcal;unpack=0"
SRC_URI:append = " ${URI_aarch64_bcal}"
SRC_URI[aarch64_bcal.sha256sum] = "cdad73594c6d30b38cfab512250b3be7512298470f994cdd09d0ef023ba56e11"

RDEPENDS:bcal = " \
 glibc \
 readline \
 "
