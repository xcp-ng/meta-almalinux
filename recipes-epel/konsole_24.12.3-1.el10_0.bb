# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "konsole"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 konsole \
 konsole-part \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/konsole-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf46155d0d4282f4a8bbc1435ccfed82b713cbf20263cab877400761adad9a54"

URI_x86_64_v2_konsole = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konsole-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konsole;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_konsole}"
SRC_URI[x86_64_v2_konsole.sha256sum] = "c68cb7ad5dfd20f6440d16ca1fe44a707023e0d3c3f0037198bbcb4440365cc2"

URI_x86_64_v2_konsole-part = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konsole-part-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konsole-part;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_konsole-part}"
SRC_URI[x86_64_v2_konsole-part.sha256sum] = "27916655885640a14ce8620a390fc585599d4da60a7ed1bd9aaf7e8ca5e63b11"

URI_aarch64_konsole = "${EPEL_MIRROR}/aarch64/Packages/k/konsole-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_konsole;unpack=0"
SRC_URI:append = " ${URI_aarch64_konsole}"
SRC_URI[aarch64_konsole.sha256sum] = "37f8994f87cabaf5228e75d274cabbfd95cb74617ece7404c169431b4811c7d6"

URI_aarch64_konsole-part = "${EPEL_MIRROR}/aarch64/Packages/k/konsole-part-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_konsole-part;unpack=0"
SRC_URI:append = " ${URI_aarch64_konsole-part}"
SRC_URI[aarch64_konsole-part.sha256sum] = "6983065ca486992ace3e17cef5ee5677b414459cfa6651da487b3da204eb3ec6"

RDEPENDS:konsole = " \
 bash \
 glibc \
 keditbookmarks \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kservice \
 kf6-kxmlgui \
 konsole-part \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:konsole-part = " \
 glibc \
 kf6-kbookmarks \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kparts \
 kf6-kpty \
 kf6-kservice \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libicu \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 "
