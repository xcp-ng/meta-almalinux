# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libxslt"
PV = "1.1.39"
PR = "8.el10_2.1"
PACKAGES = " \
 libxslt \
 libxslt-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libxslt-1.1.39-8.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "57113e23686b0c7e79773c89b166955b294d7a948350f2ede572bddecc5100a6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libxslt-1.1.39-8.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_libxslt;unpack=0"
SRC_URI[x86_64_v2_libxslt.sha256sum] = "bd0261e5ece10f3e91a0002507440f045a13d36bb294d36fdde43867d8a8611e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libxslt-devel-1.1.39-8.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_libxslt-devel;unpack=0"
SRC_URI[x86_64_v2_libxslt-devel.sha256sum] = "1d9fdf995f6b45e6db71af3d9ac7547720ad404ed2bb8ecf651ae6ecf364dbed"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libxslt-1.1.39-8.el10_2.1.aarch64.rpm;name=aarch64_libxslt;unpack=0"
SRC_URI[aarch64_libxslt.sha256sum] = "1ce827100b3c5ddf277247c6843229d1887fbfa397298f230124a59f931c8729"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libxslt-devel-1.1.39-8.el10_2.1.aarch64.rpm;name=aarch64_libxslt-devel;unpack=0"
SRC_URI[aarch64_libxslt-devel.sha256sum] = "e980fe68ca2999df8053d62cd8ffd454e6eeeb8e886a5295087cd344fb8056f1"

RDEPENDS:libxslt = " \
 glibc \
 libxml2 \
 "
RDEPENDS:libxslt-devel = " \
 bash \
 libgpg-error-devel \
 libxml2-devel \
 libxslt \
 libxslt-devel \
 pkgconf-pkg-config \
 "
