# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cpp_demangle"
PV = "0.4.5"
PR = "1.el10_1"
PACKAGES = " \
 rust-cpp_demangle+alloc-devel \
 rust-cpp_demangle+default-devel \
 rust-cpp_demangle+logging-devel \
 rust-cpp_demangle+run_libiberty_tests-devel \
 rust-cpp_demangle+std-devel \
 rust-cpp_demangle-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cpp_demangle-0.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "83a871f114543f617df2161ae059d9e6eaeecb10c744841616361a5629048b46"

URI_x86_64_v2_rust-cpp_demangle+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cpp_demangle+alloc-devel-0.4.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cpp_demangle+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cpp_demangle+alloc-devel}"
SRC_URI[x86_64_v2_rust-cpp_demangle+alloc-devel.sha256sum] = "26a1be38e31205aa53d6651cfd3036d6e30e96b9a75b19569bc8854eac9e945a"

URI_x86_64_v2_rust-cpp_demangle+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cpp_demangle+default-devel-0.4.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cpp_demangle+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cpp_demangle+default-devel}"
SRC_URI[x86_64_v2_rust-cpp_demangle+default-devel.sha256sum] = "1ac72235e30b538509cc6f4dafebf8f9bd18f966c883ea91177b77fbd7570e02"

URI_x86_64_v2_rust-cpp_demangle+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cpp_demangle+logging-devel-0.4.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cpp_demangle+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cpp_demangle+logging-devel}"
SRC_URI[x86_64_v2_rust-cpp_demangle+logging-devel.sha256sum] = "1faddabaec61dc499d11741f8649a6ff9ccf1b1edea930dec73d7f5f3b70cadb"

URI_x86_64_v2_rust-cpp_demangle+run_libiberty_tests-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cpp_demangle+run_libiberty_tests-devel-0.4.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cpp_demangle+run_libiberty_tests-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cpp_demangle+run_libiberty_tests-devel}"
SRC_URI[x86_64_v2_rust-cpp_demangle+run_libiberty_tests-devel.sha256sum] = "d3c7162a97b4d1ef5e8956d659fbaa8393a1fcea2d2d4166b6407a9fd4cc9073"

URI_x86_64_v2_rust-cpp_demangle+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cpp_demangle+std-devel-0.4.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cpp_demangle+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cpp_demangle+std-devel}"
SRC_URI[x86_64_v2_rust-cpp_demangle+std-devel.sha256sum] = "55317a7c153d5906007c926b2d8b112969948656ab512ba003dd586f8d1e2f75"

URI_x86_64_v2_rust-cpp_demangle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cpp_demangle-devel-0.4.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cpp_demangle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cpp_demangle-devel}"
SRC_URI[x86_64_v2_rust-cpp_demangle-devel.sha256sum] = "3fa2d0cd798afa6450545d2379a9db4528554084c62b51a694c2088de0029459"

URI_aarch64_rust-cpp_demangle+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cpp_demangle+alloc-devel-0.4.5-1.el10_1.noarch.rpm;name=aarch64_rust-cpp_demangle+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cpp_demangle+alloc-devel}"
SRC_URI[aarch64_rust-cpp_demangle+alloc-devel.sha256sum] = "f69e3d0973eeb2eca68298611f61e2fa37a3f18aa293c2434eff7d1c34d333cc"

URI_aarch64_rust-cpp_demangle+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cpp_demangle+default-devel-0.4.5-1.el10_1.noarch.rpm;name=aarch64_rust-cpp_demangle+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cpp_demangle+default-devel}"
SRC_URI[aarch64_rust-cpp_demangle+default-devel.sha256sum] = "d5dffdb168fd33b8bc3f6e8d3ee855175e591cf80d4815cab4f38336cf31c0c5"

URI_aarch64_rust-cpp_demangle+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cpp_demangle+logging-devel-0.4.5-1.el10_1.noarch.rpm;name=aarch64_rust-cpp_demangle+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cpp_demangle+logging-devel}"
SRC_URI[aarch64_rust-cpp_demangle+logging-devel.sha256sum] = "0d5491fc66bd645a7b6ff81d04a3cc4ad11dbe8bb0431d6a6877bb176d3588ac"

URI_aarch64_rust-cpp_demangle+run_libiberty_tests-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cpp_demangle+run_libiberty_tests-devel-0.4.5-1.el10_1.noarch.rpm;name=aarch64_rust-cpp_demangle+run_libiberty_tests-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cpp_demangle+run_libiberty_tests-devel}"
SRC_URI[aarch64_rust-cpp_demangle+run_libiberty_tests-devel.sha256sum] = "757f076faea1cd6493caf5ad053f5efe94a33837312d29e5c23be67043fc094c"

URI_aarch64_rust-cpp_demangle+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cpp_demangle+std-devel-0.4.5-1.el10_1.noarch.rpm;name=aarch64_rust-cpp_demangle+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cpp_demangle+std-devel}"
SRC_URI[aarch64_rust-cpp_demangle+std-devel.sha256sum] = "ce65e2a1bf4994019c166cd964797719986c6e06d23b35cb1d9dff3040ef071d"

URI_aarch64_rust-cpp_demangle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cpp_demangle-devel-0.4.5-1.el10_1.noarch.rpm;name=aarch64_rust-cpp_demangle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cpp_demangle-devel}"
SRC_URI[aarch64_rust-cpp_demangle-devel.sha256sum] = "e27ac45daed014a5cf6a8f53d062db9e67fdcf01fac8961d35f26d0477d4696b"

RDEPENDS:rust-cpp_demangle+alloc-devel = " \
 cargo \
 rust-cpp_demangle-devel \
 "
RDEPENDS:rust-cpp_demangle+default-devel = " \
 cargo \
 rust-cpp_demangle+std-devel \
 rust-cpp_demangle-devel \
 "
RDEPENDS:rust-cpp_demangle+logging-devel = " \
 cargo \
 rust-cpp_demangle+std-devel \
 rust-cpp_demangle-devel \
 "
RDEPENDS:rust-cpp_demangle+run_libiberty_tests-devel = " \
 cargo \
 rust-cpp_demangle-devel \
 "
RDEPENDS:rust-cpp_demangle+std-devel = " \
 cargo \
 rust-cpp_demangle+alloc-devel \
 rust-cpp_demangle-devel \
 "
RDEPENDS:rust-cpp_demangle-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 "
