# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-der-parser"
PV = "10.0.0"
PR = "3.el10_2"
PACKAGES = " \
 rust-der-parser+as_bitvec-devel \
 rust-der-parser+bigint-devel \
 rust-der-parser+bitvec-devel \
 rust-der-parser+cookie-factory-devel \
 rust-der-parser+default-devel \
 rust-der-parser+num-bigint-devel \
 rust-der-parser+serialize-devel \
 rust-der-parser+std-devel \
 rust-der-parser+unstable-devel \
 rust-der-parser-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-der-parser-10.0.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d20cb997199fbd5976778357f0d4969429fdcd206e04d8b8d5b78aa5a3af6b6c"

URI_x86_64_v2_rust-der-parser+as_bitvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der-parser+as_bitvec-devel-10.0.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der-parser+as_bitvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der-parser+as_bitvec-devel}"
SRC_URI[x86_64_v2_rust-der-parser+as_bitvec-devel.sha256sum] = "bb4691a4a4befb20b049f8bfbc03058007f8c23c4f4a1a541473074da2671ae0"

URI_x86_64_v2_rust-der-parser+bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der-parser+bigint-devel-10.0.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der-parser+bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der-parser+bigint-devel}"
SRC_URI[x86_64_v2_rust-der-parser+bigint-devel.sha256sum] = "1da113fd6ddc2e43dfc5b030cb4ba80cb039394b9a622fb4a8f5c296a87ceee7"

URI_x86_64_v2_rust-der-parser+bitvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der-parser+bitvec-devel-10.0.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der-parser+bitvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der-parser+bitvec-devel}"
SRC_URI[x86_64_v2_rust-der-parser+bitvec-devel.sha256sum] = "dcf35cecdddf9b5473d9e71a72685739327f26418593c1e279492e9152b0aa7e"

URI_x86_64_v2_rust-der-parser+cookie-factory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der-parser+cookie-factory-devel-10.0.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der-parser+cookie-factory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der-parser+cookie-factory-devel}"
SRC_URI[x86_64_v2_rust-der-parser+cookie-factory-devel.sha256sum] = "e331c47ea6b9d5517dca1235e9d8d6b3c97098569c805ef8410d2f498088db12"

URI_x86_64_v2_rust-der-parser+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der-parser+default-devel-10.0.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der-parser+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der-parser+default-devel}"
SRC_URI[x86_64_v2_rust-der-parser+default-devel.sha256sum] = "8e00a370dccc6af731b0ba725302dbcf888aa495868cf3d70addf7f15472a651"

URI_x86_64_v2_rust-der-parser+num-bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der-parser+num-bigint-devel-10.0.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der-parser+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der-parser+num-bigint-devel}"
SRC_URI[x86_64_v2_rust-der-parser+num-bigint-devel.sha256sum] = "11a149aa3131fc379220b5e793c2bb9ef37f648fb863707764d13576e5e74cb5"

URI_x86_64_v2_rust-der-parser+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der-parser+serialize-devel-10.0.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der-parser+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der-parser+serialize-devel}"
SRC_URI[x86_64_v2_rust-der-parser+serialize-devel.sha256sum] = "c87d216812814ea130889a753008a6db08cd58fa644dd8f9056f732ada7a34ad"

URI_x86_64_v2_rust-der-parser+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der-parser+std-devel-10.0.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der-parser+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der-parser+std-devel}"
SRC_URI[x86_64_v2_rust-der-parser+std-devel.sha256sum] = "02fa8b88b59f148f130c5e5f41f9fa37b3282d4ca741f451136b66534517fc23"

URI_x86_64_v2_rust-der-parser+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der-parser+unstable-devel-10.0.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der-parser+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der-parser+unstable-devel}"
SRC_URI[x86_64_v2_rust-der-parser+unstable-devel.sha256sum] = "ce12fb9e96df4ccf5423ef74866ec235910d48f6318cadd951bfbcf4d98ee2ad"

URI_x86_64_v2_rust-der-parser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der-parser-devel-10.0.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der-parser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der-parser-devel}"
SRC_URI[x86_64_v2_rust-der-parser-devel.sha256sum] = "99b841d9080e99cb25a62fd09509c9ca33c02cae02f131e78575f4c9cf2c2c8f"

URI_aarch64_rust-der-parser+as_bitvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der-parser+as_bitvec-devel-10.0.0-3.el10_2.noarch.rpm;name=aarch64_rust-der-parser+as_bitvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der-parser+as_bitvec-devel}"
SRC_URI[aarch64_rust-der-parser+as_bitvec-devel.sha256sum] = "2a66607b41d0e9c62d0bef47335f7c6f4044c5b13628fcf6ed53e230fe657a14"

URI_aarch64_rust-der-parser+bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der-parser+bigint-devel-10.0.0-3.el10_2.noarch.rpm;name=aarch64_rust-der-parser+bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der-parser+bigint-devel}"
SRC_URI[aarch64_rust-der-parser+bigint-devel.sha256sum] = "9fc9ebb012929fe3fdc721c29989bdede55bbdf0b5b29164cb8ba0690b9990ff"

URI_aarch64_rust-der-parser+bitvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der-parser+bitvec-devel-10.0.0-3.el10_2.noarch.rpm;name=aarch64_rust-der-parser+bitvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der-parser+bitvec-devel}"
SRC_URI[aarch64_rust-der-parser+bitvec-devel.sha256sum] = "46ca02ed29b7bad8b7b38172846ff51dc436d4cde4af4aacbce137b0015c04cf"

URI_aarch64_rust-der-parser+cookie-factory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der-parser+cookie-factory-devel-10.0.0-3.el10_2.noarch.rpm;name=aarch64_rust-der-parser+cookie-factory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der-parser+cookie-factory-devel}"
SRC_URI[aarch64_rust-der-parser+cookie-factory-devel.sha256sum] = "f54c8b883fd5274c63c495bc5ee075974d87082fb2741009bffbb2844a5dd6af"

URI_aarch64_rust-der-parser+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der-parser+default-devel-10.0.0-3.el10_2.noarch.rpm;name=aarch64_rust-der-parser+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der-parser+default-devel}"
SRC_URI[aarch64_rust-der-parser+default-devel.sha256sum] = "a434c48848fdb13efc749ea86c702049ea0cc8f4060243fb7b41330bf197b1c1"

URI_aarch64_rust-der-parser+num-bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der-parser+num-bigint-devel-10.0.0-3.el10_2.noarch.rpm;name=aarch64_rust-der-parser+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der-parser+num-bigint-devel}"
SRC_URI[aarch64_rust-der-parser+num-bigint-devel.sha256sum] = "0f67ea80d079abc29db1aac005772f3b7999978106f29bff4f95405a0ddf3d55"

URI_aarch64_rust-der-parser+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der-parser+serialize-devel-10.0.0-3.el10_2.noarch.rpm;name=aarch64_rust-der-parser+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der-parser+serialize-devel}"
SRC_URI[aarch64_rust-der-parser+serialize-devel.sha256sum] = "975a8829a484b8fc8ffadfc70b9fae9caf0d8821c6410914a0cb712eee3c68a6"

URI_aarch64_rust-der-parser+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der-parser+std-devel-10.0.0-3.el10_2.noarch.rpm;name=aarch64_rust-der-parser+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der-parser+std-devel}"
SRC_URI[aarch64_rust-der-parser+std-devel.sha256sum] = "b4fd90427f2d0c1f8392d3ae8552a55ccbd373a347e8cfa05e0084c5c042859a"

URI_aarch64_rust-der-parser+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der-parser+unstable-devel-10.0.0-3.el10_2.noarch.rpm;name=aarch64_rust-der-parser+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der-parser+unstable-devel}"
SRC_URI[aarch64_rust-der-parser+unstable-devel.sha256sum] = "ad3e886e8e60558675254245124d0eb808568be0b67b8b46ec737f2fa146ba78"

URI_aarch64_rust-der-parser-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der-parser-devel-10.0.0-3.el10_2.noarch.rpm;name=aarch64_rust-der-parser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der-parser-devel}"
SRC_URI[aarch64_rust-der-parser-devel.sha256sum] = "64ad8cd003d31c6e39598bcba7ea956c360f291e1eba775e0276cec7f3f313a4"

RDEPENDS:rust-der-parser+as_bitvec-devel = " \
 cargo \
 rust-der-parser+bitvec-devel \
 rust-der-parser-devel \
 "
RDEPENDS:rust-der-parser+bigint-devel = " \
 cargo \
 rust-der-parser+num-bigint-devel \
 rust-der-parser-devel \
 "
RDEPENDS:rust-der-parser+bitvec-devel = " \
 cargo \
 rust-bitvec+default-devel \
 rust-der-parser-devel \
 "
RDEPENDS:rust-der-parser+cookie-factory-devel = " \
 cargo \
 rust-cookie-factory+default-devel \
 rust-der-parser-devel \
 "
RDEPENDS:rust-der-parser+default-devel = " \
 cargo \
 rust-der-parser+std-devel \
 rust-der-parser-devel \
 "
RDEPENDS:rust-der-parser+num-bigint-devel = " \
 cargo \
 rust-der-parser-devel \
 rust-num-bigint+default-devel \
 "
RDEPENDS:rust-der-parser+serialize-devel = " \
 cargo \
 rust-der-parser+cookie-factory-devel \
 rust-der-parser+std-devel \
 rust-der-parser-devel \
 "
RDEPENDS:rust-der-parser+std-devel = " \
 cargo \
 rust-der-parser-devel \
 "
RDEPENDS:rust-der-parser+unstable-devel = " \
 cargo \
 rust-der-parser-devel \
 "
RDEPENDS:rust-der-parser-devel = " \
 cargo \
 rust \
 rust-asn1-rs+default-devel \
 rust-displaydoc-devel \
 rust-nom7+default-devel \
 rust-num-traits+default-devel \
 rust-rusticata-macros+default-devel \
 "
