# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-doctest"
PV = "0.22.4"
PR = "1.el10_0"
PACKAGES = " \
 ghc-doctest \
 ghc-doctest-devel \
 ghc-doctest-doc \
 ghc-doctest-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-doctest-0.22.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6bf0b014233c53404ac02af4b537d210e422dff6e5d0ecb4125e5a8e85bd6924"

URI_x86_64_v2_ghc-doctest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-doctest-0.22.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-doctest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-doctest}"
SRC_URI[x86_64_v2_ghc-doctest.sha256sum] = "4868e55a297fbbc5467da3f4d72ce81620a58c32ee0aa15a681552f85697fbd9"

URI_x86_64_v2_ghc-doctest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-doctest-devel-0.22.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-doctest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-doctest-devel}"
SRC_URI[x86_64_v2_ghc-doctest-devel.sha256sum] = "e7423667b8241899d2f6be6044f1bf45a364c610bd2f5329136c9a2283142e83"

URI_x86_64_v2_ghc-doctest-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-doctest-doc-0.22.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-doctest-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-doctest-doc}"
SRC_URI[x86_64_v2_ghc-doctest-doc.sha256sum] = "796b377b9ccd48d6ae898a2bafaa371dd9c5246b875cb283935f31802c87dae5"

URI_x86_64_v2_ghc-doctest-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-doctest-prof-0.22.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-doctest-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-doctest-prof}"
SRC_URI[x86_64_v2_ghc-doctest-prof.sha256sum] = "41e926c35bb843b9cd5f86997fa9e0d6582690b523a1b7363ad8edb280495ce0"

URI_aarch64_ghc-doctest = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-doctest-0.22.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-doctest;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-doctest}"
SRC_URI[aarch64_ghc-doctest.sha256sum] = "f5e6c300026dedf9bf6d2775e5565dfbc1f16b002b038555c9538ebdd2f856c4"

URI_aarch64_ghc-doctest-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-doctest-devel-0.22.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-doctest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-doctest-devel}"
SRC_URI[aarch64_ghc-doctest-devel.sha256sum] = "694037049244264165a9a45a31ecbb24a10d175b9323e4b7745151bd6d5d6e66"

URI_aarch64_ghc-doctest-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-doctest-doc-0.22.4-1.el10_0.noarch.rpm;name=aarch64_ghc-doctest-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-doctest-doc}"
SRC_URI[aarch64_ghc-doctest-doc.sha256sum] = "618d8489403c49a606a0c51da170a330314697eab7e51a7b6e1177767409626c"

URI_aarch64_ghc-doctest-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-doctest-prof-0.22.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-doctest-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-doctest-prof}"
SRC_URI[aarch64_ghc-doctest-prof.sha256sum] = "7f765766739d3c201bb8f12c396aa9c2964ded13bb928aea30519e163f1402ce"

RDEPENDS:ghc-doctest = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-code-page \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc \
 ghc-ghc-bignum \
 ghc-ghc-boot \
 ghc-ghc-boot-th \
 ghc-ghc-heap \
 ghc-ghc-paths \
 ghc-ghci \
 ghc-hpc \
 ghc-mtl \
 ghc-pretty \
 ghc-process \
 ghc-stm \
 ghc-syb \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-doctest-devel = " \
 ghc-base-devel \
 ghc-code-page-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-directory-devel \
 ghc-doctest \
 ghc-exceptions-devel \
 ghc-filepath-devel \
 ghc-ghc-devel \
 ghc-ghc-paths-devel \
 ghc-process-devel \
 ghc-syb-devel \
 ghc-transformers-devel \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc-doctest-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-doctest-prof = " \
 ghc-base-prof \
 ghc-code-page-prof \
 ghc-deepseq-prof \
 ghc-directory-prof \
 ghc-doctest-devel \
 ghc-exceptions-prof \
 ghc-filepath-prof \
 ghc-ghc-paths-prof \
 ghc-ghc-prof \
 ghc-process-prof \
 ghc-syb-prof \
 ghc-transformers-prof \
 "
