# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dbus"
PE = "1"
PV = "1.14.10"
PR = "5.el10"
PACKAGES = " \
 dbus \
 dbus-common \
 dbus-daemon \
 dbus-devel \
 dbus-doc \
 dbus-libs \
 dbus-tools \
 dbus-x11 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/dbus-1.14.10-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "007f2c4535cc93bb7fb7ee22741a65477d28c15b9f87e8436013b09b3362d394"

URI_x86_64_v2_dbus = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dbus-1.14.10-5.el10.x86_64_v2.rpm;name=x86_64_v2_dbus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dbus}"
SRC_URI[x86_64_v2_dbus.sha256sum] = "2429aeaa8f841561075614cd2c151976d84f6fa41163e03e2b6016c01ad9b651"

URI_x86_64_v2_dbus-common = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dbus-common-1.14.10-5.el10.noarch.rpm;name=x86_64_v2_dbus-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dbus-common}"
SRC_URI[x86_64_v2_dbus-common.sha256sum] = "0c163d031c1b356eb5ac309517325f3da23b89b33352538dff3870c9f499eb9d"

URI_x86_64_v2_dbus-daemon = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dbus-daemon-1.14.10-5.el10.x86_64_v2.rpm;name=x86_64_v2_dbus-daemon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dbus-daemon}"
SRC_URI[x86_64_v2_dbus-daemon.sha256sum] = "1c9e5c9d9801f816897a9d165ae76b3a64778a81858530ebee928067adb741c6"

URI_x86_64_v2_dbus-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dbus-devel-1.14.10-5.el10.x86_64_v2.rpm;name=x86_64_v2_dbus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dbus-devel}"
SRC_URI[x86_64_v2_dbus-devel.sha256sum] = "8ea3a085a8333db93cd1507f0152b94f6f2c91bf867b3945e1dce2f359d9479e"

URI_x86_64_v2_dbus-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dbus-doc-1.14.10-5.el10.noarch.rpm;name=x86_64_v2_dbus-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dbus-doc}"
SRC_URI[x86_64_v2_dbus-doc.sha256sum] = "d2a3ca9d88f4801283397c92fa9a71789e1bbd70d0644f91ee37833b01cc2ef3"

URI_x86_64_v2_dbus-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dbus-libs-1.14.10-5.el10.x86_64_v2.rpm;name=x86_64_v2_dbus-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dbus-libs}"
SRC_URI[x86_64_v2_dbus-libs.sha256sum] = "9c53b501b6b501d47ee846abafca3936a2b422baea4fb539ddd4dc13296f10a2"

URI_x86_64_v2_dbus-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dbus-tools-1.14.10-5.el10.x86_64_v2.rpm;name=x86_64_v2_dbus-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dbus-tools}"
SRC_URI[x86_64_v2_dbus-tools.sha256sum] = "ab658d30e0d7ba73c96476f180efd524dcc4176f7abff28395d52f518c7a1814"

URI_x86_64_v2_dbus-x11 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dbus-x11-1.14.10-5.el10.x86_64_v2.rpm;name=x86_64_v2_dbus-x11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dbus-x11}"
SRC_URI[x86_64_v2_dbus-x11.sha256sum] = "8ab8128105b05804d9c8cfc3e4edb420f03e5bf90fbd434e5de2b1b0e694a362"

URI_aarch64_dbus = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dbus-1.14.10-5.el10.aarch64.rpm;name=aarch64_dbus;unpack=0"
SRC_URI:append = " ${URI_aarch64_dbus}"
SRC_URI[aarch64_dbus.sha256sum] = "2ac429a480648324bbf82899b9930eb078cffc043ae9bf66c78120cb107f1cfc"

URI_aarch64_dbus-common = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dbus-common-1.14.10-5.el10.noarch.rpm;name=aarch64_dbus-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_dbus-common}"
SRC_URI[aarch64_dbus-common.sha256sum] = "0c163d031c1b356eb5ac309517325f3da23b89b33352538dff3870c9f499eb9d"

URI_aarch64_dbus-daemon = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dbus-daemon-1.14.10-5.el10.aarch64.rpm;name=aarch64_dbus-daemon;unpack=0"
SRC_URI:append = " ${URI_aarch64_dbus-daemon}"
SRC_URI[aarch64_dbus-daemon.sha256sum] = "5425860c7b8ed2f547f737ffd49ef063c6835109dfe10e9427f03d5329616a43"

URI_aarch64_dbus-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dbus-devel-1.14.10-5.el10.aarch64.rpm;name=aarch64_dbus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dbus-devel}"
SRC_URI[aarch64_dbus-devel.sha256sum] = "fcb76c5cba2c0ded181baff34a2057eacb5554817a7ea5dce1284a0019360374"

URI_aarch64_dbus-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dbus-doc-1.14.10-5.el10.noarch.rpm;name=aarch64_dbus-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_dbus-doc}"
SRC_URI[aarch64_dbus-doc.sha256sum] = "d2a3ca9d88f4801283397c92fa9a71789e1bbd70d0644f91ee37833b01cc2ef3"

URI_aarch64_dbus-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dbus-libs-1.14.10-5.el10.aarch64.rpm;name=aarch64_dbus-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_dbus-libs}"
SRC_URI[aarch64_dbus-libs.sha256sum] = "e0772dcceecbb6a32bed0f2be7842b57f0ee422a67dc4ad2fb3a78b33f072f36"

URI_aarch64_dbus-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dbus-tools-1.14.10-5.el10.aarch64.rpm;name=aarch64_dbus-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_dbus-tools}"
SRC_URI[aarch64_dbus-tools.sha256sum] = "321fc42ab4dd5d3cc90b8099bda100d07831419a654d443eecb3927f198f3d87"

URI_aarch64_dbus-x11 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dbus-x11-1.14.10-5.el10.aarch64.rpm;name=aarch64_dbus-x11;unpack=0"
SRC_URI:append = " ${URI_aarch64_dbus-x11}"
SRC_URI[aarch64_dbus-x11.sha256sum] = "d2cbc3314e68403498fe299f8993f1b280c8f56a5d0baab3a31695bff6307764"

RDEPENDS:dbus = " \
 dbus-broker \
 "
RDEPENDS:dbus-common = " \
 bash \
 "
RDEPENDS:dbus-daemon = " \
 audit-libs \
 bash \
 dbus-common \
 dbus-libs \
 dbus-tools \
 expat \
 glibc \
 libcap-ng \
 libselinux \
 shadow-utils \
 systemd-libs \
 "
RDEPENDS:dbus-devel = " \
 cmake-filesystem \
 dbus-libs \
 pkgconf-pkg-config \
 xml-common \
 "
RDEPENDS:dbus-doc = " \
 dbus-daemon \
 "
RDEPENDS:dbus-libs = " \
 glibc \
 systemd-libs \
 "
RDEPENDS:dbus-tools = " \
 dbus-libs \
 glibc \
 "
RDEPENDS:dbus-x11 = " \
 bash \
 dbus-daemon \
 dbus-libs \
 glibc \
 libX11 \
 "
