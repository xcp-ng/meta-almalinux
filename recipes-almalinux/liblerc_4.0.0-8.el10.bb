# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "liblerc"
PV = "4.0.0"
PR = "8.el10"
PACKAGES = " \
 liblerc \
 liblerc-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/liblerc-4.0.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "deb26d826b5aa235516b93471a458631252b06c6c7eb6d27ebbc5cd11c76f0e0"

URI_x86_64_v2_liblerc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/liblerc-4.0.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_liblerc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liblerc}"
SRC_URI[x86_64_v2_liblerc.sha256sum] = "2db4eca04cb768112064bbbd408c76c433ad95c2743a18e147b073d130d5ab15"

URI_x86_64_v2_liblerc-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/liblerc-devel-4.0.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_liblerc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liblerc-devel}"
SRC_URI[x86_64_v2_liblerc-devel.sha256sum] = "cfec0883330c0eed35b1845b4827b61e1d6e1904b2747230c3bb78ddb1da1047"

URI_aarch64_liblerc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/liblerc-4.0.0-8.el10.aarch64.rpm;name=aarch64_liblerc;unpack=0"
SRC_URI:append = " ${URI_aarch64_liblerc}"
SRC_URI[aarch64_liblerc.sha256sum] = "39d22e83f88375a95a4d0bc735d3f3a671e695761fb875a7fcc7c65417de6b67"

URI_aarch64_liblerc-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/liblerc-devel-4.0.0-8.el10.aarch64.rpm;name=aarch64_liblerc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_liblerc-devel}"
SRC_URI[aarch64_liblerc-devel.sha256sum] = "bd5a82fec2e4e94ac02b90f3eb9272e727ac8366f5625ec74a439f73de14252f"

RDEPENDS:liblerc = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:liblerc-devel = " \
 liblerc \
 pkgconf-pkg-config \
 "
