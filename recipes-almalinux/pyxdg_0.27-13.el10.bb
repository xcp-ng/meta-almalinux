# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pyxdg"
PV = "0.27"
PR = "13.el10"
PACKAGES = " \
 python3-pyxdg \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pyxdg-0.27-13.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "03f991b94957788018b26b786818017cec6ea07e4cc8a1bacfc4b2deab130025"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pyxdg-0.27-13.el10.noarch.rpm;name=x86_64_v2_python3-pyxdg;unpack=0"
SRC_URI[x86_64_v2_python3-pyxdg.sha256sum] = "edbb6fdef77f8bff9d8166f431d1c88d453d12a6274a13d6fe2fe9435dfdf2a7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pyxdg-0.27-13.el10.noarch.rpm;name=aarch64_python3-pyxdg;unpack=0"
SRC_URI[aarch64_python3-pyxdg.sha256sum] = "edbb6fdef77f8bff9d8166f431d1c88d453d12a6274a13d6fe2fe9435dfdf2a7"

RDEPENDS:python3-pyxdg = " \
 python3 \
 "
