# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-object-rewrite"
PV = "0.1.1"
PR = "1.el10_2"
PACKAGES = " \
 object-rewrite \
 rust-object-rewrite+all-devel \
 rust-object-rewrite+cli-devel \
 rust-object-rewrite+default-devel \
 rust-object-rewrite+doc-devel \
 rust-object-rewrite+logging-devel \
 rust-object-rewrite-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-object-rewrite-0.1.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b9cb2585d816b7f49d402c54ccf748c6022322b202e0f0600c6fe4aea40799e"

URI_x86_64_v2_object-rewrite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/object-rewrite-0.1.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_object-rewrite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_object-rewrite}"
SRC_URI[x86_64_v2_object-rewrite.sha256sum] = "ff7c38542e6597ab82ca0e26bf0612eb9c929eabd1dc8bde165c4545aa478d73"

URI_x86_64_v2_rust-object-rewrite+all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object-rewrite+all-devel-0.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object-rewrite+all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object-rewrite+all-devel}"
SRC_URI[x86_64_v2_rust-object-rewrite+all-devel.sha256sum] = "109e3a17885c370656cedb89b17e30c1e668f5cfb6f8dccd2b8efbfce97e0e47"

URI_x86_64_v2_rust-object-rewrite+cli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object-rewrite+cli-devel-0.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object-rewrite+cli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object-rewrite+cli-devel}"
SRC_URI[x86_64_v2_rust-object-rewrite+cli-devel.sha256sum] = "aa40f9013af91667bcbd82e9212b864e2fc92b755a6f6a6c331adcd17d37b68e"

URI_x86_64_v2_rust-object-rewrite+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object-rewrite+default-devel-0.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object-rewrite+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object-rewrite+default-devel}"
SRC_URI[x86_64_v2_rust-object-rewrite+default-devel.sha256sum] = "cf156d914dda8d20631758bec821385714ab0f5491402198c339e5af19855c99"

URI_x86_64_v2_rust-object-rewrite+doc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object-rewrite+doc-devel-0.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object-rewrite+doc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object-rewrite+doc-devel}"
SRC_URI[x86_64_v2_rust-object-rewrite+doc-devel.sha256sum] = "79ba5af00538e99256acf912a98f3b16734a8be25455b14278b74b6c6b34e108"

URI_x86_64_v2_rust-object-rewrite+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object-rewrite+logging-devel-0.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object-rewrite+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object-rewrite+logging-devel}"
SRC_URI[x86_64_v2_rust-object-rewrite+logging-devel.sha256sum] = "e57078f6d39603acc7ac94fe5b3b9f821ec40cd58f08d62d056bc623d559d0dc"

URI_x86_64_v2_rust-object-rewrite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object-rewrite-devel-0.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object-rewrite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object-rewrite-devel}"
SRC_URI[x86_64_v2_rust-object-rewrite-devel.sha256sum] = "e2149470557e5059da3d4ffdb42fce471ffa944dff9b07e8a33f065df1a28fbe"

URI_aarch64_object-rewrite = "${EPEL_MIRROR}/aarch64/Packages/o/object-rewrite-0.1.1-1.el10_2.aarch64.rpm;name=aarch64_object-rewrite;unpack=0"
SRC_URI:append = " ${URI_aarch64_object-rewrite}"
SRC_URI[aarch64_object-rewrite.sha256sum] = "1ef30f80b68051934879cbb74871e9926ed9c73d2666cabd76e0c02d48d4f132"

URI_aarch64_rust-object-rewrite+all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object-rewrite+all-devel-0.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-object-rewrite+all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object-rewrite+all-devel}"
SRC_URI[aarch64_rust-object-rewrite+all-devel.sha256sum] = "a997770447eaaa00d05b12407d7bbb760e85660dec83b8aee1ba837b0562905d"

URI_aarch64_rust-object-rewrite+cli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object-rewrite+cli-devel-0.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-object-rewrite+cli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object-rewrite+cli-devel}"
SRC_URI[aarch64_rust-object-rewrite+cli-devel.sha256sum] = "02f24a8fa1c0aa2b22a56bd7b307f603a7830d3d26446c7c9954aa287e976e66"

URI_aarch64_rust-object-rewrite+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object-rewrite+default-devel-0.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-object-rewrite+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object-rewrite+default-devel}"
SRC_URI[aarch64_rust-object-rewrite+default-devel.sha256sum] = "f6654944c7b483d07a58c72061c5665fc5a1da191b61cd49910f249352d57595"

URI_aarch64_rust-object-rewrite+doc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object-rewrite+doc-devel-0.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-object-rewrite+doc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object-rewrite+doc-devel}"
SRC_URI[aarch64_rust-object-rewrite+doc-devel.sha256sum] = "75d58cbf34409f2f094291cd959a12a196b064e1d48e318c253429b059bcf174"

URI_aarch64_rust-object-rewrite+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object-rewrite+logging-devel-0.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-object-rewrite+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object-rewrite+logging-devel}"
SRC_URI[aarch64_rust-object-rewrite+logging-devel.sha256sum] = "fe509f5d4432dbd3af47f10efb4256081f5b9fb442a6502907e21626a909745a"

URI_aarch64_rust-object-rewrite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object-rewrite-devel-0.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-object-rewrite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object-rewrite-devel}"
SRC_URI[aarch64_rust-object-rewrite-devel.sha256sum] = "c6bb8f9926e027468f25c99f1576dc5b68cd49dab35021c2f1a34fed7e358263"

RDEPENDS:object-rewrite = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-object-rewrite+all-devel = " \
 cargo \
 rust-object-rewrite+cli-devel \
 rust-object-rewrite+logging-devel \
 rust-object-rewrite-devel \
 "
RDEPENDS:rust-object-rewrite+cli-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-clap+cargo-devel \
 rust-clap+default-devel \
 rust-env_logger-devel \
 rust-memmap2+default-devel \
 rust-object-rewrite+logging-devel \
 rust-object-rewrite-devel \
 "
RDEPENDS:rust-object-rewrite+default-devel = " \
 cargo \
 rust-object-rewrite-devel \
 "
RDEPENDS:rust-object-rewrite+doc-devel = " \
 cargo \
 rust-object-rewrite-devel \
 "
RDEPENDS:rust-object-rewrite+logging-devel = " \
 cargo \
 rust-log+default-devel \
 rust-object-rewrite-devel \
 "
RDEPENDS:rust-object-rewrite-devel = " \
 cargo \
 virtual/crate_object/build__ge_0.35.0_with_crate_object/build__lt_0.39.0~ \
 virtual/crate_object/elf__ge_0.35.0_with_crate_object/elf__lt_0.39.0~ \
 virtual/crate_object__ge_0.35.0_with_crate_object__lt_0.39.0~ \
 "
