# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-Ping"
PV = "2.76"
PR = "511.el10"
PACKAGES = " \
 perl-Net-Ping \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Net-Ping-2.76-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "467ebf9af36bffa9dd9d604cb4efc873cc4ff5b10ce92a9a747e784c00f6015a"

URI_x86_64_v2_perl-Net-Ping = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Net-Ping-2.76-511.el10.noarch.rpm;name=x86_64_v2_perl-Net-Ping;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-Ping}"
SRC_URI[x86_64_v2_perl-Net-Ping.sha256sum] = "66a6fa92b3749c8996de606bc1c6d19fbd9819ee5301fbf5abfff310128ac6a3"

URI_aarch64_perl-Net-Ping = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Net-Ping-2.76-511.el10.noarch.rpm;name=aarch64_perl-Net-Ping;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-Ping}"
SRC_URI[aarch64_perl-Net-Ping.sha256sum] = "66a6fa92b3749c8996de606bc1c6d19fbd9819ee5301fbf5abfff310128ac6a3"

RDEPENDS:perl-Net-Ping = " \
 perl-Carp \
 perl-Exporter \
 perl-Fcntl \
 perl-FileHandle \
 perl-IO \
 perl-POSIX \
 perl-Socket \
 perl-Time-HiRes \
 perl-constant \
 perl-libs \
 perl-vars \
 "
