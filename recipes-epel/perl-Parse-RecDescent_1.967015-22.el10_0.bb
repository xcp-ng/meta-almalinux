# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Parse-RecDescent"
PV = "1.967015"
PR = "22.el10_0"
PACKAGES = " \
 perl-Parse-RecDescent \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Parse-RecDescent-1.967015-22.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b6c7fc03f4eab6a3c92a0580360f37cdfcebc1ecaa826f2f565a4d95638e401b"

URI_x86_64_v2_perl-Parse-RecDescent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Parse-RecDescent-1.967015-22.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Parse-RecDescent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Parse-RecDescent}"
SRC_URI[x86_64_v2_perl-Parse-RecDescent.sha256sum] = "5d4a5a1c5fe0dcc1d10c476eea763f733f90660682411897be831d06383f7a74"

URI_aarch64_perl-Parse-RecDescent = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Parse-RecDescent-1.967015-22.el10_0.noarch.rpm;name=aarch64_perl-Parse-RecDescent;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Parse-RecDescent}"
SRC_URI[aarch64_perl-Parse-RecDescent.sha256sum] = "85df37d795f70efd676b3a9d11915207db584053d35f65ef28a0ccd4a68203e2"

RDEPENDS:perl-Parse-RecDescent = " \
 perl-Carp \
 perl-Data-Dumper \
 perl-Text-Balanced \
 perl-libs \
 perl-vars \
 "
