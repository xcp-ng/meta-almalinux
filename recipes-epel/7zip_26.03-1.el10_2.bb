# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "7zip"
PV = "26.03"
PR = "1.el10_2"
PACKAGES = " \
 7zip \
 7zip-reduced \
 7zip-standalone \
 7zip-standalone-all \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/7/7zip-26.03-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c24df81cce25ccde14d1f450cd4bdfd877578a1ee82a2d0822d9e9c447b8dfd3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/7zip-26.03-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_7zip;unpack=0"
SRC_URI[x86_64_v2_7zip.sha256sum] = "fe35692a0c0491d04d7548f7af4a25530f81923c5f3c8b7e778c61dcfd218e88"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/7zip-reduced-26.03-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_7zip-reduced;unpack=0"
SRC_URI[x86_64_v2_7zip-reduced.sha256sum] = "a78b5b8cc02c577682214599204bbc204257892728e3c708d12ba2a511226a93"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/7zip-standalone-26.03-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_7zip-standalone;unpack=0"
SRC_URI[x86_64_v2_7zip-standalone.sha256sum] = "b2b697e4fdb5bf480e711d4db0b819ba26ad7266e26fdc6b32a4080bc1d4520c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/7zip-standalone-all-26.03-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_7zip-standalone-all;unpack=0"
SRC_URI[x86_64_v2_7zip-standalone-all.sha256sum] = "cc2b4138ded8a66e4db30cdfb1e169587b28afa02f18b64e3b92a4095d0deee7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/7/7zip-26.03-1.el10_2.aarch64.rpm;name=aarch64_7zip;unpack=0"
SRC_URI[aarch64_7zip.sha256sum] = "94152fff0636fb29098094c422f8f7c2e1e3ae78609e130204420d40747fe783"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/7/7zip-reduced-26.03-1.el10_2.aarch64.rpm;name=aarch64_7zip-reduced;unpack=0"
SRC_URI[aarch64_7zip-reduced.sha256sum] = "9f2d828df290cc176aa4530000ede4fdde966a766d3929b8eb793bfb584372ac"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/7/7zip-standalone-26.03-1.el10_2.aarch64.rpm;name=aarch64_7zip-standalone;unpack=0"
SRC_URI[aarch64_7zip-standalone.sha256sum] = "ecf41c709cbfd76e1aefcce04fead44ea4283e19800c2c6cf8522f8d6880878f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/7/7zip-standalone-all-26.03-1.el10_2.aarch64.rpm;name=aarch64_7zip-standalone-all;unpack=0"
SRC_URI[aarch64_7zip-standalone-all.sha256sum] = "6e0f9bbd590f4327b6c79ead8239f716cd788b1f7a5bd628b06a085f70dc0a22"

RDEPENDS:7zip = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:7zip-reduced = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:7zip-standalone = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:7zip-standalone-all = " \
 glibc \
 libgcc \
 libstdc++ \
 "
