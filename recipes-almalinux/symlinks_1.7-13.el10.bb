# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "symlinks"
PV = "1.7"
PR = "13.el10"
PACKAGES = " \
 symlinks \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/symlinks-1.7-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b7c1d7627fdd114aff1f9d50d3e4072c75bc7148ac5f7f8cf30c72e09cacfa1f"

URI_x86_64_v2_symlinks = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/symlinks-1.7-13.el10.x86_64_v2.rpm;name=x86_64_v2_symlinks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_symlinks}"
SRC_URI[x86_64_v2_symlinks.sha256sum] = "2f75993270d8c93fe017967897c3e4320c7c9fae457a42f2c6cd9727ad7df959"

URI_aarch64_symlinks = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/symlinks-1.7-13.el10.aarch64.rpm;name=aarch64_symlinks;unpack=0"
SRC_URI:append = " ${URI_aarch64_symlinks}"
SRC_URI[aarch64_symlinks.sha256sum] = "0cd0e2ffeafa83adccbe4112b4fdf36d3d72df5ada72dc044e2afe95a9b709ca"

RDEPENDS:symlinks = " \
 glibc \
 "
