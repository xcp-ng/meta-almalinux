# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cachefilesd"
PV = "0.10.10"
PR = "20.el10"
PACKAGES = " \
 cachefilesd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/cachefilesd-0.10.10-20.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3af81aad13ba729799dbf4d04cb55a450d450329dfeab26ef9337052e71bd85b"

URI_x86_64_v2_cachefilesd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cachefilesd-0.10.10-20.el10.x86_64_v2.rpm;name=x86_64_v2_cachefilesd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cachefilesd}"
SRC_URI[x86_64_v2_cachefilesd.sha256sum] = "46d3eab44718ed0bbadfea2607519246e9b3f996a3228b31cfb8ec0a4fd1c15b"

URI_aarch64_cachefilesd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cachefilesd-0.10.10-20.el10.aarch64.rpm;name=aarch64_cachefilesd;unpack=0"
SRC_URI:append = " ${URI_aarch64_cachefilesd}"
SRC_URI[aarch64_cachefilesd.sha256sum] = "6a15093293e92864599ed38f4e006e6af6a3a18628369c4d6a422f966ab9e06d"

RDEPENDS:cachefilesd = " \
 bash \
 glibc \
 selinux-policy \
 systemd \
 "
