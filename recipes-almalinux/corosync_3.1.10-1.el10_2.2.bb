# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "corosync"
PV = "3.1.10"
PR = "1.el10_2.2"
PACKAGES = " \
 corosync-vqsim \
 corosynclib \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/corosync-3.1.10-1.el10_2.2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "52167faef53fb1a38c193eccdaededc1457f8fd1693197a3712b985ea2b076a0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/corosync-vqsim-3.1.10-1.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_corosync-vqsim;unpack=0"
SRC_URI[x86_64_v2_corosync-vqsim.sha256sum] = "804bb6dc1e29a6378035f4f880cb031d672ee20627e6b87c4b400f379fb48f4c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/corosynclib-3.1.10-1.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_corosynclib;unpack=0"
SRC_URI[x86_64_v2_corosynclib.sha256sum] = "ef4bed824704876780d778d538e58217688ef94215fae7c3461cd9ba2db63355"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/corosync-vqsim-3.1.10-1.el10_2.2.aarch64.rpm;name=aarch64_corosync-vqsim;unpack=0"
SRC_URI[aarch64_corosync-vqsim.sha256sum] = "ee7cf74a0e1bce005ab72b4f0db2e355e9c0fe4c2985fffb71a58c03bf7cfb82"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/corosynclib-3.1.10-1.el10_2.2.aarch64.rpm;name=aarch64_corosynclib;unpack=0"
SRC_URI[aarch64_corosynclib.sha256sum] = "6286b4c8f928115dc9650a1a3db35fbe79a663bd60d9711335ffb3b3f8566123"

RDEPENDS:corosync-vqsim = " \
 corosynclib \
 glibc \
 libknet1 \
 libqb \
 pkgconf-pkg-config \
 readline \
 "
RDEPENDS:corosynclib = " \
 glibc \
 libqb \
 "
