# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "audiocd-kio"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 audiocd-kio \
 audiocd-kio-devel \
 audiocd-kio-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/audiocd-kio-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d8979f40b9800b5c500bd5ef374f4f889454cb6162638ce29510607b649cf305"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/audiocd-kio-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_audiocd-kio;unpack=0"
SRC_URI[x86_64_v2_audiocd-kio.sha256sum] = "be589d862bb49bf7269fc0ae60f291609586d03284e8618738b1baba2c5a03cd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/audiocd-kio-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_audiocd-kio-devel;unpack=0"
SRC_URI[x86_64_v2_audiocd-kio-devel.sha256sum] = "a536adbdbc7aa5edd78a439aa62d5a1be7c758752c6a823e996a0300df922128"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/audiocd-kio-doc-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_audiocd-kio-doc;unpack=0"
SRC_URI[x86_64_v2_audiocd-kio-doc.sha256sum] = "301ed661dc0c476b4dbe1adb7b37de41d6f0aaf1a39d804f7eca7cbdd29d75b5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/audiocd-kio-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_audiocd-kio;unpack=0"
SRC_URI[aarch64_audiocd-kio.sha256sum] = "f2a669584224e2765eb627473909cea9712f870e6dcba9a44950c5055145aeb4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/audiocd-kio-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_audiocd-kio-devel;unpack=0"
SRC_URI[aarch64_audiocd-kio-devel.sha256sum] = "64bfa4c46641de937dc41bfe49e2046b160b8e45474f10e5d86915205279fafa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/audiocd-kio-doc-26.08.1-1.el10_3.noarch.rpm;name=aarch64_audiocd-kio-doc;unpack=0"
SRC_URI[aarch64_audiocd-kio-doc.sha256sum] = "71299445f4ca7ccd602a2d05791d02d2da2eab0beb2b5677744f49d0c2817f80"

RDEPENDS:audiocd-kio = " \
 audiocd-kio-doc \
 cdparanoia-libs \
 flac-libs \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-solid \
 libkcddb \
 libogg \
 libstdc++ \
 libvorbis \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:audiocd-kio-devel = " \
 audiocd-kio \
 "
RDEPENDS:audiocd-kio-doc = " \
 audiocd-kio \
 "
