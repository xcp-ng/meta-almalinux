# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-listenfd"
PV = "1.0.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-listenfd+default-devel \
 rust-listenfd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-listenfd-1.0.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69a15e6bc3871bbae3b32b3791a407b4b8602ec723ae337bdfcb7c8861f959c0"

URI_x86_64_v2_rust-listenfd+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-listenfd+default-devel-1.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-listenfd+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-listenfd+default-devel}"
SRC_URI[x86_64_v2_rust-listenfd+default-devel.sha256sum] = "017e16c10cc5c3889af4cfd907d0dda5c6b84d4f5323b854e06b17232b471bf5"

URI_x86_64_v2_rust-listenfd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-listenfd-devel-1.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-listenfd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-listenfd-devel}"
SRC_URI[x86_64_v2_rust-listenfd-devel.sha256sum] = "a48d8581c006c0f819a6dd706ce948caa54e60cef7e276fe8b0c16669b1e3d49"

URI_aarch64_rust-listenfd+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-listenfd+default-devel-1.0.2-1.el10_0.noarch.rpm;name=aarch64_rust-listenfd+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-listenfd+default-devel}"
SRC_URI[aarch64_rust-listenfd+default-devel.sha256sum] = "408ab6dac321d413754dc72eddccd5d9531780498ed924b94dd0d0596e591294"

URI_aarch64_rust-listenfd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-listenfd-devel-1.0.2-1.el10_0.noarch.rpm;name=aarch64_rust-listenfd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-listenfd-devel}"
SRC_URI[aarch64_rust-listenfd-devel.sha256sum] = "e43f9bbbbb3e445e4aa17b30ef908b4588305741737b877566d7256d79aca5fc"

RDEPENDS:rust-listenfd+default-devel = " \
 cargo \
 rust-listenfd-devel \
 "
RDEPENDS:rust-listenfd-devel = " \
 cargo \
 rust-libc+default-devel \
 "
