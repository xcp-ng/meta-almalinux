# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdeflate"
PV = "1.26"
PR = "1.el10_3"
PACKAGES = " \
 libdeflate \
 libdeflate-devel \
 libdeflate-utils \
 mingw32-libdeflate \
 mingw32-libdeflate-utils \
 mingw64-libdeflate \
 mingw64-libdeflate-utils \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libdeflate-1.26-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e59eede5db3d6e86ce779c373d0cda3da122ec62005afed26e49549f735d78b3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdeflate-1.26-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdeflate;unpack=0"
SRC_URI[x86_64_v2_libdeflate.sha256sum] = "668810bee70bea1529994a00e9d4be32dbc06b97c542d9957e8693237cc32328"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdeflate-devel-1.26-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdeflate-devel;unpack=0"
SRC_URI[x86_64_v2_libdeflate-devel.sha256sum] = "84f3b088b2c8f7b3006da95ee16ff6b7086c947fccc551232e82047381f7b690"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdeflate-utils-1.26-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdeflate-utils;unpack=0"
SRC_URI[x86_64_v2_libdeflate-utils.sha256sum] = "789604ea5f0da83411ed933cbff7bcbec3bf01ef76e6df52a7fba06e39d464e0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw32-libdeflate-1.26-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_mingw32-libdeflate;unpack=0"
SRC_URI[x86_64_v2_mingw32-libdeflate.sha256sum] = "9f2e5da22eb1e48d94abd4a16df92d34beba94db80e7fcb6a9591050b1018d8f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw32-libdeflate-utils-1.26-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_mingw32-libdeflate-utils;unpack=0"
SRC_URI[x86_64_v2_mingw32-libdeflate-utils.sha256sum] = "9558be4fdcbcb80ec6483d3903ef98320e23e2f1ef2c835bc74f0b87bf04e535"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw64-libdeflate-1.26-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_mingw64-libdeflate;unpack=0"
SRC_URI[x86_64_v2_mingw64-libdeflate.sha256sum] = "db0c5bc5c13e2e1ad028c6315e363e9e918a50b95c82d9481f7b36a4ac2e8797"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw64-libdeflate-utils-1.26-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_mingw64-libdeflate-utils;unpack=0"
SRC_URI[x86_64_v2_mingw64-libdeflate-utils.sha256sum] = "d6e4bc3014119565a142157a966305bb7c1003371b1b7bfde2cc62396ce24af7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libdeflate-1.26-1.el10_3.aarch64.rpm;name=aarch64_libdeflate;unpack=0"
SRC_URI[aarch64_libdeflate.sha256sum] = "243a2ee68b6341d5cda0b3a10d75c95b116b949de20c122180aa761c1b5392fa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libdeflate-devel-1.26-1.el10_3.aarch64.rpm;name=aarch64_libdeflate-devel;unpack=0"
SRC_URI[aarch64_libdeflate-devel.sha256sum] = "5f6f076830ee8ee82f5ee7d73b194886baac528cf3ad6e0d0bd81c32c1509580"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libdeflate-utils-1.26-1.el10_3.aarch64.rpm;name=aarch64_libdeflate-utils;unpack=0"
SRC_URI[aarch64_libdeflate-utils.sha256sum] = "cdd3718f68090853796ce22fb60284ae95a5e2d3ce7d2f01ba04df66f25201b5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/mingw32-libdeflate-1.26-1.el10_3.noarch.rpm;name=aarch64_mingw32-libdeflate;unpack=0"
SRC_URI[aarch64_mingw32-libdeflate.sha256sum] = "2af666d0a19f6e33768233ec56b817862ae534888fddc2cf26b91beab1e68966"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/mingw32-libdeflate-utils-1.26-1.el10_3.noarch.rpm;name=aarch64_mingw32-libdeflate-utils;unpack=0"
SRC_URI[aarch64_mingw32-libdeflate-utils.sha256sum] = "e8cb46988febe1191638076e70038db32647de45fd6de35b8094e89c175fb935"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/mingw64-libdeflate-1.26-1.el10_3.noarch.rpm;name=aarch64_mingw64-libdeflate;unpack=0"
SRC_URI[aarch64_mingw64-libdeflate.sha256sum] = "c8b40c7705c73489a160d6cbdbe769288922020a5d731ecf1ae68383a96b15eb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/mingw64-libdeflate-utils-1.26-1.el10_3.noarch.rpm;name=aarch64_mingw64-libdeflate-utils;unpack=0"
SRC_URI[aarch64_mingw64-libdeflate-utils.sha256sum] = "107a58474b85ca2c13a527355fd281ff4498ece16f206f468651045d7ed2b26b"

RDEPENDS:libdeflate = " \
 glibc \
 "
RDEPENDS:libdeflate-devel = " \
 cmake-filesystem \
 libdeflate \
 pkgconf-pkg-config \
 "
RDEPENDS:libdeflate-utils = " \
 glibc \
 libdeflate \
 "
RDEPENDS:mingw32-libdeflate = " \
 mingw32-crt \
 mingw32-filesystem \
 "
RDEPENDS:mingw32-libdeflate-utils = " \
 mingw32-crt \
 mingw32-filesystem \
 mingw32-libdeflate \
 "
RDEPENDS:mingw64-libdeflate = " \
 mingw64-crt \
 mingw64-filesystem \
 "
RDEPENDS:mingw64-libdeflate-utils = " \
 mingw64-crt \
 mingw64-filesystem \
 mingw64-libdeflate \
 "
