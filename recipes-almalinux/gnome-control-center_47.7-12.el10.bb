# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-control-center"
PV = "47.7"
PR = "12.el10"
PACKAGES = " \
 gnome-control-center \
 gnome-control-center-filesystem \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-control-center-47.7-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "faf52ce3fce7940aad2486fc2ddc1b4edb0cf078da679f3c95211754349fb80b"

URI_x86_64_v2_gnome-control-center = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-control-center-47.7-12.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-control-center;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-control-center}"
SRC_URI[x86_64_v2_gnome-control-center.sha256sum] = "a30d3348d3750e2eb24637b55c3230c9a7b2466c28ecf09e018bb499e5f1c92f"

URI_x86_64_v2_gnome-control-center-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-control-center-filesystem-47.7-12.el10.noarch.rpm;name=x86_64_v2_gnome-control-center-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-control-center-filesystem}"
SRC_URI[x86_64_v2_gnome-control-center-filesystem.sha256sum] = "7b6ad60ed8beb33e0917b6f5b1f38c4925bfbe3ebf6ae531f149d0440db5778a"

URI_aarch64_gnome-control-center = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-control-center-47.7-12.el10.aarch64.rpm;name=aarch64_gnome-control-center;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-control-center}"
SRC_URI[aarch64_gnome-control-center.sha256sum] = "90b7b44783d4cb0131a55c0388780a8ebb98db173d205e0c95649bb276939ae3"

URI_aarch64_gnome-control-center-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-control-center-filesystem-47.7-12.el10.noarch.rpm;name=aarch64_gnome-control-center-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-control-center-filesystem}"
SRC_URI[aarch64_gnome-control-center-filesystem.sha256sum] = "7b6ad60ed8beb33e0917b6f5b1f38c4925bfbe3ebf6ae531f149d0440db5778a"

RDEPENDS:gnome-control-center = " \
 ModemManager-glib \
 NetworkManager-libnm \
 accountsservice \
 accountsservice-libs \
 alsa-lib \
 cairo \
 colord \
 colord-gtk4 \
 colord-libs \
 cups-libs \
 cups-pk-helper \
 dbus \
 fontconfig \
 gcr-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gnome-bluetooth-libs \
 gnome-control-center-filesystem \
 gnome-desktop4 \
 gnome-online-accounts \
 gnome-settings-daemon \
 gnutls \
 graphene \
 gsettings-desktop-schemas \
 gsound \
 gtk4 \
 ibus-libs \
 iso-codes \
 json-glib \
 krb5-libs \
 libX11 \
 libXi \
 libadwaita \
 libepoxy \
 libgcc \
 libgtop2 \
 libgudev \
 libnma-gtk4 \
 libpwquality \
 libsecret \
 libsmbclient \
 libsoup3 \
 libudisks2 \
 libwacom \
 libxml2 \
 pango \
 pkgconf-pkg-config \
 polkit-libs \
 pulseaudio-libs \
 pulseaudio-libs-glib2 \
 tecla \
 upower \
 upower-libs \
 "
RDEPENDS:gnome-control-center-filesystem = " \
 "
