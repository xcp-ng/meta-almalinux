# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyphen-id"
PV = "0.20040812"
PR = "31.el10"
PACKAGES = " \
 hyphen-id \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyphen-id-0.20040812-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "06b404895760a39e69163baaeba1920d7ef98563426d1c90c17efd4c143493e9"

URI_x86_64_v2_hyphen-id = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-id-0.20040812-31.el10.noarch.rpm;name=x86_64_v2_hyphen-id;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyphen-id}"
SRC_URI[x86_64_v2_hyphen-id.sha256sum] = "aeb3586e56a31d972e6bd27deae22380a9b65ede7b440ad214163f1c2c1e3b95"

URI_aarch64_hyphen-id = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-id-0.20040812-31.el10.noarch.rpm;name=aarch64_hyphen-id;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyphen-id}"
SRC_URI[aarch64_hyphen-id.sha256sum] = "aeb3586e56a31d972e6bd27deae22380a9b65ede7b440ad214163f1c2c1e3b95"

RDEPENDS:hyphen-id = " \
 hyphen \
 "
