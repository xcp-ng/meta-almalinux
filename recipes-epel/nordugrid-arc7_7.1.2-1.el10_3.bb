# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nordugrid-arc7"
PV = "7.1.2"
PR = "1.el10_3"
PACKAGES = " \
 nordugrid-arc7 \
 nordugrid-arc7-arc-exporter \
 nordugrid-arc7-arcctl \
 nordugrid-arc7-arcctl-service \
 nordugrid-arc7-archery-manage \
 nordugrid-arc7-arex \
 nordugrid-arc7-arex-lrms-contrib \
 nordugrid-arc7-client \
 nordugrid-arc7-community-rtes \
 nordugrid-arc7-datadelivery-service \
 nordugrid-arc7-devel \
 nordugrid-arc7-hed \
 nordugrid-arc7-infosys-ldap \
 nordugrid-arc7-monitor \
 nordugrid-arc7-plugins-gfal \
 nordugrid-arc7-plugins-globus \
 nordugrid-arc7-plugins-globus-common \
 nordugrid-arc7-plugins-gridftp \
 nordugrid-arc7-plugins-internal \
 nordugrid-arc7-plugins-lcas-lcmaps \
 nordugrid-arc7-plugins-needed \
 nordugrid-arc7-plugins-python \
 nordugrid-arc7-plugins-s3 \
 nordugrid-arc7-plugins-xrootd \
 nordugrid-arc7-test-utils \
 nordugrid-arc7-wn \
 python3-arcrest \
 python3-nordugrid-arc7 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nordugrid-arc7-7.1.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04f39b17f79cf702f1cf163478fd4963958a0622478a0d54d9382a755bf6ce71"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - nordugrid-arc7-plugins-xrootd: libXrdCl.so.6()(64bit)
# - nordugrid-arc7-plugins-xrootd: libXrdPosix.so.6()(64bit)

URI_x86_64_v2_nordugrid-arc7 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-7.1.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7}"
SRC_URI[x86_64_v2_nordugrid-arc7.sha256sum] = "6e16cb1972b273b5510e574f647d625523f2ef01dbf949bf9ffb5622333cb2fb"

URI_x86_64_v2_nordugrid-arc7-arc-exporter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-arc-exporter-7.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc7-arc-exporter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-arc-exporter}"
SRC_URI[x86_64_v2_nordugrid-arc7-arc-exporter.sha256sum] = "08dd16324343a4232753bd3c855d4b6d9d5585b9c84d547ccdc32afc78f94e60"

URI_x86_64_v2_nordugrid-arc7-arcctl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-arcctl-7.1.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-arcctl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-arcctl}"
SRC_URI[x86_64_v2_nordugrid-arc7-arcctl.sha256sum] = "d1a0717ef1108102bc47b70cfd5bb871d7f9b4d651e2cb2bc89cb86ee657cf8e"

URI_x86_64_v2_nordugrid-arc7-arcctl-service = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-arcctl-service-7.1.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-arcctl-service;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-arcctl-service}"
SRC_URI[x86_64_v2_nordugrid-arc7-arcctl-service.sha256sum] = "faada588ae23ddd80a5b81cbafda88662a98a04f170b3fd75410b7bc0827805e"

URI_x86_64_v2_nordugrid-arc7-archery-manage = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-archery-manage-7.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc7-archery-manage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-archery-manage}"
SRC_URI[x86_64_v2_nordugrid-arc7-archery-manage.sha256sum] = "ff81e8f381b49ef06b9f2baf1ec4ca8c75c3fc82ed214df7af08965298f48b16"

URI_x86_64_v2_nordugrid-arc7-arex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-arex-7.1.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-arex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-arex}"
SRC_URI[x86_64_v2_nordugrid-arc7-arex.sha256sum] = "36e182c5f5b580eb3737ab7c0e53ec6523ebd1ebf226e973f0d4e85ca398d9fb"

URI_x86_64_v2_nordugrid-arc7-arex-lrms-contrib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-arex-lrms-contrib-7.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc7-arex-lrms-contrib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-arex-lrms-contrib}"
SRC_URI[x86_64_v2_nordugrid-arc7-arex-lrms-contrib.sha256sum] = "5d5c73619b8121527647c3c30d28628272ff0aa10a69b6d2e7391548c553c69f"

URI_x86_64_v2_nordugrid-arc7-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-client-7.1.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-client}"
SRC_URI[x86_64_v2_nordugrid-arc7-client.sha256sum] = "07a2d12e6d3f81ab284b3ecd32611051236332fac57c731bad7dcb27d0cac9b7"

URI_x86_64_v2_nordugrid-arc7-community-rtes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-community-rtes-7.1.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-community-rtes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-community-rtes}"
SRC_URI[x86_64_v2_nordugrid-arc7-community-rtes.sha256sum] = "5bba93e2f0f3c4438b4edb1ae093fe6f776900ad1b08d3ce97690b1a78365a9a"

URI_x86_64_v2_nordugrid-arc7-datadelivery-service = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-datadelivery-service-7.1.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-datadelivery-service;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-datadelivery-service}"
SRC_URI[x86_64_v2_nordugrid-arc7-datadelivery-service.sha256sum] = "e4d526107e99198e258c3b57e504b2b2b6f21eba63fcb4b4f043bd8ad94ddaed"

URI_x86_64_v2_nordugrid-arc7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-devel-7.1.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-devel}"
SRC_URI[x86_64_v2_nordugrid-arc7-devel.sha256sum] = "f600572871e4f045d4bd17721614ce585a75a0b9ff27ff3c463f32ccf151618e"

URI_x86_64_v2_nordugrid-arc7-hed = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-hed-7.1.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-hed;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-hed}"
SRC_URI[x86_64_v2_nordugrid-arc7-hed.sha256sum] = "bbc22f6c4841f477ac520c30fff0a4f87be174099cb7d401c176e81907f08010"

URI_x86_64_v2_nordugrid-arc7-infosys-ldap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-infosys-ldap-7.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc7-infosys-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-infosys-ldap}"
SRC_URI[x86_64_v2_nordugrid-arc7-infosys-ldap.sha256sum] = "6e784ea7c739e3b98d4577bcaa9fe60c105c55eba73e016b83b8b3616ab1ff2e"

URI_x86_64_v2_nordugrid-arc7-monitor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-monitor-7.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc7-monitor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-monitor}"
SRC_URI[x86_64_v2_nordugrid-arc7-monitor.sha256sum] = "72565824e9f1976ad3ca4502366c17865255df53a2e13d495721b909dbf68050"

URI_x86_64_v2_nordugrid-arc7-plugins-gfal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-gfal-7.1.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-gfal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-gfal}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-gfal.sha256sum] = "3e3045d32cf3fe14421b2dd5abc71e2676541d609530ebe3fc4855519566ed75"

URI_x86_64_v2_nordugrid-arc7-plugins-globus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-globus-7.1.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-globus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-globus}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-globus.sha256sum] = "5e92df19e98f173cc982a1a7adb17048da5ab4d71cb29c441870ec6d36b47fb0"

URI_x86_64_v2_nordugrid-arc7-plugins-globus-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-globus-common-7.1.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-globus-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-globus-common}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-globus-common.sha256sum] = "395392a5daea056056c34141b517744f95ae2eb6254f8ababa939f14b861397f"

URI_x86_64_v2_nordugrid-arc7-plugins-gridftp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-gridftp-7.1.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-gridftp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-gridftp}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-gridftp.sha256sum] = "67053c4c79f4ac7833753228491796e54fc29e5ce1912318de2e7162441525cb"

URI_x86_64_v2_nordugrid-arc7-plugins-internal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-internal-7.1.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-internal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-internal}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-internal.sha256sum] = "92010bb158a07a6eca3c367e3d6b695b3213c34cf2af66a7073e42411b6b2c11"

URI_x86_64_v2_nordugrid-arc7-plugins-lcas-lcmaps = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-lcas-lcmaps-7.1.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-lcas-lcmaps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-lcas-lcmaps}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-lcas-lcmaps.sha256sum] = "07c6daa45108156222fb55fd3e840f2b7b2af22a7057d252613626a802d12479"

URI_x86_64_v2_nordugrid-arc7-plugins-needed = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-needed-7.1.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-needed;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-needed}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-needed.sha256sum] = "5ba18cd1b48a0cd5e7836f4cbc206638ee8b03850e53bfa48783916b44fa5f60"

URI_x86_64_v2_nordugrid-arc7-plugins-python = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-python-7.1.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-python;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-python}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-python.sha256sum] = "9593f0c075ea7522d37c256ce1e7f17d1c6d841c87317a6ab302f0c44b0702d6"

URI_x86_64_v2_nordugrid-arc7-plugins-s3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-s3-7.1.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-s3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-s3}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-s3.sha256sum] = "a4932efeb2931e7c7da48f7e0ea66dc630cd290dbb481ef96da3e57f274b549f"

URI_x86_64_v2_nordugrid-arc7-plugins-xrootd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-xrootd-7.1.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-xrootd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-xrootd}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-xrootd.sha256sum] = "779250dfebe2f7295fb3d521f2a009a02b1a2c48c98cf58896df08845a9d4f95"

URI_x86_64_v2_nordugrid-arc7-test-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-test-utils-7.1.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-test-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-test-utils}"
SRC_URI[x86_64_v2_nordugrid-arc7-test-utils.sha256sum] = "ef5b4f6a1bdf6a53644208c367863cce68247fd6f9deb4d23e053c10b07b202b"

URI_x86_64_v2_nordugrid-arc7-wn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-wn-7.1.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-wn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-wn}"
SRC_URI[x86_64_v2_nordugrid-arc7-wn.sha256sum] = "abaca8f7ae90f69e576125985ece02e48e142f6d93ac9f0dd7444d070f1be7ca"

URI_x86_64_v2_python3-arcrest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-arcrest-7.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-arcrest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-arcrest}"
SRC_URI[x86_64_v2_python3-arcrest.sha256sum] = "4f4435237f646da94024aa13042e308946dc79695efe3f648760bfe0a7bd4088"

URI_x86_64_v2_python3-nordugrid-arc7 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-nordugrid-arc7-7.1.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-nordugrid-arc7;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-nordugrid-arc7}"
SRC_URI[x86_64_v2_python3-nordugrid-arc7.sha256sum] = "ea74f96d295b79c6bf6439700948705c96093a36a35f4af02eac8d2ad472dc68"

URI_aarch64_nordugrid-arc7 = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-7.1.2-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7}"
SRC_URI[aarch64_nordugrid-arc7.sha256sum] = "c0232935c63e8791a2aa194512515d0e0d98ad32a7b0a27fc4af17aa4f64b2b2"

URI_aarch64_nordugrid-arc7-arc-exporter = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-arc-exporter-7.1.2-1.el10_3.noarch.rpm;name=aarch64_nordugrid-arc7-arc-exporter;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-arc-exporter}"
SRC_URI[aarch64_nordugrid-arc7-arc-exporter.sha256sum] = "5527e18e818f9cee135f248220003e2912ae19525c2e38ccb238710b73da4aac"

URI_aarch64_nordugrid-arc7-arcctl = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-arcctl-7.1.2-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-arcctl;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-arcctl}"
SRC_URI[aarch64_nordugrid-arc7-arcctl.sha256sum] = "264c04633c1e51adaddd6b2125976042731591255da5bd1c7d098239fb818980"

URI_aarch64_nordugrid-arc7-arcctl-service = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-arcctl-service-7.1.2-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-arcctl-service;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-arcctl-service}"
SRC_URI[aarch64_nordugrid-arc7-arcctl-service.sha256sum] = "795955a5c3b076d304a16b5550d578cdffbfd6a04fb9bdb4afa73f3dbb2d04f8"

URI_aarch64_nordugrid-arc7-archery-manage = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-archery-manage-7.1.2-1.el10_3.noarch.rpm;name=aarch64_nordugrid-arc7-archery-manage;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-archery-manage}"
SRC_URI[aarch64_nordugrid-arc7-archery-manage.sha256sum] = "9e4224c0ffe87c462519e2273c223036bbc804740d152fcfb3a3a2761d8a3dbd"

URI_aarch64_nordugrid-arc7-arex = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-arex-7.1.2-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-arex;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-arex}"
SRC_URI[aarch64_nordugrid-arc7-arex.sha256sum] = "81bc19fe9e1b9f3bcd8ab759c51c6e885f62530531d0470d7b58ac0ea7fc827a"

URI_aarch64_nordugrid-arc7-arex-lrms-contrib = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-arex-lrms-contrib-7.1.2-1.el10_3.noarch.rpm;name=aarch64_nordugrid-arc7-arex-lrms-contrib;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-arex-lrms-contrib}"
SRC_URI[aarch64_nordugrid-arc7-arex-lrms-contrib.sha256sum] = "9d615a56b108e622050243cc3124c4656f4ed1a3115328caa5415b4dd88cd6ce"

URI_aarch64_nordugrid-arc7-client = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-client-7.1.2-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-client}"
SRC_URI[aarch64_nordugrid-arc7-client.sha256sum] = "2e210d460177a61c739050978ca56f42804403b9c91cf1f16d17c94f511d3adb"

URI_aarch64_nordugrid-arc7-community-rtes = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-community-rtes-7.1.2-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-community-rtes;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-community-rtes}"
SRC_URI[aarch64_nordugrid-arc7-community-rtes.sha256sum] = "a3c398e5c447b9edf5d5390b2b21a87121a35f4e2852db071b8c358a8805b4a6"

URI_aarch64_nordugrid-arc7-datadelivery-service = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-datadelivery-service-7.1.2-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-datadelivery-service;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-datadelivery-service}"
SRC_URI[aarch64_nordugrid-arc7-datadelivery-service.sha256sum] = "7f51e569fd32d1401d5942c1c4ca306ac9b381fd0b5850d501542015dd502140"

URI_aarch64_nordugrid-arc7-devel = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-devel-7.1.2-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-devel}"
SRC_URI[aarch64_nordugrid-arc7-devel.sha256sum] = "175c6721919c3387c032b306df93ce8a080aeae29a2f353a42ace113edd19f0d"

URI_aarch64_nordugrid-arc7-hed = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-hed-7.1.2-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-hed;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-hed}"
SRC_URI[aarch64_nordugrid-arc7-hed.sha256sum] = "553c146f76653166e15969a85b0012d4b93dab4ce46cf37b0c36749513d915e2"

URI_aarch64_nordugrid-arc7-infosys-ldap = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-infosys-ldap-7.1.2-1.el10_3.noarch.rpm;name=aarch64_nordugrid-arc7-infosys-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-infosys-ldap}"
SRC_URI[aarch64_nordugrid-arc7-infosys-ldap.sha256sum] = "99e590f8d3f237bae8d262aefd91bac9f5f46e51d108c3f41a2f563b3db9c515"

URI_aarch64_nordugrid-arc7-monitor = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-monitor-7.1.2-1.el10_3.noarch.rpm;name=aarch64_nordugrid-arc7-monitor;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-monitor}"
SRC_URI[aarch64_nordugrid-arc7-monitor.sha256sum] = "e29a035bd24787ee1271cb1d6faae5c769460913ab799bd6212af62f6c2cf0f7"

URI_aarch64_nordugrid-arc7-plugins-gfal = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-gfal-7.1.2-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-gfal;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-gfal}"
SRC_URI[aarch64_nordugrid-arc7-plugins-gfal.sha256sum] = "eb5ced0a5da84fad265539edf87df1c4c748589a631b442b761d68d5328d6495"

URI_aarch64_nordugrid-arc7-plugins-globus = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-globus-7.1.2-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-globus;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-globus}"
SRC_URI[aarch64_nordugrid-arc7-plugins-globus.sha256sum] = "fc3349c6c8a7e9d45d1fc70e6e6f0b52893d38774678258abc4032328e130bfc"

URI_aarch64_nordugrid-arc7-plugins-globus-common = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-globus-common-7.1.2-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-globus-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-globus-common}"
SRC_URI[aarch64_nordugrid-arc7-plugins-globus-common.sha256sum] = "2ca414063a4adfdf2ebcaaa1120e1333a29acb64acf9489e593a94574cccc291"

URI_aarch64_nordugrid-arc7-plugins-gridftp = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-gridftp-7.1.2-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-gridftp;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-gridftp}"
SRC_URI[aarch64_nordugrid-arc7-plugins-gridftp.sha256sum] = "1d6efd82019a3950e095f955dd09043b94dcb7e5749b1de26e5f0e3b556a0791"

URI_aarch64_nordugrid-arc7-plugins-internal = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-internal-7.1.2-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-internal;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-internal}"
SRC_URI[aarch64_nordugrid-arc7-plugins-internal.sha256sum] = "7abb5222f81d0f78f1c8a7e058f134599fd47d6bfe20772173337e1f30d1df19"

URI_aarch64_nordugrid-arc7-plugins-lcas-lcmaps = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-lcas-lcmaps-7.1.2-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-lcas-lcmaps;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-lcas-lcmaps}"
SRC_URI[aarch64_nordugrid-arc7-plugins-lcas-lcmaps.sha256sum] = "8d5b869b0c24d5bd8a85328b694e81576d9646c2b2819e0f8ed107c5d980c271"

URI_aarch64_nordugrid-arc7-plugins-needed = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-needed-7.1.2-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-needed;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-needed}"
SRC_URI[aarch64_nordugrid-arc7-plugins-needed.sha256sum] = "3106a33c4d32ecb8d1d53caa51d15a20fb95571457ae767932300ca5c03f6478"

URI_aarch64_nordugrid-arc7-plugins-python = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-python-7.1.2-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-python;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-python}"
SRC_URI[aarch64_nordugrid-arc7-plugins-python.sha256sum] = "5ba2d172af5ceac41b3c2d82dff11e884c0b1e280a64dbd828b9bd15f1171cbb"

URI_aarch64_nordugrid-arc7-plugins-s3 = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-s3-7.1.2-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-s3;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-s3}"
SRC_URI[aarch64_nordugrid-arc7-plugins-s3.sha256sum] = "58bf1064292a6ce0512cb6d058c4cd63410f86b73f3cc4300edde0996d2bef42"

URI_aarch64_nordugrid-arc7-plugins-xrootd = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-xrootd-7.1.2-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-xrootd;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-xrootd}"
SRC_URI[aarch64_nordugrid-arc7-plugins-xrootd.sha256sum] = "0731ddc7e57a6aad8219e2a0f5c235891cf34e4085a9bbb94de315a603c7780e"

URI_aarch64_nordugrid-arc7-test-utils = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-test-utils-7.1.2-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-test-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-test-utils}"
SRC_URI[aarch64_nordugrid-arc7-test-utils.sha256sum] = "11abd888d5931e869752c4f0aa9cfb0dd00514409eddb54955b4cb553332febb"

URI_aarch64_nordugrid-arc7-wn = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-wn-7.1.2-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-wn;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-wn}"
SRC_URI[aarch64_nordugrid-arc7-wn.sha256sum] = "67bbd5e2f4585b60c61ffa5a15175a0ac166cd7d8be564c3bca73ced0a268b82"

URI_aarch64_python3-arcrest = "${EPEL_MIRROR}/aarch64/Packages/p/python3-arcrest-7.1.2-1.el10_3.noarch.rpm;name=aarch64_python3-arcrest;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-arcrest}"
SRC_URI[aarch64_python3-arcrest.sha256sum] = "626589f1827e70329808c362b4d197758da5f8c3c0775d02a0553e7244b9ab63"

URI_aarch64_python3-nordugrid-arc7 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-nordugrid-arc7-7.1.2-1.el10_3.aarch64.rpm;name=aarch64_python3-nordugrid-arc7;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-nordugrid-arc7}"
SRC_URI[aarch64_python3-nordugrid-arc7.sha256sum] = "1bb38436a0cb100e2b5543810480e54c392bfc52cbb8dfb2ed52fcd2089adc7c"

RDEPENDS:nordugrid-arc7 = " \
 glib2 \
 glibc \
 glibmm2.68 \
 hostname \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nspr \
 nss \
 nss-util \
 openssl \
 openssl-libs \
 python3 \
 sqlite-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-arc-exporter = " \
 python3 \
 python3-prometheus_client \
 "
RDEPENDS:nordugrid-arc7-arcctl = " \
 nordugrid-arc7 \
 python3 \
 python3-jwcrypto \
 "
RDEPENDS:nordugrid-arc7-arcctl-service = " \
 nordugrid-arc7 \
 nordugrid-arc7-arcctl \
 python3 \
 "
RDEPENDS:nordugrid-arc7-archery-manage = " \
 python3 \
 python3-dns \
 python3-ldap \
 "
RDEPENDS:nordugrid-arc7-arex = " \
 bash \
 findutils \
 glib2 \
 glibc \
 glibmm2.68 \
 hostname \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 logrotate \
 nordugrid-arc7 \
 nordugrid-arc7-arcctl \
 nordugrid-arc7-arcctl-service \
 nordugrid-arc7-hed \
 nordugrid-arc7-plugins-needed \
 nspr \
 nss \
 nss-util \
 openssl \
 openssl-libs \
 perl-Data-Dumper \
 perl-Digest-SHA1 \
 perl-DirHandle \
 perl-English \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-JSON-XS \
 perl-MIME-Base64 \
 perl-POSIX \
 perl-PathTools \
 perl-Storable \
 perl-Sys-Hostname \
 perl-Time-Local \
 perl-XML-Simple \
 perl-base \
 perl-interpreter \
 perl-libs \
 perl-vars \
 procps-ng \
 python3 \
 sqlite-libs \
 systemd \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-arex-lrms-contrib = " \
 bash \
 nordugrid-arc7-arex \
 perl-DBI \
 perl-Data-Dumper \
 perl-Exporter \
 perl-POSIX \
 perl-Sys-Hostname \
 perl-XML-Simple \
 perl-libs \
 "
RDEPENDS:nordugrid-arc7-client = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 nordugrid-arc7 \
 nordugrid-arc7-plugins-needed \
 openssl-libs \
 "
RDEPENDS:nordugrid-arc7-community-rtes = " \
 gnupg2 \
 nordugrid-arc7-arcctl \
 nordugrid-arc7-arex \
 python3 \
 python3-dns \
 "
RDEPENDS:nordugrid-arc7-datadelivery-service = " \
 bash \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 logrotate \
 nordugrid-arc7 \
 nordugrid-arc7-arcctl-service \
 nordugrid-arc7-hed \
 nordugrid-arc7-plugins-needed \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 systemd \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-devel = " \
 glib2 \
 glibc \
 glibmm2.68 \
 glibmm2.68-devel \
 libgcc \
 libstdc++ \
 libxml2-devel \
 nordugrid-arc7 \
 openssl-devel \
 "
RDEPENDS:nordugrid-arc7-hed = " \
 bash \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 systemd \
 systemd-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-infosys-ldap = " \
 bash \
 bdii \
 glue-schema \
 logrotate \
 nordugrid-arc7-arcctl-service \
 openldap-servers \
 policycoreutils-python-utils \
 systemd \
 "
RDEPENDS:nordugrid-arc7-monitor = " \
 nordugrid-arc7 \
 virtual/php \
 virtual/php-gd \
 virtual/php-ldap \
 "
RDEPENDS:nordugrid-arc7-plugins-gfal = " \
 gfal2 \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libuuid \
 libxml2 \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-globus = " \
 nordugrid-arc7-plugins-gridftp \
 nordugrid-arc7-plugins-lcas-lcmaps \
 "
RDEPENDS:nordugrid-arc7-plugins-globus-common = " \
 glib2 \
 glibc \
 glibmm2.68 \
 globus-common \
 globus-gsi-callback \
 globus-gssapi-gsi \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libuuid \
 libxml2 \
 nordugrid-arc7 \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-gridftp = " \
 glib2 \
 glibc \
 glibmm2.68 \
 globus-common \
 globus-ftp-client \
 globus-ftp-control \
 globus-io \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libuuid \
 libxml2 \
 nordugrid-arc7 \
 nordugrid-arc7-plugins-globus-common \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-internal = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nordugrid-arc7 \
 nordugrid-arc7-arex \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 sqlite-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-lcas-lcmaps = " \
 glibc \
 glibmm2.68 \
 globus-common \
 globus-gsi-cert-utils \
 globus-gsi-credential \
 globus-gssapi-gsi \
 libgcc \
 libstdc++ \
 nordugrid-arc7 \
 nordugrid-arc7-plugins-globus-common \
 openssl-libs \
 "
RDEPENDS:nordugrid-arc7-plugins-needed = " \
 glib2 \
 glibc \
 glibmm2.68 \
 ldns \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 sqlite-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-python = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 python3-libs \
 python3-nordugrid-arc7 \
 sqlite-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-s3 = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libs3 \
 libsigc++30 \
 libstdc++ \
 libuuid \
 libxml2 \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-xrootd:x86_64_v2 = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libuuid \
 libxml2 \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 zlib-ng-compat \
"
RDEPENDS:nordugrid-arc7-plugins-xrootd:aarch64 = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libuuid \
 libxml2 \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 xrootd-client-libs \
 zlib-ng-compat \
"
RDEPENDS:nordugrid-arc7-test-utils = " \
 glibc \
 libgcc \
 libsigc++30 \
 libstdc++ \
 nordugrid-arc7 \
 nordugrid-arc7-plugins-needed \
 "
RDEPENDS:nordugrid-arc7-wn = " \
 glibc \
 "
RDEPENDS:python3-arcrest = " \
 python3 \
 python3-cryptography \
 "
RDEPENDS:python3-nordugrid-arc7 = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 python3 \
 python3-libs \
 sqlite-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
