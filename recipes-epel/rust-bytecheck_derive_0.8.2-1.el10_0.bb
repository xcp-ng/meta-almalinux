# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bytecheck_derive"
PV = "0.8.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-bytecheck_derive+default-devel \
 rust-bytecheck_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bytecheck_derive-0.8.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f420fe64de1b80265d80b68c43d3fdb25c18d185d2543236f28c2d62a6e0c1b5"

URI_x86_64_v2_rust-bytecheck_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecheck_derive+default-devel-0.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecheck_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecheck_derive+default-devel}"
SRC_URI[x86_64_v2_rust-bytecheck_derive+default-devel.sha256sum] = "49892085e34b45023cd83637f71d54a5ddab3d367ff244971f4938eb4424a090"

URI_x86_64_v2_rust-bytecheck_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecheck_derive-devel-0.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecheck_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecheck_derive-devel}"
SRC_URI[x86_64_v2_rust-bytecheck_derive-devel.sha256sum] = "c9b8220a2e6e9c98c792717919ffb8cafdbb55898b9b433181aa5cdc23399f68"

URI_aarch64_rust-bytecheck_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecheck_derive+default-devel-0.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-bytecheck_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecheck_derive+default-devel}"
SRC_URI[aarch64_rust-bytecheck_derive+default-devel.sha256sum] = "c0c79e8fd256cc30727b9a2468f4856b1262e9732bc2c7b02ef6d597dbf9e734"

URI_aarch64_rust-bytecheck_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecheck_derive-devel-0.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-bytecheck_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecheck_derive-devel}"
SRC_URI[aarch64_rust-bytecheck_derive-devel.sha256sum] = "b2e7a1077d6c793cf6890446414f002c5e7ef5ea461ee5229350e8bab8e3a3e8"

RDEPENDS:rust-bytecheck_derive+default-devel = " \
 cargo \
 rust-bytecheck_derive-devel \
 "
RDEPENDS:rust-bytecheck_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
