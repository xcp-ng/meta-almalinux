# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-peterbourgon-diskv"
PV = "3.0.1"
PR = "4.el10_0"
PACKAGES = " \
 compat-golang-github-peterbourgon-diskv-3-devel \
 golang-github-peterbourgon-diskv-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-peterbourgon-diskv-3.0.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64245d5eb25e3b62945e983d88e8a346db96f20655396de8592d8564a005bcdd"

URI_x86_64_v2_compat-golang-github-peterbourgon-diskv-3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/compat-golang-github-peterbourgon-diskv-3-devel-3.0.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_compat-golang-github-peterbourgon-diskv-3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_compat-golang-github-peterbourgon-diskv-3-devel}"
SRC_URI[x86_64_v2_compat-golang-github-peterbourgon-diskv-3-devel.sha256sum] = "a8e14f017df565c6ec01b726ada1f640dfdf1537064bf6a6509e69a7165fce8d"

URI_x86_64_v2_golang-github-peterbourgon-diskv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-peterbourgon-diskv-devel-3.0.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-peterbourgon-diskv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-peterbourgon-diskv-devel}"
SRC_URI[x86_64_v2_golang-github-peterbourgon-diskv-devel.sha256sum] = "07acf817803964e72514b4776551bf0dcc6001f7353191dea717460d6666199c"

URI_aarch64_compat-golang-github-peterbourgon-diskv-3-devel = "${EPEL_MIRROR}/aarch64/Packages/c/compat-golang-github-peterbourgon-diskv-3-devel-3.0.1-4.el10_0.noarch.rpm;name=aarch64_compat-golang-github-peterbourgon-diskv-3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_compat-golang-github-peterbourgon-diskv-3-devel}"
SRC_URI[aarch64_compat-golang-github-peterbourgon-diskv-3-devel.sha256sum] = "50ce0eca27d9cfc457c1180fe01bcc0519d53795210a184eba55148f88c82dbd"

URI_aarch64_golang-github-peterbourgon-diskv-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-peterbourgon-diskv-devel-3.0.1-4.el10_0.noarch.rpm;name=aarch64_golang-github-peterbourgon-diskv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-peterbourgon-diskv-devel}"
SRC_URI[aarch64_golang-github-peterbourgon-diskv-devel.sha256sum] = "c46c4e34fc65e7ba8a2801519c78079147cb8cae42947b2012a07fbdcc1333a6"

RDEPENDS:compat-golang-github-peterbourgon-diskv-3-devel = " \
 go-filesystem \
 golang-github-peterbourgon-diskv-devel \
 "
RDEPENDS:golang-github-peterbourgon-diskv-devel = " \
 go-filesystem \
 golang-github-google-btree-devel \
 "
