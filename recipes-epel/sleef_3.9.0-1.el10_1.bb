# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sleef"
PV = "3.9.0"
PR = "1.el10_1"
PACKAGES = " \
 sleef \
 sleef-devel \
 sleef-dft \
 sleef-dft-devel \
 sleef-doc \
 sleef-gnuabi \
 sleef-gnuabi-devel \
 sleef-quad \
 sleef-quad-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sleef-3.9.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3a9eb788f7a9eabf78d6eefe4c499af9899544950e24274a76f05b9035a9a25"

URI_x86_64_v2_sleef = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sleef-3.9.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sleef;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sleef}"
SRC_URI[x86_64_v2_sleef.sha256sum] = "ce29153859e17ec47bf3dcb796e0618fd200350208abcaffb812a5fa3981b9ef"

URI_x86_64_v2_sleef-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sleef-devel-3.9.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sleef-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sleef-devel}"
SRC_URI[x86_64_v2_sleef-devel.sha256sum] = "b219e72e0c230e71387c1d237d7909210f93399aa333154d5083ddb00df363b9"

URI_x86_64_v2_sleef-dft = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sleef-dft-3.9.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sleef-dft;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sleef-dft}"
SRC_URI[x86_64_v2_sleef-dft.sha256sum] = "b52b20978f2447cc0ed24554b59358f4f034fc58f30d9a725a5421873fc7e8b5"

URI_x86_64_v2_sleef-dft-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sleef-dft-devel-3.9.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sleef-dft-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sleef-dft-devel}"
SRC_URI[x86_64_v2_sleef-dft-devel.sha256sum] = "4133963ad106ce9f14224dd6c7a9f1efc5cfecab88a3925cc4ce6c2473c74ed9"

URI_x86_64_v2_sleef-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sleef-doc-3.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_sleef-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sleef-doc}"
SRC_URI[x86_64_v2_sleef-doc.sha256sum] = "48a18c724a92b8c40c0b688b77f938e7a1d6784eb4b976220238954404a83318"

URI_x86_64_v2_sleef-gnuabi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sleef-gnuabi-3.9.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sleef-gnuabi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sleef-gnuabi}"
SRC_URI[x86_64_v2_sleef-gnuabi.sha256sum] = "5cdc436078cbc2eff56a0255ab4fe63669a4e0fc146850fd5bb6f9045c2a3e9c"

URI_x86_64_v2_sleef-gnuabi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sleef-gnuabi-devel-3.9.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sleef-gnuabi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sleef-gnuabi-devel}"
SRC_URI[x86_64_v2_sleef-gnuabi-devel.sha256sum] = "e0e8021376486185b036610cacd2a1f203bf6dc4b2502cfc947cafa38e4feafd"

URI_x86_64_v2_sleef-quad = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sleef-quad-3.9.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sleef-quad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sleef-quad}"
SRC_URI[x86_64_v2_sleef-quad.sha256sum] = "22f63573eec581b0f4ee0f6264e073410c495ab8f2ddedff8a0091bd902bb955"

URI_x86_64_v2_sleef-quad-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sleef-quad-devel-3.9.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sleef-quad-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sleef-quad-devel}"
SRC_URI[x86_64_v2_sleef-quad-devel.sha256sum] = "2fcfa1916678e11dfa79fad1f0f859f052397a9d9b2055f8d3d7cbf0e620a26f"

URI_aarch64_sleef = "${EPEL_MIRROR}/aarch64/Packages/s/sleef-3.9.0-1.el10_1.aarch64.rpm;name=aarch64_sleef;unpack=0"
SRC_URI:append = " ${URI_aarch64_sleef}"
SRC_URI[aarch64_sleef.sha256sum] = "4a0baae8556c7fff13f1c5f24c90a003a067d8fc64076578c0cdad967bf91e8c"

URI_aarch64_sleef-devel = "${EPEL_MIRROR}/aarch64/Packages/s/sleef-devel-3.9.0-1.el10_1.aarch64.rpm;name=aarch64_sleef-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sleef-devel}"
SRC_URI[aarch64_sleef-devel.sha256sum] = "792fe21544cc25af9912c212cf5ca9f2a170b7c79494a9c63089eea52e1bf592"

URI_aarch64_sleef-dft = "${EPEL_MIRROR}/aarch64/Packages/s/sleef-dft-3.9.0-1.el10_1.aarch64.rpm;name=aarch64_sleef-dft;unpack=0"
SRC_URI:append = " ${URI_aarch64_sleef-dft}"
SRC_URI[aarch64_sleef-dft.sha256sum] = "d92e3fc02b78811eb7af2f8ab4b55db01a05e1cfaf4d884b8b2043db60266fba"

URI_aarch64_sleef-dft-devel = "${EPEL_MIRROR}/aarch64/Packages/s/sleef-dft-devel-3.9.0-1.el10_1.aarch64.rpm;name=aarch64_sleef-dft-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sleef-dft-devel}"
SRC_URI[aarch64_sleef-dft-devel.sha256sum] = "bc5260ae3abcd064767624d99f58d45f74a6dbf31fb7d3e890d5128ae87dcd73"

URI_aarch64_sleef-doc = "${EPEL_MIRROR}/aarch64/Packages/s/sleef-doc-3.9.0-1.el10_1.noarch.rpm;name=aarch64_sleef-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_sleef-doc}"
SRC_URI[aarch64_sleef-doc.sha256sum] = "82dbf91679cab9380c4068d93c256b8a52be44d25ce329ea35f7a4d02345110d"

URI_aarch64_sleef-gnuabi = "${EPEL_MIRROR}/aarch64/Packages/s/sleef-gnuabi-3.9.0-1.el10_1.aarch64.rpm;name=aarch64_sleef-gnuabi;unpack=0"
SRC_URI:append = " ${URI_aarch64_sleef-gnuabi}"
SRC_URI[aarch64_sleef-gnuabi.sha256sum] = "43270aab9f79732361fc7d62e2ee81eb0dc8d62acbadf0ada32dd3a9920e9ec7"

URI_aarch64_sleef-gnuabi-devel = "${EPEL_MIRROR}/aarch64/Packages/s/sleef-gnuabi-devel-3.9.0-1.el10_1.aarch64.rpm;name=aarch64_sleef-gnuabi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sleef-gnuabi-devel}"
SRC_URI[aarch64_sleef-gnuabi-devel.sha256sum] = "439adb4976e0903dec97af02eb1ab880980d6467cefba53ca227d5008dea84d9"

URI_aarch64_sleef-quad = "${EPEL_MIRROR}/aarch64/Packages/s/sleef-quad-3.9.0-1.el10_1.aarch64.rpm;name=aarch64_sleef-quad;unpack=0"
SRC_URI:append = " ${URI_aarch64_sleef-quad}"
SRC_URI[aarch64_sleef-quad.sha256sum] = "adff13eab3cc1b5b4529e2ca70770cada30611482da42f9c4c224789c641dca3"

URI_aarch64_sleef-quad-devel = "${EPEL_MIRROR}/aarch64/Packages/s/sleef-quad-devel-3.9.0-1.el10_1.aarch64.rpm;name=aarch64_sleef-quad-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sleef-quad-devel}"
SRC_URI[aarch64_sleef-quad-devel.sha256sum] = "d48091a967a23d4a36c23be15fe28591708b370a513c312137431c865537aca8"

RDEPENDS:sleef = " \
 glibc \
 "
RDEPENDS:sleef-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 sleef \
 "
RDEPENDS:sleef-dft = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 sleef \
 "
RDEPENDS:sleef-dft-devel = " \
 sleef-dft \
 "
RDEPENDS:sleef-doc = " \
 "
RDEPENDS:sleef-gnuabi = " \
 glibc \
 "
RDEPENDS:sleef-gnuabi-devel = " \
 sleef-gnuabi \
 "
RDEPENDS:sleef-quad = " \
 glibc \
 "
RDEPENDS:sleef-quad-devel = " \
 sleef-quad \
 "
