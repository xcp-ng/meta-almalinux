# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-python-multipart"
PV = "0.0.27"
PR = "1.el10_1"
PACKAGES = " \
 python3-python-multipart \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-python-multipart-0.0.27-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b5f98734c2f25328c353fa58eb0b3f3c53fa24d57c038caed8bf7e0c1b84664d"

URI_x86_64_v2_python3-python-multipart = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-python-multipart-0.0.27-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-python-multipart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-python-multipart}"
SRC_URI[x86_64_v2_python3-python-multipart.sha256sum] = "d703254bce81956a7c87f3e8bc04fd7a58571b724026de73cfc8b4e72b3c69e3"

URI_aarch64_python3-python-multipart = "${EPEL_MIRROR}/aarch64/Packages/p/python3-python-multipart-0.0.27-1.el10_1.noarch.rpm;name=aarch64_python3-python-multipart;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-python-multipart}"
SRC_URI[aarch64_python3-python-multipart.sha256sum] = "5e64dd0d7be4ee0ed2ab0998b02c3c98ba22eba61a1991f32343f655d512e3a2"

RDEPENDS:python3-python-multipart = " \
 python3 \
 "
