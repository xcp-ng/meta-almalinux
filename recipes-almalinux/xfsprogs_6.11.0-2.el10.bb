# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xfsprogs"
PV = "6.11.0"
PR = "2.el10"
PACKAGES = " \
 xfsprogs \
 xfsprogs-devel \
 xfsprogs-xfs_scrub \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/xfsprogs-6.11.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8183163e6435d68cd469be14e35ee946a1a53b8bbbbf85b49cfd4f97141117b3"

URI_x86_64_v2_xfsprogs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/xfsprogs-6.11.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_xfsprogs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xfsprogs}"
SRC_URI[x86_64_v2_xfsprogs.sha256sum] = "fb2c0f3756a189b78f2d841157ca3d8b7f526445282f5ec36adb5d64db520dd4"

URI_x86_64_v2_xfsprogs-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xfsprogs-devel-6.11.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_xfsprogs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xfsprogs-devel}"
SRC_URI[x86_64_v2_xfsprogs-devel.sha256sum] = "d61f5f4d8f8e083425c912e0ab1f9cf9db98dfb1ed541cd938f40de147c6b1ab"

URI_x86_64_v2_xfsprogs-xfs_scrub = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xfsprogs-xfs_scrub-6.11.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_xfsprogs-xfs_scrub;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xfsprogs-xfs_scrub}"
SRC_URI[x86_64_v2_xfsprogs-xfs_scrub.sha256sum] = "f0571b302af10a0eae9d5d65bff90095e2b93a324595e71db8c6162e7f23536e"

URI_aarch64_xfsprogs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/xfsprogs-6.11.0-2.el10.aarch64.rpm;name=aarch64_xfsprogs;unpack=0"
SRC_URI:append = " ${URI_aarch64_xfsprogs}"
SRC_URI[aarch64_xfsprogs.sha256sum] = "fe0c15a95b15b7ff2ce6853f4e940284e74e8ad17542e920dd30f84e556e0bec"

URI_aarch64_xfsprogs-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xfsprogs-devel-6.11.0-2.el10.aarch64.rpm;name=aarch64_xfsprogs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xfsprogs-devel}"
SRC_URI[aarch64_xfsprogs-devel.sha256sum] = "c2f4a1dbf192f22176e9041169cd2dcb2009dd2b804f37a07621a48ee724c9e1"

URI_aarch64_xfsprogs-xfs_scrub = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xfsprogs-xfs_scrub-6.11.0-2.el10.aarch64.rpm;name=aarch64_xfsprogs-xfs_scrub;unpack=0"
SRC_URI:append = " ${URI_aarch64_xfsprogs-xfs_scrub}"
SRC_URI[aarch64_xfsprogs-xfs_scrub.sha256sum] = "b5c4c7f1dc1a48186daf50994c6e5c1aa1fd6e53c39f1d07212238d1e347ac57"

RDEPENDS:xfsprogs = " \
 bash \
 glibc \
 inih \
 libblkid \
 libedit \
 libuuid \
 userspace-rcu \
 "
RDEPENDS:xfsprogs-devel = " \
 libuuid-devel \
 xfsprogs \
 "
RDEPENDS:xfsprogs-xfs_scrub = " \
 bash \
 glibc \
 libicu \
 python3 \
 userspace-rcu \
 util-linux \
 xfsprogs \
 "
