# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-png"
PV = "0.18.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-png+default-devel \
 rust-png+zlib-rs-devel \
 rust-png-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-png-0.18.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1afdcc8ff2efe2395b573cfe701056af7c729e2f3043775d9ef53995722a7715"

URI_x86_64_v2_rust-png+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-png+default-devel-0.18.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-png+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-png+default-devel}"
SRC_URI[x86_64_v2_rust-png+default-devel.sha256sum] = "129657ecf1c143e8c407f993f2e692aa8358014e15c7295ba54dc8c35cd2b227"

URI_x86_64_v2_rust-png+zlib-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-png+zlib-rs-devel-0.18.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-png+zlib-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-png+zlib-rs-devel}"
SRC_URI[x86_64_v2_rust-png+zlib-rs-devel.sha256sum] = "74f52c6b58aa368b39bc454f12a8ea13a348747b6cb679aff501c47f2ecec3ef"

URI_x86_64_v2_rust-png-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-png-devel-0.18.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-png-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-png-devel}"
SRC_URI[x86_64_v2_rust-png-devel.sha256sum] = "313f40e66281448d6cd55ebf845e77c63c5920ba536cd20bf254248fdf1b41d5"

URI_aarch64_rust-png+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-png+default-devel-0.18.1-1.el10_2.noarch.rpm;name=aarch64_rust-png+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-png+default-devel}"
SRC_URI[aarch64_rust-png+default-devel.sha256sum] = "c30894f48db03e1604995d248134070985d725a0e801fac2992d33c183e54ccc"

URI_aarch64_rust-png+zlib-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-png+zlib-rs-devel-0.18.1-1.el10_2.noarch.rpm;name=aarch64_rust-png+zlib-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-png+zlib-rs-devel}"
SRC_URI[aarch64_rust-png+zlib-rs-devel.sha256sum] = "08c52c58cf13fca58ad3e80724c9fe48394f4ec10536286e70f637ba331fbf0e"

URI_aarch64_rust-png-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-png-devel-0.18.1-1.el10_2.noarch.rpm;name=aarch64_rust-png-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-png-devel}"
SRC_URI[aarch64_rust-png-devel.sha256sum] = "1696ef483c9709e93cc8a21eb2484cb1d92a3fce930c8db1e34e0ecb0c8d5bae"

RDEPENDS:rust-png+default-devel = " \
 cargo \
 rust-png-devel \
 "
RDEPENDS:rust-png+zlib-rs-devel = " \
 cargo \
 rust-flate2+zlib-rs-devel \
 rust-png-devel \
 "
RDEPENDS:rust-png-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-crc32fast+default-devel \
 rust-fdeflate+default-devel \
 rust-flate2+default-devel \
 rust-miniz_oxide0.8+default-devel \
 rust-miniz_oxide0.8+simd-devel \
 "
