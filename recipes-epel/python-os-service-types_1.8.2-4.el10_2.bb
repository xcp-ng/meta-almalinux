# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-os-service-types"
PV = "1.8.2"
PR = "4.el10_2"
PACKAGES = " \
 python-os-service-types-doc \
 python3-os-service-types \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-os-service-types-1.8.2-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd98c9f48871090bd9d24ba446c4a05d4946f3fe18e5b85be52c8a8eafdbbca5"

URI_x86_64_v2_python-os-service-types-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-os-service-types-doc-1.8.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-os-service-types-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-os-service-types-doc}"
SRC_URI[x86_64_v2_python-os-service-types-doc.sha256sum] = "a1b72fe53f2c91f4fc09386da460f30f900f2aec99c0ade50af65304a1539a85"

URI_x86_64_v2_python3-os-service-types = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-os-service-types-1.8.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-os-service-types;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-os-service-types}"
SRC_URI[x86_64_v2_python3-os-service-types.sha256sum] = "e6c2bafc22db26185d4e0e29f7e03eabc69a13de3a053efeebd3c0bfabfe1681"

URI_aarch64_python-os-service-types-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-os-service-types-doc-1.8.2-4.el10_2.noarch.rpm;name=aarch64_python-os-service-types-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-os-service-types-doc}"
SRC_URI[aarch64_python-os-service-types-doc.sha256sum] = "5a0dfae9d3ae285a4e43c7820798da5355e4b856b4492d6f0da92d80b47c86e7"

URI_aarch64_python3-os-service-types = "${EPEL_MIRROR}/aarch64/Packages/p/python3-os-service-types-1.8.2-4.el10_2.noarch.rpm;name=aarch64_python3-os-service-types;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-os-service-types}"
SRC_URI[aarch64_python3-os-service-types.sha256sum] = "02bb6d0ce3290de8d0694581626c17aae5da481718b900767be5e9f3e483af7c"

RDEPENDS:python-os-service-types-doc = " \
 python3-os-service-types \
 "
RDEPENDS:python3-os-service-types = " \
 python3 \
 python3-pbr \
 python3-typing-extensions \
 "
