# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-jiff"
PV = "0.2.35"
PR = "1.el10_3"
PACKAGES = " \
 rust-jiff+alloc-devel \
 rust-jiff+default-devel \
 rust-jiff+logging-devel \
 rust-jiff+perf-inline-devel \
 rust-jiff+serde-devel \
 rust-jiff+std-devel \
 rust-jiff+tz-fat-devel \
 rust-jiff+tz-system-devel \
 rust-jiff+tzdb-bundle-platform-devel \
 rust-jiff+tzdb-concatenated-devel \
 rust-jiff+tzdb-zoneinfo-devel \
 rust-jiff-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-jiff-0.2.35-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6e3cf35f6f9fb3bebc404c50953131f502d7284bd22586834e5db813a1a6901"

URI_x86_64_v2_rust-jiff+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+alloc-devel-0.2.35-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+alloc-devel}"
SRC_URI[x86_64_v2_rust-jiff+alloc-devel.sha256sum] = "690464824fd8977a8b600caf5210099607ae6f891f59af2e2fbd6de64b8e894d"

URI_x86_64_v2_rust-jiff+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+default-devel-0.2.35-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+default-devel}"
SRC_URI[x86_64_v2_rust-jiff+default-devel.sha256sum] = "32c53c77255bb6e9398cb494d3d2d9fa1e936a8c0f0d8642d3ac3f6a733e1240"

URI_x86_64_v2_rust-jiff+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+logging-devel-0.2.35-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+logging-devel}"
SRC_URI[x86_64_v2_rust-jiff+logging-devel.sha256sum] = "1d6140a479ec81603f86367990c4f2adaada373b783308e00c699e3bbadd0578"

URI_x86_64_v2_rust-jiff+perf-inline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+perf-inline-devel-0.2.35-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+perf-inline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+perf-inline-devel}"
SRC_URI[x86_64_v2_rust-jiff+perf-inline-devel.sha256sum] = "b4e302bd1dfcf310fd896e88a830628e9a13e93b85522b1416b6d8461bfba056"

URI_x86_64_v2_rust-jiff+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+serde-devel-0.2.35-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+serde-devel}"
SRC_URI[x86_64_v2_rust-jiff+serde-devel.sha256sum] = "042f2e4a6c58550354112a363e7716be29d9b06204263f8daf4b43d4ab12276c"

URI_x86_64_v2_rust-jiff+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+std-devel-0.2.35-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+std-devel}"
SRC_URI[x86_64_v2_rust-jiff+std-devel.sha256sum] = "2d31ca6af2f964520b41355f64234585585147fc19fd37df550166f783c8442a"

URI_x86_64_v2_rust-jiff+tz-fat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+tz-fat-devel-0.2.35-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+tz-fat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+tz-fat-devel}"
SRC_URI[x86_64_v2_rust-jiff+tz-fat-devel.sha256sum] = "860f4fa464f60f4109d3d74681c6bf89c84a36d7f54a38089cfaca073825a42f"

URI_x86_64_v2_rust-jiff+tz-system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+tz-system-devel-0.2.35-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+tz-system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+tz-system-devel}"
SRC_URI[x86_64_v2_rust-jiff+tz-system-devel.sha256sum] = "62fa38639d531668d63af329a708d6b81ca2e0439839aa79405469f01a0f80ed"

URI_x86_64_v2_rust-jiff+tzdb-bundle-platform-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+tzdb-bundle-platform-devel-0.2.35-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+tzdb-bundle-platform-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+tzdb-bundle-platform-devel}"
SRC_URI[x86_64_v2_rust-jiff+tzdb-bundle-platform-devel.sha256sum] = "164421fbd21af9f2d42641be6a2e1ce1b977377be40ef4958838e03c0ab12317"

URI_x86_64_v2_rust-jiff+tzdb-concatenated-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+tzdb-concatenated-devel-0.2.35-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+tzdb-concatenated-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+tzdb-concatenated-devel}"
SRC_URI[x86_64_v2_rust-jiff+tzdb-concatenated-devel.sha256sum] = "30ec8f98176c621531ec9c26ff3714d07cf814d985c0a738a948248602eea69f"

URI_x86_64_v2_rust-jiff+tzdb-zoneinfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+tzdb-zoneinfo-devel-0.2.35-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+tzdb-zoneinfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+tzdb-zoneinfo-devel}"
SRC_URI[x86_64_v2_rust-jiff+tzdb-zoneinfo-devel.sha256sum] = "1b3c827ddc97fc0d6c96547e275e7829718a24f1d21e8f87f142f524a0c2bf3a"

URI_x86_64_v2_rust-jiff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff-devel-0.2.35-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff-devel}"
SRC_URI[x86_64_v2_rust-jiff-devel.sha256sum] = "0e7cf590c65d8e6063e549cc5e5c176807008d7a16b050c7801bd1a22aa55e84"

URI_aarch64_rust-jiff+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+alloc-devel-0.2.35-1.el10_3.noarch.rpm;name=aarch64_rust-jiff+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+alloc-devel}"
SRC_URI[aarch64_rust-jiff+alloc-devel.sha256sum] = "a098e39c3bdcde02690289d9cd925500abb48d197e9386de504bb353aa9aeaae"

URI_aarch64_rust-jiff+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+default-devel-0.2.35-1.el10_3.noarch.rpm;name=aarch64_rust-jiff+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+default-devel}"
SRC_URI[aarch64_rust-jiff+default-devel.sha256sum] = "296ed5f35be4d83f0fff6803764c4460b5b7725ca45e1e027f90b61899ac698f"

URI_aarch64_rust-jiff+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+logging-devel-0.2.35-1.el10_3.noarch.rpm;name=aarch64_rust-jiff+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+logging-devel}"
SRC_URI[aarch64_rust-jiff+logging-devel.sha256sum] = "da1f428b13107e9dc149b165bdc2f14b491362e443fb109fa78fc0d3da3003cf"

URI_aarch64_rust-jiff+perf-inline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+perf-inline-devel-0.2.35-1.el10_3.noarch.rpm;name=aarch64_rust-jiff+perf-inline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+perf-inline-devel}"
SRC_URI[aarch64_rust-jiff+perf-inline-devel.sha256sum] = "2db8e7603d3587045b8b80addb11fa695f59624551bae76e54ac17a92298af85"

URI_aarch64_rust-jiff+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+serde-devel-0.2.35-1.el10_3.noarch.rpm;name=aarch64_rust-jiff+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+serde-devel}"
SRC_URI[aarch64_rust-jiff+serde-devel.sha256sum] = "7d69956a7aa78beb72a0d1a584e8b0bdf75f546d45d5db9b22676b181f9c334b"

URI_aarch64_rust-jiff+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+std-devel-0.2.35-1.el10_3.noarch.rpm;name=aarch64_rust-jiff+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+std-devel}"
SRC_URI[aarch64_rust-jiff+std-devel.sha256sum] = "6f33e3eda1afb9ae1550a078a5aeca3fc31755e0d006cb7b6aae7ee8398aba9d"

URI_aarch64_rust-jiff+tz-fat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+tz-fat-devel-0.2.35-1.el10_3.noarch.rpm;name=aarch64_rust-jiff+tz-fat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+tz-fat-devel}"
SRC_URI[aarch64_rust-jiff+tz-fat-devel.sha256sum] = "e8524b693f1681d3af558c7835aaf70e1f813f4866a0c920b81c51059698bb3c"

URI_aarch64_rust-jiff+tz-system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+tz-system-devel-0.2.35-1.el10_3.noarch.rpm;name=aarch64_rust-jiff+tz-system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+tz-system-devel}"
SRC_URI[aarch64_rust-jiff+tz-system-devel.sha256sum] = "77323f4a006a58f9ecf973864d15f7bbe5db8cabf0a848f496bf751cdb4d6a1d"

URI_aarch64_rust-jiff+tzdb-bundle-platform-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+tzdb-bundle-platform-devel-0.2.35-1.el10_3.noarch.rpm;name=aarch64_rust-jiff+tzdb-bundle-platform-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+tzdb-bundle-platform-devel}"
SRC_URI[aarch64_rust-jiff+tzdb-bundle-platform-devel.sha256sum] = "36397a6b6d448fa052f0d77e7b77803f323f97499fdd35e998db413f4e2c85d2"

URI_aarch64_rust-jiff+tzdb-concatenated-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+tzdb-concatenated-devel-0.2.35-1.el10_3.noarch.rpm;name=aarch64_rust-jiff+tzdb-concatenated-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+tzdb-concatenated-devel}"
SRC_URI[aarch64_rust-jiff+tzdb-concatenated-devel.sha256sum] = "64727322adf00c51989a6a455bdab4a1eadcb639777693d422f40e95493d697d"

URI_aarch64_rust-jiff+tzdb-zoneinfo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+tzdb-zoneinfo-devel-0.2.35-1.el10_3.noarch.rpm;name=aarch64_rust-jiff+tzdb-zoneinfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+tzdb-zoneinfo-devel}"
SRC_URI[aarch64_rust-jiff+tzdb-zoneinfo-devel.sha256sum] = "67c51b4686c233a95c799a9981eb3615a6aeae60b4e1e09f3b6719acc4afbba2"

URI_aarch64_rust-jiff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff-devel-0.2.35-1.el10_3.noarch.rpm;name=aarch64_rust-jiff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff-devel}"
SRC_URI[aarch64_rust-jiff-devel.sha256sum] = "80bb4ca8d762776dad2ca3f476454c7b4b6eb9b4605bdeed99766485466bef87"

RDEPENDS:rust-jiff+alloc-devel = " \
 cargo \
 rust-jiff-core+alloc-devel \
 rust-jiff-devel \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-jiff+default-devel = " \
 cargo \
 rust-jiff+perf-inline-devel \
 rust-jiff+std-devel \
 rust-jiff+tz-fat-devel \
 rust-jiff+tz-system-devel \
 rust-jiff+tzdb-bundle-platform-devel \
 rust-jiff+tzdb-concatenated-devel \
 rust-jiff+tzdb-zoneinfo-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff+logging-devel = " \
 cargo \
 rust-jiff-core+logging-devel \
 rust-jiff-devel \
 rust-log-devel \
 "
RDEPENDS:rust-jiff+perf-inline-devel = " \
 cargo \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff+serde-devel = " \
 cargo \
 rust-jiff-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-jiff+std-devel = " \
 cargo \
 rust-jiff+alloc-devel \
 rust-jiff-core+std-devel \
 rust-jiff-devel \
 rust-log+std-devel \
 rust-log-devel \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-jiff+tz-fat-devel = " \
 cargo \
 rust-jiff-core+tz-fat-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff+tz-system-devel = " \
 cargo \
 rust-jiff+std-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff+tzdb-bundle-platform-devel = " \
 cargo \
 rust-jiff+alloc-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff+tzdb-concatenated-devel = " \
 cargo \
 rust-jiff+std-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff+tzdb-zoneinfo-devel = " \
 cargo \
 rust-jiff+std-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff-devel = " \
 cargo \
 rust \
 rust-jiff-core-devel \
 "
