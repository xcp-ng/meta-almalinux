# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdialog"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kdialog \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdialog-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0dcb1069bafcfb9d36625942adb9958ea0927c1e0b23cc3fc662691e1cf4d92b"

URI_x86_64_v2_kdialog = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdialog-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdialog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdialog}"
SRC_URI[x86_64_v2_kdialog.sha256sum] = "98edadd72c2eb0cc1863e9ef95188ec48c5a43e77baf1fd0da6eabc7c4d60f33"

URI_aarch64_kdialog = "${EPEL_MIRROR}/aarch64/Packages/k/kdialog-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kdialog;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdialog}"
SRC_URI[aarch64_kdialog.sha256sum] = "cc324728b805da31eca8cd9f004861398070da3a4037c3ce09d8ff06487930f0"

RDEPENDS:kdialog = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libX11 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
