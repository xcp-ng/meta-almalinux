# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "upower"
PV = "1.90.10"
PR = "2.el10"
PACKAGES = " \
 upower \
 upower-devel \
 upower-devel-docs \
 upower-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/upower-1.90.10-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "475742faa5fc387404bc853a92cb5353eae298f2b931da306c071b97567c174e"

URI_x86_64_v2_upower = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/upower-1.90.10-2.el10.x86_64_v2.rpm;name=x86_64_v2_upower;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_upower}"
SRC_URI[x86_64_v2_upower.sha256sum] = "dd7716680eb628e9a07bc5a055f373cb9a4c03284e1cb1862a0aa41e1b25fa96"

URI_x86_64_v2_upower-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/upower-devel-1.90.10-2.el10.x86_64_v2.rpm;name=x86_64_v2_upower-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_upower-devel}"
SRC_URI[x86_64_v2_upower-devel.sha256sum] = "b71ca0fbe03cc5e992d43dc17770fa02119bf84861c26002b96307cee00433b1"

URI_x86_64_v2_upower-devel-docs = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/upower-devel-docs-1.90.10-2.el10.noarch.rpm;name=x86_64_v2_upower-devel-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_upower-devel-docs}"
SRC_URI[x86_64_v2_upower-devel-docs.sha256sum] = "16c08ec4f99fa2bf28238b293112b4716b8263fad3cac783d5105acdad7f887e"

URI_x86_64_v2_upower-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/upower-libs-1.90.10-2.el10.x86_64_v2.rpm;name=x86_64_v2_upower-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_upower-libs}"
SRC_URI[x86_64_v2_upower-libs.sha256sum] = "8ae00868211453b2370b7ba75c785ab8e9e1e49d360be60671ee2518778c6449"

URI_aarch64_upower = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/upower-1.90.10-2.el10.aarch64.rpm;name=aarch64_upower;unpack=0"
SRC_URI:append = " ${URI_aarch64_upower}"
SRC_URI[aarch64_upower.sha256sum] = "24fd19ae9121a9bf15f11467b0bb1557473fdbf43c641a917b9131b928aa2f0d"

URI_aarch64_upower-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/upower-devel-1.90.10-2.el10.aarch64.rpm;name=aarch64_upower-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_upower-devel}"
SRC_URI[aarch64_upower-devel.sha256sum] = "40993ddd9432dd10521beae772317ea905b6c44b644695d148752c2867e4f830"

URI_aarch64_upower-devel-docs = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/upower-devel-docs-1.90.10-2.el10.noarch.rpm;name=aarch64_upower-devel-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_upower-devel-docs}"
SRC_URI[aarch64_upower-devel-docs.sha256sum] = "16c08ec4f99fa2bf28238b293112b4716b8263fad3cac783d5105acdad7f887e"

URI_aarch64_upower-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/upower-libs-1.90.10-2.el10.aarch64.rpm;name=aarch64_upower-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_upower-libs}"
SRC_URI[aarch64_upower-libs.sha256sum] = "73d2e72c45ee8ee86b0c305a2264a131704245ed588b2aa18ec9fb497b8ac1e3"

RDEPENDS:upower = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libgudev \
 polkit-libs \
 python3 \
 systemd-udev \
 upower-libs \
 "
RDEPENDS:upower-devel = " \
 glib2-devel \
 pkgconf-pkg-config \
 polkit-devel \
 upower-libs \
 "
RDEPENDS:upower-devel-docs = " \
 upower-libs \
 "
RDEPENDS:upower-libs = " \
 glib2 \
 glibc \
 gobject-introspection \
 libgcc \
 "
