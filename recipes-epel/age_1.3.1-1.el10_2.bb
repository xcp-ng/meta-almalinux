# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "age"
PV = "1.3.1"
PR = "1.el10_2"
PACKAGES = " \
 age \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/age-1.3.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f119bafc42825f49577565ca6b1c3098d89504026a234222a6c46c8e044e463"

URI_x86_64_v2_age = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/age-1.3.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_age;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_age}"
SRC_URI[x86_64_v2_age.sha256sum] = "f3f5dfa6b550fd334755f55ce6785ed67545e9cd285b6f955e05fdc46280ba3c"

URI_aarch64_age = "${EPEL_MIRROR}/aarch64/Packages/a/age-1.3.1-1.el10_2.aarch64.rpm;name=aarch64_age;unpack=0"
SRC_URI:append = " ${URI_aarch64_age}"
SRC_URI[aarch64_age.sha256sum] = "fc252d0e2f07a0f7ae67b76676316ccba462fc65392cde9845bfd1a9616bf1fb"

RDEPENDS:age = " \
 glibc \
 "
