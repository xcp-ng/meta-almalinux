# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ruby4.0"
PV = "4.0.3"
PR = "35.el10"
PACKAGES = " \
 ruby4.0 \
 ruby4.0-devel \
 ruby4.0-doc \
 ruby4.0-rubygem-mysql2 \
 ruby4.0-rubygem-pg \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ruby4.0-4.0.3-35.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80e651aa0621597d20de046c57f6b97eafb610a1ed72d3a8fce06f83d3aac28a"

URI_x86_64_v2_ruby4.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby4.0-4.0.3-35.el10.x86_64_v2.rpm;name=x86_64_v2_ruby4.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby4.0}"
SRC_URI[x86_64_v2_ruby4.0.sha256sum] = "a96e3b6d9c03cb916c38377ae2407a92965c8fe75cc313041feb843b5bf6e70b"
RPROVIDES:ruby4.0:x86_64_v2 = "virtual/ruby_release_ virtual/ruby_runtime_executable_"

URI_x86_64_v2_ruby4.0-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby4.0-devel-4.0.3-35.el10.x86_64_v2.rpm;name=x86_64_v2_ruby4.0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby4.0-devel}"
SRC_URI[x86_64_v2_ruby4.0-devel.sha256sum] = "43f25f79ddf24c3512206c5d55c44fb565c4288ee73782f5fcf9d2a68b83e855"

URI_x86_64_v2_ruby4.0-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ruby4.0-doc-4.0.3-35.el10.noarch.rpm;name=x86_64_v2_ruby4.0-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby4.0-doc}"
SRC_URI[x86_64_v2_ruby4.0-doc.sha256sum] = "6b2e81b37d1c7de1c1e5424d4c731cd8a062dd58b623b2566cc82f87fcb374c0"

URI_x86_64_v2_ruby4.0-rubygem-mysql2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby4.0-rubygem-mysql2-0.5.7-35.el10.x86_64_v2.rpm;name=x86_64_v2_ruby4.0-rubygem-mysql2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby4.0-rubygem-mysql2}"
SRC_URI[x86_64_v2_ruby4.0-rubygem-mysql2.sha256sum] = "0795c0ff6a19eada3a39db589bf3540255ac1b4fa779f4289e16e440fe9a8496"

URI_x86_64_v2_ruby4.0-rubygem-pg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby4.0-rubygem-pg-1.6.3-35.el10.x86_64_v2.rpm;name=x86_64_v2_ruby4.0-rubygem-pg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby4.0-rubygem-pg}"
SRC_URI[x86_64_v2_ruby4.0-rubygem-pg.sha256sum] = "765422df187b51650f021b5450da2eb5f4faa2617f2fb79a1f34fd4dab547691"

URI_aarch64_ruby4.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby4.0-4.0.3-35.el10.aarch64.rpm;name=aarch64_ruby4.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby4.0}"
SRC_URI[aarch64_ruby4.0.sha256sum] = "0f362c1bd27b8586bc98d657db04ae45a3dd611799a8a92772cda98da787f8f4"
RPROVIDES:ruby4.0:aarch64 = "virtual/ruby_release_ virtual/ruby_runtime_executable_"

URI_aarch64_ruby4.0-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby4.0-devel-4.0.3-35.el10.aarch64.rpm;name=aarch64_ruby4.0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby4.0-devel}"
SRC_URI[aarch64_ruby4.0-devel.sha256sum] = "08e9c9dd6eb9fbb9a874fc9d5fe832511a77208bf3135c37d6519603d8cfd050"

URI_aarch64_ruby4.0-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ruby4.0-doc-4.0.3-35.el10.noarch.rpm;name=aarch64_ruby4.0-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby4.0-doc}"
SRC_URI[aarch64_ruby4.0-doc.sha256sum] = "6b2e81b37d1c7de1c1e5424d4c731cd8a062dd58b623b2566cc82f87fcb374c0"

URI_aarch64_ruby4.0-rubygem-mysql2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby4.0-rubygem-mysql2-0.5.7-35.el10.aarch64.rpm;name=aarch64_ruby4.0-rubygem-mysql2;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby4.0-rubygem-mysql2}"
SRC_URI[aarch64_ruby4.0-rubygem-mysql2.sha256sum] = "86d15494cedac13b9c10b456242df59a01fbe2c76b2266759a79b94acfce3521"

URI_aarch64_ruby4.0-rubygem-pg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby4.0-rubygem-pg-1.6.3-35.el10.aarch64.rpm;name=aarch64_ruby4.0-rubygem-pg;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby4.0-rubygem-pg}"
SRC_URI[aarch64_ruby4.0-rubygem-pg.sha256sum] = "e483afda46ab3393b04db79fb41a0f1541e6ec56f2d0e41bbb920c1cd338c2d5"

RDEPENDS:ruby4.0 = " \
 glibc \
 gmp \
 libffi \
 libgcc \
 libxcrypt \
 libyaml \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:ruby4.0-devel = " \
 pkgconf-pkg-config \
 ruby4.0 \
 "
RDEPENDS:ruby4.0-doc = " \
 ruby4.0 \
 "
RDEPENDS:ruby4.0-rubygem-mysql2 = " \
 glibc \
 mariadb-connector-c \
 ruby4.0 \
 "
RDEPENDS:ruby4.0-rubygem-pg = " \
 glibc \
 libpq \
 ruby4.0 \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/ruby_release_ rpm/virtual/ruby_runtime_executable_"

PROVIDES:append:aarch64 = " rpm/virtual/ruby_release_ rpm/virtual/ruby_runtime_executable_"
