# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-hatch-nodejs-version"
PV = "0.3.2"
PR = "2.el10_0"
PACKAGES = " \
 python3-hatch-nodejs-version \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-hatch-nodejs-version-0.3.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9238684bf1d37c8d9b416276d2ab0ec96478d9bfe1a428d4229185e100f44a1a"

URI_x86_64_v2_python3-hatch-nodejs-version = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-hatch-nodejs-version-0.3.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-hatch-nodejs-version;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-hatch-nodejs-version}"
SRC_URI[x86_64_v2_python3-hatch-nodejs-version.sha256sum] = "ef4497c4a60ba6a3b4842631ad72aef74fec93f1c60f2668024b5488e00a1da8"

URI_aarch64_python3-hatch-nodejs-version = "${EPEL_MIRROR}/aarch64/Packages/p/python3-hatch-nodejs-version-0.3.2-2.el10_0.noarch.rpm;name=aarch64_python3-hatch-nodejs-version;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-hatch-nodejs-version}"
SRC_URI[aarch64_python3-hatch-nodejs-version.sha256sum] = "efdb34f93bcf5a8420b1be7501df3863441eeb60b462fc8366956a4b528cfe56"

RDEPENDS:python3-hatch-nodejs-version = " \
 python3 \
 python3-hatchling \
 "
