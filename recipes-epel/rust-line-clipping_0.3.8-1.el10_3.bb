# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-line-clipping"
PV = "0.3.8"
PR = "1.el10_3"
PACKAGES = " \
 rust-line-clipping+default-devel \
 rust-line-clipping-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-line-clipping-0.3.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a574399ccf40338f3ddd97a31c25d2c96958eb1196bde6c888eebd2efa466557"

URI_x86_64_v2_rust-line-clipping+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-line-clipping+default-devel-0.3.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-line-clipping+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-line-clipping+default-devel}"
SRC_URI[x86_64_v2_rust-line-clipping+default-devel.sha256sum] = "50d4db50757ea17bb0d3652dee12931eede825ae93f71237b1b418ee25df7c45"

URI_x86_64_v2_rust-line-clipping-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-line-clipping-devel-0.3.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-line-clipping-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-line-clipping-devel}"
SRC_URI[x86_64_v2_rust-line-clipping-devel.sha256sum] = "189073eae6f633615a038cdc7b1ba8b2d6623ce51a45f36be497fbd263f58937"

URI_aarch64_rust-line-clipping+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-line-clipping+default-devel-0.3.8-1.el10_3.noarch.rpm;name=aarch64_rust-line-clipping+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-line-clipping+default-devel}"
SRC_URI[aarch64_rust-line-clipping+default-devel.sha256sum] = "faa146be611ad575016379a20aa53e12c53ddfccc2aad8c453081b1a0f145078"

URI_aarch64_rust-line-clipping-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-line-clipping-devel-0.3.8-1.el10_3.noarch.rpm;name=aarch64_rust-line-clipping-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-line-clipping-devel}"
SRC_URI[aarch64_rust-line-clipping-devel.sha256sum] = "fbf5ab5e23cb5fead5c881396d173965267750eba0f8e443e84ba36a100f61c0"

RDEPENDS:rust-line-clipping+default-devel = " \
 cargo \
 rust-line-clipping-devel \
 "
RDEPENDS:rust-line-clipping-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 "
