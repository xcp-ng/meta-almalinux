# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "firewalld"
PV = "2.4.3"
PR = "2.el10_2"
PACKAGES = " \
 firewall-applet \
 firewall-config \
 firewalld \
 firewalld-filesystem \
 python3-firewall \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/firewalld-2.4.3-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a76a27f5454cf652e52f639d5a4c81696589b7cd71e0f47db058eb7ce59c946"

URI_x86_64_v2_firewall-applet = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/firewall-applet-2.4.3-2.el10_2.noarch.rpm;name=x86_64_v2_firewall-applet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_firewall-applet}"
SRC_URI[x86_64_v2_firewall-applet.sha256sum] = "ffd8842c4200c16d8b22a3fc27d1abb69890ea11ced8037460c3287145134b4d"

URI_x86_64_v2_firewall-config = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/firewall-config-2.4.3-2.el10_2.noarch.rpm;name=x86_64_v2_firewall-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_firewall-config}"
SRC_URI[x86_64_v2_firewall-config.sha256sum] = "2ef289a90c0f7ee9f71fbd1f86cc86a327ddb42e4ddd8254c4b75e1f163dcaa9"

URI_x86_64_v2_firewalld = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/firewalld-2.4.3-2.el10_2.noarch.rpm;name=x86_64_v2_firewalld;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_firewalld}"
SRC_URI[x86_64_v2_firewalld.sha256sum] = "f6cbbbe71210fc4d4a586fc8284d0640c5a1477f1452b85658d5ed390f393641"

URI_x86_64_v2_firewalld-filesystem = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/firewalld-filesystem-2.4.3-2.el10_2.noarch.rpm;name=x86_64_v2_firewalld-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_firewalld-filesystem}"
SRC_URI[x86_64_v2_firewalld-filesystem.sha256sum] = "4d2a18bb2b8e8571f94cad6366350cf6341cee5341693672d7323b225b9e57df"

URI_x86_64_v2_python3-firewall = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-firewall-2.4.3-2.el10_2.noarch.rpm;name=x86_64_v2_python3-firewall;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-firewall}"
SRC_URI[x86_64_v2_python3-firewall.sha256sum] = "6497431e1a461d72c35dfd8cfb961d5aca12979d95d9aca8da0d5132d23fe26a"

URI_aarch64_firewall-applet = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/firewall-applet-2.4.3-2.el10_2.noarch.rpm;name=aarch64_firewall-applet;unpack=0"
SRC_URI:append = " ${URI_aarch64_firewall-applet}"
SRC_URI[aarch64_firewall-applet.sha256sum] = "ffd8842c4200c16d8b22a3fc27d1abb69890ea11ced8037460c3287145134b4d"

URI_aarch64_firewall-config = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/firewall-config-2.4.3-2.el10_2.noarch.rpm;name=aarch64_firewall-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_firewall-config}"
SRC_URI[aarch64_firewall-config.sha256sum] = "2ef289a90c0f7ee9f71fbd1f86cc86a327ddb42e4ddd8254c4b75e1f163dcaa9"

URI_aarch64_firewalld = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/firewalld-2.4.3-2.el10_2.noarch.rpm;name=aarch64_firewalld;unpack=0"
SRC_URI:append = " ${URI_aarch64_firewalld}"
SRC_URI[aarch64_firewalld.sha256sum] = "f6cbbbe71210fc4d4a586fc8284d0640c5a1477f1452b85658d5ed390f393641"

URI_aarch64_firewalld-filesystem = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/firewalld-filesystem-2.4.3-2.el10_2.noarch.rpm;name=aarch64_firewalld-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_firewalld-filesystem}"
SRC_URI[aarch64_firewalld-filesystem.sha256sum] = "4d2a18bb2b8e8571f94cad6366350cf6341cee5341693672d7323b225b9e57df"

URI_aarch64_python3-firewall = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-firewall-2.4.3-2.el10_2.noarch.rpm;name=aarch64_python3-firewall;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-firewall}"
SRC_URI[aarch64_python3-firewall.sha256sum] = "6497431e1a461d72c35dfd8cfb961d5aca12979d95d9aca8da0d5132d23fe26a"

RDEPENDS:firewall-applet = " \
 NetworkManager-libnm \
 dbus-x11 \
 firewall-config \
 firewalld \
 hicolor-icon-theme \
 libnotify \
 python3 \
 python3-firewall \
 python3-gobject \
 python3-pyqt6-base \
 "
RDEPENDS:firewall-config = " \
 NetworkManager-libnm \
 dbus-x11 \
 firewalld \
 gtk3 \
 hicolor-icon-theme \
 python3 \
 python3-firewall \
 python3-gobject \
 "
RDEPENDS:firewalld = " \
 bash \
 firewalld-filesystem \
 python3 \
 python3-firewall \
 systemd \
 "
RDEPENDS:firewalld-filesystem = " \
 "
RDEPENDS:python3-firewall = " \
 python3 \
 python3-dbus \
 python3-gobject-base \
 python3-nftables \
 "
