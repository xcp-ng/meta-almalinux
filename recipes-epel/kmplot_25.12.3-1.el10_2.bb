# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmplot"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kmplot \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmplot-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb3f1c1da54de005afc92c98f88abcb9d702fb8475791f4bcaf0e418993ecb27"

URI_x86_64_v2_kmplot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmplot-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmplot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmplot}"
SRC_URI[x86_64_v2_kmplot.sha256sum] = "76ab388428c8a2f43239bd99c459d8f753314256b5e15cf4c2604c78a8478adf"

URI_aarch64_kmplot = "${EPEL_MIRROR}/aarch64/Packages/k/kmplot-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kmplot;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmplot}"
SRC_URI[aarch64_kmplot.sha256sum] = "634382b991b2d759cde4d6d2eee3d5f5d0cb958fc4f0bbde3ac75ae84ac58b6c"

RDEPENDS:kmplot = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
