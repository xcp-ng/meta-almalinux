# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serdect"
PV = "0.2.0"
PR = "4.el10_0"
PACKAGES = " \
 rust-serdect+alloc-devel \
 rust-serdect+default-devel \
 rust-serdect+zeroize-devel \
 rust-serdect-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serdect-0.2.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0d869d41cbc83a32a160c5b002364747af33955fd2e9588cea7750881e611f19"

URI_x86_64_v2_rust-serdect+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serdect+alloc-devel-0.2.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serdect+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serdect+alloc-devel}"
SRC_URI[x86_64_v2_rust-serdect+alloc-devel.sha256sum] = "13892bfc4681980f1902f8e9a5d74f278e46e8c63adc2698917a45a2a61b3874"

URI_x86_64_v2_rust-serdect+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serdect+default-devel-0.2.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serdect+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serdect+default-devel}"
SRC_URI[x86_64_v2_rust-serdect+default-devel.sha256sum] = "f9d528cab4e298604be8b105c6fd6c44d4f1cb9825a7ace9b33ea1b9f8f8c237"

URI_x86_64_v2_rust-serdect+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serdect+zeroize-devel-0.2.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serdect+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serdect+zeroize-devel}"
SRC_URI[x86_64_v2_rust-serdect+zeroize-devel.sha256sum] = "410fc12bf2b53dadca90a24b732b0a6d1826a6ad50fd5640dbd5ff81f6c1884d"

URI_x86_64_v2_rust-serdect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serdect-devel-0.2.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serdect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serdect-devel}"
SRC_URI[x86_64_v2_rust-serdect-devel.sha256sum] = "9beb8f7fe4dbe60e32fefe560391005497921a09253197683ebf49d7ccc04c3a"

URI_aarch64_rust-serdect+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serdect+alloc-devel-0.2.0-4.el10_0.noarch.rpm;name=aarch64_rust-serdect+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serdect+alloc-devel}"
SRC_URI[aarch64_rust-serdect+alloc-devel.sha256sum] = "7d687293d65efbbbd52092a26e1c01652210436c5abb82a9e0af5f4e26045f38"

URI_aarch64_rust-serdect+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serdect+default-devel-0.2.0-4.el10_0.noarch.rpm;name=aarch64_rust-serdect+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serdect+default-devel}"
SRC_URI[aarch64_rust-serdect+default-devel.sha256sum] = "15d1a6ebc9bb961b41ede2cef360e66ab0fac57e3cf7b395c4a7bc0c81a28c25"

URI_aarch64_rust-serdect+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serdect+zeroize-devel-0.2.0-4.el10_0.noarch.rpm;name=aarch64_rust-serdect+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serdect+zeroize-devel}"
SRC_URI[aarch64_rust-serdect+zeroize-devel.sha256sum] = "793bc6e849df0453c879bea2bfd488f75bbecb5af13d6e9478413bf367c4c7cf"

URI_aarch64_rust-serdect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serdect-devel-0.2.0-4.el10_0.noarch.rpm;name=aarch64_rust-serdect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serdect-devel}"
SRC_URI[aarch64_rust-serdect-devel.sha256sum] = "67a66303468c28eee898ca73bb71849b727d50d0cc8675aecc793f823653d933"

RDEPENDS:rust-serdect+alloc-devel = " \
 cargo \
 rust-base16ct+alloc-devel \
 rust-serde+alloc-devel \
 rust-serdect-devel \
 "
RDEPENDS:rust-serdect+default-devel = " \
 cargo \
 rust-serdect+alloc-devel \
 rust-serdect-devel \
 "
RDEPENDS:rust-serdect+zeroize-devel = " \
 cargo \
 rust-serdect-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-serdect-devel = " \
 cargo \
 rust \
 rust-base16ct-devel \
 rust-serde-devel \
 "
