# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nodejs24"
PE = "1"
PV = "24.21.0"
PR = "1.el10_2"
PACKAGES = " \
 nodejs24 \
 nodejs24-devel \
 nodejs24-docs \
 nodejs24-full-i18n \
 nodejs24-libs \
 nodejs24-npm \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nodejs24-24.21.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f6a814b102669f803d7cbdd2f9d6383b40883c26f3b6e8957475eb7a80cf131f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs24-24.21.0-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_nodejs24;unpack=0"
SRC_URI[x86_64_v2_nodejs24.sha256sum] = "852b88bc1f3757e93d4f4ea60e7e41ec80bbac68188c15fd3e3141c23247cbec"
RPROVIDES:nodejs24:append:x86_64_v2 = " virtual/nodejs_engine_ virtual/nodejs_engine__ge_0.8.0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs24-devel-24.21.0-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_nodejs24-devel;unpack=0"
SRC_URI[x86_64_v2_nodejs24-devel.sha256sum] = "0cad9b5eeb80cb86e3c4cf6c213e19c68ba28fce65466912ed3bf7d8b3210fbb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs24-docs-24.21.0-1.el10_2.noarch.rpm;name=x86_64_v2_nodejs24-docs;unpack=0"
SRC_URI[x86_64_v2_nodejs24-docs.sha256sum] = "3c0582da0fa349b5c85a8671a5ccff46d1d89830e1e263672e2e93e4eb5161c5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs24-full-i18n-24.21.0-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_nodejs24-full-i18n;unpack=0"
SRC_URI[x86_64_v2_nodejs24-full-i18n.sha256sum] = "59c57ba3bbf6ade56fe154025ce8727330cf5c89237ee8c064d125493834c371"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs24-libs-24.21.0-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_nodejs24-libs;unpack=0"
SRC_URI[x86_64_v2_nodejs24-libs.sha256sum] = "ec3ca4373fa8f0d271200a6587c6baa8584f1f62f4e9d4c5918231c6260d5d40"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs24-npm-11.19.0-1.24.21.0.1.el10_2.noarch.rpm;name=x86_64_v2_nodejs24-npm;unpack=0"
SRC_URI[x86_64_v2_nodejs24-npm.sha256sum] = "c33582aee585c85053bce7f5822e3f7bccd46c315de9ed48e5522daeeeec7080"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs24-24.21.0-1.el10_2.aarch64.rpm;name=aarch64_nodejs24;unpack=0"
SRC_URI[aarch64_nodejs24.sha256sum] = "90585f81ad3a3373df1b3401743d4ffee865518485a67d1e0029964bcba85dc1"
RPROVIDES:nodejs24:append:aarch64 = " virtual/nodejs_engine_ virtual/nodejs_engine__ge_0.8.0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs24-devel-24.21.0-1.el10_2.aarch64.rpm;name=aarch64_nodejs24-devel;unpack=0"
SRC_URI[aarch64_nodejs24-devel.sha256sum] = "f4a3cba3fb88d87950bed205f721bf15046808c38062b8e51db14aec52d0e010"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs24-docs-24.21.0-1.el10_2.noarch.rpm;name=aarch64_nodejs24-docs;unpack=0"
SRC_URI[aarch64_nodejs24-docs.sha256sum] = "3c0582da0fa349b5c85a8671a5ccff46d1d89830e1e263672e2e93e4eb5161c5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs24-full-i18n-24.21.0-1.el10_2.aarch64.rpm;name=aarch64_nodejs24-full-i18n;unpack=0"
SRC_URI[aarch64_nodejs24-full-i18n.sha256sum] = "7801c6e666ab708e902c62d610264eb43400a1374858445afaa601042b8f312c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs24-libs-24.21.0-1.el10_2.aarch64.rpm;name=aarch64_nodejs24-libs;unpack=0"
SRC_URI[aarch64_nodejs24-libs.sha256sum] = "d1a7f724f7992879cf9eaa9822a107fc4945d30d8b9054cde5a538f177d4e1d7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs24-npm-11.19.0-1.24.21.0.1.el10_2.noarch.rpm;name=aarch64_nodejs24-npm;unpack=0"
SRC_URI[aarch64_nodejs24-npm.sha256sum] = "c33582aee585c85053bce7f5822e3f7bccd46c315de9ed48e5522daeeeec7080"

RDEPENDS:nodejs24 = " \
 ca-certificates \
 glibc \
 nodejs24-libs \
 "
RDEPENDS:nodejs24-devel = " \
 brotli-devel \
 libuv-devel \
 nodejs-packaging \
 nodejs24 \
 nodejs24-libs \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:nodejs24-docs = " \
 nodejs24 \
 "
RDEPENDS:nodejs24-full-i18n = " \
 nodejs24 \
 "
RDEPENDS:nodejs24-libs = " \
 c-ares \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 libuv \
 openssl-libs \
 sqlite-libs \
 zlib-ng-compat \
 "
RDEPENDS:nodejs24-npm = " \
 bash \
 nodejs24 \
 "
