# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyspf"
PV = "2.0.14"
PR = "26.el10_2"
PACKAGES = " \
 python3-pyspf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyspf-2.0.14-26.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c9db22bf3261d2db14b5466c3e60ba0b2eb9f4664bcb53857e55a01c0ee70da"

URI_x86_64_v2_python3-pyspf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyspf-2.0.14-26.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pyspf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyspf}"
SRC_URI[x86_64_v2_python3-pyspf.sha256sum] = "06fda489697775d9a935bca9c8a74b99766b7c6fb918d066f19095d8bdf660da"

URI_aarch64_python3-pyspf = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyspf-2.0.14-26.el10_2.noarch.rpm;name=aarch64_python3-pyspf;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyspf}"
SRC_URI[aarch64_python3-pyspf.sha256sum] = "e962140145c3d2be9f643a80aec27263fdd49febd95cc26711be3fe5d84f0c06"

RDEPENDS:python3-pyspf = " \
 python3 \
 python3-py3dns \
 "
