# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-block-buffer0.10"
PV = "0.10.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-block-buffer0.10+default-devel \
 rust-block-buffer0.10-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-block-buffer0.10-0.10.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "23cf66bb79d7223f8ef9ff85d7565b5acc6ff6ed05c6d032c795d16efc7b639d"

URI_x86_64_v2_rust-block-buffer0.10+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-block-buffer0.10+default-devel-0.10.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-block-buffer0.10+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-block-buffer0.10+default-devel}"
SRC_URI[x86_64_v2_rust-block-buffer0.10+default-devel.sha256sum] = "87979f7ec691d4d153e702e6cbff60b96003a0b2f8886803754dbd1f24499080"

URI_x86_64_v2_rust-block-buffer0.10-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-block-buffer0.10-devel-0.10.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-block-buffer0.10-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-block-buffer0.10-devel}"
SRC_URI[x86_64_v2_rust-block-buffer0.10-devel.sha256sum] = "be5dfcab77ae91348fb88935c84bf8a9c5d08a3afd7699dc0b19b95dcba124af"

URI_aarch64_rust-block-buffer0.10+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-block-buffer0.10+default-devel-0.10.4-1.el10_2.noarch.rpm;name=aarch64_rust-block-buffer0.10+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-block-buffer0.10+default-devel}"
SRC_URI[aarch64_rust-block-buffer0.10+default-devel.sha256sum] = "147f31a917ef1f9110d3f4f23fbbce558f894e0d9c159b7f1db02b670070a377"

URI_aarch64_rust-block-buffer0.10-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-block-buffer0.10-devel-0.10.4-1.el10_2.noarch.rpm;name=aarch64_rust-block-buffer0.10-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-block-buffer0.10-devel}"
SRC_URI[aarch64_rust-block-buffer0.10-devel.sha256sum] = "57932c06ce1538c3bc51608ba9de6d1feb6e965a521b8ea417aa4d2a868bf3c6"

RDEPENDS:rust-block-buffer0.10+default-devel = " \
 cargo \
 rust-block-buffer0.10-devel \
 "
RDEPENDS:rust-block-buffer0.10-devel = " \
 cargo \
 rust-generic-array+default-devel \
 "
