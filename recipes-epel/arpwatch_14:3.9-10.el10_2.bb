# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "arpwatch"
PE = "14"
PV = "3.9"
PR = "10.el10_2"
PACKAGES = " \
 arpwatch \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/arpwatch-3.9-10.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0903150d833f1f8bfabd15e737a5868bf4570a7c9592c7afa6890cce9f503a4c"

URI_x86_64_v2_arpwatch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/arpwatch-3.9-10.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_arpwatch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_arpwatch}"
SRC_URI[x86_64_v2_arpwatch.sha256sum] = "822dc35ea25b6d7d9a1c953084031b7792e36dc0287fb11fda1a34bdf343007d"

URI_aarch64_arpwatch = "${EPEL_MIRROR}/aarch64/Packages/a/arpwatch-3.9-10.el10_2.aarch64.rpm;name=aarch64_arpwatch;unpack=0"
SRC_URI:append = " ${URI_aarch64_arpwatch}"
SRC_URI[aarch64_arpwatch.sha256sum] = "f9c980dc2cbd1bcad8489405affe1b48cc4f008bce19ea3f631a8c833c979bb2"

RDEPENDS:arpwatch = " \
 bash \
 glibc \
 libpcap \
 python3 \
 shadow-utils \
 virtual//usr/sbin/sendmail \
 "
