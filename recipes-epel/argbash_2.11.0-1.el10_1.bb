# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "argbash"
PV = "2.11.0"
PR = "1.el10_1"
PACKAGES = " \
 argbash \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/argbash-2.11.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d2da435edfd18fb261fcaeaf6fb3cefa89816f8e5a005003ba4e3a6e4784e140"

URI_x86_64_v2_argbash = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/argbash-2.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_argbash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_argbash}"
SRC_URI[x86_64_v2_argbash.sha256sum] = "05c067b610813ecc9a982a23a1cca0e09e2af73afd6526de4c6d8a8e2b3bad1c"

URI_aarch64_argbash = "${EPEL_MIRROR}/aarch64/Packages/a/argbash-2.11.0-1.el10_1.noarch.rpm;name=aarch64_argbash;unpack=0"
SRC_URI:append = " ${URI_aarch64_argbash}"
SRC_URI[aarch64_argbash.sha256sum] = "68a7166adf79e53aa378e6af8ad65241c30abccee1a6725c55a273e36f7011ac"

RDEPENDS:argbash = " \
 autoconf \
 bash \
 grep \
 sed \
 virtual/coreutils \
 "
