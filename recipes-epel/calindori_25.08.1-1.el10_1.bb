# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "calindori"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 calindori \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/calindori-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7e424cb73d6613d74bd53d45f7325cd1fd33c9fc9213bf36c2893535015734c4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/calindori-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_calindori;unpack=0"
SRC_URI[x86_64_v2_calindori.sha256sum] = "820787466ea78580ce04c0c417c309d7953b5540d21b2beab9df396197ec7f63"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/calindori-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_calindori;unpack=0"
SRC_URI[aarch64_calindori.sha256sum] = "8553263fca27b4ee04afe0cf16b0187c739057ede1d8bbc0bb527b85283a4b9f"

RDEPENDS:calindori = " \
 glibc \
 hicolor-icon-theme \
 kf6-kcalendarcore \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-knotifications \
 kf6-kpeople \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwayland \
 "
