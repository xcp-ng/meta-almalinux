# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "c-ares"
PV = "1.34.6"
PR = "2.el10_2"
PACKAGES = " \
 c-ares \
 c-ares-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/c-ares-1.34.6-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e2d236377b558c0a554ccea51be1acc85d246c1c200ae53184968ec3dc264f95"

URI_x86_64_v2_c-ares = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/c-ares-1.34.6-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_c-ares;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_c-ares}"
SRC_URI[x86_64_v2_c-ares.sha256sum] = "0474f7475623cee2adb7d8fa1dfb84c9bbea57977cacedd959ad1c5cf066b3c6"

URI_x86_64_v2_c-ares-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/c-ares-devel-1.34.6-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_c-ares-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_c-ares-devel}"
SRC_URI[x86_64_v2_c-ares-devel.sha256sum] = "4a0537e5ef8f2fce625c7d31ab3b43eb26fba4ebe768697f33a8544393624313"

URI_aarch64_c-ares = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/c-ares-1.34.6-2.el10_2.aarch64.rpm;name=aarch64_c-ares;unpack=0"
SRC_URI:append = " ${URI_aarch64_c-ares}"
SRC_URI[aarch64_c-ares.sha256sum] = "c2f06ac6602d6c9c28824afbde8ef43a83c5ec21815f71efccf75670292c39aa"

URI_aarch64_c-ares-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/c-ares-devel-1.34.6-2.el10_2.aarch64.rpm;name=aarch64_c-ares-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_c-ares-devel}"
SRC_URI[aarch64_c-ares-devel.sha256sum] = "fcb05cde723a1b040ed0a5b85c80e96419757927d07452b27c9553c4c4ce3753"

RDEPENDS:c-ares = " \
 glibc \
 "
RDEPENDS:c-ares-devel = " \
 c-ares \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
