# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libusb-compat-0.1"
PV = "0.1.8"
PR = "9.el10_0"
PACKAGES = " \
 libusb-compat-0.1 \
 libusb-compat-0.1-devel \
 libusb-compat-0.1-tests-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libusb-compat-0.1-0.1.8-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd92d7af6dcc103ace158216e8c860a3d80aef49277bd4407f772d9f73974916"

URI_x86_64_v2_libusb-compat-0.1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libusb-compat-0.1-0.1.8-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libusb-compat-0.1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libusb-compat-0.1}"
SRC_URI[x86_64_v2_libusb-compat-0.1.sha256sum] = "b711c8015c84533ca8d77b721286714cc46d847a939fe476c1353c0f1a92f100"

URI_x86_64_v2_libusb-compat-0.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libusb-compat-0.1-devel-0.1.8-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libusb-compat-0.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libusb-compat-0.1-devel}"
SRC_URI[x86_64_v2_libusb-compat-0.1-devel.sha256sum] = "5d314d5b2439a37a638531b3e69cb884bb1ff2558c37ce2fc734846ec3fb500a"

URI_x86_64_v2_libusb-compat-0.1-tests-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libusb-compat-0.1-tests-examples-0.1.8-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libusb-compat-0.1-tests-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libusb-compat-0.1-tests-examples}"
SRC_URI[x86_64_v2_libusb-compat-0.1-tests-examples.sha256sum] = "118f441d09fb3fd3a082471a13dba04ce2b7d347c56a48c19a6063179a269d1a"

URI_aarch64_libusb-compat-0.1 = "${EPEL_MIRROR}/aarch64/Packages/l/libusb-compat-0.1-0.1.8-9.el10_0.aarch64.rpm;name=aarch64_libusb-compat-0.1;unpack=0"
SRC_URI:append = " ${URI_aarch64_libusb-compat-0.1}"
SRC_URI[aarch64_libusb-compat-0.1.sha256sum] = "a065a128d791466f5d56540e4d93a2c870a3725516c0faabdaefb297ff917c44"

URI_aarch64_libusb-compat-0.1-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libusb-compat-0.1-devel-0.1.8-9.el10_0.aarch64.rpm;name=aarch64_libusb-compat-0.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libusb-compat-0.1-devel}"
SRC_URI[aarch64_libusb-compat-0.1-devel.sha256sum] = "c7efd106a259ba40c3c50a0429754bd04bba41d5e5b9354dff4e07f9352f116c"

URI_aarch64_libusb-compat-0.1-tests-examples = "${EPEL_MIRROR}/aarch64/Packages/l/libusb-compat-0.1-tests-examples-0.1.8-9.el10_0.aarch64.rpm;name=aarch64_libusb-compat-0.1-tests-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_libusb-compat-0.1-tests-examples}"
SRC_URI[aarch64_libusb-compat-0.1-tests-examples.sha256sum] = "ffb8386254e6a930942e3e989d98774ffee9deb5ef2e03c76299f5850bed7524"

RDEPENDS:libusb-compat-0.1 = " \
 glibc \
 libusb1 \
 "
RDEPENDS:libusb-compat-0.1-devel = " \
 bash \
 libusb-compat-0.1 \
 libusb1-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libusb-compat-0.1-tests-examples = " \
 glibc \
 libusb-compat-0.1 \
 "
