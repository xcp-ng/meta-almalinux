# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "btrfs-progs"
PV = "6.12"
PR = "3.el10_0"
PACKAGES = " \
 btrfs-progs \
 btrfs-progs-devel \
 libbtrfs \
 libbtrfsutil \
 python3-btrfsutil \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/btrfs-progs-6.12-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30e909adf75f52e557db1ed7e67e22b8a998186de55f7ae8856590d0e3367988"

URI_x86_64_v2_btrfs-progs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/btrfs-progs-6.12-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_btrfs-progs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_btrfs-progs}"
SRC_URI[x86_64_v2_btrfs-progs.sha256sum] = "984c0d19b7139efd00807cdb20af4e8d6eeec68b0a24df3a0e1c9f0fa2d214a3"

URI_x86_64_v2_btrfs-progs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/btrfs-progs-devel-6.12-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_btrfs-progs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_btrfs-progs-devel}"
SRC_URI[x86_64_v2_btrfs-progs-devel.sha256sum] = "fed87f42d44facf86ab8e0a5a15a763177e5c23b9a8e1d5daad66c535e19efe4"

URI_x86_64_v2_libbtrfs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbtrfs-6.12-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libbtrfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbtrfs}"
SRC_URI[x86_64_v2_libbtrfs.sha256sum] = "e97c3bfe188b59bed0561c0728a952efa62ac63dcfbab908ba95968acb13f29a"

URI_x86_64_v2_libbtrfsutil = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbtrfsutil-6.12-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libbtrfsutil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbtrfsutil}"
SRC_URI[x86_64_v2_libbtrfsutil.sha256sum] = "857d8fccbc6749345ac3312df15ceaf1583158cbcf1c0a778e0c8e3fb3969e10"

URI_x86_64_v2_python3-btrfsutil = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-btrfsutil-6.12-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-btrfsutil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-btrfsutil}"
SRC_URI[x86_64_v2_python3-btrfsutil.sha256sum] = "8ffd70b5ce5073f20f21f4792476bdae4798437955fb741ef6fd2580fe8fa945"

URI_aarch64_btrfs-progs = "${EPEL_MIRROR}/aarch64/Packages/b/btrfs-progs-6.12-3.el10_0.aarch64.rpm;name=aarch64_btrfs-progs;unpack=0"
SRC_URI:append = " ${URI_aarch64_btrfs-progs}"
SRC_URI[aarch64_btrfs-progs.sha256sum] = "3c08a2bb08feea1c202a2415de62880c47171a959a67c7c73f50b74fae61bbeb"

URI_aarch64_btrfs-progs-devel = "${EPEL_MIRROR}/aarch64/Packages/b/btrfs-progs-devel-6.12-3.el10_0.aarch64.rpm;name=aarch64_btrfs-progs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_btrfs-progs-devel}"
SRC_URI[aarch64_btrfs-progs-devel.sha256sum] = "92017927221e146e5faba8eec2f107a98f761ffafd17968d5a52c959797bca23"

URI_aarch64_libbtrfs = "${EPEL_MIRROR}/aarch64/Packages/l/libbtrfs-6.12-3.el10_0.aarch64.rpm;name=aarch64_libbtrfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbtrfs}"
SRC_URI[aarch64_libbtrfs.sha256sum] = "d37a2cf665de3a7b0bceed1cd7fcecdc6c216abc68e598945d2877a71ac88f25"

URI_aarch64_libbtrfsutil = "${EPEL_MIRROR}/aarch64/Packages/l/libbtrfsutil-6.12-3.el10_0.aarch64.rpm;name=aarch64_libbtrfsutil;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbtrfsutil}"
SRC_URI[aarch64_libbtrfsutil.sha256sum] = "39279150c67a8f165b711a9818adf1481d85727a390138d86a7b69863cf2d7aa"

URI_aarch64_python3-btrfsutil = "${EPEL_MIRROR}/aarch64/Packages/p/python3-btrfsutil-6.12-3.el10_0.aarch64.rpm;name=aarch64_python3-btrfsutil;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-btrfsutil}"
SRC_URI[aarch64_python3-btrfsutil.sha256sum] = "ea83f47f2c70ac480c8847be172f7175d108ba13ec8949fc7ddd49e40ad62043"

RDEPENDS:btrfs-progs = " \
 bash \
 e2fsprogs-libs \
 glibc \
 libblkid \
 libcom_err \
 libgcrypt \
 libuuid \
 libzstd \
 lzo \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:btrfs-progs-devel = " \
 btrfs-progs \
 libbtrfs \
 libbtrfsutil \
 pkgconf-pkg-config \
 "
RDEPENDS:libbtrfs = " \
 glibc \
 "
RDEPENDS:libbtrfsutil = " \
 glibc \
 "
RDEPENDS:python3-btrfsutil = " \
 glibc \
 libbtrfsutil \
 python3 \
 "
