# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kio-gdrive"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kio-gdrive \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kio-gdrive-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b3f95c8803749433cbb0a5898e7d91a027a47d421b22c33b944ce567d9ec786c"

URI_x86_64_v2_kio-gdrive = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kio-gdrive-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kio-gdrive;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kio-gdrive}"
SRC_URI[x86_64_v2_kio-gdrive.sha256sum] = "179f4204cef41990b4d16598b2464ede2f926a242831fc452e2b3c6388f14090"

URI_aarch64_kio-gdrive = "${EPEL_MIRROR}/aarch64/Packages/k/kio-gdrive-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kio-gdrive;unpack=0"
SRC_URI:append = " ${URI_aarch64_kio-gdrive}"
SRC_URI[aarch64_kio-gdrive.sha256sum] = "9daefedf36b197f5f724073bb7f6f9301e030c251bb8591feb2628506db37870"

RDEPENDS:kio-gdrive = " \
 accounts-qml-module-qt6 \
 glibc \
 kaccounts-integration-qt6 \
 kaccounts-providers \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 kf6-purpose \
 libaccounts-qt6 \
 libkgapi \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
