# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gssdp"
PV = "1.6.3"
PR = "1.el10_1"
PACKAGES = " \
 gssdp \
 gssdp-devel \
 gssdp-docs \
 gssdp-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gssdp-1.6.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de10df67ac1d9f1e91f737fba679b8ff7944e291531a24dcd42e02d2ca2082b7"

URI_x86_64_v2_gssdp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gssdp-1.6.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gssdp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gssdp}"
SRC_URI[x86_64_v2_gssdp.sha256sum] = "d32bd53abae393f53ab5b92c7320a1d2d037b6655c36fc452476dd0f212ccfa9"

URI_x86_64_v2_gssdp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gssdp-devel-1.6.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gssdp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gssdp-devel}"
SRC_URI[x86_64_v2_gssdp-devel.sha256sum] = "c41501d52350f32a8128db196dc9d908ce74104f89accb0959cfef78ef2c056b"

URI_x86_64_v2_gssdp-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gssdp-docs-1.6.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_gssdp-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gssdp-docs}"
SRC_URI[x86_64_v2_gssdp-docs.sha256sum] = "e7e9f4f27c50a8a4c8b8eba618c5022d6b9b18092e3faafc442f0e21b28d6523"

URI_x86_64_v2_gssdp-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gssdp-utils-1.6.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gssdp-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gssdp-utils}"
SRC_URI[x86_64_v2_gssdp-utils.sha256sum] = "8ef4c078fe2f2f0ea6594100f9f278be7cbe2cadb52ac31c0865d75fa39afd2b"

URI_aarch64_gssdp = "${EPEL_MIRROR}/aarch64/Packages/g/gssdp-1.6.3-1.el10_1.aarch64.rpm;name=aarch64_gssdp;unpack=0"
SRC_URI:append = " ${URI_aarch64_gssdp}"
SRC_URI[aarch64_gssdp.sha256sum] = "5969b26c066d24553262138ff4b03f053c1f81e1e9f1fa0d5ea05c00dc4be467"

URI_aarch64_gssdp-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gssdp-devel-1.6.3-1.el10_1.aarch64.rpm;name=aarch64_gssdp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gssdp-devel}"
SRC_URI[aarch64_gssdp-devel.sha256sum] = "e6eab5d5de3d2e6eeeb7f862a1f28d6a1a861158b63ce48589071889a27f27b4"

URI_aarch64_gssdp-docs = "${EPEL_MIRROR}/aarch64/Packages/g/gssdp-docs-1.6.3-1.el10_1.noarch.rpm;name=aarch64_gssdp-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gssdp-docs}"
SRC_URI[aarch64_gssdp-docs.sha256sum] = "eee7cb65365ffb927ef3a6df50480fb9383bd7c2714ac81a47b90dcd760adf37"

URI_aarch64_gssdp-utils = "${EPEL_MIRROR}/aarch64/Packages/g/gssdp-utils-1.6.3-1.el10_1.aarch64.rpm;name=aarch64_gssdp-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_gssdp-utils}"
SRC_URI[aarch64_gssdp-utils.sha256sum] = "e1764fceef3ff81d0fc60673c3c80bb3435baddf5435bfd6ed3ca20874c820cf"

RDEPENDS:gssdp = " \
 glib2 \
 glibc \
 libsoup3 \
 "
RDEPENDS:gssdp-devel = " \
 glib2-devel \
 gssdp \
 libsoup3-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:gssdp-docs = " \
 gssdp \
 "
RDEPENDS:gssdp-utils = " \
 glib2 \
 glibc \
 gssdp \
 gtk4 \
 libsoup3 \
 "
