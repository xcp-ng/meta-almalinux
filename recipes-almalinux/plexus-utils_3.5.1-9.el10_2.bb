# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plexus-utils"
PV = "3.5.1"
PR = "9.el10_2"
PACKAGES = " \
 plexus-utils \
 plexus-utils-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/plexus-utils-3.5.1-9.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6eaf798283f0f06e5f0e51422fd56635f2fe54dcf3fc73eb1a9d2d9e260f82a3"

URI_x86_64_v2_plexus-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plexus-utils-3.5.1-9.el10_2.noarch.rpm;name=x86_64_v2_plexus-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plexus-utils}"
SRC_URI[x86_64_v2_plexus-utils.sha256sum] = "0e05d395f8b55a153026dfa3c8010ad4245d0439c34d80e42db758da41ab8738"

URI_x86_64_v2_plexus-utils-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/plexus-utils-javadoc-3.5.1-9.el10_2.noarch.rpm;name=x86_64_v2_plexus-utils-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plexus-utils-javadoc}"
SRC_URI[x86_64_v2_plexus-utils-javadoc.sha256sum] = "046d045fce643909feecc9e8b368b5978198541c747268014c772e7983fa2b97"

URI_aarch64_plexus-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plexus-utils-3.5.1-9.el10_2.noarch.rpm;name=aarch64_plexus-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_plexus-utils}"
SRC_URI[aarch64_plexus-utils.sha256sum] = "0e05d395f8b55a153026dfa3c8010ad4245d0439c34d80e42db758da41ab8738"

URI_aarch64_plexus-utils-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/plexus-utils-javadoc-3.5.1-9.el10_2.noarch.rpm;name=aarch64_plexus-utils-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_plexus-utils-javadoc}"
SRC_URI[aarch64_plexus-utils-javadoc.sha256sum] = "046d045fce643909feecc9e8b368b5978198541c747268014c772e7983fa2b97"

RDEPENDS:plexus-utils = " \
 javapackages-filesystem \
 "
RDEPENDS:plexus-utils-javadoc = " \
 javapackages-filesystem \
 "
