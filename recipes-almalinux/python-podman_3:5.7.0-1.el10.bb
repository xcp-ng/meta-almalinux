# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-podman"
PE = "3"
PV = "5.7.0"
PR = "1.el10"
PACKAGES = " \
 python3-podman \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-podman-5.7.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "230b0af7b7eb6a83d3fc4538cf6da4231b9b8e69fc00a738e8289a83169369ef"

URI_x86_64_v2_python3-podman = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-podman-5.7.0-1.el10.noarch.rpm;name=x86_64_v2_python3-podman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-podman}"
SRC_URI[x86_64_v2_python3-podman.sha256sum] = "e52d5c2292c51b4dff2eedab72f8cd939d6ad12d447bc337bf265e1b7cf4f272"

URI_aarch64_python3-podman = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-podman-5.7.0-1.el10.noarch.rpm;name=aarch64_python3-podman;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-podman}"
SRC_URI[aarch64_python3-podman.sha256sum] = "e52d5c2292c51b4dff2eedab72f8cd939d6ad12d447bc337bf265e1b7cf4f272"

RDEPENDS:python3-podman = " \
 python3 \
 python3-requests \
 python3-urllib3 \
 "
