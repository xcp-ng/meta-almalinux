# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-kramdown"
PV = "2.4.0"
PR = "10.el10_0"
PACKAGES = " \
 rubygem-kramdown \
 rubygem-kramdown-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-kramdown-2.4.0-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e50a2c663649581c567c0dc1e52e94c948d2f9240f336f1a7f3cc3887dfb2e5"

URI_x86_64_v2_rubygem-kramdown = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-kramdown-2.4.0-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-kramdown;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-kramdown}"
SRC_URI[x86_64_v2_rubygem-kramdown.sha256sum] = "d892a0f2889db51b8d64f9bf42808a6b8a4fc6f5ab27ef59d31ae78e5fa8051c"

URI_x86_64_v2_rubygem-kramdown-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-kramdown-doc-2.4.0-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-kramdown-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-kramdown-doc}"
SRC_URI[x86_64_v2_rubygem-kramdown-doc.sha256sum] = "f328eabc180cf8945c7eccfe96d06704bf2e46746f2dafe9088b4a4f4bc8d309"

URI_aarch64_rubygem-kramdown = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-kramdown-2.4.0-10.el10_0.noarch.rpm;name=aarch64_rubygem-kramdown;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-kramdown}"
SRC_URI[aarch64_rubygem-kramdown.sha256sum] = "c8ff963402345eb7a2092a442b01d148d2c6278ab3910ad3efc6120d51eda505"

URI_aarch64_rubygem-kramdown-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-kramdown-doc-2.4.0-10.el10_0.noarch.rpm;name=aarch64_rubygem-kramdown-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-kramdown-doc}"
SRC_URI[aarch64_rubygem-kramdown-doc.sha256sum] = "0a0247331f45eea7837874157798f49cc8cf9f879c537feb76edfcfbfcebb7c4"

RDEPENDS:rubygem-kramdown = " \
 ruby \
 rubygem-rexml \
 rubygems \
 virtual/ruby_release_ \
 "
RDEPENDS:rubygem-kramdown-doc = " \
 rubygem-kramdown \
 "
