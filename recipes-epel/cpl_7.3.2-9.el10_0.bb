# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cpl"
PV = "7.3.2"
PR = "9.el10_0"
PACKAGES = " \
 cpl \
 cpl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cpl-7.3.2-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fef9bcfe58a5917ec6bc7b24ec0798706f98cb94994105b1464f46d4f1d884cc"

URI_x86_64_v2_cpl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cpl-7.3.2-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cpl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cpl}"
SRC_URI[x86_64_v2_cpl.sha256sum] = "47fe56cccdd2127017d4b63499129562bd13a05e055b83bc1463d30b559108f3"

URI_x86_64_v2_cpl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cpl-devel-7.3.2-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cpl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cpl-devel}"
SRC_URI[x86_64_v2_cpl-devel.sha256sum] = "6802afe565cdd25e61df2a423ba4786c9c300d62e47b2dbbf70101889c7cf8ec"

URI_aarch64_cpl = "${EPEL_MIRROR}/aarch64/Packages/c/cpl-7.3.2-9.el10_0.aarch64.rpm;name=aarch64_cpl;unpack=0"
SRC_URI:append = " ${URI_aarch64_cpl}"
SRC_URI[aarch64_cpl.sha256sum] = "d539cc2ae83fc18bc846ab2c6234ef40ee3dd028cd568c4556dfaa3793030813"

URI_aarch64_cpl-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cpl-devel-7.3.2-9.el10_0.aarch64.rpm;name=aarch64_cpl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cpl-devel}"
SRC_URI[aarch64_cpl-devel.sha256sum] = "494a5daa513a084a7c92de035a55d5254a78ed16a67ba3d2291a15b07cde1669"

RDEPENDS:cpl = " \
 cfitsio \
 fftw-libs-double \
 fftw-libs-single \
 glibc \
 libgcc \
 libgomp \
 wcslib \
 "
RDEPENDS:cpl-devel = " \
 cpl \
 pkgconf-pkg-config \
 "
