# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-spawn-shell"
PV = "0.3.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-colcon-spawn-shell \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-spawn-shell-0.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c205b76fc39083e4d52df8445b8a100c12d00a183ce69b9c80b3b62bc6b7e94c"

URI_x86_64_v2_python3-colcon-spawn-shell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-spawn-shell-0.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-spawn-shell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-spawn-shell}"
SRC_URI[x86_64_v2_python3-colcon-spawn-shell.sha256sum] = "1c13c38e001db13a61c21e373e4c2c5c842a700709fb1a46ee294cfd3faa1a5c"

URI_aarch64_python3-colcon-spawn-shell = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-spawn-shell-0.3.0-1.el10_0.noarch.rpm;name=aarch64_python3-colcon-spawn-shell;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-spawn-shell}"
SRC_URI[aarch64_python3-colcon-spawn-shell.sha256sum] = "1645fd491a337cad9ca20e54fd89688edb156b4c423f8ed95affcf457a4bfe42"

RDEPENDS:python3-colcon-spawn-shell = " \
 python3 \
 python3-colcon-bash \
 python3-colcon-core \
 "
