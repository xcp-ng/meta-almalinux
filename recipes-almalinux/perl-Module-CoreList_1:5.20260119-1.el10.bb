# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Module-CoreList"
PE = "1"
PV = "5.20260119"
PR = "1.el10"
PACKAGES = " \
 perl-Module-CoreList \
 perl-Module-CoreList-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Module-CoreList-5.20260119-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f023bac13c96aac9291e65011a46612adf47a5e8908eca724fa6985a5ad778f0"

URI_x86_64_v2_perl-Module-CoreList = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Module-CoreList-5.20260119-1.el10.noarch.rpm;name=x86_64_v2_perl-Module-CoreList;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Module-CoreList}"
SRC_URI[x86_64_v2_perl-Module-CoreList.sha256sum] = "e7cb5df7b068a1140cbce550a2a4409e0a3bf9cde28c78eaa16b6601ef1e431f"

URI_x86_64_v2_perl-Module-CoreList-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Module-CoreList-tools-5.20260119-1.el10.noarch.rpm;name=x86_64_v2_perl-Module-CoreList-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Module-CoreList-tools}"
SRC_URI[x86_64_v2_perl-Module-CoreList-tools.sha256sum] = "c0edcbc8fa4251294f3d411afa57db41a51091db5633402cc4ea0d4772c348d2"

URI_aarch64_perl-Module-CoreList = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Module-CoreList-5.20260119-1.el10.noarch.rpm;name=aarch64_perl-Module-CoreList;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Module-CoreList}"
SRC_URI[aarch64_perl-Module-CoreList.sha256sum] = "e7cb5df7b068a1140cbce550a2a4409e0a3bf9cde28c78eaa16b6601ef1e431f"

URI_aarch64_perl-Module-CoreList-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Module-CoreList-tools-5.20260119-1.el10.noarch.rpm;name=aarch64_perl-Module-CoreList-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Module-CoreList-tools}"
SRC_URI[aarch64_perl-Module-CoreList-tools.sha256sum] = "c0edcbc8fa4251294f3d411afa57db41a51091db5633402cc4ea0d4772c348d2"

RDEPENDS:perl-Module-CoreList = " \
 perl-Module-CoreList \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-version \
 "
RDEPENDS:perl-Module-CoreList-tools = " \
 perl-Getopt-Long \
 perl-Module-CoreList \
 perl-Pod-Usage \
 perl-Scalar-List-Utils \
 perl-interpreter \
 perl-libs \
 perl-version \
 "
