# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pandoc-cli"
PV = "3.1.11.1"
PR = "34.el10_2"
PACKAGES:x86_64_v2 = " \
 ghc-hslua-cli \
 ghc-hslua-cli-devel \
 ghc-hslua-cli-doc \
 ghc-hslua-list \
 ghc-hslua-list-devel \
 ghc-hslua-list-doc \
 ghc-hslua-module-doclayout \
 ghc-hslua-module-doclayout-devel \
 ghc-hslua-module-doclayout-doc \
 ghc-hslua-module-path \
 ghc-hslua-module-path-devel \
 ghc-hslua-module-path-doc \
 ghc-hslua-module-system \
 ghc-hslua-module-system-devel \
 ghc-hslua-module-system-doc \
 ghc-hslua-module-version \
 ghc-hslua-module-version-devel \
 ghc-hslua-module-version-doc \
 ghc-hslua-module-zip \
 ghc-hslua-module-zip-devel \
 ghc-hslua-module-zip-doc \
 ghc-hslua-repl \
 ghc-hslua-repl-devel \
 ghc-hslua-repl-doc \
 ghc-lpeg \
 ghc-lpeg-devel \
 ghc-lpeg-doc \
 ghc-pandoc-lua-engine \
 ghc-pandoc-lua-engine-devel \
 ghc-pandoc-lua-engine-doc \
 ghc-pandoc-lua-marshal \
 ghc-pandoc-lua-marshal-devel \
 ghc-pandoc-lua-marshal-doc \
 pandoc \
 pandoc-pdf \
"
PACKAGES:aarch64 = " \
 ghc-hslua-cli \
 ghc-hslua-cli-devel \
 ghc-hslua-cli-doc \
 ghc-hslua-cli-prof \
 ghc-hslua-list \
 ghc-hslua-list-devel \
 ghc-hslua-list-doc \
 ghc-hslua-list-prof \
 ghc-hslua-module-doclayout \
 ghc-hslua-module-doclayout-devel \
 ghc-hslua-module-doclayout-doc \
 ghc-hslua-module-doclayout-prof \
 ghc-hslua-module-path \
 ghc-hslua-module-path-devel \
 ghc-hslua-module-path-doc \
 ghc-hslua-module-path-prof \
 ghc-hslua-module-system \
 ghc-hslua-module-system-devel \
 ghc-hslua-module-system-doc \
 ghc-hslua-module-system-prof \
 ghc-hslua-module-version \
 ghc-hslua-module-version-devel \
 ghc-hslua-module-version-doc \
 ghc-hslua-module-version-prof \
 ghc-hslua-module-zip \
 ghc-hslua-module-zip-devel \
 ghc-hslua-module-zip-doc \
 ghc-hslua-module-zip-prof \
 ghc-hslua-repl \
 ghc-hslua-repl-devel \
 ghc-hslua-repl-doc \
 ghc-hslua-repl-prof \
 ghc-lpeg \
 ghc-lpeg-devel \
 ghc-lpeg-doc \
 ghc-lpeg-prof \
 ghc-pandoc-lua-engine \
 ghc-pandoc-lua-engine-devel \
 ghc-pandoc-lua-engine-doc \
 ghc-pandoc-lua-engine-prof \
 ghc-pandoc-lua-marshal \
 ghc-pandoc-lua-marshal-devel \
 ghc-pandoc-lua-marshal-doc \
 ghc-pandoc-lua-marshal-prof \
 pandoc \
 pandoc-pdf \
"

URI_src = "${EPELSRC_MIRROR}/Packages/p/pandoc-cli-3.1.11.1-34.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "51bc0fc29a10f52d40cc9101c40b87d8ff80295e843664e3d0ded58e2988aaa8"

URI_x86_64_v2_ghc-hslua-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-cli-1.4.3-34.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-cli}"
SRC_URI[x86_64_v2_ghc-hslua-cli.sha256sum] = "56b5a1d585512aefa371841e613cff8d739381636573a2cc29182b241b8c3380"

URI_x86_64_v2_ghc-hslua-cli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-cli-devel-1.4.3-34.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-cli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-cli-devel}"
SRC_URI[x86_64_v2_ghc-hslua-cli-devel.sha256sum] = "03183a6effe91e7d64a3a996c23a7f0b32c480518dd2ac489f0f776ce1f2d644"

URI_x86_64_v2_ghc-hslua-cli-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-cli-doc-1.4.3-34.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hslua-cli-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-cli-doc}"
SRC_URI[x86_64_v2_ghc-hslua-cli-doc.sha256sum] = "88cb90fa81459e3ff4e9b9a8340a2f46309795816668d1af549945725a6d6394"

URI_x86_64_v2_ghc-hslua-list = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-list-1.1.1-34.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-list;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-list}"
SRC_URI[x86_64_v2_ghc-hslua-list.sha256sum] = "73d9dfa7cc69d5263c4fefb1b044482eb027e4ff1698a004b34010bde7eeebb5"

URI_x86_64_v2_ghc-hslua-list-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-list-devel-1.1.1-34.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-list-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-list-devel}"
SRC_URI[x86_64_v2_ghc-hslua-list-devel.sha256sum] = "2c9916c34a3e2faf3b700b3f7eeac17940b61d24573eba7d80b139aa338d0299"

URI_x86_64_v2_ghc-hslua-list-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-list-doc-1.1.1-34.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hslua-list-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-list-doc}"
SRC_URI[x86_64_v2_ghc-hslua-list-doc.sha256sum] = "c60895f33abb289b1f2b6c3c6b539ea944b3659de314607bfc99dd0053dcb781"

URI_x86_64_v2_ghc-hslua-module-doclayout = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-doclayout-1.1.1.2-34.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-module-doclayout;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-doclayout}"
SRC_URI[x86_64_v2_ghc-hslua-module-doclayout.sha256sum] = "9dda2677c44d07a5af2bc07107bd5b09f75cc7a298a6ab9450f86a1fdd5d5447"

URI_x86_64_v2_ghc-hslua-module-doclayout-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-doclayout-devel-1.1.1.2-34.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-module-doclayout-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-doclayout-devel}"
SRC_URI[x86_64_v2_ghc-hslua-module-doclayout-devel.sha256sum] = "6578de5adf6d2270e807aba964d0b58012aeb0f951407074170b2ee5a018b40b"

URI_x86_64_v2_ghc-hslua-module-doclayout-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-doclayout-doc-1.1.1.2-34.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hslua-module-doclayout-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-doclayout-doc}"
SRC_URI[x86_64_v2_ghc-hslua-module-doclayout-doc.sha256sum] = "67ecc993bcd9499e7f9ae4d27758ac068b03238683583449fed98a88473b76d1"

URI_x86_64_v2_ghc-hslua-module-path = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-path-1.1.1-34.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-module-path;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-path}"
SRC_URI[x86_64_v2_ghc-hslua-module-path.sha256sum] = "c4e62865ce5934876810de57bcf525cc12665871c612325e747607304a7e9884"

URI_x86_64_v2_ghc-hslua-module-path-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-path-devel-1.1.1-34.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-module-path-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-path-devel}"
SRC_URI[x86_64_v2_ghc-hslua-module-path-devel.sha256sum] = "9c08fbbf914e1b2080cd224319948c0c8622bbc8e95a9806966ee661b8181c81"

URI_x86_64_v2_ghc-hslua-module-path-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-path-doc-1.1.1-34.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hslua-module-path-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-path-doc}"
SRC_URI[x86_64_v2_ghc-hslua-module-path-doc.sha256sum] = "be8ce625362497a142cde2054e22129f3809f3a74d2db5402a50067c53a065a0"

URI_x86_64_v2_ghc-hslua-module-system = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-system-1.1.2-34.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-module-system;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-system}"
SRC_URI[x86_64_v2_ghc-hslua-module-system.sha256sum] = "667be5c1729087d558a914a4a0b6a55f19cb0a8f0ab3036f1712ad3684d195e7"

URI_x86_64_v2_ghc-hslua-module-system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-system-devel-1.1.2-34.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-module-system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-system-devel}"
SRC_URI[x86_64_v2_ghc-hslua-module-system-devel.sha256sum] = "582e967d14af98ed88203b87cd946a40c32e2a3fa609fd6d946eab72cb9f6db5"

URI_x86_64_v2_ghc-hslua-module-system-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-system-doc-1.1.2-34.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hslua-module-system-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-system-doc}"
SRC_URI[x86_64_v2_ghc-hslua-module-system-doc.sha256sum] = "0c4e36901a6fb6a682c4462a26496515dbd2ca2589d02d044e1314c91c59a211"

URI_x86_64_v2_ghc-hslua-module-version = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-version-1.1.1-34.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-module-version;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-version}"
SRC_URI[x86_64_v2_ghc-hslua-module-version.sha256sum] = "ed2ed2ad9aedab9f37b0da4919237eea4670e5792eceac1151adb61362c6bd67"

URI_x86_64_v2_ghc-hslua-module-version-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-version-devel-1.1.1-34.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-module-version-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-version-devel}"
SRC_URI[x86_64_v2_ghc-hslua-module-version-devel.sha256sum] = "4fc144cd9e9cdf7e111717c1431b058409f8d7898424b7df7fa961d43d6b7d74"

URI_x86_64_v2_ghc-hslua-module-version-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-version-doc-1.1.1-34.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hslua-module-version-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-version-doc}"
SRC_URI[x86_64_v2_ghc-hslua-module-version-doc.sha256sum] = "6c3fd78dde0a3073aa9293ee8497a2ac1550748deb680ba5a812411496781522"

URI_x86_64_v2_ghc-hslua-module-zip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-zip-1.1.3-34.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-module-zip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-zip}"
SRC_URI[x86_64_v2_ghc-hslua-module-zip.sha256sum] = "40623cf0a9a50be7aba862d170c6f2828406b66c4204afdfe35110f18ba52bcd"

URI_x86_64_v2_ghc-hslua-module-zip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-zip-devel-1.1.3-34.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-module-zip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-zip-devel}"
SRC_URI[x86_64_v2_ghc-hslua-module-zip-devel.sha256sum] = "b35525b5467ddef8972d5927a2bcf23da55a1666fe8f094a9bd90fcf0572b28b"

URI_x86_64_v2_ghc-hslua-module-zip-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-zip-doc-1.1.3-34.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hslua-module-zip-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-zip-doc}"
SRC_URI[x86_64_v2_ghc-hslua-module-zip-doc.sha256sum] = "a3f4d8ede1148c5ebaedca32db64c004680dc730c2453f6a1189912bfcfda067"

URI_x86_64_v2_ghc-hslua-repl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-repl-0.1.2-34.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-repl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-repl}"
SRC_URI[x86_64_v2_ghc-hslua-repl.sha256sum] = "69cb9ae16153dccb7edb59c13a7d3e77debc6b995d5949ebce7a9e541e441c5b"

URI_x86_64_v2_ghc-hslua-repl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-repl-devel-0.1.2-34.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-repl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-repl-devel}"
SRC_URI[x86_64_v2_ghc-hslua-repl-devel.sha256sum] = "a552279c54114184137d38014b5f57ca8a9a6e81f20f027f5db18be7b9196554"

URI_x86_64_v2_ghc-hslua-repl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-repl-doc-0.1.2-34.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hslua-repl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-repl-doc}"
SRC_URI[x86_64_v2_ghc-hslua-repl-doc.sha256sum] = "49fa600f8573993575690fca10741e553edba43c26382e691de098c655e00b54"

URI_x86_64_v2_ghc-lpeg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-lpeg-1.0.4-34.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-lpeg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-lpeg}"
SRC_URI[x86_64_v2_ghc-lpeg.sha256sum] = "3f71dcac52b65543d4a0723920d8ef511bf377f0d72274c211d872bd85525dcd"

URI_x86_64_v2_ghc-lpeg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-lpeg-devel-1.0.4-34.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-lpeg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-lpeg-devel}"
SRC_URI[x86_64_v2_ghc-lpeg-devel.sha256sum] = "216ce1a52722677e2564a3ab4b9c41efe3dc30280ac95e52f1452e459cf7c8a1"

URI_x86_64_v2_ghc-lpeg-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-lpeg-doc-1.0.4-34.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-lpeg-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-lpeg-doc}"
SRC_URI[x86_64_v2_ghc-lpeg-doc.sha256sum] = "84a4fabf551b2d76b32e1f679e239b0392eaca898224fe18ec81cee6eb797f7d"

URI_x86_64_v2_ghc-pandoc-lua-engine = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pandoc-lua-engine-0.2.1.2-34.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pandoc-lua-engine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pandoc-lua-engine}"
SRC_URI[x86_64_v2_ghc-pandoc-lua-engine.sha256sum] = "d267f29e5ececf164a9ff2ecce42f00d29333844541a485d0026c91b3792e210"

URI_x86_64_v2_ghc-pandoc-lua-engine-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pandoc-lua-engine-devel-0.2.1.2-34.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pandoc-lua-engine-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pandoc-lua-engine-devel}"
SRC_URI[x86_64_v2_ghc-pandoc-lua-engine-devel.sha256sum] = "55c42f21991500a6793d0d3595772d82c75c078f3384e8d1c92241603dcd6813"

URI_x86_64_v2_ghc-pandoc-lua-engine-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pandoc-lua-engine-doc-0.2.1.2-34.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-pandoc-lua-engine-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pandoc-lua-engine-doc}"
SRC_URI[x86_64_v2_ghc-pandoc-lua-engine-doc.sha256sum] = "ce8fa3c50fef0d11bd3b9e20e706a50b109823cdc16dac0495cfbfd447f75f7e"

URI_x86_64_v2_ghc-pandoc-lua-marshal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pandoc-lua-marshal-0.2.7.1-34.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pandoc-lua-marshal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pandoc-lua-marshal}"
SRC_URI[x86_64_v2_ghc-pandoc-lua-marshal.sha256sum] = "eee6d2e393e63fd4d2bc8e5ba06a2a260b3b8bb6f0fb29220ec3ac656af9f79e"

URI_x86_64_v2_ghc-pandoc-lua-marshal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pandoc-lua-marshal-devel-0.2.7.1-34.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pandoc-lua-marshal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pandoc-lua-marshal-devel}"
SRC_URI[x86_64_v2_ghc-pandoc-lua-marshal-devel.sha256sum] = "23ac589d13cca4f8b256736d112718250c524c519a9cd1fa5c17f2f50a435225"

URI_x86_64_v2_ghc-pandoc-lua-marshal-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pandoc-lua-marshal-doc-0.2.7.1-34.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-pandoc-lua-marshal-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pandoc-lua-marshal-doc}"
SRC_URI[x86_64_v2_ghc-pandoc-lua-marshal-doc.sha256sum] = "fdb5788e8ee5149fd7d5e1b4dd53dc1e09978176013a274886a64aceec7d3e6f"

URI_x86_64_v2_pandoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pandoc-3.1.11.1-34.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pandoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pandoc}"
SRC_URI[x86_64_v2_pandoc.sha256sum] = "a962c22e58e9fa9df36acb1c93eb1a79250e2f915a4982a8d33a217024d21cc1"

URI_x86_64_v2_pandoc-pdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pandoc-pdf-3.1.11.1-34.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pandoc-pdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pandoc-pdf}"
SRC_URI[x86_64_v2_pandoc-pdf.sha256sum] = "2a933b9e0527d01538a7ab5392900cdab0a4170d32fcc4f6c40ddcf6f2a1c213"

URI_aarch64_ghc-hslua-cli = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-cli-1.4.3-34.el10_2.aarch64.rpm;name=aarch64_ghc-hslua-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-cli}"
SRC_URI[aarch64_ghc-hslua-cli.sha256sum] = "641e25c7995d22d8823b81199ee4bd599fb7bb2d58bafb6f5d6812a79339566c"

URI_aarch64_ghc-hslua-cli-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-cli-devel-1.4.3-34.el10_2.aarch64.rpm;name=aarch64_ghc-hslua-cli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-cli-devel}"
SRC_URI[aarch64_ghc-hslua-cli-devel.sha256sum] = "21bf8b0fb77ad698900e59633ba814d0fbd89a52e3774ca6911b29b52ba1ffa2"

URI_aarch64_ghc-hslua-cli-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-cli-doc-1.4.3-34.el10_2.noarch.rpm;name=aarch64_ghc-hslua-cli-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-cli-doc}"
SRC_URI[aarch64_ghc-hslua-cli-doc.sha256sum] = "d52b0d5c9948a0412032ed347573652fd46f5d61b160c03aa8c740c409e0d884"

URI_aarch64_ghc-hslua-cli-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-cli-prof-1.4.3-34.el10_2.aarch64.rpm;name=aarch64_ghc-hslua-cli-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-cli-prof}"
SRC_URI[aarch64_ghc-hslua-cli-prof.sha256sum] = "58e30772d8d7e72e1b489408e09e8e6f66b6d9567447ec4cc5e25709acb0da2a"

URI_aarch64_ghc-hslua-list = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-list-1.1.1-34.el10_2.aarch64.rpm;name=aarch64_ghc-hslua-list;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-list}"
SRC_URI[aarch64_ghc-hslua-list.sha256sum] = "5d9c9462e686e133da2e1f5b036268f88ac0cf85cd3932b0c25b879a1a18f302"

URI_aarch64_ghc-hslua-list-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-list-devel-1.1.1-34.el10_2.aarch64.rpm;name=aarch64_ghc-hslua-list-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-list-devel}"
SRC_URI[aarch64_ghc-hslua-list-devel.sha256sum] = "897c5b16f8fe8cb03c0356f40f38db5d6585950f76cf8ee122cf804738ae857a"

URI_aarch64_ghc-hslua-list-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-list-doc-1.1.1-34.el10_2.noarch.rpm;name=aarch64_ghc-hslua-list-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-list-doc}"
SRC_URI[aarch64_ghc-hslua-list-doc.sha256sum] = "eb3f421e2e156b32b4435b3b7461b1415a08949fee89f34ae9ebc8c61c7208b7"

URI_aarch64_ghc-hslua-list-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-list-prof-1.1.1-34.el10_2.aarch64.rpm;name=aarch64_ghc-hslua-list-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-list-prof}"
SRC_URI[aarch64_ghc-hslua-list-prof.sha256sum] = "dc622c039851409448949c1c5858950b3583b504bb13af35e2efe1236284edc0"

URI_aarch64_ghc-hslua-module-doclayout = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-doclayout-1.1.1.2-34.el10_2.aarch64.rpm;name=aarch64_ghc-hslua-module-doclayout;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-doclayout}"
SRC_URI[aarch64_ghc-hslua-module-doclayout.sha256sum] = "d9daa0fa07e1c1ce785bf7322a65a775fc47fcee6a1b0a3a635796c092cd7feb"

URI_aarch64_ghc-hslua-module-doclayout-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-doclayout-devel-1.1.1.2-34.el10_2.aarch64.rpm;name=aarch64_ghc-hslua-module-doclayout-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-doclayout-devel}"
SRC_URI[aarch64_ghc-hslua-module-doclayout-devel.sha256sum] = "16f4d936c0dce3a60dffa0b58d08b62cb23e075a1678836978cf52f9a5a6b389"

URI_aarch64_ghc-hslua-module-doclayout-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-doclayout-doc-1.1.1.2-34.el10_2.noarch.rpm;name=aarch64_ghc-hslua-module-doclayout-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-doclayout-doc}"
SRC_URI[aarch64_ghc-hslua-module-doclayout-doc.sha256sum] = "6bb281445334f00858b14a58469c526e86a03578ae2a625d6cff0f1933a7f87a"

URI_aarch64_ghc-hslua-module-doclayout-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-doclayout-prof-1.1.1.2-34.el10_2.aarch64.rpm;name=aarch64_ghc-hslua-module-doclayout-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-doclayout-prof}"
SRC_URI[aarch64_ghc-hslua-module-doclayout-prof.sha256sum] = "b37faab76a0674dff577fe338a30b40bc330a946786c25ff00301a0933c7967e"

URI_aarch64_ghc-hslua-module-path = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-path-1.1.1-34.el10_2.aarch64.rpm;name=aarch64_ghc-hslua-module-path;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-path}"
SRC_URI[aarch64_ghc-hslua-module-path.sha256sum] = "6d8f72eda02b59c4bf987acac6fdaaf49fc5efd03c237072150fa187c4698503"

URI_aarch64_ghc-hslua-module-path-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-path-devel-1.1.1-34.el10_2.aarch64.rpm;name=aarch64_ghc-hslua-module-path-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-path-devel}"
SRC_URI[aarch64_ghc-hslua-module-path-devel.sha256sum] = "71c647fcd8c1e8e2b975f777f61a3eaf7ccee239eb94f5a2f23c2a2cfdd75da1"

URI_aarch64_ghc-hslua-module-path-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-path-doc-1.1.1-34.el10_2.noarch.rpm;name=aarch64_ghc-hslua-module-path-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-path-doc}"
SRC_URI[aarch64_ghc-hslua-module-path-doc.sha256sum] = "d641b5491c662ca750b501867664bae6b6905358b303a9ec4ba60dd4a2d1c538"

URI_aarch64_ghc-hslua-module-path-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-path-prof-1.1.1-34.el10_2.aarch64.rpm;name=aarch64_ghc-hslua-module-path-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-path-prof}"
SRC_URI[aarch64_ghc-hslua-module-path-prof.sha256sum] = "2a2d2f8decd47af645f1f0eb9abf8b9fe606b80411bc4ebb7a12595118b964a5"

URI_aarch64_ghc-hslua-module-system = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-system-1.1.2-34.el10_2.aarch64.rpm;name=aarch64_ghc-hslua-module-system;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-system}"
SRC_URI[aarch64_ghc-hslua-module-system.sha256sum] = "fdc918f5f437c094e81379e50fba8ab93f7c8322222ed0f2e5a436b04cf682ba"

URI_aarch64_ghc-hslua-module-system-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-system-devel-1.1.2-34.el10_2.aarch64.rpm;name=aarch64_ghc-hslua-module-system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-system-devel}"
SRC_URI[aarch64_ghc-hslua-module-system-devel.sha256sum] = "2a57c0c3e122df76cfeab671d9e7c0b5c3f2577b0e18909fe360972fabef2f9a"

URI_aarch64_ghc-hslua-module-system-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-system-doc-1.1.2-34.el10_2.noarch.rpm;name=aarch64_ghc-hslua-module-system-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-system-doc}"
SRC_URI[aarch64_ghc-hslua-module-system-doc.sha256sum] = "77d8e2e291dca922c01f2f837b16923cf8329406a630bcc112da5b536d6e913a"

URI_aarch64_ghc-hslua-module-system-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-system-prof-1.1.2-34.el10_2.aarch64.rpm;name=aarch64_ghc-hslua-module-system-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-system-prof}"
SRC_URI[aarch64_ghc-hslua-module-system-prof.sha256sum] = "ba9c9991c90b505f175a5f776f68ba1d0fee3293e9bdd8d8bcef107b63970fa4"

URI_aarch64_ghc-hslua-module-version = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-version-1.1.1-34.el10_2.aarch64.rpm;name=aarch64_ghc-hslua-module-version;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-version}"
SRC_URI[aarch64_ghc-hslua-module-version.sha256sum] = "55156b1d00721f0f2aec5441f5953309fd541325ef59de3811fb720e951016ed"

URI_aarch64_ghc-hslua-module-version-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-version-devel-1.1.1-34.el10_2.aarch64.rpm;name=aarch64_ghc-hslua-module-version-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-version-devel}"
SRC_URI[aarch64_ghc-hslua-module-version-devel.sha256sum] = "2a8010406e59b7c29b1e4e945aec050f0570738c334f2867310a3b4f87a7cf4c"

URI_aarch64_ghc-hslua-module-version-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-version-doc-1.1.1-34.el10_2.noarch.rpm;name=aarch64_ghc-hslua-module-version-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-version-doc}"
SRC_URI[aarch64_ghc-hslua-module-version-doc.sha256sum] = "7a41eeaf014034ea04b4beff2e2961c6d952f0e01bef8bbbda8a4e6ffef471f5"

URI_aarch64_ghc-hslua-module-version-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-version-prof-1.1.1-34.el10_2.aarch64.rpm;name=aarch64_ghc-hslua-module-version-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-version-prof}"
SRC_URI[aarch64_ghc-hslua-module-version-prof.sha256sum] = "340dc9a41dbe19af3d62a7f3d2f2d572302768c60f27fcac6056e986b06f007e"

URI_aarch64_ghc-hslua-module-zip = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-zip-1.1.3-34.el10_2.aarch64.rpm;name=aarch64_ghc-hslua-module-zip;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-zip}"
SRC_URI[aarch64_ghc-hslua-module-zip.sha256sum] = "0f09e3b9f6dd7242d9c0b82ee47d2cbbba5f0b330f09b3a1725822929028b65a"

URI_aarch64_ghc-hslua-module-zip-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-zip-devel-1.1.3-34.el10_2.aarch64.rpm;name=aarch64_ghc-hslua-module-zip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-zip-devel}"
SRC_URI[aarch64_ghc-hslua-module-zip-devel.sha256sum] = "7c33994142445ab808c49ae9e3908c8198b48ddfdf7e3478c6bb3032ca5d3616"

URI_aarch64_ghc-hslua-module-zip-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-zip-doc-1.1.3-34.el10_2.noarch.rpm;name=aarch64_ghc-hslua-module-zip-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-zip-doc}"
SRC_URI[aarch64_ghc-hslua-module-zip-doc.sha256sum] = "74f3a6f680c8208139ffc98293c2532e363b63208b939440d61beb25d57f3b0d"

URI_aarch64_ghc-hslua-module-zip-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-zip-prof-1.1.3-34.el10_2.aarch64.rpm;name=aarch64_ghc-hslua-module-zip-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-zip-prof}"
SRC_URI[aarch64_ghc-hslua-module-zip-prof.sha256sum] = "8d109d0373ff46bb94f903f610f8bbb219174cc1e93214352dffa05a1c89a51b"

URI_aarch64_ghc-hslua-repl = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-repl-0.1.2-34.el10_2.aarch64.rpm;name=aarch64_ghc-hslua-repl;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-repl}"
SRC_URI[aarch64_ghc-hslua-repl.sha256sum] = "cf3012a08489ac1c4df3f11ef770b3923c2c93cc26e49b991e6a5a2518f5c464"

URI_aarch64_ghc-hslua-repl-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-repl-devel-0.1.2-34.el10_2.aarch64.rpm;name=aarch64_ghc-hslua-repl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-repl-devel}"
SRC_URI[aarch64_ghc-hslua-repl-devel.sha256sum] = "a157d2d67e8abfcf9b809110361c6459201fa0e997f7b3eb563350fa34d85dc3"

URI_aarch64_ghc-hslua-repl-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-repl-doc-0.1.2-34.el10_2.noarch.rpm;name=aarch64_ghc-hslua-repl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-repl-doc}"
SRC_URI[aarch64_ghc-hslua-repl-doc.sha256sum] = "2056debf3b6cadb69a219b43e6fecf3d5bf35c3076de301f8f0e1e1849de2635"

URI_aarch64_ghc-hslua-repl-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-repl-prof-0.1.2-34.el10_2.aarch64.rpm;name=aarch64_ghc-hslua-repl-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-repl-prof}"
SRC_URI[aarch64_ghc-hslua-repl-prof.sha256sum] = "84209edd7c8d5674e202f4bef1d19372e0d9fe70236a2170ea6a793606badc5f"

URI_aarch64_ghc-lpeg = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-lpeg-1.0.4-34.el10_2.aarch64.rpm;name=aarch64_ghc-lpeg;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-lpeg}"
SRC_URI[aarch64_ghc-lpeg.sha256sum] = "11228ba8ec956ba10da67567b3234709f2dbbc3c6f056ca889fde3871e3357f7"

URI_aarch64_ghc-lpeg-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-lpeg-devel-1.0.4-34.el10_2.aarch64.rpm;name=aarch64_ghc-lpeg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-lpeg-devel}"
SRC_URI[aarch64_ghc-lpeg-devel.sha256sum] = "6e346f9e12ebae7df00b973aa63ae795be5fc82bebe12a23a0550e47f158b3c0"

URI_aarch64_ghc-lpeg-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-lpeg-doc-1.0.4-34.el10_2.noarch.rpm;name=aarch64_ghc-lpeg-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-lpeg-doc}"
SRC_URI[aarch64_ghc-lpeg-doc.sha256sum] = "ecd132e6cce5a4ade91325895997680a2877f9d853a4180724a7206687796a4f"

URI_aarch64_ghc-lpeg-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-lpeg-prof-1.0.4-34.el10_2.aarch64.rpm;name=aarch64_ghc-lpeg-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-lpeg-prof}"
SRC_URI[aarch64_ghc-lpeg-prof.sha256sum] = "04e48c8c396db022f7c5b0887feeb38b7093b5219da0fb8549d2ecce8b317db1"

URI_aarch64_ghc-pandoc-lua-engine = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pandoc-lua-engine-0.2.1.2-34.el10_2.aarch64.rpm;name=aarch64_ghc-pandoc-lua-engine;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pandoc-lua-engine}"
SRC_URI[aarch64_ghc-pandoc-lua-engine.sha256sum] = "46febd97e48f5b993ba6a01bbb272e563baf72686c628930a9794bdf65a36433"

URI_aarch64_ghc-pandoc-lua-engine-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pandoc-lua-engine-devel-0.2.1.2-34.el10_2.aarch64.rpm;name=aarch64_ghc-pandoc-lua-engine-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pandoc-lua-engine-devel}"
SRC_URI[aarch64_ghc-pandoc-lua-engine-devel.sha256sum] = "34714a70cf632f8704f0e74f406932fca0ed5754a96bef654cf76835ba0d2e47"

URI_aarch64_ghc-pandoc-lua-engine-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pandoc-lua-engine-doc-0.2.1.2-34.el10_2.noarch.rpm;name=aarch64_ghc-pandoc-lua-engine-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pandoc-lua-engine-doc}"
SRC_URI[aarch64_ghc-pandoc-lua-engine-doc.sha256sum] = "1e87b7167b3e940a0aa2e58dc6fa3cbb465652467055a039e1e4b99694ea9040"

URI_aarch64_ghc-pandoc-lua-engine-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pandoc-lua-engine-prof-0.2.1.2-34.el10_2.aarch64.rpm;name=aarch64_ghc-pandoc-lua-engine-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pandoc-lua-engine-prof}"
SRC_URI[aarch64_ghc-pandoc-lua-engine-prof.sha256sum] = "5c36fdfcfa7ebbcb9e47a80132604f0cc2bbf025955e49bdfa836273d212b6f0"

URI_aarch64_ghc-pandoc-lua-marshal = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pandoc-lua-marshal-0.2.7.1-34.el10_2.aarch64.rpm;name=aarch64_ghc-pandoc-lua-marshal;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pandoc-lua-marshal}"
SRC_URI[aarch64_ghc-pandoc-lua-marshal.sha256sum] = "7bee67cc2c0e9af68626a3c31a06a2137f155db1d78ea2a63f7fa0c98c752319"

URI_aarch64_ghc-pandoc-lua-marshal-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pandoc-lua-marshal-devel-0.2.7.1-34.el10_2.aarch64.rpm;name=aarch64_ghc-pandoc-lua-marshal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pandoc-lua-marshal-devel}"
SRC_URI[aarch64_ghc-pandoc-lua-marshal-devel.sha256sum] = "b6f15132c02f73e4dd2d04e387c937a7358eccb9caad458e2bd4de0f81dd1fa1"

URI_aarch64_ghc-pandoc-lua-marshal-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pandoc-lua-marshal-doc-0.2.7.1-34.el10_2.noarch.rpm;name=aarch64_ghc-pandoc-lua-marshal-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pandoc-lua-marshal-doc}"
SRC_URI[aarch64_ghc-pandoc-lua-marshal-doc.sha256sum] = "a1483db80f1730a1c274d5cdfaa57dfa1bdb6edcd9bad92fab3cb5a5a25df35d"

URI_aarch64_ghc-pandoc-lua-marshal-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pandoc-lua-marshal-prof-0.2.7.1-34.el10_2.aarch64.rpm;name=aarch64_ghc-pandoc-lua-marshal-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pandoc-lua-marshal-prof}"
SRC_URI[aarch64_ghc-pandoc-lua-marshal-prof.sha256sum] = "3fd362aa9e54d65ac4906041aa02bd159e023f8cc270a26942a82400c89716c1"

URI_aarch64_pandoc = "${EPEL_MIRROR}/aarch64/Packages/p/pandoc-3.1.11.1-34.el10_2.aarch64.rpm;name=aarch64_pandoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pandoc}"
SRC_URI[aarch64_pandoc.sha256sum] = "f72f00756a24f1b088cc2af5120df4acfef90306c909b0b2bb4dd1710e3453f5"

URI_aarch64_pandoc-pdf = "${EPEL_MIRROR}/aarch64/Packages/p/pandoc-pdf-3.1.11.1-34.el10_2.aarch64.rpm;name=aarch64_pandoc-pdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_pandoc-pdf}"
SRC_URI[aarch64_pandoc-pdf.sha256sum] = "336c3d51c98fbbcb801077edc51c3b843488a562c5a3f394556d1efdbb0a072f"

RDEPENDS:ghc-hslua-cli = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hslua-core \
 ghc-hslua-marshalling \
 ghc-hslua-repl \
 ghc-isocline \
 ghc-lua \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hslua-cli-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-hslua-cli \
 ghc-hslua-core-devel \
 ghc-hslua-marshalling-devel \
 ghc-hslua-repl-devel \
 ghc-lua-devel \
 ghc-text-devel \
 ghc-unix-devel \
 "
RDEPENDS:ghc-hslua-cli-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hslua-list = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hslua-core \
 ghc-lua \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hslua-list-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-hslua-core-devel \
 ghc-hslua-list \
 "
RDEPENDS:ghc-hslua-list-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hslua-module-doclayout = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-array \
 ghc-assoc \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-bifunctors \
 ghc-binary \
 ghc-bytestring \
 ghc-comonad \
 ghc-containers \
 ghc-contravariant \
 ghc-data-fix \
 ghc-deepseq \
 ghc-distributive \
 ghc-dlist \
 ghc-doclayout \
 ghc-emojis \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hslua \
 ghc-hslua-aeson \
 ghc-hslua-classes \
 ghc-hslua-core \
 ghc-hslua-marshalling \
 ghc-hslua-objectorientation \
 ghc-hslua-packaging \
 ghc-hslua-typing \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-lua \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-random \
 ghc-safe \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-splitmix \
 ghc-stm \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-stream \
 ghc-witherable \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hslua-module-doclayout-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-doclayout-devel \
 ghc-hslua-devel \
 ghc-hslua-module-doclayout \
 ghc-text-devel \
 "
RDEPENDS:ghc-hslua-module-doclayout-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hslua-module-path = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hslua-core \
 ghc-hslua-marshalling \
 ghc-hslua-objectorientation \
 ghc-hslua-packaging \
 ghc-hslua-typing \
 ghc-lua \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hslua-module-path-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-filepath-devel \
 ghc-hslua-core-devel \
 ghc-hslua-marshalling-devel \
 ghc-hslua-module-path \
 ghc-hslua-packaging-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-hslua-module-path-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hslua-module-system = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hslua-core \
 ghc-hslua-marshalling \
 ghc-hslua-objectorientation \
 ghc-hslua-packaging \
 ghc-hslua-typing \
 ghc-lua \
 ghc-mtl \
 ghc-pretty \
 ghc-random \
 ghc-splitmix \
 ghc-stm \
 ghc-template-haskell \
 ghc-temporary \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hslua-module-system-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-directory-devel \
 ghc-exceptions-devel \
 ghc-hslua-core-devel \
 ghc-hslua-marshalling-devel \
 ghc-hslua-module-system \
 ghc-hslua-packaging-devel \
 ghc-temporary-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-hslua-module-system-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hslua-module-version = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hslua-core \
 ghc-hslua-marshalling \
 ghc-hslua-objectorientation \
 ghc-hslua-packaging \
 ghc-hslua-typing \
 ghc-lua \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hslua-module-version-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-filepath-devel \
 ghc-hslua-core-devel \
 ghc-hslua-marshalling-devel \
 ghc-hslua-module-version \
 ghc-hslua-packaging-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-hslua-module-version-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hslua-module-zip = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-digest \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hslua-core \
 ghc-hslua-list \
 ghc-hslua-marshalling \
 ghc-hslua-objectorientation \
 ghc-hslua-packaging \
 ghc-hslua-typing \
 ghc-lua \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 ghc-zip-archive \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-hslua-module-zip-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-filepath-devel \
 ghc-hslua-core-devel \
 ghc-hslua-list-devel \
 ghc-hslua-marshalling-devel \
 ghc-hslua-module-zip \
 ghc-hslua-packaging-devel \
 ghc-hslua-typing-devel \
 ghc-text-devel \
 ghc-time-devel \
 ghc-zip-archive-devel \
 "
RDEPENDS:ghc-hslua-module-zip-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hslua-repl = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hslua-core \
 ghc-isocline \
 ghc-lua \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hslua-repl-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-hslua-core-devel \
 ghc-hslua-repl \
 ghc-isocline-devel \
 ghc-lua-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-hslua-repl-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-lpeg = " \
 ghc-base \
 ghc-ghc-bignum \
 ghc-lua \
 glibc \
 gmp \
 "
RDEPENDS:ghc-lpeg-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-lpeg \
 ghc-lua-devel \
 "
RDEPENDS:ghc-lpeg-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-pandoc-lua-engine = " \
 ghc-Glob \
 ghc-JuicyPixels \
 ghc-OneTuple \
 ghc-Only \
 ghc-QuickCheck \
 ghc-SHA \
 ghc-StateVar \
 ghc-aeson \
 ghc-aeson-pretty \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-appar \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base16-bytestring \
 ghc-base64-bytestring \
 ghc-basement \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-byteorder \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-cassava \
 ghc-cereal \
 ghc-citeproc \
 ghc-colour \
 ghc-commonmark \
 ghc-commonmark-extensions \
 ghc-commonmark-pandoc \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-crypton \
 ghc-crypton-connection \
 ghc-crypton-x509 \
 ghc-crypton-x509-store \
 ghc-crypton-x509-system \
 ghc-crypton-x509-validation \
 ghc-data-default \
 ghc-data-default-class \
 ghc-data-default-instances-containers \
 ghc-data-default-instances-dlist \
 ghc-data-default-instances-old-locale \
 ghc-data-fix \
 ghc-deepseq \
 ghc-digest \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-doclayout \
 ghc-doctemplates \
 ghc-emojis \
 ghc-exceptions \
 ghc-file-embed \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-gridtables \
 ghc-haddock-library \
 ghc-hashable \
 ghc-haskell-lexer \
 ghc-hourglass \
 ghc-hslua \
 ghc-hslua-aeson \
 ghc-hslua-classes \
 ghc-hslua-core \
 ghc-hslua-list \
 ghc-hslua-marshalling \
 ghc-hslua-module-doclayout \
 ghc-hslua-module-path \
 ghc-hslua-module-system \
 ghc-hslua-module-text \
 ghc-hslua-module-version \
 ghc-hslua-module-zip \
 ghc-hslua-objectorientation \
 ghc-hslua-packaging \
 ghc-hslua-repl \
 ghc-hslua-typing \
 ghc-http-client \
 ghc-http-client-tls \
 ghc-http-types \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-iproute \
 ghc-ipynb \
 ghc-isocline \
 ghc-jira-wiki-markup \
 ghc-libyaml \
 ghc-lpeg \
 ghc-lua \
 ghc-memory \
 ghc-mime-types \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-network-uri \
 ghc-old-locale \
 ghc-old-time \
 ghc-ordered-containers \
 ghc-os-string \
 ghc-pandoc \
 ghc-pandoc-lua-marshal \
 ghc-pandoc-types \
 ghc-parsec \
 ghc-pem \
 ghc-pretty \
 ghc-pretty-show \
 ghc-prettyprinter \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-regex-base \
 ghc-regex-tdfa \
 ghc-resourcet \
 ghc-safe \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-skylighting \
 ghc-skylighting-core \
 ghc-skylighting-format-ansi \
 ghc-skylighting-format-blaze-html \
 ghc-skylighting-format-context \
 ghc-skylighting-format-latex \
 ghc-socks \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-syb \
 ghc-tagged \
 ghc-tagsoup \
 ghc-template-haskell \
 ghc-temporary \
 ghc-texmath \
 ghc-text \
 ghc-text-conversions \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-compat \
 ghc-th-lift \
 ghc-th-lift-instances \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-tls \
 ghc-toml-parser \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-typst \
 ghc-typst-symbols \
 ghc-unicode-collation \
 ghc-unicode-data \
 ghc-unicode-transforms \
 ghc-uniplate \
 ghc-unix \
 ghc-unix-time \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-utf8-string \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-witherable \
 ghc-xml \
 ghc-xml-conduit \
 ghc-xml-types \
 ghc-yaml \
 ghc-zip-archive \
 ghc-zlib \
 glibc \
 gmp \
 libyaml \
 zlib-ng-compat \
 "
RDEPENDS:ghc-pandoc-lua-engine-devel = " \
 ghc-SHA-devel \
 ghc-aeson-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-citeproc-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-data-default-devel \
 ghc-doclayout-devel \
 ghc-doctemplates-devel \
 ghc-exceptions-devel \
 ghc-hslua-devel \
 ghc-hslua-module-doclayout-devel \
 ghc-hslua-module-path-devel \
 ghc-hslua-module-system-devel \
 ghc-hslua-module-text-devel \
 ghc-hslua-module-version-devel \
 ghc-hslua-module-zip-devel \
 ghc-hslua-repl-devel \
 ghc-lpeg-devel \
 ghc-mtl-devel \
 ghc-pandoc-devel \
 ghc-pandoc-lua-engine \
 ghc-pandoc-lua-marshal-devel \
 ghc-pandoc-types-devel \
 ghc-parsec-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-pandoc-lua-engine-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-pandoc-lua-marshal = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-array \
 ghc-assoc \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-bifunctors \
 ghc-binary \
 ghc-bytestring \
 ghc-comonad \
 ghc-containers \
 ghc-contravariant \
 ghc-data-fix \
 ghc-deepseq \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hslua \
 ghc-hslua-aeson \
 ghc-hslua-classes \
 ghc-hslua-core \
 ghc-hslua-list \
 ghc-hslua-marshalling \
 ghc-hslua-objectorientation \
 ghc-hslua-packaging \
 ghc-hslua-typing \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-lua \
 ghc-mtl \
 ghc-os-string \
 ghc-pandoc-types \
 ghc-pretty \
 ghc-primitive \
 ghc-random \
 ghc-safe \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-splitmix \
 ghc-stm \
 ghc-strict \
 ghc-syb \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-stream \
 ghc-witherable \
 glibc \
 gmp \
 "
RDEPENDS:ghc-pandoc-lua-marshal-devel = " \
 ghc-aeson-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-exceptions-devel \
 ghc-hslua-devel \
 ghc-hslua-list-devel \
 ghc-hslua-marshalling-devel \
 ghc-pandoc-lua-marshal \
 ghc-pandoc-types-devel \
 ghc-safe-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-pandoc-lua-marshal-doc = " \
 ghc-filesystem \
 "
RDEPENDS:pandoc = " \
 glibc \
 gmp \
 libffi \
 libyaml \
 pandoc-common \
 zlib-ng-compat \
 "
RDEPENDS:pandoc-pdf = " \
 pandoc \
 texlive-collection-latex \
 texlive-ec \
 "
RDEPENDS:ghc-hslua-cli-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-hslua-cli-devel \
 ghc-hslua-core-prof \
 ghc-hslua-marshalling-prof \
 ghc-hslua-repl-prof \
 ghc-lua-prof \
 ghc-text-prof \
 ghc-unix-prof \
 "
RDEPENDS:ghc-hslua-list-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-hslua-core-prof \
 ghc-hslua-list-devel \
 "
RDEPENDS:ghc-hslua-module-doclayout-prof = " \
 ghc-base-prof \
 ghc-doclayout-prof \
 ghc-hslua-module-doclayout-devel \
 ghc-hslua-prof \
 ghc-text-prof \
 "
RDEPENDS:ghc-hslua-module-path-prof = " \
 ghc-base-prof \
 ghc-filepath-prof \
 ghc-hslua-core-prof \
 ghc-hslua-marshalling-prof \
 ghc-hslua-module-path-devel \
 ghc-hslua-packaging-prof \
 ghc-text-prof \
 "
RDEPENDS:ghc-hslua-module-system-prof = " \
 ghc-base-prof \
 ghc-directory-prof \
 ghc-exceptions-prof \
 ghc-hslua-core-prof \
 ghc-hslua-marshalling-prof \
 ghc-hslua-module-system-devel \
 ghc-hslua-packaging-prof \
 ghc-temporary-prof \
 ghc-text-prof \
 "
RDEPENDS:ghc-hslua-module-version-prof = " \
 ghc-base-prof \
 ghc-filepath-prof \
 ghc-hslua-core-prof \
 ghc-hslua-marshalling-prof \
 ghc-hslua-module-version-devel \
 ghc-hslua-packaging-prof \
 ghc-text-prof \
 "
RDEPENDS:ghc-hslua-module-zip-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-filepath-prof \
 ghc-hslua-core-prof \
 ghc-hslua-list-prof \
 ghc-hslua-marshalling-prof \
 ghc-hslua-module-zip-devel \
 ghc-hslua-packaging-prof \
 ghc-hslua-typing-prof \
 ghc-text-prof \
 ghc-time-prof \
 ghc-zip-archive-prof \
 "
RDEPENDS:ghc-hslua-repl-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-hslua-core-prof \
 ghc-hslua-repl-devel \
 ghc-isocline-prof \
 ghc-lua-prof \
 ghc-text-prof \
 "
RDEPENDS:ghc-lpeg-prof = " \
 ghc-base-prof \
 ghc-lpeg-devel \
 ghc-lua-prof \
 "
RDEPENDS:ghc-pandoc-lua-engine-prof = " \
 ghc-SHA-prof \
 ghc-aeson-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-citeproc-prof \
 ghc-containers-prof \
 ghc-data-default-prof \
 ghc-doclayout-prof \
 ghc-doctemplates-prof \
 ghc-exceptions-prof \
 ghc-hslua-module-doclayout-prof \
 ghc-hslua-module-path-prof \
 ghc-hslua-module-system-prof \
 ghc-hslua-module-text-prof \
 ghc-hslua-module-version-prof \
 ghc-hslua-module-zip-prof \
 ghc-hslua-prof \
 ghc-hslua-repl-prof \
 ghc-lpeg-prof \
 ghc-mtl-prof \
 ghc-pandoc-lua-engine-devel \
 ghc-pandoc-lua-marshal-prof \
 ghc-pandoc-prof \
 ghc-pandoc-types-prof \
 ghc-parsec-prof \
 ghc-text-prof \
 "
RDEPENDS:ghc-pandoc-lua-marshal-prof = " \
 ghc-aeson-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-exceptions-prof \
 ghc-hslua-list-prof \
 ghc-hslua-marshalling-prof \
 ghc-hslua-prof \
 ghc-pandoc-lua-marshal-devel \
 ghc-pandoc-types-prof \
 ghc-safe-prof \
 ghc-text-prof \
 "
