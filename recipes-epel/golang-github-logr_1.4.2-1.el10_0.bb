# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-logr"
PV = "1.4.2"
PR = "1.el10_0"
PACKAGES = " \
 golang-github-logr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-logr-1.4.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "002caa268b078dcc7fa63d0f1736d98b480c903c60466088a72bfad22e3b27e9"

URI_x86_64_v2_golang-github-logr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-logr-devel-1.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-logr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-logr-devel}"
SRC_URI[x86_64_v2_golang-github-logr-devel.sha256sum] = "09a988841e06f84a9911dba7895a5814c4e74dc16db7aafe1a5334cd3f27497d"

URI_aarch64_golang-github-logr-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-logr-devel-1.4.2-1.el10_0.noarch.rpm;name=aarch64_golang-github-logr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-logr-devel}"
SRC_URI[aarch64_golang-github-logr-devel.sha256sum] = "21c8f80a1470941648be2e8ff7ba0937b62e3fff0cd3e431b000b0ddcd60b067"

RDEPENDS:golang-github-logr-devel = " \
 go-filesystem \
 "
