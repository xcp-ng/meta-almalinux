# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-hashtables"
PV = "1.3.1"
PR = "11.el10_0"
PACKAGES = " \
 ghc-hashtables \
 ghc-hashtables-devel \
 ghc-hashtables-doc \
 ghc-hashtables-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-hashtables-1.3.1-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a782c2763ede371f05a5ebbd95684a1f4e08b46b144d9cf550a6c9e084ba3dce"

URI_x86_64_v2_ghc-hashtables = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hashtables-1.3.1-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hashtables;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hashtables}"
SRC_URI[x86_64_v2_ghc-hashtables.sha256sum] = "78b6645131fa316ec02177c52fa9e8c7eb1b5440e54a6c821454430c042d1265"

URI_x86_64_v2_ghc-hashtables-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hashtables-devel-1.3.1-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hashtables-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hashtables-devel}"
SRC_URI[x86_64_v2_ghc-hashtables-devel.sha256sum] = "7f1e501d5ea67522d009d1c3fa155aecd8bfd5ac9eaeb57ce00d38758db1e171"

URI_x86_64_v2_ghc-hashtables-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hashtables-doc-1.3.1-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hashtables-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hashtables-doc}"
SRC_URI[x86_64_v2_ghc-hashtables-doc.sha256sum] = "75755e1cc2b423e600e938ea20fdf24f79e1252c1d50ca68fb439dd382cb8037"

URI_x86_64_v2_ghc-hashtables-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hashtables-prof-1.3.1-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hashtables-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hashtables-prof}"
SRC_URI[x86_64_v2_ghc-hashtables-prof.sha256sum] = "8089645213f9b3c4ce8a6baeefe7328898529ce87f4acb0eee4406de31a4178f"

URI_aarch64_ghc-hashtables = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hashtables-1.3.1-11.el10_0.aarch64.rpm;name=aarch64_ghc-hashtables;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hashtables}"
SRC_URI[aarch64_ghc-hashtables.sha256sum] = "f1cd01fa333c2fee97cbe05e2a5f76bf8073e14ded29163610dfd5e27f3ac3dc"

URI_aarch64_ghc-hashtables-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hashtables-devel-1.3.1-11.el10_0.aarch64.rpm;name=aarch64_ghc-hashtables-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hashtables-devel}"
SRC_URI[aarch64_ghc-hashtables-devel.sha256sum] = "295763fe0bfa0ca6e174ae23a19a0426b1d78fc04ce24a99b7c37a5dcb13e70d"

URI_aarch64_ghc-hashtables-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hashtables-doc-1.3.1-11.el10_0.noarch.rpm;name=aarch64_ghc-hashtables-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hashtables-doc}"
SRC_URI[aarch64_ghc-hashtables-doc.sha256sum] = "c6831e3b8a169bf6924cebf94b5f51d16c9c697714d1a1296e5b0c14ca4d691f"

URI_aarch64_ghc-hashtables-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hashtables-prof-1.3.1-11.el10_0.aarch64.rpm;name=aarch64_ghc-hashtables-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hashtables-prof}"
SRC_URI[aarch64_ghc-hashtables-prof.sha256sum] = "e758c09c9c0d8d2a6b0c56defbf9ae6fb04d8c5d17a2644e1ac64b515597d662"

RDEPENDS:ghc-hashtables = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 ghc-vector \
 ghc-vector-stream \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hashtables-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-hashable-devel \
 ghc-hashtables \
 ghc-primitive-devel \
 ghc-vector-devel \
 "
RDEPENDS:ghc-hashtables-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hashtables-prof = " \
 ghc-base-prof \
 ghc-hashable-prof \
 ghc-hashtables-devel \
 ghc-primitive-prof \
 ghc-vector-prof \
 "
