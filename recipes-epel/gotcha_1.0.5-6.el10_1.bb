# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gotcha"
PV = "1.0.5"
PR = "6.el10_1"
PACKAGES = " \
 gotcha \
 gotcha-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gotcha-1.0.5-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf85f82c7a668dbc09a18e6a1b1918ada57e38a1c01af8f3b46745aa0b244e29"

URI_x86_64_v2_gotcha = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gotcha-1.0.5-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gotcha;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gotcha}"
SRC_URI[x86_64_v2_gotcha.sha256sum] = "de3d96d4d297710c8879bd83670c05e5a6415e57520dd96491d3126201814a1b"

URI_x86_64_v2_gotcha-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gotcha-devel-1.0.5-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gotcha-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gotcha-devel}"
SRC_URI[x86_64_v2_gotcha-devel.sha256sum] = "ecff2e48a792118bcc283f2fa8b48e642a774c72c0a0f7d4bc5dbb4ec241a471"

URI_aarch64_gotcha = "${EPEL_MIRROR}/aarch64/Packages/g/gotcha-1.0.5-6.el10_1.aarch64.rpm;name=aarch64_gotcha;unpack=0"
SRC_URI:append = " ${URI_aarch64_gotcha}"
SRC_URI[aarch64_gotcha.sha256sum] = "3da8e707b9457b1cbf24ec9fd08875760883595eebb3a75f135383fad774b7b6"

URI_aarch64_gotcha-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gotcha-devel-1.0.5-6.el10_1.aarch64.rpm;name=aarch64_gotcha-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gotcha-devel}"
SRC_URI[aarch64_gotcha-devel.sha256sum] = "c8cc9215b7ba10be8c45dcc9e51facc9b1febd4b1c6152c40b98fb956e326927"

RDEPENDS:gotcha = " \
 glibc \
 "
RDEPENDS:gotcha-devel = " \
 cmake-filesystem \
 gotcha \
 "
