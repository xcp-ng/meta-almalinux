# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-bitmap"
PV = "0.3.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-bitmap+default-devel \
 rust-gix-bitmap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-bitmap-0.3.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "83f91cfa41493a08af6b5066a631514ec581552e62adcd42ce9083010bf61a64"

URI_x86_64_v2_rust-gix-bitmap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-bitmap+default-devel-0.3.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-bitmap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-bitmap+default-devel}"
SRC_URI[x86_64_v2_rust-gix-bitmap+default-devel.sha256sum] = "263d6e6efbf8d745f0c876050b2b4c6d8e8966cc1486a132e7ddea4e386ce309"

URI_x86_64_v2_rust-gix-bitmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-bitmap-devel-0.3.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-bitmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-bitmap-devel}"
SRC_URI[x86_64_v2_rust-gix-bitmap-devel.sha256sum] = "542139e2d6d81a70801392ff0f91ea1cae686fd642359b485dfaf2da53477b27"

URI_aarch64_rust-gix-bitmap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-bitmap+default-devel-0.3.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-bitmap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-bitmap+default-devel}"
SRC_URI[aarch64_rust-gix-bitmap+default-devel.sha256sum] = "69aa823d6b265ac983400a11a880c4155350c3c5c59f705898aa5d96d1af2348"

URI_aarch64_rust-gix-bitmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-bitmap-devel-0.3.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-bitmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-bitmap-devel}"
SRC_URI[aarch64_rust-gix-bitmap-devel.sha256sum] = "fe3b795e3ff774befb716750376498f2d9e6326530e3f240b5bd361c015266e6"

RDEPENDS:rust-gix-bitmap+default-devel = " \
 cargo \
 rust-gix-bitmap-devel \
 "
RDEPENDS:rust-gix-bitmap-devel = " \
 cargo \
 rust \
 rust-gix-error+default-devel \
 "
