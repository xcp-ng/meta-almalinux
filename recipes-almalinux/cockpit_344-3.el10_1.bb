# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cockpit"
PV = "344"
PR = "3.el10_1"
PACKAGES = " \
 cockpit \
 cockpit-bridge \
 cockpit-doc \
 cockpit-packagekit \
 cockpit-storaged \
 cockpit-system \
 cockpit-ws \
 cockpit-ws-selinux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/cockpit-344-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8f45d5782e1e7580a81814a8e56d0b07d9c4a2ac187b3261db65ababddf698c"

URI_x86_64_v2_cockpit = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-344-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_cockpit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit}"
SRC_URI[x86_64_v2_cockpit.sha256sum] = "35e0a8206ce25a6c3db56118c1e036a05fec7711387f2e82ee8059efc76df2c4"

URI_x86_64_v2_cockpit-bridge = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-bridge-344-3.el10_1.noarch.rpm;name=x86_64_v2_cockpit-bridge;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-bridge}"
SRC_URI[x86_64_v2_cockpit-bridge.sha256sum] = "9e6ee07b13d8b35e2f11c48c6e6bdb1980d72349f1fa3fb136ccd540e3992b26"

URI_x86_64_v2_cockpit-doc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-doc-344-3.el10_1.noarch.rpm;name=x86_64_v2_cockpit-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-doc}"
SRC_URI[x86_64_v2_cockpit-doc.sha256sum] = "9f322694f3345572a0e40446eaffca2720adfea8f1ef2b20bd629155d9cbe990"

URI_x86_64_v2_cockpit-packagekit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cockpit-packagekit-344-3.el10_1.noarch.rpm;name=x86_64_v2_cockpit-packagekit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-packagekit}"
SRC_URI[x86_64_v2_cockpit-packagekit.sha256sum] = "11293ac3d661b2cd4dacc6727b2a52e223882a1feb776216e9bfe472ad4f89cf"

URI_x86_64_v2_cockpit-storaged = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cockpit-storaged-344-3.el10_1.noarch.rpm;name=x86_64_v2_cockpit-storaged;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-storaged}"
SRC_URI[x86_64_v2_cockpit-storaged.sha256sum] = "3a22ce68ac3c5d13ec0963cb55316c16653fbdd0788b4cc4843d1d8b5a3defbc"

URI_x86_64_v2_cockpit-system = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-system-344-3.el10_1.noarch.rpm;name=x86_64_v2_cockpit-system;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-system}"
SRC_URI[x86_64_v2_cockpit-system.sha256sum] = "4026399a841ded5ce87cf197de55ed145156e2cae14ad78a9910433951741600"

URI_x86_64_v2_cockpit-ws = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-ws-344-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_cockpit-ws;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-ws}"
SRC_URI[x86_64_v2_cockpit-ws.sha256sum] = "21b7a7e8f516693d108e870bdf1e31499acb9d976e61d74f3ecb9d0f118c313c"

URI_x86_64_v2_cockpit-ws-selinux = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-ws-selinux-344-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_cockpit-ws-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-ws-selinux}"
SRC_URI[x86_64_v2_cockpit-ws-selinux.sha256sum] = "3dadab51178b2de249bd4ec65154befcfe11c56dc2d9f434d4f6da526d5ed690"

URI_aarch64_cockpit = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-344-3.el10_1.aarch64.rpm;name=aarch64_cockpit;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit}"
SRC_URI[aarch64_cockpit.sha256sum] = "e96e653edf4f6a360d0423b05b13681b3832a232b601d5b786b9af27544e92b8"

URI_aarch64_cockpit-bridge = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-bridge-344-3.el10_1.noarch.rpm;name=aarch64_cockpit-bridge;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-bridge}"
SRC_URI[aarch64_cockpit-bridge.sha256sum] = "9e6ee07b13d8b35e2f11c48c6e6bdb1980d72349f1fa3fb136ccd540e3992b26"

URI_aarch64_cockpit-doc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-doc-344-3.el10_1.noarch.rpm;name=aarch64_cockpit-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-doc}"
SRC_URI[aarch64_cockpit-doc.sha256sum] = "9f322694f3345572a0e40446eaffca2720adfea8f1ef2b20bd629155d9cbe990"

URI_aarch64_cockpit-packagekit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cockpit-packagekit-344-3.el10_1.noarch.rpm;name=aarch64_cockpit-packagekit;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-packagekit}"
SRC_URI[aarch64_cockpit-packagekit.sha256sum] = "11293ac3d661b2cd4dacc6727b2a52e223882a1feb776216e9bfe472ad4f89cf"

URI_aarch64_cockpit-storaged = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cockpit-storaged-344-3.el10_1.noarch.rpm;name=aarch64_cockpit-storaged;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-storaged}"
SRC_URI[aarch64_cockpit-storaged.sha256sum] = "3a22ce68ac3c5d13ec0963cb55316c16653fbdd0788b4cc4843d1d8b5a3defbc"

URI_aarch64_cockpit-system = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-system-344-3.el10_1.noarch.rpm;name=aarch64_cockpit-system;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-system}"
SRC_URI[aarch64_cockpit-system.sha256sum] = "4026399a841ded5ce87cf197de55ed145156e2cae14ad78a9910433951741600"

URI_aarch64_cockpit-ws = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-ws-344-3.el10_1.aarch64.rpm;name=aarch64_cockpit-ws;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-ws}"
SRC_URI[aarch64_cockpit-ws.sha256sum] = "5539bd0326d3a03365e383d92cfee006024b8f6824c09b5274bfb34fe8bbdd09"

URI_aarch64_cockpit-ws-selinux = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-ws-selinux-344-3.el10_1.aarch64.rpm;name=aarch64_cockpit-ws-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-ws-selinux}"
SRC_URI[aarch64_cockpit-ws-selinux.sha256sum] = "8553d37c9e59d10369a716d5c451e642ec7c646492dfc8056afd328d6c456fa0"

RDEPENDS:cockpit = " \
 cockpit-bridge \
 cockpit-system \
 cockpit-ws \
 "
RDEPENDS:cockpit-bridge = " \
 python3 \
 "
RDEPENDS:cockpit-doc = " \
 "
RDEPENDS:cockpit-packagekit = " \
 PackageKit \
 cockpit-bridge \
 polkit \
 "
RDEPENDS:cockpit-storaged = " \
 bash \
 cockpit-system \
 python3 \
 python3-dbus \
 udisks2 \
 "
RDEPENDS:cockpit-system = " \
 NetworkManager \
 cockpit-bridge \
 grep \
 libpwquality \
 shadow-utils \
 sos \
 sudo \
 virtual//usr/bin/date \
 "
RDEPENDS:cockpit-ws = " \
 bash \
 cockpit-ws-selinux \
 glib-networking \
 glib2 \
 glibc \
 gnutls \
 json-glib \
 krb5-libs \
 libgcc \
 libxcrypt \
 openssl \
 pam-libs \
 systemd-libs \
 "
RDEPENDS:cockpit-ws-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 selinux-policy-targeted \
 "
