# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cxx-gen"
PV = "0.7.199"
PR = "1.el10_3"
PACKAGES = " \
 rust-cxx-gen+default-devel \
 rust-cxx-gen-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cxx-gen-0.7.199-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9aaf1e0daa98854d945575eab9c1e48367b40b4f773371b652fabe3db631781b"

URI_x86_64_v2_rust-cxx-gen+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx-gen+default-devel-0.7.199-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx-gen+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx-gen+default-devel}"
SRC_URI[x86_64_v2_rust-cxx-gen+default-devel.sha256sum] = "754be9f8746e351e83305434d8846c14dbe82d649da60392d53beb7b22807af4"

URI_x86_64_v2_rust-cxx-gen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx-gen-devel-0.7.199-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx-gen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx-gen-devel}"
SRC_URI[x86_64_v2_rust-cxx-gen-devel.sha256sum] = "1c8f38a74d730b0248ef425c40e33f8289f76cb9e71321ee64c9466d71a65d12"

URI_aarch64_rust-cxx-gen+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx-gen+default-devel-0.7.199-1.el10_3.noarch.rpm;name=aarch64_rust-cxx-gen+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx-gen+default-devel}"
SRC_URI[aarch64_rust-cxx-gen+default-devel.sha256sum] = "e30fe2dd7ca6615e52e80d79cc84ccb868db2a1073b67e83f778e0f946fd07a3"

URI_aarch64_rust-cxx-gen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx-gen-devel-0.7.199-1.el10_3.noarch.rpm;name=aarch64_rust-cxx-gen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx-gen-devel}"
SRC_URI[aarch64_rust-cxx-gen-devel.sha256sum] = "b848e7c61a1a2d98dfbe0f62fea3757ed279304ddcf5994ec7869ac9cc37359a"

RDEPENDS:rust-cxx-gen+default-devel = " \
 cargo \
 rust-cxx-gen-devel \
 "
RDEPENDS:rust-cxx-gen-devel = " \
 cargo \
 rust \
 rust-codespan-reporting+default-devel \
 rust-indexmap+default-devel \
 rust-proc-macro2+span-locations-devel \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn-devel \
 "
