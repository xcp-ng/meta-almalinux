# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "delve"
PV = "1.26.1"
PR = "1.el10"
PACKAGES = " \
 delve \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/delve-1.26.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d8ca66fd8d9772fccfc3a8a5968eb52b7ac2b5782ee7d7801399670e2b388418"

URI_x86_64_v2_delve = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/delve-1.26.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_delve;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_delve}"
SRC_URI[x86_64_v2_delve.sha256sum] = "15b1d6fcdaf10e63bd138b669ffe84f1e14d8754a11ff3f854b5c45cd7a726b3"

URI_aarch64_delve = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/delve-1.26.1-1.el10.aarch64.rpm;name=aarch64_delve;unpack=0"
SRC_URI:append = " ${URI_aarch64_delve}"
SRC_URI[aarch64_delve.sha256sum] = "fbdb9cbb0399db878702e58d145d84aeacb30b114e486baf4ce603e8a3e0136f"

RDEPENDS:delve = " \
 glibc \
 "
