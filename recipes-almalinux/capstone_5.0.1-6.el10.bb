# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "capstone"
PV = "5.0.1"
PR = "6.el10"
PACKAGES = " \
 capstone \
 capstone-devel \
 capstone-java \
 python3-capstone \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/capstone-5.0.1-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7197b7009fd96390d910336fb99d78770cbddf38687bcb52ab8b602af9aea0f8"

URI_x86_64_v2_capstone = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/capstone-5.0.1-6.el10.x86_64_v2.rpm;name=x86_64_v2_capstone;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_capstone}"
SRC_URI[x86_64_v2_capstone.sha256sum] = "e184c34cd74e7d34b72bc4849b07166ef67e214af3d5db8b4bb8f47f6d819d34"

URI_x86_64_v2_capstone-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/capstone-devel-5.0.1-6.el10.x86_64_v2.rpm;name=x86_64_v2_capstone-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_capstone-devel}"
SRC_URI[x86_64_v2_capstone-devel.sha256sum] = "1fd3a4a6f357496c17dbc697dfbd8298f967af22241b8009a0245d9e3b5782a3"

URI_x86_64_v2_capstone-java = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/capstone-java-5.0.1-6.el10.noarch.rpm;name=x86_64_v2_capstone-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_capstone-java}"
SRC_URI[x86_64_v2_capstone-java.sha256sum] = "57bbd122f20723c0ed85a9f5f35a1e2571be5102ca8ed16ab851fe8ac75e219d"

URI_x86_64_v2_python3-capstone = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-capstone-5.0.1-6.el10.noarch.rpm;name=x86_64_v2_python3-capstone;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-capstone}"
SRC_URI[x86_64_v2_python3-capstone.sha256sum] = "37095d9cb8d6189137ed9e0597b9c73c424d844bbc65a2b4216ce75c5799d454"

URI_aarch64_capstone = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/capstone-5.0.1-6.el10.aarch64.rpm;name=aarch64_capstone;unpack=0"
SRC_URI:append = " ${URI_aarch64_capstone}"
SRC_URI[aarch64_capstone.sha256sum] = "96fabaeb0351bceeb9e7a518ad3074ce53e4cc50f82152b382b7d8bce2189d8c"

URI_aarch64_capstone-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/capstone-devel-5.0.1-6.el10.aarch64.rpm;name=aarch64_capstone-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_capstone-devel}"
SRC_URI[aarch64_capstone-devel.sha256sum] = "e18d7121712c5f6befe9071d4c2ddbfe7dd660cf9c7a36ba36de913930975320"

URI_aarch64_capstone-java = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/capstone-java-5.0.1-6.el10.noarch.rpm;name=aarch64_capstone-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_capstone-java}"
SRC_URI[aarch64_capstone-java.sha256sum] = "57bbd122f20723c0ed85a9f5f35a1e2571be5102ca8ed16ab851fe8ac75e219d"

URI_aarch64_python3-capstone = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-capstone-5.0.1-6.el10.noarch.rpm;name=aarch64_python3-capstone;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-capstone}"
SRC_URI[aarch64_python3-capstone.sha256sum] = "37095d9cb8d6189137ed9e0597b9c73c424d844bbc65a2b4216ce75c5799d454"

RDEPENDS:capstone = " \
 glibc \
 "
RDEPENDS:capstone-devel = " \
 capstone \
 pkgconf-pkg-config \
 "
RDEPENDS:capstone-java = " \
 capstone \
 "
RDEPENDS:python3-capstone = " \
 capstone \
 python3 \
 "
