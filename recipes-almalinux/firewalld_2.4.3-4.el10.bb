# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "firewalld"
PV = "2.4.3"
PR = "4.el10"
PACKAGES = " \
 firewall-applet \
 firewall-config \
 firewalld \
 firewalld-filesystem \
 python3-firewall \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/firewalld-2.4.3-4.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "282ebdc6ae84efdc7ae19a427e1170af80fa33de02b9ade51b3fce7ee41e746c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/firewall-applet-2.4.3-4.el10.noarch.rpm;name=x86_64_v2_firewall-applet;unpack=0"
SRC_URI[x86_64_v2_firewall-applet.sha256sum] = "f9fd362be8c3d0f0d5ec9ba0be4016986fe75a2b10c6db613afc6e82d67ce56a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/firewall-config-2.4.3-4.el10.noarch.rpm;name=x86_64_v2_firewall-config;unpack=0"
SRC_URI[x86_64_v2_firewall-config.sha256sum] = "d854f954ed28adba60961e11e32026a43e36110b7017c31689d967502ac78513"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/firewalld-2.4.3-4.el10.noarch.rpm;name=x86_64_v2_firewalld;unpack=0"
SRC_URI[x86_64_v2_firewalld.sha256sum] = "ab07cf3279eceb5b34cfc978be27a0d5fa739a7b154c398346ef462b2ecb93f8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/firewalld-filesystem-2.4.3-4.el10.noarch.rpm;name=x86_64_v2_firewalld-filesystem;unpack=0"
SRC_URI[x86_64_v2_firewalld-filesystem.sha256sum] = "9780b7b6ec49c5687a62c57cf838785ae81fa25d175a2369146c4249ebfea8dd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-firewall-2.4.3-4.el10.noarch.rpm;name=x86_64_v2_python3-firewall;unpack=0"
SRC_URI[x86_64_v2_python3-firewall.sha256sum] = "a4d889357ef6f33b94e6dd7827bc4cc6eadbfe110612751e579ae24ae3dc9fb8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/firewall-applet-2.4.3-4.el10.noarch.rpm;name=aarch64_firewall-applet;unpack=0"
SRC_URI[aarch64_firewall-applet.sha256sum] = "f9fd362be8c3d0f0d5ec9ba0be4016986fe75a2b10c6db613afc6e82d67ce56a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/firewall-config-2.4.3-4.el10.noarch.rpm;name=aarch64_firewall-config;unpack=0"
SRC_URI[aarch64_firewall-config.sha256sum] = "d854f954ed28adba60961e11e32026a43e36110b7017c31689d967502ac78513"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/firewalld-2.4.3-4.el10.noarch.rpm;name=aarch64_firewalld;unpack=0"
SRC_URI[aarch64_firewalld.sha256sum] = "ab07cf3279eceb5b34cfc978be27a0d5fa739a7b154c398346ef462b2ecb93f8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/firewalld-filesystem-2.4.3-4.el10.noarch.rpm;name=aarch64_firewalld-filesystem;unpack=0"
SRC_URI[aarch64_firewalld-filesystem.sha256sum] = "9780b7b6ec49c5687a62c57cf838785ae81fa25d175a2369146c4249ebfea8dd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-firewall-2.4.3-4.el10.noarch.rpm;name=aarch64_python3-firewall;unpack=0"
SRC_URI[aarch64_python3-firewall.sha256sum] = "a4d889357ef6f33b94e6dd7827bc4cc6eadbfe110612751e579ae24ae3dc9fb8"

RDEPENDS:firewall-applet = " \
 NetworkManager-libnm \
 dbus-x11 \
 firewall-config \
 firewalld \
 hicolor-icon-theme \
 libnotify \
 python3 \
 python3-firewall \
 python3-gobject \
 python3-pyqt6-base \
 "
RDEPENDS:firewall-config = " \
 NetworkManager-libnm \
 dbus-x11 \
 firewalld \
 gtk3 \
 hicolor-icon-theme \
 python3 \
 python3-firewall \
 python3-gobject \
 "
RDEPENDS:firewalld = " \
 bash \
 firewalld-filesystem \
 python3 \
 python3-firewall \
 systemd \
 "
RDEPENDS:firewalld-filesystem = " \
 "
RDEPENDS:python3-firewall = " \
 python3 \
 python3-dbus \
 python3-gobject-base \
 python3-nftables \
 "
