# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-petgraph"
PV = "0.8.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-petgraph+default-devel \
 rust-petgraph+generate-devel \
 rust-petgraph+graphmap-devel \
 rust-petgraph+matrix_graph-devel \
 rust-petgraph+rayon-devel \
 rust-petgraph+serde-1-devel \
 rust-petgraph+serde-devel \
 rust-petgraph+serde_derive-devel \
 rust-petgraph+stable_graph-devel \
 rust-petgraph+std-devel \
 rust-petgraph+unstable-devel \
 rust-petgraph-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-petgraph-0.8.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb77c4b97911f97ec56158cd80e51fdaf0f34de959de07713efb7ff8b8b704fa"

URI_x86_64_v2_rust-petgraph+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph+default-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph+default-devel}"
SRC_URI[x86_64_v2_rust-petgraph+default-devel.sha256sum] = "f1222cdfb45f3714f2cc3293cd1063c8fefbdf82e59b4f3df18c3ea421934ab7"

URI_x86_64_v2_rust-petgraph+generate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph+generate-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph+generate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph+generate-devel}"
SRC_URI[x86_64_v2_rust-petgraph+generate-devel.sha256sum] = "e2b881b6a8168330a4799813525cfdbe0afa6c18525346cb4f1403f47990208f"

URI_x86_64_v2_rust-petgraph+graphmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph+graphmap-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph+graphmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph+graphmap-devel}"
SRC_URI[x86_64_v2_rust-petgraph+graphmap-devel.sha256sum] = "ae774dd02f8c369c81026d04b9a008fcd20cd09e1d5b58cb4d161e5822efaa7f"

URI_x86_64_v2_rust-petgraph+matrix_graph-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph+matrix_graph-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph+matrix_graph-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph+matrix_graph-devel}"
SRC_URI[x86_64_v2_rust-petgraph+matrix_graph-devel.sha256sum] = "7e886c9ba08b20e04d2990131a19af004425aebe7cab144123b9192bf3d82ebe"

URI_x86_64_v2_rust-petgraph+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph+rayon-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph+rayon-devel}"
SRC_URI[x86_64_v2_rust-petgraph+rayon-devel.sha256sum] = "a339f9112134d71f3f9fc4fea3b5102b8df45bb2ac6a9c2dc377b820f62737af"

URI_x86_64_v2_rust-petgraph+serde-1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph+serde-1-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph+serde-1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph+serde-1-devel}"
SRC_URI[x86_64_v2_rust-petgraph+serde-1-devel.sha256sum] = "43af3c842ffb37e011b6138bedf7e012ea653efcfd79340692ef13e241f03dfd"

URI_x86_64_v2_rust-petgraph+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph+serde-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph+serde-devel}"
SRC_URI[x86_64_v2_rust-petgraph+serde-devel.sha256sum] = "37d3bed53bb423ff5501309b00b1995d3447020a0c9b2702e14dfdae4d316c58"

URI_x86_64_v2_rust-petgraph+serde_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph+serde_derive-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph+serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph+serde_derive-devel}"
SRC_URI[x86_64_v2_rust-petgraph+serde_derive-devel.sha256sum] = "4c8e7a41d135fc1b6f79c13a63b94feda7e365c69fd16255e38b9d0ee3a9b5e7"

URI_x86_64_v2_rust-petgraph+stable_graph-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph+stable_graph-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph+stable_graph-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph+stable_graph-devel}"
SRC_URI[x86_64_v2_rust-petgraph+stable_graph-devel.sha256sum] = "b345056b2a3b13cf59646243c43e55927044c96f906e0a0385b65ef15b709534"

URI_x86_64_v2_rust-petgraph+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph+std-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph+std-devel}"
SRC_URI[x86_64_v2_rust-petgraph+std-devel.sha256sum] = "cc7a9e3e391644721ec319549feb648bb057377e98499686f13783935a6a74a0"

URI_x86_64_v2_rust-petgraph+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph+unstable-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph+unstable-devel}"
SRC_URI[x86_64_v2_rust-petgraph+unstable-devel.sha256sum] = "2f86b5f64ddc4a37f21303b9e1798bff5304a6fd7b35f500e164a102b631e5a8"

URI_x86_64_v2_rust-petgraph-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph-devel}"
SRC_URI[x86_64_v2_rust-petgraph-devel.sha256sum] = "3fc810608decc72f9f749ce2395fe3afca510fbbbd5c4d930c87d78ec93b6353"

URI_aarch64_rust-petgraph+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph+default-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-petgraph+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph+default-devel}"
SRC_URI[aarch64_rust-petgraph+default-devel.sha256sum] = "2af149891284368ba508fd462838ffe6fd4663f73ee64a627329566b156c679b"

URI_aarch64_rust-petgraph+generate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph+generate-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-petgraph+generate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph+generate-devel}"
SRC_URI[aarch64_rust-petgraph+generate-devel.sha256sum] = "eecf1fa042d5cebbc22822215a590f914c26eaf57586f25efbecee86cc598d59"

URI_aarch64_rust-petgraph+graphmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph+graphmap-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-petgraph+graphmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph+graphmap-devel}"
SRC_URI[aarch64_rust-petgraph+graphmap-devel.sha256sum] = "598ab3a67bd2b2a30022698ed3c4cac7b5c433a45366ba4a610f4a0678a520e8"

URI_aarch64_rust-petgraph+matrix_graph-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph+matrix_graph-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-petgraph+matrix_graph-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph+matrix_graph-devel}"
SRC_URI[aarch64_rust-petgraph+matrix_graph-devel.sha256sum] = "746e43ffb7931f02058c9f2429e1d9142c2568ac71f8cf3b2dc46258e4cc1ed6"

URI_aarch64_rust-petgraph+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph+rayon-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-petgraph+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph+rayon-devel}"
SRC_URI[aarch64_rust-petgraph+rayon-devel.sha256sum] = "438e62bf8f14462e7a27a3e43429ff658bbf76152b203730f975a356ff24ba19"

URI_aarch64_rust-petgraph+serde-1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph+serde-1-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-petgraph+serde-1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph+serde-1-devel}"
SRC_URI[aarch64_rust-petgraph+serde-1-devel.sha256sum] = "c9c1a824586d6c50e7c0b1f2e4bacaeb3a8fca9ebcbec4f96dd69c2d6f934c25"

URI_aarch64_rust-petgraph+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph+serde-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-petgraph+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph+serde-devel}"
SRC_URI[aarch64_rust-petgraph+serde-devel.sha256sum] = "b6358f1c1998be7f3f9876fb5895b18b32256bbaf740d5c3a0a44427f314b82c"

URI_aarch64_rust-petgraph+serde_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph+serde_derive-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-petgraph+serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph+serde_derive-devel}"
SRC_URI[aarch64_rust-petgraph+serde_derive-devel.sha256sum] = "28f82ff2c8ff121e1c513880931d2613b76df2109964f3d436e4debce4813b36"

URI_aarch64_rust-petgraph+stable_graph-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph+stable_graph-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-petgraph+stable_graph-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph+stable_graph-devel}"
SRC_URI[aarch64_rust-petgraph+stable_graph-devel.sha256sum] = "82498327ccf4b7c967028eccd7db1c4ed87c665ab962e9a4c0005a38cc30eefb"

URI_aarch64_rust-petgraph+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph+std-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-petgraph+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph+std-devel}"
SRC_URI[aarch64_rust-petgraph+std-devel.sha256sum] = "74c6f632ae4136a21a449159f085202ed66267299d50b4306350bca3014c58a2"

URI_aarch64_rust-petgraph+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph+unstable-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-petgraph+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph+unstable-devel}"
SRC_URI[aarch64_rust-petgraph+unstable-devel.sha256sum] = "e69cc1105d81c5ece275f5c3e6be82bcd22aafa9e36eeb62e8c2382eb7caa449"

URI_aarch64_rust-petgraph-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-petgraph-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph-devel}"
SRC_URI[aarch64_rust-petgraph-devel.sha256sum] = "4dec47eba0d19256f0e7f2493702370e80cfe926e2f5b8597df57b7696dacce9"

RDEPENDS:rust-petgraph+default-devel = " \
 cargo \
 rust-petgraph+graphmap-devel \
 rust-petgraph+matrix_graph-devel \
 rust-petgraph+stable_graph-devel \
 rust-petgraph+std-devel \
 rust-petgraph-devel \
 "
RDEPENDS:rust-petgraph+generate-devel = " \
 cargo \
 rust-petgraph-devel \
 "
RDEPENDS:rust-petgraph+graphmap-devel = " \
 cargo \
 rust-petgraph-devel \
 "
RDEPENDS:rust-petgraph+matrix_graph-devel = " \
 cargo \
 rust-petgraph-devel \
 "
RDEPENDS:rust-petgraph+rayon-devel = " \
 cargo \
 rust-hashbrown0.15+rayon-devel \
 rust-indexmap+rayon-devel \
 rust-petgraph+std-devel \
 rust-petgraph-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-petgraph+serde-1-devel = " \
 cargo \
 rust-petgraph+serde-devel \
 rust-petgraph+serde_derive-devel \
 rust-petgraph-devel \
 "
RDEPENDS:rust-petgraph+serde-devel = " \
 cargo \
 rust-petgraph-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-petgraph+serde_derive-devel = " \
 cargo \
 rust-petgraph-devel \
 rust-serde_derive-devel \
 "
RDEPENDS:rust-petgraph+stable_graph-devel = " \
 cargo \
 rust-petgraph-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-petgraph+std-devel = " \
 cargo \
 rust-indexmap+std-devel \
 rust-petgraph-devel \
 "
RDEPENDS:rust-petgraph+unstable-devel = " \
 cargo \
 rust-petgraph+generate-devel \
 rust-petgraph-devel \
 "
RDEPENDS:rust-petgraph-devel = " \
 cargo \
 rust \
 rust-fixedbitset-devel \
 rust-hashbrown0.15+default-hasher-devel \
 rust-hashbrown0.15+inline-more-devel \
 rust-hashbrown0.15-devel \
 rust-indexmap-devel \
 "
