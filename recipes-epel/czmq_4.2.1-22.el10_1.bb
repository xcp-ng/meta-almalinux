# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "czmq"
PV = "4.2.1"
PR = "22.el10_1"
PACKAGES = " \
 czmq \
 czmq-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/czmq-4.2.1-22.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6577a0d0c9f4572b75354edda774e7823088b3cb5b8596085ca6ccf446147e19"

URI_x86_64_v2_czmq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/czmq-4.2.1-22.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_czmq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_czmq}"
SRC_URI[x86_64_v2_czmq.sha256sum] = "73e6918b38895ebf62e00b9b975aa92c75869235d093816bd541679bc4713eb2"

URI_x86_64_v2_czmq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/czmq-devel-4.2.1-22.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_czmq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_czmq-devel}"
SRC_URI[x86_64_v2_czmq-devel.sha256sum] = "d6927fb88d62bf682246382a4b9127c99df6dcb082ceccb759ed4a788f3c1d46"

URI_aarch64_czmq = "${EPEL_MIRROR}/aarch64/Packages/c/czmq-4.2.1-22.el10_1.aarch64.rpm;name=aarch64_czmq;unpack=0"
SRC_URI:append = " ${URI_aarch64_czmq}"
SRC_URI[aarch64_czmq.sha256sum] = "2e4c0f34ef79ed3c74f71c42f366cb4dbf87e8fc7eeb4cdfe55eb20192d25bf2"

URI_aarch64_czmq-devel = "${EPEL_MIRROR}/aarch64/Packages/c/czmq-devel-4.2.1-22.el10_1.aarch64.rpm;name=aarch64_czmq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_czmq-devel}"
SRC_URI[aarch64_czmq-devel.sha256sum] = "746924dc735d8cb5bff6110264e96555a8ab85383c1fe8577e5cfb395f82925e"

RDEPENDS:czmq = " \
 glibc \
 libuuid \
 zeromq \
 "
RDEPENDS:czmq-devel = " \
 cmake-filesystem \
 czmq \
 glibc \
 libuuid-devel \
 pkgconf-pkg-config \
 zeromq-devel \
 "
