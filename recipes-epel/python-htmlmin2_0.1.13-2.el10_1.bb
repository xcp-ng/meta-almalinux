# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-htmlmin2"
PV = "0.1.13"
PR = "2.el10_1"
PACKAGES = " \
 python3-htmlmin2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-htmlmin2-0.1.13-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "507e350d9c90710249359c1a600886ee5dee8183f51fc3b2cb0287bc8becc256"

URI_x86_64_v2_python3-htmlmin2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-htmlmin2-0.1.13-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-htmlmin2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-htmlmin2}"
SRC_URI[x86_64_v2_python3-htmlmin2.sha256sum] = "44388533f6fc360f9fd7e6c39668bc709c883fd57e4084ec3bb35cf3e75e9a56"

URI_aarch64_python3-htmlmin2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-htmlmin2-0.1.13-2.el10_1.noarch.rpm;name=aarch64_python3-htmlmin2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-htmlmin2}"
SRC_URI[aarch64_python3-htmlmin2.sha256sum] = "335e59cdf23e2c25601340d283be222b305f77766d136abb4d200430b6e1a361"

RDEPENDS:python3-htmlmin2 = " \
 python3 \
 "
