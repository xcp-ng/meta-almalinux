# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-alloc-stdlib"
PV = "0.2.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-alloc-stdlib+default-devel \
 rust-alloc-stdlib+unsafe-devel \
 rust-alloc-stdlib-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-alloc-stdlib-0.2.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "157a84544813f021037ec2788706d261fd6c40675a9931c266b927a35b67b9e6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-alloc-stdlib+default-devel-0.2.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-alloc-stdlib+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-alloc-stdlib+default-devel.sha256sum] = "39ab666ff781491faafd4615b59bdf39a70e0465b59b7eafb6849850b938dcbb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-alloc-stdlib+unsafe-devel-0.2.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-alloc-stdlib+unsafe-devel;unpack=0"
SRC_URI[x86_64_v2_rust-alloc-stdlib+unsafe-devel.sha256sum] = "7e712c9a0d402ebd824b658de2f15e0364d2b358aaeaa78f80b6427341ec29e9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-alloc-stdlib-devel-0.2.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-alloc-stdlib-devel;unpack=0"
SRC_URI[x86_64_v2_rust-alloc-stdlib-devel.sha256sum] = "0c19c0fbb13c881e5b8c6e09f77a98b77bdc655b346381a2b0ff44247af91774"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-alloc-stdlib+default-devel-0.2.4-1.el10_3.noarch.rpm;name=aarch64_rust-alloc-stdlib+default-devel;unpack=0"
SRC_URI[aarch64_rust-alloc-stdlib+default-devel.sha256sum] = "77b3029d182c5cbe029b57a28705810f8b859ca0e247a3047653b7fa9c356a57"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-alloc-stdlib+unsafe-devel-0.2.4-1.el10_3.noarch.rpm;name=aarch64_rust-alloc-stdlib+unsafe-devel;unpack=0"
SRC_URI[aarch64_rust-alloc-stdlib+unsafe-devel.sha256sum] = "5f584ce84410123c8b1ab226ca5caeb8072e8d0c504ec21aa5084d203f5f9eca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-alloc-stdlib-devel-0.2.4-1.el10_3.noarch.rpm;name=aarch64_rust-alloc-stdlib-devel;unpack=0"
SRC_URI[aarch64_rust-alloc-stdlib-devel.sha256sum] = "dafdd25654650f1623616c4d054bcdf86306acf58388ebc86d798ae37ba2e4de"

RDEPENDS:rust-alloc-stdlib+default-devel = " \
 cargo \
 rust-alloc-stdlib-devel \
 "
RDEPENDS:rust-alloc-stdlib+unsafe-devel = " \
 cargo \
 rust-alloc-no-stdlib+unsafe-devel \
 rust-alloc-stdlib-devel \
 "
RDEPENDS:rust-alloc-stdlib-devel = " \
 cargo \
 rust-alloc-no-stdlib+default-devel \
 "
