# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "highway"
PV = "1.3.0"
PR = "1.el10_2"
PACKAGES = " \
 highway \
 highway-devel \
 highway-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/h/highway-1.3.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6d3291bfdb975f9e656128a97b28a099b60c8baf89f699c39d960d0487194fea"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/highway-1.3.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_highway;unpack=0"
SRC_URI[x86_64_v2_highway.sha256sum] = "cabda2d2090e51b965f0f8ff6c635b9cc29e4c2b2c51eee55538b0e7e8fac80f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/highway-devel-1.3.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_highway-devel;unpack=0"
SRC_URI[x86_64_v2_highway-devel.sha256sum] = "bed7471d43f4856a5acae368702fe90b54213d3349ba27e02ad5eba2ace52ef0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/highway-doc-1.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_highway-doc;unpack=0"
SRC_URI[x86_64_v2_highway-doc.sha256sum] = "18c39b0c61cca69a3fe598174f60551ef36b472b810ac7a82214616abb4831cb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/highway-1.3.0-1.el10_2.aarch64.rpm;name=aarch64_highway;unpack=0"
SRC_URI[aarch64_highway.sha256sum] = "8781ac03661ffe2427033695e4d6bb3ba417602ed6c873a2e29ad98c95ce0a1d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/highway-devel-1.3.0-1.el10_2.aarch64.rpm;name=aarch64_highway-devel;unpack=0"
SRC_URI[aarch64_highway-devel.sha256sum] = "33cf17b59c17b2d2bb4901060a3836496339a80b1de0a6d7aad6c2a58ad6b283"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/highway-doc-1.3.0-1.el10_2.noarch.rpm;name=aarch64_highway-doc;unpack=0"
SRC_URI[aarch64_highway-doc.sha256sum] = "7dd3b3245dd19d3be7c7ff8a53b1ae83d781d939301bc981d879f58abf7ab526"

RDEPENDS:highway:x86_64_v2 = " \
 glibc \
 libgcc \
 libstdc++ \
"
RDEPENDS:highway:aarch64 = " \
 glibc \
 libstdc++ \
"
RDEPENDS:highway-devel = " \
 cmake-filesystem \
 gtest-devel \
 highway \
 pkgconf-pkg-config \
 "
RDEPENDS:highway-doc = " \
 "
