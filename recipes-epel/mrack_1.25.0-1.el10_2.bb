# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mrack"
PV = "1.25.0"
PR = "1.el10_2"
PACKAGES = " \
 mrack \
 mrack-cli \
 python3-mrack-aws \
 python3-mrack-beaker \
 python3-mrack-openstack \
 python3-mrack-podman \
 python3-mrack-virt \
 python3-mracklib \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mrack-1.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1a53aa5f3d346cad0e863615045e7d68135090f0d06e02dd15dda0b9e17011de"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - python3-mracklib: sshpass

URI_x86_64_v2_mrack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mrack-1.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_mrack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mrack}"
SRC_URI[x86_64_v2_mrack.sha256sum] = "a2d982375171ee25fff8f60752d66b47239e14201263319ff725ed635db14940"

URI_x86_64_v2_mrack-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mrack-cli-1.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_mrack-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mrack-cli}"
SRC_URI[x86_64_v2_mrack-cli.sha256sum] = "3d8aff607fea114958d56ceb4ae0967df4d85ac7106e00444bd3c8609430c645"

URI_x86_64_v2_python3-mrack-aws = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mrack-aws-1.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mrack-aws;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mrack-aws}"
SRC_URI[x86_64_v2_python3-mrack-aws.sha256sum] = "b46f0547d9a885e9a7e4bb802f53301495751e0c68781e76731053b2d1941fdc"

URI_x86_64_v2_python3-mrack-beaker = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mrack-beaker-1.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mrack-beaker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mrack-beaker}"
SRC_URI[x86_64_v2_python3-mrack-beaker.sha256sum] = "5f013f496e734a6097f004a5327dbe607180406811ab6665991b782fe84bcc5f"

URI_x86_64_v2_python3-mrack-openstack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mrack-openstack-1.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mrack-openstack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mrack-openstack}"
SRC_URI[x86_64_v2_python3-mrack-openstack.sha256sum] = "0a70141b58d25d793328b29c907e733d95d3a891b6f3546791c74d826999b860"

URI_x86_64_v2_python3-mrack-podman = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mrack-podman-1.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mrack-podman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mrack-podman}"
SRC_URI[x86_64_v2_python3-mrack-podman.sha256sum] = "b02d4cf5738dbbe8191e75387a5508b22e80fd1889443007c89613ce7ff104a2"

URI_x86_64_v2_python3-mrack-virt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mrack-virt-1.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mrack-virt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mrack-virt}"
SRC_URI[x86_64_v2_python3-mrack-virt.sha256sum] = "3e39e81277e64d92ae98969e429979632340f86bbe650fb6994d299e62f9b0fd"

URI_x86_64_v2_python3-mracklib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mracklib-1.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mracklib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mracklib}"
SRC_URI[x86_64_v2_python3-mracklib.sha256sum] = "23f9dbc56bb7db73c5ee24738ba6d5d7266d2752bb845dd7fafcbe1712e46ab3"

URI_aarch64_mrack = "${EPEL_MIRROR}/aarch64/Packages/m/mrack-1.25.0-1.el10_2.noarch.rpm;name=aarch64_mrack;unpack=0"
SRC_URI:append = " ${URI_aarch64_mrack}"
SRC_URI[aarch64_mrack.sha256sum] = "70aeeb37729234763ff10e9e5c1519da7eb00c5bbe367a757d1ab6dd948d4a57"

URI_aarch64_mrack-cli = "${EPEL_MIRROR}/aarch64/Packages/m/mrack-cli-1.25.0-1.el10_2.noarch.rpm;name=aarch64_mrack-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_mrack-cli}"
SRC_URI[aarch64_mrack-cli.sha256sum] = "7d6f72b9418db6537f385e0c8ab463612c34ab8cb5a743287d09d7827bcc84ac"

URI_aarch64_python3-mrack-aws = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mrack-aws-1.25.0-1.el10_2.noarch.rpm;name=aarch64_python3-mrack-aws;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mrack-aws}"
SRC_URI[aarch64_python3-mrack-aws.sha256sum] = "64d737723c7b892d79415e1b2901235a134a2ed27cee85cf49e2d4fd6502fcb0"

URI_aarch64_python3-mrack-beaker = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mrack-beaker-1.25.0-1.el10_2.noarch.rpm;name=aarch64_python3-mrack-beaker;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mrack-beaker}"
SRC_URI[aarch64_python3-mrack-beaker.sha256sum] = "343f4b26a2a90a762e1c9ffca461c12dfc73939b32e5cb6964efb66aaf73d94b"

URI_aarch64_python3-mrack-openstack = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mrack-openstack-1.25.0-1.el10_2.noarch.rpm;name=aarch64_python3-mrack-openstack;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mrack-openstack}"
SRC_URI[aarch64_python3-mrack-openstack.sha256sum] = "8a18b8dd37d83749cea09e70dfca6c1d65adf554178b0ec10b3eb13babfec343"

URI_aarch64_python3-mrack-podman = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mrack-podman-1.25.0-1.el10_2.noarch.rpm;name=aarch64_python3-mrack-podman;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mrack-podman}"
SRC_URI[aarch64_python3-mrack-podman.sha256sum] = "3e8752585ca14c56a91a6e774acff15f4e37f590eeafed6b9d0353b260a01994"

URI_aarch64_python3-mrack-virt = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mrack-virt-1.25.0-1.el10_2.noarch.rpm;name=aarch64_python3-mrack-virt;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mrack-virt}"
SRC_URI[aarch64_python3-mrack-virt.sha256sum] = "db5d572c8565d2f3ea97af6007f920366528c999ebfeda6e40692b9c41bb17f6"

URI_aarch64_python3-mracklib = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mracklib-1.25.0-1.el10_2.noarch.rpm;name=aarch64_python3-mracklib;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mracklib}"
SRC_URI[aarch64_python3-mracklib.sha256sum] = "adf60b185c45bc313e8b59901d1bbaef21ce4eafe018847b2d37295a8f9d1a5c"

RDEPENDS:mrack = " \
 mrack-cli \
 python3-mrack-aws \
 python3-mrack-beaker \
 python3-mrack-openstack \
 python3-mrack-podman \
 python3-mrack-virt \
 python3-mracklib \
 "
RDEPENDS:mrack-cli = " \
 python3 \
 python3-click \
 python3-mracklib \
 "
RDEPENDS:python3-mrack-aws = " \
 python3 \
 python3-boto3 \
 python3-botocore \
 python3-mracklib \
 "
RDEPENDS:python3-mrack-beaker = " \
 beaker-client \
 python3 \
 python3-mracklib \
 "
RDEPENDS:python3-mrack-openstack = " \
 python3 \
 python3-mracklib \
 "
RDEPENDS:python3-mrack-podman = " \
 podman \
 python3 \
 python3-mracklib \
 "
RDEPENDS:python3-mrack-virt = " \
 python3 \
 python3-mracklib \
 testcloud \
 "
RDEPENDS:python3-mracklib:x86_64_v2 = " \
 python3 \
 python3-pyyaml \
"
RDEPENDS:python3-mracklib:aarch64 = " \
 python3 \
 python3-pyyaml \
 sshpass \
"
