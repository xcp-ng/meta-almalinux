# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "git-credential-oauth"
PV = "0.16.0"
PR = "1.el10_1"
PACKAGES = " \
 git-credential-oauth \
 golang-github-hickford-git-credential-oauth-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/git-credential-oauth-0.16.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ae1589390451559093bf36afa9753667947bfabea8d73f982537988bc47ea885"

URI_x86_64_v2_git-credential-oauth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/git-credential-oauth-0.16.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_git-credential-oauth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-credential-oauth}"
SRC_URI[x86_64_v2_git-credential-oauth.sha256sum] = "d86ed8940d6e42cfaafe68bbd25554e60d67365f0eabe1034c8dfcd8f615b9c6"

URI_x86_64_v2_golang-github-hickford-git-credential-oauth-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-hickford-git-credential-oauth-devel-0.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-hickford-git-credential-oauth-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-hickford-git-credential-oauth-devel}"
SRC_URI[x86_64_v2_golang-github-hickford-git-credential-oauth-devel.sha256sum] = "88a45431319f1287d22c44f90d538687e8047e2992e05b132ee328a238b65496"

URI_aarch64_git-credential-oauth = "${EPEL_MIRROR}/aarch64/Packages/g/git-credential-oauth-0.16.0-1.el10_1.aarch64.rpm;name=aarch64_git-credential-oauth;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-credential-oauth}"
SRC_URI[aarch64_git-credential-oauth.sha256sum] = "6a55e334a09073f9cf5a4229a3ef52acf2c2f1cb577fd4e4eae75f6afac1f74d"

URI_aarch64_golang-github-hickford-git-credential-oauth-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-hickford-git-credential-oauth-devel-0.16.0-1.el10_1.noarch.rpm;name=aarch64_golang-github-hickford-git-credential-oauth-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-hickford-git-credential-oauth-devel}"
SRC_URI[aarch64_golang-github-hickford-git-credential-oauth-devel.sha256sum] = "a593033dd26a1b2dfb554b1e3ab8a542db01c7653f3e0bf0c26ae2b13fab5f02"

RDEPENDS:git-credential-oauth = " \
 glibc \
 "
RDEPENDS:golang-github-hickford-git-credential-oauth-devel = " \
 go-filesystem \
 golang-x-oauth2-devel \
 "
