# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "py-radix"
PV = "0.10.0"
PR = "12.el10_0"
PACKAGES = " \
 python3-py-radix \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/py-radix-0.10.0-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ecf34d976e433ecfad5d4d93bcbfd8b9cb7d4d580d132cd679cff3575f356bfa"

URI_x86_64_v2_python3-py-radix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-py-radix-0.10.0-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-py-radix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-py-radix}"
SRC_URI[x86_64_v2_python3-py-radix.sha256sum] = "f9244f389918648ada00d2694471ee0e2bb40bda3c2963d62df50c12e91078d8"

URI_aarch64_python3-py-radix = "${EPEL_MIRROR}/aarch64/Packages/p/python3-py-radix-0.10.0-12.el10_0.aarch64.rpm;name=aarch64_python3-py-radix;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-py-radix}"
SRC_URI[aarch64_python3-py-radix.sha256sum] = "54e109eecd992d927ec43bb7b70f2071a0998c78a50275d8cd3b586c2fde29e4"

RDEPENDS:python3-py-radix = " \
 glibc \
 python3 \
 "
