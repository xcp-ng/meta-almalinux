# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cifs-utils"
PV = "7.2"
PR = "0.el10_0.1"
PACKAGES = " \
 cifs-utils \
 cifs-utils-devel \
 pam_cifscreds \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/cifs-utils-7.2-0.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "82473fea90d320a651850521e35f00af0df9e0ce475d5b88eed9177d3ed573aa"

URI_x86_64_v2_cifs-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cifs-utils-7.2-0.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_cifs-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cifs-utils}"
SRC_URI[x86_64_v2_cifs-utils.sha256sum] = "436b4dfe8f367fc6d566481b363c91bf6b5c2b7e13aa4bad06ae93236711ad9f"

URI_x86_64_v2_cifs-utils-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/cifs-utils-devel-7.2-0.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_cifs-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cifs-utils-devel}"
SRC_URI[x86_64_v2_cifs-utils-devel.sha256sum] = "ffaf98ea2fd66510cfea9e77b24b8fa4087a818aace068babb399fa226b71b5e"

URI_x86_64_v2_pam_cifscreds = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pam_cifscreds-7.2-0.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_pam_cifscreds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam_cifscreds}"
SRC_URI[x86_64_v2_pam_cifscreds.sha256sum] = "a280b837d6beea6ca25ffd9ab299b119913308bf81cb64ac096129317f251eef"

URI_aarch64_cifs-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cifs-utils-7.2-0.el10_0.1.aarch64.rpm;name=aarch64_cifs-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_cifs-utils}"
SRC_URI[aarch64_cifs-utils.sha256sum] = "fce789929018130d1628db872d3bf82255bf491b594139e2ef5140a6927719b2"

URI_aarch64_cifs-utils-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/cifs-utils-devel-7.2-0.el10_0.1.aarch64.rpm;name=aarch64_cifs-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cifs-utils-devel}"
SRC_URI[aarch64_cifs-utils-devel.sha256sum] = "2cd6db9a0ccbe91e15a7f87a3e6d42c8162a5c7dacb01b28adab86b29394448a"

URI_aarch64_pam_cifscreds = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pam_cifscreds-7.2-0.el10_0.1.aarch64.rpm;name=aarch64_pam_cifscreds;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam_cifscreds}"
SRC_URI[aarch64_pam_cifscreds.sha256sum] = "a7dfe539686e5ab3da8ca2defdc6cba884807aa8a74eb533716fe61ca80a08dc"

RDEPENDS:cifs-utils = " \
 alternatives \
 bash \
 glibc \
 keyutils \
 keyutils-libs \
 krb5-libs \
 libcap-ng \
 libtalloc \
 libwbclient \
 "
RDEPENDS:cifs-utils-devel = " \
 "
RDEPENDS:pam_cifscreds = " \
 glibc \
 keyutils-libs \
 libtalloc \
 pam-libs \
 "
