# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-GitLab-API-v4"
PV = "0.27"
PR = "7.el10_1"
PACKAGES = " \
 perl-GitLab-API-v4 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-GitLab-API-v4-0.27-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2b1791990ebb2c219670c9e431cf9262913c16d6a6e732c0b9b7b8e1085adb9a"

URI_x86_64_v2_perl-GitLab-API-v4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-GitLab-API-v4-0.27-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-GitLab-API-v4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-GitLab-API-v4}"
SRC_URI[x86_64_v2_perl-GitLab-API-v4.sha256sum] = "5b293839a01221bb25042699b0691b92b9e2eee0fac87f40fe6a667c89f19447"

URI_aarch64_perl-GitLab-API-v4 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-GitLab-API-v4-0.27-7.el10_1.noarch.rpm;name=aarch64_perl-GitLab-API-v4;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-GitLab-API-v4}"
SRC_URI[aarch64_perl-GitLab-API-v4.sha256sum] = "55e69a6cd729f164c19b61cb06f95674286e61536d75210142583a74ec5dd54c"

RDEPENDS:perl-GitLab-API-v4 = " \
 perl-Carp \
 perl-Const-Fast \
 perl-Exporter \
 perl-Getopt-Long \
 perl-GitLab-API-v4 \
 perl-HTTP-Tiny \
 perl-HTTP-Tiny-Multipart \
 perl-IO-Prompter \
 perl-JSON-MaybeXS \
 perl-Log-Any \
 perl-Log-Any-Adapter-Screen \
 perl-Moo \
 perl-Path-Tiny \
 perl-Pod-Usage \
 perl-Scalar-List-Utils \
 perl-Try-Tiny \
 perl-Type-Tiny \
 perl-URI \
 perl-interpreter \
 perl-libs \
 perl-namespace-clean \
 perl-strictures \
 "
