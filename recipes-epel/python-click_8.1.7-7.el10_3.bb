# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-click"
PV = "8.1.7"
PR = "7.el10_3"
PACKAGES = " \
 python3-click \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-click-8.1.7-7.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0143e3cd0cf4fb1ee98e2b91f9148e2ce743a797af06aca038acff87624c57b4"

URI_x86_64_v2_python3-click = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-click-8.1.7-7.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-click;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-click}"
SRC_URI[x86_64_v2_python3-click.sha256sum] = "e67a79528d52637dc353dd835dd1dd01c0eb09f9c41ebbca2f6c08a41c2e8c4d"

URI_aarch64_python3-click = "${EPEL_MIRROR}/aarch64/Packages/p/python3-click-8.1.7-7.el10_3.noarch.rpm;name=aarch64_python3-click;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-click}"
SRC_URI[aarch64_python3-click.sha256sum] = "59b66f0a07c5dab0a031e083dd2eddf980014c27724355cc861f6876d372b057"

RDEPENDS:python3-click = " \
 python3 \
 "
