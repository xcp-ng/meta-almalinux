# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-knotifyconfig"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-knotifyconfig \
 kf6-knotifyconfig-devel \
 kf6-knotifyconfig-doc \
 kf6-knotifyconfig-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-knotifyconfig-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1e9f49bb73caae80d27a876266f2e03df55975297db4b2520f5a50c1d3ccfc64"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifyconfig-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-knotifyconfig;unpack=0"
SRC_URI[x86_64_v2_kf6-knotifyconfig.sha256sum] = "590387a07132d6cda104d1c511551dc714ea4877ec88cf211112c5688cdac24d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifyconfig-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-knotifyconfig-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-knotifyconfig-devel.sha256sum] = "ef3cc195895966dac4ae445d44d35a6d5f81f12e6fc02c05869424af2674555f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifyconfig-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-knotifyconfig-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-knotifyconfig-doc.sha256sum] = "3728a7a1bac78c712357c75d2c40f301e20d0649208642d26d46c5e3985511d0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifyconfig-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-knotifyconfig-html;unpack=0"
SRC_URI[x86_64_v2_kf6-knotifyconfig-html.sha256sum] = "788db0d42faa5105e6642cebedc2da5269233d83ea95f7198b731446577bf8d9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifyconfig-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-knotifyconfig;unpack=0"
SRC_URI[aarch64_kf6-knotifyconfig.sha256sum] = "0aee9e0cb30f1c6d7e22281975bcf1f221ad8839601ccdd4675a2b47cf4e99d4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifyconfig-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-knotifyconfig-devel;unpack=0"
SRC_URI[aarch64_kf6-knotifyconfig-devel.sha256sum] = "0a485f16bc8500f77d7b745b17d4d0221321fba928f9a2c4ac45f6cad3bb089d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifyconfig-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-knotifyconfig-doc;unpack=0"
SRC_URI[aarch64_kf6-knotifyconfig-doc.sha256sum] = "ff4fbe3f8c55503d1c9154aa105cc89ec03312f6a9235b636cd7ad62fcb68bfd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifyconfig-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-knotifyconfig-html;unpack=0"
SRC_URI[aarch64_kf6-knotifyconfig-html.sha256sum] = "3c182f3c1f8509d5b70239e12f62dd1cabfbc8b67b55cf6e9201c47ebdb04b0d"

RDEPENDS:kf6-knotifyconfig = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 libcanberra \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-knotifyconfig-devel = " \
 cmake-filesystem \
 kf6-knotifyconfig \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-knotifyconfig-doc = " \
 "
RDEPENDS:kf6-knotifyconfig-html = " \
 "
