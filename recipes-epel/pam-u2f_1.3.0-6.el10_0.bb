# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pam-u2f"
PV = "1.3.0"
PR = "6.el10_0"
PACKAGES = " \
 pam-u2f \
 pamu2fcfg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pam-u2f-1.3.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "03a32210a563ac5d44e55065ae9e1a23d16584581cda8fd6777bb91049e792f2"

URI_x86_64_v2_pam-u2f = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pam-u2f-1.3.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pam-u2f;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam-u2f}"
SRC_URI[x86_64_v2_pam-u2f.sha256sum] = "6a30853fd1a89e8e2cf4d6fb7829957135437982ebacf887247cd5d19ccbaf3d"

URI_x86_64_v2_pamu2fcfg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pamu2fcfg-1.3.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pamu2fcfg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pamu2fcfg}"
SRC_URI[x86_64_v2_pamu2fcfg.sha256sum] = "03419333b3a61ba84f980811fe6f0790dc920c8bf0348279d199eabe339a3868"

URI_aarch64_pam-u2f = "${EPEL_MIRROR}/aarch64/Packages/p/pam-u2f-1.3.0-6.el10_0.aarch64.rpm;name=aarch64_pam-u2f;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam-u2f}"
SRC_URI[aarch64_pam-u2f.sha256sum] = "866e1cf7357f849ccbc89d9541f5416877c25d486843c9257bef7fb008f7327e"

URI_aarch64_pamu2fcfg = "${EPEL_MIRROR}/aarch64/Packages/p/pamu2fcfg-1.3.0-6.el10_0.aarch64.rpm;name=aarch64_pamu2fcfg;unpack=0"
SRC_URI:append = " ${URI_aarch64_pamu2fcfg}"
SRC_URI[aarch64_pamu2fcfg.sha256sum] = "06aa156c0f3b751072458fc853bfaa5b489a8f87572225e71b6398165a6d07e3"

RDEPENDS:pam-u2f = " \
 glibc \
 libfido2 \
 openssl-libs \
 pam-libs \
 "
RDEPENDS:pamu2fcfg = " \
 glibc \
 libfido2 \
 openssl-libs \
 pam-u2f \
 "
