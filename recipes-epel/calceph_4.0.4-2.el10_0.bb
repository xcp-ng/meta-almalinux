# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "calceph"
PV = "4.0.4"
PR = "2.el10_0"
PACKAGES = " \
 calceph \
 calceph-devel \
 calceph-fortran-devel \
 calceph-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/calceph-4.0.4-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "79424e782e8abffe2c8c63ff937289cd0e1a514bc4404b54719cdf8d669e9615"

URI_x86_64_v2_calceph = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/calceph-4.0.4-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_calceph;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_calceph}"
SRC_URI[x86_64_v2_calceph.sha256sum] = "6382a55487ad8af3c2a3c0904f16b955ec676ff223ce7703fee28595d919fbd0"

URI_x86_64_v2_calceph-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/calceph-devel-4.0.4-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_calceph-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_calceph-devel}"
SRC_URI[x86_64_v2_calceph-devel.sha256sum] = "fb3225834902205a1da6c74aa3fe8807ac49fe23f7e74d8bb3ca10c3731e53f5"

URI_x86_64_v2_calceph-fortran-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/calceph-fortran-devel-4.0.4-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_calceph-fortran-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_calceph-fortran-devel}"
SRC_URI[x86_64_v2_calceph-fortran-devel.sha256sum] = "076f495afeb181d6df01d2f9fbb917761a524904b426e4c5205eeb7287d0c058"

URI_x86_64_v2_calceph-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/calceph-libs-4.0.4-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_calceph-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_calceph-libs}"
SRC_URI[x86_64_v2_calceph-libs.sha256sum] = "2f11e05224d3e7cd88c5c3199746d3b9534c6cbe4a5c8f5f8da39e95ea147b3a"

URI_aarch64_calceph = "${EPEL_MIRROR}/aarch64/Packages/c/calceph-4.0.4-2.el10_0.aarch64.rpm;name=aarch64_calceph;unpack=0"
SRC_URI:append = " ${URI_aarch64_calceph}"
SRC_URI[aarch64_calceph.sha256sum] = "69b5045fa88c36da7560c4bc061c1d6a80edde8aa7db141e7e89e958b125bd03"

URI_aarch64_calceph-devel = "${EPEL_MIRROR}/aarch64/Packages/c/calceph-devel-4.0.4-2.el10_0.aarch64.rpm;name=aarch64_calceph-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_calceph-devel}"
SRC_URI[aarch64_calceph-devel.sha256sum] = "ff3b18fc7e5108894032d6465e49bbc80418b475e9f9679998ef3782b8875416"

URI_aarch64_calceph-fortran-devel = "${EPEL_MIRROR}/aarch64/Packages/c/calceph-fortran-devel-4.0.4-2.el10_0.aarch64.rpm;name=aarch64_calceph-fortran-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_calceph-fortran-devel}"
SRC_URI[aarch64_calceph-fortran-devel.sha256sum] = "ac6d384b182910b9e948167745707060f6441754638f09fc3b18bf952b13f05e"

URI_aarch64_calceph-libs = "${EPEL_MIRROR}/aarch64/Packages/c/calceph-libs-4.0.4-2.el10_0.aarch64.rpm;name=aarch64_calceph-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_calceph-libs}"
SRC_URI[aarch64_calceph-libs.sha256sum] = "7720a71c53e10d330ecdd1024cc8d511d0859b956b457b0dca9115e2b9b5dfdf"

RDEPENDS:calceph = " \
 calceph-libs \
 glibc \
 "
RDEPENDS:calceph-devel = " \
 calceph \
 calceph-libs \
 cmake-filesystem \
 "
RDEPENDS:calceph-fortran-devel = " \
 calceph \
 calceph-devel \
 gcc-gfortran \
 "
RDEPENDS:calceph-libs:x86_64_v2 = " \
 glibc \
 libgcc \
 libgfortran \
"
RDEPENDS:calceph-libs:aarch64 = " \
 glibc \
 libgfortran \
"
