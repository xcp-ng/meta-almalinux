# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dejagnu"
PE = "1"
PV = "1.6.3"
PR = "11.el10"
PACKAGES = " \
 dejagnu \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/dejagnu-1.6.3-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "89d0bbd44087ab32c2c653e8e4b73d0f5b53c05410eda2317755849954b60c37"

URI_x86_64_v2_dejagnu = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dejagnu-1.6.3-11.el10.noarch.rpm;name=x86_64_v2_dejagnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dejagnu}"
SRC_URI[x86_64_v2_dejagnu.sha256sum] = "969730168b90e214c2fdc761f771fcfd0627feed53898df026e30884b7db54a2"

URI_aarch64_dejagnu = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dejagnu-1.6.3-11.el10.noarch.rpm;name=aarch64_dejagnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_dejagnu}"
SRC_URI[aarch64_dejagnu.sha256sum] = "969730168b90e214c2fdc761f771fcfd0627feed53898df026e30884b7db54a2"

RDEPENDS:dejagnu = " \
 bash \
 expect \
 "
