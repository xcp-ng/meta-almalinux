# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksmtp"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 ksmtp \
 ksmtp-devel \
 ksmtp-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ksmtp-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4617f7064b4493cd17085d9c8b7ee366c4a1547502ff690a3eccf3ca8ba45273"

URI_x86_64_v2_ksmtp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksmtp-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksmtp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksmtp}"
SRC_URI[x86_64_v2_ksmtp.sha256sum] = "6eb40e48d67bab177375feeef4f1b036f54446d2a6ae67c3a3a64f2ec1614840"

URI_x86_64_v2_ksmtp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksmtp-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksmtp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksmtp-devel}"
SRC_URI[x86_64_v2_ksmtp-devel.sha256sum] = "bc09b4dfa32718812fe68e655375728d9032702114bd75a2531b0d3500418fc2"

URI_x86_64_v2_ksmtp-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksmtp-doc-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ksmtp-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksmtp-doc}"
SRC_URI[x86_64_v2_ksmtp-doc.sha256sum] = "f17bff2aa9364e3112e8d2b4fbbe7c890bd441b3f90d7a2b5787ed2e61d4f763"

URI_aarch64_ksmtp = "${EPEL_MIRROR}/aarch64/Packages/k/ksmtp-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_ksmtp;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksmtp}"
SRC_URI[aarch64_ksmtp.sha256sum] = "c1abf7b649fed0f1f0481c5624c2dd9bfc3f07b71db1a9046118288ec47d630c"

URI_aarch64_ksmtp-devel = "${EPEL_MIRROR}/aarch64/Packages/k/ksmtp-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_ksmtp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksmtp-devel}"
SRC_URI[aarch64_ksmtp-devel.sha256sum] = "365e6303d05f192e08807ebfa59c5dafa488c9a7be52fdb5d49dcaddeb3d9489"

URI_aarch64_ksmtp-doc = "${EPEL_MIRROR}/aarch64/Packages/k/ksmtp-doc-25.08.1-1.el10_1.noarch.rpm;name=aarch64_ksmtp-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksmtp-doc}"
SRC_URI[aarch64_ksmtp-doc.sha256sum] = "2674f70e4d8fa0ffff509e36848736e9e95cc1469be4ebb06e6eff9c12ed7fbc"

RDEPENDS:ksmtp = " \
 cyrus-sasl-lib \
 cyrus-sasl-plain \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:ksmtp-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kmime-devel \
 ksmtp \
 "
RDEPENDS:ksmtp-doc = " \
 "
