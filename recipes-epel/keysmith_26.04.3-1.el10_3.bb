# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keysmith"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 keysmith \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/keysmith-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d012466d62b2000dcb813aa8e94f7d8d49ab5202b3173fe87a92e09fc551995f"

URI_x86_64_v2_keysmith = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/keysmith-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_keysmith;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keysmith}"
SRC_URI[x86_64_v2_keysmith.sha256sum] = "583dad8959d29e988433b329eeca964e17f1f47d649eac80ead6493d8a3ff7d2"

URI_aarch64_keysmith = "${EPEL_MIRROR}/aarch64/Packages/k/keysmith-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_keysmith;unpack=0"
SRC_URI:append = " ${URI_aarch64_keysmith}"
SRC_URI[aarch64_keysmith.sha256sum] = "84c08414ab0e8080c9efd9ec957d68b4a86273f141b238b7d0198b86e74b6bc2"

RDEPENDS:keysmith = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kwindowsystem \
 kf6-prison \
 kf6-qqc2-desktop-style \
 libsodium \
 libstdc++ \
 openssl-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
