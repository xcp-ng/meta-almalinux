# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-cucumber-gherkin"
PV = "22.0.0"
PR = "10.el10_1"
PACKAGES = " \
 rubygem-cucumber-gherkin \
 rubygem-cucumber-gherkin-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-cucumber-gherkin-22.0.0-10.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e40aee67a7acb85e047be0c0f03eb50a25de9058e304a49b89a215533e459217"

URI_x86_64_v2_rubygem-cucumber-gherkin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-cucumber-gherkin-22.0.0-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-cucumber-gherkin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-cucumber-gherkin}"
SRC_URI[x86_64_v2_rubygem-cucumber-gherkin.sha256sum] = "abeb42e42e48884c3b4a5b10b19610a5c3fbcf252f9d69dd6e020c988784f683"

URI_x86_64_v2_rubygem-cucumber-gherkin-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-cucumber-gherkin-doc-22.0.0-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-cucumber-gherkin-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-cucumber-gherkin-doc}"
SRC_URI[x86_64_v2_rubygem-cucumber-gherkin-doc.sha256sum] = "e9a49a01bc195eb7c2574019f6f5e8ae67745ea5408807b7c9b1e55c2cdc7761"

URI_aarch64_rubygem-cucumber-gherkin = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-cucumber-gherkin-22.0.0-10.el10_1.noarch.rpm;name=aarch64_rubygem-cucumber-gherkin;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-cucumber-gherkin}"
SRC_URI[aarch64_rubygem-cucumber-gherkin.sha256sum] = "b3291f716d77a23f30d8cc9f9e1957326eae6939c8853fb21b3d2db9d9607a26"

URI_aarch64_rubygem-cucumber-gherkin-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-cucumber-gherkin-doc-22.0.0-10.el10_1.noarch.rpm;name=aarch64_rubygem-cucumber-gherkin-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-cucumber-gherkin-doc}"
SRC_URI[aarch64_rubygem-cucumber-gherkin-doc.sha256sum] = "39a02bf67aaad46d2ba1adff101db638534ab1d4d699250f84d5300f7cba2499"

RDEPENDS:rubygem-cucumber-gherkin = " \
 ruby \
 rubygem-cucumber-messages \
 rubygems \
 "
RDEPENDS:rubygem-cucumber-gherkin-doc = " \
 rubygem-cucumber-gherkin \
 "
