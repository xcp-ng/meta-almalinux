# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansible-collection-community-crypto"
PV = "2.26.7"
PR = "2.el10_3"
PACKAGES = " \
 ansible-collection-community-crypto \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/ansible-collection-community-crypto-2.26.7-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69217d5b6f59c95a246bcd4a2b4d15e72fb22bf9d37ab85d5d15543e6274b20c"

URI_x86_64_v2_ansible-collection-community-crypto = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ansible-collection-community-crypto-2.26.7-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ansible-collection-community-crypto;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-collection-community-crypto}"
SRC_URI[x86_64_v2_ansible-collection-community-crypto.sha256sum] = "faa1c96dd284b9b7ec70f05efe767e75593e7f351bf53d700bd2b008d44ac8f2"

URI_aarch64_ansible-collection-community-crypto = "${EPEL_MIRROR}/aarch64/Packages/a/ansible-collection-community-crypto-2.26.7-2.el10_3.noarch.rpm;name=aarch64_ansible-collection-community-crypto;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-collection-community-crypto}"
SRC_URI[aarch64_ansible-collection-community-crypto.sha256sum] = "5d51bb284c871a2966401196923a0fea9424f637546d09cb1e71da23c68481bf"

RDEPENDS:ansible-collection-community-crypto = " \
 ansible-core \
 "
