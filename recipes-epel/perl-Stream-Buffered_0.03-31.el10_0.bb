# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Stream-Buffered"
PV = "0.03"
PR = "31.el10_0"
PACKAGES = " \
 perl-Stream-Buffered \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Stream-Buffered-0.03-31.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0c39308dc4b1d357e7aa24f51c240916500cd7688593ffbe1a8520446135539"

URI_x86_64_v2_perl-Stream-Buffered = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Stream-Buffered-0.03-31.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Stream-Buffered;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Stream-Buffered}"
SRC_URI[x86_64_v2_perl-Stream-Buffered.sha256sum] = "108dd2cf7e7c309f31537c4e55ca576c5e2a7586327d82dc59db115e3765d202"

URI_aarch64_perl-Stream-Buffered = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Stream-Buffered-0.03-31.el10_0.noarch.rpm;name=aarch64_perl-Stream-Buffered;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Stream-Buffered}"
SRC_URI[aarch64_perl-Stream-Buffered.sha256sum] = "f1705b5766e62295f5528f2538d473dff00ea0f6589be91d2adb3f7278b79e2f"

RDEPENDS:perl-Stream-Buffered = " \
 perl-FileHandle \
 perl-IO \
 perl-Stream-Buffered \
 perl-base \
 perl-libs \
 "
