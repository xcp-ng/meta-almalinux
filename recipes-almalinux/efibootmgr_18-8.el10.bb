# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "efibootmgr"
PV = "18"
PR = "8.el10"
PACKAGES = " \
 efibootmgr \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/efibootmgr-18-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "750701488a7da37e18909c1f4bd37fa97d9e515f6293b403406eeca5aa089ccb"

URI_x86_64_v2_efibootmgr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/efibootmgr-18-8.el10.x86_64_v2.rpm;name=x86_64_v2_efibootmgr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_efibootmgr}"
SRC_URI[x86_64_v2_efibootmgr.sha256sum] = "f37c6bb9822a1c8d1e30a63f66b904a281bb19758b3c3ab13946bafba850d799"

URI_aarch64_efibootmgr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/efibootmgr-18-8.el10.aarch64.rpm;name=aarch64_efibootmgr;unpack=0"
SRC_URI:append = " ${URI_aarch64_efibootmgr}"
SRC_URI[aarch64_efibootmgr.sha256sum] = "de423205e83c5fef8740823ea99ecc086cfb984a4041f83bff0f9889dc517502"

RDEPENDS:efibootmgr = " \
 efi-filesystem \
 efivar-libs \
 glibc \
 popt \
 "
