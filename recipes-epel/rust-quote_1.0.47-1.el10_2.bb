# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-quote"
PV = "1.0.47"
PR = "1.el10_2"
PACKAGES = " \
 rust-quote+default-devel \
 rust-quote+proc-macro-devel \
 rust-quote-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-quote-1.0.47-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "efbda6081d9553dfdb844ace1cb1aff96e107573e0846c2ca41a04fdc0a4d2a0"

URI_x86_64_v2_rust-quote+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quote+default-devel-1.0.47-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quote+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quote+default-devel}"
SRC_URI[x86_64_v2_rust-quote+default-devel.sha256sum] = "542ab9d8b6c863e4acdfa40df9f33aa3719262b33aa1aca3e822fd36116d3e06"

URI_x86_64_v2_rust-quote+proc-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quote+proc-macro-devel-1.0.47-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quote+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quote+proc-macro-devel}"
SRC_URI[x86_64_v2_rust-quote+proc-macro-devel.sha256sum] = "312c4f6d54fcf87066aeebbfbf1df9ec550218eebf1682543fa767ea7af04564"

URI_x86_64_v2_rust-quote-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quote-devel-1.0.47-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quote-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quote-devel}"
SRC_URI[x86_64_v2_rust-quote-devel.sha256sum] = "ceb322c0e1f5a1b8da4a60c695333076c23a5af54401873f5fdbaf8b42fa70ec"

URI_aarch64_rust-quote+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quote+default-devel-1.0.47-1.el10_2.noarch.rpm;name=aarch64_rust-quote+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quote+default-devel}"
SRC_URI[aarch64_rust-quote+default-devel.sha256sum] = "584f74051f3e9c5b07fc739351fa0f8270211a756b871cae3f781114c55373b7"

URI_aarch64_rust-quote+proc-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quote+proc-macro-devel-1.0.47-1.el10_2.noarch.rpm;name=aarch64_rust-quote+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quote+proc-macro-devel}"
SRC_URI[aarch64_rust-quote+proc-macro-devel.sha256sum] = "5bd2e952fb195bbdad1c2b2028b45f995d711bf13468a6eeab6509d571eebf54"

URI_aarch64_rust-quote-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quote-devel-1.0.47-1.el10_2.noarch.rpm;name=aarch64_rust-quote-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quote-devel}"
SRC_URI[aarch64_rust-quote-devel.sha256sum] = "6a7a64e4d6f572d153d100799502160cbef022968b4dd67b7788306df9c1a2ca"

RDEPENDS:rust-quote+default-devel = " \
 cargo \
 rust-quote+proc-macro-devel \
 rust-quote-devel \
 "
RDEPENDS:rust-quote+proc-macro-devel = " \
 cargo \
 rust-proc-macro2+proc-macro-devel \
 rust-quote-devel \
 "
RDEPENDS:rust-quote-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 "
