# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tracing-attributes"
PV = "0.1.31"
PR = "1.el10_2"
PACKAGES = " \
 rust-tracing-attributes+async-await-devel \
 rust-tracing-attributes+default-devel \
 rust-tracing-attributes-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tracing-attributes-0.1.31-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ebb96126446675c1f9115e5ceee6d8b557ec78f2aed54ccf52e049cb8f94f6cf"

URI_x86_64_v2_rust-tracing-attributes+async-await-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-attributes+async-await-devel-0.1.31-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-attributes+async-await-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-attributes+async-await-devel}"
SRC_URI[x86_64_v2_rust-tracing-attributes+async-await-devel.sha256sum] = "efa13333c49243942fbeea646d694adb3991340e0350856f1eee432bb516509b"

URI_x86_64_v2_rust-tracing-attributes+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-attributes+default-devel-0.1.31-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-attributes+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-attributes+default-devel}"
SRC_URI[x86_64_v2_rust-tracing-attributes+default-devel.sha256sum] = "438d07ebcc5cea71bc877e63e0ed65c805ae3a0285e63dc423999af04478c6a2"

URI_x86_64_v2_rust-tracing-attributes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-attributes-devel-0.1.31-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-attributes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-attributes-devel}"
SRC_URI[x86_64_v2_rust-tracing-attributes-devel.sha256sum] = "4a5fd187459fca21c10612ad58bde67eefb2530debb20649de7161842655349e"

URI_aarch64_rust-tracing-attributes+async-await-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-attributes+async-await-devel-0.1.31-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-attributes+async-await-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-attributes+async-await-devel}"
SRC_URI[aarch64_rust-tracing-attributes+async-await-devel.sha256sum] = "ddeca613affb80496053a8b0382ebbb4650332017b191a127865c7c0ee85dd2f"

URI_aarch64_rust-tracing-attributes+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-attributes+default-devel-0.1.31-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-attributes+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-attributes+default-devel}"
SRC_URI[aarch64_rust-tracing-attributes+default-devel.sha256sum] = "4bdf7d4ceb1b98191d13249724dc0fae53b269a8964166e7dffd7cffbdd1f40d"

URI_aarch64_rust-tracing-attributes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-attributes-devel-0.1.31-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-attributes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-attributes-devel}"
SRC_URI[aarch64_rust-tracing-attributes-devel.sha256sum] = "68d5b374ebd8771f27aa88ace8f34fe580c122dbcbc33f92c19f43f69b844641"

RDEPENDS:rust-tracing-attributes+async-await-devel = " \
 cargo \
 rust-tracing-attributes-devel \
 "
RDEPENDS:rust-tracing-attributes+default-devel = " \
 cargo \
 rust-tracing-attributes-devel \
 "
RDEPENDS:rust-tracing-attributes-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+clone-impls-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn+visit-mut-devel \
 rust-syn-devel \
 "
