# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "debhelper"
PV = "13.30"
PR = "2.el10_3"
PACKAGES = " \
 debhelper \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/debhelper-13.30-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b318cd3117bbb7d6d1439f2319a0f2f84a0eaaa316a77f1c95e5dd05489bc954"

URI_x86_64_v2_debhelper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/debhelper-13.30-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_debhelper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_debhelper}"
SRC_URI[x86_64_v2_debhelper.sha256sum] = "a2fda7cfc99316c83da34e5bebaf5257d79b390001b540bc0ffdd53f61554545"

URI_aarch64_debhelper = "${EPEL_MIRROR}/aarch64/Packages/d/debhelper-13.30-2.el10_3.noarch.rpm;name=aarch64_debhelper;unpack=0"
SRC_URI:append = " ${URI_aarch64_debhelper}"
SRC_URI[aarch64_debhelper.sha256sum] = "c8c1e8db760ab7ffbbc1d337cae0c3af77be3fed2f8ca055a19dfb03adfca319"

RDEPENDS:debhelper = " \
 binutils \
 dh-autoreconf \
 dpkg \
 dpkg-dev \
 dpkg-perl \
 gzip \
 perl-Carp \
 perl-Digest-SHA \
 perl-Errno \
 perl-Exporter \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-stat \
 perl-Getopt-Long \
 perl-JSON-PP \
 perl-PathTools \
 perl-Time-Piece \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-parent \
 po-debconf \
 "
