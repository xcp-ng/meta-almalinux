# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "java-25-openjdk"
PE = "1"
PV = "25.0.4.1.1"
PR = "1.1.el10.alma.1"
PACKAGES = " \
 java-25-openjdk \
 java-25-openjdk-crypto-adapter \
 java-25-openjdk-crypto-adapter-fastdebug \
 java-25-openjdk-crypto-adapter-slowdebug \
 java-25-openjdk-demo \
 java-25-openjdk-demo-fastdebug \
 java-25-openjdk-demo-slowdebug \
 java-25-openjdk-devel \
 java-25-openjdk-devel-fastdebug \
 java-25-openjdk-devel-slowdebug \
 java-25-openjdk-fastdebug \
 java-25-openjdk-headless \
 java-25-openjdk-headless-fastdebug \
 java-25-openjdk-headless-slowdebug \
 java-25-openjdk-javadoc \
 java-25-openjdk-javadoc-zip \
 java-25-openjdk-jmods \
 java-25-openjdk-jmods-fastdebug \
 java-25-openjdk-jmods-slowdebug \
 java-25-openjdk-slowdebug \
 java-25-openjdk-src \
 java-25-openjdk-src-fastdebug \
 java-25-openjdk-src-slowdebug \
 java-25-openjdk-static-libs \
 java-25-openjdk-static-libs-fastdebug \
 java-25-openjdk-static-libs-slowdebug \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/java-25-openjdk-25.0.4.1.1-1.1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e1e1255257d12e2877051e39454cd593a51ced171cc2fbb1526317df2c544e5"

URI_x86_64_v2_java-25-openjdk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-25.0.4.1.1-1.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk}"
SRC_URI[x86_64_v2_java-25-openjdk.sha256sum] = "9a4a253eba8b95aa19bbdd4d1f4620b62466a8c501429f7c1c8097d3d7689bed"

URI_x86_64_v2_java-25-openjdk-crypto-adapter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-crypto-adapter-25.0.4.1.1-1.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-crypto-adapter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-crypto-adapter}"
SRC_URI[x86_64_v2_java-25-openjdk-crypto-adapter.sha256sum] = "18e2991065e33a6ce56d8af1f700255585657c7b3c5529477a6870fde8611aa6"

URI_x86_64_v2_java-25-openjdk-crypto-adapter-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-crypto-adapter-fastdebug-25.0.4.1.1-1.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-crypto-adapter-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-crypto-adapter-fastdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-crypto-adapter-fastdebug.sha256sum] = "cdd6404c28630d25a4b86d0e0960261166c76af3c74026f2b07a40bcb28d06a1"

URI_x86_64_v2_java-25-openjdk-crypto-adapter-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-crypto-adapter-slowdebug-25.0.4.1.1-1.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-crypto-adapter-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-crypto-adapter-slowdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-crypto-adapter-slowdebug.sha256sum] = "cfadd7474d226b88fdacb1f8c78029feeb80937fbb9cf3605d5459fa4d1aab7d"

URI_x86_64_v2_java-25-openjdk-demo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-demo-25.0.4.1.1-1.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-demo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-demo}"
SRC_URI[x86_64_v2_java-25-openjdk-demo.sha256sum] = "840b1b19d869a7bce390c7c38691f6953aebb29798195cc455deac6eb069814d"

URI_x86_64_v2_java-25-openjdk-demo-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-demo-fastdebug-25.0.4.1.1-1.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-demo-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-demo-fastdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-demo-fastdebug.sha256sum] = "2861426cc1ebbab1f37eb9c86d785eeef9ec8da1a8a595bbd9da34bf8ab8fafb"

URI_x86_64_v2_java-25-openjdk-demo-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-demo-slowdebug-25.0.4.1.1-1.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-demo-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-demo-slowdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-demo-slowdebug.sha256sum] = "bc764a8400fdeece0bd9dd11cebf979eb32e415d542348fddf6aaea394f9793f"

URI_x86_64_v2_java-25-openjdk-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-devel-25.0.4.1.1-1.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-devel}"
SRC_URI[x86_64_v2_java-25-openjdk-devel.sha256sum] = "3f11e511ced88215e7df5d0f5fdc452913fab6e7c25492b8e6417ada3f2e3d00"

URI_x86_64_v2_java-25-openjdk-devel-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-devel-fastdebug-25.0.4.1.1-1.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-devel-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-devel-fastdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-devel-fastdebug.sha256sum] = "d4e1cf1ccf9572d82d8b2c35f9c877f1f464f20b964acd2dff75d06e77a13f21"

URI_x86_64_v2_java-25-openjdk-devel-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-devel-slowdebug-25.0.4.1.1-1.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-devel-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-devel-slowdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-devel-slowdebug.sha256sum] = "76801a56f0790fe12df7ec9cdadd79f4156c1b7340027879f0d45bca99615387"

URI_x86_64_v2_java-25-openjdk-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-fastdebug-25.0.4.1.1-1.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-fastdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-fastdebug.sha256sum] = "62598efdb35fd9947341e43243285818558d7e469db8a166f8ae0395d70ac499"

URI_x86_64_v2_java-25-openjdk-headless = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-headless-25.0.4.1.1-1.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-headless;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-headless}"
SRC_URI[x86_64_v2_java-25-openjdk-headless.sha256sum] = "b8458fd49a0a2c8f5721467f7fd2e50dc435ba99d9cd131365f1e1a5d10a5ff9"
RPROVIDES:java-25-openjdk-headless:x86_64_v2 = "virtual/java-headless_or_java-21-headless_or_java-25-headless virtual/java-headless_or_java-25-headless"

URI_x86_64_v2_java-25-openjdk-headless-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-headless-fastdebug-25.0.4.1.1-1.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-headless-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-headless-fastdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-headless-fastdebug.sha256sum] = "b58d10012552e4a58a6a3dfd65dd8e9bdecdb6f05367e1d5cc52ac367956a164"

URI_x86_64_v2_java-25-openjdk-headless-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-headless-slowdebug-25.0.4.1.1-1.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-headless-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-headless-slowdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-headless-slowdebug.sha256sum] = "983b482d983c284509a363cd5f83dd953dfbcd0f83c8c09f84f25eeb5ddc01ac"

URI_x86_64_v2_java-25-openjdk-javadoc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-javadoc-25.0.4.1.1-1.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-javadoc}"
SRC_URI[x86_64_v2_java-25-openjdk-javadoc.sha256sum] = "c0c1c09b0d8cb679555b64eae90094cd6a60de84032bc3cb7a2344bcc0da8037"

URI_x86_64_v2_java-25-openjdk-javadoc-zip = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-javadoc-zip-25.0.4.1.1-1.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-javadoc-zip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-javadoc-zip}"
SRC_URI[x86_64_v2_java-25-openjdk-javadoc-zip.sha256sum] = "acabda2714fcca3d44b9ec8591c54822c9281615595aca114626c5cc79dc86b9"

URI_x86_64_v2_java-25-openjdk-jmods = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-jmods-25.0.4.1.1-1.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-jmods;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-jmods}"
SRC_URI[x86_64_v2_java-25-openjdk-jmods.sha256sum] = "6ea1ac15dc43292daeb50674f333ddd700b0bb4c954e16d8e293acbc9abc0fc9"

URI_x86_64_v2_java-25-openjdk-jmods-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-jmods-fastdebug-25.0.4.1.1-1.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-jmods-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-jmods-fastdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-jmods-fastdebug.sha256sum] = "63812db0ced0c40754df6d51856d71f6d82a9292aed70e73a2b06515a31d52d6"

URI_x86_64_v2_java-25-openjdk-jmods-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-jmods-slowdebug-25.0.4.1.1-1.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-jmods-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-jmods-slowdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-jmods-slowdebug.sha256sum] = "bca6638264ae104e19cbe813e5afd22ec9ef9bc9e06b97482051354fa14ed014"

URI_x86_64_v2_java-25-openjdk-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-slowdebug-25.0.4.1.1-1.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-slowdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-slowdebug.sha256sum] = "8b59cfa32725f8f3f985c443bd010cd457a6ac6fe9c1ec33a73a937a12ed95c0"

URI_x86_64_v2_java-25-openjdk-src = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-src-25.0.4.1.1-1.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-src;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-src}"
SRC_URI[x86_64_v2_java-25-openjdk-src.sha256sum] = "1692588f22d38321f86fd8cfa13be3111e38e37e624c8554f9b5a2bf1933369c"

URI_x86_64_v2_java-25-openjdk-src-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-src-fastdebug-25.0.4.1.1-1.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-src-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-src-fastdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-src-fastdebug.sha256sum] = "ae5ba2afcbcd62951be0b2d1c0136fc0a25802197b8649d1627bf38167ed6873"

URI_x86_64_v2_java-25-openjdk-src-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-src-slowdebug-25.0.4.1.1-1.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-src-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-src-slowdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-src-slowdebug.sha256sum] = "2d7174962c0a57c5e4e8663dc57a87ccff4e2a43e3c23705040eeceeedaa229a"

URI_x86_64_v2_java-25-openjdk-static-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-static-libs-25.0.4.1.1-1.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-static-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-static-libs}"
SRC_URI[x86_64_v2_java-25-openjdk-static-libs.sha256sum] = "1bb5fa6d596b66f64924a10a7bcea3e3f62c4b372b1c4f8ccc7b3624f84dff04"

URI_x86_64_v2_java-25-openjdk-static-libs-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-static-libs-fastdebug-25.0.4.1.1-1.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-static-libs-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-static-libs-fastdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-static-libs-fastdebug.sha256sum] = "eabdd8103613fa3fd878431bf2ec834ca80cc03eeb1d78a0e15dd3f9ec0b7666"

URI_x86_64_v2_java-25-openjdk-static-libs-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-static-libs-slowdebug-25.0.4.1.1-1.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-static-libs-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-static-libs-slowdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-static-libs-slowdebug.sha256sum] = "cbb0a8b75b7d9587221629e95e4dcbcfc5fbdc328d4393f608d45ef0b485412a"

URI_aarch64_java-25-openjdk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-25.0.4.1.1-1.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk}"
SRC_URI[aarch64_java-25-openjdk.sha256sum] = "9635aa43a825b9e9686f211587f24a636b83ba99fa76cdf4f4c414a5d7d48961"

URI_aarch64_java-25-openjdk-crypto-adapter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-crypto-adapter-25.0.4.1.1-1.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-crypto-adapter;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-crypto-adapter}"
SRC_URI[aarch64_java-25-openjdk-crypto-adapter.sha256sum] = "8679046dccdd6758c5d1e47e631945aa3f80452da9743a341298eeac6e6b0d81"

URI_aarch64_java-25-openjdk-crypto-adapter-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-crypto-adapter-fastdebug-25.0.4.1.1-1.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-crypto-adapter-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-crypto-adapter-fastdebug}"
SRC_URI[aarch64_java-25-openjdk-crypto-adapter-fastdebug.sha256sum] = "2850a863dcbaeba5012fdd3987a6a2ab23c0d9dabed5c831c96b036f1f7bc19f"

URI_aarch64_java-25-openjdk-crypto-adapter-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-crypto-adapter-slowdebug-25.0.4.1.1-1.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-crypto-adapter-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-crypto-adapter-slowdebug}"
SRC_URI[aarch64_java-25-openjdk-crypto-adapter-slowdebug.sha256sum] = "6baa0271c80c979879d0143a62c96be8d547500f985d472a12fa10e10e1a4b79"

URI_aarch64_java-25-openjdk-demo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-demo-25.0.4.1.1-1.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-demo;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-demo}"
SRC_URI[aarch64_java-25-openjdk-demo.sha256sum] = "5c7e01b18aad6090b39f09beb826f75423d4a7ae06deeac00d072e89606e8bff"

URI_aarch64_java-25-openjdk-demo-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-demo-fastdebug-25.0.4.1.1-1.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-demo-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-demo-fastdebug}"
SRC_URI[aarch64_java-25-openjdk-demo-fastdebug.sha256sum] = "2bb8e08eab2a66d4685423d26136af713b9589602c109b7f2d2b557ef582d402"

URI_aarch64_java-25-openjdk-demo-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-demo-slowdebug-25.0.4.1.1-1.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-demo-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-demo-slowdebug}"
SRC_URI[aarch64_java-25-openjdk-demo-slowdebug.sha256sum] = "4621f0376cefdeedc3c36bfbd879ba74103b0f37186e28b8821e78f4de777fb0"

URI_aarch64_java-25-openjdk-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-devel-25.0.4.1.1-1.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-devel}"
SRC_URI[aarch64_java-25-openjdk-devel.sha256sum] = "343630f2b1ac4afa5e02de6cbf328616ed202bffab74e9f921123142f4aee7f3"

URI_aarch64_java-25-openjdk-devel-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-devel-fastdebug-25.0.4.1.1-1.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-devel-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-devel-fastdebug}"
SRC_URI[aarch64_java-25-openjdk-devel-fastdebug.sha256sum] = "acb8ec4e3b09a9b6e1f8b42710bf79ab00042d6e7ed808ce4cad9aa761f23185"

URI_aarch64_java-25-openjdk-devel-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-devel-slowdebug-25.0.4.1.1-1.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-devel-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-devel-slowdebug}"
SRC_URI[aarch64_java-25-openjdk-devel-slowdebug.sha256sum] = "6f8da1d0111ae146ef74dbd4405881ab27239a8923004f9c8cc740e5825415bd"

URI_aarch64_java-25-openjdk-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-fastdebug-25.0.4.1.1-1.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-fastdebug}"
SRC_URI[aarch64_java-25-openjdk-fastdebug.sha256sum] = "adbc1c3c551bebb4f8d45e09f7011b83b24751fe0f3e28d1c112af3a5a3e6a55"

URI_aarch64_java-25-openjdk-headless = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-headless-25.0.4.1.1-1.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-headless;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-headless}"
SRC_URI[aarch64_java-25-openjdk-headless.sha256sum] = "e549db3fbc2926d27150a86f02956ff0c26691b4f7003eeee2117e2bad1dd916"
RPROVIDES:java-25-openjdk-headless:aarch64 = "virtual/java-headless_or_java-21-headless_or_java-25-headless virtual/java-headless_or_java-25-headless"

URI_aarch64_java-25-openjdk-headless-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-headless-fastdebug-25.0.4.1.1-1.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-headless-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-headless-fastdebug}"
SRC_URI[aarch64_java-25-openjdk-headless-fastdebug.sha256sum] = "07d088dc124d8da6667655fbfc79b52ca42ef70b2309538cd410bb0aabf94a89"

URI_aarch64_java-25-openjdk-headless-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-headless-slowdebug-25.0.4.1.1-1.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-headless-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-headless-slowdebug}"
SRC_URI[aarch64_java-25-openjdk-headless-slowdebug.sha256sum] = "7958938e78e973cc8754362c10e8f8153c9860756522f328160a12486a6a4342"

URI_aarch64_java-25-openjdk-javadoc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-javadoc-25.0.4.1.1-1.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-javadoc}"
SRC_URI[aarch64_java-25-openjdk-javadoc.sha256sum] = "246772c47aa7bf47a7d2a1259f2c9d371cb5e30c1689129884d2edce0a0fae58"

URI_aarch64_java-25-openjdk-javadoc-zip = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-javadoc-zip-25.0.4.1.1-1.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-javadoc-zip;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-javadoc-zip}"
SRC_URI[aarch64_java-25-openjdk-javadoc-zip.sha256sum] = "be7db33df9ddeab4e5614e7eb2c6b6ff6bb589b435f3a30109d2c1910eee169d"

URI_aarch64_java-25-openjdk-jmods = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-jmods-25.0.4.1.1-1.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-jmods;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-jmods}"
SRC_URI[aarch64_java-25-openjdk-jmods.sha256sum] = "3b05a51bf53f33b533535d57cfa0995ec5c1a1efedbace0e18b81cd7126f9bba"

URI_aarch64_java-25-openjdk-jmods-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-jmods-fastdebug-25.0.4.1.1-1.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-jmods-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-jmods-fastdebug}"
SRC_URI[aarch64_java-25-openjdk-jmods-fastdebug.sha256sum] = "4fe54f1099bb9127c9b1b0d2b040a5fa2c00f7dbac70eebf68474979f636558b"

URI_aarch64_java-25-openjdk-jmods-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-jmods-slowdebug-25.0.4.1.1-1.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-jmods-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-jmods-slowdebug}"
SRC_URI[aarch64_java-25-openjdk-jmods-slowdebug.sha256sum] = "f2f3e5dfc0bb3658f2e0c49cdd599f554c397e6ecef277b8526b6bb6ab893adb"

URI_aarch64_java-25-openjdk-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-slowdebug-25.0.4.1.1-1.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-slowdebug}"
SRC_URI[aarch64_java-25-openjdk-slowdebug.sha256sum] = "ed18dbf2a5af9657cc2b85428c85eeec0a87c80b4c7424b184fc22d9e1918f3d"

URI_aarch64_java-25-openjdk-src = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-src-25.0.4.1.1-1.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-src;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-src}"
SRC_URI[aarch64_java-25-openjdk-src.sha256sum] = "1ca36d0dd9bc7e77e88aa0d6872cde113e1999b4b906a4cd7538549556b64346"

URI_aarch64_java-25-openjdk-src-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-src-fastdebug-25.0.4.1.1-1.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-src-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-src-fastdebug}"
SRC_URI[aarch64_java-25-openjdk-src-fastdebug.sha256sum] = "81331a636b8e3bbe65b7ce3073a1456fb50c46c958641130edecd3d6fac80674"

URI_aarch64_java-25-openjdk-src-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-src-slowdebug-25.0.4.1.1-1.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-src-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-src-slowdebug}"
SRC_URI[aarch64_java-25-openjdk-src-slowdebug.sha256sum] = "9b1c22eeb327b2d0c180453d32d75d63b57e947e65b0833ca90cda7b10104a5c"

URI_aarch64_java-25-openjdk-static-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-static-libs-25.0.4.1.1-1.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-static-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-static-libs}"
SRC_URI[aarch64_java-25-openjdk-static-libs.sha256sum] = "a9a07a071b87fb07f27e40187093ef7a55faf478cae88d581dc270dde8116247"

URI_aarch64_java-25-openjdk-static-libs-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-static-libs-fastdebug-25.0.4.1.1-1.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-static-libs-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-static-libs-fastdebug}"
SRC_URI[aarch64_java-25-openjdk-static-libs-fastdebug.sha256sum] = "1f24febcfe66ebf9441b42d219948b40698dcb5fb16d3428ae9ef77b6ee03300"

URI_aarch64_java-25-openjdk-static-libs-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-static-libs-slowdebug-25.0.4.1.1-1.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-static-libs-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-static-libs-slowdebug}"
SRC_URI[aarch64_java-25-openjdk-static-libs-slowdebug.sha256sum] = "7038ef8c91611afcf16d39add775fd077b3b278ae21af816b43ea5a9e5cda2d9"

RDEPENDS:java-25-openjdk = " \
 bash \
 fontconfig \
 glibc \
 java-25-openjdk-headless \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-25-openjdk-crypto-adapter = " \
 glibc \
 nss \
 nss-softokn \
 "
RDEPENDS:java-25-openjdk-crypto-adapter-fastdebug = " \
 glibc \
 nss \
 nss-softokn \
 "
RDEPENDS:java-25-openjdk-crypto-adapter-slowdebug = " \
 glibc \
 nss \
 nss-softokn \
 "
RDEPENDS:java-25-openjdk-demo = " \
 java-25-openjdk \
 "
RDEPENDS:java-25-openjdk-demo-fastdebug = " \
 java-25-openjdk-fastdebug \
 "
RDEPENDS:java-25-openjdk-demo-slowdebug = " \
 java-25-openjdk-slowdebug \
 "
RDEPENDS:java-25-openjdk-devel = " \
 alternatives \
 bash \
 glibc \
 java-25-openjdk \
 "
RDEPENDS:java-25-openjdk-devel-fastdebug = " \
 alternatives \
 bash \
 glibc \
 java-25-openjdk-fastdebug \
 "
RDEPENDS:java-25-openjdk-devel-slowdebug = " \
 alternatives \
 bash \
 glibc \
 java-25-openjdk-slowdebug \
 "
RDEPENDS:java-25-openjdk-fastdebug = " \
 bash \
 fontconfig \
 glibc \
 java-25-openjdk-headless-fastdebug \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-25-openjdk-headless = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 java-25-openjdk-crypto-adapter \
 javapackages-filesystem \
 lksctp-tools \
 tzdata-java \
 "
RDEPENDS:java-25-openjdk-headless-fastdebug = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 java-25-openjdk-crypto-adapter-fastdebug \
 javapackages-filesystem \
 lksctp-tools \
 tzdata-java \
 "
RDEPENDS:java-25-openjdk-headless-slowdebug = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 java-25-openjdk-crypto-adapter-slowdebug \
 javapackages-filesystem \
 lksctp-tools \
 tzdata-java \
 "
RDEPENDS:java-25-openjdk-javadoc = " \
 alternatives \
 bash \
 java-25-openjdk-headless \
 javapackages-filesystem \
 "
RDEPENDS:java-25-openjdk-javadoc-zip = " \
 alternatives \
 bash \
 java-25-openjdk-headless \
 javapackages-filesystem \
 "
RDEPENDS:java-25-openjdk-jmods = " \
 java-25-openjdk-devel \
 "
RDEPENDS:java-25-openjdk-jmods-fastdebug = " \
 java-25-openjdk-devel-fastdebug \
 "
RDEPENDS:java-25-openjdk-jmods-slowdebug = " \
 java-25-openjdk-devel-slowdebug \
 "
RDEPENDS:java-25-openjdk-slowdebug = " \
 bash \
 fontconfig \
 glibc \
 java-25-openjdk-headless-slowdebug \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-25-openjdk-src = " \
 java-25-openjdk-headless \
 "
RDEPENDS:java-25-openjdk-src-fastdebug = " \
 java-25-openjdk-headless-fastdebug \
 "
RDEPENDS:java-25-openjdk-src-slowdebug = " \
 java-25-openjdk-headless-slowdebug \
 "
RDEPENDS:java-25-openjdk-static-libs = " \
 java-25-openjdk-devel \
 "
RDEPENDS:java-25-openjdk-static-libs-fastdebug = " \
 java-25-openjdk-devel-fastdebug \
 "
RDEPENDS:java-25-openjdk-static-libs-slowdebug = " \
 java-25-openjdk-devel-slowdebug \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/java-headless_or_java-21-headless_or_java-25-headless rpm/virtual/java-headless_or_java-25-headless"

PROVIDES:append:aarch64 = " rpm/virtual/java-headless_or_java-21-headless_or_java-25-headless rpm/virtual/java-headless_or_java-25-headless"
