# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-intl_pluralrules"
PV = "7.0.2"
PR = "7.el10_2"
PACKAGES = " \
 rust-intl_pluralrules+default-devel \
 rust-intl_pluralrules-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-intl_pluralrules-7.0.2-7.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b66a92c45193d8995f430630e2f02140d3537569e5f25cc7be264adb30c8b40"

URI_x86_64_v2_rust-intl_pluralrules+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-intl_pluralrules+default-devel-7.0.2-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-intl_pluralrules+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-intl_pluralrules+default-devel}"
SRC_URI[x86_64_v2_rust-intl_pluralrules+default-devel.sha256sum] = "4db5fb6fee82ace4923b5ae5f9aa8e497fb32f365ac7865a78460c283f3e726f"

URI_x86_64_v2_rust-intl_pluralrules-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-intl_pluralrules-devel-7.0.2-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-intl_pluralrules-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-intl_pluralrules-devel}"
SRC_URI[x86_64_v2_rust-intl_pluralrules-devel.sha256sum] = "16ecf64d21cd865820de3cc7f549a37f5ebe3410141f24c9423b609815ea0977"

URI_aarch64_rust-intl_pluralrules+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-intl_pluralrules+default-devel-7.0.2-7.el10_2.noarch.rpm;name=aarch64_rust-intl_pluralrules+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-intl_pluralrules+default-devel}"
SRC_URI[aarch64_rust-intl_pluralrules+default-devel.sha256sum] = "2b7fa8b5524e669d913d6871f37887383d285b269305577d9b3ba13b9d361715"

URI_aarch64_rust-intl_pluralrules-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-intl_pluralrules-devel-7.0.2-7.el10_2.noarch.rpm;name=aarch64_rust-intl_pluralrules-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-intl_pluralrules-devel}"
SRC_URI[aarch64_rust-intl_pluralrules-devel.sha256sum] = "0b48e2e6e69f0bcfa850961fb958ace7400b3f532b4300a1a74fa85b43fb04bf"

RDEPENDS:rust-intl_pluralrules+default-devel = " \
 cargo \
 rust-intl_pluralrules-devel \
 "
RDEPENDS:rust-intl_pluralrules-devel = " \
 cargo \
 rust-unic-langid+default-devel \
 "
