# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iproute"
PV = "6.11.0"
PR = "1.el10"
PACKAGES = " \
 iproute \
 iproute-devel \
 iproute-tc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/iproute-6.11.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "59dd4604e23d62d78b3b8e62ac8a8a22cfa4de2f56c1a3aff931ed465557a659"

URI_x86_64_v2_iproute = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iproute-6.11.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_iproute;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iproute}"
SRC_URI[x86_64_v2_iproute.sha256sum] = "e9966c7117592e82e3bb6b347873f0fd67fc49cd953307b88e6cfaaa4ff7eed1"

URI_x86_64_v2_iproute-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/iproute-devel-6.11.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_iproute-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iproute-devel}"
SRC_URI[x86_64_v2_iproute-devel.sha256sum] = "e98ad5b23f604d22e75bfc50b09c3471d9acfac18703aa765e22c7d0cda7051a"

URI_x86_64_v2_iproute-tc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iproute-tc-6.11.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_iproute-tc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iproute-tc}"
SRC_URI[x86_64_v2_iproute-tc.sha256sum] = "431d1f5ad7f6296f28142bf708fb396c4a2feba56f3520543c9bf8043b1fff65"

URI_aarch64_iproute = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iproute-6.11.0-1.el10.aarch64.rpm;name=aarch64_iproute;unpack=0"
SRC_URI:append = " ${URI_aarch64_iproute}"
SRC_URI[aarch64_iproute.sha256sum] = "8164072a69be6956d219de2bbaeca7651f15f4fa07fd532320aa4d8b1685918a"

URI_aarch64_iproute-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/iproute-devel-6.11.0-1.el10.aarch64.rpm;name=aarch64_iproute-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_iproute-devel}"
SRC_URI[aarch64_iproute-devel.sha256sum] = "7ae887b514d403be27943cf3b21503c3bb9b5f8d14b1974e9e65fec8db1aa692"

URI_aarch64_iproute-tc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iproute-tc-6.11.0-1.el10.aarch64.rpm;name=aarch64_iproute-tc;unpack=0"
SRC_URI:append = " ${URI_aarch64_iproute-tc}"
SRC_URI[aarch64_iproute-tc.sha256sum] = "049c200257f0ba2ca299233f50bbe80fa65e4b92de573a2166dbf2d8ba85cd15"

RDEPENDS:iproute = " \
 elfutils-libelf \
 glibc \
 libbpf \
 libcap \
 libmnl \
 libselinux \
 psmisc \
 "
RDEPENDS:iproute-devel = " \
 iproute \
 "
RDEPENDS:iproute-tc = " \
 elfutils-libelf \
 glibc \
 iproute \
 iptables-libs \
 libbpf \
 libcap \
 libmnl \
 "
