# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bigdecimal0.3"
PV = "0.3.1"
PR = "3.el10_0"
PACKAGES = " \
 rust-bigdecimal0.3+default-devel \
 rust-bigdecimal0.3+serde-devel \
 rust-bigdecimal0.3+string-only-devel \
 rust-bigdecimal0.3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bigdecimal0.3-0.3.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "706dbc8336dc787ad1ea0e82604273b1f48c62f9a89f0406a9b17af8fa640e69"

URI_x86_64_v2_rust-bigdecimal0.3+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bigdecimal0.3+default-devel-0.3.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bigdecimal0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bigdecimal0.3+default-devel}"
SRC_URI[x86_64_v2_rust-bigdecimal0.3+default-devel.sha256sum] = "dc1ef621cf55c9ebcb3566f493c6aa27475c4bb6ca4160452aaf292fbaf6f50c"

URI_x86_64_v2_rust-bigdecimal0.3+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bigdecimal0.3+serde-devel-0.3.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bigdecimal0.3+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bigdecimal0.3+serde-devel}"
SRC_URI[x86_64_v2_rust-bigdecimal0.3+serde-devel.sha256sum] = "c26a655f7ce41526081f313fb9dd4aa6693d756f3144c9a43ab1be60cc0d188b"

URI_x86_64_v2_rust-bigdecimal0.3+string-only-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bigdecimal0.3+string-only-devel-0.3.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bigdecimal0.3+string-only-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bigdecimal0.3+string-only-devel}"
SRC_URI[x86_64_v2_rust-bigdecimal0.3+string-only-devel.sha256sum] = "502c212049db57d94508d681c302511a9a7876290c0cb3854fa1640574345d32"

URI_x86_64_v2_rust-bigdecimal0.3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bigdecimal0.3-devel-0.3.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bigdecimal0.3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bigdecimal0.3-devel}"
SRC_URI[x86_64_v2_rust-bigdecimal0.3-devel.sha256sum] = "34490cf95a3abd08721fd6943591d6bb6f9ab3b3fb8029beb4f65deb9f9f5785"

URI_aarch64_rust-bigdecimal0.3+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bigdecimal0.3+default-devel-0.3.1-3.el10_0.noarch.rpm;name=aarch64_rust-bigdecimal0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bigdecimal0.3+default-devel}"
SRC_URI[aarch64_rust-bigdecimal0.3+default-devel.sha256sum] = "060c3aef3f24fc113dfd38ef0efd4d84337d2e080823cd5a65e14cd8b615ed83"

URI_aarch64_rust-bigdecimal0.3+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bigdecimal0.3+serde-devel-0.3.1-3.el10_0.noarch.rpm;name=aarch64_rust-bigdecimal0.3+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bigdecimal0.3+serde-devel}"
SRC_URI[aarch64_rust-bigdecimal0.3+serde-devel.sha256sum] = "01269c567d77f79bd25139f788a92f60fec7f8a4f33b4c4b0ba29bd809e6248a"

URI_aarch64_rust-bigdecimal0.3+string-only-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bigdecimal0.3+string-only-devel-0.3.1-3.el10_0.noarch.rpm;name=aarch64_rust-bigdecimal0.3+string-only-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bigdecimal0.3+string-only-devel}"
SRC_URI[aarch64_rust-bigdecimal0.3+string-only-devel.sha256sum] = "cc61b8805c89360dba0f13e2941635f154fbd0902e67eeeb80871ceef49c3887"

URI_aarch64_rust-bigdecimal0.3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bigdecimal0.3-devel-0.3.1-3.el10_0.noarch.rpm;name=aarch64_rust-bigdecimal0.3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bigdecimal0.3-devel}"
SRC_URI[aarch64_rust-bigdecimal0.3-devel.sha256sum] = "40e6a61ad5ce04d3efeec2915c979e656080e8a7dbc7f46890526e151c16fc58"

RDEPENDS:rust-bigdecimal0.3+default-devel = " \
 cargo \
 rust-bigdecimal0.3-devel \
 "
RDEPENDS:rust-bigdecimal0.3+serde-devel = " \
 cargo \
 rust-bigdecimal0.3-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-bigdecimal0.3+string-only-devel = " \
 cargo \
 rust-bigdecimal0.3-devel \
 "
RDEPENDS:rust-bigdecimal0.3-devel = " \
 cargo \
 rust-num-bigint+default-devel \
 rust-num-integer+default-devel \
 rust-num-traits+default-devel \
 "
