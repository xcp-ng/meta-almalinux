# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-roxmltree"
PV = "0.21.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-roxmltree+default-devel \
 rust-roxmltree+positions-devel \
 rust-roxmltree+std-devel \
 rust-roxmltree-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-roxmltree-0.21.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "88ebf9d14e606da2246c7debafc00fa177fefd1f684ddde34dc9afd81da1984f"

URI_x86_64_v2_rust-roxmltree+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-roxmltree+default-devel-0.21.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-roxmltree+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-roxmltree+default-devel}"
SRC_URI[x86_64_v2_rust-roxmltree+default-devel.sha256sum] = "676c5405f01345ecf127465b2074cd0b85fe7c07d1c18e0566a569afa93fc088"

URI_x86_64_v2_rust-roxmltree+positions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-roxmltree+positions-devel-0.21.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-roxmltree+positions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-roxmltree+positions-devel}"
SRC_URI[x86_64_v2_rust-roxmltree+positions-devel.sha256sum] = "9f8c293c4179b934f298e6b99051fce6dae5fec5a2642d4d249bb40b68ced88c"

URI_x86_64_v2_rust-roxmltree+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-roxmltree+std-devel-0.21.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-roxmltree+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-roxmltree+std-devel}"
SRC_URI[x86_64_v2_rust-roxmltree+std-devel.sha256sum] = "3bb05734375b36143b18cbe6254af05a439f8c76915e85b367ff737101680edf"

URI_x86_64_v2_rust-roxmltree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-roxmltree-devel-0.21.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-roxmltree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-roxmltree-devel}"
SRC_URI[x86_64_v2_rust-roxmltree-devel.sha256sum] = "e498cf1bc5d9a55d0da2b06719197cb90ee9e96eb3adef155697994457d33f98"

URI_aarch64_rust-roxmltree+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-roxmltree+default-devel-0.21.1-1.el10_3.noarch.rpm;name=aarch64_rust-roxmltree+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-roxmltree+default-devel}"
SRC_URI[aarch64_rust-roxmltree+default-devel.sha256sum] = "970ab2a53503eb9f867368627f9ec67e771030a257376baadac7b86c73b87d3b"

URI_aarch64_rust-roxmltree+positions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-roxmltree+positions-devel-0.21.1-1.el10_3.noarch.rpm;name=aarch64_rust-roxmltree+positions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-roxmltree+positions-devel}"
SRC_URI[aarch64_rust-roxmltree+positions-devel.sha256sum] = "110c909465b7ebc2ace00cb0d18f112b5889f5f03b009f2af9f63cf505a52769"

URI_aarch64_rust-roxmltree+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-roxmltree+std-devel-0.21.1-1.el10_3.noarch.rpm;name=aarch64_rust-roxmltree+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-roxmltree+std-devel}"
SRC_URI[aarch64_rust-roxmltree+std-devel.sha256sum] = "30cfcb03d7d62114a8435940666624a641b5f893515897958e7390df42620cdb"

URI_aarch64_rust-roxmltree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-roxmltree-devel-0.21.1-1.el10_3.noarch.rpm;name=aarch64_rust-roxmltree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-roxmltree-devel}"
SRC_URI[aarch64_rust-roxmltree-devel.sha256sum] = "5e68ffb9e58fa407df2fe01c808abb79dec3dd5e21ef717ef29fdf61db2d65d0"

RDEPENDS:rust-roxmltree+default-devel = " \
 cargo \
 rust-roxmltree+positions-devel \
 rust-roxmltree+std-devel \
 rust-roxmltree-devel \
 "
RDEPENDS:rust-roxmltree+positions-devel = " \
 cargo \
 rust-roxmltree-devel \
 "
RDEPENDS:rust-roxmltree+std-devel = " \
 cargo \
 rust-memchr+std-devel \
 rust-roxmltree-devel \
 "
RDEPENDS:rust-roxmltree-devel = " \
 cargo \
 rust \
 rust-memchr-devel \
 "
