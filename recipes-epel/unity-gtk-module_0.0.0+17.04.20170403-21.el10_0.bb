# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "unity-gtk-module"
PV = "0.0.0+17.04.20170403"
PR = "21.el10_0"
PACKAGES = " \
 libunity-gtk-parser-devel \
 libunity-gtk2-parser \
 libunity-gtk2-parser-devel \
 libunity-gtk3-parser \
 libunity-gtk3-parser-devel \
 unity-gtk-module-common \
 unity-gtk2-module \
 unity-gtk3-module \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/unity-gtk-module-0.0.0+17.04.20170403-21.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a26da11f0f65b6848cd3c6e5888f49d6dd1f9b2005aa85c8fbe24ccfe7fc6131"

URI_x86_64_v2_libunity-gtk-parser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libunity-gtk-parser-devel-0.0.0+17.04.20170403-21.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_libunity-gtk-parser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libunity-gtk-parser-devel}"
SRC_URI[x86_64_v2_libunity-gtk-parser-devel.sha256sum] = "814f097a1e193e1cd4a9100a9a1cb9796acbab25cc881379630c33681de45209"

URI_x86_64_v2_libunity-gtk2-parser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libunity-gtk2-parser-0.0.0+17.04.20170403-21.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libunity-gtk2-parser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libunity-gtk2-parser}"
SRC_URI[x86_64_v2_libunity-gtk2-parser.sha256sum] = "e7636f01a88c8e72186f5f3549705b2dccaf73d89a53c7a107c0667e1ef59a6d"

URI_x86_64_v2_libunity-gtk2-parser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libunity-gtk2-parser-devel-0.0.0+17.04.20170403-21.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libunity-gtk2-parser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libunity-gtk2-parser-devel}"
SRC_URI[x86_64_v2_libunity-gtk2-parser-devel.sha256sum] = "894e65df4c698cd6289851e293694da57656f6006b0ae67c0177bd3a66cb97ae"

URI_x86_64_v2_libunity-gtk3-parser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libunity-gtk3-parser-0.0.0+17.04.20170403-21.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libunity-gtk3-parser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libunity-gtk3-parser}"
SRC_URI[x86_64_v2_libunity-gtk3-parser.sha256sum] = "65efbf4325d7d1098ff27cae683e371885ebbce77f178993075e4c882c6d9b52"

URI_x86_64_v2_libunity-gtk3-parser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libunity-gtk3-parser-devel-0.0.0+17.04.20170403-21.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libunity-gtk3-parser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libunity-gtk3-parser-devel}"
SRC_URI[x86_64_v2_libunity-gtk3-parser-devel.sha256sum] = "d0231b17465fd3fda85341b365b5682531d111f56a03d55daead5a67c7fc7c6e"

URI_x86_64_v2_unity-gtk-module-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/unity-gtk-module-common-0.0.0+17.04.20170403-21.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_unity-gtk-module-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unity-gtk-module-common}"
SRC_URI[x86_64_v2_unity-gtk-module-common.sha256sum] = "a7f4efb832b799e060ecc89c3c4d93efee3901d75ec3448a52de8e0e85aead6e"

URI_x86_64_v2_unity-gtk2-module = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/unity-gtk2-module-0.0.0+17.04.20170403-21.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_unity-gtk2-module;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unity-gtk2-module}"
SRC_URI[x86_64_v2_unity-gtk2-module.sha256sum] = "75e9807a017b08fd605a6c0fe9b200319720bf271e7afe2e4d9f07d5e5931006"

URI_x86_64_v2_unity-gtk3-module = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/unity-gtk3-module-0.0.0+17.04.20170403-21.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_unity-gtk3-module;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unity-gtk3-module}"
SRC_URI[x86_64_v2_unity-gtk3-module.sha256sum] = "8934ce1c3b3289373e2244f76154b96d8e1a1d04b92b7a2d6025998be3c19c62"

URI_aarch64_libunity-gtk-parser-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libunity-gtk-parser-devel-0.0.0+17.04.20170403-21.el10_0.noarch.rpm;name=aarch64_libunity-gtk-parser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libunity-gtk-parser-devel}"
SRC_URI[aarch64_libunity-gtk-parser-devel.sha256sum] = "f970ee293eb0968429165d40758a1b2e9db4d4c999140743c895363450ed75d9"

URI_aarch64_libunity-gtk2-parser = "${EPEL_MIRROR}/aarch64/Packages/l/libunity-gtk2-parser-0.0.0+17.04.20170403-21.el10_0.aarch64.rpm;name=aarch64_libunity-gtk2-parser;unpack=0"
SRC_URI:append = " ${URI_aarch64_libunity-gtk2-parser}"
SRC_URI[aarch64_libunity-gtk2-parser.sha256sum] = "41736a8944041ed6250dcc91de7b89e263fa9d1a6af3f24722cfd2de64157c01"

URI_aarch64_libunity-gtk2-parser-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libunity-gtk2-parser-devel-0.0.0+17.04.20170403-21.el10_0.aarch64.rpm;name=aarch64_libunity-gtk2-parser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libunity-gtk2-parser-devel}"
SRC_URI[aarch64_libunity-gtk2-parser-devel.sha256sum] = "108697594a9b0e38483d6f4a45f6e22cb5cc7e78184593dff9d30f7ee4ad0ce3"

URI_aarch64_libunity-gtk3-parser = "${EPEL_MIRROR}/aarch64/Packages/l/libunity-gtk3-parser-0.0.0+17.04.20170403-21.el10_0.aarch64.rpm;name=aarch64_libunity-gtk3-parser;unpack=0"
SRC_URI:append = " ${URI_aarch64_libunity-gtk3-parser}"
SRC_URI[aarch64_libunity-gtk3-parser.sha256sum] = "8f0925fc17ed12f17900fdaa537535b08ba875b5c9636b61c0d965ee609a807a"

URI_aarch64_libunity-gtk3-parser-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libunity-gtk3-parser-devel-0.0.0+17.04.20170403-21.el10_0.aarch64.rpm;name=aarch64_libunity-gtk3-parser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libunity-gtk3-parser-devel}"
SRC_URI[aarch64_libunity-gtk3-parser-devel.sha256sum] = "828beab162dcc2bb03206f293469d9a36f88404a493575b7fd9ae98457828c59"

URI_aarch64_unity-gtk-module-common = "${EPEL_MIRROR}/aarch64/Packages/u/unity-gtk-module-common-0.0.0+17.04.20170403-21.el10_0.noarch.rpm;name=aarch64_unity-gtk-module-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_unity-gtk-module-common}"
SRC_URI[aarch64_unity-gtk-module-common.sha256sum] = "4b0ee9e53e828ddcc313270cecc2d99e4b218569f902d947e7abd36a5515a7da"

URI_aarch64_unity-gtk2-module = "${EPEL_MIRROR}/aarch64/Packages/u/unity-gtk2-module-0.0.0+17.04.20170403-21.el10_0.aarch64.rpm;name=aarch64_unity-gtk2-module;unpack=0"
SRC_URI:append = " ${URI_aarch64_unity-gtk2-module}"
SRC_URI[aarch64_unity-gtk2-module.sha256sum] = "2d0092224f072ffc17dcaf782d7fc104d6bca7a1aa2c8debcb1a89f04b0a9ecb"

URI_aarch64_unity-gtk3-module = "${EPEL_MIRROR}/aarch64/Packages/u/unity-gtk3-module-0.0.0+17.04.20170403-21.el10_0.aarch64.rpm;name=aarch64_unity-gtk3-module;unpack=0"
SRC_URI:append = " ${URI_aarch64_unity-gtk3-module}"
SRC_URI[aarch64_unity-gtk3-module.sha256sum] = "da0137d712d71f194ead6e31149ee702dbd41b95acbf85934000d1c679524493"

RDEPENDS:libunity-gtk-parser-devel = " \
 "
RDEPENDS:libunity-gtk2-parser = " \
 atk \
 cairo \
 fontconfig \
 freetype \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk2 \
 harfbuzz \
 pango \
 "
RDEPENDS:libunity-gtk2-parser-devel = " \
 gtk2-devel \
 libunity-gtk-parser-devel \
 libunity-gtk2-parser \
 pkgconf-pkg-config \
 "
RDEPENDS:libunity-gtk3-parser = " \
 atk \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 pango \
 "
RDEPENDS:libunity-gtk3-parser-devel = " \
 gtk3-devel \
 libunity-gtk-parser-devel \
 libunity-gtk3-parser \
 pkgconf-pkg-config \
 "
RDEPENDS:unity-gtk-module-common = " \
 bash \
 dbus \
 gawk \
 sed \
 systemd \
 "
RDEPENDS:unity-gtk2-module = " \
 atk \
 cairo \
 fontconfig \
 freetype \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk2 \
 harfbuzz \
 libX11 \
 libunity-gtk2-parser \
 pango \
 unity-gtk-module-common \
 "
RDEPENDS:unity-gtk3-module = " \
 atk \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 libX11 \
 libunity-gtk3-parser \
 pango \
 unity-gtk-module-common \
 "
