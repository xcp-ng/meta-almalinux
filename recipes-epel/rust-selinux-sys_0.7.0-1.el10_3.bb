# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-selinux-sys"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-selinux-sys+default-devel \
 rust-selinux-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-selinux-sys-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e66e08954f449c412c1835d5af73685697f8d74a3fc997ea9c94db83fb60cec3"

URI_x86_64_v2_rust-selinux-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-selinux-sys+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-selinux-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-selinux-sys+default-devel}"
SRC_URI[x86_64_v2_rust-selinux-sys+default-devel.sha256sum] = "8b5f1069ec16e674c7fad9809bb88af1fb85348d1a04756dc540d9279c76b039"

URI_x86_64_v2_rust-selinux-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-selinux-sys-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-selinux-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-selinux-sys-devel}"
SRC_URI[x86_64_v2_rust-selinux-sys-devel.sha256sum] = "acd7334ef0ecd22a251003ebc0b09897c6d7ce945a28993e8e5c6e8792ea279e"

URI_aarch64_rust-selinux-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-selinux-sys+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-selinux-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-selinux-sys+default-devel}"
SRC_URI[aarch64_rust-selinux-sys+default-devel.sha256sum] = "989b32a876d2881abec6a29a33f846cd0691753b76b3b461626a38fa740f8a1f"

URI_aarch64_rust-selinux-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-selinux-sys-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-selinux-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-selinux-sys-devel}"
SRC_URI[aarch64_rust-selinux-sys-devel.sha256sum] = "910beede7dfe0ebed2d09f0edc3e0b4dee6a069118754d13cf54b39a9553c511"

RDEPENDS:rust-selinux-sys+default-devel = " \
 cargo \
 rust-selinux-sys-devel \
 "
RDEPENDS:rust-selinux-sys-devel = " \
 cargo \
 libselinux-devel \
 rust \
 rust-bindgen+default-devel \
 rust-cc+default-devel \
 rust-dunce+default-devel \
 rust-walkdir+default-devel \
 "
