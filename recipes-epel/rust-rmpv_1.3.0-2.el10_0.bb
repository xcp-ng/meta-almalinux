# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rmpv"
PV = "1.3.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-rmpv+default-devel \
 rust-rmpv+serde-devel \
 rust-rmpv+serde_bytes-devel \
 rust-rmpv+with-serde-devel \
 rust-rmpv-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rmpv-1.3.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6da3f4da20b90a0751f23bfe7be5904a7cd611a9c0d5a56a2b876992780dda86"

URI_x86_64_v2_rust-rmpv+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rmpv+default-devel-1.3.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rmpv+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rmpv+default-devel}"
SRC_URI[x86_64_v2_rust-rmpv+default-devel.sha256sum] = "41c2d16215f4624037503e2fa80ca2d302bad1802ee9bafcf7db2fcd8ea566fd"

URI_x86_64_v2_rust-rmpv+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rmpv+serde-devel-1.3.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rmpv+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rmpv+serde-devel}"
SRC_URI[x86_64_v2_rust-rmpv+serde-devel.sha256sum] = "c41b2a2f88d16ebb9308c8a288212cae10fe6faa33ca8381824afa366fa0de79"

URI_x86_64_v2_rust-rmpv+serde_bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rmpv+serde_bytes-devel-1.3.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rmpv+serde_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rmpv+serde_bytes-devel}"
SRC_URI[x86_64_v2_rust-rmpv+serde_bytes-devel.sha256sum] = "cd05609cf842fe4c944824c45cd24122642e5dc1d571499859c1bace7a383a4e"

URI_x86_64_v2_rust-rmpv+with-serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rmpv+with-serde-devel-1.3.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rmpv+with-serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rmpv+with-serde-devel}"
SRC_URI[x86_64_v2_rust-rmpv+with-serde-devel.sha256sum] = "8b9b86b46dd21ed0ec277fe6bf4f141de76b9fde92d8bc058ac1a81c849641f2"

URI_x86_64_v2_rust-rmpv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rmpv-devel-1.3.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rmpv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rmpv-devel}"
SRC_URI[x86_64_v2_rust-rmpv-devel.sha256sum] = "5836020655f40e25d646a062cce8e7e62452c8d6b2c24f6671973cd1e9e963a7"

URI_aarch64_rust-rmpv+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rmpv+default-devel-1.3.0-2.el10_0.noarch.rpm;name=aarch64_rust-rmpv+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rmpv+default-devel}"
SRC_URI[aarch64_rust-rmpv+default-devel.sha256sum] = "db7d4c2c930c7126913f9973ff892ec240b4f7300975692ca615b4d0d8311842"

URI_aarch64_rust-rmpv+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rmpv+serde-devel-1.3.0-2.el10_0.noarch.rpm;name=aarch64_rust-rmpv+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rmpv+serde-devel}"
SRC_URI[aarch64_rust-rmpv+serde-devel.sha256sum] = "e2445fdefe181bdcb834090b64ee989ade6edb19c02803a9854e857c292b5273"

URI_aarch64_rust-rmpv+serde_bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rmpv+serde_bytes-devel-1.3.0-2.el10_0.noarch.rpm;name=aarch64_rust-rmpv+serde_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rmpv+serde_bytes-devel}"
SRC_URI[aarch64_rust-rmpv+serde_bytes-devel.sha256sum] = "9f88ed8db6f40192380f9a97cf50572c05cb68e03d6c147220d958ea3a4ec281"

URI_aarch64_rust-rmpv+with-serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rmpv+with-serde-devel-1.3.0-2.el10_0.noarch.rpm;name=aarch64_rust-rmpv+with-serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rmpv+with-serde-devel}"
SRC_URI[aarch64_rust-rmpv+with-serde-devel.sha256sum] = "9f8b3523f2e4a61f174f7daaf22028b51f0f5f9d7ab227842d712b7f30664772"

URI_aarch64_rust-rmpv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rmpv-devel-1.3.0-2.el10_0.noarch.rpm;name=aarch64_rust-rmpv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rmpv-devel}"
SRC_URI[aarch64_rust-rmpv-devel.sha256sum] = "a26945d35a1152a634bf5472c03c5861d1fafe60f2a2edd9d5d55e52f6e34b87"

RDEPENDS:rust-rmpv+default-devel = " \
 cargo \
 rust-rmpv-devel \
 "
RDEPENDS:rust-rmpv+serde-devel = " \
 cargo \
 rust-rmpv-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-rmpv+serde_bytes-devel = " \
 cargo \
 rust-rmpv-devel \
 rust-serde_bytes+default-devel \
 "
RDEPENDS:rust-rmpv+with-serde-devel = " \
 cargo \
 rust-rmpv+serde-devel \
 rust-rmpv+serde_bytes-devel \
 rust-rmpv-devel \
 "
RDEPENDS:rust-rmpv-devel = " \
 cargo \
 rust \
 rust-num-traits+default-devel \
 rust-rmp+default-devel \
 "
