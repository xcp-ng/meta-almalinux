# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apptainer"
PV = "1.4.4"
PR = "1.el10_0"
PACKAGES = " \
 apptainer \
 apptainer-suid \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/apptainer-1.4.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "518793206f86e71e1e265c763f6eac8c50f0b6bb40af3b4ca1656e72aa5bb637"

URI_x86_64_v2_apptainer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apptainer-1.4.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apptainer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apptainer}"
SRC_URI[x86_64_v2_apptainer.sha256sum] = "e7911e51129a0f8c1c7446a814a99ab947ffaa11a9698434d29c2a47c8eb2f30"

URI_x86_64_v2_apptainer-suid = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apptainer-suid-1.4.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apptainer-suid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apptainer-suid}"
SRC_URI[x86_64_v2_apptainer-suid.sha256sum] = "9cd5c80acfc28e0296a67ae1e302159154fa6d936fa5168c75418d792ab05f0c"

URI_aarch64_apptainer = "${EPEL_MIRROR}/aarch64/Packages/a/apptainer-1.4.4-1.el10_0.aarch64.rpm;name=aarch64_apptainer;unpack=0"
SRC_URI:append = " ${URI_aarch64_apptainer}"
SRC_URI[aarch64_apptainer.sha256sum] = "687bc9d40461fc2be11a36bb8e73e1120ab6d1a817287e118d7d2b13d105785f"

URI_aarch64_apptainer-suid = "${EPEL_MIRROR}/aarch64/Packages/a/apptainer-suid-1.4.4-1.el10_0.aarch64.rpm;name=aarch64_apptainer-suid;unpack=0"
SRC_URI:append = " ${URI_aarch64_apptainer-suid}"
SRC_URI[aarch64_apptainer-suid.sha256sum] = "40e4d9c97588fc975aac93983a8879a3af2c2d98b6884ab723690d99c85d8a4c"

RDEPENDS:apptainer = " \
 bash \
 fakeroot \
 fuse3-libs \
 glibc \
 libgcc \
 libseccomp \
 libzstd \
 lz4-libs \
 lzo \
 shadow-utils-subid \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:apptainer-suid = " \
 apptainer \
 glibc \
 libseccomp \
 shadow-utils-subid \
 "
