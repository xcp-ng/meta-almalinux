# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rhel-system-roles"
PV = "1.127.2"
PR = "0.1.el10"
PACKAGES = " \
 rhel-system-roles \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rhel-system-roles-1.127.2-0.1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "557dcff6cac54c6b6f5107293c02980f856e260dadc3bd6b5e647f3801ce1668"

URI_x86_64_v2_rhel-system-roles = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rhel-system-roles-1.127.2-0.1.el10.noarch.rpm;name=x86_64_v2_rhel-system-roles;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rhel-system-roles}"
SRC_URI[x86_64_v2_rhel-system-roles.sha256sum] = "e74b55256aabfadb32ca4592cf829e985bd167ad40ea575d658661f2a73a999e"

URI_aarch64_rhel-system-roles = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rhel-system-roles-1.127.2-0.1.el10.noarch.rpm;name=aarch64_rhel-system-roles;unpack=0"
SRC_URI:append = " ${URI_aarch64_rhel-system-roles}"
SRC_URI[aarch64_rhel-system-roles.sha256sum] = "e74b55256aabfadb32ca4592cf829e985bd167ad40ea575d658661f2a73a999e"

RDEPENDS:rhel-system-roles = " \
 ansible-core \
 bash \
 python-unversioned-command \
 virtual//usr/bin/env \
 "
