# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gram-job-manager-lsf"
PV = "3.0"
PR = "22.el10_0"
PACKAGES = " \
 globus-gram-job-manager-lsf \
 globus-gram-job-manager-lsf-setup-poll \
 globus-gram-job-manager-lsf-setup-seg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gram-job-manager-lsf-3.0-22.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65d8e4538d6976008ccc945fbc4e8dccb6dcda955c6ad6e02342817759e8ce09"

URI_x86_64_v2_globus-gram-job-manager-lsf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-lsf-3.0-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-job-manager-lsf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager-lsf}"
SRC_URI[x86_64_v2_globus-gram-job-manager-lsf.sha256sum] = "ff50e78581ebd1e081a4db78e1f772357b36387e8639ab46e18c52c415f6a451"

URI_x86_64_v2_globus-gram-job-manager-lsf-setup-poll = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-lsf-setup-poll-3.0-22.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gram-job-manager-lsf-setup-poll;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager-lsf-setup-poll}"
SRC_URI[x86_64_v2_globus-gram-job-manager-lsf-setup-poll.sha256sum] = "e2a85574b283ee18c2350a79ae686bab283bd3c8f1d634068fe149f23de2d205"
RPROVIDES:globus-gram-job-manager-lsf-setup-poll:x86_64_v2 = "virtual/globus-gram-job-manager-lsf-setup_eq_3.0-22.el10_0.alma_altarch"

URI_x86_64_v2_globus-gram-job-manager-lsf-setup-seg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-lsf-setup-seg-3.0-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-job-manager-lsf-setup-seg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager-lsf-setup-seg}"
SRC_URI[x86_64_v2_globus-gram-job-manager-lsf-setup-seg.sha256sum] = "51d88b0bb23360ef093aed3f6dacc52af2b27a9aaa09d4602b5e98330df267e0"
RPROVIDES:globus-gram-job-manager-lsf-setup-seg:x86_64_v2 = "virtual/globus-gram-job-manager-lsf-setup_eq_3.0-22.el10_0.alma_altarch"

URI_aarch64_globus-gram-job-manager-lsf = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-lsf-3.0-22.el10_0.aarch64.rpm;name=aarch64_globus-gram-job-manager-lsf;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager-lsf}"
SRC_URI[aarch64_globus-gram-job-manager-lsf.sha256sum] = "b751e251931e1c87ab5dee291e90cb966ec59c5fd3d097ffe84503b04da830ce"

URI_aarch64_globus-gram-job-manager-lsf-setup-poll = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-lsf-setup-poll-3.0-22.el10_0.noarch.rpm;name=aarch64_globus-gram-job-manager-lsf-setup-poll;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager-lsf-setup-poll}"
SRC_URI[aarch64_globus-gram-job-manager-lsf-setup-poll.sha256sum] = "a9ee871b0efdb068143122449c7ea9a6587aa4d484ba2810fad1464b38f5e586"
RPROVIDES:globus-gram-job-manager-lsf-setup-poll:aarch64 = "virtual/globus-gram-job-manager-lsf-setup_eq_3.0-22.el10_0"

URI_aarch64_globus-gram-job-manager-lsf-setup-seg = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-lsf-setup-seg-3.0-22.el10_0.aarch64.rpm;name=aarch64_globus-gram-job-manager-lsf-setup-seg;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager-lsf-setup-seg}"
SRC_URI[aarch64_globus-gram-job-manager-lsf-setup-seg.sha256sum] = "f423d6238eefda03ee15d62b3cf7aeac2d3324734b23ff2499baa152c4c652ea"
RPROVIDES:globus-gram-job-manager-lsf-setup-seg:aarch64 = "virtual/globus-gram-job-manager-lsf-setup_eq_3.0-22.el10_0"

RDEPENDS:globus-gram-job-manager-lsf:x86_64_v2 = " \
 globus-common \
 globus-gass-cache-program \
 globus-gatekeeper \
 globus-gram-job-manager \
 globus-gram-job-manager-scripts \
 globus-gram-protocol \
 perl-IPC-Open3 \
 perl-libs \
 virtual/globus-gram-job-manager-lsf-setup_eq_3.0-22.el10_0.alma_altarch \
"
RDEPENDS:globus-gram-job-manager-lsf:aarch64 = " \
 globus-common \
 globus-gass-cache-program \
 globus-gatekeeper \
 globus-gram-job-manager \
 globus-gram-job-manager-scripts \
 globus-gram-protocol \
 perl-IPC-Open3 \
 perl-libs \
 virtual/globus-gram-job-manager-lsf-setup_eq_3.0-22.el10_0 \
"
RDEPENDS:globus-gram-job-manager-lsf-setup-poll = " \
 bash \
 globus-gram-job-manager-lsf \
 globus-gram-job-manager-scripts \
 "
RDEPENDS:globus-gram-job-manager-lsf-setup-seg = " \
 bash \
 glibc \
 globus-common \
 globus-gram-job-manager-lsf \
 globus-gram-job-manager-scripts \
 globus-scheduler-event-generator \
 globus-scheduler-event-generator-progs \
 systemd \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/globus-gram-job-manager-lsf-setup_eq_3.0-22.el10_0.alma_altarch"

PROVIDES:append:aarch64 = " rpm/virtual/globus-gram-job-manager-lsf-setup_eq_3.0-22.el10_0"
