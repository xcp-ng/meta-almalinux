# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-DateTime-Format-Builder"
PV = "0.8300"
PR = "9.el10_0"
PACKAGES = " \
 perl-DateTime-Format-Builder \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-DateTime-Format-Builder-0.8300-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9601881c22735f165dffc3af48fe87879b0fa09e4b4baa62bf1a73bb3ec14955"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DateTime-Format-Builder-0.8300-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-DateTime-Format-Builder;unpack=0"
SRC_URI[x86_64_v2_perl-DateTime-Format-Builder.sha256sum] = "6831d9a54a6772986e5fc568db4201c6180a85244f2cfa32178fc15126034b9a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-DateTime-Format-Builder-0.8300-9.el10_0.noarch.rpm;name=aarch64_perl-DateTime-Format-Builder;unpack=0"
SRC_URI[aarch64_perl-DateTime-Format-Builder.sha256sum] = "72fb821b2803234b7f9ec6c16b263390a328a87a5bbb43173d1adddaaaf52e21"

RDEPENDS:perl-DateTime-Format-Builder = " \
 perl-Carp \
 perl-DateTime \
 perl-DateTime-Format-Builder \
 perl-DateTime-Format-Strptime \
 perl-Params-Validate \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-parent \
 "
