# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-camino-tempfile"
PV = "1.4.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-camino-tempfile+default-devel \
 rust-camino-tempfile+nightly-devel \
 rust-camino-tempfile-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-camino-tempfile-1.4.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f33e41892cd8a0d2f2850b9c386c2a4e214abdb4ce0603694e04ce575897f027"

URI_x86_64_v2_rust-camino-tempfile+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-camino-tempfile+default-devel-1.4.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-camino-tempfile+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-camino-tempfile+default-devel}"
SRC_URI[x86_64_v2_rust-camino-tempfile+default-devel.sha256sum] = "c5900a534d38cbebd576e07d84282db655af4025e3bfede1da5f2bf79e0f176b"

URI_x86_64_v2_rust-camino-tempfile+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-camino-tempfile+nightly-devel-1.4.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-camino-tempfile+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-camino-tempfile+nightly-devel}"
SRC_URI[x86_64_v2_rust-camino-tempfile+nightly-devel.sha256sum] = "ffbbce3f2ecb0a8b3568b28e76444610d0c60ca6300c242a571b176d25a60405"

URI_x86_64_v2_rust-camino-tempfile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-camino-tempfile-devel-1.4.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-camino-tempfile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-camino-tempfile-devel}"
SRC_URI[x86_64_v2_rust-camino-tempfile-devel.sha256sum] = "2bc02aef6eb59bf070334c3c173e2dba0e2d98023a93732db70980556b7bc655"

URI_aarch64_rust-camino-tempfile+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-camino-tempfile+default-devel-1.4.1-1.el10_2.noarch.rpm;name=aarch64_rust-camino-tempfile+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-camino-tempfile+default-devel}"
SRC_URI[aarch64_rust-camino-tempfile+default-devel.sha256sum] = "0e8e607150999e13da0d61452ab6264850c6f15e924677a936b8e95d15da0157"

URI_aarch64_rust-camino-tempfile+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-camino-tempfile+nightly-devel-1.4.1-1.el10_2.noarch.rpm;name=aarch64_rust-camino-tempfile+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-camino-tempfile+nightly-devel}"
SRC_URI[aarch64_rust-camino-tempfile+nightly-devel.sha256sum] = "2e6333c97791b4d34590f621275d718f968ed8fbbd4caa0ef1f46246f2d88714"

URI_aarch64_rust-camino-tempfile-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-camino-tempfile-devel-1.4.1-1.el10_2.noarch.rpm;name=aarch64_rust-camino-tempfile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-camino-tempfile-devel}"
SRC_URI[aarch64_rust-camino-tempfile-devel.sha256sum] = "887757dcd6c79fd49fe724ad8e56cc9aa584d205dabfefc4e7f6d6567589787e"

RDEPENDS:rust-camino-tempfile+default-devel = " \
 cargo \
 rust-camino-tempfile-devel \
 "
RDEPENDS:rust-camino-tempfile+nightly-devel = " \
 cargo \
 rust-camino-tempfile-devel \
 rust-tempfile+nightly-devel \
 "
RDEPENDS:rust-camino-tempfile-devel = " \
 cargo \
 rust \
 rust-camino+default-devel \
 rust-tempfile+default-devel \
 "
