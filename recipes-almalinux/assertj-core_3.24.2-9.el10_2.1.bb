# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "assertj-core"
PV = "3.24.2"
PR = "9.el10_2.1"
PACKAGES = " \
 assertj-core \
 assertj-core-javadoc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/assertj-core-3.24.2-9.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5c1a563a1c1016fc6719a159483e548c4f10409cf07a0dbd29b050c6e0c3b909"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/assertj-core-3.24.2-9.el10_2.1.noarch.rpm;name=x86_64_v2_assertj-core;unpack=0"
SRC_URI[x86_64_v2_assertj-core.sha256sum] = "2001c3bdd1cac076d06f46697038efbcaea5ed8fff25714109166daf9b16ee5c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/assertj-core-javadoc-3.24.2-9.el10_2.1.noarch.rpm;name=x86_64_v2_assertj-core-javadoc;unpack=0"
SRC_URI[x86_64_v2_assertj-core-javadoc.sha256sum] = "4e7371349a195ff0dfb89d4ac5346a706e544f1edfca0754afaaaf3b875bb039"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/assertj-core-3.24.2-9.el10_2.1.noarch.rpm;name=aarch64_assertj-core;unpack=0"
SRC_URI[aarch64_assertj-core.sha256sum] = "2001c3bdd1cac076d06f46697038efbcaea5ed8fff25714109166daf9b16ee5c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/assertj-core-javadoc-3.24.2-9.el10_2.1.noarch.rpm;name=aarch64_assertj-core-javadoc;unpack=0"
SRC_URI[aarch64_assertj-core-javadoc.sha256sum] = "4e7371349a195ff0dfb89d4ac5346a706e544f1edfca0754afaaaf3b875bb039"

RDEPENDS:assertj-core = " \
 byte-buddy \
 javapackages-filesystem \
 "
RDEPENDS:assertj-core-javadoc = " \
 javapackages-filesystem \
 "
