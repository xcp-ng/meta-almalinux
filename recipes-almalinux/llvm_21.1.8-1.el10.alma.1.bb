# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "llvm"
PV = "21.1.8"
PR = "1.el10.alma.1"
PACKAGES = " \
 clang \
 clang-analyzer \
 clang-devel \
 clang-libs \
 clang-resource-filesystem \
 clang-tools-extra \
 compiler-rt \
 git-clang-format \
 libomp \
 libomp-devel \
 lld \
 lld-devel \
 lld-libs \
 lldb \
 lldb-devel \
 llvm \
 llvm-devel \
 llvm-doc \
 llvm-filesystem \
 llvm-googletest \
 llvm-libs \
 llvm-static \
 llvm-test \
 llvm-toolset \
 python3-clang \
 python3-lit \
 python3-lldb \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/llvm-21.1.8-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6abbcd708f1c55c6e59e6556f51aea73aaf099e73460c3dc995926e996904644"

URI_x86_64_v2_clang = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clang-21.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang}"
SRC_URI[x86_64_v2_clang.sha256sum] = "b2285bfccf8f70ba6f31e366362c321e1fd7e4061dcaec57c8bcf97934273ab0"

URI_x86_64_v2_clang-analyzer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clang-analyzer-21.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clang-analyzer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang-analyzer}"
SRC_URI[x86_64_v2_clang-analyzer.sha256sum] = "ce0906eb93b3159784434e33bf0cc4e6e51119e2500ec21549552500fd2efc14"

URI_x86_64_v2_clang-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clang-devel-21.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clang-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang-devel}"
SRC_URI[x86_64_v2_clang-devel.sha256sum] = "a4eea7c92200df255d5d700b7beb8038cabaac62b486f8c492cc9dc998b3642c"

URI_x86_64_v2_clang-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clang-libs-21.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clang-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang-libs}"
SRC_URI[x86_64_v2_clang-libs.sha256sum] = "dbcd3e4bdce59e1648dbddf759d6a736f96c28cdc3809e892d632abe03293e30"

URI_x86_64_v2_clang-resource-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clang-resource-filesystem-21.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clang-resource-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang-resource-filesystem}"
SRC_URI[x86_64_v2_clang-resource-filesystem.sha256sum] = "9dece486917f4f2c9c2373cc06a7d8f697bc0830aa40ca0c47ecd747fe446bd9"

URI_x86_64_v2_clang-tools-extra = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clang-tools-extra-21.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clang-tools-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang-tools-extra}"
SRC_URI[x86_64_v2_clang-tools-extra.sha256sum] = "54340ae0f9c686f89d4639bf115c5c0fa46a051c60f53c213d35d66092546f1b"

URI_x86_64_v2_compiler-rt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/compiler-rt-21.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_compiler-rt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_compiler-rt}"
SRC_URI[x86_64_v2_compiler-rt.sha256sum] = "59662b332acae343694451804f2f7fff03fb470bf80fbaf99c7c505932536719"

URI_x86_64_v2_git-clang-format = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/git-clang-format-21.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_git-clang-format;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-clang-format}"
SRC_URI[x86_64_v2_git-clang-format.sha256sum] = "990838b672939fdf70e80df118f4a1d478d961d63261e3b7f94e6349273bba55"

URI_x86_64_v2_libomp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libomp-21.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libomp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libomp}"
SRC_URI[x86_64_v2_libomp.sha256sum] = "cc28b9be0dc545c07a9889ae611015321e4c52d1b6133aacc3ba74b645ab2d46"
RPROVIDES:libomp:x86_64_v2 = "virtual/libomp.so_VERSION__64bit_ virtual/libomp.so___64bit_"

URI_x86_64_v2_libomp-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libomp-devel-21.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libomp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libomp-devel}"
SRC_URI[x86_64_v2_libomp-devel.sha256sum] = "078d25561f56e2531690c86da7612253065476a96f6fefae7d7d82b2f4102c84"

URI_x86_64_v2_lld = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lld-21.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lld;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lld}"
SRC_URI[x86_64_v2_lld.sha256sum] = "179c03bf9b0d191052b452f3bf758651f4fcf230928a8f17a5068efcd1e0c003"

URI_x86_64_v2_lld-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lld-devel-21.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lld-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lld-devel}"
SRC_URI[x86_64_v2_lld-devel.sha256sum] = "1d1106a72e81c68ef6da8694c6ea8577be5dbb1fcff381f3f7ad7b0b2d5e56fe"

URI_x86_64_v2_lld-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lld-libs-21.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lld-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lld-libs}"
SRC_URI[x86_64_v2_lld-libs.sha256sum] = "2f0a463b6f9a473a0dd336ce458d903a4f3f2bcccd3426c80bae4f794b7f5cdb"

URI_x86_64_v2_lldb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lldb-21.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lldb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lldb}"
SRC_URI[x86_64_v2_lldb.sha256sum] = "2db69fd2e2bf5511fe61741ab4e6098a6698907695deb193085c75f7f4ee0e65"

URI_x86_64_v2_lldb-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lldb-devel-21.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lldb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lldb-devel}"
SRC_URI[x86_64_v2_lldb-devel.sha256sum] = "61189aec4b05ba1506a5950b329b41d594335cb9a93b919471804be60f827e88"

URI_x86_64_v2_llvm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-21.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm}"
SRC_URI[x86_64_v2_llvm.sha256sum] = "faa533bc1b5947357a93c8f6af7cc920b32713952a84cf6bf45596da6b1c7add"

URI_x86_64_v2_llvm-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-devel-21.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm-devel}"
SRC_URI[x86_64_v2_llvm-devel.sha256sum] = "25edcac86b8f65b25fc0ee31965ca3ea18a466ebe5346b8c928657a77d21351b"

URI_x86_64_v2_llvm-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-doc-21.1.8-1.el10.alma.1.noarch.rpm;name=x86_64_v2_llvm-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm-doc}"
SRC_URI[x86_64_v2_llvm-doc.sha256sum] = "37747b73a44316860b959d282ee625b43d564ca123ac3128c47c8af4e9255126"

URI_x86_64_v2_llvm-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-filesystem-21.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm-filesystem}"
SRC_URI[x86_64_v2_llvm-filesystem.sha256sum] = "080ed3eefb2a1a7742417b74b8d81af0be0453e9555067afe6860df62507b6f3"

URI_x86_64_v2_llvm-googletest = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-googletest-21.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-googletest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm-googletest}"
SRC_URI[x86_64_v2_llvm-googletest.sha256sum] = "679e7bba075d2abeecd370758a4238bdc3ff603f81672972dd4c5d93596bd55d"

URI_x86_64_v2_llvm-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-libs-21.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm-libs}"
SRC_URI[x86_64_v2_llvm-libs.sha256sum] = "c34072a1cb4eba835acf79159981b568c4189075bd5d4d1a425b36c8da49cdb8"

URI_x86_64_v2_llvm-static = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-static-21.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm-static}"
SRC_URI[x86_64_v2_llvm-static.sha256sum] = "408a4454392524135520f0d74a46dd336e8e22f81a8903df1567f46f1b594c31"

URI_x86_64_v2_llvm-test = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-test-21.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm-test}"
SRC_URI[x86_64_v2_llvm-test.sha256sum] = "5f8006d423941ed69f3fa042535f18e3b2b82986dbf123ed15ee1074ad5a432c"

URI_x86_64_v2_llvm-toolset = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-toolset-21.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-toolset;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm-toolset}"
SRC_URI[x86_64_v2_llvm-toolset.sha256sum] = "6b9f0dab872b0b7cfae0efe95c136b71b9e557e6a61c0d4012b178aedf912a7a"

URI_x86_64_v2_python3-clang = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-clang-21.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-clang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-clang}"
SRC_URI[x86_64_v2_python3-clang.sha256sum] = "155bb3e4a11ce1dcfd4122473977c270b20e910b3983b45a305965a36c351e0f"

URI_x86_64_v2_python3-lit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-lit-21.1.8-1.el10.alma.1.noarch.rpm;name=x86_64_v2_python3-lit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lit}"
SRC_URI[x86_64_v2_python3-lit.sha256sum] = "c1a2cf83c380efc7eb470aeee2288be5236ee34aae9aa36d2877c7e865544b6c"

URI_x86_64_v2_python3-lldb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-lldb-21.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-lldb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lldb}"
SRC_URI[x86_64_v2_python3-lldb.sha256sum] = "fa783df652e4ffad4680510a5d88fe806e9cbe65e55b3ac179bd7ee199b31ca8"

URI_aarch64_clang = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clang-21.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_clang;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang}"
SRC_URI[aarch64_clang.sha256sum] = "7ba0ca88e4267740de6eda468d3174f71c6a39a390fac7a745719366c17f0ac5"

URI_aarch64_clang-analyzer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clang-analyzer-21.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_clang-analyzer;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang-analyzer}"
SRC_URI[aarch64_clang-analyzer.sha256sum] = "6f848a92bba3577e2e031948ec3b44d7e8d97814772fead4de3aa4d6ed537f7b"

URI_aarch64_clang-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clang-devel-21.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_clang-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang-devel}"
SRC_URI[aarch64_clang-devel.sha256sum] = "2e8836cbe4ddacb1530eedbd88a31d20d4ba31c8edeae081188b82938b2a9f99"

URI_aarch64_clang-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clang-libs-21.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_clang-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang-libs}"
SRC_URI[aarch64_clang-libs.sha256sum] = "d9a143231273a1a7d5a0139b260369c0b02b3be42caf68ca739e3fc35eafb4f2"

URI_aarch64_clang-resource-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clang-resource-filesystem-21.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_clang-resource-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang-resource-filesystem}"
SRC_URI[aarch64_clang-resource-filesystem.sha256sum] = "dee4e8783e90c0473473470019c0bf48743a1e34557514fb4e068b79ad9e60b6"

URI_aarch64_clang-tools-extra = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clang-tools-extra-21.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_clang-tools-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang-tools-extra}"
SRC_URI[aarch64_clang-tools-extra.sha256sum] = "095487c3901e112fda31d08486c0b558fff03b9d0356e35ab6927bdab632673d"

URI_aarch64_compiler-rt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/compiler-rt-21.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_compiler-rt;unpack=0"
SRC_URI:append = " ${URI_aarch64_compiler-rt}"
SRC_URI[aarch64_compiler-rt.sha256sum] = "64ef162c3c4033239ef9015203cb547bd12b42557076eb991fde669270d67732"

URI_aarch64_git-clang-format = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/git-clang-format-21.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_git-clang-format;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-clang-format}"
SRC_URI[aarch64_git-clang-format.sha256sum] = "37eaf48ee2818f5a2e24e1a601e7bc8368258dd0455c8790b6beb7d72cddae02"

URI_aarch64_libomp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libomp-21.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_libomp;unpack=0"
SRC_URI:append = " ${URI_aarch64_libomp}"
SRC_URI[aarch64_libomp.sha256sum] = "2d3f567eaa6262b1706c2bad3ade4e43b7c1932db4ff87f1ffffe212c364ce41"

URI_aarch64_libomp-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libomp-devel-21.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_libomp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libomp-devel}"
SRC_URI[aarch64_libomp-devel.sha256sum] = "00e0ec1cda972cee010ae70d4ac2f0eccfb8a755e484a8d4929720c4589b3f7d"

URI_aarch64_lld = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lld-21.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_lld;unpack=0"
SRC_URI:append = " ${URI_aarch64_lld}"
SRC_URI[aarch64_lld.sha256sum] = "441c772edc9d7c230613c0660ca4f1cc2b06a7ec34fe0af5607e71c83b5618bb"

URI_aarch64_lld-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lld-devel-21.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_lld-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lld-devel}"
SRC_URI[aarch64_lld-devel.sha256sum] = "52dde4973196c02a02021bf629912b464d795104b52d3e56d6385bd14a3aa906"

URI_aarch64_lld-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lld-libs-21.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_lld-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_lld-libs}"
SRC_URI[aarch64_lld-libs.sha256sum] = "da5a548f7e543359d411c9dd0de81265e01d91d59f9f05c44949878b2b21a544"

URI_aarch64_lldb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lldb-21.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_lldb;unpack=0"
SRC_URI:append = " ${URI_aarch64_lldb}"
SRC_URI[aarch64_lldb.sha256sum] = "1494439d3e5962f9913f1a0ba809a3b5f5506e214c05857e2d8ffd98f037e410"

URI_aarch64_lldb-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lldb-devel-21.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_lldb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lldb-devel}"
SRC_URI[aarch64_lldb-devel.sha256sum] = "7d0bfcb7464103cdf9e82b07ff610857683c65a47b235925b59c2299372fed1f"

URI_aarch64_llvm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-21.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_llvm;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm}"
SRC_URI[aarch64_llvm.sha256sum] = "23b62afc58253dc4406443db561f05c022992d853cd6900b0a73c30810d551c4"

URI_aarch64_llvm-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-devel-21.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_llvm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm-devel}"
SRC_URI[aarch64_llvm-devel.sha256sum] = "df87e7a8aec9aa11a27fa3a2faea84f782d8da4733f42878138157bdd4b437b2"

URI_aarch64_llvm-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-doc-21.1.8-1.el10.alma.1.noarch.rpm;name=aarch64_llvm-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm-doc}"
SRC_URI[aarch64_llvm-doc.sha256sum] = "37747b73a44316860b959d282ee625b43d564ca123ac3128c47c8af4e9255126"

URI_aarch64_llvm-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-filesystem-21.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_llvm-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm-filesystem}"
SRC_URI[aarch64_llvm-filesystem.sha256sum] = "d3f61c576bbb267a9cd082868feb1c500978698ab0105452021938e0df8b9433"

URI_aarch64_llvm-googletest = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-googletest-21.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_llvm-googletest;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm-googletest}"
SRC_URI[aarch64_llvm-googletest.sha256sum] = "16362f33d569e49ede8f5bcecbacd5b48ff2d53ff013ef7d51bdc2d3dc015713"

URI_aarch64_llvm-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-libs-21.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_llvm-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm-libs}"
SRC_URI[aarch64_llvm-libs.sha256sum] = "4404dc1a68b1acd7ffc123f4ebaed3b103ca14258b4b7356099acf861b0a4dbf"

URI_aarch64_llvm-static = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-static-21.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_llvm-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm-static}"
SRC_URI[aarch64_llvm-static.sha256sum] = "0adc9af4ca9b69e6f743583cc4e3eba6dd135bdb95d256370f108907d05e6955"

URI_aarch64_llvm-test = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-test-21.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_llvm-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm-test}"
SRC_URI[aarch64_llvm-test.sha256sum] = "523e0f1668219de351446b0da447dc3de50044b9c75f4864d92d32943db7f117"

URI_aarch64_llvm-toolset = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-toolset-21.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_llvm-toolset;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm-toolset}"
SRC_URI[aarch64_llvm-toolset.sha256sum] = "4c789964d5fe2426f2d9da54dc85c4e41e3891c7c0c96f76690c03d0f9eed312"

URI_aarch64_python3-clang = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-clang-21.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_python3-clang;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-clang}"
SRC_URI[aarch64_python3-clang.sha256sum] = "ff69c84a540a87059f90c6c4f0e9c72f0b5ea1559b99603d1d0f0f54c379cf2a"

URI_aarch64_python3-lit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-lit-21.1.8-1.el10.alma.1.noarch.rpm;name=aarch64_python3-lit;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lit}"
SRC_URI[aarch64_python3-lit.sha256sum] = "c1a2cf83c380efc7eb470aeee2288be5236ee34aae9aa36d2877c7e865544b6c"

URI_aarch64_python3-lldb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-lldb-21.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_python3-lldb;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lldb}"
SRC_URI[aarch64_python3-lldb.sha256sum] = "64ed2c6d833e94c33ba3357a2efa61912fe27d5cca21b7123a212db9d51873e4"

RDEPENDS:clang = " \
 clang-libs \
 gcc-c++ \
 glibc \
 libgcc \
 libstdc++ \
 libstdc++-devel \
 llvm-libs \
 "
RDEPENDS:clang-analyzer = " \
 clang \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-FindBin \
 perl-Hash-Util \
 perl-PathTools \
 perl-Sys-Hostname \
 perl-Term-ANSIColor \
 perl-Text-ParseWords \
 perl-interpreter \
 perl-lib \
 perl-libs \
 python3 \
 "
RDEPENDS:clang-devel = " \
 clang \
 clang-libs \
 clang-tools-extra \
 cmake-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 llvm-devel \
 "
RDEPENDS:clang-libs = " \
 clang-resource-filesystem \
 gcc-toolset-15-gcc-c++ \
 glibc \
 libgcc \
 libstdc++ \
 llvm-libs \
 "
RDEPENDS:clang-resource-filesystem = " \
 "
RDEPENDS:clang-tools-extra = " \
 clang-libs \
 emacs-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 libxml2 \
 llvm-libs \
 python3 \
 "
RDEPENDS:compiler-rt = " \
 clang-resource-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
RDEPENDS:git-clang-format = " \
 clang-tools-extra \
 git \
 python3 \
 "
RDEPENDS:libomp = " \
 elfutils-libelf \
 glibc \
 libffi \
 libgcc \
 libstdc++ \
 llvm-libs \
 "
RDEPENDS:libomp-devel = " \
 clang-resource-filesystem \
 libomp \
 "
RDEPENDS:lld = " \
 alternatives \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 lld-libs \
 llvm-libs \
 "
RDEPENDS:lld-devel = " \
 cmake-filesystem \
 lld \
 lld-libs \
 "
RDEPENDS:lld-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 llvm-libs \
 zlib-ng-compat \
 "
RDEPENDS:lldb = " \
 clang-libs \
 glibc \
 libedit \
 libgcc \
 libstdc++ \
 libxml2 \
 llvm-libs \
 ncurses-libs \
 python3-libs \
 python3-lldb \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:lldb-devel = " \
 lldb \
 "
RDEPENDS:llvm = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 llvm-libs \
 python3 \
 zlib-ng-compat \
 "
RDEPENDS:llvm-devel = " \
 alternatives \
 bash \
 cmake-filesystem \
 glibc \
 libedit-devel \
 libgcc \
 libstdc++ \
 libzstd-devel \
 llvm \
 llvm-googletest \
 llvm-libs \
 llvm-static \
 llvm-test \
 "
RDEPENDS:llvm-doc = " \
 llvm \
 "
RDEPENDS:llvm-filesystem = " \
 "
RDEPENDS:llvm-googletest = " \
 llvm-filesystem \
 "
RDEPENDS:llvm-libs = " \
 glibc \
 libedit \
 libffi \
 libgcc \
 libstdc++ \
 libxml2 \
 libzstd \
 llvm-filesystem \
 zlib-ng-compat \
 "
RDEPENDS:llvm-static = " \
 llvm-filesystem \
 "
RDEPENDS:llvm-test = " \
 glibc \
 libgcc \
 libstdc++ \
 llvm \
 llvm-libs \
 "
RDEPENDS:llvm-toolset = " \
 clang \
 lld \
 llvm \
 "
RDEPENDS:python3-clang = " \
 clang-devel \
 python3 \
 "
RDEPENDS:python3-lit = " \
 python3 \
 "
RDEPENDS:python3-lldb = " \
 lldb \
 python3 \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/libomp.so_VERSION__64bit_ rpm/virtual/libomp.so___64bit_"
