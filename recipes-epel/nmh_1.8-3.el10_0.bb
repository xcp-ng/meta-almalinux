# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nmh"
PV = "1.8"
PR = "3.el10_0"
PACKAGES = " \
 nmh \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nmh-1.8-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa4bc5e7570e193e6b745ff867104594246d939a1a53da7ee4ca7418278e5526"

URI_x86_64_v2_nmh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nmh-1.8-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nmh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nmh}"
SRC_URI[x86_64_v2_nmh.sha256sum] = "c72c24add046c0eeba1527d89f9693d55384a479cca0b67b953f978bacb05d05"

URI_aarch64_nmh = "${EPEL_MIRROR}/aarch64/Packages/n/nmh-1.8-3.el10_0.aarch64.rpm;name=aarch64_nmh;unpack=0"
SRC_URI:append = " ${URI_aarch64_nmh}"
SRC_URI[aarch64_nmh.sha256sum] = "5f5616cbe514866c83931de9851c05dfc79d3527272d1c72e94195ccf810d423"

RDEPENDS:nmh = " \
 bash \
 cyrus-sasl-lib \
 gdbm-libs \
 glibc \
 lynx \
 ncurses-libs \
 openssl-libs \
 readline \
 virtual/libcurl.so.4___64bit_ \
 "
