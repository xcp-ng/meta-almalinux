# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-ocaml"
PV = "0.24.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-tree-sitter-ocaml+default-devel \
 rust-tree-sitter-ocaml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-ocaml-0.24.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc16eb3f058403f9da11e07472e74bb829c98829a769064fc46d971a94210156"

URI_x86_64_v2_rust-tree-sitter-ocaml+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-ocaml+default-devel-0.24.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-ocaml+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-ocaml+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-ocaml+default-devel.sha256sum] = "f5a8920f563dcd3566afc3cea7fdb23484d65c020291f1100ae9cbcbbf9edb89"

URI_x86_64_v2_rust-tree-sitter-ocaml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-ocaml-devel-0.24.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-ocaml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-ocaml-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-ocaml-devel.sha256sum] = "0d0d48eb23a02b799b611c86297a4227de73c92389ab95108206ce58209c681a"

URI_aarch64_rust-tree-sitter-ocaml+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-ocaml+default-devel-0.24.0-2.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-ocaml+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-ocaml+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-ocaml+default-devel.sha256sum] = "6f0185b820fbf6df5b248b904e31cc9443e7d475599d3173c1b4c4e61bd51fcc"

URI_aarch64_rust-tree-sitter-ocaml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-ocaml-devel-0.24.0-2.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-ocaml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-ocaml-devel}"
SRC_URI[aarch64_rust-tree-sitter-ocaml-devel.sha256sum] = "79fe4cc1f6381104e9090a600aba4c7e0e8add47e23784584b80ab0dc53f6e77"

RDEPENDS:rust-tree-sitter-ocaml+default-devel = " \
 cargo \
 rust-tree-sitter-ocaml-devel \
 "
RDEPENDS:rust-tree-sitter-ocaml-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
