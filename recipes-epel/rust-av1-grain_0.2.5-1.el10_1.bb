# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-av1-grain"
PV = "0.2.5"
PR = "1.el10_1"
PACKAGES = " \
 rust-av1-grain+create-devel \
 rust-av1-grain+default-devel \
 rust-av1-grain+diff-devel \
 rust-av1-grain+estimate-devel \
 rust-av1-grain+nom-devel \
 rust-av1-grain+num-rational-devel \
 rust-av1-grain+parse-devel \
 rust-av1-grain+serde-devel \
 rust-av1-grain+serialize-devel \
 rust-av1-grain+unstable-devel \
 rust-av1-grain+v_frame-devel \
 rust-av1-grain-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-av1-grain-0.2.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5be447af5f35af530da18cab0bdf2686bae7f464f487a2f314e3bd1c0d5bc55c"

URI_x86_64_v2_rust-av1-grain+create-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain+create-devel-0.2.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain+create-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain+create-devel}"
SRC_URI[x86_64_v2_rust-av1-grain+create-devel.sha256sum] = "d8f88b648e9d7f4de741eb469a74ebef787b5f4f89890cbd0ecb7778dd3360bb"

URI_x86_64_v2_rust-av1-grain+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain+default-devel-0.2.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain+default-devel}"
SRC_URI[x86_64_v2_rust-av1-grain+default-devel.sha256sum] = "49ef578f34028a08c640c89086d607a976b854b44bd491211935d6f96e48f46e"

URI_x86_64_v2_rust-av1-grain+diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain+diff-devel-0.2.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain+diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain+diff-devel}"
SRC_URI[x86_64_v2_rust-av1-grain+diff-devel.sha256sum] = "3cdb052c4bd101428c7e9553111c79eb371fd87456dc2b537308f7f983ae3fec"

URI_x86_64_v2_rust-av1-grain+estimate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain+estimate-devel-0.2.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain+estimate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain+estimate-devel}"
SRC_URI[x86_64_v2_rust-av1-grain+estimate-devel.sha256sum] = "f73bd020ce9280593336b1b3a78e2bd0602d9bccd60e1a3a0c6846435fd17c89"

URI_x86_64_v2_rust-av1-grain+nom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain+nom-devel-0.2.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain+nom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain+nom-devel}"
SRC_URI[x86_64_v2_rust-av1-grain+nom-devel.sha256sum] = "69b1aefd01f6cf094b87b93ffea650bf1f0c76a7997a5ad979adf8c1e1375ce3"

URI_x86_64_v2_rust-av1-grain+num-rational-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain+num-rational-devel-0.2.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain+num-rational-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain+num-rational-devel}"
SRC_URI[x86_64_v2_rust-av1-grain+num-rational-devel.sha256sum] = "21244a8c82744d0e5e4f68e56833652376ddf0882b28987b5af2b734fac6a344"

URI_x86_64_v2_rust-av1-grain+parse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain+parse-devel-0.2.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain+parse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain+parse-devel}"
SRC_URI[x86_64_v2_rust-av1-grain+parse-devel.sha256sum] = "87819ff8609c465feb921e663a22ba01a2b7306ed5ecfeb0008a71af8328a8ae"

URI_x86_64_v2_rust-av1-grain+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain+serde-devel-0.2.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain+serde-devel}"
SRC_URI[x86_64_v2_rust-av1-grain+serde-devel.sha256sum] = "663443269ad0dc169246a12e90eb7e13f8c61f03e7f93841692e6bc0f116e94f"

URI_x86_64_v2_rust-av1-grain+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain+serialize-devel-0.2.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain+serialize-devel}"
SRC_URI[x86_64_v2_rust-av1-grain+serialize-devel.sha256sum] = "c88572673781a144fd29934d1708ce360c5f08ed22c015bf143876a269bdac8f"

URI_x86_64_v2_rust-av1-grain+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain+unstable-devel-0.2.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain+unstable-devel}"
SRC_URI[x86_64_v2_rust-av1-grain+unstable-devel.sha256sum] = "18ebb61c27485df52aa5b10cc8046fa6c3c4c138d9032779e07ef066df388a1b"

URI_x86_64_v2_rust-av1-grain+v_frame-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain+v_frame-devel-0.2.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain+v_frame-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain+v_frame-devel}"
SRC_URI[x86_64_v2_rust-av1-grain+v_frame-devel.sha256sum] = "4965aadc950df38370a52a2df9b202b99d16efe40681604f220c856d2d85739c"

URI_x86_64_v2_rust-av1-grain-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain-devel-0.2.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain-devel}"
SRC_URI[x86_64_v2_rust-av1-grain-devel.sha256sum] = "528447452615e463be9acbdd96bfe807a6224726de371c599b3a29f77e50f218"

URI_aarch64_rust-av1-grain+create-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain+create-devel-0.2.5-1.el10_1.noarch.rpm;name=aarch64_rust-av1-grain+create-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain+create-devel}"
SRC_URI[aarch64_rust-av1-grain+create-devel.sha256sum] = "fada7806eea7fc79f0ff1f6376d27feb9af830455ab18122247bb1d82da346db"

URI_aarch64_rust-av1-grain+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain+default-devel-0.2.5-1.el10_1.noarch.rpm;name=aarch64_rust-av1-grain+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain+default-devel}"
SRC_URI[aarch64_rust-av1-grain+default-devel.sha256sum] = "941300e6c2102a7ba69906ae5cdab92721db590cfce848ece5fd8007c4e30328"

URI_aarch64_rust-av1-grain+diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain+diff-devel-0.2.5-1.el10_1.noarch.rpm;name=aarch64_rust-av1-grain+diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain+diff-devel}"
SRC_URI[aarch64_rust-av1-grain+diff-devel.sha256sum] = "1ff2ffb09714497b49395895c32e972a11b987fc536e5d1ba2b2eeed22dfbc19"

URI_aarch64_rust-av1-grain+estimate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain+estimate-devel-0.2.5-1.el10_1.noarch.rpm;name=aarch64_rust-av1-grain+estimate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain+estimate-devel}"
SRC_URI[aarch64_rust-av1-grain+estimate-devel.sha256sum] = "ff5ef9a2c60ea8671506fdca36330af7acea15f65b8c588ac7e7ecd25586ba61"

URI_aarch64_rust-av1-grain+nom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain+nom-devel-0.2.5-1.el10_1.noarch.rpm;name=aarch64_rust-av1-grain+nom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain+nom-devel}"
SRC_URI[aarch64_rust-av1-grain+nom-devel.sha256sum] = "b13cd070a18de5f5d3bd06903794a229280cff4fce3efc8fc58248de1b0f9fe3"

URI_aarch64_rust-av1-grain+num-rational-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain+num-rational-devel-0.2.5-1.el10_1.noarch.rpm;name=aarch64_rust-av1-grain+num-rational-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain+num-rational-devel}"
SRC_URI[aarch64_rust-av1-grain+num-rational-devel.sha256sum] = "f37db09858a98106ae54a25a1a76652ace93de669ba98de07297adf9c77327d7"

URI_aarch64_rust-av1-grain+parse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain+parse-devel-0.2.5-1.el10_1.noarch.rpm;name=aarch64_rust-av1-grain+parse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain+parse-devel}"
SRC_URI[aarch64_rust-av1-grain+parse-devel.sha256sum] = "3af822a498b1bf7564f362f1c387c752515bca7eda36d271cd2b8e989ff4f343"

URI_aarch64_rust-av1-grain+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain+serde-devel-0.2.5-1.el10_1.noarch.rpm;name=aarch64_rust-av1-grain+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain+serde-devel}"
SRC_URI[aarch64_rust-av1-grain+serde-devel.sha256sum] = "ac4b1dce99879c3a7f954f90e000c2feadedda56388df9a714272e8eda50e9b2"

URI_aarch64_rust-av1-grain+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain+serialize-devel-0.2.5-1.el10_1.noarch.rpm;name=aarch64_rust-av1-grain+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain+serialize-devel}"
SRC_URI[aarch64_rust-av1-grain+serialize-devel.sha256sum] = "7128abbb2e51379300930af794eb8091b892f27b955ec18de42c77afba72c242"

URI_aarch64_rust-av1-grain+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain+unstable-devel-0.2.5-1.el10_1.noarch.rpm;name=aarch64_rust-av1-grain+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain+unstable-devel}"
SRC_URI[aarch64_rust-av1-grain+unstable-devel.sha256sum] = "d297bcd5cb066805a9ca956eaca89bb76648901d1fad3d0803f07377d172f0f1"

URI_aarch64_rust-av1-grain+v_frame-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain+v_frame-devel-0.2.5-1.el10_1.noarch.rpm;name=aarch64_rust-av1-grain+v_frame-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain+v_frame-devel}"
SRC_URI[aarch64_rust-av1-grain+v_frame-devel.sha256sum] = "893c9b9bb28d9b1f543580dc2a02d786f75e5e6f80d2572c1e2e9abd71af3846"

URI_aarch64_rust-av1-grain-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain-devel-0.2.5-1.el10_1.noarch.rpm;name=aarch64_rust-av1-grain-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain-devel}"
SRC_URI[aarch64_rust-av1-grain-devel.sha256sum] = "33836be574868e9f89dede5dcc70b4c5c4d8cd6a808b0d53d5e1c422561df517"

RDEPENDS:rust-av1-grain+create-devel = " \
 cargo \
 rust-av1-grain-devel \
 "
RDEPENDS:rust-av1-grain+default-devel = " \
 cargo \
 rust-av1-grain+create-devel \
 rust-av1-grain+diff-devel \
 rust-av1-grain+estimate-devel \
 rust-av1-grain+parse-devel \
 rust-av1-grain-devel \
 "
RDEPENDS:rust-av1-grain+diff-devel = " \
 cargo \
 rust-av1-grain+num-rational-devel \
 rust-av1-grain+v_frame-devel \
 rust-av1-grain-devel \
 "
RDEPENDS:rust-av1-grain+estimate-devel = " \
 cargo \
 rust-av1-grain+v_frame-devel \
 rust-av1-grain-devel \
 "
RDEPENDS:rust-av1-grain+nom-devel = " \
 cargo \
 rust-av1-grain-devel \
 rust-nom+default-devel \
 "
RDEPENDS:rust-av1-grain+num-rational-devel = " \
 cargo \
 rust-av1-grain-devel \
 rust-num-rational+default-devel \
 "
RDEPENDS:rust-av1-grain+parse-devel = " \
 cargo \
 rust-av1-grain+nom-devel \
 rust-av1-grain-devel \
 "
RDEPENDS:rust-av1-grain+serde-devel = " \
 cargo \
 rust-av1-grain-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-av1-grain+serialize-devel = " \
 cargo \
 rust-arrayvec+serde-devel \
 rust-av1-grain+serde-devel \
 rust-av1-grain-devel \
 "
RDEPENDS:rust-av1-grain+unstable-devel = " \
 cargo \
 rust-av1-grain-devel \
 "
RDEPENDS:rust-av1-grain+v_frame-devel = " \
 cargo \
 rust-av1-grain-devel \
 rust-v_frame+default-devel \
 "
RDEPENDS:rust-av1-grain-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-arrayvec+default-devel \
 rust-log+default-devel \
 "
