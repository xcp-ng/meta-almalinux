# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ktuberling"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 ktuberling \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/ktuberling-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "72d006345d91cdc60a714df7a47797609d7c4b0bee5df1d0ebf424f1710062ba"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktuberling-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktuberling;unpack=0"
SRC_URI[x86_64_v2_ktuberling.sha256sum] = "6dbb30df18bb3acf80357e8483fcd6b11c7db6ca4617be724ddc8fb94c0bb81e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/ktuberling-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_ktuberling;unpack=0"
SRC_URI[aarch64_ktuberling.sha256sum] = "8c016d03d2bc0d859e907721e661a5d19ffe5c0e4d2aff6ec3b5af1aa843ca07"

RDEPENDS:ktuberling = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
 "
