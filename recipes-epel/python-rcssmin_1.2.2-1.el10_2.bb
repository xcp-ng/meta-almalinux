# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rcssmin"
PV = "1.2.2"
PR = "1.el10_2"
PACKAGES = " \
 python3-rcssmin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-rcssmin-1.2.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de484d2ccaac8d16ed3bb13454911cafb55506a192b45936e98164e2cca9da77"

URI_x86_64_v2_python3-rcssmin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rcssmin-1.2.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-rcssmin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rcssmin}"
SRC_URI[x86_64_v2_python3-rcssmin.sha256sum] = "5d0be5372ac730aa4f577fe6c66b60cfbdf474a666cfcbfa45737dd433b3c9e9"

URI_aarch64_python3-rcssmin = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rcssmin-1.2.2-1.el10_2.aarch64.rpm;name=aarch64_python3-rcssmin;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rcssmin}"
SRC_URI[aarch64_python3-rcssmin.sha256sum] = "cf6a8a4000cc92958b98cb0a1206f3ee23e03cb84592e7ef4a55e93f4fa44a97"

RDEPENDS:python3-rcssmin = " \
 glibc \
 python3 \
 "
