# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-Warn"
PV = "0.37"
PR = "7.el10"
PACKAGES = " \
 perl-Test-Warn \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Test-Warn-0.37-7.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "977ffe891edd38afbd80552b6b4d42ed9e67a13efaa2d6a2ae23968a2ead51c0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Test-Warn-0.37-7.el10.noarch.rpm;name=x86_64_v2_perl-Test-Warn;unpack=0"
SRC_URI[x86_64_v2_perl-Test-Warn.sha256sum] = "b0a080c76cbaac456946d2f177d12d95a7e3db6d66633e4409b88c9303281da0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Test-Warn-0.37-7.el10.noarch.rpm;name=aarch64_perl-Test-Warn;unpack=0"
SRC_URI[aarch64_perl-Test-Warn.sha256sum] = "b0a080c76cbaac456946d2f177d12d95a7e3db6d66633e4409b88c9303281da0"

RDEPENDS:perl-Test-Warn = " \
 perl-Carp \
 perl-Exporter \
 perl-Sub-Uplevel \
 perl-Test-Simple \
 perl-libs \
 "
