# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-half"
PV = "2.7.1"
PR = "2.el10_1"
PACKAGES = " \
 rust-half+alloc-devel \
 rust-half+arbitrary-devel \
 rust-half+bytemuck-devel \
 rust-half+default-devel \
 rust-half+num-traits-devel \
 rust-half+rand_distr-devel \
 rust-half+rkyv-devel \
 rust-half+serde-devel \
 rust-half+std-devel \
 rust-half+use-intrinsics-devel \
 rust-half+zerocopy-devel \
 rust-half-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-half-2.7.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c682b84473af7d5c1a5e6851a64865f2090b1ab276f290ee6a34be1ca748ec70"

URI_x86_64_v2_rust-half+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half+alloc-devel-2.7.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half+alloc-devel}"
SRC_URI[x86_64_v2_rust-half+alloc-devel.sha256sum] = "9ac53d86d97e3918d0b64ea2f8c6e2669785f93d1063e678485ea3d099522915"

URI_x86_64_v2_rust-half+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half+arbitrary-devel-2.7.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-half+arbitrary-devel.sha256sum] = "b3d82a5392f06c17bbe4f18403570992f1d0925077f3b0d7f07dfe37080d3a19"

URI_x86_64_v2_rust-half+bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half+bytemuck-devel-2.7.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half+bytemuck-devel}"
SRC_URI[x86_64_v2_rust-half+bytemuck-devel.sha256sum] = "f9c07149f45391633894f613f05a0257aa8325604ac66f05b17bf70a78c01e15"

URI_x86_64_v2_rust-half+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half+default-devel-2.7.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half+default-devel}"
SRC_URI[x86_64_v2_rust-half+default-devel.sha256sum] = "0355af127e455b435427e7c27c73fa68605a79fefc92402230af7217d150b6e3"

URI_x86_64_v2_rust-half+num-traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half+num-traits-devel-2.7.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half+num-traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half+num-traits-devel}"
SRC_URI[x86_64_v2_rust-half+num-traits-devel.sha256sum] = "300c2ad297bfb69499242b202585c964cee5a2c30831fa1b94f69fa688ad5d54"

URI_x86_64_v2_rust-half+rand_distr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half+rand_distr-devel-2.7.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half+rand_distr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half+rand_distr-devel}"
SRC_URI[x86_64_v2_rust-half+rand_distr-devel.sha256sum] = "3db2352805f0182dc283717cfef097bceb9190f8d47b9a8037943887da495b48"

URI_x86_64_v2_rust-half+rkyv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half+rkyv-devel-2.7.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half+rkyv-devel}"
SRC_URI[x86_64_v2_rust-half+rkyv-devel.sha256sum] = "c16230a8a5f8369510d454c87842c5b4368d8418f34fd54bc0941f5187c39abe"

URI_x86_64_v2_rust-half+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half+serde-devel-2.7.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half+serde-devel}"
SRC_URI[x86_64_v2_rust-half+serde-devel.sha256sum] = "2eec079870f0131b7221a766f9fe3c307eb9fb27f880d2cdb9c21a7cb0acf392"

URI_x86_64_v2_rust-half+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half+std-devel-2.7.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half+std-devel}"
SRC_URI[x86_64_v2_rust-half+std-devel.sha256sum] = "f36aeff25fb77983c9d0bc98966cf5541e4138d8ac97071f0bcd07d0ceb35886"

URI_x86_64_v2_rust-half+use-intrinsics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half+use-intrinsics-devel-2.7.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half+use-intrinsics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half+use-intrinsics-devel}"
SRC_URI[x86_64_v2_rust-half+use-intrinsics-devel.sha256sum] = "a14511739fd7d645110e3664c66772dbf74bcb4142213ba0e2addc3d94001e51"

URI_x86_64_v2_rust-half+zerocopy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half+zerocopy-devel-2.7.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half+zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half+zerocopy-devel}"
SRC_URI[x86_64_v2_rust-half+zerocopy-devel.sha256sum] = "6dc9eef3fc82782a79ca1ae42d3024dc83bc5d6ed25ad4ae1b51fcc96cb9ed36"

URI_x86_64_v2_rust-half-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-half-devel-2.7.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-half-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-half-devel}"
SRC_URI[x86_64_v2_rust-half-devel.sha256sum] = "ed4abcfd206a0bcd6a091dfbb2b8feda4c796bd09976c5dcc04db3183c601dee"
RPROVIDES:rust-half-devel:x86_64_v2 = "virtual/crate_half__ge_1.8.0_with_crate_half__lt_3.0.0~"

URI_aarch64_rust-half+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half+alloc-devel-2.7.1-2.el10_1.noarch.rpm;name=aarch64_rust-half+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half+alloc-devel}"
SRC_URI[aarch64_rust-half+alloc-devel.sha256sum] = "009c2f61283d4761db78d756fd404f7422e181564d16240e8ab8072496741be3"

URI_aarch64_rust-half+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half+arbitrary-devel-2.7.1-2.el10_1.noarch.rpm;name=aarch64_rust-half+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half+arbitrary-devel}"
SRC_URI[aarch64_rust-half+arbitrary-devel.sha256sum] = "e41a0b1b377b86c272cc6453a69780f86294e8989569c23d1562ec4b8b0cda7c"

URI_aarch64_rust-half+bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half+bytemuck-devel-2.7.1-2.el10_1.noarch.rpm;name=aarch64_rust-half+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half+bytemuck-devel}"
SRC_URI[aarch64_rust-half+bytemuck-devel.sha256sum] = "7f5ee9dbee15de30ac078590ecdf32b9df86f774d1c4619fb288f31b671b415f"

URI_aarch64_rust-half+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half+default-devel-2.7.1-2.el10_1.noarch.rpm;name=aarch64_rust-half+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half+default-devel}"
SRC_URI[aarch64_rust-half+default-devel.sha256sum] = "9e83fd05e8d0fcd7e053824342ca10d6f5815eb96ac829fcaed87d54159f5a84"

URI_aarch64_rust-half+num-traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half+num-traits-devel-2.7.1-2.el10_1.noarch.rpm;name=aarch64_rust-half+num-traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half+num-traits-devel}"
SRC_URI[aarch64_rust-half+num-traits-devel.sha256sum] = "df553c842b1d98e55fd46116d9b851b028d1e7a647e3e10386247ab1969d43c4"

URI_aarch64_rust-half+rand_distr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half+rand_distr-devel-2.7.1-2.el10_1.noarch.rpm;name=aarch64_rust-half+rand_distr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half+rand_distr-devel}"
SRC_URI[aarch64_rust-half+rand_distr-devel.sha256sum] = "3d6a8680f16a25befc98713b074bd7f32afc8558e68388990fe053491e3bc7c9"

URI_aarch64_rust-half+rkyv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half+rkyv-devel-2.7.1-2.el10_1.noarch.rpm;name=aarch64_rust-half+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half+rkyv-devel}"
SRC_URI[aarch64_rust-half+rkyv-devel.sha256sum] = "d16877ca556a0a6ae759109c8eeb4a6e0a0139afa50b6fa0595335cba2e49a5c"

URI_aarch64_rust-half+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half+serde-devel-2.7.1-2.el10_1.noarch.rpm;name=aarch64_rust-half+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half+serde-devel}"
SRC_URI[aarch64_rust-half+serde-devel.sha256sum] = "415aa2ad2d6774aadad2ff4e3e54f6c1d18936938460906219e761c57cfefa4a"

URI_aarch64_rust-half+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half+std-devel-2.7.1-2.el10_1.noarch.rpm;name=aarch64_rust-half+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half+std-devel}"
SRC_URI[aarch64_rust-half+std-devel.sha256sum] = "3bb06fbbab282cc7a65938b9ae337590f60066b2d1e71684551a591ddc3997f6"

URI_aarch64_rust-half+use-intrinsics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half+use-intrinsics-devel-2.7.1-2.el10_1.noarch.rpm;name=aarch64_rust-half+use-intrinsics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half+use-intrinsics-devel}"
SRC_URI[aarch64_rust-half+use-intrinsics-devel.sha256sum] = "055a4e80876c1e7b0648f9e85b7735736660482d1dde2d2ce2e29bea79f03c7d"

URI_aarch64_rust-half+zerocopy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half+zerocopy-devel-2.7.1-2.el10_1.noarch.rpm;name=aarch64_rust-half+zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half+zerocopy-devel}"
SRC_URI[aarch64_rust-half+zerocopy-devel.sha256sum] = "230d87433cccad1d379030a8590e8f2a0044f793f7b02d8558d6fd7cb33910e1"

URI_aarch64_rust-half-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-half-devel-2.7.1-2.el10_1.noarch.rpm;name=aarch64_rust-half-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-half-devel}"
SRC_URI[aarch64_rust-half-devel.sha256sum] = "c2bd9efcfe135ac4bbe460be1d22a298bb168b535a07eb516c1ddad3d654b584"
RPROVIDES:rust-half-devel:aarch64 = "virtual/crate_half__ge_1.8.0_with_crate_half__lt_3.0.0~"

RDEPENDS:rust-half+alloc-devel = " \
 cargo \
 rust-half-devel \
 "
RDEPENDS:rust-half+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-half-devel \
 "
RDEPENDS:rust-half+bytemuck-devel = " \
 cargo \
 rust-bytemuck+derive-devel \
 rust-bytemuck-devel \
 rust-half-devel \
 "
RDEPENDS:rust-half+default-devel = " \
 cargo \
 rust-half+std-devel \
 rust-half-devel \
 "
RDEPENDS:rust-half+num-traits-devel = " \
 cargo \
 rust-half-devel \
 rust-num-traits+libm-devel \
 rust-num-traits-devel \
 "
RDEPENDS:rust-half+rand_distr-devel = " \
 cargo \
 rust-half-devel \
 rust-rand+thread_rng-devel \
 rust-rand-devel \
 rust-rand_distr-devel \
 "
RDEPENDS:rust-half+rkyv-devel = " \
 cargo \
 rust-half-devel \
 rust-rkyv+default-devel \
 "
RDEPENDS:rust-half+serde-devel = " \
 cargo \
 rust-half-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-half+std-devel = " \
 cargo \
 rust-half+alloc-devel \
 rust-half-devel \
 "
RDEPENDS:rust-half+use-intrinsics-devel = " \
 cargo \
 rust-half-devel \
 "
RDEPENDS:rust-half+zerocopy-devel = " \
 cargo \
 rust-half-devel \
 "
RDEPENDS:rust-half-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-zerocopy+derive-devel \
 rust-zerocopy+simd-devel \
 rust-zerocopy-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_half__ge_1.8.0_with_crate_half__lt_3.0.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_half__ge_1.8.0_with_crate_half__lt_3.0.0~"
