# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "HepMC"
PV = "2.06.11"
PR = "19.el10_3"
PACKAGES = " \
 HepMC \
 HepMC-devel \
 HepMC-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/HepMC-2.06.11-19.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63ad5783fc50bc2dd2843aa53b7d15a1000460ab90de106e3c9053e3793afad9"

URI_x86_64_v2_HepMC = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC-2.06.11-19.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC}"
SRC_URI[x86_64_v2_HepMC.sha256sum] = "ce4c4bed8e4a9f4710e44e0ed8d97360304ecd4502fcda102a5686efb67a9ebc"

URI_x86_64_v2_HepMC-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC-devel-2.06.11-19.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC-devel}"
SRC_URI[x86_64_v2_HepMC-devel.sha256sum] = "2e2bbd6243ccfb8bbccb146d11512c669a9bb320df8b39418c26898caba70bce"

URI_x86_64_v2_HepMC-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC-doc-2.06.11-19.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_HepMC-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC-doc}"
SRC_URI[x86_64_v2_HepMC-doc.sha256sum] = "f519d6f398fe7ea001a0dd67963b7330e5d666d110cb1f091e350ef126b2b658"

URI_aarch64_HepMC = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC-2.06.11-19.el10_3.aarch64.rpm;name=aarch64_HepMC;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC}"
SRC_URI[aarch64_HepMC.sha256sum] = "8b3c269b79cb2cf37c7b2c353fc5c1a6f7571164dc9eabcf53c2e29817c90c21"

URI_aarch64_HepMC-devel = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC-devel-2.06.11-19.el10_3.aarch64.rpm;name=aarch64_HepMC-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC-devel}"
SRC_URI[aarch64_HepMC-devel.sha256sum] = "3b77bc7cda010bc02cf811be7ee777efb59498b123d40a23a79c4134ddb623cf"

URI_aarch64_HepMC-doc = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC-doc-2.06.11-19.el10_3.noarch.rpm;name=aarch64_HepMC-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC-doc}"
SRC_URI[aarch64_HepMC-doc.sha256sum] = "b6e2d11d473437ce0a88c3cadf0d995f6a19e95eea88e3558e899ba29e6c1da5"

RDEPENDS:HepMC = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:HepMC-devel = " \
 HepMC \
 "
RDEPENDS:HepMC-doc = " \
 "
