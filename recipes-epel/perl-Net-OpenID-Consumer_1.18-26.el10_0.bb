# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-OpenID-Consumer"
PV = "1.18"
PR = "26.el10_0"
PACKAGES = " \
 perl-Net-OpenID-Consumer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-OpenID-Consumer-1.18-26.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ccce54677743b90c86aa60bf128731aecc622b162c60be8247984106eb4b944a"

URI_x86_64_v2_perl-Net-OpenID-Consumer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-OpenID-Consumer-1.18-26.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-OpenID-Consumer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-OpenID-Consumer}"
SRC_URI[x86_64_v2_perl-Net-OpenID-Consumer.sha256sum] = "c2a29e3b9aaf4bf29cccc4cd09181dde44e97d946d132fbc36143949ebf8ed01"

URI_aarch64_perl-Net-OpenID-Consumer = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-OpenID-Consumer-1.18-26.el10_0.noarch.rpm;name=aarch64_perl-Net-OpenID-Consumer;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-OpenID-Consumer}"
SRC_URI[aarch64_perl-Net-OpenID-Consumer.sha256sum] = "6306cb332b7a1446315a708799523ed9abd6da95831cbd34934b11007c7daff1"

RDEPENDS:perl-Net-OpenID-Consumer = " \
 perl-Carp \
 perl-Digest-SHA \
 perl-HTML-Parser \
 perl-HTTP-Message \
 perl-JSON \
 perl-MIME-Base64 \
 perl-Net-OpenID-Common \
 perl-Net-OpenID-Consumer \
 perl-Storable \
 perl-Time-Local \
 perl-URI \
 perl-fields \
 perl-libs \
 perl-libwww-perl \
 "
