# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tinyproxy"
PV = "1.11.2"
PR = "8.el10_3"
PACKAGES = " \
 tinyproxy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tinyproxy-1.11.2-8.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b4792f04c7c504a96d4d9a8e25604b77f4d748af7831c1bd0bdfca08de4936d2"

URI_x86_64_v2_tinyproxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tinyproxy-1.11.2-8.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tinyproxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tinyproxy}"
SRC_URI[x86_64_v2_tinyproxy.sha256sum] = "bdf218d7423b819755ce6addd0845fdf7081ba4a7f517ea7765687ac2b938188"

URI_aarch64_tinyproxy = "${EPEL_MIRROR}/aarch64/Packages/t/tinyproxy-1.11.2-8.el10_3.aarch64.rpm;name=aarch64_tinyproxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_tinyproxy}"
SRC_URI[aarch64_tinyproxy.sha256sum] = "730d358030e04301c2c9d2578497e94b2f9bafd5842eaecd4075657ae2a1d67c"

RDEPENDS:tinyproxy = " \
 bash \
 glibc \
 "
