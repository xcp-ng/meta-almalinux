# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_install"
PV = "0.7.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-uu_install+default-devel \
 rust-uu_install+selinux-devel \
 rust-uu_install-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_install-0.7.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2cf9f7a11a7c251ebca6d9db18b336e0304ca15eda6642ad7242948b9fb6b43"

URI_x86_64_v2_rust-uu_install+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_install+default-devel-0.7.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_install+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_install+default-devel}"
SRC_URI[x86_64_v2_rust-uu_install+default-devel.sha256sum] = "701790372757381c8f5004573db6629358148aaebbff54da2c1b0e68934cdd89"

URI_x86_64_v2_rust-uu_install+selinux-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_install+selinux-devel-0.7.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_install+selinux-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_install+selinux-devel}"
SRC_URI[x86_64_v2_rust-uu_install+selinux-devel.sha256sum] = "1cb26ed8e91563271b85a9852ae419ceb3f65d2ae040ba4cdad85a836bafcb78"

URI_x86_64_v2_rust-uu_install-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_install-devel-0.7.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_install-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_install-devel}"
SRC_URI[x86_64_v2_rust-uu_install-devel.sha256sum] = "100827074c43cb4b9db66884d9c6645ace103ba5a109a0837baa5e2d8d3d2770"

URI_aarch64_rust-uu_install+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_install+default-devel-0.7.0-2.el10_3.noarch.rpm;name=aarch64_rust-uu_install+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_install+default-devel}"
SRC_URI[aarch64_rust-uu_install+default-devel.sha256sum] = "d08f8bab473a339e674872f70474ef56206a68827ccf7e2b7b8c0e5395639c45"

URI_aarch64_rust-uu_install+selinux-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_install+selinux-devel-0.7.0-2.el10_3.noarch.rpm;name=aarch64_rust-uu_install+selinux-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_install+selinux-devel}"
SRC_URI[aarch64_rust-uu_install+selinux-devel.sha256sum] = "a4a3ac923993f0098af5d832d7c4511075240f4b2dd38a9bd7c767edaca8d415"

URI_aarch64_rust-uu_install-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_install-devel-0.7.0-2.el10_3.noarch.rpm;name=aarch64_rust-uu_install-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_install-devel}"
SRC_URI[aarch64_rust-uu_install-devel.sha256sum] = "afc13044635dbe98b42a3d80f65845ac7dbffc1083e6934cd5171c29c1aa6c03"

RDEPENDS:rust-uu_install+default-devel = " \
 cargo \
 rust-uu_install-devel \
 "
RDEPENDS:rust-uu_install+selinux-devel = " \
 cargo \
 rust-selinux+default-devel \
 rust-uu_install-devel \
 rust-uucore+selinux-devel \
 "
RDEPENDS:rust-uu_install-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-file_diff+default-devel \
 rust-filetime+default-devel \
 rust-fluent+default-devel \
 rust-thiserror+default-devel \
 rust-uucore+backup-control-devel \
 rust-uucore+buf-copy-devel \
 rust-uucore+default-devel \
 rust-uucore+entries-devel \
 rust-uucore+fs-devel \
 rust-uucore+mode-devel \
 rust-uucore+perms-devel \
 rust-uucore+process-devel \
 "
