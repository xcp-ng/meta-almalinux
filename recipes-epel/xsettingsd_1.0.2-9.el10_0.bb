# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xsettingsd"
PV = "1.0.2"
PR = "9.el10_0"
PACKAGES = " \
 xsettingsd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xsettingsd-1.0.2-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "071b7651e31fc0000ca3974f3277ff4b5aeafb9b0ac839252117a29f43cc5d63"

URI_x86_64_v2_xsettingsd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xsettingsd-1.0.2-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xsettingsd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xsettingsd}"
SRC_URI[x86_64_v2_xsettingsd.sha256sum] = "49515e374c22e15caffd1098a85f0d52b811b53c77e818ccb94f85425149c704"

URI_aarch64_xsettingsd = "${EPEL_MIRROR}/aarch64/Packages/x/xsettingsd-1.0.2-9.el10_0.aarch64.rpm;name=aarch64_xsettingsd;unpack=0"
SRC_URI:append = " ${URI_aarch64_xsettingsd}"
SRC_URI[aarch64_xsettingsd.sha256sum] = "dd93dda21bf80a312d64a3c3b56c1a6a11e67aa210ad3e1f86ddaeefd5bf56a5"

RDEPENDS:xsettingsd = " \
 bash \
 glibc \
 libX11 \
 libgcc \
 libstdc++ \
 "
