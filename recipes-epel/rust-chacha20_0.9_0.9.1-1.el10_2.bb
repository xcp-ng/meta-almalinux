# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-chacha20_0.9"
PV = "0.9.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-chacha20_0.9+default-devel \
 rust-chacha20_0.9+std-devel \
 rust-chacha20_0.9+zeroize-devel \
 rust-chacha20_0.9-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-chacha20_0.9-0.9.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36f2d7458c0908bdb658b106592f0e1e6d600355bb4d353f65e550cc957285d6"

URI_x86_64_v2_rust-chacha20_0.9+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chacha20_0.9+default-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chacha20_0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chacha20_0.9+default-devel}"
SRC_URI[x86_64_v2_rust-chacha20_0.9+default-devel.sha256sum] = "b3cf875ae3c55e2ef95cc4cd87cb3d41036222e394dab69e39a45f9763fa2eaf"

URI_x86_64_v2_rust-chacha20_0.9+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chacha20_0.9+std-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chacha20_0.9+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chacha20_0.9+std-devel}"
SRC_URI[x86_64_v2_rust-chacha20_0.9+std-devel.sha256sum] = "d1fb00a7e35fa3767f6d761611970174b31bd6fe226f2e41ad64d1de464011dc"

URI_x86_64_v2_rust-chacha20_0.9+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chacha20_0.9+zeroize-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chacha20_0.9+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chacha20_0.9+zeroize-devel}"
SRC_URI[x86_64_v2_rust-chacha20_0.9+zeroize-devel.sha256sum] = "d35aff78281d5c009fe35ec2569446c428d618a2ab770523440dec044fae0c6d"

URI_x86_64_v2_rust-chacha20_0.9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chacha20_0.9-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chacha20_0.9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chacha20_0.9-devel}"
SRC_URI[x86_64_v2_rust-chacha20_0.9-devel.sha256sum] = "a8dd36c760d2aae391b89fa5a78fb5f9832b474587b6d9d0f754eb24d8f2c4ec"

URI_aarch64_rust-chacha20_0.9+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chacha20_0.9+default-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-chacha20_0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chacha20_0.9+default-devel}"
SRC_URI[aarch64_rust-chacha20_0.9+default-devel.sha256sum] = "4aae975aa0a753c94c03c8e20cf8136c21f4f7c8e4af859eec5a7faf3e849588"

URI_aarch64_rust-chacha20_0.9+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chacha20_0.9+std-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-chacha20_0.9+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chacha20_0.9+std-devel}"
SRC_URI[aarch64_rust-chacha20_0.9+std-devel.sha256sum] = "d4c72cf5e58ac99c6a9ee062f3a4b10c8b2b397b931d93c17f7c1ab5f2141994"

URI_aarch64_rust-chacha20_0.9+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chacha20_0.9+zeroize-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-chacha20_0.9+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chacha20_0.9+zeroize-devel}"
SRC_URI[aarch64_rust-chacha20_0.9+zeroize-devel.sha256sum] = "8ea59d128e38ba5221042b64712a440c0a7deb65ce78b1f8a672f60c9600f618"

URI_aarch64_rust-chacha20_0.9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chacha20_0.9-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-chacha20_0.9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chacha20_0.9-devel}"
SRC_URI[aarch64_rust-chacha20_0.9-devel.sha256sum] = "90c70dc65157ba9d1b2743bcc507a48130ce46008fbbe801153dfcb4d99739cf"

RDEPENDS:rust-chacha20_0.9+default-devel = " \
 cargo \
 rust-chacha20_0.9-devel \
 "
RDEPENDS:rust-chacha20_0.9+std-devel = " \
 cargo \
 rust-chacha20_0.9-devel \
 rust-cipher0.4+std-devel \
 "
RDEPENDS:rust-chacha20_0.9+zeroize-devel = " \
 cargo \
 rust-chacha20_0.9-devel \
 rust-cipher0.4+zeroize-devel \
 "
RDEPENDS:rust-chacha20_0.9-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-cipher0.4+default-devel \
 rust-cpufeatures0.2+default-devel \
 "
