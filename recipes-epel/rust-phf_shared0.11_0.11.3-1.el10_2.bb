# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-phf_shared0.11"
PV = "0.11.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-phf_shared0.11+default-devel \
 rust-phf_shared0.11+std-devel \
 rust-phf_shared0.11+uncased-devel \
 rust-phf_shared0.11+unicase-devel \
 rust-phf_shared0.11-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-phf_shared0.11-0.11.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f73f3daf7f2df5aa122d634ecf7d84651e0dd0059f54d6344d30fdce886387c"

URI_x86_64_v2_rust-phf_shared0.11+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_shared0.11+default-devel-0.11.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_shared0.11+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_shared0.11+default-devel}"
SRC_URI[x86_64_v2_rust-phf_shared0.11+default-devel.sha256sum] = "bf16eb532bf56407aed529b1376d90b6079a6829f53dd59d1560e4997de4fcfd"

URI_x86_64_v2_rust-phf_shared0.11+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_shared0.11+std-devel-0.11.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_shared0.11+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_shared0.11+std-devel}"
SRC_URI[x86_64_v2_rust-phf_shared0.11+std-devel.sha256sum] = "26b2c480be485ca8a74ddb45d5c833edaef415a266bdc72390ca56c2e4a04dd8"

URI_x86_64_v2_rust-phf_shared0.11+uncased-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_shared0.11+uncased-devel-0.11.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_shared0.11+uncased-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_shared0.11+uncased-devel}"
SRC_URI[x86_64_v2_rust-phf_shared0.11+uncased-devel.sha256sum] = "6374f2f913f9651381a383f8e66bbc1abb03c5037aa936048f5607f38f6e2429"

URI_x86_64_v2_rust-phf_shared0.11+unicase-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_shared0.11+unicase-devel-0.11.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_shared0.11+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_shared0.11+unicase-devel}"
SRC_URI[x86_64_v2_rust-phf_shared0.11+unicase-devel.sha256sum] = "2193c6376e339a32c0bf0566422f44e6698ff1a8d9d9de42e68e3ff09bad03d2"

URI_x86_64_v2_rust-phf_shared0.11-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_shared0.11-devel-0.11.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_shared0.11-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_shared0.11-devel}"
SRC_URI[x86_64_v2_rust-phf_shared0.11-devel.sha256sum] = "b9c8ec5d36856900db47a0b3e9afb8d6dcdac45626797e914bf4c9706ee785ba"

URI_aarch64_rust-phf_shared0.11+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_shared0.11+default-devel-0.11.3-1.el10_2.noarch.rpm;name=aarch64_rust-phf_shared0.11+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_shared0.11+default-devel}"
SRC_URI[aarch64_rust-phf_shared0.11+default-devel.sha256sum] = "8302056eec06c2ad2b82d88bff57d7eef206996a97a96baff86bf5e52eb41f38"

URI_aarch64_rust-phf_shared0.11+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_shared0.11+std-devel-0.11.3-1.el10_2.noarch.rpm;name=aarch64_rust-phf_shared0.11+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_shared0.11+std-devel}"
SRC_URI[aarch64_rust-phf_shared0.11+std-devel.sha256sum] = "bcb7de31c87df13ea6539756b79923a23b1400b296162430ed17751bbbbbd38a"

URI_aarch64_rust-phf_shared0.11+uncased-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_shared0.11+uncased-devel-0.11.3-1.el10_2.noarch.rpm;name=aarch64_rust-phf_shared0.11+uncased-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_shared0.11+uncased-devel}"
SRC_URI[aarch64_rust-phf_shared0.11+uncased-devel.sha256sum] = "76e458e4c50c3b1042a67fa8c07df6abc5d70573b2b629e540256f1d9067a1b5"

URI_aarch64_rust-phf_shared0.11+unicase-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_shared0.11+unicase-devel-0.11.3-1.el10_2.noarch.rpm;name=aarch64_rust-phf_shared0.11+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_shared0.11+unicase-devel}"
SRC_URI[aarch64_rust-phf_shared0.11+unicase-devel.sha256sum] = "9a0d48b5c3516e32f610afc556f5c364cdd2b74498a74e25d8a9a8b1c6c95b50"

URI_aarch64_rust-phf_shared0.11-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_shared0.11-devel-0.11.3-1.el10_2.noarch.rpm;name=aarch64_rust-phf_shared0.11-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_shared0.11-devel}"
SRC_URI[aarch64_rust-phf_shared0.11-devel.sha256sum] = "bde4919b6d1517ae4152c682925c4dfa23400c0e23217d0f7661ed7b30250d85"

RDEPENDS:rust-phf_shared0.11+default-devel = " \
 cargo \
 rust-phf_shared0.11+std-devel \
 rust-phf_shared0.11-devel \
 "
RDEPENDS:rust-phf_shared0.11+std-devel = " \
 cargo \
 rust-phf_shared0.11-devel \
 "
RDEPENDS:rust-phf_shared0.11+uncased-devel = " \
 cargo \
 rust-phf_shared0.11-devel \
 rust-uncased-devel \
 "
RDEPENDS:rust-phf_shared0.11+unicase-devel = " \
 cargo \
 rust-phf_shared0.11-devel \
 rust-unicase+default-devel \
 "
RDEPENDS:rust-phf_shared0.11-devel = " \
 cargo \
 rust \
 rust-siphasher+default-devel \
 "
