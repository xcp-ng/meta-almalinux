# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clang15"
PV = "15.0.7"
PR = "9.el10_0"
PACKAGES = " \
 clang15 \
 clang15-devel \
 clang15-libs \
 clang15-resource-filesystem \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/clang15-15.0.7-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2b0f0bad5add98533a1a5113a24a0b2ca71b1865bb46071d7d3db969a377cdfa"

URI_x86_64_v2_clang15 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clang15-15.0.7-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clang15;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang15}"
SRC_URI[x86_64_v2_clang15.sha256sum] = "20bd62938c9ed645929a5452a0e08016251e8be58c6d37d5d9ca722fd2580632"

URI_x86_64_v2_clang15-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clang15-devel-15.0.7-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clang15-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang15-devel}"
SRC_URI[x86_64_v2_clang15-devel.sha256sum] = "ee26d4036b4abe48a43efa323bfe9e61bfe8fa0151dd617ca0122c4fb3573dd0"

URI_x86_64_v2_clang15-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clang15-libs-15.0.7-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clang15-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang15-libs}"
SRC_URI[x86_64_v2_clang15-libs.sha256sum] = "d8391b53364753a890b0c4a7b228ce4151c18b99ed6dd9f54950b95c8345ebcf"

URI_x86_64_v2_clang15-resource-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clang15-resource-filesystem-15.0.7-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clang15-resource-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang15-resource-filesystem}"
SRC_URI[x86_64_v2_clang15-resource-filesystem.sha256sum] = "ef9d7b22799a57de59ef4cb4f2c60af24e188a91441122f0ddd1118354cd27d7"

URI_aarch64_clang15 = "${EPEL_MIRROR}/aarch64/Packages/c/clang15-15.0.7-9.el10_0.aarch64.rpm;name=aarch64_clang15;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang15}"
SRC_URI[aarch64_clang15.sha256sum] = "d1455fd58341c4deed56f0edf022f3da13b31416145e71bebe34a4b0ddb83c05"

URI_aarch64_clang15-devel = "${EPEL_MIRROR}/aarch64/Packages/c/clang15-devel-15.0.7-9.el10_0.aarch64.rpm;name=aarch64_clang15-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang15-devel}"
SRC_URI[aarch64_clang15-devel.sha256sum] = "3b98f4cdc5af17a0c9a0dac5b1106d887abdb81b7b7107ee64d7734d1f5c572d"

URI_aarch64_clang15-libs = "${EPEL_MIRROR}/aarch64/Packages/c/clang15-libs-15.0.7-9.el10_0.aarch64.rpm;name=aarch64_clang15-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang15-libs}"
SRC_URI[aarch64_clang15-libs.sha256sum] = "2e47b463a890c4adbd4bbc11eb025df3b8aae7b86d4c3da6609d22b04804987c"

URI_aarch64_clang15-resource-filesystem = "${EPEL_MIRROR}/aarch64/Packages/c/clang15-resource-filesystem-15.0.7-9.el10_0.aarch64.rpm;name=aarch64_clang15-resource-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang15-resource-filesystem}"
SRC_URI[aarch64_clang15-resource-filesystem.sha256sum] = "0ebd4bccc8d30f2ab177d01950da600382cdac5f61616049fd2aa7cc7795febd"

RDEPENDS:clang15 = " \
 clang15-libs \
 gcc-c++ \
 glibc \
 libstdc++ \
 libstdc++-devel \
 llvm15-libs \
 "
RDEPENDS:clang15-devel = " \
 clang15 \
 clang15-libs \
 "
RDEPENDS:clang15-libs = " \
 clang15-resource-filesystem \
 glibc \
 libstdc++ \
 llvm15-libs \
 "
RDEPENDS:clang15-resource-filesystem = " \
 "
