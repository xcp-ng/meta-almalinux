# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-llvm-bitcode"
PV = "0.4.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-llvm-bitcode+default-devel \
 rust-llvm-bitcode-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-llvm-bitcode-0.4.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c034efb6f02e0ea20ea2ba10523ed1429953947f0d9f5ad9f8dc10ae6c7e87d"

URI_x86_64_v2_rust-llvm-bitcode+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-llvm-bitcode+default-devel-0.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-llvm-bitcode+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-llvm-bitcode+default-devel}"
SRC_URI[x86_64_v2_rust-llvm-bitcode+default-devel.sha256sum] = "f881065ec78f9f6f077eca34f675edf84f9b417ee2ac98c483dff403d0ba873b"

URI_x86_64_v2_rust-llvm-bitcode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-llvm-bitcode-devel-0.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-llvm-bitcode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-llvm-bitcode-devel}"
SRC_URI[x86_64_v2_rust-llvm-bitcode-devel.sha256sum] = "9bbc02466d1ecb11a6fb6a22170c506cae0342c14ae2d00bd5b7afd78a1166db"

URI_aarch64_rust-llvm-bitcode+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-llvm-bitcode+default-devel-0.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-llvm-bitcode+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-llvm-bitcode+default-devel}"
SRC_URI[aarch64_rust-llvm-bitcode+default-devel.sha256sum] = "8e879809e6a522a90d7961e502cb7ebac0814714e9c103f25db77828edef205c"

URI_aarch64_rust-llvm-bitcode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-llvm-bitcode-devel-0.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-llvm-bitcode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-llvm-bitcode-devel}"
SRC_URI[aarch64_rust-llvm-bitcode-devel.sha256sum] = "1e0ea3d4b2dc553105e2f126df4ff58d5affaa6b11ec99b9fde25759299ccbbc"

RDEPENDS:rust-llvm-bitcode+default-devel = " \
 cargo \
 rust-llvm-bitcode-devel \
 "
RDEPENDS:rust-llvm-bitcode-devel = " \
 cargo \
 rust-bitflags+std-devel \
 rust-bitflags-devel \
 rust-num_enum+default-devel \
 "
