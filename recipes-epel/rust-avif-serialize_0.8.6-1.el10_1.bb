# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-avif-serialize"
PV = "0.8.6"
PR = "1.el10_1"
PACKAGES = " \
 rust-avif-serialize+default-devel \
 rust-avif-serialize-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-avif-serialize-0.8.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "243d93bf807b51ad18645bdc07fa2491098fb87e0787fbc04651538057fc1c22"

URI_x86_64_v2_rust-avif-serialize+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-avif-serialize+default-devel-0.8.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-avif-serialize+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-avif-serialize+default-devel}"
SRC_URI[x86_64_v2_rust-avif-serialize+default-devel.sha256sum] = "24c910c4b615d0986c0aea78fa23642492e13e6cb59ce2ffd52614a7a328ce4e"

URI_x86_64_v2_rust-avif-serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-avif-serialize-devel-0.8.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-avif-serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-avif-serialize-devel}"
SRC_URI[x86_64_v2_rust-avif-serialize-devel.sha256sum] = "2c7bf85058564b6c777ad8df85e7e0d333bb676096b4fd22df89c93058721406"

URI_aarch64_rust-avif-serialize+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-avif-serialize+default-devel-0.8.6-1.el10_1.noarch.rpm;name=aarch64_rust-avif-serialize+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-avif-serialize+default-devel}"
SRC_URI[aarch64_rust-avif-serialize+default-devel.sha256sum] = "f4619c7fabd87ca88195081ded8bfebafae33fd4047d050252dbdd661271d83b"

URI_aarch64_rust-avif-serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-avif-serialize-devel-0.8.6-1.el10_1.noarch.rpm;name=aarch64_rust-avif-serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-avif-serialize-devel}"
SRC_URI[aarch64_rust-avif-serialize-devel.sha256sum] = "22041a9b3afa430cf45e6ac87862bec85f76910b4a4c12c59940bfd9f120839c"

RDEPENDS:rust-avif-serialize+default-devel = " \
 cargo \
 rust-avif-serialize-devel \
 "
RDEPENDS:rust-avif-serialize-devel = " \
 cargo \
 rust \
 rust-arrayvec+default-devel \
 "
