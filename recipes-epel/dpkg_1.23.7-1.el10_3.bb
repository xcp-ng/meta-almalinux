# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dpkg"
PV = "1.23.7"
PR = "1.el10_3"
PACKAGES = " \
 dpkg \
 dpkg-dev \
 dpkg-devel \
 dpkg-perl \
 dselect \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dpkg-1.23.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3226b774aa78017993d374734c43052941a28bd7de5696c6e6e049b0623fe49a"

URI_x86_64_v2_dpkg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dpkg-1.23.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dpkg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dpkg}"
SRC_URI[x86_64_v2_dpkg.sha256sum] = "ff7d05928f358c4460d3ebb292b7c758cc4f3769829d3e943add81a0e28e9971"

URI_x86_64_v2_dpkg-dev = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dpkg-dev-1.23.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_dpkg-dev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dpkg-dev}"
SRC_URI[x86_64_v2_dpkg-dev.sha256sum] = "6ff943e23112774fd9ebf28972115a70aa95505b1c2f48e47c920d17afae717f"

URI_x86_64_v2_dpkg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dpkg-devel-1.23.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dpkg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dpkg-devel}"
SRC_URI[x86_64_v2_dpkg-devel.sha256sum] = "fefaf0d0c6447f173b26cf769b950528f44f76637a1b04fca7750fc64f315a0d"

URI_x86_64_v2_dpkg-perl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dpkg-perl-1.23.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_dpkg-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dpkg-perl}"
SRC_URI[x86_64_v2_dpkg-perl.sha256sum] = "997cdfaf6e0af987d5810731fb66a0fbd22d347dcef6bec603f1702f93401f7a"

URI_x86_64_v2_dselect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dselect-1.23.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dselect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dselect}"
SRC_URI[x86_64_v2_dselect.sha256sum] = "daca9bac02c7792b859a0c46db5605c7c6fa3cae65b4931263ea1b9116095cfd"

URI_aarch64_dpkg = "${EPEL_MIRROR}/aarch64/Packages/d/dpkg-1.23.7-1.el10_3.aarch64.rpm;name=aarch64_dpkg;unpack=0"
SRC_URI:append = " ${URI_aarch64_dpkg}"
SRC_URI[aarch64_dpkg.sha256sum] = "ba98807cd7cf90fd13824227ab8df641510204b8f664927c13fb2950bddb7e91"

URI_aarch64_dpkg-dev = "${EPEL_MIRROR}/aarch64/Packages/d/dpkg-dev-1.23.7-1.el10_3.noarch.rpm;name=aarch64_dpkg-dev;unpack=0"
SRC_URI:append = " ${URI_aarch64_dpkg-dev}"
SRC_URI[aarch64_dpkg-dev.sha256sum] = "e0a34c3b16dae1cfb502448d2032d8b17bafa9481a9fca99378687b5ed47ba23"

URI_aarch64_dpkg-devel = "${EPEL_MIRROR}/aarch64/Packages/d/dpkg-devel-1.23.7-1.el10_3.aarch64.rpm;name=aarch64_dpkg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dpkg-devel}"
SRC_URI[aarch64_dpkg-devel.sha256sum] = "22cffc213f69b3bbd5411c6c12a11b84e70220810bbd8ea182132899e0ea87be"

URI_aarch64_dpkg-perl = "${EPEL_MIRROR}/aarch64/Packages/d/dpkg-perl-1.23.7-1.el10_3.noarch.rpm;name=aarch64_dpkg-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_dpkg-perl}"
SRC_URI[aarch64_dpkg-perl.sha256sum] = "37763e07ea954024d5416f3e8d7fd951813e9d7a89289d707988fd9576cc589c"

URI_aarch64_dselect = "${EPEL_MIRROR}/aarch64/Packages/d/dselect-1.23.7-1.el10_3.aarch64.rpm;name=aarch64_dselect;unpack=0"
SRC_URI:append = " ${URI_aarch64_dselect}"
SRC_URI[aarch64_dselect.sha256sum] = "50b104c096cc46b5b91cad09c74f65b6afe0871544f1054472688dc76eaddfa6"

RDEPENDS:dpkg = " \
 bash \
 bzip2-libs \
 glibc \
 libmd \
 libselinux \
 libzstd \
 tar \
 xz-libs \
 zlib-ng \
 "
RDEPENDS:dpkg-dev = " \
 binutils \
 bzip2 \
 dpkg-perl \
 gcc \
 make \
 patch \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-POSIX \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-constant \
 perl-interpreter \
 perl-libs \
 xz \
 xz-lzma-compat \
 zstd \
 "
RDEPENDS:dpkg-devel = " \
 pkgconf-pkg-config \
 "
RDEPENDS:dpkg-perl = " \
 dpkg \
 dpkg-perl \
 perl-Carp \
 perl-Digest \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-Digest-SHA1 \
 perl-Errno \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Compare \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-IO \
 perl-MIME-Base64 \
 perl-POSIX \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-Tie \
 perl-Time-HiRes \
 perl-Time-Piece \
 perl-TimeDate \
 perl-constant \
 perl-libs \
 perl-overload \
 perl-parent \
 "
RDEPENDS:dselect = " \
 bash \
 dpkg \
 dpkg-perl \
 dselect \
 glibc \
 libgcc \
 libstdc++ \
 ncurses-libs \
 perl-Carp \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Path \
 perl-interpreter \
 perl-libs \
 perl-overload \
 perl-parent \
 "
