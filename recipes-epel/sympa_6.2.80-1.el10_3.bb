# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sympa"
PV = "6.2.80"
PR = "1.el10_3"
PACKAGES = " \
 sympa \
 sympa-devel-doc \
 sympa-httpd \
 sympa-lighttpd \
 sympa-nginx \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/sympa-6.2.80-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "41121a99118c637f6362a6ae6122244afd74319530d209abd406f3fe65ce6b67"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sympa-6.2.80-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sympa;unpack=0"
SRC_URI[x86_64_v2_sympa.sha256sum] = "68a60eace0a3ed2873e299ef839a40f2b1d514b4769206feb941bad23b8db164"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sympa-devel-doc-6.2.80-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_sympa-devel-doc;unpack=0"
SRC_URI[x86_64_v2_sympa-devel-doc.sha256sum] = "17976444200dff701803e713ae73b543b5b6ac33bd677dbdd7546ca28ddb02ea"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sympa-httpd-6.2.80-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_sympa-httpd;unpack=0"
SRC_URI[x86_64_v2_sympa-httpd.sha256sum] = "207dda77491312b3499f7106cd3280fbd7be551968fd0709eaf250e1ed238ec7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sympa-lighttpd-6.2.80-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_sympa-lighttpd;unpack=0"
SRC_URI[x86_64_v2_sympa-lighttpd.sha256sum] = "97f1a6af5893f813123b69158a65cf2cb0dde62ee5b9801967f85e1a7f0bdc59"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sympa-nginx-6.2.80-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_sympa-nginx;unpack=0"
SRC_URI[x86_64_v2_sympa-nginx.sha256sum] = "2ca86b066ab1a56076dd8acb68bc84ff9480065a993da4e6c1135b69e94692cd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sympa-6.2.80-1.el10_3.aarch64.rpm;name=aarch64_sympa;unpack=0"
SRC_URI[aarch64_sympa.sha256sum] = "ca22c601f2dbe0f3c2090df4bcdbf78fd7a0996b96c74d6534998aadd0dc6369"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sympa-devel-doc-6.2.80-1.el10_3.noarch.rpm;name=aarch64_sympa-devel-doc;unpack=0"
SRC_URI[aarch64_sympa-devel-doc.sha256sum] = "d293b55185a61dea9791fc3fc2d8f44a15d7f15bcf7cabbad5ed9104b0a19a6c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sympa-httpd-6.2.80-1.el10_3.noarch.rpm;name=aarch64_sympa-httpd;unpack=0"
SRC_URI[aarch64_sympa-httpd.sha256sum] = "e53357079e85cb1dd5c36506f39370fe8e0d9dfe4df1edf091075663593e7e8f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sympa-lighttpd-6.2.80-1.el10_3.noarch.rpm;name=aarch64_sympa-lighttpd;unpack=0"
SRC_URI[aarch64_sympa-lighttpd.sha256sum] = "8b5be49d0178b4d182f2a2f1701f1a753050e8949bb84bfd3e5d7efd049bd38f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sympa-nginx-6.2.80-1.el10_3.noarch.rpm;name=aarch64_sympa-nginx;unpack=0"
SRC_URI[aarch64_sympa-nginx.sha256sum] = "b247014faafd0364b673f2bae732cfd73355082af9606c436e5aafa6a1c6c2d7"

RDEPENDS:sympa = " \
 bash \
 glibc \
 js-jquery \
 js-jquery-ui \
 logrotate \
 mhonarc \
 perl-Archive-Zip-SimpleZip \
 perl-AuthCAS \
 perl-CGI \
 perl-CGI-Fast \
 perl-Carp \
 perl-Class-Singleton \
 perl-Clone \
 perl-Crypt-CipherSaber \
 perl-Crypt-Eksblowfish \
 perl-Crypt-OpenSSL-X509 \
 perl-Crypt-SMIME \
 perl-DBD-CSV \
 perl-DBD-MySQL \
 perl-DBI \
 perl-Data-Dumper \
 perl-Data-Password \
 perl-DateTime \
 perl-DateTime-Format-Mail \
 perl-DateTime-TimeZone \
 perl-Digest-MD5 \
 perl-Encode \
 perl-Encode-EUCJPASCII \
 perl-Encode-HanExtra \
 perl-Encode-Locale \
 perl-English \
 perl-FCGI \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Copy-Recursive \
 perl-File-Find \
 perl-File-NFSLock \
 perl-File-Path \
 perl-Getopt-Long \
 perl-HTML-Formatter \
 perl-HTML-Parser \
 perl-HTML-StripScripts-Parser \
 perl-HTML-Tree \
 perl-HTTP-Cookies \
 perl-HTTP-Message \
 perl-IO \
 perl-IO-Socket-IP \
 perl-IO-Socket-SSL \
 perl-IO-stringy \
 perl-LDAP \
 perl-LWP-Protocol-https \
 perl-MIME-Base64 \
 perl-MIME-Charset \
 perl-MIME-EncWords \
 perl-MIME-Lite-HTML \
 perl-MIME-tools \
 perl-Mail-DKIM \
 perl-MailTools \
 perl-Net-CIDR \
 perl-Net-DNS \
 perl-POSIX \
 perl-PathTools \
 perl-Pod-Usage \
 perl-SOAP-Lite \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-Sys-Hostname \
 perl-Sys-Syslog \
 perl-Template-Toolkit \
 perl-Term-ProgressBar \
 perl-Time-HiRes \
 perl-Time-Local \
 perl-URI \
 perl-URI-Find \
 perl-Unicode-LineBreak \
 perl-Unicode-Normalize \
 perl-Unicode-UTF8 \
 perl-XML-LibXML \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-lib \
 perl-libintl-perl \
 perl-libnet \
 perl-libs \
 perl-libwww-perl \
 perl-parent \
 shadow-utils \
 sympa \
 systemd \
 virtual/smtpdaemon \
 "
RDEPENDS:sympa-devel-doc = " \
 sympa \
 "
RDEPENDS:sympa-httpd = " \
 bash \
 httpd \
 multiwatch \
 sympa \
 "
RDEPENDS:sympa-lighttpd = " \
 lighttpd \
 lighttpd-fastcgi \
 sympa \
 "
RDEPENDS:sympa-nginx = " \
 bash \
 multiwatch \
 nginx \
 sympa \
 "
