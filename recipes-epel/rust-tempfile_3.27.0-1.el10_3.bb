# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tempfile"
PV = "3.27.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-tempfile+default-devel \
 rust-tempfile+getrandom-devel \
 rust-tempfile+nightly-devel \
 rust-tempfile-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tempfile-3.27.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e1be361a35e57975a5283dd4a3a3dfc75291cf5af8648e83e3c7a179c0d3354"

URI_x86_64_v2_rust-tempfile+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tempfile+default-devel-3.27.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tempfile+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tempfile+default-devel}"
SRC_URI[x86_64_v2_rust-tempfile+default-devel.sha256sum] = "30a8714ecd457c801cceb219f89aa89d119cec9711a7a0ec79ff73f27d2e7a03"

URI_x86_64_v2_rust-tempfile+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tempfile+getrandom-devel-3.27.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tempfile+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tempfile+getrandom-devel}"
SRC_URI[x86_64_v2_rust-tempfile+getrandom-devel.sha256sum] = "516b4b3f8a57aebcdc2206e298c8e1c52c4b4b90e0aed1c3b72b55e2f7269d6a"

URI_x86_64_v2_rust-tempfile+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tempfile+nightly-devel-3.27.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tempfile+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tempfile+nightly-devel}"
SRC_URI[x86_64_v2_rust-tempfile+nightly-devel.sha256sum] = "4f36b75341fae5a29993bc7aa2e9f45c8dffc80a186f9723d6399e0871201b1b"

URI_x86_64_v2_rust-tempfile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tempfile-devel-3.27.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tempfile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tempfile-devel}"
SRC_URI[x86_64_v2_rust-tempfile-devel.sha256sum] = "c9316564a0883e54217a8bf7d1dd2f2da46b4fc035b913aa591a39086d07f7a8"

URI_aarch64_rust-tempfile+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tempfile+default-devel-3.27.0-1.el10_3.noarch.rpm;name=aarch64_rust-tempfile+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tempfile+default-devel}"
SRC_URI[aarch64_rust-tempfile+default-devel.sha256sum] = "87f52bdca3cbc5f5a6abad72f761491a775015f432981ec16383329a9b7de40b"

URI_aarch64_rust-tempfile+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tempfile+getrandom-devel-3.27.0-1.el10_3.noarch.rpm;name=aarch64_rust-tempfile+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tempfile+getrandom-devel}"
SRC_URI[aarch64_rust-tempfile+getrandom-devel.sha256sum] = "1ef7eeeb93070bd76107610c97055218ac98f33b8f31f804696e9b1de928a963"

URI_aarch64_rust-tempfile+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tempfile+nightly-devel-3.27.0-1.el10_3.noarch.rpm;name=aarch64_rust-tempfile+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tempfile+nightly-devel}"
SRC_URI[aarch64_rust-tempfile+nightly-devel.sha256sum] = "1da89e341fd2c1b8793aa8da53d9c27c7d97f3e8021936a0b4eefd0c70eaea3e"

URI_aarch64_rust-tempfile-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tempfile-devel-3.27.0-1.el10_3.noarch.rpm;name=aarch64_rust-tempfile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tempfile-devel}"
SRC_URI[aarch64_rust-tempfile-devel.sha256sum] = "01f512f5f3755836a807c65f974050e4049d6b9c0a5cea7da5fbdfaa27ae33b1"

RDEPENDS:rust-tempfile+default-devel = " \
 cargo \
 rust-tempfile+getrandom-devel \
 rust-tempfile-devel \
 "
RDEPENDS:rust-tempfile+getrandom-devel = " \
 cargo \
 rust-tempfile-devel \
 virtual/crate_getrandom__ge_0.3.0_with_crate_getrandom__lt_0.5.0~ \
 "
RDEPENDS:rust-tempfile+nightly-devel = " \
 cargo \
 rust-tempfile-devel \
 "
RDEPENDS:rust-tempfile-devel = " \
 cargo \
 rust \
 rust-fastrand+default-devel \
 rust-once_cell+std-devel \
 rust-once_cell-devel \
 rust-rustix+default-devel \
 rust-rustix+fs-devel \
 "
