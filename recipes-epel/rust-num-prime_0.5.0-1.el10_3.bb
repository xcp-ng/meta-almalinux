# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num-prime"
PV = "0.5.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-num-prime+big-int-devel \
 rust-num-prime+big-table-devel \
 rust-num-prime+default-devel \
 rust-num-prime+num-bigint-devel \
 rust-num-prime-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-num-prime-0.5.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f8ddda8a8caee451eff139fe76f6e9be5e630bdb24f342227d6f3d38d0b1298"

URI_x86_64_v2_rust-num-prime+big-int-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-prime+big-int-devel-0.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-prime+big-int-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-prime+big-int-devel}"
SRC_URI[x86_64_v2_rust-num-prime+big-int-devel.sha256sum] = "55cf232f4c491091562fec5d1bf10de36693aaf14ab94d424d6752ec5faafdd1"

URI_x86_64_v2_rust-num-prime+big-table-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-prime+big-table-devel-0.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-prime+big-table-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-prime+big-table-devel}"
SRC_URI[x86_64_v2_rust-num-prime+big-table-devel.sha256sum] = "5823adb6c5d906caf128c956a10afe16d268f515212c2a204b3b44a09bcca2fd"

URI_x86_64_v2_rust-num-prime+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-prime+default-devel-0.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-prime+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-prime+default-devel}"
SRC_URI[x86_64_v2_rust-num-prime+default-devel.sha256sum] = "c99498b4e998eea40bd52928e4a0ea504d523f14edbde8c3f06764d823c35bcc"

URI_x86_64_v2_rust-num-prime+num-bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-prime+num-bigint-devel-0.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-prime+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-prime+num-bigint-devel}"
SRC_URI[x86_64_v2_rust-num-prime+num-bigint-devel.sha256sum] = "aaa122d8da9fc3c74dda5b3cc54e396fd6027f2ab080e682b270a297e9f58767"

URI_x86_64_v2_rust-num-prime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-prime-devel-0.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-prime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-prime-devel}"
SRC_URI[x86_64_v2_rust-num-prime-devel.sha256sum] = "cb4ef636424a38829458232ee3637d64f223bd1e3d856cc50dfbf875d6d108fd"

URI_aarch64_rust-num-prime+big-int-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-prime+big-int-devel-0.5.0-1.el10_3.noarch.rpm;name=aarch64_rust-num-prime+big-int-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-prime+big-int-devel}"
SRC_URI[aarch64_rust-num-prime+big-int-devel.sha256sum] = "6709761e85931eeaaacbcb81ab24599cc8a208c074ab5f2ac8a48d9fbf886691"

URI_aarch64_rust-num-prime+big-table-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-prime+big-table-devel-0.5.0-1.el10_3.noarch.rpm;name=aarch64_rust-num-prime+big-table-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-prime+big-table-devel}"
SRC_URI[aarch64_rust-num-prime+big-table-devel.sha256sum] = "f309b9cb0bed05bceea5a56611e89e275e5feb21484588784d6e2bfa0f116bb4"

URI_aarch64_rust-num-prime+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-prime+default-devel-0.5.0-1.el10_3.noarch.rpm;name=aarch64_rust-num-prime+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-prime+default-devel}"
SRC_URI[aarch64_rust-num-prime+default-devel.sha256sum] = "6ec003ec33cfd43b72c6ac14db2be4e0a11b7586f8b3a937b3ce89765cdbc029"

URI_aarch64_rust-num-prime+num-bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-prime+num-bigint-devel-0.5.0-1.el10_3.noarch.rpm;name=aarch64_rust-num-prime+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-prime+num-bigint-devel}"
SRC_URI[aarch64_rust-num-prime+num-bigint-devel.sha256sum] = "c391d18ffcf5b3dd3ac26f718280deedc5d0e73c2bfa00a561050aa5d718c282"

URI_aarch64_rust-num-prime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-prime-devel-0.5.0-1.el10_3.noarch.rpm;name=aarch64_rust-num-prime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-prime-devel}"
SRC_URI[aarch64_rust-num-prime-devel.sha256sum] = "d29793a7932cf56bda11addbd477260d8a0bdb666d8b75725e790b1491327275"

RDEPENDS:rust-num-prime+big-int-devel = " \
 cargo \
 rust-num-modular+num-bigint-devel \
 rust-num-modular+num-integer-devel \
 rust-num-modular+num-traits-devel \
 rust-num-prime+num-bigint-devel \
 rust-num-prime-devel \
 "
RDEPENDS:rust-num-prime+big-table-devel = " \
 cargo \
 rust-num-prime-devel \
 "
RDEPENDS:rust-num-prime+default-devel = " \
 cargo \
 rust-num-prime+big-int-devel \
 rust-num-prime+big-table-devel \
 rust-num-prime-devel \
 "
RDEPENDS:rust-num-prime+num-bigint-devel = " \
 cargo \
 rust-num-bigint+default-devel \
 rust-num-bigint+rand-devel \
 rust-num-prime-devel \
 "
RDEPENDS:rust-num-prime-devel = " \
 bash \
 cargo \
 rust \
 rust-bitvec+default-devel \
 rust-either+default-devel \
 rust-lru+default-devel \
 rust-num-integer+default-devel \
 rust-num-modular+default-devel \
 rust-num-traits+default-devel \
 rust-rand0.8+default-devel \
 "
