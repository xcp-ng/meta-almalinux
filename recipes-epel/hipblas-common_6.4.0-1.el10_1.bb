# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hipblas-common"
PV = "6.4.0"
PR = "1.el10_1"
PACKAGES:x86_64_v2 = " \
 hipblas-common-devel \
"
PACKAGES:aarch64 = " \
  \
"

SRC_URI = "${EPELSRC_MIRROR}/Packages/h/hipblas-common-6.4.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1d4c360ec3cae2e8f9f0856b4a9e85ba7763e73773c09799586701490eb4285c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipblas-common-devel-6.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_hipblas-common-devel;unpack=0"
SRC_URI[x86_64_v2_hipblas-common-devel.sha256sum] = "e865e934e43a921b723c49425b3908e4303f4f9c5cf8d0ad56df88f1eec9435d"

RDEPENDS:hipblas-common-devel = " \
 cmake-filesystem \
 "
