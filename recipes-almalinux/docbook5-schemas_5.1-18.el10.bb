# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "docbook5-schemas"
PV = "5.1"
PR = "18.el10"
PACKAGES = " \
 docbook5-schemas \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/docbook5-schemas-5.1-18.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa2a17bec5e4ff96a148d039d10948c2135d9604201cae7970fbf212bc20c93a"

URI_x86_64_v2_docbook5-schemas = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/docbook5-schemas-5.1-18.el10.noarch.rpm;name=x86_64_v2_docbook5-schemas;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_docbook5-schemas}"
SRC_URI[x86_64_v2_docbook5-schemas.sha256sum] = "8e885c89e6d925fa024a5e0236cb94adb3b068975bdb3e4fd804a4e67a9cfdd9"

URI_aarch64_docbook5-schemas = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/docbook5-schemas-5.1-18.el10.noarch.rpm;name=aarch64_docbook5-schemas;unpack=0"
SRC_URI:append = " ${URI_aarch64_docbook5-schemas}"
SRC_URI[aarch64_docbook5-schemas.sha256sum] = "8e885c89e6d925fa024a5e0236cb94adb3b068975bdb3e4fd804a4e67a9cfdd9"

RDEPENDS:docbook5-schemas = " \
 bash \
 libxml2 \
 xml-common \
 "
