# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-boolean.py"
PV = "4.0"
PR = "12.el10_0"
PACKAGES = " \
 python3-boolean.py \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-boolean.py-4.0-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a1bafadc6d6d2248a96be3b2afe449a7b6edb032ea0d5d134c4ae271ee93d73c"

URI_x86_64_v2_python3-boolean.py = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-boolean.py-4.0-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-boolean.py;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-boolean.py}"
SRC_URI[x86_64_v2_python3-boolean.py.sha256sum] = "ca2de548fc3f888583b698b9fa1618fcfaded67d7b513d3050d3e853a3b05e53"

URI_aarch64_python3-boolean.py = "${EPEL_MIRROR}/aarch64/Packages/p/python3-boolean.py-4.0-12.el10_0.noarch.rpm;name=aarch64_python3-boolean.py;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-boolean.py}"
SRC_URI[aarch64_python3-boolean.py.sha256sum] = "1701dd50c83f92bf692f1c161c64c4879ed49f315026e33576d64c2e68de68b2"

RDEPENDS:python3-boolean.py = " \
 python3 \
 "
