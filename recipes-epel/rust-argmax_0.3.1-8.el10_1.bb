# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-argmax"
PV = "0.3.1"
PR = "8.el10_1"
PACKAGES = " \
 rust-argmax+default-devel \
 rust-argmax-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-argmax-0.3.1-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25dc143abbf1b98ec6e67432ef8e9e7f06fb4c1b8e7f796c6579f2304552f047"

URI_x86_64_v2_rust-argmax+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argmax+default-devel-0.3.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argmax+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argmax+default-devel}"
SRC_URI[x86_64_v2_rust-argmax+default-devel.sha256sum] = "cc09949f2fae817eac1044a16fdc22150e7449cb25b583f77be38b89388dec9c"

URI_x86_64_v2_rust-argmax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argmax-devel-0.3.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argmax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argmax-devel}"
SRC_URI[x86_64_v2_rust-argmax-devel.sha256sum] = "e21dadcdce54790b343bb4c340535fc9ac386fd4e3f0bb525cb824790986e2a2"

URI_aarch64_rust-argmax+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argmax+default-devel-0.3.1-8.el10_1.noarch.rpm;name=aarch64_rust-argmax+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argmax+default-devel}"
SRC_URI[aarch64_rust-argmax+default-devel.sha256sum] = "262940cec80ad978bc7369bb17dd7e275242c3002cd84df3366518989519b2c1"

URI_aarch64_rust-argmax-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argmax-devel-0.3.1-8.el10_1.noarch.rpm;name=aarch64_rust-argmax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argmax-devel}"
SRC_URI[aarch64_rust-argmax-devel.sha256sum] = "876b6ba0b31d86dabe4b68e17aa1095270385b694472e996e45f12cc91111b0c"

RDEPENDS:rust-argmax+default-devel = " \
 cargo \
 rust-argmax-devel \
 "
RDEPENDS:rust-argmax-devel = " \
 cargo \
 rust-lazy_static+default-devel \
 rust-libc+default-devel \
 virtual/crate_nix/feature__ge_0.24.2_with_crate_nix/feature__lt_0.30.0~ \
 virtual/crate_nix__ge_0.24.2_with_crate_nix__lt_0.30.0~ \
 "
