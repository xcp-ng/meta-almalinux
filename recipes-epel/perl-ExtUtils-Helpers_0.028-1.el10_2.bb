# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-ExtUtils-Helpers"
PV = "0.028"
PR = "1.el10_2"
PACKAGES = " \
 perl-ExtUtils-Helpers \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-ExtUtils-Helpers-0.028-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "17bbe67ddfcf4d3e1dd4f8b55f997e527885e26309f3e2d47e67b5e03c7015db"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-ExtUtils-Helpers-0.028-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-ExtUtils-Helpers;unpack=0"
SRC_URI[x86_64_v2_perl-ExtUtils-Helpers.sha256sum] = "480b0559d0349c09949d329ee175f395942f9d2a5129c6d1c315d7b6001cded8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-ExtUtils-Helpers-0.028-1.el10_2.noarch.rpm;name=aarch64_perl-ExtUtils-Helpers;unpack=0"
SRC_URI[aarch64_perl-ExtUtils-Helpers.sha256sum] = "1e454c5b1605304a1cc57ecd635be4bfbfdbfc7c11ba472b4fd7966805625d6d"

RDEPENDS:perl-ExtUtils-Helpers = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Basename \
 perl-PathTools \
 perl-Text-ParseWords \
 perl-libs \
 "
