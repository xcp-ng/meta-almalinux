# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ibus-libpinyin"
PV = "1.15.7"
PR = "3.el10"
PACKAGES = " \
 ibus-libpinyin \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ibus-libpinyin-1.15.7-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4d647abcba9b4ebc0e1350cc7b194b19822bd6ff33987b2ea236a0b6f9b84b30"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-libpinyin-1.15.7-3.el10.x86_64_v2.rpm;name=x86_64_v2_ibus-libpinyin;unpack=0"
SRC_URI[x86_64_v2_ibus-libpinyin.sha256sum] = "9151a9e579e32daecd7f5ef6c29964e9139e8729813e2335bc8744dd7f0e6fb3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-libpinyin-1.15.7-3.el10.aarch64.rpm;name=aarch64_ibus-libpinyin;unpack=0"
SRC_URI[aarch64_ibus-libpinyin.sha256sum] = "0b5b12c347cdd503a48af5d813cf7f111274d1a9b64bd8732ca1ecf53ad02e28"

RDEPENDS:ibus-libpinyin = " \
 bash \
 glib2 \
 glibc \
 ibus \
 ibus-libs \
 libgcc \
 libpinyin \
 libpinyin-data \
 libstdc++ \
 lua-libs \
 python3-gobject \
 sqlite-libs \
 "
