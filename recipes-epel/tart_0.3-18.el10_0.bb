# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tart"
PV = "0.3"
PR = "18.el10_0"
PACKAGES = " \
 ghc-tart \
 ghc-tart-devel \
 ghc-tart-doc \
 ghc-tart-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tart-0.3-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f39e78f7dfd19f3d2007390dc860e80c185fac097e1af165b015d10101d539a"

URI_x86_64_v2_ghc-tart = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tart-0.3-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tart}"
SRC_URI[x86_64_v2_ghc-tart.sha256sum] = "171be00083f9d7b9b27ee4abd75930c27e047ee551ddb77f8173e348bcb1c751"

URI_x86_64_v2_ghc-tart-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tart-devel-0.3-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tart-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tart-devel}"
SRC_URI[x86_64_v2_ghc-tart-devel.sha256sum] = "b2ce03beec7373409aada594bf48ca8c82634f175d2fe0c43e7520c9a6d95729"

URI_x86_64_v2_ghc-tart-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tart-doc-0.3-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-tart-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tart-doc}"
SRC_URI[x86_64_v2_ghc-tart-doc.sha256sum] = "71374a87e30c691004e61b39df81fb62906748d08d7595bd2c4953b5aeac22c2"

URI_x86_64_v2_ghc-tart-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tart-prof-0.3-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tart-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tart-prof}"
SRC_URI[x86_64_v2_ghc-tart-prof.sha256sum] = "38cfb47f6fc56b293771b874eb943517763ce396d896d7e994ab817b0f186c5c"

URI_aarch64_ghc-tart = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tart-0.3-18.el10_0.aarch64.rpm;name=aarch64_ghc-tart;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tart}"
SRC_URI[aarch64_ghc-tart.sha256sum] = "44f72e0ebb0069198882e7068867f65b0fd9500cb22904fd4285917d5ad5f558"

URI_aarch64_ghc-tart-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tart-devel-0.3-18.el10_0.aarch64.rpm;name=aarch64_ghc-tart-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tart-devel}"
SRC_URI[aarch64_ghc-tart-devel.sha256sum] = "f3069cbd003b9869da1ea7a1271f3614f3217522dd41c05617adc3b2f0c6067c"

URI_aarch64_ghc-tart-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tart-doc-0.3-18.el10_0.noarch.rpm;name=aarch64_ghc-tart-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tart-doc}"
SRC_URI[aarch64_ghc-tart-doc.sha256sum] = "56c03aed2b2bca904dc07dcbfd23de350f919dc31dd3848496673273ca949b9f"

URI_aarch64_ghc-tart-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tart-prof-0.3-18.el10_0.aarch64.rpm;name=aarch64_ghc-tart-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tart-prof}"
SRC_URI[aarch64_ghc-tart-prof.sha256sum] = "91f6b3a48baefe10f57efc325f0beccd3a2025e41d9921b2a5972b27072f8c7d"

RDEPENDS:ghc-tart = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-blaze-builder \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-microlens \
 ghc-microlens-ghc \
 ghc-microlens-mtl \
 ghc-microlens-platform \
 ghc-microlens-th \
 ghc-mtl \
 ghc-os-string \
 ghc-parsec \
 ghc-pretty \
 ghc-primitive \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-th-abstraction \
 ghc-time \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unordered-containers \
 ghc-utf8-string \
 ghc-vector \
 ghc-vector-stream \
 ghc-vty \
 glibc \
 gmp \
 "
RDEPENDS:ghc-tart-devel = " \
 ghc-array-devel \
 ghc-base-devel \
 ghc-binary-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-microlens-platform-devel \
 ghc-mtl-devel \
 ghc-tart \
 ghc-text-devel \
 ghc-vty-devel \
 "
RDEPENDS:ghc-tart-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-tart-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-binary-prof \
 ghc-bytestring-prof \
 ghc-microlens-platform-prof \
 ghc-mtl-prof \
 ghc-tart-devel \
 ghc-text-prof \
 ghc-vty-prof \
 "
