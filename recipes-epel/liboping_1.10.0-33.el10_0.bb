# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "liboping"
PV = "1.10.0"
PR = "33.el10_0"
PACKAGES = " \
 liboping \
 liboping-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/liboping-1.10.0-33.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f75f416ae97f94918f974b374980fee2903691cae6f19bb14b47c40e06d4995"

URI_x86_64_v2_liboping = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liboping-1.10.0-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liboping;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liboping}"
SRC_URI[x86_64_v2_liboping.sha256sum] = "40ba4fc341cf4c6acae2b12508b22c6b112a9f81cfa6800c286ddf9807b4a9d2"

URI_x86_64_v2_liboping-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liboping-devel-1.10.0-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liboping-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liboping-devel}"
SRC_URI[x86_64_v2_liboping-devel.sha256sum] = "313a98289b81757778d986b45ff111faf5c50b6867185dba1ffc94b4b4dbba53"

URI_aarch64_liboping = "${EPEL_MIRROR}/aarch64/Packages/l/liboping-1.10.0-33.el10_0.aarch64.rpm;name=aarch64_liboping;unpack=0"
SRC_URI:append = " ${URI_aarch64_liboping}"
SRC_URI[aarch64_liboping.sha256sum] = "08450dcf1981630e6a62f9456c846e9054fc1ef76083d08faa8668a25206737f"

URI_aarch64_liboping-devel = "${EPEL_MIRROR}/aarch64/Packages/l/liboping-devel-1.10.0-33.el10_0.aarch64.rpm;name=aarch64_liboping-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_liboping-devel}"
SRC_URI[aarch64_liboping-devel.sha256sum] = "65c7b72351b332758b89f0d619f804b60513c29005152710d914c9efa521a3b0"

RDEPENDS:liboping = " \
 glibc \
 ncurses-libs \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:liboping-devel = " \
 liboping \
 pkgconf-pkg-config \
 "
