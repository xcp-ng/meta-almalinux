# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hashbag"
PV = "0.1.13"
PR = "1.el10_3"
PACKAGES = " \
 rust-hashbag+amortize-devel \
 rust-hashbag+default-devel \
 rust-hashbag+griddle-devel \
 rust-hashbag+serde-devel \
 rust-hashbag-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-hashbag-0.1.13-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "85fdf32f4e2554ab61bf78b8dd163376151760dfdcd4c77eb5929c6528c815e4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbag+amortize-devel-0.1.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbag+amortize-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hashbag+amortize-devel.sha256sum] = "259259b69bd3fe9553015ab4cdfa71531d8c6e31b90f40ccf3a4eed550994d5c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbag+default-devel-0.1.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbag+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hashbag+default-devel.sha256sum] = "6fec7ac0f9137b3374c3d612bfedd3c851915e134beb43b30d9625a63b79e96a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbag+griddle-devel-0.1.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbag+griddle-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hashbag+griddle-devel.sha256sum] = "ddac93230264cf47007f35322d34d294fdf957c83502000126b280263baf8625"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbag+serde-devel-0.1.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbag+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hashbag+serde-devel.sha256sum] = "bb4585a8c6c11f1cd5271cac5091405b46eeeb77c4da449abb74b7e867bd83b2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbag-devel-0.1.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbag-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hashbag-devel.sha256sum] = "a114266ac503487725b47126e4b611ff5abdbcb91a6048e1525ea53e20700438"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbag+amortize-devel-0.1.13-1.el10_3.noarch.rpm;name=aarch64_rust-hashbag+amortize-devel;unpack=0"
SRC_URI[aarch64_rust-hashbag+amortize-devel.sha256sum] = "65ecae2766ac164c2dba36e5ce2c0c3495680708f1944e00dc9dd5f96dc76131"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbag+default-devel-0.1.13-1.el10_3.noarch.rpm;name=aarch64_rust-hashbag+default-devel;unpack=0"
SRC_URI[aarch64_rust-hashbag+default-devel.sha256sum] = "395792921242d77c69776f21b75834ae0da9f6e90e47659f52205087bb8af1a4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbag+griddle-devel-0.1.13-1.el10_3.noarch.rpm;name=aarch64_rust-hashbag+griddle-devel;unpack=0"
SRC_URI[aarch64_rust-hashbag+griddle-devel.sha256sum] = "d102ee2f7dbb7a5c71d7900d55124d87330902f22a2d029886973252d32f8574"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbag+serde-devel-0.1.13-1.el10_3.noarch.rpm;name=aarch64_rust-hashbag+serde-devel;unpack=0"
SRC_URI[aarch64_rust-hashbag+serde-devel.sha256sum] = "19bf53f6a7bdeb1c86c3008cb98f364373c8ecdea11e92d4f48da2c8fa367275"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbag-devel-0.1.13-1.el10_3.noarch.rpm;name=aarch64_rust-hashbag-devel;unpack=0"
SRC_URI[aarch64_rust-hashbag-devel.sha256sum] = "6184e49aa05208bfd95da62695cb5cfafcbb01493cd9de5bd926e330e4995d61"

RDEPENDS:rust-hashbag+amortize-devel = " \
 cargo \
 rust-hashbag+griddle-devel \
 rust-hashbag-devel \
 "
RDEPENDS:rust-hashbag+default-devel = " \
 cargo \
 rust-hashbag-devel \
 "
RDEPENDS:rust-hashbag+griddle-devel = " \
 cargo \
 rust-griddle+default-devel \
 rust-hashbag-devel \
 "
RDEPENDS:rust-hashbag+serde-devel = " \
 cargo \
 rust-hashbag-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-hashbag-devel = " \
 cargo \
 "
