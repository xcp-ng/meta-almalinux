# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bincode1"
PV = "1.3.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-bincode1+default-devel \
 rust-bincode1+i128-devel \
 rust-bincode1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bincode1-1.3.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "95b573da74b7339fc8be1b571eea266b3f5f54430e8e30b846ea4de1111341c4"

URI_x86_64_v2_rust-bincode1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bincode1+default-devel-1.3.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bincode1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bincode1+default-devel}"
SRC_URI[x86_64_v2_rust-bincode1+default-devel.sha256sum] = "96589990730af3111c9ff7b17826b5dc6dca466e2da493b40bdedee8c9e9ce5d"

URI_x86_64_v2_rust-bincode1+i128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bincode1+i128-devel-1.3.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bincode1+i128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bincode1+i128-devel}"
SRC_URI[x86_64_v2_rust-bincode1+i128-devel.sha256sum] = "1a5ef1b2bb817b8f41dad0a0b2a48f3645033ba02f84c0a1783bbf32082810e1"

URI_x86_64_v2_rust-bincode1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bincode1-devel-1.3.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bincode1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bincode1-devel}"
SRC_URI[x86_64_v2_rust-bincode1-devel.sha256sum] = "83d971466754456ba4551aceb19315320fea1229073947bb28050082a51ed2f9"

URI_aarch64_rust-bincode1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bincode1+default-devel-1.3.3-1.el10_1.noarch.rpm;name=aarch64_rust-bincode1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bincode1+default-devel}"
SRC_URI[aarch64_rust-bincode1+default-devel.sha256sum] = "d80c83bb169278b7bf38ea4d33940119e525c2cec4fa75e46f0726294ea057bb"

URI_aarch64_rust-bincode1+i128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bincode1+i128-devel-1.3.3-1.el10_1.noarch.rpm;name=aarch64_rust-bincode1+i128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bincode1+i128-devel}"
SRC_URI[aarch64_rust-bincode1+i128-devel.sha256sum] = "53624af7dc603abea88111b28186fc3801f51b348d15411d89365a28001c8344"

URI_aarch64_rust-bincode1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bincode1-devel-1.3.3-1.el10_1.noarch.rpm;name=aarch64_rust-bincode1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bincode1-devel}"
SRC_URI[aarch64_rust-bincode1-devel.sha256sum] = "b4151fd2943603cd4d7ccd807906510ae6a5f68ac616fad6884869a2b8213f36"

RDEPENDS:rust-bincode1+default-devel = " \
 cargo \
 rust-bincode1-devel \
 "
RDEPENDS:rust-bincode1+i128-devel = " \
 cargo \
 rust-bincode1-devel \
 "
RDEPENDS:rust-bincode1-devel = " \
 cargo \
 rust-serde+default-devel \
 "
