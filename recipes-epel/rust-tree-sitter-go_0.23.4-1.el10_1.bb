# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-go"
PV = "0.23.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-tree-sitter-go+default-devel \
 rust-tree-sitter-go-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-go-0.23.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab4d6c04edd130f20f647aab6dfff8d94ac912cdaa29cb3da0913e0f9dc22c79"

URI_x86_64_v2_rust-tree-sitter-go+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-go+default-devel-0.23.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-go+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-go+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-go+default-devel.sha256sum] = "2967de979ab33f6764c8693de94eefb99328b0dc10f35b7c3f024733f8b50c7c"

URI_x86_64_v2_rust-tree-sitter-go-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-go-devel-0.23.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-go-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-go-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-go-devel.sha256sum] = "97cbf2bfe61ddd33ff76492b30cfd7ef46e93da071c728921f7231be8db8bd94"

URI_aarch64_rust-tree-sitter-go+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-go+default-devel-0.23.4-1.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-go+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-go+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-go+default-devel.sha256sum] = "f8208fe440223b87292bb8a5debfa1dde063c52fa0e84e2fc37868d6726f5af3"

URI_aarch64_rust-tree-sitter-go-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-go-devel-0.23.4-1.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-go-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-go-devel}"
SRC_URI[aarch64_rust-tree-sitter-go-devel.sha256sum] = "e539464222bbc2d70b594f835eac080bb5f36fe82d76c38b3e5d6adda988a4d5"

RDEPENDS:rust-tree-sitter-go+default-devel = " \
 cargo \
 rust-tree-sitter-go-devel \
 "
RDEPENDS:rust-tree-sitter-go-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
