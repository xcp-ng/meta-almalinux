# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "scdoc"
PV = "1.11.3"
PR = "2.el10_0"
PACKAGES = " \
 scdoc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/scdoc-1.11.3-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "39a4dfefd476c12fde0e22fb1795b7d22977778e7203fbc8324ffd7fe6639b42"

URI_x86_64_v2_scdoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scdoc-1.11.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scdoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scdoc}"
SRC_URI[x86_64_v2_scdoc.sha256sum] = "abfcfe097cd3e359725cb3eee8faf204a0c3e08aa86d75854a39a2c5350af4d5"

URI_aarch64_scdoc = "${EPEL_MIRROR}/aarch64/Packages/s/scdoc-1.11.3-2.el10_0.aarch64.rpm;name=aarch64_scdoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_scdoc}"
SRC_URI[aarch64_scdoc.sha256sum] = "4645266e582e30ff0cfac9138afa37de4bcad4691a8add58723f1e9e7ac059f5"

RDEPENDS:scdoc = " \
 glibc \
 pkgconf-pkg-config \
 "
