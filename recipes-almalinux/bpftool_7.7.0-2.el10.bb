# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bpftool"
PV = "7.7.0"
PR = "2.el10"
PACKAGES = " \
 bpftool \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/bpftool-7.7.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec5c1e72c1fe2a90d0d0486626810f0e782196e2fa2f405f1d14eb979a90b96e"

URI_x86_64_v2_bpftool = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bpftool-7.7.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_bpftool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bpftool}"
SRC_URI[x86_64_v2_bpftool.sha256sum] = "d44fcb646afeb5182925d3a73e627d3aa35b6333e1f1da00ece79cd6a0a6bbf2"

URI_aarch64_bpftool = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bpftool-7.7.0-2.el10.aarch64.rpm;name=aarch64_bpftool;unpack=0"
SRC_URI:append = " ${URI_aarch64_bpftool}"
SRC_URI[aarch64_bpftool.sha256sum] = "042fafbad243d148c5fc144dd477fdb7bc92b59624de2ecc793d4f720c3318cb"

RDEPENDS:bpftool = " \
 elfutils-libelf \
 glibc \
 libcap \
 llvm-libs \
 zlib-ng-compat \
 "
