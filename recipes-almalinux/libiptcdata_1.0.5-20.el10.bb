# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libiptcdata"
PV = "1.0.5"
PR = "20.el10"
PACKAGES = " \
 libiptcdata \
 libiptcdata-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libiptcdata-1.0.5-20.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa38c0e25518eccf186130889c462ae219a674118b7d89f996ebd56ea95cb41d"

URI_x86_64_v2_libiptcdata = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libiptcdata-1.0.5-20.el10.x86_64_v2.rpm;name=x86_64_v2_libiptcdata;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libiptcdata}"
SRC_URI[x86_64_v2_libiptcdata.sha256sum] = "12acba8073513efe8c6533a348b5c041447122a9d4de481c26c94a9313e253f1"

URI_x86_64_v2_libiptcdata-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libiptcdata-devel-1.0.5-20.el10.x86_64_v2.rpm;name=x86_64_v2_libiptcdata-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libiptcdata-devel}"
SRC_URI[x86_64_v2_libiptcdata-devel.sha256sum] = "0bdfb74af4b79ae3cad89ad45ceb37002efc9eb8fc71dae1b7648eb428849b0d"

URI_aarch64_libiptcdata = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libiptcdata-1.0.5-20.el10.aarch64.rpm;name=aarch64_libiptcdata;unpack=0"
SRC_URI:append = " ${URI_aarch64_libiptcdata}"
SRC_URI[aarch64_libiptcdata.sha256sum] = "85beda71326505d9d51c0a2e9d65ec0e165bc32ce2fadb854e60aca0e49e8414"

URI_aarch64_libiptcdata-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libiptcdata-devel-1.0.5-20.el10.aarch64.rpm;name=aarch64_libiptcdata-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libiptcdata-devel}"
SRC_URI[aarch64_libiptcdata-devel.sha256sum] = "33703dc004798d19a199cabf2dc05c47d6e478fd9c063c76280030684e3c1220"

RDEPENDS:libiptcdata = " \
 glibc \
 "
RDEPENDS:libiptcdata-devel = " \
 libiptcdata \
 pkgconf-pkg-config \
 "
