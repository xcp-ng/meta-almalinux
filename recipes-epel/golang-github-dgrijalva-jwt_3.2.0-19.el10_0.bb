# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-dgrijalva-jwt"
PV = "3.2.0"
PR = "19.el10_0"
PACKAGES = " \
 golang-github-dgrijalva-jwt \
 golang-github-dgrijalva-jwt-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/golang-github-dgrijalva-jwt-3.2.0-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "90c98af62ede2db982c71c67dc123b8b9ecc77a8bdce716d9cf113a38ee70ca8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-dgrijalva-jwt-3.2.0-19.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_golang-github-dgrijalva-jwt;unpack=0"
SRC_URI[x86_64_v2_golang-github-dgrijalva-jwt.sha256sum] = "71c466008aab2ded11f4e6d21cb03b18f8b00172bb81ba97e1ead9b124e18c7a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-dgrijalva-jwt-devel-3.2.0-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-dgrijalva-jwt-devel;unpack=0"
SRC_URI[x86_64_v2_golang-github-dgrijalva-jwt-devel.sha256sum] = "88b5010c03c6cfd81262c71293afecf3076374c4c5aefbff9cd4a6a619df7e06"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-github-dgrijalva-jwt-3.2.0-19.el10_0.aarch64.rpm;name=aarch64_golang-github-dgrijalva-jwt;unpack=0"
SRC_URI[aarch64_golang-github-dgrijalva-jwt.sha256sum] = "8992ed0a4e7fe2160a5729d113486f5800c1a02b6c45fbff1732380f8d635471"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-github-dgrijalva-jwt-devel-3.2.0-19.el10_0.noarch.rpm;name=aarch64_golang-github-dgrijalva-jwt-devel;unpack=0"
SRC_URI[aarch64_golang-github-dgrijalva-jwt-devel.sha256sum] = "1f8a67bc27a416df903c69d86ec12ea6e4be660018af4909e41165fff71153f8"

RDEPENDS:golang-github-dgrijalva-jwt = " \
 glibc \
 "
RDEPENDS:golang-github-dgrijalva-jwt-devel = " \
 go-filesystem \
 "
