# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdegraphics-mobipocket"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kdegraphics-mobipocket \
 kdegraphics-mobipocket-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kdegraphics-mobipocket-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "708887800ce0383b670a0939a7003a46a4cbabbe4498d1577f2ad6984d2432e1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdegraphics-mobipocket-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdegraphics-mobipocket;unpack=0"
SRC_URI[x86_64_v2_kdegraphics-mobipocket.sha256sum] = "bd337299344777951365ed4a12d383f28135edbdc86d168565813a171a030de9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdegraphics-mobipocket-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdegraphics-mobipocket-devel;unpack=0"
SRC_URI[x86_64_v2_kdegraphics-mobipocket-devel.sha256sum] = "69885af3b9a26da183ad3aade3dd60561709d3cc3b9458a7c1dc1892f59c7f95"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kdegraphics-mobipocket-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kdegraphics-mobipocket;unpack=0"
SRC_URI[aarch64_kdegraphics-mobipocket.sha256sum] = "fe64c052c4df45d23063bee7e64795822cf54c0a213777cc84353e912e7f102d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kdegraphics-mobipocket-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kdegraphics-mobipocket-devel;unpack=0"
SRC_URI[aarch64_kdegraphics-mobipocket-devel.sha256sum] = "86ef3b75a1dd6300315aa43866d09c136ccf89977811e7d0176119ce381b7ebe"

RDEPENDS:kdegraphics-mobipocket = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kdegraphics-mobipocket-devel = " \
 cmake-filesystem \
 kdegraphics-mobipocket \
 "
