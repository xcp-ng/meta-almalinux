# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libXcomposite"
PV = "0.4.6"
PR = "5.el10"
PACKAGES = " \
 libXcomposite \
 libXcomposite-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libXcomposite-0.4.6-5.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7de3299bb4ae58dd70aba5c0caf10d8911f94ecd1453e5733fa3ae03a6a5d88d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libXcomposite-0.4.6-5.el10.x86_64_v2.rpm;name=x86_64_v2_libXcomposite;unpack=0"
SRC_URI[x86_64_v2_libXcomposite.sha256sum] = "5c1ca4308cadf9fc06cf92d82f47b5be8dce3fe64671830818c3df7767521d9a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libXcomposite-devel-0.4.6-5.el10.x86_64_v2.rpm;name=x86_64_v2_libXcomposite-devel;unpack=0"
SRC_URI[x86_64_v2_libXcomposite-devel.sha256sum] = "052a5ee0bf5d451ae656dc5d6a6ab0f43e013032a350de857d66fed58d19b52a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libXcomposite-0.4.6-5.el10.aarch64.rpm;name=aarch64_libXcomposite;unpack=0"
SRC_URI[aarch64_libXcomposite.sha256sum] = "f1b597d3988e5469a4fd72207bb1102386e9d66d4d2c82eb3b1ffe857a0c5c74"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libXcomposite-devel-0.4.6-5.el10.aarch64.rpm;name=aarch64_libXcomposite-devel;unpack=0"
SRC_URI[aarch64_libXcomposite-devel.sha256sum] = "d5e66d149bf080d8faee9891f1048bae2da5c6ddec29bae74eb4d2df051c9713"

RDEPENDS:libXcomposite = " \
 glibc \
 libX11 \
 "
RDEPENDS:libXcomposite-devel = " \
 libX11-devel \
 libXcomposite \
 libXfixes-devel \
 pkgconf-pkg-config \
 xorg-x11-proto-devel \
 "
