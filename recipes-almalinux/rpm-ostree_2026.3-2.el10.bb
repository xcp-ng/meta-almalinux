# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rpm-ostree"
PV = "2026.3"
PR = "2.el10"
PACKAGES = " \
 rpm-ostree \
 rpm-ostree-libs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rpm-ostree-2026.3-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f8d04b160330c85312a8edfbf9887642f62c6070d461cba5babb162ff31f7546"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - rpm-ostree: libcap.so.2()(64bit)

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-ostree-2026.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_rpm-ostree;unpack=0"
SRC_URI[x86_64_v2_rpm-ostree.sha256sum] = "cac1e215ed7a4684204920c5324525cf0fe0bc0c8b07767ae42d24f0788a331a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-ostree-libs-2026.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_rpm-ostree-libs;unpack=0"
SRC_URI[x86_64_v2_rpm-ostree-libs.sha256sum] = "fb9ba86b2c0a1357ecf62ddcb10e794dfa0ab03c9d8df924af072ea00c63d1c6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-ostree-2026.3-2.el10.aarch64.rpm;name=aarch64_rpm-ostree;unpack=0"
SRC_URI[aarch64_rpm-ostree.sha256sum] = "18baf26ae1ff5431f23fa88befb7fd8bc2089418b2b8ff6b32f15e0fbef1621c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-ostree-libs-2026.3-2.el10.aarch64.rpm;name=aarch64_rpm-ostree-libs;unpack=0"
SRC_URI[aarch64_rpm-ostree-libs.sha256sum] = "ac996889df7a45f7b6e434c5ff36ea632411cbd930321a37587b373cbea3dbfd"

RDEPENDS:rpm-ostree:x86_64_v2 = " \
 bash \
 bootc \
 bubblewrap \
 fuse3 \
 glib2 \
 glibc \
 json-c \
 json-glib \
 libarchive \
 libcap \
 libgcc \
 libmodulemd \
 librepo \
 libsolv \
 libstdc++ \
 libzstd \
 openssl-libs \
 ostree \
 ostree-libs \
 pcre2 \
 polkit-libs \
 rpm-libs \
 rpm-ostree-libs \
 skopeo \
 sqlite-libs \
 systemd-libs \
 zlib-ng-compat \
"
RDEPENDS:rpm-ostree:aarch64 = " \
 bash \
 bootc \
 bubblewrap \
 fuse3 \
 glib2 \
 glibc \
 json-c \
 json-glib \
 libarchive \
 libgcc \
 libmodulemd \
 librepo \
 libsolv \
 libstdc++ \
 libzstd \
 openssl-libs \
 ostree \
 ostree-libs \
 pcre2 \
 polkit-libs \
 rpm-libs \
 rpm-ostree-libs \
 skopeo \
 sqlite-libs \
 systemd-libs \
 zlib-ng-compat \
"
RDEPENDS:rpm-ostree-libs = " \
 glib2 \
 glibc \
 json-glib \
 libgcc \
 ostree-libs \
 popt \
 rpm-libs \
 "
