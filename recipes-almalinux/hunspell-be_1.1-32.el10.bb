# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-be"
PV = "1.1"
PR = "32.el10"
PACKAGES = " \
 hunspell-be \
 hyphen-be \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-be-1.1-32.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "69ed0f902f1a70235d6d85d94e76d78cf34de0d71aca7b86bbd38a8d6847e53f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-be-1.1-32.el10.noarch.rpm;name=x86_64_v2_hunspell-be;unpack=0"
SRC_URI[x86_64_v2_hunspell-be.sha256sum] = "be844094539ffd39ca192cd9beb6d1e35de5103fb0b37173320fabb6196b52ad"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-be-1.1-32.el10.noarch.rpm;name=x86_64_v2_hyphen-be;unpack=0"
SRC_URI[x86_64_v2_hyphen-be.sha256sum] = "597381f368919cad13e4d8f17f1636f002e60885479e8c13cc839b0666617c4d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-be-1.1-32.el10.noarch.rpm;name=aarch64_hunspell-be;unpack=0"
SRC_URI[aarch64_hunspell-be.sha256sum] = "be844094539ffd39ca192cd9beb6d1e35de5103fb0b37173320fabb6196b52ad"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-be-1.1-32.el10.noarch.rpm;name=aarch64_hyphen-be;unpack=0"
SRC_URI[aarch64_hyphen-be.sha256sum] = "597381f368919cad13e4d8f17f1636f002e60885479e8c13cc839b0666617c4d"

RDEPENDS:hunspell-be = " \
 hunspell-filesystem \
 "
RDEPENDS:hyphen-be = " \
 hyphen \
 "
