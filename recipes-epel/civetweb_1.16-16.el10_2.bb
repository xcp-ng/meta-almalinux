# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "civetweb"
PV = "1.16"
PR = "16.el10_2"
PACKAGES = " \
 civetweb \
 civetweb-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/civetweb-1.16-16.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e7f2173650378eebe40c81d5f87e749eb325f7c4f3f52702acebd6333b2fb802"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/civetweb-1.16-16.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_civetweb;unpack=0"
SRC_URI[x86_64_v2_civetweb.sha256sum] = "d7d3fb3c29865601a9cbd0cb19251d73324ed18e42a9e125abcc17d851384f5c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/civetweb-devel-1.16-16.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_civetweb-devel;unpack=0"
SRC_URI[x86_64_v2_civetweb-devel.sha256sum] = "ac8d2337dc732abf533f34f3a333bedb5340ace489377d5e15156a6577f911f8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/civetweb-1.16-16.el10_2.aarch64.rpm;name=aarch64_civetweb;unpack=0"
SRC_URI[aarch64_civetweb.sha256sum] = "a1a3b70aae514b002d503a2a503873d3905ad3a8149b8b9a3f48c72628dcf261"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/civetweb-devel-1.16-16.el10_2.aarch64.rpm;name=aarch64_civetweb-devel;unpack=0"
SRC_URI[aarch64_civetweb-devel.sha256sum] = "53e02225a5c0b7b2be3863bbca5cf173c4435dfd95d7017632950965af649e1a"

RDEPENDS:civetweb = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:civetweb-devel = " \
 civetweb \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
