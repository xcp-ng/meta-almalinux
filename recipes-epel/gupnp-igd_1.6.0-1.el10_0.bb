# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gupnp-igd"
PV = "1.6.0"
PR = "1.el10_0"
PACKAGES = " \
 gupnp-igd \
 gupnp-igd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gupnp-igd-1.6.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f050743d8a699651a4cc464cc916f7f288cd593b3a05d86e33ca9c33424eb815"

URI_x86_64_v2_gupnp-igd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gupnp-igd-1.6.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gupnp-igd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gupnp-igd}"
SRC_URI[x86_64_v2_gupnp-igd.sha256sum] = "25415408e993bc4e258c0641af12d3462152e9ce7b5ff3ff8f208f2afa91d7bf"

URI_x86_64_v2_gupnp-igd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gupnp-igd-devel-1.6.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gupnp-igd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gupnp-igd-devel}"
SRC_URI[x86_64_v2_gupnp-igd-devel.sha256sum] = "72fdf8b5f99297ceb546f0af48fe6c7bc83baf7faf65d4c894abe6dcc98f3590"

URI_aarch64_gupnp-igd = "${EPEL_MIRROR}/aarch64/Packages/g/gupnp-igd-1.6.0-1.el10_0.aarch64.rpm;name=aarch64_gupnp-igd;unpack=0"
SRC_URI:append = " ${URI_aarch64_gupnp-igd}"
SRC_URI[aarch64_gupnp-igd.sha256sum] = "752e0ce73bfc03bb90d8ca7f1f17379dab748a135af957b4ddb2efcedee9c328"

URI_aarch64_gupnp-igd-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gupnp-igd-devel-1.6.0-1.el10_0.aarch64.rpm;name=aarch64_gupnp-igd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gupnp-igd-devel}"
SRC_URI[aarch64_gupnp-igd-devel.sha256sum] = "4f02225147f18a72d097610bfd7c18eb07ad03a09bc51716906d4d83dac66aa2"

RDEPENDS:gupnp-igd = " \
 glib2 \
 glibc \
 gssdp \
 gupnp \
 "
RDEPENDS:gupnp-igd-devel = " \
 glib2-devel \
 gssdp-devel \
 gupnp-devel \
 gupnp-igd \
 pkgconf-pkg-config \
 "
