# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-coveragepy-result"
PV = "0.0.8"
PR = "1.el10_3"
PACKAGES = " \
 python3-colcon-coveragepy-result \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-coveragepy-result-0.0.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aac38c8599442c957ccabf4d5b330ff4d5fa80e36121d4c6f462a1fbea2e3dec"

URI_x86_64_v2_python3-colcon-coveragepy-result = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-coveragepy-result-0.0.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-coveragepy-result;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-coveragepy-result}"
SRC_URI[x86_64_v2_python3-colcon-coveragepy-result.sha256sum] = "066f3c0beac4025f748d5a2bb529e0229c66a4f1708d63f5ea10439386a211d3"

URI_aarch64_python3-colcon-coveragepy-result = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-coveragepy-result-0.0.8-1.el10_3.noarch.rpm;name=aarch64_python3-colcon-coveragepy-result;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-coveragepy-result}"
SRC_URI[aarch64_python3-colcon-coveragepy-result.sha256sum] = "8f1c72066486f85b4c6bcd5b75794da73bfcea338867514253255e047daebccf"

RDEPENDS:python3-colcon-coveragepy-result = " \
 python3 \
 python3-colcon-core \
 python3-coverage \
 "
