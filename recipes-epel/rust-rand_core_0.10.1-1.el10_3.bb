# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_core"
PV = "0.10.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-rand_core+default-devel \
 rust-rand_core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_core-0.10.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf918c57364f799cd2fe1f4535861d76cfdb4a16cbaf5cd4873b4c25f945a7ad"

URI_x86_64_v2_rust-rand_core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_core+default-devel-0.10.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_core+default-devel}"
SRC_URI[x86_64_v2_rust-rand_core+default-devel.sha256sum] = "c48404c5b960be18a9fb5556c7d6450d2feb41aee9bfd012f17934380bdc83b1"

URI_x86_64_v2_rust-rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_core-devel-0.10.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_core-devel}"
SRC_URI[x86_64_v2_rust-rand_core-devel.sha256sum] = "0bf445b430d9ffd6fe1298ba9ebe79e988ccb83c6e6ce1c3112eccced23b972f"

URI_aarch64_rust-rand_core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_core+default-devel-0.10.1-1.el10_3.noarch.rpm;name=aarch64_rust-rand_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_core+default-devel}"
SRC_URI[aarch64_rust-rand_core+default-devel.sha256sum] = "66fb2d909c4d69cbf3f7faa99cc05be6968c03dc14d7340fda17a5872cc13586"

URI_aarch64_rust-rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_core-devel-0.10.1-1.el10_3.noarch.rpm;name=aarch64_rust-rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_core-devel}"
SRC_URI[aarch64_rust-rand_core-devel.sha256sum] = "22e706bb2880b18b42bbe308909eb38e833bd7ff91b123d8e0e09c39f4b1c55b"

RDEPENDS:rust-rand_core+default-devel = " \
 cargo \
 rust-rand_core-devel \
 "
RDEPENDS:rust-rand_core-devel = " \
 cargo \
 rust \
 "
