# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmamba"
PV = "2.6.0"
PR = "4.el10_3"
PACKAGES = " \
 libmamba \
 libmamba-devel \
 mamba \
 python3-libmambapy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libmamba-2.6.0-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d76eb522f10aee847affbafc61979f1947ba9004dc08e139c1691b9a048e74b0"

URI_x86_64_v2_libmamba = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmamba-2.6.0-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmamba;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmamba}"
SRC_URI[x86_64_v2_libmamba.sha256sum] = "5c333740ca0c04d9fbe069e9f214c9d866e47c9738e1ddfc741bd9ed1033964c"

URI_x86_64_v2_libmamba-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmamba-devel-2.6.0-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmamba-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmamba-devel}"
SRC_URI[x86_64_v2_libmamba-devel.sha256sum] = "c72e3c090f28a2a2ff4d8ab2ffbf2ea7c1540604ac4caec0d6d62acb84521cda"

URI_x86_64_v2_mamba = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mamba-2.6.0-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mamba;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mamba}"
SRC_URI[x86_64_v2_mamba.sha256sum] = "d453b9b77ae74eab1a3b37822753c22d8894821f3fc662d2438b36549c56cf62"

URI_x86_64_v2_python3-libmambapy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-libmambapy-2.6.0-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-libmambapy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libmambapy}"
SRC_URI[x86_64_v2_python3-libmambapy.sha256sum] = "8039cd5299e5e1b7028f029dbce560e49647f4914f0a271667c7debf63891655"

URI_aarch64_libmamba = "${EPEL_MIRROR}/aarch64/Packages/l/libmamba-2.6.0-4.el10_3.aarch64.rpm;name=aarch64_libmamba;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmamba}"
SRC_URI[aarch64_libmamba.sha256sum] = "de5eb635555d0682c968ec2c3ebbd60469352421a382b3dadcd9b6ff78df5e09"

URI_aarch64_libmamba-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libmamba-devel-2.6.0-4.el10_3.aarch64.rpm;name=aarch64_libmamba-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmamba-devel}"
SRC_URI[aarch64_libmamba-devel.sha256sum] = "0cad0ddbcec7f4926f158b49e937eb6b661a046c7c7156aba8098bf135c7faa4"

URI_aarch64_mamba = "${EPEL_MIRROR}/aarch64/Packages/m/mamba-2.6.0-4.el10_3.aarch64.rpm;name=aarch64_mamba;unpack=0"
SRC_URI:append = " ${URI_aarch64_mamba}"
SRC_URI[aarch64_mamba.sha256sum] = "9bde10f6b0bb404b7d19873a57638a6113c71927b6fedcec72408480642b7ece"

URI_aarch64_python3-libmambapy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-libmambapy-2.6.0-4.el10_3.aarch64.rpm;name=aarch64_python3-libmambapy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libmambapy}"
SRC_URI[aarch64_python3-libmambapy.sha256sum] = "cff68602b3018c90a0a226ac0ad00d1b5229ec29fc5f86b236d23bfdbfebe1bf"

RDEPENDS:libmamba = " \
 bzip2-libs \
 fmt \
 glibc \
 libarchive \
 libgcc \
 libsolv \
 libstdc++ \
 libzstd \
 msgpack-c \
 openssl-libs \
 reproc \
 simdjson \
 virtual/libcurl.so.4___64bit_ \
 yaml-cpp \
 "
RDEPENDS:libmamba-devel = " \
 cmake-filesystem \
 expected-devel \
 fmt-devel \
 json-devel \
 libmamba \
 libsolv-devel \
 pkgconf-pkg-config \
 reproc-devel \
 spdlog-devel \
 yaml-cpp-devel \
 "
RDEPENDS:mamba = " \
 fmt \
 glibc \
 libgcc \
 libmamba \
 libstdc++ \
 reproc \
 yaml-cpp \
 "
RDEPENDS:python3-libmambapy = " \
 fmt \
 glibc \
 libgcc \
 libmamba \
 libstdc++ \
 python3 \
 "
