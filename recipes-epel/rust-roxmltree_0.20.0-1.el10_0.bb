# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-roxmltree"
PV = "0.20.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-roxmltree+default-devel \
 rust-roxmltree+positions-devel \
 rust-roxmltree+std-devel \
 rust-roxmltree-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-roxmltree-0.20.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e30fbca7f725c055bb4440c4c972cc1b0be2f4851e4c547030158b7527ae043f"

URI_x86_64_v2_rust-roxmltree+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-roxmltree+default-devel-0.20.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-roxmltree+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-roxmltree+default-devel}"
SRC_URI[x86_64_v2_rust-roxmltree+default-devel.sha256sum] = "3c201ebc251738724b3e3296ef20cb8bdabb23696230b6cfd1f446b88e1b01ae"

URI_x86_64_v2_rust-roxmltree+positions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-roxmltree+positions-devel-0.20.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-roxmltree+positions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-roxmltree+positions-devel}"
SRC_URI[x86_64_v2_rust-roxmltree+positions-devel.sha256sum] = "dc4684d8f10c06de07f358ae591cf2e80c3784fadc01979eac0db5080f1acf05"

URI_x86_64_v2_rust-roxmltree+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-roxmltree+std-devel-0.20.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-roxmltree+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-roxmltree+std-devel}"
SRC_URI[x86_64_v2_rust-roxmltree+std-devel.sha256sum] = "e8b9c1ff1050f69c50cd21f41fe38924a5b8aeb1f235d9f8b5ef28442a8fa383"

URI_x86_64_v2_rust-roxmltree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-roxmltree-devel-0.20.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-roxmltree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-roxmltree-devel}"
SRC_URI[x86_64_v2_rust-roxmltree-devel.sha256sum] = "4b7b6772a129b2b8b8f513dc830d272962a507f07506e9e27b3ccae8ddd73576"

URI_aarch64_rust-roxmltree+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-roxmltree+default-devel-0.20.0-1.el10_0.noarch.rpm;name=aarch64_rust-roxmltree+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-roxmltree+default-devel}"
SRC_URI[aarch64_rust-roxmltree+default-devel.sha256sum] = "c9281c2814a486cae852010095c441088ab8a2afe99764f0153a313c1edce9f8"

URI_aarch64_rust-roxmltree+positions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-roxmltree+positions-devel-0.20.0-1.el10_0.noarch.rpm;name=aarch64_rust-roxmltree+positions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-roxmltree+positions-devel}"
SRC_URI[aarch64_rust-roxmltree+positions-devel.sha256sum] = "4dc161f990efa8e173472a532e0beb632bd91d124fd0279472ff38d983262ff6"

URI_aarch64_rust-roxmltree+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-roxmltree+std-devel-0.20.0-1.el10_0.noarch.rpm;name=aarch64_rust-roxmltree+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-roxmltree+std-devel}"
SRC_URI[aarch64_rust-roxmltree+std-devel.sha256sum] = "761eae9459cae23ffe75c5df348df2cd06d978b6e69f2c3afeb492d0ef1c5682"

URI_aarch64_rust-roxmltree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-roxmltree-devel-0.20.0-1.el10_0.noarch.rpm;name=aarch64_rust-roxmltree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-roxmltree-devel}"
SRC_URI[aarch64_rust-roxmltree-devel.sha256sum] = "2295830fab11e33c3aba44eeb6c1e23772772ca47de6dae4ac9a99b812ef4e92"

RDEPENDS:rust-roxmltree+default-devel = " \
 cargo \
 rust-roxmltree+positions-devel \
 rust-roxmltree+std-devel \
 rust-roxmltree-devel \
 "
RDEPENDS:rust-roxmltree+positions-devel = " \
 cargo \
 rust-roxmltree-devel \
 "
RDEPENDS:rust-roxmltree+std-devel = " \
 cargo \
 rust-roxmltree-devel \
 "
RDEPENDS:rust-roxmltree-devel = " \
 cargo \
 rust \
 "
