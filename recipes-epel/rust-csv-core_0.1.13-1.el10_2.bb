# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-csv-core"
PV = "0.1.13"
PR = "1.el10_2"
PACKAGES = " \
 rust-csv-core+default-devel \
 rust-csv-core+libc-devel \
 rust-csv-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-csv-core-0.1.13-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "327377d0a84febd16d96eb47045af8d7a34463495d723864fbf4a0abb499d943"

URI_x86_64_v2_rust-csv-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-csv-core+default-devel-0.1.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-csv-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-csv-core+default-devel}"
SRC_URI[x86_64_v2_rust-csv-core+default-devel.sha256sum] = "f137062d862ad309e9bd3b0ea9ab0986aadd44dfa47dfeb92478995ae4b3fbe4"

URI_x86_64_v2_rust-csv-core+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-csv-core+libc-devel-0.1.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-csv-core+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-csv-core+libc-devel}"
SRC_URI[x86_64_v2_rust-csv-core+libc-devel.sha256sum] = "dfdb607e521bfdba4e13e96449d741986b0aa6cd2e839e6d9deffd99b3eea232"

URI_x86_64_v2_rust-csv-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-csv-core-devel-0.1.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-csv-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-csv-core-devel}"
SRC_URI[x86_64_v2_rust-csv-core-devel.sha256sum] = "bcdc7d23a38848e56d68055e17b621bf15198d18682cc708afd8422a71a47e3d"

URI_aarch64_rust-csv-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-csv-core+default-devel-0.1.13-1.el10_2.noarch.rpm;name=aarch64_rust-csv-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-csv-core+default-devel}"
SRC_URI[aarch64_rust-csv-core+default-devel.sha256sum] = "8f44dbee85ee28e4de5b7fb338a8a2ba2216ae3b105d233eef92422388d0b075"

URI_aarch64_rust-csv-core+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-csv-core+libc-devel-0.1.13-1.el10_2.noarch.rpm;name=aarch64_rust-csv-core+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-csv-core+libc-devel}"
SRC_URI[aarch64_rust-csv-core+libc-devel.sha256sum] = "e54a184c77e08d8af5b60cc1eab283d6a0537701cfe96f597a31d0912625b68b"

URI_aarch64_rust-csv-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-csv-core-devel-0.1.13-1.el10_2.noarch.rpm;name=aarch64_rust-csv-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-csv-core-devel}"
SRC_URI[aarch64_rust-csv-core-devel.sha256sum] = "3f29b978fe1e524992ccb53965b28cb2f129b3f905af1aea4d39b5db12bf7430"

RDEPENDS:rust-csv-core+default-devel = " \
 cargo \
 rust-csv-core-devel \
 "
RDEPENDS:rust-csv-core+libc-devel = " \
 cargo \
 rust-csv-core-devel \
 rust-memchr+libc-devel \
 "
RDEPENDS:rust-csv-core-devel = " \
 cargo \
 rust-memchr-devel \
 "
