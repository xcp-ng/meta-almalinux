# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tomcat"
PE = "1"
PV = "10.1.49"
PR = "3.el10_2.alma.1"
PACKAGES = " \
 tomcat \
 tomcat-admin-webapps \
 tomcat-docs-webapp \
 tomcat-el-5.0-api \
 tomcat-jsp-3.1-api \
 tomcat-lib \
 tomcat-servlet-6.0-api \
 tomcat-webapps \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tomcat-10.1.49-3.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72d4edec1b26697f21987dc6c7950d88a4ad08ae7843c63ab484d3dc6c9b03a6"

URI_x86_64_v2_tomcat = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat-10.1.49-3.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tomcat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat}"
SRC_URI[x86_64_v2_tomcat.sha256sum] = "7a52ade066f085dc82c61eb86e4ef336c98d2ac6ba70eff0127686795e779fa3"

URI_x86_64_v2_tomcat-admin-webapps = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat-admin-webapps-10.1.49-3.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tomcat-admin-webapps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat-admin-webapps}"
SRC_URI[x86_64_v2_tomcat-admin-webapps.sha256sum] = "f1ca32a57c82c415745065d6ad5dee139ea70ca3e4b206c2c5213577fb413f9f"

URI_x86_64_v2_tomcat-docs-webapp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat-docs-webapp-10.1.49-3.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tomcat-docs-webapp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat-docs-webapp}"
SRC_URI[x86_64_v2_tomcat-docs-webapp.sha256sum] = "cd529a071ef3d5271bd60e65c7097b158dc762889174cff1d29908a19942df9b"

URI_x86_64_v2_tomcat-el-5.0-api = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat-el-5.0-api-10.1.49-3.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tomcat-el-5.0-api;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat-el-5.0-api}"
SRC_URI[x86_64_v2_tomcat-el-5.0-api.sha256sum] = "4b09a49a6a830ea70914354fdb2180be3d73be82a0bebb83bdfefc3d3432cb85"

URI_x86_64_v2_tomcat-jsp-3.1-api = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat-jsp-3.1-api-10.1.49-3.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tomcat-jsp-3.1-api;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat-jsp-3.1-api}"
SRC_URI[x86_64_v2_tomcat-jsp-3.1-api.sha256sum] = "1819dbffc1a4bca43680dfb716f9f6bfca480b2c4603395e77e0a419a58fbf40"

URI_x86_64_v2_tomcat-lib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat-lib-10.1.49-3.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tomcat-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat-lib}"
SRC_URI[x86_64_v2_tomcat-lib.sha256sum] = "8493861578941c0333c0447a8fba9719aa909187e4dfce1eb7ea6f9689eb73f4"
RPROVIDES:tomcat-lib:x86_64_v2 = "virtual/mvn_org.apache.tomcat_tomcat-catalina_ virtual/mvn_org.apache.tomcat_tomcat-catalina__ge_9.0.62 virtual/mvn_org.apache.tomcat_tomcat-coyote_ virtual/mvn_org.apache.tomcat_tomcat-coyote__ge_9.0.62 virtual/mvn_org.apache.tomcat_tomcat-juli_ virtual/mvn_org.apache.tomcat_tomcat-juli__ge_9.0.62"

URI_x86_64_v2_tomcat-servlet-6.0-api = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat-servlet-6.0-api-10.1.49-3.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tomcat-servlet-6.0-api;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat-servlet-6.0-api}"
SRC_URI[x86_64_v2_tomcat-servlet-6.0-api.sha256sum] = "2554b1cd27aae45d566ee543e529a7f8b631976f3dc644dccaa3151198093639"

URI_x86_64_v2_tomcat-webapps = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat-webapps-10.1.49-3.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tomcat-webapps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat-webapps}"
SRC_URI[x86_64_v2_tomcat-webapps.sha256sum] = "8545fc47344bf1f124375700093b8bd550c7b5bbd3885316391a2c6901779bf3"

URI_aarch64_tomcat = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat-10.1.49-3.el10_2.alma.1.noarch.rpm;name=aarch64_tomcat;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat}"
SRC_URI[aarch64_tomcat.sha256sum] = "7a52ade066f085dc82c61eb86e4ef336c98d2ac6ba70eff0127686795e779fa3"

URI_aarch64_tomcat-admin-webapps = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat-admin-webapps-10.1.49-3.el10_2.alma.1.noarch.rpm;name=aarch64_tomcat-admin-webapps;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat-admin-webapps}"
SRC_URI[aarch64_tomcat-admin-webapps.sha256sum] = "f1ca32a57c82c415745065d6ad5dee139ea70ca3e4b206c2c5213577fb413f9f"

URI_aarch64_tomcat-docs-webapp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat-docs-webapp-10.1.49-3.el10_2.alma.1.noarch.rpm;name=aarch64_tomcat-docs-webapp;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat-docs-webapp}"
SRC_URI[aarch64_tomcat-docs-webapp.sha256sum] = "cd529a071ef3d5271bd60e65c7097b158dc762889174cff1d29908a19942df9b"

URI_aarch64_tomcat-el-5.0-api = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat-el-5.0-api-10.1.49-3.el10_2.alma.1.noarch.rpm;name=aarch64_tomcat-el-5.0-api;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat-el-5.0-api}"
SRC_URI[aarch64_tomcat-el-5.0-api.sha256sum] = "4b09a49a6a830ea70914354fdb2180be3d73be82a0bebb83bdfefc3d3432cb85"

URI_aarch64_tomcat-jsp-3.1-api = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat-jsp-3.1-api-10.1.49-3.el10_2.alma.1.noarch.rpm;name=aarch64_tomcat-jsp-3.1-api;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat-jsp-3.1-api}"
SRC_URI[aarch64_tomcat-jsp-3.1-api.sha256sum] = "1819dbffc1a4bca43680dfb716f9f6bfca480b2c4603395e77e0a419a58fbf40"

URI_aarch64_tomcat-lib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat-lib-10.1.49-3.el10_2.alma.1.noarch.rpm;name=aarch64_tomcat-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat-lib}"
SRC_URI[aarch64_tomcat-lib.sha256sum] = "8493861578941c0333c0447a8fba9719aa909187e4dfce1eb7ea6f9689eb73f4"
RPROVIDES:tomcat-lib:aarch64 = "virtual/mvn_org.apache.tomcat_tomcat-catalina_ virtual/mvn_org.apache.tomcat_tomcat-catalina__ge_9.0.62 virtual/mvn_org.apache.tomcat_tomcat-coyote_ virtual/mvn_org.apache.tomcat_tomcat-coyote__ge_9.0.62 virtual/mvn_org.apache.tomcat_tomcat-juli_ virtual/mvn_org.apache.tomcat_tomcat-juli__ge_9.0.62"

URI_aarch64_tomcat-servlet-6.0-api = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat-servlet-6.0-api-10.1.49-3.el10_2.alma.1.noarch.rpm;name=aarch64_tomcat-servlet-6.0-api;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat-servlet-6.0-api}"
SRC_URI[aarch64_tomcat-servlet-6.0-api.sha256sum] = "2554b1cd27aae45d566ee543e529a7f8b631976f3dc644dccaa3151198093639"

URI_aarch64_tomcat-webapps = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat-webapps-10.1.49-3.el10_2.alma.1.noarch.rpm;name=aarch64_tomcat-webapps;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat-webapps}"
SRC_URI[aarch64_tomcat-webapps.sha256sum] = "8545fc47344bf1f124375700093b8bd550c7b5bbd3885316391a2c6901779bf3"

RDEPENDS:tomcat = " \
 bash \
 javapackages-tools \
 shadow-utils \
 systemd \
 tomcat-lib \
 virtual/java-headless_or_java-25-headless \
 "
RDEPENDS:tomcat-admin-webapps = " \
 tomcat \
 "
RDEPENDS:tomcat-docs-webapp = " \
 tomcat \
 "
RDEPENDS:tomcat-el-5.0-api = " \
 javapackages-filesystem \
 "
RDEPENDS:tomcat-jsp-3.1-api = " \
 javapackages-filesystem \
 tomcat-el-5.0-api \
 tomcat-servlet-6.0-api \
 "
RDEPENDS:tomcat-lib = " \
 ecj \
 javapackages-filesystem \
 tomcat-el-5.0-api \
 tomcat-jsp-3.1-api \
 tomcat-servlet-6.0-api \
 virtual/coreutils \
 "
RDEPENDS:tomcat-servlet-6.0-api = " \
 javapackages-filesystem \
 "
RDEPENDS:tomcat-webapps = " \
 tomcat \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/mvn_org.apache.tomcat_tomcat-catalina_ rpm/virtual/mvn_org.apache.tomcat_tomcat-catalina__ge_9.0.62 rpm/virtual/mvn_org.apache.tomcat_tomcat-coyote_ rpm/virtual/mvn_org.apache.tomcat_tomcat-coyote__ge_9.0.62 rpm/virtual/mvn_org.apache.tomcat_tomcat-juli_ rpm/virtual/mvn_org.apache.tomcat_tomcat-juli__ge_9.0.62"

PROVIDES:append:aarch64 = " rpm/virtual/mvn_org.apache.tomcat_tomcat-catalina_ rpm/virtual/mvn_org.apache.tomcat_tomcat-catalina__ge_9.0.62 rpm/virtual/mvn_org.apache.tomcat_tomcat-coyote_ rpm/virtual/mvn_org.apache.tomcat_tomcat-coyote__ge_9.0.62 rpm/virtual/mvn_org.apache.tomcat_tomcat-juli_ rpm/virtual/mvn_org.apache.tomcat_tomcat-juli__ge_9.0.62"
