# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgdither"
PV = "0.6"
PR = "42.el10_0"
PACKAGES = " \
 libgdither \
 libgdither-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libgdither-0.6-42.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "99ba6639ba40ee8dc685a5c2f1f04309317a82b43cacef6b4d12d49aa0fdcea2"

URI_x86_64_v2_libgdither = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgdither-0.6-42.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgdither;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgdither}"
SRC_URI[x86_64_v2_libgdither.sha256sum] = "82a330cca91434f2854709a66453d20c0c9f64c874e1c1981800bd72bb8bdf5d"

URI_x86_64_v2_libgdither-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgdither-devel-0.6-42.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgdither-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgdither-devel}"
SRC_URI[x86_64_v2_libgdither-devel.sha256sum] = "a549c244e63041366f8536f47788d05b83cf27431ce51160c98bc6bf90dc1b5f"

URI_aarch64_libgdither = "${EPEL_MIRROR}/aarch64/Packages/l/libgdither-0.6-42.el10_0.aarch64.rpm;name=aarch64_libgdither;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgdither}"
SRC_URI[aarch64_libgdither.sha256sum] = "2cf02ec9d15f07b245927696661e04f4a2fbce41232154ae3571921c7728b432"

URI_aarch64_libgdither-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libgdither-devel-0.6-42.el10_0.aarch64.rpm;name=aarch64_libgdither-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgdither-devel}"
SRC_URI[aarch64_libgdither-devel.sha256sum] = "7c22862bb8594fa83718fd1cacb78757a9d72b5144b3deffc3d2b048d7e3da9c"

RDEPENDS:libgdither = " \
 glibc \
 "
RDEPENDS:libgdither-devel = " \
 libgdither \
 pkgconf-pkg-config \
 "
