# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-streadway-amqp"
PV = "1.0.0"
PR = "15.el10_0"
PACKAGES = " \
 golang-github-streadway-amqp-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/golang-github-streadway-amqp-1.0.0-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "666e84374c52aec7b715e67f78ada337cf864d181ee8443ec42cb48571bd7752"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-streadway-amqp-devel-1.0.0-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-streadway-amqp-devel;unpack=0"
SRC_URI[x86_64_v2_golang-github-streadway-amqp-devel.sha256sum] = "f5f7cfad69b10ba4cf6d12b976d9e347891df301cb00f63da1a4e9c875200825"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-github-streadway-amqp-devel-1.0.0-15.el10_0.noarch.rpm;name=aarch64_golang-github-streadway-amqp-devel;unpack=0"
SRC_URI[aarch64_golang-github-streadway-amqp-devel.sha256sum] = "7ae3b841968a4367cc148441ffc144de173a5de800525ec46d97aa958968f337"

RDEPENDS:golang-github-streadway-amqp-devel = " \
 go-filesystem \
 "
