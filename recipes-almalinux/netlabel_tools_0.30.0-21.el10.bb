# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "netlabel_tools"
PV = "0.30.0"
PR = "21.el10"
PACKAGES = " \
 netlabel_tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/netlabel_tools-0.30.0-21.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a9a73135f4864a09b840bca46a180b5a07722ab81d14dbc620f939ca3105abab"

URI_x86_64_v2_netlabel_tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/netlabel_tools-0.30.0-21.el10.x86_64_v2.rpm;name=x86_64_v2_netlabel_tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netlabel_tools}"
SRC_URI[x86_64_v2_netlabel_tools.sha256sum] = "87f08c3ee264e3323670e7668e65de89fcc33360690f1d07c158eb47637b3d1d"

URI_aarch64_netlabel_tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/netlabel_tools-0.30.0-21.el10.aarch64.rpm;name=aarch64_netlabel_tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_netlabel_tools}"
SRC_URI[aarch64_netlabel_tools.sha256sum] = "97ee1bb48a4b545c041ba895da7ec749e4dc33371c0f5abab72f4192261a66a2"

RDEPENDS:netlabel_tools = " \
 bash \
 glibc \
 libnl3 \
 systemd \
 "
