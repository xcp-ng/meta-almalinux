# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "numad"
PV = "0.5"
PR = "46.20150602git.el10"
PACKAGES = " \
 numad \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/numad-0.5-46.20150602git.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64a1b32ae6dbd51f99e46c8d77c0773146eb988853ab564dccd50ea909414975"

URI_x86_64_v2_numad = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/numad-0.5-46.20150602git.el10.x86_64_v2.rpm;name=x86_64_v2_numad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_numad}"
SRC_URI[x86_64_v2_numad.sha256sum] = "d0f6d2d15f1b8cea13faece48d943220cfb92d31abfb8e1ee911b2e02ba63d46"

URI_aarch64_numad = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/numad-0.5-46.20150602git.el10.aarch64.rpm;name=aarch64_numad;unpack=0"
SRC_URI:append = " ${URI_aarch64_numad}"
SRC_URI[aarch64_numad.sha256sum] = "aafcb210bb0b52ab25a4e7339414cbabcf9044dd036b27b40a5452ebb596e7d0"

RDEPENDS:numad = " \
 bash \
 glibc \
 "
