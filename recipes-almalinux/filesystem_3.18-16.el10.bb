# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "filesystem"
PV = "3.18"
PR = "16.el10"
PACKAGES = " \
 filesystem \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/filesystem-3.18-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "011facdf645823fed4574fb0921b7c67c68871d95979c2ed4f348da02c7c71af"

URI_x86_64_v2_filesystem = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/filesystem-3.18-16.el10.x86_64_v2.rpm;name=x86_64_v2_filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_filesystem}"
SRC_URI[x86_64_v2_filesystem.sha256sum] = "48a832985e0498608f6002366d29879dd1d375b75ac3472dcddb22b64ca31e98"

URI_aarch64_filesystem = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/filesystem-3.18-16.el10.aarch64.rpm;name=aarch64_filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_filesystem}"
SRC_URI[aarch64_filesystem.sha256sum] = "1fc7e9a59e55db0ead1b0a4242cac003e5bd6f54c1499a7ca120f9e5a2efbcc6"

RDEPENDS:filesystem = " \
 setup \
 "
