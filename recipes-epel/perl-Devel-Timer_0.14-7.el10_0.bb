# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Devel-Timer"
PV = "0.14"
PR = "7.el10_0"
PACKAGES = " \
 perl-Devel-Timer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Devel-Timer-0.14-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0206dc3b6b449b9986bf9e9ca6e30a47f818a1bd8682887e00182c80e2427e32"

URI_x86_64_v2_perl-Devel-Timer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Devel-Timer-0.14-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Devel-Timer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Devel-Timer}"
SRC_URI[x86_64_v2_perl-Devel-Timer.sha256sum] = "36edf55e79b047ceae24492faea227cc62f40177385c436693265329e75810d7"

URI_aarch64_perl-Devel-Timer = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Devel-Timer-0.14-7.el10_0.noarch.rpm;name=aarch64_perl-Devel-Timer;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Devel-Timer}"
SRC_URI[aarch64_perl-Devel-Timer.sha256sum] = "a287c94bba9788b078dc52f39c14f4fb9b643233a397bf87280f9196e0b0d41b"

RDEPENDS:perl-Devel-Timer = " \
 perl-Time-HiRes \
 perl-libs \
 "
