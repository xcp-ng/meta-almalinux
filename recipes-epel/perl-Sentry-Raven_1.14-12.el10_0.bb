# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sentry-Raven"
PV = "1.14"
PR = "12.el10_0"
PACKAGES = " \
 perl-Sentry-Raven \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Sentry-Raven-1.14-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04e81ce082c5125a515dfa3d80140a61ee3e5c90ffc89b655583683eb96ee1d9"

URI_x86_64_v2_perl-Sentry-Raven = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sentry-Raven-1.14-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Sentry-Raven;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sentry-Raven}"
SRC_URI[x86_64_v2_perl-Sentry-Raven.sha256sum] = "1695c01258456e3493c69f3605a5c0f1c731e3d1ee7aa4c337a6211c59aa5225"

URI_aarch64_perl-Sentry-Raven = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Sentry-Raven-1.14-12.el10_0.noarch.rpm;name=aarch64_perl-Sentry-Raven;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sentry-Raven}"
SRC_URI[aarch64_perl-Sentry-Raven.sha256sum] = "ea41038a86d92e6955e0740965dd77efc538f427cd2a3150c148befed60918ff"

RDEPENDS:perl-Sentry-Raven = " \
 perl-Data-Dump \
 perl-Devel-StackTrace \
 perl-English \
 perl-File-Basename \
 perl-File-Slurp \
 perl-HTTP-Message \
 perl-JSON-XS \
 perl-LWP-Protocol-https \
 perl-Moo \
 perl-MooX-Types-MooseLike \
 perl-Scalar-List-Utils \
 perl-Sys-Hostname \
 perl-Time-Piece \
 perl-URI \
 perl-UUID-Tiny \
 perl-constant \
 perl-libs \
 perl-libwww-perl \
 "
