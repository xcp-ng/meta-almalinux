# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cucumber-expressions"
PV = "18.0.1"
PR = "3.el10_2"
PACKAGES = " \
 python3-cucumber-expressions \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cucumber-expressions-18.0.1-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a9e12e80d14aa34c0398b74503035e020af749fb023726231582e7f4e9d60a15"

URI_x86_64_v2_python3-cucumber-expressions = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cucumber-expressions-18.0.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cucumber-expressions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cucumber-expressions}"
SRC_URI[x86_64_v2_python3-cucumber-expressions.sha256sum] = "0cb445fb302cc309153394451dc5d99ac62754f4f1f7d9e249fb638fde65bcb3"

URI_aarch64_python3-cucumber-expressions = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cucumber-expressions-18.0.1-3.el10_2.noarch.rpm;name=aarch64_python3-cucumber-expressions;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cucumber-expressions}"
SRC_URI[aarch64_python3-cucumber-expressions.sha256sum] = "4430726f2eed8a34d158a35ae583a72c67eca61f313fb7e875165c17b62767cf"

RDEPENDS:python3-cucumber-expressions = " \
 python3 \
 "
