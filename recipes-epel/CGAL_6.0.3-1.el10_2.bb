# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "CGAL"
PV = "6.0.3"
PR = "1.el10_2"
PACKAGES = " \
 CGAL-demos-source \
 CGAL-devel \
 CGAL-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/CGAL-6.0.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "71758c972d8ee55dfa64ede2dc5c3b0054a4ccead800dc17ea9c52edd98f0d61"

URI_x86_64_v2_CGAL-demos-source = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/CGAL-demos-source-6.0.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_CGAL-demos-source;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_CGAL-demos-source}"
SRC_URI[x86_64_v2_CGAL-demos-source.sha256sum] = "3133f401e36a7a675a946415969783ec3621b682517099ecdc69a87c5f7b443a"

URI_x86_64_v2_CGAL-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/CGAL-devel-6.0.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_CGAL-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_CGAL-devel}"
SRC_URI[x86_64_v2_CGAL-devel.sha256sum] = "6fe34eb4e83bcf03cd71a1401180993518ed37104ccf03c325187a1c39896688"

URI_x86_64_v2_CGAL-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/CGAL-qt6-devel-6.0.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_CGAL-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_CGAL-qt6-devel}"
SRC_URI[x86_64_v2_CGAL-qt6-devel.sha256sum] = "8e1e594fa36868a6daaeb5d5e5962cd10b5df9239429a930c0a09544d717315f"

URI_aarch64_CGAL-demos-source = "${EPEL_MIRROR}/aarch64/Packages/c/CGAL-demos-source-6.0.3-1.el10_2.noarch.rpm;name=aarch64_CGAL-demos-source;unpack=0"
SRC_URI:append = " ${URI_aarch64_CGAL-demos-source}"
SRC_URI[aarch64_CGAL-demos-source.sha256sum] = "e899f0c7e23589281e0f9430e3e0746ef560688fce4457aa7aa66d39fe530fd8"

URI_aarch64_CGAL-devel = "${EPEL_MIRROR}/aarch64/Packages/c/CGAL-devel-6.0.3-1.el10_2.aarch64.rpm;name=aarch64_CGAL-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_CGAL-devel}"
SRC_URI[aarch64_CGAL-devel.sha256sum] = "308852b7a24cc31f59a94cdde4618cf98a64a6dcde59e9ba01b456d3bfa3e356"

URI_aarch64_CGAL-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/c/CGAL-qt6-devel-6.0.3-1.el10_2.aarch64.rpm;name=aarch64_CGAL-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_CGAL-qt6-devel}"
SRC_URI[aarch64_CGAL-qt6-devel.sha256sum] = "aae5ac8e2f999c5b54a9f2ae59875b370a74b7ecf858881744b0e6588194c95f"

RDEPENDS:CGAL-demos-source = " \
 CGAL-devel \
 bash \
 "
RDEPENDS:CGAL-devel = " \
 bash \
 boost-devel \
 cmake \
 cmake-filesystem \
 gmp-devel \
 mpfr-devel \
 "
RDEPENDS:CGAL-qt6-devel = " \
 CGAL-devel \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtsvg-devel \
 qt6-qttools-devel \
 "
