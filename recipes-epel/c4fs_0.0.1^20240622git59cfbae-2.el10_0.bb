# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "c4fs"
PV = "0.0.1^20240622git59cfbae"
PR = "2.el10_0"
PACKAGES = " \
 c4fs \
 c4fs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/c4fs-0.0.1^20240622git59cfbae-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b69ba711dea9af74fe995fe28c30a7ea47e22cdf0cb2b3d12d88db8461e1b536"

URI_x86_64_v2_c4fs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/c4fs-0.0.1^20240622git59cfbae-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_c4fs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_c4fs}"
SRC_URI[x86_64_v2_c4fs.sha256sum] = "9da3983fdba2837d9a0cbd9abe3f38704a86f984aff79c0ed50ebe5bd8da6301"

URI_x86_64_v2_c4fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/c4fs-devel-0.0.1^20240622git59cfbae-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_c4fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_c4fs-devel}"
SRC_URI[x86_64_v2_c4fs-devel.sha256sum] = "d86de7061cacf6376fa0059b27729e61f901add0d54298f7e78f6e5253fd3319"

URI_aarch64_c4fs = "${EPEL_MIRROR}/aarch64/Packages/c/c4fs-0.0.1^20240622git59cfbae-2.el10_0.aarch64.rpm;name=aarch64_c4fs;unpack=0"
SRC_URI:append = " ${URI_aarch64_c4fs}"
SRC_URI[aarch64_c4fs.sha256sum] = "c5556b8f81337283e6eaf2156086a5da7870076dfe4d6eb39036b81a141ac728"

URI_aarch64_c4fs-devel = "${EPEL_MIRROR}/aarch64/Packages/c/c4fs-devel-0.0.1^20240622git59cfbae-2.el10_0.aarch64.rpm;name=aarch64_c4fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_c4fs-devel}"
SRC_URI[aarch64_c4fs-devel.sha256sum] = "6c519fad085ef516db1329c7cbf0ff91e14a93c778cf579f8f8fc801a8070c98"

RDEPENDS:c4fs = " \
 c4core \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:c4fs-devel = " \
 c4core-devel \
 c4fs \
 cmake-filesystem \
 "
