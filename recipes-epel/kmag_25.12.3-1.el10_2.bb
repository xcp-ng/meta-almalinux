# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmag"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kmag \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmag-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "68b0911c2683a636f5832d096fe3887abdfa6386b21055061d1d70a352937de3"

URI_x86_64_v2_kmag = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmag-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmag;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmag}"
SRC_URI[x86_64_v2_kmag.sha256sum] = "ef1da2fbe8f8c4e892219cf8265417ddff2018655c31799436f351c580b66eeb"

URI_aarch64_kmag = "${EPEL_MIRROR}/aarch64/Packages/k/kmag-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kmag;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmag}"
SRC_URI[aarch64_kmag.sha256sum] = "f5e63e65c3eb1d716502cae496150b5ace8533d16c6aacd37265339e4b3d888d"

RDEPENDS:kmag = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qaccessibilityclient-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
