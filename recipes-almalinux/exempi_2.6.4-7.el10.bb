# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "exempi"
PV = "2.6.4"
PR = "7.el10"
PACKAGES = " \
 exempi \
 exempi-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/exempi-2.6.4-7.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6348e0587f41507c098f1cae54e1ace5104115fd5f506cdad1ea1dc1e2a3473b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/exempi-2.6.4-7.el10.x86_64_v2.rpm;name=x86_64_v2_exempi;unpack=0"
SRC_URI[x86_64_v2_exempi.sha256sum] = "2c9598a467d0d69f2dd06f3350914eedb3a2e13f4e62f043514afe4060bff5bb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/exempi-devel-2.6.4-7.el10.x86_64_v2.rpm;name=x86_64_v2_exempi-devel;unpack=0"
SRC_URI[x86_64_v2_exempi-devel.sha256sum] = "64e7c94bb18ad74cda8e59adf2d1e1a2fe848f9b57a4ff0c38f94e095497d1be"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/exempi-2.6.4-7.el10.aarch64.rpm;name=aarch64_exempi;unpack=0"
SRC_URI[aarch64_exempi.sha256sum] = "a63f38017912c42ce61df36a0b99596a1cdc633e938298ba12c2894cea5240a0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/exempi-devel-2.6.4-7.el10.aarch64.rpm;name=aarch64_exempi-devel;unpack=0"
SRC_URI[aarch64_exempi-devel.sha256sum] = "922ac2c3721b66afb379c3347cacd1d9618456eaeed8875f72cbc77a41534b02"

RDEPENDS:exempi = " \
 expat \
 glibc \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
RDEPENDS:exempi-devel = " \
 exempi \
 pkgconf-pkg-config \
 "
