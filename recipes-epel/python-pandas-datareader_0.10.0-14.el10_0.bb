# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pandas-datareader"
PV = "0.10.0"
PR = "14.el10_0"
PACKAGES = " \
 python3-pandas-datareader \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pandas-datareader-0.10.0-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "800c0bb63d86c88e60c3fc3a31b2b660e05c22f5cb108cff816671f933b77a9d"

URI_x86_64_v2_python3-pandas-datareader = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pandas-datareader-0.10.0-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pandas-datareader;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pandas-datareader}"
SRC_URI[x86_64_v2_python3-pandas-datareader.sha256sum] = "acdbda297dca28df14b62d5d776fea93f14209ddd38bda7a88b156e136d5ae56"

URI_aarch64_python3-pandas-datareader = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pandas-datareader-0.10.0-14.el10_0.noarch.rpm;name=aarch64_python3-pandas-datareader;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pandas-datareader}"
SRC_URI[aarch64_python3-pandas-datareader.sha256sum] = "1ca9916a1377c0cce127de8493e08d9cc1eede317411273adab18dab97176bb9"

RDEPENDS:python3-pandas-datareader = " \
 python3 \
 python3-lxml \
 python3-pandas \
 python3-requests \
 "
