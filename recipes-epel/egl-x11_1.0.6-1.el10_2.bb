# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "egl-x11"
PV = "1.0.6"
PR = "1.el10_2"
PACKAGES = " \
 egl-x11 \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/e/egl-x11-1.0.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "46d15eb7f5109f80ba5ef524bbc2bc56544ba16cdf437b3f7e326ba530b8a4dd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/egl-x11-1.0.6-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_egl-x11;unpack=0"
SRC_URI[x86_64_v2_egl-x11.sha256sum] = "b3396eeaea1d4ddb20d784a84f89b5034435044b489d6a73dffd3bda5dbd0101"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/e/egl-x11-1.0.6-1.el10_2.aarch64.rpm;name=aarch64_egl-x11;unpack=0"
SRC_URI[aarch64_egl-x11.sha256sum] = "dc0015e837b87ea3460e96b644f7378c0ddada454cc17b42a5a65ce7e19ebeec"

RDEPENDS:egl-x11 = " \
 glibc \
 libX11 \
 libX11-xcb \
 libdrm \
 libglvnd-egl \
 libxcb \
 mesa-libgbm \
 "
