# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "amg4psblas"
PV = "1.2.0"
PR = "1.post1.el10_3"
PACKAGES = " \
 amg4psblas-doc \
 amg4psblas-mpich \
 amg4psblas-mpich-devel \
 amg4psblas-mpich-static \
 amg4psblas-openmpi \
 amg4psblas-openmpi-devel \
 amg4psblas-openmpi-static \
 amg4psblas-serial \
 amg4psblas-serial-devel \
 amg4psblas-serial-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/amg4psblas-1.2.0-1.post1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b5154a41315075b949ad85ba9ef2b5c88a4a55e1cc7b680fa227c97d66993ed2"

URI_x86_64_v2_amg4psblas-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/amg4psblas-doc-1.2.0-1.post1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_amg4psblas-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amg4psblas-doc}"
SRC_URI[x86_64_v2_amg4psblas-doc.sha256sum] = "7011be9cb7938a66221da719cab9ed41a3322cc5968dd4555698a239dd0b9714"

URI_x86_64_v2_amg4psblas-mpich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/amg4psblas-mpich-1.2.0-1.post1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_amg4psblas-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amg4psblas-mpich}"
SRC_URI[x86_64_v2_amg4psblas-mpich.sha256sum] = "9c5269b9ab81fbd9466201d64aa518ce313ec338a869f41cb027eab078deacb4"

URI_x86_64_v2_amg4psblas-mpich-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/amg4psblas-mpich-devel-1.2.0-1.post1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_amg4psblas-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amg4psblas-mpich-devel}"
SRC_URI[x86_64_v2_amg4psblas-mpich-devel.sha256sum] = "325028a6f15c17f294cceb52bb6d51d8fcecbf7fdc86b23bd8187cc60989e6f2"

URI_x86_64_v2_amg4psblas-mpich-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/amg4psblas-mpich-static-1.2.0-1.post1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_amg4psblas-mpich-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amg4psblas-mpich-static}"
SRC_URI[x86_64_v2_amg4psblas-mpich-static.sha256sum] = "2c5390469c70d36224b5a7f81f835b6720679b81da2b9e5c1446e19acfad387c"

URI_x86_64_v2_amg4psblas-openmpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/amg4psblas-openmpi-1.2.0-1.post1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_amg4psblas-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amg4psblas-openmpi}"
SRC_URI[x86_64_v2_amg4psblas-openmpi.sha256sum] = "05e57ba492e6637cd5ce74c518220a432de61b7de6e1fd9753588460e640f0db"

URI_x86_64_v2_amg4psblas-openmpi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/amg4psblas-openmpi-devel-1.2.0-1.post1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_amg4psblas-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amg4psblas-openmpi-devel}"
SRC_URI[x86_64_v2_amg4psblas-openmpi-devel.sha256sum] = "0d3b1f79bfada8cd3e72e4550f57a079078eafb28475482e1c57df6284f8330c"

URI_x86_64_v2_amg4psblas-openmpi-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/amg4psblas-openmpi-static-1.2.0-1.post1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_amg4psblas-openmpi-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amg4psblas-openmpi-static}"
SRC_URI[x86_64_v2_amg4psblas-openmpi-static.sha256sum] = "ba3f17ab3f71b9a2a6a3f77809f91b12db508df78bc5f95add9f4c10d716759f"

URI_x86_64_v2_amg4psblas-serial = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/amg4psblas-serial-1.2.0-1.post1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_amg4psblas-serial;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amg4psblas-serial}"
SRC_URI[x86_64_v2_amg4psblas-serial.sha256sum] = "120503df8af00660d7887cb8e26f784898e9d8cac5bca57605eed19598430f8a"

URI_x86_64_v2_amg4psblas-serial-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/amg4psblas-serial-devel-1.2.0-1.post1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_amg4psblas-serial-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amg4psblas-serial-devel}"
SRC_URI[x86_64_v2_amg4psblas-serial-devel.sha256sum] = "bffce992634b619c3cc4843bf328a41b52657debdf9ae913865adaf155aba3e0"

URI_x86_64_v2_amg4psblas-serial-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/amg4psblas-serial-static-1.2.0-1.post1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_amg4psblas-serial-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amg4psblas-serial-static}"
SRC_URI[x86_64_v2_amg4psblas-serial-static.sha256sum] = "d094d3ff70cff338c8e4c111040d1363f80b7047ccfaa453e35bff9540d25476"

URI_aarch64_amg4psblas-doc = "${EPEL_MIRROR}/aarch64/Packages/a/amg4psblas-doc-1.2.0-1.post1.el10_3.noarch.rpm;name=aarch64_amg4psblas-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_amg4psblas-doc}"
SRC_URI[aarch64_amg4psblas-doc.sha256sum] = "804902f436b87b242344d41f44009276bfb50feecd57ae3cc7c11e5262dfce50"

URI_aarch64_amg4psblas-mpich = "${EPEL_MIRROR}/aarch64/Packages/a/amg4psblas-mpich-1.2.0-1.post1.el10_3.aarch64.rpm;name=aarch64_amg4psblas-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_amg4psblas-mpich}"
SRC_URI[aarch64_amg4psblas-mpich.sha256sum] = "3f82c3bfb398cd770802de93183dcae3edab0d62af9ba4ba702983473f96e1b3"

URI_aarch64_amg4psblas-mpich-devel = "${EPEL_MIRROR}/aarch64/Packages/a/amg4psblas-mpich-devel-1.2.0-1.post1.el10_3.aarch64.rpm;name=aarch64_amg4psblas-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_amg4psblas-mpich-devel}"
SRC_URI[aarch64_amg4psblas-mpich-devel.sha256sum] = "a4b74be38731ec8f736134b73e9ed6f69e96946532388a8be977d7c2405230fa"

URI_aarch64_amg4psblas-mpich-static = "${EPEL_MIRROR}/aarch64/Packages/a/amg4psblas-mpich-static-1.2.0-1.post1.el10_3.aarch64.rpm;name=aarch64_amg4psblas-mpich-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_amg4psblas-mpich-static}"
SRC_URI[aarch64_amg4psblas-mpich-static.sha256sum] = "99cff35e77499a68828b4af40c208643ce3796aab67c5658aa73558d8891edf3"

URI_aarch64_amg4psblas-openmpi = "${EPEL_MIRROR}/aarch64/Packages/a/amg4psblas-openmpi-1.2.0-1.post1.el10_3.aarch64.rpm;name=aarch64_amg4psblas-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_amg4psblas-openmpi}"
SRC_URI[aarch64_amg4psblas-openmpi.sha256sum] = "cf48756fd8a3bef4d5278fee281734ff34668d6d70a5170ff837225d4c6e26a6"

URI_aarch64_amg4psblas-openmpi-devel = "${EPEL_MIRROR}/aarch64/Packages/a/amg4psblas-openmpi-devel-1.2.0-1.post1.el10_3.aarch64.rpm;name=aarch64_amg4psblas-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_amg4psblas-openmpi-devel}"
SRC_URI[aarch64_amg4psblas-openmpi-devel.sha256sum] = "89172daacb0ab7202670d0dd86cb8070354f2f7a0d376689d483de278e3825fc"

URI_aarch64_amg4psblas-openmpi-static = "${EPEL_MIRROR}/aarch64/Packages/a/amg4psblas-openmpi-static-1.2.0-1.post1.el10_3.aarch64.rpm;name=aarch64_amg4psblas-openmpi-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_amg4psblas-openmpi-static}"
SRC_URI[aarch64_amg4psblas-openmpi-static.sha256sum] = "8c972e1c846fb9382fa7c2539c40218c82e102904ba34243f7191c6e7d977a9a"

URI_aarch64_amg4psblas-serial = "${EPEL_MIRROR}/aarch64/Packages/a/amg4psblas-serial-1.2.0-1.post1.el10_3.aarch64.rpm;name=aarch64_amg4psblas-serial;unpack=0"
SRC_URI:append = " ${URI_aarch64_amg4psblas-serial}"
SRC_URI[aarch64_amg4psblas-serial.sha256sum] = "5b4ace2d1ff481bb95d818b3768b750db3e6fba3331d7b2962e0a2df924cc88a"

URI_aarch64_amg4psblas-serial-devel = "${EPEL_MIRROR}/aarch64/Packages/a/amg4psblas-serial-devel-1.2.0-1.post1.el10_3.aarch64.rpm;name=aarch64_amg4psblas-serial-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_amg4psblas-serial-devel}"
SRC_URI[aarch64_amg4psblas-serial-devel.sha256sum] = "b4669cc658fe5bae836bed8e779154e060d3d587708b0d25b3ad7b7b5f6567b8"

URI_aarch64_amg4psblas-serial-static = "${EPEL_MIRROR}/aarch64/Packages/a/amg4psblas-serial-static-1.2.0-1.post1.el10_3.aarch64.rpm;name=aarch64_amg4psblas-serial-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_amg4psblas-serial-static}"
SRC_URI[aarch64_amg4psblas-serial-static.sha256sum] = "c4e579567b8266e48de4372191ba8bbc11b01ff9a476d5c37e42c925a709d066"

RDEPENDS:amg4psblas-doc = " \
 "
RDEPENDS:amg4psblas-mpich = " \
 amg4psblas-doc \
 glibc \
 libgcc \
 libgfortran \
 mpich \
 "
RDEPENDS:amg4psblas-mpich-devel = " \
 amg4psblas-mpich \
 psblas3-mpich-devel \
 "
RDEPENDS:amg4psblas-mpich-static = " \
 mpich \
 "
RDEPENDS:amg4psblas-openmpi = " \
 amg4psblas-doc \
 glibc \
 libgcc \
 libgfortran \
 openmpi \
 "
RDEPENDS:amg4psblas-openmpi-devel = " \
 amg4psblas-openmpi \
 psblas3-openmpi-devel \
 "
RDEPENDS:amg4psblas-openmpi-static = " \
 "
RDEPENDS:amg4psblas-serial = " \
 MUMPS \
 SuperLU \
 amg4psblas-doc \
 glibc \
 libgcc \
 libgfortran \
 psblas3-serial \
 suitesparse \
 "
RDEPENDS:amg4psblas-serial-devel = " \
 amg4psblas-serial \
 gcc-gfortran \
 psblas3-serial-devel \
 "
RDEPENDS:amg4psblas-serial-static = " \
 amg4psblas-doc \
 "
