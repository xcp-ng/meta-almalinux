# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tempfile"
PV = "3.23.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-tempfile+default-devel \
 rust-tempfile+getrandom-devel \
 rust-tempfile+nightly-devel \
 rust-tempfile-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tempfile-3.23.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4bfd6d49160592eb0a6982d0e40a4ac1767772f2f222f83e1c5ab64bc7c04dc3"

URI_x86_64_v2_rust-tempfile+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tempfile+default-devel-3.23.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tempfile+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tempfile+default-devel}"
SRC_URI[x86_64_v2_rust-tempfile+default-devel.sha256sum] = "c4d6912d0e9d7927095cf6a528c7f2348a443d5c3997916a22020f612f0bdeda"

URI_x86_64_v2_rust-tempfile+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tempfile+getrandom-devel-3.23.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tempfile+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tempfile+getrandom-devel}"
SRC_URI[x86_64_v2_rust-tempfile+getrandom-devel.sha256sum] = "37966abfc784855b0950058fa9512ac41c605b72ebf0786c2e2b8796b69c8016"

URI_x86_64_v2_rust-tempfile+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tempfile+nightly-devel-3.23.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tempfile+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tempfile+nightly-devel}"
SRC_URI[x86_64_v2_rust-tempfile+nightly-devel.sha256sum] = "a98ef99506d3ef9d80251cbbe5eed75e21430134ce448a038787a0e791537144"

URI_x86_64_v2_rust-tempfile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tempfile-devel-3.23.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tempfile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tempfile-devel}"
SRC_URI[x86_64_v2_rust-tempfile-devel.sha256sum] = "af0d48b49a039367fa20f88ee68681b08873ecfbabf6f35b93f35a571b15c625"

URI_aarch64_rust-tempfile+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tempfile+default-devel-3.23.0-1.el10_1.noarch.rpm;name=aarch64_rust-tempfile+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tempfile+default-devel}"
SRC_URI[aarch64_rust-tempfile+default-devel.sha256sum] = "5dcacf21e96a29dc337791765c4bdb52db533c0d0dfe1e163e6d095efffcf7bf"

URI_aarch64_rust-tempfile+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tempfile+getrandom-devel-3.23.0-1.el10_1.noarch.rpm;name=aarch64_rust-tempfile+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tempfile+getrandom-devel}"
SRC_URI[aarch64_rust-tempfile+getrandom-devel.sha256sum] = "676146542f307045a9a52a43ba05932a074de5b87df2a23bc89482c594c02fff"

URI_aarch64_rust-tempfile+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tempfile+nightly-devel-3.23.0-1.el10_1.noarch.rpm;name=aarch64_rust-tempfile+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tempfile+nightly-devel}"
SRC_URI[aarch64_rust-tempfile+nightly-devel.sha256sum] = "d3bafe547e995e073699f48fd06a2a30df40a7b43842690726b35be3080ba397"

URI_aarch64_rust-tempfile-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tempfile-devel-3.23.0-1.el10_1.noarch.rpm;name=aarch64_rust-tempfile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tempfile-devel}"
SRC_URI[aarch64_rust-tempfile-devel.sha256sum] = "f2225a43e469e8dafe706137a3d802688dfa5dab7d9b36a3e33e689480ec85b3"

RDEPENDS:rust-tempfile+default-devel = " \
 cargo \
 rust-tempfile+getrandom-devel \
 rust-tempfile-devel \
 "
RDEPENDS:rust-tempfile+getrandom-devel = " \
 cargo \
 rust-getrandom-devel \
 rust-tempfile-devel \
 "
RDEPENDS:rust-tempfile+nightly-devel = " \
 cargo \
 rust-tempfile-devel \
 "
RDEPENDS:rust-tempfile-devel = " \
 cargo \
 rust \
 rust-fastrand+default-devel \
 rust-once_cell+std-devel \
 rust-once_cell-devel \
 rust-rustix+default-devel \
 rust-rustix+fs-devel \
 "
