# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kspaceduel"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kspaceduel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kspaceduel-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "911f041d444060f6c55d82d4d4f40f3a7f791e92eeebd015e7e6157b2bf4e9bf"

URI_x86_64_v2_kspaceduel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kspaceduel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kspaceduel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kspaceduel}"
SRC_URI[x86_64_v2_kspaceduel.sha256sum] = "f71f7381a4ba6d92165502e607273c4d178f393dcdbe35dbfa79489b400265d3"

URI_aarch64_kspaceduel = "${EPEL_MIRROR}/aarch64/Packages/k/kspaceduel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kspaceduel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kspaceduel}"
SRC_URI[aarch64_kspaceduel.sha256sum] = "c01c38815bf3c21bd981461116c02d04fdf28010e20b8d3dfc90b53d44e03f42"

RDEPENDS:kspaceduel = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
