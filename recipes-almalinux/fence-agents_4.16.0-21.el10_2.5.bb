# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fence-agents"
PV = "4.16.0"
PR = "21.el10_2.5"
PACKAGES:x86_64_v2 = " \
 fence-agents-aliyun \
 fence-agents-all \
 fence-agents-amt-ws \
 fence-agents-apc \
 fence-agents-apc-snmp \
 fence-agents-aws \
 fence-agents-azure-arm \
 fence-agents-bladecenter \
 fence-agents-brocade \
 fence-agents-cisco-mds \
 fence-agents-cisco-ucs \
 fence-agents-common \
 fence-agents-drac5 \
 fence-agents-eaton-snmp \
 fence-agents-emerson \
 fence-agents-eps \
 fence-agents-gce \
 fence-agents-heuristics-ping \
 fence-agents-hpblade \
 fence-agents-ibm-powervs \
 fence-agents-ibm-vpc \
 fence-agents-ibmblade \
 fence-agents-ifmib \
 fence-agents-ilo-moonshot \
 fence-agents-ilo-mp \
 fence-agents-ilo-ssh \
 fence-agents-ilo2 \
 fence-agents-intelmodular \
 fence-agents-ipdu \
 fence-agents-ipmilan \
 fence-agents-kdump \
 fence-agents-kubevirt \
 fence-agents-lpar \
 fence-agents-mpath \
 fence-agents-nutanix-ahv \
 fence-agents-openstack \
 fence-agents-redfish \
 fence-agents-rhevm \
 fence-agents-rsa \
 fence-agents-rsb \
 fence-agents-sbd \
 fence-agents-scsi \
 fence-agents-virsh \
 fence-agents-vmware-rest \
 fence-agents-vmware-soap \
 fence-agents-wti \
 fence-virt \
 fence-virtd \
 fence-virtd-cpg \
 fence-virtd-libvirt \
 fence-virtd-multicast \
 fence-virtd-serial \
 fence-virtd-tcp \
 ha-cloud-support \
"
PACKAGES:aarch64 = " \
 fence-agents-all \
 fence-agents-amt-ws \
 fence-agents-apc \
 fence-agents-apc-snmp \
 fence-agents-bladecenter \
 fence-agents-brocade \
 fence-agents-cisco-mds \
 fence-agents-cisco-ucs \
 fence-agents-common \
 fence-agents-drac5 \
 fence-agents-eaton-snmp \
 fence-agents-emerson \
 fence-agents-eps \
 fence-agents-heuristics-ping \
 fence-agents-hpblade \
 fence-agents-ibm-powervs \
 fence-agents-ibm-vpc \
 fence-agents-ibmblade \
 fence-agents-ifmib \
 fence-agents-ilo-moonshot \
 fence-agents-ilo-mp \
 fence-agents-ilo-ssh \
 fence-agents-ilo2 \
 fence-agents-intelmodular \
 fence-agents-ipdu \
 fence-agents-ipmilan \
 fence-agents-kdump \
 fence-agents-kubevirt \
 fence-agents-lpar \
 fence-agents-mpath \
 fence-agents-nutanix-ahv \
 fence-agents-redfish \
 fence-agents-rhevm \
 fence-agents-rsa \
 fence-agents-rsb \
 fence-agents-sbd \
 fence-agents-scsi \
 fence-agents-virsh \
 fence-agents-vmware-rest \
 fence-agents-vmware-soap \
 fence-agents-wti \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/fence-agents-4.16.0-21.el10_2.5.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cdf240226a7f95403dba6500d4a31b1bce0c84ff2b262b3fe2eeb5d27cd1a515"

URI_x86_64_v2_fence-agents-aliyun = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-aliyun-4.16.0-21.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_fence-agents-aliyun;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-aliyun}"
SRC_URI[x86_64_v2_fence-agents-aliyun.sha256sum] = "a4d489d60108099d6eefdf7f6f44af6b38ea8c2cb8396dbbc430f5385b4e9098"

URI_x86_64_v2_fence-agents-all = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-all-4.16.0-21.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_fence-agents-all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-all}"
SRC_URI[x86_64_v2_fence-agents-all.sha256sum] = "e9a620bd36bf856171c1cecc8c201e9a3039e2a808161c6fcda9f5413fbb85d6"

URI_x86_64_v2_fence-agents-amt-ws = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-amt-ws-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-amt-ws;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-amt-ws}"
SRC_URI[x86_64_v2_fence-agents-amt-ws.sha256sum] = "4f4f9455dc2124c09068d3955018c52d59c5e5787e20c74b56664df7585682b8"

URI_x86_64_v2_fence-agents-apc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-apc-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-apc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-apc}"
SRC_URI[x86_64_v2_fence-agents-apc.sha256sum] = "bec0c532edc9657fca3d85daa3a0597c46af622904928c2339a37f0adf7ed7ce"

URI_x86_64_v2_fence-agents-apc-snmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-apc-snmp-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-apc-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-apc-snmp}"
SRC_URI[x86_64_v2_fence-agents-apc-snmp.sha256sum] = "0ed42a2237e32de2ee788e8d1ce0205de2e3e3668fe8621b0454862360f4cae9"

URI_x86_64_v2_fence-agents-aws = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-aws-4.16.0-21.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_fence-agents-aws;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-aws}"
SRC_URI[x86_64_v2_fence-agents-aws.sha256sum] = "1c1a066c56a916c08165ce2852ef4ca97387d9182b0bee48d36b26c35cb1a8ab"

URI_x86_64_v2_fence-agents-azure-arm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-azure-arm-4.16.0-21.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_fence-agents-azure-arm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-azure-arm}"
SRC_URI[x86_64_v2_fence-agents-azure-arm.sha256sum] = "032af64bcd10bde68b2388dd314060970da7c540163af46a05622613d0c712e6"

URI_x86_64_v2_fence-agents-bladecenter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-bladecenter-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-bladecenter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-bladecenter}"
SRC_URI[x86_64_v2_fence-agents-bladecenter.sha256sum] = "43be7813f12ea8487c7144e058efdca667f8ee63e3b8fb3688b1ee768242c4db"

URI_x86_64_v2_fence-agents-brocade = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-brocade-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-brocade;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-brocade}"
SRC_URI[x86_64_v2_fence-agents-brocade.sha256sum] = "512d3a91950b1d4aba9d521f1b1298cb5281a94cc741007163fdefa3ff9c6d6b"

URI_x86_64_v2_fence-agents-cisco-mds = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-cisco-mds-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-cisco-mds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-cisco-mds}"
SRC_URI[x86_64_v2_fence-agents-cisco-mds.sha256sum] = "0585c3e9f38920e515019f74ebdb69e2987cda9c3fc8f55553b0d5b46a04667e"

URI_x86_64_v2_fence-agents-cisco-ucs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-cisco-ucs-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-cisco-ucs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-cisco-ucs}"
SRC_URI[x86_64_v2_fence-agents-cisco-ucs.sha256sum] = "9380d9758dfd4d1453e71e86b6de038363038a4d33fa19c298d368038b30f2cd"

URI_x86_64_v2_fence-agents-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-common-4.16.0-21.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_fence-agents-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-common}"
SRC_URI[x86_64_v2_fence-agents-common.sha256sum] = "3eea86a9b2e7978c718daa37a47dec023fd62a6bb5a36ee23afbdad03426d642"

URI_x86_64_v2_fence-agents-drac5 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-drac5-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-drac5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-drac5}"
SRC_URI[x86_64_v2_fence-agents-drac5.sha256sum] = "c72dc94ebe3471be09580a457d1e65fd832107047626548b5bfb15a04b9060dc"

URI_x86_64_v2_fence-agents-eaton-snmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-eaton-snmp-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-eaton-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-eaton-snmp}"
SRC_URI[x86_64_v2_fence-agents-eaton-snmp.sha256sum] = "089facbd88cf4480c948daef5080d8a4e863f876af741e894953a052c18472f1"

URI_x86_64_v2_fence-agents-emerson = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-emerson-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-emerson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-emerson}"
SRC_URI[x86_64_v2_fence-agents-emerson.sha256sum] = "b3ba20e516f6f7d2812656bf61775f98e42e342544de7b9ed01aa80028d7e454"

URI_x86_64_v2_fence-agents-eps = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-eps-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-eps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-eps}"
SRC_URI[x86_64_v2_fence-agents-eps.sha256sum] = "70805cb3186ce3b83c61dd6a92392e10e2269d97bb12901831a705caa2e13e67"

URI_x86_64_v2_fence-agents-gce = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-gce-4.16.0-21.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_fence-agents-gce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-gce}"
SRC_URI[x86_64_v2_fence-agents-gce.sha256sum] = "f319b5c5cc0c8b42c50256250745e3265a4fa26518b0160c1e57641443a70cca"

URI_x86_64_v2_fence-agents-heuristics-ping = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-heuristics-ping-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-heuristics-ping;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-heuristics-ping}"
SRC_URI[x86_64_v2_fence-agents-heuristics-ping.sha256sum] = "9a5a0dc003e77f5a9ea108f92a622c5d6976e36a844c4b748e069257b31f1021"

URI_x86_64_v2_fence-agents-hpblade = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-hpblade-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-hpblade;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-hpblade}"
SRC_URI[x86_64_v2_fence-agents-hpblade.sha256sum] = "89fef3d43f7585019392d0dc5d961f1c4648edbad79329024e184b6e229a1f31"

URI_x86_64_v2_fence-agents-ibm-powervs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ibm-powervs-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-ibm-powervs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ibm-powervs}"
SRC_URI[x86_64_v2_fence-agents-ibm-powervs.sha256sum] = "769c27a5bdf674e7ae7d3e284ca2ef59c325032952f687138b4de3eb49bbf684"

URI_x86_64_v2_fence-agents-ibm-vpc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ibm-vpc-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-ibm-vpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ibm-vpc}"
SRC_URI[x86_64_v2_fence-agents-ibm-vpc.sha256sum] = "f902c8e652433f804325f4d993ebdaaa7d96b4806e8da803c04d74fd44eb47e5"

URI_x86_64_v2_fence-agents-ibmblade = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ibmblade-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-ibmblade;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ibmblade}"
SRC_URI[x86_64_v2_fence-agents-ibmblade.sha256sum] = "7d422de49cf099ef097c46e463774d835a7a6341739f62bf21f362bf0369b424"

URI_x86_64_v2_fence-agents-ifmib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ifmib-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-ifmib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ifmib}"
SRC_URI[x86_64_v2_fence-agents-ifmib.sha256sum] = "079ef24bb4d641ff4713ab43de2a354ad8dc7350f764f31380313fb52bb8e396"

URI_x86_64_v2_fence-agents-ilo-moonshot = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ilo-moonshot-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-ilo-moonshot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ilo-moonshot}"
SRC_URI[x86_64_v2_fence-agents-ilo-moonshot.sha256sum] = "33a6033ef28cbf57fe6ae177ba899bee9efa2586458cfc9f4b17d8816f4852e9"

URI_x86_64_v2_fence-agents-ilo-mp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ilo-mp-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-ilo-mp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ilo-mp}"
SRC_URI[x86_64_v2_fence-agents-ilo-mp.sha256sum] = "eeb9b2bc6cde8b87c3ec4e65ba4ab628d789e89f6bb675f9de06ddff240c830a"

URI_x86_64_v2_fence-agents-ilo-ssh = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ilo-ssh-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-ilo-ssh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ilo-ssh}"
SRC_URI[x86_64_v2_fence-agents-ilo-ssh.sha256sum] = "3b06b3b6370f1542f6c561b830148802a761f1a54cced27f5b897bc72bbf000c"

URI_x86_64_v2_fence-agents-ilo2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ilo2-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-ilo2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ilo2}"
SRC_URI[x86_64_v2_fence-agents-ilo2.sha256sum] = "eb84f77d4c349914d249a21e99b260421c5f9152deb8ab4f6aefcad2c4b71e68"

URI_x86_64_v2_fence-agents-intelmodular = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-intelmodular-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-intelmodular;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-intelmodular}"
SRC_URI[x86_64_v2_fence-agents-intelmodular.sha256sum] = "af75659dc64c53a891fd4636e3b0602ad519684579d5271ea03c01a7caa278b2"

URI_x86_64_v2_fence-agents-ipdu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ipdu-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-ipdu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ipdu}"
SRC_URI[x86_64_v2_fence-agents-ipdu.sha256sum] = "fc9de80e97011d49b8861f131eb3794c92c566c1c4502d917365892d71a8bb61"

URI_x86_64_v2_fence-agents-ipmilan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ipmilan-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-ipmilan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ipmilan}"
SRC_URI[x86_64_v2_fence-agents-ipmilan.sha256sum] = "cc3c20cef2b889d5204bd8db41430e7e4147d375fba2c598f1d7f4ae9a00fd26"

URI_x86_64_v2_fence-agents-kdump = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-kdump-4.16.0-21.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_fence-agents-kdump;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-kdump}"
SRC_URI[x86_64_v2_fence-agents-kdump.sha256sum] = "a7c0af4a97db21f10c718360495200005870c28e7269ac3e8ad195c439e743d3"

URI_x86_64_v2_fence-agents-kubevirt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-kubevirt-4.16.0-21.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_fence-agents-kubevirt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-kubevirt}"
SRC_URI[x86_64_v2_fence-agents-kubevirt.sha256sum] = "cbf3cae696912bb7382c505117647a24eb44b2d260dfc30cf96b87e5c4246f2c"

URI_x86_64_v2_fence-agents-lpar = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-lpar-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-lpar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-lpar}"
SRC_URI[x86_64_v2_fence-agents-lpar.sha256sum] = "91ae58cf021e245e1a1bf1024c70c1f559915400b560633a3068c117a652dbec"

URI_x86_64_v2_fence-agents-mpath = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-mpath-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-mpath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-mpath}"
SRC_URI[x86_64_v2_fence-agents-mpath.sha256sum] = "63316b6226135353f691c6e8611077a5d55c61e96e1bbd2f0feae1ef1156055f"

URI_x86_64_v2_fence-agents-nutanix-ahv = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-nutanix-ahv-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-nutanix-ahv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-nutanix-ahv}"
SRC_URI[x86_64_v2_fence-agents-nutanix-ahv.sha256sum] = "c009350e071848c015df98437c80cab01c9ca98f0801415e0e5a445ee998c502"

URI_x86_64_v2_fence-agents-openstack = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-openstack-4.16.0-21.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_fence-agents-openstack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-openstack}"
SRC_URI[x86_64_v2_fence-agents-openstack.sha256sum] = "9b097854e612818ee90d30c50c6fba1e7f79c3716557de87cf7648f87c029179"

URI_x86_64_v2_fence-agents-redfish = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-redfish-4.16.0-21.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_fence-agents-redfish;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-redfish}"
SRC_URI[x86_64_v2_fence-agents-redfish.sha256sum] = "f19d61955c24363cb9cd767a1025045c87740f218c01a0e728adf04cbff80735"

URI_x86_64_v2_fence-agents-rhevm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-rhevm-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-rhevm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-rhevm}"
SRC_URI[x86_64_v2_fence-agents-rhevm.sha256sum] = "c41641cbe4507b116bd310318f52a3d80536a50089c6df7dca2a11a7a759457c"

URI_x86_64_v2_fence-agents-rsa = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-rsa-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-rsa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-rsa}"
SRC_URI[x86_64_v2_fence-agents-rsa.sha256sum] = "1af89745129e72d3cf10835d0b18dc20f4fbb3c87def696fa64d2677f26078eb"

URI_x86_64_v2_fence-agents-rsb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-rsb-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-rsb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-rsb}"
SRC_URI[x86_64_v2_fence-agents-rsb.sha256sum] = "205874c6618128431f134d578571738ee9368d524e16f9991bf507a48a1fc4af"

URI_x86_64_v2_fence-agents-sbd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-sbd-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-sbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-sbd}"
SRC_URI[x86_64_v2_fence-agents-sbd.sha256sum] = "393ba16d2124e745058334be1a9ea19466f1ea2ed79be749f9534c0eb2eae3a0"

URI_x86_64_v2_fence-agents-scsi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-scsi-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-scsi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-scsi}"
SRC_URI[x86_64_v2_fence-agents-scsi.sha256sum] = "02a9562b78a8a24d7e333970efbc532e24161062499846a84fe75f07c16df2e2"

URI_x86_64_v2_fence-agents-virsh = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-virsh-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-virsh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-virsh}"
SRC_URI[x86_64_v2_fence-agents-virsh.sha256sum] = "0fbe596f99db8f892c67c85f7cca46ccd883667a63ee6aa5c0a06fc771d1546a"

URI_x86_64_v2_fence-agents-vmware-rest = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-vmware-rest-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-vmware-rest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-vmware-rest}"
SRC_URI[x86_64_v2_fence-agents-vmware-rest.sha256sum] = "bc1b3776aff2e7d3bbe29a17599074c9bf396e5e1b77fe5ab1defede6847358b"

URI_x86_64_v2_fence-agents-vmware-soap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-vmware-soap-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-vmware-soap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-vmware-soap}"
SRC_URI[x86_64_v2_fence-agents-vmware-soap.sha256sum] = "998f6222b512104dd6ebeef7539b27e306dc5fcfa10ff8331e8975e680821aff"

URI_x86_64_v2_fence-agents-wti = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-wti-4.16.0-21.el10_2.5.noarch.rpm;name=x86_64_v2_fence-agents-wti;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-wti}"
SRC_URI[x86_64_v2_fence-agents-wti.sha256sum] = "2ac50c4183e12154477c90ad233354a1b426ce6ada8318cd9ff1c95783d0a6e9"

URI_x86_64_v2_fence-virt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virt-4.16.0-21.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_fence-virt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-virt}"
SRC_URI[x86_64_v2_fence-virt.sha256sum] = "d4d7c75ba3d522608bec900e479af0504bf824df198cf989a2b5c34111ebd9f2"

URI_x86_64_v2_fence-virtd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-4.16.0-21.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_fence-virtd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-virtd}"
SRC_URI[x86_64_v2_fence-virtd.sha256sum] = "1c859889147401fe5dc425549dfd18408405cd0aa1bde27b559c1216a58e421a"

URI_x86_64_v2_fence-virtd-cpg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-cpg-4.16.0-21.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_fence-virtd-cpg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-virtd-cpg}"
SRC_URI[x86_64_v2_fence-virtd-cpg.sha256sum] = "8c4ee59cf52dcdb1af369d4b8999eb8aa3b0f793446f26f7d3e5d8fe64240359"

URI_x86_64_v2_fence-virtd-libvirt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-libvirt-4.16.0-21.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_fence-virtd-libvirt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-virtd-libvirt}"
SRC_URI[x86_64_v2_fence-virtd-libvirt.sha256sum] = "a6ddf1a1d37c084897d74b25a2b990462c04056432b85d76f410f98ed7529587"

URI_x86_64_v2_fence-virtd-multicast = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-multicast-4.16.0-21.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_fence-virtd-multicast;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-virtd-multicast}"
SRC_URI[x86_64_v2_fence-virtd-multicast.sha256sum] = "65efd24257c0e60cb531d44888b175a4a8af287349499364ca831a5bf96d36a6"

URI_x86_64_v2_fence-virtd-serial = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-serial-4.16.0-21.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_fence-virtd-serial;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-virtd-serial}"
SRC_URI[x86_64_v2_fence-virtd-serial.sha256sum] = "82abf7608308292d22e7961b4643d0c77e4425af172230652e5d53ddf17f5e26"

URI_x86_64_v2_fence-virtd-tcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-tcp-4.16.0-21.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_fence-virtd-tcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-virtd-tcp}"
SRC_URI[x86_64_v2_fence-virtd-tcp.sha256sum] = "ca9cce476887124ca97a195b9c4f8a3ed463982b8cb75a94910cf81c3b9d95b0"

URI_x86_64_v2_ha-cloud-support = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ha-cloud-support-4.16.0-21.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_ha-cloud-support;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ha-cloud-support}"
SRC_URI[x86_64_v2_ha-cloud-support.sha256sum] = "d759306a62c03f0dc232c65eebfffdfd528fa4a8b46ae825a867266caa2f6117"

URI_aarch64_fence-agents-all = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-all-4.16.0-21.el10_2.5.aarch64.rpm;name=aarch64_fence-agents-all;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-all}"
SRC_URI[aarch64_fence-agents-all.sha256sum] = "73b0a13a85ada47a9a4ffbb7a54671de1fb1bd00660c520127128d3edcee81dd"

URI_aarch64_fence-agents-amt-ws = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-amt-ws-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-amt-ws;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-amt-ws}"
SRC_URI[aarch64_fence-agents-amt-ws.sha256sum] = "4f4f9455dc2124c09068d3955018c52d59c5e5787e20c74b56664df7585682b8"

URI_aarch64_fence-agents-apc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-apc-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-apc;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-apc}"
SRC_URI[aarch64_fence-agents-apc.sha256sum] = "bec0c532edc9657fca3d85daa3a0597c46af622904928c2339a37f0adf7ed7ce"

URI_aarch64_fence-agents-apc-snmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-apc-snmp-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-apc-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-apc-snmp}"
SRC_URI[aarch64_fence-agents-apc-snmp.sha256sum] = "0ed42a2237e32de2ee788e8d1ce0205de2e3e3668fe8621b0454862360f4cae9"

URI_aarch64_fence-agents-bladecenter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-bladecenter-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-bladecenter;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-bladecenter}"
SRC_URI[aarch64_fence-agents-bladecenter.sha256sum] = "43be7813f12ea8487c7144e058efdca667f8ee63e3b8fb3688b1ee768242c4db"

URI_aarch64_fence-agents-brocade = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-brocade-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-brocade;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-brocade}"
SRC_URI[aarch64_fence-agents-brocade.sha256sum] = "512d3a91950b1d4aba9d521f1b1298cb5281a94cc741007163fdefa3ff9c6d6b"

URI_aarch64_fence-agents-cisco-mds = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-cisco-mds-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-cisco-mds;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-cisco-mds}"
SRC_URI[aarch64_fence-agents-cisco-mds.sha256sum] = "0585c3e9f38920e515019f74ebdb69e2987cda9c3fc8f55553b0d5b46a04667e"

URI_aarch64_fence-agents-cisco-ucs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-cisco-ucs-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-cisco-ucs;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-cisco-ucs}"
SRC_URI[aarch64_fence-agents-cisco-ucs.sha256sum] = "9380d9758dfd4d1453e71e86b6de038363038a4d33fa19c298d368038b30f2cd"

URI_aarch64_fence-agents-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-common-4.16.0-21.el10_2.5.aarch64.rpm;name=aarch64_fence-agents-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-common}"
SRC_URI[aarch64_fence-agents-common.sha256sum] = "ab8556814e76774ad75a9587ebad14888791859081cd49582084ccc0597bdc35"

URI_aarch64_fence-agents-drac5 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-drac5-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-drac5;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-drac5}"
SRC_URI[aarch64_fence-agents-drac5.sha256sum] = "c72dc94ebe3471be09580a457d1e65fd832107047626548b5bfb15a04b9060dc"

URI_aarch64_fence-agents-eaton-snmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-eaton-snmp-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-eaton-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-eaton-snmp}"
SRC_URI[aarch64_fence-agents-eaton-snmp.sha256sum] = "089facbd88cf4480c948daef5080d8a4e863f876af741e894953a052c18472f1"

URI_aarch64_fence-agents-emerson = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-emerson-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-emerson;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-emerson}"
SRC_URI[aarch64_fence-agents-emerson.sha256sum] = "b3ba20e516f6f7d2812656bf61775f98e42e342544de7b9ed01aa80028d7e454"

URI_aarch64_fence-agents-eps = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-eps-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-eps;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-eps}"
SRC_URI[aarch64_fence-agents-eps.sha256sum] = "70805cb3186ce3b83c61dd6a92392e10e2269d97bb12901831a705caa2e13e67"

URI_aarch64_fence-agents-heuristics-ping = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-heuristics-ping-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-heuristics-ping;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-heuristics-ping}"
SRC_URI[aarch64_fence-agents-heuristics-ping.sha256sum] = "9a5a0dc003e77f5a9ea108f92a622c5d6976e36a844c4b748e069257b31f1021"

URI_aarch64_fence-agents-hpblade = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-hpblade-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-hpblade;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-hpblade}"
SRC_URI[aarch64_fence-agents-hpblade.sha256sum] = "89fef3d43f7585019392d0dc5d961f1c4648edbad79329024e184b6e229a1f31"

URI_aarch64_fence-agents-ibm-powervs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ibm-powervs-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-ibm-powervs;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ibm-powervs}"
SRC_URI[aarch64_fence-agents-ibm-powervs.sha256sum] = "769c27a5bdf674e7ae7d3e284ca2ef59c325032952f687138b4de3eb49bbf684"

URI_aarch64_fence-agents-ibm-vpc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ibm-vpc-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-ibm-vpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ibm-vpc}"
SRC_URI[aarch64_fence-agents-ibm-vpc.sha256sum] = "f902c8e652433f804325f4d993ebdaaa7d96b4806e8da803c04d74fd44eb47e5"

URI_aarch64_fence-agents-ibmblade = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ibmblade-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-ibmblade;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ibmblade}"
SRC_URI[aarch64_fence-agents-ibmblade.sha256sum] = "7d422de49cf099ef097c46e463774d835a7a6341739f62bf21f362bf0369b424"

URI_aarch64_fence-agents-ifmib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ifmib-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-ifmib;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ifmib}"
SRC_URI[aarch64_fence-agents-ifmib.sha256sum] = "079ef24bb4d641ff4713ab43de2a354ad8dc7350f764f31380313fb52bb8e396"

URI_aarch64_fence-agents-ilo-moonshot = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ilo-moonshot-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-ilo-moonshot;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ilo-moonshot}"
SRC_URI[aarch64_fence-agents-ilo-moonshot.sha256sum] = "33a6033ef28cbf57fe6ae177ba899bee9efa2586458cfc9f4b17d8816f4852e9"

URI_aarch64_fence-agents-ilo-mp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ilo-mp-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-ilo-mp;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ilo-mp}"
SRC_URI[aarch64_fence-agents-ilo-mp.sha256sum] = "eeb9b2bc6cde8b87c3ec4e65ba4ab628d789e89f6bb675f9de06ddff240c830a"

URI_aarch64_fence-agents-ilo-ssh = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ilo-ssh-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-ilo-ssh;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ilo-ssh}"
SRC_URI[aarch64_fence-agents-ilo-ssh.sha256sum] = "3b06b3b6370f1542f6c561b830148802a761f1a54cced27f5b897bc72bbf000c"

URI_aarch64_fence-agents-ilo2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ilo2-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-ilo2;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ilo2}"
SRC_URI[aarch64_fence-agents-ilo2.sha256sum] = "eb84f77d4c349914d249a21e99b260421c5f9152deb8ab4f6aefcad2c4b71e68"

URI_aarch64_fence-agents-intelmodular = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-intelmodular-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-intelmodular;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-intelmodular}"
SRC_URI[aarch64_fence-agents-intelmodular.sha256sum] = "af75659dc64c53a891fd4636e3b0602ad519684579d5271ea03c01a7caa278b2"

URI_aarch64_fence-agents-ipdu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ipdu-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-ipdu;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ipdu}"
SRC_URI[aarch64_fence-agents-ipdu.sha256sum] = "fc9de80e97011d49b8861f131eb3794c92c566c1c4502d917365892d71a8bb61"

URI_aarch64_fence-agents-ipmilan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ipmilan-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-ipmilan;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ipmilan}"
SRC_URI[aarch64_fence-agents-ipmilan.sha256sum] = "cc3c20cef2b889d5204bd8db41430e7e4147d375fba2c598f1d7f4ae9a00fd26"

URI_aarch64_fence-agents-kdump = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-kdump-4.16.0-21.el10_2.5.aarch64.rpm;name=aarch64_fence-agents-kdump;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-kdump}"
SRC_URI[aarch64_fence-agents-kdump.sha256sum] = "6def648ca6ebfab532d8e08c3bacc1a5ae334f06181f1846ce38444d5e879e76"

URI_aarch64_fence-agents-kubevirt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-kubevirt-4.16.0-21.el10_2.5.aarch64.rpm;name=aarch64_fence-agents-kubevirt;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-kubevirt}"
SRC_URI[aarch64_fence-agents-kubevirt.sha256sum] = "8d32e8f80f4ccfac7e1e573957aeec1d8d8e0018d56034eefd0092a119556351"

URI_aarch64_fence-agents-lpar = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-lpar-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-lpar;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-lpar}"
SRC_URI[aarch64_fence-agents-lpar.sha256sum] = "91ae58cf021e245e1a1bf1024c70c1f559915400b560633a3068c117a652dbec"

URI_aarch64_fence-agents-mpath = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-mpath-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-mpath;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-mpath}"
SRC_URI[aarch64_fence-agents-mpath.sha256sum] = "63316b6226135353f691c6e8611077a5d55c61e96e1bbd2f0feae1ef1156055f"

URI_aarch64_fence-agents-nutanix-ahv = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-nutanix-ahv-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-nutanix-ahv;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-nutanix-ahv}"
SRC_URI[aarch64_fence-agents-nutanix-ahv.sha256sum] = "c009350e071848c015df98437c80cab01c9ca98f0801415e0e5a445ee998c502"

URI_aarch64_fence-agents-redfish = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-redfish-4.16.0-21.el10_2.5.aarch64.rpm;name=aarch64_fence-agents-redfish;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-redfish}"
SRC_URI[aarch64_fence-agents-redfish.sha256sum] = "fe2062d94db1627f4705299945f6703899942b21e00a55891d780ce62810ddd5"

URI_aarch64_fence-agents-rhevm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-rhevm-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-rhevm;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-rhevm}"
SRC_URI[aarch64_fence-agents-rhevm.sha256sum] = "c41641cbe4507b116bd310318f52a3d80536a50089c6df7dca2a11a7a759457c"

URI_aarch64_fence-agents-rsa = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-rsa-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-rsa;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-rsa}"
SRC_URI[aarch64_fence-agents-rsa.sha256sum] = "1af89745129e72d3cf10835d0b18dc20f4fbb3c87def696fa64d2677f26078eb"

URI_aarch64_fence-agents-rsb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-rsb-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-rsb;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-rsb}"
SRC_URI[aarch64_fence-agents-rsb.sha256sum] = "205874c6618128431f134d578571738ee9368d524e16f9991bf507a48a1fc4af"

URI_aarch64_fence-agents-sbd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-sbd-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-sbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-sbd}"
SRC_URI[aarch64_fence-agents-sbd.sha256sum] = "393ba16d2124e745058334be1a9ea19466f1ea2ed79be749f9534c0eb2eae3a0"

URI_aarch64_fence-agents-scsi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-scsi-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-scsi;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-scsi}"
SRC_URI[aarch64_fence-agents-scsi.sha256sum] = "02a9562b78a8a24d7e333970efbc532e24161062499846a84fe75f07c16df2e2"

URI_aarch64_fence-agents-virsh = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-virsh-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-virsh;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-virsh}"
SRC_URI[aarch64_fence-agents-virsh.sha256sum] = "0fbe596f99db8f892c67c85f7cca46ccd883667a63ee6aa5c0a06fc771d1546a"

URI_aarch64_fence-agents-vmware-rest = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-vmware-rest-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-vmware-rest;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-vmware-rest}"
SRC_URI[aarch64_fence-agents-vmware-rest.sha256sum] = "bc1b3776aff2e7d3bbe29a17599074c9bf396e5e1b77fe5ab1defede6847358b"

URI_aarch64_fence-agents-vmware-soap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-vmware-soap-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-vmware-soap;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-vmware-soap}"
SRC_URI[aarch64_fence-agents-vmware-soap.sha256sum] = "998f6222b512104dd6ebeef7539b27e306dc5fcfa10ff8331e8975e680821aff"

URI_aarch64_fence-agents-wti = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-wti-4.16.0-21.el10_2.5.noarch.rpm;name=aarch64_fence-agents-wti;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-wti}"
SRC_URI[aarch64_fence-agents-wti.sha256sum] = "2ac50c4183e12154477c90ad233354a1b426ce6ada8318cd9ff1c95783d0a6e9"

RDEPENDS:fence-agents-aliyun = " \
 fence-agents-common \
 ha-cloud-support \
 python3 \
 python3-jmespath \
 "
RDEPENDS:fence-agents-all:x86_64_v2 = " \
 fence-agents-amt-ws \
 fence-agents-apc \
 fence-agents-apc-snmp \
 fence-agents-bladecenter \
 fence-agents-brocade \
 fence-agents-cisco-mds \
 fence-agents-cisco-ucs \
 fence-agents-drac5 \
 fence-agents-eaton-snmp \
 fence-agents-emerson \
 fence-agents-eps \
 fence-agents-heuristics-ping \
 fence-agents-hpblade \
 fence-agents-ibmblade \
 fence-agents-ifmib \
 fence-agents-ilo-moonshot \
 fence-agents-ilo-mp \
 fence-agents-ilo-ssh \
 fence-agents-ilo2 \
 fence-agents-intelmodular \
 fence-agents-ipdu \
 fence-agents-ipmilan \
 fence-agents-kdump \
 fence-agents-mpath \
 fence-agents-redfish \
 fence-agents-rhevm \
 fence-agents-rsa \
 fence-agents-rsb \
 fence-agents-sbd \
 fence-agents-scsi \
 fence-agents-vmware-rest \
 fence-agents-vmware-soap \
 fence-agents-wti \
 fence-virt \
"
RDEPENDS:fence-agents-all:aarch64 = " \
 fence-agents-amt-ws \
 fence-agents-apc \
 fence-agents-apc-snmp \
 fence-agents-bladecenter \
 fence-agents-brocade \
 fence-agents-cisco-mds \
 fence-agents-cisco-ucs \
 fence-agents-drac5 \
 fence-agents-eaton-snmp \
 fence-agents-emerson \
 fence-agents-eps \
 fence-agents-heuristics-ping \
 fence-agents-hpblade \
 fence-agents-ibmblade \
 fence-agents-ifmib \
 fence-agents-ilo-moonshot \
 fence-agents-ilo-mp \
 fence-agents-ilo-ssh \
 fence-agents-ilo2 \
 fence-agents-intelmodular \
 fence-agents-ipdu \
 fence-agents-ipmilan \
 fence-agents-kdump \
 fence-agents-mpath \
 fence-agents-redfish \
 fence-agents-rhevm \
 fence-agents-rsa \
 fence-agents-rsb \
 fence-agents-sbd \
 fence-agents-scsi \
 fence-agents-vmware-rest \
 fence-agents-vmware-soap \
 fence-agents-wti \
"
RDEPENDS:fence-agents-amt-ws = " \
 fence-agents-common \
 openwsman-python3 \
 python3 \
 "
RDEPENDS:fence-agents-apc = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-apc-snmp = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-aws = " \
 fence-agents-common \
 ha-cloud-support \
 python3 \
 "
RDEPENDS:fence-agents-azure-arm = " \
 fence-agents-common \
 ha-cloud-support \
 python3 \
 "
RDEPENDS:fence-agents-bladecenter = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-brocade = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-cisco-mds = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-cisco-ucs = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-common = " \
 glibc \
 openssl-libs \
 pkgconf-pkg-config \
 python3 \
 python3-pexpect \
 python3-ptyprocess \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:fence-agents-drac5 = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-eaton-snmp = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-emerson = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-eps = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-gce = " \
 fence-agents-common \
 ha-cloud-support \
 python3 \
 "
RDEPENDS:fence-agents-heuristics-ping = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-hpblade = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-ibm-powervs = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-ibm-vpc = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-ibmblade = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-ifmib = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-ilo-moonshot = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-ilo-mp = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-ilo-ssh = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-ilo2 = " \
 fence-agents-common \
 gnutls-utils \
 python3 \
 "
RDEPENDS:fence-agents-intelmodular = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-ipdu = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-ipmilan = " \
 fence-agents-common \
 ipmitool \
 python3 \
 "
RDEPENDS:fence-agents-kdump = " \
 fence-agents-common \
 glibc \
 "
RDEPENDS:fence-agents-kubevirt = " \
 fence-agents-common \
 python3 \
 python3-charset-normalizer \
 python3-dateutil \
 python3-oauthlib \
 python3-pyasn1 \
 python3-pyyaml \
 python3-requests \
 python3-requests-oauthlib \
 python3-six \
 python3-urllib3 \
 "
RDEPENDS:fence-agents-lpar = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-mpath = " \
 device-mapper-multipath \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-nutanix-ahv = " \
 fence-agents-common \
 python3 \
 python3-requests \
 "
RDEPENDS:fence-agents-openstack = " \
 fence-agents-common \
 python3 \
 python3-requests \
 "
RDEPENDS:fence-agents-redfish = " \
 fence-agents-common \
 python3 \
 python3-requests \
 "
RDEPENDS:fence-agents-rhevm = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-rsa = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-rsb = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-sbd = " \
 fence-agents-common \
 python3 \
 sbd \
 "
RDEPENDS:fence-agents-scsi = " \
 fence-agents-common \
 python3 \
 sg3_utils \
 "
RDEPENDS:fence-agents-virsh = " \
 fence-agents-common \
 libvirt-client \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-vmware-rest = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-vmware-soap = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-wti = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-virt = " \
 glibc \
 nss \
 systemd \
 "
RDEPENDS:fence-virtd = " \
 glibc \
 libuuid \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:fence-virtd-cpg = " \
 corosynclib \
 fence-virtd \
 glibc \
 libqb \
 libvirt-libs \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:fence-virtd-libvirt = " \
 fence-virtd \
 glibc \
 libvirt \
 libvirt-libs \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:fence-virtd-multicast = " \
 fence-virtd \
 glibc \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:fence-virtd-serial = " \
 fence-virtd \
 glibc \
 libvirt \
 libvirt-libs \
 libxml2 \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:fence-virtd-tcp = " \
 fence-virtd \
 glibc \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:ha-cloud-support = " \
 awscli2 \
 glibc \
 python3-cffi \
 python3-charset-normalizer \
 python3-colorama \
 python3-cryptography \
 python3-dateutil \
 python3-docutils \
 python3-idna \
 python3-jmespath \
 python3-oauthlib \
 python3-packaging \
 python3-protobuf \
 python3-pyasn1 \
 python3-pycparser \
 python3-pyparsing \
 python3-pyyaml \
 python3-requests \
 python3-requests-oauthlib \
 python3-six \
 python3-typing-extensions \
 python3-urllib3 \
 "
