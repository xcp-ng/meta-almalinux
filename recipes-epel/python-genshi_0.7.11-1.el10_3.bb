# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-genshi"
PV = "0.7.11"
PR = "1.el10_3"
PACKAGES = " \
 python3-genshi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-genshi-0.7.11-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "40d6bca7962c6d15c30dee124fc06101c9e369cfb943ed99a4b21592c504c3d2"

URI_x86_64_v2_python3-genshi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-genshi-0.7.11-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-genshi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-genshi}"
SRC_URI[x86_64_v2_python3-genshi.sha256sum] = "cfefbc4e9ddcb27ec8691e8079a1287ec19361df4833ccd5e037a5266ce82ce0"

URI_aarch64_python3-genshi = "${EPEL_MIRROR}/aarch64/Packages/p/python3-genshi-0.7.11-1.el10_3.aarch64.rpm;name=aarch64_python3-genshi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-genshi}"
SRC_URI[aarch64_python3-genshi.sha256sum] = "23a8ff0c3c06960f6a7bb64ebd9a9cd60ffe726f5f5a883387a9f3d91227aeed"

RDEPENDS:python3-genshi = " \
 glibc \
 python3 \
 "
