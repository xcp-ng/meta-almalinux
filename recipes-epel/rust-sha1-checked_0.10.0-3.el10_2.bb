# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sha1-checked"
PV = "0.10.0"
PR = "3.el10_2"
PACKAGES = " \
 rust-sha1-checked+default-devel \
 rust-sha1-checked+oid-devel \
 rust-sha1-checked+std-devel \
 rust-sha1-checked+zeroize-devel \
 rust-sha1-checked-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sha1-checked-0.10.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab184be454ddfd224ca65a6aa897d9bf4eaf4bf53149f6a29d8a3aa71084b7b7"

URI_x86_64_v2_rust-sha1-checked+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1-checked+default-devel-0.10.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1-checked+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1-checked+default-devel}"
SRC_URI[x86_64_v2_rust-sha1-checked+default-devel.sha256sum] = "ff9182929400ed7fd112f4ed8893aaf8b08ea2f0856562229d0fedbf6e876246"

URI_x86_64_v2_rust-sha1-checked+oid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1-checked+oid-devel-0.10.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1-checked+oid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1-checked+oid-devel}"
SRC_URI[x86_64_v2_rust-sha1-checked+oid-devel.sha256sum] = "3ed593845ed6b000a326aa30ccc73009a08cc3f7c6b99efe791936110198b3cb"

URI_x86_64_v2_rust-sha1-checked+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1-checked+std-devel-0.10.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1-checked+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1-checked+std-devel}"
SRC_URI[x86_64_v2_rust-sha1-checked+std-devel.sha256sum] = "2c8a59070f1baed2d521692fdfb7afbc12c2315c503f1a7aaf1e79829ef0276e"

URI_x86_64_v2_rust-sha1-checked+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1-checked+zeroize-devel-0.10.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1-checked+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1-checked+zeroize-devel}"
SRC_URI[x86_64_v2_rust-sha1-checked+zeroize-devel.sha256sum] = "40f9e5916a9fab598e912b6b2fcdcdb2a3b00d490a9bbaed4e5015d9f24331ba"

URI_x86_64_v2_rust-sha1-checked-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1-checked-devel-0.10.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1-checked-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1-checked-devel}"
SRC_URI[x86_64_v2_rust-sha1-checked-devel.sha256sum] = "9fbe7a856015540e175fa6b91bb35f058255a60c4b00b5af40a5cfd8ce996dee"

URI_aarch64_rust-sha1-checked+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1-checked+default-devel-0.10.0-3.el10_2.noarch.rpm;name=aarch64_rust-sha1-checked+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1-checked+default-devel}"
SRC_URI[aarch64_rust-sha1-checked+default-devel.sha256sum] = "5554063cddf03e99b702536758d0ad6d8c5fea1659ffd73a3846755c6aa5517b"

URI_aarch64_rust-sha1-checked+oid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1-checked+oid-devel-0.10.0-3.el10_2.noarch.rpm;name=aarch64_rust-sha1-checked+oid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1-checked+oid-devel}"
SRC_URI[aarch64_rust-sha1-checked+oid-devel.sha256sum] = "c6e585f7ccafc0c43be2799f9eec72a60f339dc2dc63e2bef568af087589140c"

URI_aarch64_rust-sha1-checked+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1-checked+std-devel-0.10.0-3.el10_2.noarch.rpm;name=aarch64_rust-sha1-checked+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1-checked+std-devel}"
SRC_URI[aarch64_rust-sha1-checked+std-devel.sha256sum] = "200883e7799a51b794f4f1201d772c29c9adad5b0f971ff9bac3dcfbac512ade"

URI_aarch64_rust-sha1-checked+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1-checked+zeroize-devel-0.10.0-3.el10_2.noarch.rpm;name=aarch64_rust-sha1-checked+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1-checked+zeroize-devel}"
SRC_URI[aarch64_rust-sha1-checked+zeroize-devel.sha256sum] = "ba7591628a5244caa929ab881a3bad5fdd8147a6da828cd485c291fba25c08c2"

URI_aarch64_rust-sha1-checked-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1-checked-devel-0.10.0-3.el10_2.noarch.rpm;name=aarch64_rust-sha1-checked-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1-checked-devel}"
SRC_URI[aarch64_rust-sha1-checked-devel.sha256sum] = "48a88314c82459297e545e454aee1c027431cc7ee2c4c5bf4585e7554713a32a"

RDEPENDS:rust-sha1-checked+default-devel = " \
 cargo \
 rust-sha1-checked+oid-devel \
 rust-sha1-checked+std-devel \
 rust-sha1-checked-devel \
 "
RDEPENDS:rust-sha1-checked+oid-devel = " \
 cargo \
 rust-digest+oid-devel \
 rust-sha1+oid-devel \
 rust-sha1-checked-devel \
 "
RDEPENDS:rust-sha1-checked+std-devel = " \
 cargo \
 rust-digest+std-devel \
 rust-sha1+std-devel \
 rust-sha1-checked-devel \
 "
RDEPENDS:rust-sha1-checked+zeroize-devel = " \
 cargo \
 rust-sha1-checked-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-sha1-checked-devel = " \
 cargo \
 rust \
 rust-digest+default-devel \
 rust-sha1+compress-devel \
 rust-sha1-devel \
 "
