# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xapian-core"
PV = "1.4.23"
PR = "4.el10"
PACKAGES = " \
 xapian-core \
 xapian-core-devel \
 xapian-core-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xapian-core-1.4.23-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52a5d3966a98eef174e5e344321c60e15d2ba9e6ade3aa238b8050c7a76ca3a5"

URI_x86_64_v2_xapian-core = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xapian-core-1.4.23-4.el10.x86_64_v2.rpm;name=x86_64_v2_xapian-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xapian-core}"
SRC_URI[x86_64_v2_xapian-core.sha256sum] = "283d8d552cddcb2effd432eca84cf812f6cf0403a4d4303cb4938a503865e330"

URI_x86_64_v2_xapian-core-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xapian-core-devel-1.4.23-4.el10.x86_64_v2.rpm;name=x86_64_v2_xapian-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xapian-core-devel}"
SRC_URI[x86_64_v2_xapian-core-devel.sha256sum] = "75899c0e474b39990f5f0a5860267b4f9bdf6f73e6269af1527a4f4763b131e6"

URI_x86_64_v2_xapian-core-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xapian-core-libs-1.4.23-4.el10.x86_64_v2.rpm;name=x86_64_v2_xapian-core-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xapian-core-libs}"
SRC_URI[x86_64_v2_xapian-core-libs.sha256sum] = "51760d93f659f31530da608d33de1bdaeac01662a58b3b98815fc478c7763197"

URI_aarch64_xapian-core = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xapian-core-1.4.23-4.el10.aarch64.rpm;name=aarch64_xapian-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_xapian-core}"
SRC_URI[aarch64_xapian-core.sha256sum] = "7f3954378d48faecfa3e4c9de38cd9454a1dc45515dc18542072f5e192db3549"

URI_aarch64_xapian-core-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xapian-core-devel-1.4.23-4.el10.aarch64.rpm;name=aarch64_xapian-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xapian-core-devel}"
SRC_URI[aarch64_xapian-core-devel.sha256sum] = "a51e7cde2ebb48f1cc4eae71dbd9a8791f3d013dea80475657c5980243d91dcb"

URI_aarch64_xapian-core-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xapian-core-libs-1.4.23-4.el10.aarch64.rpm;name=aarch64_xapian-core-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_xapian-core-libs}"
SRC_URI[aarch64_xapian-core-libs.sha256sum] = "9a69561dfbb86b3536e2b8a4c48b21aa5764d143415ab7846c075bbcd58b6177"

RDEPENDS:xapian-core = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 xapian-core-libs \
 "
RDEPENDS:xapian-core-devel = " \
 bash \
 libuuid-devel \
 pkgconf-pkg-config \
 xapian-core \
 xapian-core-libs \
 "
RDEPENDS:xapian-core-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 libuuid \
 zlib-ng-compat \
 "
