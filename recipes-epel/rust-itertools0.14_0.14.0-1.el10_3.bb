# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-itertools0.14"
PV = "0.14.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-itertools0.14+default-devel \
 rust-itertools0.14+use_alloc-devel \
 rust-itertools0.14+use_std-devel \
 rust-itertools0.14-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-itertools0.14-0.14.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f93ede4964e3c0f90ffee2b13b979178feecde4648e8a12e1aeaa835c1e741a"

URI_x86_64_v2_rust-itertools0.14+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-itertools0.14+default-devel-0.14.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-itertools0.14+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-itertools0.14+default-devel}"
SRC_URI[x86_64_v2_rust-itertools0.14+default-devel.sha256sum] = "8c7b43f478b4a26ae3f8c920ccefe2ea9b75ff6c0ff58c6c7846959a0a5cafcf"
RPROVIDES:rust-itertools0.14+default-devel:x86_64_v2 = "virtual/crate_itertools/default__ge_0.10.1_with_crate_itertools/default__lt_0.15.0~ virtual/crate_itertools/default__ge_0.13.0_with_crate_itertools/default__lt_0.15.0~"

URI_x86_64_v2_rust-itertools0.14+use_alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-itertools0.14+use_alloc-devel-0.14.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-itertools0.14+use_alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-itertools0.14+use_alloc-devel}"
SRC_URI[x86_64_v2_rust-itertools0.14+use_alloc-devel.sha256sum] = "752ebe358299cda9e26851cc9c8d583833bca6388d49010d803b922b808a9fb9"
RPROVIDES:rust-itertools0.14+use_alloc-devel:x86_64_v2 = "virtual/crate_itertools/use_alloc__ge_0.10.0_with_crate_itertools/use_alloc__lt_0.15.0~"

URI_x86_64_v2_rust-itertools0.14+use_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-itertools0.14+use_std-devel-0.14.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-itertools0.14+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-itertools0.14+use_std-devel}"
SRC_URI[x86_64_v2_rust-itertools0.14+use_std-devel.sha256sum] = "29520782772c700871fe7533c77c6feed0bf3927ed3d5d59e7184ca58e8e8b14"

URI_x86_64_v2_rust-itertools0.14-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-itertools0.14-devel-0.14.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-itertools0.14-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-itertools0.14-devel}"
SRC_URI[x86_64_v2_rust-itertools0.14-devel.sha256sum] = "5da1b57bcdba3d7535a207b2af1439c569dc1ff600ef5272c0f6789677362aea"
RPROVIDES:rust-itertools0.14-devel:x86_64_v2 = "virtual/crate_itertools__ge_0.10.0_with_crate_itertools__lt_0.15.0~"

URI_aarch64_rust-itertools0.14+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-itertools0.14+default-devel-0.14.0-1.el10_3.noarch.rpm;name=aarch64_rust-itertools0.14+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-itertools0.14+default-devel}"
SRC_URI[aarch64_rust-itertools0.14+default-devel.sha256sum] = "10dc3b70edac1b602f079d8efe8d8e652f2ee16e1c34b7b46eda3d3074fd6308"
RPROVIDES:rust-itertools0.14+default-devel:aarch64 = "virtual/crate_itertools/default__ge_0.10.1_with_crate_itertools/default__lt_0.15.0~ virtual/crate_itertools/default__ge_0.13.0_with_crate_itertools/default__lt_0.15.0~"

URI_aarch64_rust-itertools0.14+use_alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-itertools0.14+use_alloc-devel-0.14.0-1.el10_3.noarch.rpm;name=aarch64_rust-itertools0.14+use_alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-itertools0.14+use_alloc-devel}"
SRC_URI[aarch64_rust-itertools0.14+use_alloc-devel.sha256sum] = "faf7c5398f51e00b1299dff738f2ac445644ef1d433883e4ebd16836e81147e6"
RPROVIDES:rust-itertools0.14+use_alloc-devel:aarch64 = "virtual/crate_itertools/use_alloc__ge_0.10.0_with_crate_itertools/use_alloc__lt_0.15.0~"

URI_aarch64_rust-itertools0.14+use_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-itertools0.14+use_std-devel-0.14.0-1.el10_3.noarch.rpm;name=aarch64_rust-itertools0.14+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-itertools0.14+use_std-devel}"
SRC_URI[aarch64_rust-itertools0.14+use_std-devel.sha256sum] = "930cd50a7553b887ab1c6f433d63a429d48324b05654401173bd9f908275e3e9"

URI_aarch64_rust-itertools0.14-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-itertools0.14-devel-0.14.0-1.el10_3.noarch.rpm;name=aarch64_rust-itertools0.14-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-itertools0.14-devel}"
SRC_URI[aarch64_rust-itertools0.14-devel.sha256sum] = "11edca7edd9a96a2a3fd2bf51c902f1e3555e5539287adbcb52efba427a0372c"
RPROVIDES:rust-itertools0.14-devel:aarch64 = "virtual/crate_itertools__ge_0.10.0_with_crate_itertools__lt_0.15.0~"

RDEPENDS:rust-itertools0.14+default-devel = " \
 cargo \
 rust-itertools0.14+use_std-devel \
 rust-itertools0.14-devel \
 "
RDEPENDS:rust-itertools0.14+use_alloc-devel = " \
 cargo \
 rust-itertools0.14-devel \
 "
RDEPENDS:rust-itertools0.14+use_std-devel = " \
 cargo \
 rust-either+use_std-devel \
 rust-itertools0.14+use_alloc-devel \
 rust-itertools0.14-devel \
 "
RDEPENDS:rust-itertools0.14-devel = " \
 cargo \
 rust \
 rust-either-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_itertools/default__ge_0.10.1_with_crate_itertools/default__lt_0.15.0~ rpm/virtual/crate_itertools/default__ge_0.13.0_with_crate_itertools/default__lt_0.15.0~ rpm/virtual/crate_itertools/use_alloc__ge_0.10.0_with_crate_itertools/use_alloc__lt_0.15.0~ rpm/virtual/crate_itertools__ge_0.10.0_with_crate_itertools__lt_0.15.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_itertools/default__ge_0.10.1_with_crate_itertools/default__lt_0.15.0~ rpm/virtual/crate_itertools/default__ge_0.13.0_with_crate_itertools/default__lt_0.15.0~ rpm/virtual/crate_itertools/use_alloc__ge_0.10.0_with_crate_itertools/use_alloc__lt_0.15.0~ rpm/virtual/crate_itertools__ge_0.10.0_with_crate_itertools__lt_0.15.0~"
