# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "httpd"
PV = "2.4.63"
PR = "4.el10_1.3"
PACKAGES = " \
 httpd \
 httpd-core \
 httpd-devel \
 httpd-filesystem \
 httpd-manual \
 httpd-tools \
 mod_ldap \
 mod_lua \
 mod_proxy_html \
 mod_session \
 mod_ssl \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/httpd-2.4.63-4.el10_1.3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2916d88798fd8901fd9f598695f59fd18e10761af381d7cd3813885153976ad3"

URI_x86_64_v2_httpd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-2.4.63-4.el10_1.3.x86_64_v2.rpm;name=x86_64_v2_httpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_httpd}"
SRC_URI[x86_64_v2_httpd.sha256sum] = "e3101bb74be671f52e5ee2f179ccef0653f87528edf0bc98c87c8881ae6303b3"
RPROVIDES:httpd:append:x86_64_v2 = " virtual/httpd_or_nginx virtual/webserver"

URI_x86_64_v2_httpd-core = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-core-2.4.63-4.el10_1.3.x86_64_v2.rpm;name=x86_64_v2_httpd-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_httpd-core}"
SRC_URI[x86_64_v2_httpd-core.sha256sum] = "d4a1a5032f7ac2b5e9d0f68c65e5bed146ac896e1c049a82d31ede1c7851c278"

URI_x86_64_v2_httpd-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-devel-2.4.63-4.el10_1.3.x86_64_v2.rpm;name=x86_64_v2_httpd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_httpd-devel}"
SRC_URI[x86_64_v2_httpd-devel.sha256sum] = "86ac51a7352e49c4ce696a65955d1880f002bf8b36521c87d0bf602d0abd52ff"

URI_x86_64_v2_httpd-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-filesystem-2.4.63-4.el10_1.3.noarch.rpm;name=x86_64_v2_httpd-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_httpd-filesystem}"
SRC_URI[x86_64_v2_httpd-filesystem.sha256sum] = "f320ff587a4fcd09a925bec9c40e35d269b63143948e6d12c7074adaa47577f9"

URI_x86_64_v2_httpd-manual = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-manual-2.4.63-4.el10_1.3.noarch.rpm;name=x86_64_v2_httpd-manual;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_httpd-manual}"
SRC_URI[x86_64_v2_httpd-manual.sha256sum] = "4e9822d4b29ec4263e08b046e74bee6a4261cb5cf56717eaf7a4cfaca0edb0a0"

URI_x86_64_v2_httpd-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-tools-2.4.63-4.el10_1.3.x86_64_v2.rpm;name=x86_64_v2_httpd-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_httpd-tools}"
SRC_URI[x86_64_v2_httpd-tools.sha256sum] = "d58a26f86dae92f391d2ff5804c1a4d260a0402abfb883a7e692e2fca2e77a40"

URI_x86_64_v2_mod_ldap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_ldap-2.4.63-4.el10_1.3.x86_64_v2.rpm;name=x86_64_v2_mod_ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_ldap}"
SRC_URI[x86_64_v2_mod_ldap.sha256sum] = "3996fdbc0bd554fe5f72c7bcbc34dc2452fb0a9ef47930a2c25fdcc73da1f73a"

URI_x86_64_v2_mod_lua = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_lua-2.4.63-4.el10_1.3.x86_64_v2.rpm;name=x86_64_v2_mod_lua;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_lua}"
SRC_URI[x86_64_v2_mod_lua.sha256sum] = "03e6ddbe6b317c5191dcd2ef97c89f1d6bf7c199ebe9866c8825e3311a7e0a41"

URI_x86_64_v2_mod_proxy_html = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_proxy_html-2.4.63-4.el10_1.3.x86_64_v2.rpm;name=x86_64_v2_mod_proxy_html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_proxy_html}"
SRC_URI[x86_64_v2_mod_proxy_html.sha256sum] = "02c8ba7e60c78abbe71132ee4a5e8d23b703a2fe5dbe9b6ba5929e722f011247"

URI_x86_64_v2_mod_session = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_session-2.4.63-4.el10_1.3.x86_64_v2.rpm;name=x86_64_v2_mod_session;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_session}"
SRC_URI[x86_64_v2_mod_session.sha256sum] = "bbcd51addbd1275f77a7033e29e4277a7b1f8038aac2b816251da1f1e64b9835"

URI_x86_64_v2_mod_ssl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_ssl-2.4.63-4.el10_1.3.x86_64_v2.rpm;name=x86_64_v2_mod_ssl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_ssl}"
SRC_URI[x86_64_v2_mod_ssl.sha256sum] = "a24988e3f6df20328c6b92305831e73cc2c7e606aceb578951cb6b209599cdb4"

URI_aarch64_httpd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-2.4.63-4.el10_1.3.aarch64.rpm;name=aarch64_httpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_httpd}"
SRC_URI[aarch64_httpd.sha256sum] = "8c212f401a3f9204e69eea656e1e25ae8670dad1c3d5a9f8c986586c8fb8f4ec"
RPROVIDES:httpd:append:aarch64 = " virtual/httpd_or_nginx virtual/webserver"

URI_aarch64_httpd-core = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-core-2.4.63-4.el10_1.3.aarch64.rpm;name=aarch64_httpd-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_httpd-core}"
SRC_URI[aarch64_httpd-core.sha256sum] = "66736009297b5ee9ae9fef242942a141d8ff0da5f82e2a46a8ff27b588e3beb3"

URI_aarch64_httpd-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-devel-2.4.63-4.el10_1.3.aarch64.rpm;name=aarch64_httpd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_httpd-devel}"
SRC_URI[aarch64_httpd-devel.sha256sum] = "97e0e2428ace7c1d1213bb693b3be5ad223b2e5b385b93f73558ed249a237355"

URI_aarch64_httpd-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-filesystem-2.4.63-4.el10_1.3.noarch.rpm;name=aarch64_httpd-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_httpd-filesystem}"
SRC_URI[aarch64_httpd-filesystem.sha256sum] = "f320ff587a4fcd09a925bec9c40e35d269b63143948e6d12c7074adaa47577f9"

URI_aarch64_httpd-manual = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-manual-2.4.63-4.el10_1.3.noarch.rpm;name=aarch64_httpd-manual;unpack=0"
SRC_URI:append = " ${URI_aarch64_httpd-manual}"
SRC_URI[aarch64_httpd-manual.sha256sum] = "4e9822d4b29ec4263e08b046e74bee6a4261cb5cf56717eaf7a4cfaca0edb0a0"

URI_aarch64_httpd-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-tools-2.4.63-4.el10_1.3.aarch64.rpm;name=aarch64_httpd-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_httpd-tools}"
SRC_URI[aarch64_httpd-tools.sha256sum] = "02c43b629d4cde23b327b00d6996b75df5c821846fb7ee405df6c6db5a89276c"

URI_aarch64_mod_ldap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_ldap-2.4.63-4.el10_1.3.aarch64.rpm;name=aarch64_mod_ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_ldap}"
SRC_URI[aarch64_mod_ldap.sha256sum] = "bf895e8772912e143838ff4c22b35f8bab4e1b569145b44dc88aa48bb1c7e84f"

URI_aarch64_mod_lua = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_lua-2.4.63-4.el10_1.3.aarch64.rpm;name=aarch64_mod_lua;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_lua}"
SRC_URI[aarch64_mod_lua.sha256sum] = "bfa9289cf72296b17f40657f57c2de5884283a48bc39222e0283b337fb77a690"

URI_aarch64_mod_proxy_html = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_proxy_html-2.4.63-4.el10_1.3.aarch64.rpm;name=aarch64_mod_proxy_html;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_proxy_html}"
SRC_URI[aarch64_mod_proxy_html.sha256sum] = "7c36ef1b6264eef59c940b6631b22bd787c450e0ee26601e108fed6acb00451b"

URI_aarch64_mod_session = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_session-2.4.63-4.el10_1.3.aarch64.rpm;name=aarch64_mod_session;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_session}"
SRC_URI[aarch64_mod_session.sha256sum] = "85295f10b24c283252cdcbc0019fba4778d970e4bd4758c07b89dae80b3e999e"

URI_aarch64_mod_ssl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_ssl-2.4.63-4.el10_1.3.aarch64.rpm;name=aarch64_mod_ssl;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_ssl}"
SRC_URI[aarch64_mod_ssl.sha256sum] = "ec73a2c18f81c30a595df1286806a997f9534a0073c064ebaa6bdbd6ade26f12"

RDEPENDS:httpd = " \
 almalinux-logos-httpd \
 bash \
 glibc \
 httpd-core \
 libbrotli \
 libselinux \
 systemd \
 systemd-libs \
 "
RDEPENDS:httpd-core = " \
 apr \
 apr-util \
 apr-util-lmdb \
 bash \
 glibc \
 httpd-filesystem \
 httpd-tools \
 mailcap \
 pcre2 \
 zlib-ng-compat \
 "
RDEPENDS:httpd-devel = " \
 apr-devel \
 apr-util-devel \
 bash \
 httpd-core \
 libtool \
 perl-interpreter \
 perl-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:httpd-filesystem = " \
 bash \
 shadow-utils \
 "
RDEPENDS:httpd-manual = " \
 httpd-core \
 "
RDEPENDS:httpd-tools = " \
 apr \
 apr-util \
 glibc \
 libxcrypt \
 openssl-libs \
 "
RDEPENDS:mod_ldap = " \
 apr-util-ldap \
 glibc \
 httpd-core \
 openldap \
 "
RDEPENDS:mod_lua = " \
 glibc \
 httpd-core \
 libxcrypt \
 lua-libs \
 "
RDEPENDS:mod_proxy_html = " \
 glibc \
 httpd-core \
 libxml2 \
 "
RDEPENDS:mod_session = " \
 glibc \
 httpd-core \
 "
RDEPENDS:mod_ssl = " \
 bash \
 glibc \
 hostname \
 httpd-core \
 httpd-filesystem \
 openssl-libs \
 sscg \
 "
