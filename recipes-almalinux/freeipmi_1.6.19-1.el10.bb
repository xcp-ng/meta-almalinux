# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "freeipmi"
PV = "1.6.19"
PR = "1.el10"
PACKAGES = " \
 freeipmi \
 freeipmi-bmc-watchdog \
 freeipmi-devel \
 freeipmi-ipmidetectd \
 freeipmi-ipmiseld \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/freeipmi-1.6.19-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "db4e3ca75843cad1160c0906b0a9f323647b9bf697c19c51d19c0ce367a89110"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeipmi-1.6.19-1.el10.x86_64_v2.rpm;name=x86_64_v2_freeipmi;unpack=0"
SRC_URI[x86_64_v2_freeipmi.sha256sum] = "581bf9e745109d63bdec91e2fa3fde4f0dea2a13bfc74affecad7d022534e6e4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeipmi-bmc-watchdog-1.6.19-1.el10.x86_64_v2.rpm;name=x86_64_v2_freeipmi-bmc-watchdog;unpack=0"
SRC_URI[x86_64_v2_freeipmi-bmc-watchdog.sha256sum] = "5760778c608080079a567653003247e3933463a9d0b0ce806ccb0dab1fc72c12"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/freeipmi-devel-1.6.19-1.el10.x86_64_v2.rpm;name=x86_64_v2_freeipmi-devel;unpack=0"
SRC_URI[x86_64_v2_freeipmi-devel.sha256sum] = "0d5e26635126b03ebaba0f3d2a5ba78a37f822c30ec72757249532dc94373899"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeipmi-ipmidetectd-1.6.19-1.el10.x86_64_v2.rpm;name=x86_64_v2_freeipmi-ipmidetectd;unpack=0"
SRC_URI[x86_64_v2_freeipmi-ipmidetectd.sha256sum] = "41708b3bfed401070063b674a0afdefd5f6b3a5cd4a9d2b0f1a13bb191044276"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeipmi-ipmiseld-1.6.19-1.el10.x86_64_v2.rpm;name=x86_64_v2_freeipmi-ipmiseld;unpack=0"
SRC_URI[x86_64_v2_freeipmi-ipmiseld.sha256sum] = "19fc9f9ffaa43e0da922e4c6fd70ce4d1cdb2494fc9495878d4b2a8fba388ff8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeipmi-1.6.19-1.el10.aarch64.rpm;name=aarch64_freeipmi;unpack=0"
SRC_URI[aarch64_freeipmi.sha256sum] = "59fe18066a4c4c604adb46409b65575b4d40f16ee0bc704ee368212edea9c6ac"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeipmi-bmc-watchdog-1.6.19-1.el10.aarch64.rpm;name=aarch64_freeipmi-bmc-watchdog;unpack=0"
SRC_URI[aarch64_freeipmi-bmc-watchdog.sha256sum] = "e93e7461832bd02a7816c3563eedf18dcf1d5103780fe92a2cbff5433dcce5f0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/freeipmi-devel-1.6.19-1.el10.aarch64.rpm;name=aarch64_freeipmi-devel;unpack=0"
SRC_URI[aarch64_freeipmi-devel.sha256sum] = "a91c375c793c30e9ef025a9ac8e8941259771c7701e583b98688df59f1d172a4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeipmi-ipmidetectd-1.6.19-1.el10.aarch64.rpm;name=aarch64_freeipmi-ipmidetectd;unpack=0"
SRC_URI[aarch64_freeipmi-ipmidetectd.sha256sum] = "68a767c18e305aa8417bf81ff945e438026951d1b1cdc6ec3099d19a84ee9693"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeipmi-ipmiseld-1.6.19-1.el10.aarch64.rpm;name=aarch64_freeipmi-ipmiseld;unpack=0"
SRC_URI[aarch64_freeipmi-ipmiseld.sha256sum] = "beadcc7e2d857126aeab1ab37bac00da19d6c9ceaca374f2e8fad7a49caa9284"

RDEPENDS:freeipmi = " \
 bash \
 glibc \
 libgcrypt \
 systemd \
 "
RDEPENDS:freeipmi-bmc-watchdog = " \
 bash \
 freeipmi \
 glibc \
 "
RDEPENDS:freeipmi-devel = " \
 freeipmi \
 pkgconf-pkg-config \
 "
RDEPENDS:freeipmi-ipmidetectd = " \
 bash \
 freeipmi \
 glibc \
 "
RDEPENDS:freeipmi-ipmiseld = " \
 bash \
 freeipmi \
 glibc \
 "
