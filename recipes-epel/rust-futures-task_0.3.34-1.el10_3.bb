# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-task"
PV = "0.3.34"
PR = "1.el10_3"
PACKAGES = " \
 rust-futures-task+alloc-devel \
 rust-futures-task+cfg-target-has-atomic-devel \
 rust-futures-task+default-devel \
 rust-futures-task+std-devel \
 rust-futures-task+unstable-devel \
 rust-futures-task-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-futures-task-0.3.34-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cd9228d3a91d89146cb35b6f16d23806c486efdb6538b3525391423b474b031b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-task+alloc-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-task+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-task+alloc-devel.sha256sum] = "c8a4b4d1cb5c32c96e965cb872d98c24efe48102d2b8e57aa1b8b1c36f183b3c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-task+cfg-target-has-atomic-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-task+cfg-target-has-atomic-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-task+cfg-target-has-atomic-devel.sha256sum] = "2331391cad7a59badecbc45bb4dd9e0a61e0ba676496ae5b4ad5e939c48337be"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-task+default-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-task+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-task+default-devel.sha256sum] = "eef7e016e9c9fb35ae1938fab0a4b1ab0e30f3e436112029098d5583da305cc8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-task+std-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-task+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-task+std-devel.sha256sum] = "b8223135a8150887f4d191c8ca5410728fb0074f9c002c7e977c58322972767d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-task+unstable-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-task+unstable-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-task+unstable-devel.sha256sum] = "9df98e2a2f74907d7705519715b9f6c6d0c3d322ccf7a4daabad296b8cfa2b3a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-task-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-task-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-task-devel.sha256sum] = "4fc0832dfd2d53ea6ef5c4db67f7c159dcdd1b645f21694a5f2dd095642a401f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-task+alloc-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-task+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-futures-task+alloc-devel.sha256sum] = "71b7fe2ac93edacccfc1016cb66f50ea6c7a8c63045829020f2c1f6839e6f60f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-task+cfg-target-has-atomic-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-task+cfg-target-has-atomic-devel;unpack=0"
SRC_URI[aarch64_rust-futures-task+cfg-target-has-atomic-devel.sha256sum] = "b5ed00cd58ab49f4c96c6b0b82dbd2fe8707efd9f7556f4902eb68aac01c676b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-task+default-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-task+default-devel;unpack=0"
SRC_URI[aarch64_rust-futures-task+default-devel.sha256sum] = "fe0cc5ab51f8eb36062ecfda9bb8faf31bd0c38375fb253dc3d37f14285620a9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-task+std-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-task+std-devel;unpack=0"
SRC_URI[aarch64_rust-futures-task+std-devel.sha256sum] = "d5ec1f6bd32bf0d0d797e8a3b6c9d564dadac5d927596614148d0074bd59812f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-task+unstable-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-task+unstable-devel;unpack=0"
SRC_URI[aarch64_rust-futures-task+unstable-devel.sha256sum] = "584f56d0af0f34f35492b0289f65a263f407c4373bfa55f0a107422d3759d331"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-task-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-task-devel;unpack=0"
SRC_URI[aarch64_rust-futures-task-devel.sha256sum] = "b1bb264670e05478787c8ba62765e580acf1492536f01a210a046ffa98716d06"

RDEPENDS:rust-futures-task+alloc-devel = " \
 cargo \
 rust-futures-task-devel \
 "
RDEPENDS:rust-futures-task+cfg-target-has-atomic-devel = " \
 cargo \
 rust-futures-task-devel \
 "
RDEPENDS:rust-futures-task+default-devel = " \
 cargo \
 rust-futures-task+std-devel \
 rust-futures-task-devel \
 "
RDEPENDS:rust-futures-task+std-devel = " \
 cargo \
 rust-futures-task+alloc-devel \
 rust-futures-task-devel \
 "
RDEPENDS:rust-futures-task+unstable-devel = " \
 cargo \
 rust-futures-task-devel \
 "
RDEPENDS:rust-futures-task-devel = " \
 cargo \
 rust \
 "
