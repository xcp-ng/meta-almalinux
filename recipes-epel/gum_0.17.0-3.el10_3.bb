# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gum"
PV = "0.17.0"
PR = "3.el10_3"
PACKAGES = " \
 gum \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/gum-0.17.0-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "db4ed6073d43f4aec1aeeaec58e5236bc42c76270d42483f65c1833741342aec"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gum-0.17.0-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gum;unpack=0"
SRC_URI[x86_64_v2_gum.sha256sum] = "e357664f814540700ba2ad322faae6eaef2f1c48b02ad2ae826fa6f084f227b7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gum-0.17.0-3.el10_3.aarch64.rpm;name=aarch64_gum;unpack=0"
SRC_URI[aarch64_gum.sha256sum] = "2e91b8125e3e3b8684d2cb2a4aba66df7ffcfa83ee33fb3d9dc7e8117e095510"

RDEPENDS:gum = " \
 glibc \
 "
