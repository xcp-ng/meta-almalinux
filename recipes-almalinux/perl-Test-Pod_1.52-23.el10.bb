# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-Pod"
PV = "1.52"
PR = "23.el10"
PACKAGES = " \
 perl-Test-Pod \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Test-Pod-1.52-23.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e781e641072876fd7f67c684a26d4d9a9cb820b3edc460be3661960d313b61c3"

URI_x86_64_v2_perl-Test-Pod = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Test-Pod-1.52-23.el10.noarch.rpm;name=x86_64_v2_perl-Test-Pod;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-Pod}"
SRC_URI[x86_64_v2_perl-Test-Pod.sha256sum] = "a5a0c45dbdedc6d57d57057129b3ca2290d9253fb3133615edf49d32bc2c8e2b"

URI_aarch64_perl-Test-Pod = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Test-Pod-1.52-23.el10.noarch.rpm;name=aarch64_perl-Test-Pod;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-Pod}"
SRC_URI[aarch64_perl-Test-Pod.sha256sum] = "a5a0c45dbdedc6d57d57057129b3ca2290d9253fb3133615edf49d32bc2c8e2b"

RDEPENDS:perl-Test-Pod = " \
 perl-File-Find \
 perl-Pod-Simple \
 perl-Test-Simple \
 perl-libs \
 "
