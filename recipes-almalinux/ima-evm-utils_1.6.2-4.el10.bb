# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ima-evm-utils"
PV = "1.6.2"
PR = "4.el10"
PACKAGES = " \
 ima-evm-utils \
 ima-evm-utils-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/ima-evm-utils-1.6.2-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25bdc485ae594626e3144869c80d86ff2570749f729299bb1691f1041c428380"

URI_x86_64_v2_ima-evm-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ima-evm-utils-1.6.2-4.el10.x86_64_v2.rpm;name=x86_64_v2_ima-evm-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ima-evm-utils}"
SRC_URI[x86_64_v2_ima-evm-utils.sha256sum] = "5e1d5484e636fd34faeaee17853ba0c61461497a7601fd54ef8e8dc5c6e24ce0"

URI_x86_64_v2_ima-evm-utils-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ima-evm-utils-devel-1.6.2-4.el10.x86_64_v2.rpm;name=x86_64_v2_ima-evm-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ima-evm-utils-devel}"
SRC_URI[x86_64_v2_ima-evm-utils-devel.sha256sum] = "f7ebb42371c015cfd67a1b190662fa5206c37e70c804861c344208b0cfd87048"

URI_aarch64_ima-evm-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ima-evm-utils-1.6.2-4.el10.aarch64.rpm;name=aarch64_ima-evm-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_ima-evm-utils}"
SRC_URI[aarch64_ima-evm-utils.sha256sum] = "27ee14ea8ce70a80abe8f5b1c60306027bc78a9084a498cf24bccfef34f67f97"

URI_aarch64_ima-evm-utils-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ima-evm-utils-devel-1.6.2-4.el10.aarch64.rpm;name=aarch64_ima-evm-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ima-evm-utils-devel}"
SRC_URI[aarch64_ima-evm-utils-devel.sha256sum] = "ee61d70e44d86514d3c259a84c770a3e21cc183049512559c97eb9c5aa8534b7"

RDEPENDS:ima-evm-utils = " \
 attr \
 bash \
 glibc \
 keyutils \
 keyutils-libs \
 openssl-libs \
 tpm2-tss \
 "
RDEPENDS:ima-evm-utils-devel = " \
 ima-evm-utils \
 "
