# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "stdair"
PV = "1.00.21"
PR = "1.el10_2"
PACKAGES = " \
 stdair \
 stdair-devel \
 stdair-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/stdair-1.00.21-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2eb917b0e16f34e472b15bbf94fabf4192a7ff5976aa1ebdef609b26bae480aa"

URI_x86_64_v2_stdair = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stdair-1.00.21-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stdair;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stdair}"
SRC_URI[x86_64_v2_stdair.sha256sum] = "bfe7b5fcb9b7163e44bc090a554808b2dfdf7264411d75e66fbb4c0ae0d83e4f"

URI_x86_64_v2_stdair-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stdair-devel-1.00.21-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stdair-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stdair-devel}"
SRC_URI[x86_64_v2_stdair-devel.sha256sum] = "a6ff666b723b8e50ed278be1ba8f70acbdc38bbd00a527857021d7cd0e58f647"

URI_x86_64_v2_stdair-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stdair-doc-1.00.21-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stdair-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stdair-doc}"
SRC_URI[x86_64_v2_stdair-doc.sha256sum] = "a692385cd1ba50365e4cb79d57fe5c4d234f6ddabd2f80b10db5579dab89e9a6"

URI_aarch64_stdair = "${EPEL_MIRROR}/aarch64/Packages/s/stdair-1.00.21-1.el10_2.aarch64.rpm;name=aarch64_stdair;unpack=0"
SRC_URI:append = " ${URI_aarch64_stdair}"
SRC_URI[aarch64_stdair.sha256sum] = "08826abb6962a4bb041a8ef60807df3f5df8a5e5823cc9700b10339374727d69"

URI_aarch64_stdair-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stdair-devel-1.00.21-1.el10_2.aarch64.rpm;name=aarch64_stdair-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stdair-devel}"
SRC_URI[aarch64_stdair-devel.sha256sum] = "f67320fbe12f235f07c2b922a8a4649dda407d9bc9eed65ebd3b1bfe7ae4705a"

URI_aarch64_stdair-doc = "${EPEL_MIRROR}/aarch64/Packages/s/stdair-doc-1.00.21-1.el10_2.aarch64.rpm;name=aarch64_stdair-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_stdair-doc}"
SRC_URI[aarch64_stdair-doc.sha256sum] = "010c5451a1462fcef4e210ca5534315ae79a927058db7376a71b211be2befd25"

RDEPENDS:stdair = " \
 bash \
 boost-filesystem \
 boost-program-options \
 boost-serialization \
 glibc \
 libgcc \
 libstdc++ \
 soci \
 soci-mysql \
 "
RDEPENDS:stdair-devel = " \
 bash \
 cmake-filesystem \
 pkgconf-pkg-config \
 stdair \
 "
RDEPENDS:stdair-doc = " \
 "
