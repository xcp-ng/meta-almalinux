# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tinyproxy"
PV = "1.11.2"
PR = "2.el10_0"
PACKAGES = " \
 tinyproxy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tinyproxy-1.11.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5d691184ecfedc8ac7747d142e6c4950c58130ac78c8d61ab3c0f2fe185e7e9b"

URI_x86_64_v2_tinyproxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tinyproxy-1.11.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tinyproxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tinyproxy}"
SRC_URI[x86_64_v2_tinyproxy.sha256sum] = "be804911886cd86f3ba6208d2abc63f494bf33eabdc57f61f3c9dc7a3d7180a8"

URI_aarch64_tinyproxy = "${EPEL_MIRROR}/aarch64/Packages/t/tinyproxy-1.11.2-2.el10_0.aarch64.rpm;name=aarch64_tinyproxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_tinyproxy}"
SRC_URI[aarch64_tinyproxy.sha256sum] = "09a633d62d6f95d188b64ac7c90dd773bab5bb31bd2ab1b09c0173aceaad7b3f"

RDEPENDS:tinyproxy = " \
 bash \
 glibc \
 "
