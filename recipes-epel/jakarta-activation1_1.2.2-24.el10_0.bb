# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jakarta-activation1"
PV = "1.2.2"
PR = "24.el10_0"
PACKAGES = " \
 jakarta-activation1 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/jakarta-activation1-1.2.2-24.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2b59b2477f0716551fbd1a43bd08735bd2b516275f1fd326326c1139594d30dc"

URI_x86_64_v2_jakarta-activation1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jakarta-activation1-1.2.2-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_jakarta-activation1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jakarta-activation1}"
SRC_URI[x86_64_v2_jakarta-activation1.sha256sum] = "45dd4753b69b3225817d8c94fefb7e31cfe937ee1f74ada27eded1937dc57593"

URI_aarch64_jakarta-activation1 = "${EPEL_MIRROR}/aarch64/Packages/j/jakarta-activation1-1.2.2-24.el10_0.noarch.rpm;name=aarch64_jakarta-activation1;unpack=0"
SRC_URI:append = " ${URI_aarch64_jakarta-activation1}"
SRC_URI[aarch64_jakarta-activation1.sha256sum] = "edeec4c52f9b5dee071a9010795dbe1ec5a0a1edc34f6b9e2db9528b6de5db0c"

RDEPENDS:jakarta-activation1 = " \
 javapackages-filesystem \
 "
