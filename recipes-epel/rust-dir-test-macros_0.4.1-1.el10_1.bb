# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dir-test-macros"
PV = "0.4.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-dir-test-macros+default-devel \
 rust-dir-test-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dir-test-macros-0.4.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf5d65449e9d58a1cadd180335b0a69bcb2e926f0be0e64547ce718afd6e72be"

URI_x86_64_v2_rust-dir-test-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dir-test-macros+default-devel-0.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dir-test-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dir-test-macros+default-devel}"
SRC_URI[x86_64_v2_rust-dir-test-macros+default-devel.sha256sum] = "ca2788af804bcb083e8f43bba962dfde3f3535241b9fd4c7c5c62290b1ff94c8"

URI_x86_64_v2_rust-dir-test-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dir-test-macros-devel-0.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dir-test-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dir-test-macros-devel}"
SRC_URI[x86_64_v2_rust-dir-test-macros-devel.sha256sum] = "ce835e4c4a4b9ef02388f10fc91a7e236d01443463e34e05b4f640dc514ff57a"

URI_aarch64_rust-dir-test-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dir-test-macros+default-devel-0.4.1-1.el10_1.noarch.rpm;name=aarch64_rust-dir-test-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dir-test-macros+default-devel}"
SRC_URI[aarch64_rust-dir-test-macros+default-devel.sha256sum] = "3863f3b2118877d087de819c429fcd8056a1a80603291261eebdcb2d9f1fcef7"

URI_aarch64_rust-dir-test-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dir-test-macros-devel-0.4.1-1.el10_1.noarch.rpm;name=aarch64_rust-dir-test-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dir-test-macros-devel}"
SRC_URI[aarch64_rust-dir-test-macros-devel.sha256sum] = "63609fc83cf71fde6e67de517cf8a86da113cab24ff347499bab3392545cf2c8"

RDEPENDS:rust-dir-test-macros+default-devel = " \
 cargo \
 rust-dir-test-macros-devel \
 "
RDEPENDS:rust-dir-test-macros-devel = " \
 cargo \
 rust-glob+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
