# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sslh"
PV = "2.3.1"
PR = "4.el10_3"
PACKAGES = " \
 sslh \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sslh-2.3.1-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ddc27dbd67be95d3820c9aa1057e04f2182706fdeebd8e90fcbdc5b1ef14048"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - sslh: libcap.so.2()(64bit)

URI_x86_64_v2_sslh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sslh-2.3.1-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sslh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sslh}"
SRC_URI[x86_64_v2_sslh.sha256sum] = "7b80b77dcfcc9b5da6898fb943500fb533353c210f735e5f786a66abeda87fc9"

URI_aarch64_sslh = "${EPEL_MIRROR}/aarch64/Packages/s/sslh-2.3.1-4.el10_3.aarch64.rpm;name=aarch64_sslh;unpack=0"
SRC_URI:append = " ${URI_aarch64_sslh}"
SRC_URI[aarch64_sslh.sha256sum] = "ee49125a29b9f78ed3d37e4cd33beb9dfbab1a7d1916ff4e0939ce6514cafd83"

RDEPENDS:sslh:x86_64_v2 = " \
 bash \
 glibc \
 libbsd \
 libcap \
 libconfig \
 libev \
 pcre2 \
 systemd-libs \
"
RDEPENDS:sslh:aarch64 = " \
 bash \
 glibc \
 libbsd \
 libconfig \
 libev \
 pcre2 \
 systemd-libs \
"
