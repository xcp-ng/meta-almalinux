# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-partitionmanager"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kde-partitionmanager \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kde-partitionmanager-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4468a1d9921042d55a300164ad6fa568d74420bdc60c0674432886faf4be015"

URI_x86_64_v2_kde-partitionmanager = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-partitionmanager-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-partitionmanager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-partitionmanager}"
SRC_URI[x86_64_v2_kde-partitionmanager.sha256sum] = "5437448f8790a20ea9c6cd69063f11bce0d23471373660f31295bb62632d03c5"

URI_aarch64_kde-partitionmanager = "${EPEL_MIRROR}/aarch64/Packages/k/kde-partitionmanager-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kde-partitionmanager;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-partitionmanager}"
SRC_URI[aarch64_kde-partitionmanager.sha256sum] = "3640f5e41535fe1060932ad8f6259fe50978d74659fd7312b8c01dc78b9ba51f"

RDEPENDS:kde-partitionmanager = " \
 glibc \
 kf6-filesystem \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kpmcore \
 libstdc++ \
 polkit-qt6-1 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
