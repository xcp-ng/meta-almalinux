# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opkssh"
PV = "0.16.0"
PR = "3.el10_2"
PACKAGES = " \
 opkssh \
 opkssh-doc \
 opkssh-server \
 opkssh-server-selinux \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/o/opkssh-0.16.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0f612c3ebafcdba04b589bbf817f1bfe030808fbd17f3c4572ff92ac072136ab"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opkssh-0.16.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opkssh;unpack=0"
SRC_URI[x86_64_v2_opkssh.sha256sum] = "4ed3b00ea3b0d3516c0de4942f8aa644cd1fc4114538af85fee2a242a7195844"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opkssh-doc-0.16.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_opkssh-doc;unpack=0"
SRC_URI[x86_64_v2_opkssh-doc.sha256sum] = "0a4bd1a09ecb3cbb9eba0a6f288d6a3e38922670230d524d2cb8b3cf7afe5ef2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opkssh-server-0.16.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_opkssh-server;unpack=0"
SRC_URI[x86_64_v2_opkssh-server.sha256sum] = "85044b0acf9e7f3823b7e0cda079fe6d7c9076bfd8fac4c6d920056b01c7c4df"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opkssh-server-selinux-0.16.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_opkssh-server-selinux;unpack=0"
SRC_URI[x86_64_v2_opkssh-server-selinux.sha256sum] = "da7ac7a4ab443feb960699fd878e011efcdd9770609536e21ff0bff8d62f0d83"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/opkssh-0.16.0-3.el10_2.aarch64.rpm;name=aarch64_opkssh;unpack=0"
SRC_URI[aarch64_opkssh.sha256sum] = "ec8fc903d7f46fddb72cc956ec134c6b1543877d01b7e0d64d436be2dd7a4633"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/opkssh-doc-0.16.0-3.el10_2.noarch.rpm;name=aarch64_opkssh-doc;unpack=0"
SRC_URI[aarch64_opkssh-doc.sha256sum] = "bb13eb277a76ad780f571b25872aaa8f3c245cbad015ba49ccf8a3cf3794db89"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/opkssh-server-0.16.0-3.el10_2.noarch.rpm;name=aarch64_opkssh-server;unpack=0"
SRC_URI[aarch64_opkssh-server.sha256sum] = "f3bb462a5a9b5d7982a4bc0509058e4a17f767eb23165167ab9620f52225f2ad"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/opkssh-server-selinux-0.16.0-3.el10_2.noarch.rpm;name=aarch64_opkssh-server-selinux;unpack=0"
SRC_URI[aarch64_opkssh-server-selinux.sha256sum] = "1a8f35d1c586da3a2fb22b383f8a384a1518c40b146fae5c1734fb1a0fb98de2"

RDEPENDS:opkssh = " \
 glibc \
 shadow-utils \
 "
RDEPENDS:opkssh-doc = " \
 "
RDEPENDS:opkssh-server = " \
 bash \
 opkssh \
 opkssh-server-selinux \
 "
RDEPENDS:opkssh-server-selinux = " \
 bash \
 selinux-policy-targeted \
 "
