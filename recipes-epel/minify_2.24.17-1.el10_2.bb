# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "minify"
PV = "2.24.17"
PR = "1.el10_2"
PACKAGES = " \
 minify \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/minify-2.24.17-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9bf4beaa0722a3c4753f09c183df92965633fa9a327980c59b4a6f283ad13997"

URI_x86_64_v2_minify = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/minify-2.24.17-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_minify;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_minify}"
SRC_URI[x86_64_v2_minify.sha256sum] = "0e3eea7ea3ff3cc98a2899c63e6239e65ab8b849e667818f461132b40d1b5eb1"

URI_aarch64_minify = "${EPEL_MIRROR}/aarch64/Packages/m/minify-2.24.17-1.el10_2.aarch64.rpm;name=aarch64_minify;unpack=0"
SRC_URI:append = " ${URI_aarch64_minify}"
SRC_URI[aarch64_minify.sha256sum] = "89aa47b587fab241296cd347014b09fafb0e2a454f1c33837dea897553824ca4"

RDEPENDS:minify = " \
 glibc \
 "
