# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-timer"
PV = "3.0.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-futures-timer+default-devel \
 rust-futures-timer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-timer-3.0.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1df66687ab7a917a9a56dbc53cd24462e10eb9aaeabde167f1c0d3b36815bcb7"

URI_x86_64_v2_rust-futures-timer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-timer+default-devel-3.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-timer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-timer+default-devel}"
SRC_URI[x86_64_v2_rust-futures-timer+default-devel.sha256sum] = "0068abb3e97e101af5b7f37315cea412ad6229d8e181b9f90a7c82bd1097fbda"

URI_x86_64_v2_rust-futures-timer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-timer-devel-3.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-timer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-timer-devel}"
SRC_URI[x86_64_v2_rust-futures-timer-devel.sha256sum] = "fcbfd9938008c4974f949dafeede4c69596f8b6034e2826d75df162a5f9784b5"

URI_aarch64_rust-futures-timer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-timer+default-devel-3.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-futures-timer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-timer+default-devel}"
SRC_URI[aarch64_rust-futures-timer+default-devel.sha256sum] = "23a4e0aef594b6370525fd8bde6fb37cef10cadd27f518bd4315bc416fcf77e5"

URI_aarch64_rust-futures-timer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-timer-devel-3.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-futures-timer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-timer-devel}"
SRC_URI[aarch64_rust-futures-timer-devel.sha256sum] = "d3f5c37ce4a3e9c7bb8b7b41126fa6986b0d04c700587837e9c52b34d5329da2"

RDEPENDS:rust-futures-timer+default-devel = " \
 cargo \
 rust-futures-timer-devel \
 "
RDEPENDS:rust-futures-timer-devel = " \
 cargo \
 "
