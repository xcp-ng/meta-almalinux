# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kpmcore"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kpmcore \
 kpmcore-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kpmcore-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "68fed1f5b8cc12d25782bd067a06aa910d9086e7c2eb8074ba984cd2920702fb"

URI_x86_64_v2_kpmcore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpmcore-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpmcore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpmcore}"
SRC_URI[x86_64_v2_kpmcore.sha256sum] = "90e3b367a540abff8a09ed3c850e8d5c6a3d8e59b026ff9358ba2eb6ed94718b"

URI_x86_64_v2_kpmcore-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpmcore-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpmcore-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpmcore-devel}"
SRC_URI[x86_64_v2_kpmcore-devel.sha256sum] = "b41dd9af7bc3ad2d6ef32cf6b21719cdf53cd276d3c7465487fbbd41032bd890"

URI_aarch64_kpmcore = "${EPEL_MIRROR}/aarch64/Packages/k/kpmcore-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kpmcore;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpmcore}"
SRC_URI[aarch64_kpmcore.sha256sum] = "b0dc50231ba82509a5fbf31abb7f155d887f60eb6ea63841d6f5c7bad02abe73"

URI_aarch64_kpmcore-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kpmcore-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kpmcore-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpmcore-devel}"
SRC_URI[aarch64_kpmcore-devel.sha256sum] = "673391462a5625fcc084756380132c3119ca22bc45c53a41517988ff58ac7785"

RDEPENDS:kpmcore = " \
 e2fsprogs \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libblkid \
 libgcc \
 libstdc++ \
 polkit-qt6-1 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kpmcore-devel = " \
 cmake-filesystem \
 kpmcore \
 qt6-qtbase-devel \
 "
