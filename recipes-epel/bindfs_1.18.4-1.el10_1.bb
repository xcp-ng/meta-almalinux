# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bindfs"
PV = "1.18.4"
PR = "1.el10_1"
PACKAGES = " \
 bindfs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bindfs-1.18.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "34f958260cbf9af38689ff53448f4bba49803f0ef9be303072ea7ec84c9c58a1"

URI_x86_64_v2_bindfs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bindfs-1.18.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bindfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bindfs}"
SRC_URI[x86_64_v2_bindfs.sha256sum] = "9feb0c619d9105dd45cff627d13c3c99d24656d438f1f43f06da4c4f02bbfa1c"

URI_aarch64_bindfs = "${EPEL_MIRROR}/aarch64/Packages/b/bindfs-1.18.4-1.el10_1.aarch64.rpm;name=aarch64_bindfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_bindfs}"
SRC_URI[aarch64_bindfs.sha256sum] = "373b25204cad1103cb3f8836279da59736283a91b48d3d99c241279d70b53e87"

RDEPENDS:bindfs = " \
 fuse3 \
 fuse3-libs \
 glibc \
 "
