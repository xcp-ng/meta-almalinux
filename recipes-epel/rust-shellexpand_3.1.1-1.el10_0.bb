# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-shellexpand"
PV = "3.1.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-shellexpand+base-0-devel \
 rust-shellexpand+bstr-devel \
 rust-shellexpand+default-devel \
 rust-shellexpand+dirs-devel \
 rust-shellexpand+full-devel \
 rust-shellexpand+full-msrv-1-31-devel \
 rust-shellexpand+full-msrv-1-51-devel \
 rust-shellexpand+os_str_bytes-devel \
 rust-shellexpand+path-devel \
 rust-shellexpand+tilde-devel \
 rust-shellexpand-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-shellexpand-3.1.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "302d267f68ecb25591f46d077d340e9187de2b444ba7f7acb0de4e692f5efc21"

URI_x86_64_v2_rust-shellexpand+base-0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+base-0-devel-3.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+base-0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shellexpand+base-0-devel}"
SRC_URI[x86_64_v2_rust-shellexpand+base-0-devel.sha256sum] = "b885d38f67e924810480975406689fe53d0607992d721228da6c065f41c8216f"

URI_x86_64_v2_rust-shellexpand+bstr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+bstr-devel-3.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+bstr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shellexpand+bstr-devel}"
SRC_URI[x86_64_v2_rust-shellexpand+bstr-devel.sha256sum] = "ee44b5f611a4c20a72f786dfcff393516c5a34eba1d766bd1d15c0a3f0bd1505"

URI_x86_64_v2_rust-shellexpand+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+default-devel-3.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shellexpand+default-devel}"
SRC_URI[x86_64_v2_rust-shellexpand+default-devel.sha256sum] = "b2f3c9ff331dd38323632d5c7efceb8754944f01a4f1434048ef6233918f390c"

URI_x86_64_v2_rust-shellexpand+dirs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+dirs-devel-3.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+dirs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shellexpand+dirs-devel}"
SRC_URI[x86_64_v2_rust-shellexpand+dirs-devel.sha256sum] = "33b0db838323c55bcb9018c29166193300195e240cf0d5c3dca1508be9d4c5ea"

URI_x86_64_v2_rust-shellexpand+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+full-devel-3.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shellexpand+full-devel}"
SRC_URI[x86_64_v2_rust-shellexpand+full-devel.sha256sum] = "48fe6a7ecaca361b55ddd033e6793775cfb0cfb8877a711a267e49a512243cb6"

URI_x86_64_v2_rust-shellexpand+full-msrv-1-31-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+full-msrv-1-31-devel-3.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+full-msrv-1-31-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shellexpand+full-msrv-1-31-devel}"
SRC_URI[x86_64_v2_rust-shellexpand+full-msrv-1-31-devel.sha256sum] = "a5cd0e93aa961c2df9240c2e137dafc0635ce657963fede02783935ca2a1077a"

URI_x86_64_v2_rust-shellexpand+full-msrv-1-51-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+full-msrv-1-51-devel-3.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+full-msrv-1-51-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shellexpand+full-msrv-1-51-devel}"
SRC_URI[x86_64_v2_rust-shellexpand+full-msrv-1-51-devel.sha256sum] = "b0a0099dbef7e1240a4924b7e98ec1c0e17b42ad541a4034d864ae90b987980a"

URI_x86_64_v2_rust-shellexpand+os_str_bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+os_str_bytes-devel-3.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+os_str_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shellexpand+os_str_bytes-devel}"
SRC_URI[x86_64_v2_rust-shellexpand+os_str_bytes-devel.sha256sum] = "b6373ec3c83152d8be7b01180107672d53cd345c3b1cd6309ead56fbcc38509d"

URI_x86_64_v2_rust-shellexpand+path-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+path-devel-3.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+path-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shellexpand+path-devel}"
SRC_URI[x86_64_v2_rust-shellexpand+path-devel.sha256sum] = "4c91c447002451c6ed2a108c9adb5fc134c54837a62ada9e7abdb7d1e713a369"

URI_x86_64_v2_rust-shellexpand+tilde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+tilde-devel-3.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+tilde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shellexpand+tilde-devel}"
SRC_URI[x86_64_v2_rust-shellexpand+tilde-devel.sha256sum] = "e1d3d91b7426acd3208f45cce6cf70ce9545fe16a5736e115dc38f8302e8c192"

URI_x86_64_v2_rust-shellexpand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand-devel-3.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shellexpand-devel}"
SRC_URI[x86_64_v2_rust-shellexpand-devel.sha256sum] = "adcea3f82d9d580e4c80c89b6812e04a811cdc2e19ea47ed1000768b54e90805"

URI_aarch64_rust-shellexpand+base-0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+base-0-devel-3.1.1-1.el10_0.noarch.rpm;name=aarch64_rust-shellexpand+base-0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shellexpand+base-0-devel}"
SRC_URI[aarch64_rust-shellexpand+base-0-devel.sha256sum] = "8f9a50432af8c04bee48bd1c71b30be5b329ac22b42bdb0724412653d233d4b4"

URI_aarch64_rust-shellexpand+bstr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+bstr-devel-3.1.1-1.el10_0.noarch.rpm;name=aarch64_rust-shellexpand+bstr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shellexpand+bstr-devel}"
SRC_URI[aarch64_rust-shellexpand+bstr-devel.sha256sum] = "fdbb5eedec5b1cd0acdc7c8cdd77e723dcd67e4f3c5b3d572a97a16a9f30662c"

URI_aarch64_rust-shellexpand+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+default-devel-3.1.1-1.el10_0.noarch.rpm;name=aarch64_rust-shellexpand+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shellexpand+default-devel}"
SRC_URI[aarch64_rust-shellexpand+default-devel.sha256sum] = "18b718646b9f5eaab60cbb24a9a058ca4b60ef0210b4423e85544f32d8f4fe21"

URI_aarch64_rust-shellexpand+dirs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+dirs-devel-3.1.1-1.el10_0.noarch.rpm;name=aarch64_rust-shellexpand+dirs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shellexpand+dirs-devel}"
SRC_URI[aarch64_rust-shellexpand+dirs-devel.sha256sum] = "256598845021ede23129316ed182fc811290810dd80251ca2506a7174ea75d05"

URI_aarch64_rust-shellexpand+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+full-devel-3.1.1-1.el10_0.noarch.rpm;name=aarch64_rust-shellexpand+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shellexpand+full-devel}"
SRC_URI[aarch64_rust-shellexpand+full-devel.sha256sum] = "c0c7240f43239bb318092b3caa39f25c6fb68ad15d33fe38b31133d31f300e8a"

URI_aarch64_rust-shellexpand+full-msrv-1-31-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+full-msrv-1-31-devel-3.1.1-1.el10_0.noarch.rpm;name=aarch64_rust-shellexpand+full-msrv-1-31-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shellexpand+full-msrv-1-31-devel}"
SRC_URI[aarch64_rust-shellexpand+full-msrv-1-31-devel.sha256sum] = "704dc6d578e0bcffdfcaf5d79c94b78f42178cd53ebf26a70e92d54194d954d4"

URI_aarch64_rust-shellexpand+full-msrv-1-51-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+full-msrv-1-51-devel-3.1.1-1.el10_0.noarch.rpm;name=aarch64_rust-shellexpand+full-msrv-1-51-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shellexpand+full-msrv-1-51-devel}"
SRC_URI[aarch64_rust-shellexpand+full-msrv-1-51-devel.sha256sum] = "90941ed264f3afeedd868bafedc5420ecccb24a864a4905550adceb2c3c40dc4"

URI_aarch64_rust-shellexpand+os_str_bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+os_str_bytes-devel-3.1.1-1.el10_0.noarch.rpm;name=aarch64_rust-shellexpand+os_str_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shellexpand+os_str_bytes-devel}"
SRC_URI[aarch64_rust-shellexpand+os_str_bytes-devel.sha256sum] = "9c36b199f4d3dbf0878790e76d4c42114c9706f67e38f94ea48320eb59b9774b"

URI_aarch64_rust-shellexpand+path-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+path-devel-3.1.1-1.el10_0.noarch.rpm;name=aarch64_rust-shellexpand+path-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shellexpand+path-devel}"
SRC_URI[aarch64_rust-shellexpand+path-devel.sha256sum] = "61faad6d2e501a14e980f18946e3a8e0f852dace1f25409ea05146eb573d3f9d"

URI_aarch64_rust-shellexpand+tilde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+tilde-devel-3.1.1-1.el10_0.noarch.rpm;name=aarch64_rust-shellexpand+tilde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shellexpand+tilde-devel}"
SRC_URI[aarch64_rust-shellexpand+tilde-devel.sha256sum] = "06363c8d59389962874e05d9295fb81409f1673a2a777b2e9837f3da975851a4"

URI_aarch64_rust-shellexpand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand-devel-3.1.1-1.el10_0.noarch.rpm;name=aarch64_rust-shellexpand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shellexpand-devel}"
SRC_URI[aarch64_rust-shellexpand-devel.sha256sum] = "ac447b0ddfab8c7ddfff3e59056b2ce2491f762939474b406923262dbeeb4a32"

RDEPENDS:rust-shellexpand+base-0-devel = " \
 cargo \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+bstr-devel = " \
 cargo \
 rust-bstr+default-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+default-devel = " \
 cargo \
 rust-shellexpand+base-0-devel \
 rust-shellexpand+tilde-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+dirs-devel = " \
 cargo \
 rust-dirs+default-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+full-devel = " \
 cargo \
 rust-shellexpand+full-msrv-1-51-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+full-msrv-1-31-devel = " \
 cargo \
 rust-shellexpand+base-0-devel \
 rust-shellexpand+tilde-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+full-msrv-1-51-devel = " \
 cargo \
 rust-shellexpand+full-msrv-1-31-devel \
 rust-shellexpand+path-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+os_str_bytes-devel = " \
 cargo \
 rust-os_str_bytes+default-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+path-devel = " \
 cargo \
 rust-shellexpand+bstr-devel \
 rust-shellexpand+os_str_bytes-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+tilde-devel = " \
 cargo \
 rust-shellexpand+dirs-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand-devel = " \
 bash \
 cargo \
 rust \
 "
