# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-strum_macros0.21"
PV = "0.21.1"
PR = "8.el10_0"
PACKAGES = " \
 rust-strum_macros0.21+default-devel \
 rust-strum_macros0.21-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-strum_macros0.21-0.21.1-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b4a2b90e9ae62ae0ff5b2d8f86a1022afb3c5c618c11e2bb9b9f64a5751af5a2"

URI_x86_64_v2_rust-strum_macros0.21+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum_macros0.21+default-devel-0.21.1-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum_macros0.21+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum_macros0.21+default-devel}"
SRC_URI[x86_64_v2_rust-strum_macros0.21+default-devel.sha256sum] = "44bdb97845fefd6cc5291e43ba230407f57e9be9fa8d0ea8428ed6b49ee2ba06"

URI_x86_64_v2_rust-strum_macros0.21-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum_macros0.21-devel-0.21.1-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum_macros0.21-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum_macros0.21-devel}"
SRC_URI[x86_64_v2_rust-strum_macros0.21-devel.sha256sum] = "be6c12be98080ce08dd165da0d3d1c4e2506834638cf8a1fd204c19f49b0f805"

URI_aarch64_rust-strum_macros0.21+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum_macros0.21+default-devel-0.21.1-8.el10_0.noarch.rpm;name=aarch64_rust-strum_macros0.21+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum_macros0.21+default-devel}"
SRC_URI[aarch64_rust-strum_macros0.21+default-devel.sha256sum] = "b2c8805c2867064405a5344afc035ee360a10eca040cc6fd4ccff335f4b3c6d3"

URI_aarch64_rust-strum_macros0.21-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum_macros0.21-devel-0.21.1-8.el10_0.noarch.rpm;name=aarch64_rust-strum_macros0.21-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum_macros0.21-devel}"
SRC_URI[aarch64_rust-strum_macros0.21-devel.sha256sum] = "1b18c58a937209a9f6c6f77ec83823d05a37cefba4454afe15f4b374405b8b04"

RDEPENDS:rust-strum_macros0.21+default-devel = " \
 cargo \
 rust-strum_macros0.21-devel \
 "
RDEPENDS:rust-strum_macros0.21-devel = " \
 cargo \
 rust-heck0.3+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn1+default-devel \
 rust-syn1+extra-traits-devel \
 rust-syn1+parsing-devel \
 "
