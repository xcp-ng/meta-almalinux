# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-termios"
PV = "0.3.3"
PR = "13.el10_2"
PACKAGES = " \
 rust-termios+default-devel \
 rust-termios-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-termios-0.3.3-13.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eb10c37b66a72efbb877fcb37e8b3adec31e6cbfe396bb8b581c31738bd04856"

URI_x86_64_v2_rust-termios+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-termios+default-devel-0.3.3-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-termios+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-termios+default-devel}"
SRC_URI[x86_64_v2_rust-termios+default-devel.sha256sum] = "f10009b127872af901c34c6763208069e3a0d0b03a5d27187aaad1005c285509"

URI_x86_64_v2_rust-termios-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-termios-devel-0.3.3-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-termios-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-termios-devel}"
SRC_URI[x86_64_v2_rust-termios-devel.sha256sum] = "4f4c3a0f4606247c2b01c5e243955ddce5e2697ec4722c419c436f47d004cdc4"

URI_aarch64_rust-termios+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-termios+default-devel-0.3.3-13.el10_2.noarch.rpm;name=aarch64_rust-termios+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-termios+default-devel}"
SRC_URI[aarch64_rust-termios+default-devel.sha256sum] = "2a743edc82d9371ef5b95322a87ae97581f4333a9a24b42d677029bb43ca1449"

URI_aarch64_rust-termios-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-termios-devel-0.3.3-13.el10_2.noarch.rpm;name=aarch64_rust-termios-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-termios-devel}"
SRC_URI[aarch64_rust-termios-devel.sha256sum] = "97bbbde97e22db27401f2f42da472ab6c30f25204057e29c669e148ab8414320"

RDEPENDS:rust-termios+default-devel = " \
 cargo \
 rust-termios-devel \
 "
RDEPENDS:rust-termios-devel = " \
 cargo \
 rust-libc+default-devel \
 "
