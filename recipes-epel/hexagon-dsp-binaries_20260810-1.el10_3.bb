# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hexagon-dsp-binaries"
PV = "20260810"
PR = "1.el10_3"
PACKAGES = " \
 hexagon-dsp-binaries \
 hexagon-dsp-binaries-arduino-monza \
 hexagon-dsp-binaries-qualcomm-db410c \
 hexagon-dsp-binaries-qualcomm-db820c \
 hexagon-dsp-binaries-qualcomm-glymur-crd \
 hexagon-dsp-binaries-qualcomm-hamoa-iot-evk \
 hexagon-dsp-binaries-qualcomm-iq8275-evk \
 hexagon-dsp-binaries-qualcomm-iq9075-evk \
 hexagon-dsp-binaries-qualcomm-kaanapali-mtp \
 hexagon-dsp-binaries-qualcomm-purwa-iot-evk \
 hexagon-dsp-binaries-qualcomm-qcm6490-idp \
 hexagon-dsp-binaries-qualcomm-qcs615-ride \
 hexagon-dsp-binaries-qualcomm-qcs8300-ride \
 hexagon-dsp-binaries-qualcomm-sa8775p-ride \
 hexagon-dsp-binaries-qualcomm-sdm845-hdk \
 hexagon-dsp-binaries-qualcomm-shikra-cqm-evk \
 hexagon-dsp-binaries-qualcomm-shikra-cqs-evk \
 hexagon-dsp-binaries-qualcomm-shikra-iqs-evk \
 hexagon-dsp-binaries-qualcomm-sm8750-mtp \
 hexagon-dsp-binaries-radxa-dragon-q6a \
 hexagon-dsp-binaries-thundercomm-db845c \
 hexagon-dsp-binaries-thundercomm-rb1 \
 hexagon-dsp-binaries-thundercomm-rb2 \
 hexagon-dsp-binaries-thundercomm-rb3gen2 \
 hexagon-dsp-binaries-thundercomm-rb5 \
 hexagon-dsp-binaries-thundercomm-rubikpi3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/hexagon-dsp-binaries-20260810-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bebec22c075c306ad53f9ebb79ece932ec27a1c186ad6c4275f3fbb1ec7e9c2d"

URI_aarch64_hexagon-dsp-binaries = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-20260810-1.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries}"
SRC_URI[aarch64_hexagon-dsp-binaries.sha256sum] = "640bac79e3e71a5b249c4e825e16e9dfa41e461118aab739f96a3b781b529100"

URI_aarch64_hexagon-dsp-binaries-arduino-monza = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-arduino-monza-20260810-1.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-arduino-monza;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-arduino-monza}"
SRC_URI[aarch64_hexagon-dsp-binaries-arduino-monza.sha256sum] = "e75b50948cbd2857abddd289347343809d0596f231e581df5a02fa3361213f60"

URI_aarch64_hexagon-dsp-binaries-qualcomm-db410c = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-db410c-20260810-1.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-db410c;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-db410c}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-db410c.sha256sum] = "0f0b169582f1c7fe568f44e77e4eddbb904d09b698976e1ea38de9af3a4d02f3"

URI_aarch64_hexagon-dsp-binaries-qualcomm-db820c = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-db820c-20260810-1.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-db820c;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-db820c}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-db820c.sha256sum] = "f7a71a07723e4d03aa104e00249576532d5622df10802cfe9d5602b37e788d6f"

URI_aarch64_hexagon-dsp-binaries-qualcomm-glymur-crd = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-glymur-crd-20260810-1.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-glymur-crd;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-glymur-crd}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-glymur-crd.sha256sum] = "5c54869a906936eaa56a122133597109565c31f5dd869eab27188784553cf630"

URI_aarch64_hexagon-dsp-binaries-qualcomm-hamoa-iot-evk = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-hamoa-iot-evk-20260810-1.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-hamoa-iot-evk;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-hamoa-iot-evk}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-hamoa-iot-evk.sha256sum] = "08dd475fe28dc8a8006907dbead7b1f9134f18378097dc9856cc4dade8c2cc8b"

URI_aarch64_hexagon-dsp-binaries-qualcomm-iq8275-evk = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-iq8275-evk-20260810-1.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-iq8275-evk;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-iq8275-evk}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-iq8275-evk.sha256sum] = "9a181e6216cbc7f89e73683cef3c16ca1f86c4d05099c3c644b9862cdac6da18"

URI_aarch64_hexagon-dsp-binaries-qualcomm-iq9075-evk = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-iq9075-evk-20260810-1.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-iq9075-evk;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-iq9075-evk}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-iq9075-evk.sha256sum] = "ed47feaa08887c64ff72207af8acc05e61767128ab818baa72bb53ef9094cf46"

URI_aarch64_hexagon-dsp-binaries-qualcomm-kaanapali-mtp = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-kaanapali-mtp-20260810-1.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-kaanapali-mtp;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-kaanapali-mtp}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-kaanapali-mtp.sha256sum] = "7015f1d8f66ded3a071011b2f417de2f700788dea359bd073d904f1516e5c1e8"

URI_aarch64_hexagon-dsp-binaries-qualcomm-purwa-iot-evk = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-purwa-iot-evk-20260810-1.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-purwa-iot-evk;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-purwa-iot-evk}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-purwa-iot-evk.sha256sum] = "dfe10b15135b182dedc3c9c126e34661b260178e7e0187383f49841f5ea5fda4"

URI_aarch64_hexagon-dsp-binaries-qualcomm-qcm6490-idp = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-qcm6490-idp-20260810-1.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-qcm6490-idp;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-qcm6490-idp}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-qcm6490-idp.sha256sum] = "42fa1e5e16feaf79de8cf11742f07a64afad48ca28ea5bcdd3851dfa3a85d8b7"

URI_aarch64_hexagon-dsp-binaries-qualcomm-qcs615-ride = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-qcs615-ride-20260810-1.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-qcs615-ride;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-qcs615-ride}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-qcs615-ride.sha256sum] = "5200d231c7737cdd8ec939d17eb592753ca44bf2abf12ca9e53e98334f253271"

URI_aarch64_hexagon-dsp-binaries-qualcomm-qcs8300-ride = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-qcs8300-ride-20260810-1.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-qcs8300-ride;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-qcs8300-ride}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-qcs8300-ride.sha256sum] = "4006c10764e2ae636d550f3e93fc141756e6dea238b45e400419a8f4442ae7bc"

URI_aarch64_hexagon-dsp-binaries-qualcomm-sa8775p-ride = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-sa8775p-ride-20260810-1.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-sa8775p-ride;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-sa8775p-ride}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-sa8775p-ride.sha256sum] = "126fe8e8fce44ec9586c90f858e0d1498427804bcbc8a0b4e6718d32037a7932"

URI_aarch64_hexagon-dsp-binaries-qualcomm-sdm845-hdk = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-sdm845-hdk-20260810-1.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-sdm845-hdk;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-sdm845-hdk}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-sdm845-hdk.sha256sum] = "acd603aaa9f83a0ff967157f076c30a7e6048173ff696d61a5a776ef42cd7bc5"

URI_aarch64_hexagon-dsp-binaries-qualcomm-shikra-cqm-evk = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-shikra-cqm-evk-20260810-1.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-shikra-cqm-evk;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-shikra-cqm-evk}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-shikra-cqm-evk.sha256sum] = "e47ef07f782d8094411789e82ae9001d5679810173a84c175bf578c6b67087a8"

URI_aarch64_hexagon-dsp-binaries-qualcomm-shikra-cqs-evk = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-shikra-cqs-evk-20260810-1.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-shikra-cqs-evk;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-shikra-cqs-evk}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-shikra-cqs-evk.sha256sum] = "9e436fa52f442e4d0aa69eafe2c66603e199173c060a0df8c93f88dbed7dc529"

URI_aarch64_hexagon-dsp-binaries-qualcomm-shikra-iqs-evk = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-shikra-iqs-evk-20260810-1.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-shikra-iqs-evk;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-shikra-iqs-evk}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-shikra-iqs-evk.sha256sum] = "c803fa1ee01c9897f75a44792cb3e90a9186ee08efcc7ab8ff8f903d73f2dceb"

URI_aarch64_hexagon-dsp-binaries-qualcomm-sm8750-mtp = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-sm8750-mtp-20260810-1.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-sm8750-mtp;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-sm8750-mtp}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-sm8750-mtp.sha256sum] = "cc6d673ebbefb19624516f76ddf3db5f4a8705c005d1ae61e5e092c87a563120"

URI_aarch64_hexagon-dsp-binaries-radxa-dragon-q6a = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-radxa-dragon-q6a-20260810-1.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-radxa-dragon-q6a;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-radxa-dragon-q6a}"
SRC_URI[aarch64_hexagon-dsp-binaries-radxa-dragon-q6a.sha256sum] = "5c44246c4d7e0711cb43e4e13a03e53af3b826c848450f0a9d0c63ca1b82c872"

URI_aarch64_hexagon-dsp-binaries-thundercomm-db845c = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-thundercomm-db845c-20260810-1.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-thundercomm-db845c;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-thundercomm-db845c}"
SRC_URI[aarch64_hexagon-dsp-binaries-thundercomm-db845c.sha256sum] = "89a0ab008e6a9c9462e5d19d924e3459ed8d4fceafc16484d68370132d1717f0"

URI_aarch64_hexagon-dsp-binaries-thundercomm-rb1 = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-thundercomm-rb1-20260810-1.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-thundercomm-rb1;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-thundercomm-rb1}"
SRC_URI[aarch64_hexagon-dsp-binaries-thundercomm-rb1.sha256sum] = "fb4a8c1d8c1b9b13515bb8addd0bdc495899a3ce7b22153a7daa4b808fcdf4cd"

URI_aarch64_hexagon-dsp-binaries-thundercomm-rb2 = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-thundercomm-rb2-20260810-1.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-thundercomm-rb2;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-thundercomm-rb2}"
SRC_URI[aarch64_hexagon-dsp-binaries-thundercomm-rb2.sha256sum] = "19ff44d35e9f0a8a649c64f8576c9d429c384ef25e5cce57d9960c9556d6871d"

URI_aarch64_hexagon-dsp-binaries-thundercomm-rb3gen2 = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-thundercomm-rb3gen2-20260810-1.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-thundercomm-rb3gen2;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-thundercomm-rb3gen2}"
SRC_URI[aarch64_hexagon-dsp-binaries-thundercomm-rb3gen2.sha256sum] = "de8d3f8bb45d1d7d62c3254f41c0dc39f82345addf252b5ff121d17aaab89690"

URI_aarch64_hexagon-dsp-binaries-thundercomm-rb5 = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-thundercomm-rb5-20260810-1.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-thundercomm-rb5;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-thundercomm-rb5}"
SRC_URI[aarch64_hexagon-dsp-binaries-thundercomm-rb5.sha256sum] = "879b107a59b4210d38df9dda054130e88a4ff2050dc34cc5577b82d6e058e5d6"

URI_aarch64_hexagon-dsp-binaries-thundercomm-rubikpi3 = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-thundercomm-rubikpi3-20260810-1.el10_3.noarch.rpm;name=aarch64_hexagon-dsp-binaries-thundercomm-rubikpi3;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-thundercomm-rubikpi3}"
SRC_URI[aarch64_hexagon-dsp-binaries-thundercomm-rubikpi3.sha256sum] = "71d64d6c83da7745f6b803ae4294fefdeb3dc3b0ade565ea89fb1ad47a086ef7"

RDEPENDS:hexagon-dsp-binaries = " \
 "
RDEPENDS:hexagon-dsp-binaries-arduino-monza = " \
 hexagon-dsp-binaries \
 hexagon-dsp-binaries-qualcomm-qcs8300-ride \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-db410c = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-db820c = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-glymur-crd = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-hamoa-iot-evk = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-iq8275-evk = " \
 hexagon-dsp-binaries \
 hexagon-dsp-binaries-qualcomm-qcs8300-ride \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-iq9075-evk = " \
 hexagon-dsp-binaries \
 hexagon-dsp-binaries-qualcomm-sa8775p-ride \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-kaanapali-mtp = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-purwa-iot-evk = " \
 hexagon-dsp-binaries \
 hexagon-dsp-binaries-qualcomm-hamoa-iot-evk \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-qcm6490-idp = " \
 hexagon-dsp-binaries \
 hexagon-dsp-binaries-thundercomm-rb3gen2 \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-qcs615-ride = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-qcs8300-ride = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-sa8775p-ride = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-sdm845-hdk = " \
 hexagon-dsp-binaries \
 hexagon-dsp-binaries-thundercomm-db845c \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-shikra-cqm-evk = " \
 hexagon-dsp-binaries \
 hexagon-dsp-binaries-qualcomm-shikra-cqs-evk \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-shikra-cqs-evk = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-shikra-iqs-evk = " \
 hexagon-dsp-binaries \
 hexagon-dsp-binaries-qualcomm-shikra-cqs-evk \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-sm8750-mtp = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-radxa-dragon-q6a = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-thundercomm-db845c = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-thundercomm-rb1 = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-thundercomm-rb2 = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-thundercomm-rb3gen2 = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-thundercomm-rb5 = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-thundercomm-rubikpi3 = " \
 hexagon-dsp-binaries \
 hexagon-dsp-binaries-thundercomm-rb3gen2 \
 qcom-firmware \
 "
