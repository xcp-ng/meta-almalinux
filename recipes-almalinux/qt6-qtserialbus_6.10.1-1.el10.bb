# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtserialbus"
PV = "6.10.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qtserialbus \
 qt6-qtserialbus-devel \
 qt6-qtserialbus-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtserialbus-6.10.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1a80d00ab705687e1895f70bbd07c999ba69aff0ca3e2b50af5eeef3a8bafed0"

URI_x86_64_v2_qt6-qtserialbus = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtserialbus-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtserialbus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtserialbus}"
SRC_URI[x86_64_v2_qt6-qtserialbus.sha256sum] = "0b1fd9d3cac18e944432f57a59e5e58410961e5e309475cf4dc89e9d5b7f38fe"

URI_x86_64_v2_qt6-qtserialbus-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtserialbus-devel-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtserialbus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtserialbus-devel}"
SRC_URI[x86_64_v2_qt6-qtserialbus-devel.sha256sum] = "2196c394690bd6f95b8237164e78cf49683ea3dc326c26221690cebdb6cf6f6f"

URI_x86_64_v2_qt6-qtserialbus-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtserialbus-examples-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtserialbus-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtserialbus-examples}"
SRC_URI[x86_64_v2_qt6-qtserialbus-examples.sha256sum] = "5351c2fbb056d4b5956cf0d6cc4c823e7347134c23a4ed33ed1cba6c153d98b4"

URI_aarch64_qt6-qtserialbus = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtserialbus-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtserialbus;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtserialbus}"
SRC_URI[aarch64_qt6-qtserialbus.sha256sum] = "b3826364eb9d6191a20e3244de1478f0794f1150cc0daef7a20064936a668ce2"

URI_aarch64_qt6-qtserialbus-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtserialbus-devel-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtserialbus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtserialbus-devel}"
SRC_URI[aarch64_qt6-qtserialbus-devel.sha256sum] = "310d5b4da0d83188fcb8d77fe1724561a129828195c40097ac06c3219aa69675"

URI_aarch64_qt6-qtserialbus-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtserialbus-examples-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtserialbus-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtserialbus-examples}"
SRC_URI[aarch64_qt6-qtserialbus-examples.sha256sum] = "280bcd90a494aeb1097ae037453bde4151527ee583e4807fe55602d6d4b1bccf"

RDEPENDS:qt6-qtserialbus = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtserialport \
 "
RDEPENDS:qt6-qtserialbus-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtserialbus \
 qt6-qtserialport-devel \
 "
RDEPENDS:qt6-qtserialbus-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtserialbus \
 qt6-qtserialport \
 "
