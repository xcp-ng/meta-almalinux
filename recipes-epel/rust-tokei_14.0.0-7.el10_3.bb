# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokei"
PV = "14.0.0"
PR = "7.el10_3"
PACKAGES = " \
 rust-tokei+all-devel \
 rust-tokei+cbor-devel \
 rust-tokei+cli-devel \
 rust-tokei+default-devel \
 rust-tokei+yaml-devel \
 rust-tokei-devel \
 tokei \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokei-14.0.0-7.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "24cb2c7ebfadc37b502c8a9448a86a6cb7728562121cee249715c12418e1ff0b"

URI_x86_64_v2_rust-tokei+all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokei+all-devel-14.0.0-7.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokei+all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokei+all-devel}"
SRC_URI[x86_64_v2_rust-tokei+all-devel.sha256sum] = "b67bcb753cc611616453a6e0670e348c72ed6ff4c631126e23a929b24fc3ca8c"

URI_x86_64_v2_rust-tokei+cbor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokei+cbor-devel-14.0.0-7.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokei+cbor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokei+cbor-devel}"
SRC_URI[x86_64_v2_rust-tokei+cbor-devel.sha256sum] = "5a4cced876f0611ba7ab8f8d008540cceb135604c78f5fac7871ba13f5b4a440"

URI_x86_64_v2_rust-tokei+cli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokei+cli-devel-14.0.0-7.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokei+cli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokei+cli-devel}"
SRC_URI[x86_64_v2_rust-tokei+cli-devel.sha256sum] = "2c21d463f8d452a4be09004bb26854d071d9af304b9800b564a5b202794a2aba"

URI_x86_64_v2_rust-tokei+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokei+default-devel-14.0.0-7.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokei+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokei+default-devel}"
SRC_URI[x86_64_v2_rust-tokei+default-devel.sha256sum] = "8eb80ae4aa24e2940aa58e538784784139d538ab0222cc378561610e4bb28a05"

URI_x86_64_v2_rust-tokei+yaml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokei+yaml-devel-14.0.0-7.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokei+yaml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokei+yaml-devel}"
SRC_URI[x86_64_v2_rust-tokei+yaml-devel.sha256sum] = "450a97a4d5c34cfbcea8926a27684cdf9e98aa1df58b9fdaf39c73f4d659ad43"

URI_x86_64_v2_rust-tokei-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokei-devel-14.0.0-7.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokei-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokei-devel}"
SRC_URI[x86_64_v2_rust-tokei-devel.sha256sum] = "a86dfc5dc92723dd8249a93f386e44b0303e99d5fd4aae301b4a0cb06b16379a"

URI_x86_64_v2_tokei = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tokei-14.0.0-7.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tokei;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tokei}"
SRC_URI[x86_64_v2_tokei.sha256sum] = "b607df712e670fd2eb180098c803307152f35a67830c73237c406f53db68467b"

URI_aarch64_rust-tokei+all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokei+all-devel-14.0.0-7.el10_3.noarch.rpm;name=aarch64_rust-tokei+all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokei+all-devel}"
SRC_URI[aarch64_rust-tokei+all-devel.sha256sum] = "aae1457ee62a2adb418af72d3943c21ec7cdfbc4f9a32a0dac3ca121e8580ae3"

URI_aarch64_rust-tokei+cbor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokei+cbor-devel-14.0.0-7.el10_3.noarch.rpm;name=aarch64_rust-tokei+cbor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokei+cbor-devel}"
SRC_URI[aarch64_rust-tokei+cbor-devel.sha256sum] = "405ff58e7b109b3bf48569c58e09aba58433cf7555c6eef8c455e43c48b8d20f"

URI_aarch64_rust-tokei+cli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokei+cli-devel-14.0.0-7.el10_3.noarch.rpm;name=aarch64_rust-tokei+cli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokei+cli-devel}"
SRC_URI[aarch64_rust-tokei+cli-devel.sha256sum] = "f6ae0bea3a5fa860556a0a8e89c1d1d2f6607bca12abb19b54d009252a995c2d"

URI_aarch64_rust-tokei+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokei+default-devel-14.0.0-7.el10_3.noarch.rpm;name=aarch64_rust-tokei+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokei+default-devel}"
SRC_URI[aarch64_rust-tokei+default-devel.sha256sum] = "11841d01b775efadd4b671240e3aee78475e9a696cc24a4a837f11b8b71d91ca"

URI_aarch64_rust-tokei+yaml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokei+yaml-devel-14.0.0-7.el10_3.noarch.rpm;name=aarch64_rust-tokei+yaml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokei+yaml-devel}"
SRC_URI[aarch64_rust-tokei+yaml-devel.sha256sum] = "98e316885c7d9bfc35ad2aaa2722270239b64c4605fef6a3f761815437c65e8c"

URI_aarch64_rust-tokei-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokei-devel-14.0.0-7.el10_3.noarch.rpm;name=aarch64_rust-tokei-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokei-devel}"
SRC_URI[aarch64_rust-tokei-devel.sha256sum] = "a58135dabf9d8bf89a711636b5d3cdbda5eb853e97cd8496068cf21ef888ee56"

URI_aarch64_tokei = "${EPEL_MIRROR}/aarch64/Packages/t/tokei-14.0.0-7.el10_3.aarch64.rpm;name=aarch64_tokei;unpack=0"
SRC_URI:append = " ${URI_aarch64_tokei}"
SRC_URI[aarch64_tokei.sha256sum] = "7da8753d9a47df05128127788f50e9bafd8823ae9253cb3de379fce78339f140"

RDEPENDS:rust-tokei+all-devel = " \
 cargo \
 rust-tokei+cbor-devel \
 rust-tokei+yaml-devel \
 rust-tokei-devel \
 "
RDEPENDS:rust-tokei+cbor-devel = " \
 cargo \
 rust-hex+default-devel \
 rust-serde_cbor+default-devel \
 rust-tokei-devel \
 "
RDEPENDS:rust-tokei+cli-devel = " \
 cargo \
 rust-clap+cargo-devel \
 rust-clap+default-devel \
 rust-clap+string-devel \
 rust-clap+wrap_help-devel \
 rust-colored+default-devel \
 rust-env_logger+default-devel \
 rust-num-format+default-devel \
 rust-tokei-devel \
 "
RDEPENDS:rust-tokei+default-devel = " \
 cargo \
 rust-tokei+cli-devel \
 rust-tokei-devel \
 "
RDEPENDS:rust-tokei+yaml-devel = " \
 cargo \
 rust-serde_yaml+default-devel \
 rust-tokei-devel \
 "
RDEPENDS:rust-tokei-devel = " \
 cargo \
 rust \
 rust-aho-corasick+default-devel \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-clap-cargo+default-devel \
 rust-crossbeam-channel+default-devel \
 rust-dashmap+default-devel \
 rust-dashmap+serde-devel \
 rust-encoding_rs_io+default-devel \
 rust-etcetera+default-devel \
 rust-grep-searcher+default-devel \
 rust-ignore+default-devel \
 rust-json5+default-devel \
 rust-log+default-devel \
 rust-once_cell+default-devel \
 rust-parking_lot+default-devel \
 rust-rayon+default-devel \
 rust-regex+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-serde_json+default-devel \
 rust-table_formatter+default-devel \
 rust-tera+default-devel \
 rust-term_size+default-devel \
 rust-toml0.9+default-devel \
 "
RDEPENDS:tokei = " \
 glibc \
 libgcc \
 "
