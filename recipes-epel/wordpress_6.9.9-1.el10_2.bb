# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wordpress"
PV = "6.9.9"
PR = "1.el10_2"
PACKAGES = " \
 wordpress \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/w/wordpress-6.9.9-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3e807be14c66d7576248d74e035ca421ae977d79395a71e821c519ee703d799a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wordpress-6.9.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_wordpress;unpack=0"
SRC_URI[x86_64_v2_wordpress.sha256sum] = "17ad2f96704896992b20c58ae7f0a6fab25792de76ed74533dc44bb89b45ab22"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/wordpress-6.9.9-1.el10_2.noarch.rpm;name=aarch64_wordpress;unpack=0"
SRC_URI[aarch64_wordpress.sha256sum] = "37d8aa0ee41363d1b76bc80fb7395af541e819aeb13711b70255e660d879e5cc"

RDEPENDS:wordpress = " \
 ca-certificates \
 httpd \
 httpd-filesystem \
 nginx-filesystem \
 virtual/php-ctype \
 virtual/php-curl \
 virtual/php-dom \
 virtual/php-exif \
 virtual/php-fileinfo \
 virtual/php-filter \
 virtual/php-gd \
 virtual/php-gettext \
 virtual/php-iconv \
 virtual/php-intl \
 virtual/php-json \
 virtual/php-libxml \
 virtual/php-mbstring \
 virtual/php-mysqli \
 virtual/php-openssl \
 virtual/php-simplexml \
 virtual/php-sodium \
 virtual/php-xml \
 virtual/php-xmlreader \
 virtual/php-zip \
 virtual/php-zlib \
 virtual/php_httpd_ \
 virtual/php_language__ge_7.2 \
 virtual/webserver \
 "
