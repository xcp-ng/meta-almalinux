# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-normpath"
PV = "1.5.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-normpath+default-devel \
 rust-normpath+localization-devel \
 rust-normpath+serde-devel \
 rust-normpath-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-normpath-1.5.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a09341407804fdb2e540364a7af11d744fad1d4523d17b7bfa196ff50811ed4c"

URI_x86_64_v2_rust-normpath+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-normpath+default-devel-1.5.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-normpath+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-normpath+default-devel}"
SRC_URI[x86_64_v2_rust-normpath+default-devel.sha256sum] = "48852b97593ca36c489eca4dd39a6241a528196ba71309ecf65a391b71e0d187"

URI_x86_64_v2_rust-normpath+localization-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-normpath+localization-devel-1.5.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-normpath+localization-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-normpath+localization-devel}"
SRC_URI[x86_64_v2_rust-normpath+localization-devel.sha256sum] = "1e2075b8ce4a6dc5dbf09b2dd878542019cfd8583962aa1382fd07784c1314ec"

URI_x86_64_v2_rust-normpath+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-normpath+serde-devel-1.5.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-normpath+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-normpath+serde-devel}"
SRC_URI[x86_64_v2_rust-normpath+serde-devel.sha256sum] = "18bbc2e0b46862bcee792f1a8569ec81d53a34b98ecd5184f6fe959e37c1b85d"

URI_x86_64_v2_rust-normpath-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-normpath-devel-1.5.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-normpath-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-normpath-devel}"
SRC_URI[x86_64_v2_rust-normpath-devel.sha256sum] = "77c585ad9d62949c63b46a952cb45cc88c0ca06efe54bf3aa303f11b4a12ae5c"

URI_aarch64_rust-normpath+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-normpath+default-devel-1.5.1-1.el10_2.noarch.rpm;name=aarch64_rust-normpath+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-normpath+default-devel}"
SRC_URI[aarch64_rust-normpath+default-devel.sha256sum] = "74b76ff6b7c8f97b0cc61aeaae376b779ac6280b0a43ccbe317b93bee6233906"

URI_aarch64_rust-normpath+localization-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-normpath+localization-devel-1.5.1-1.el10_2.noarch.rpm;name=aarch64_rust-normpath+localization-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-normpath+localization-devel}"
SRC_URI[aarch64_rust-normpath+localization-devel.sha256sum] = "395bee1ac8998742174cf29834043984f70fc575f345e6e38a7c21ca1dbb1e1a"

URI_aarch64_rust-normpath+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-normpath+serde-devel-1.5.1-1.el10_2.noarch.rpm;name=aarch64_rust-normpath+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-normpath+serde-devel}"
SRC_URI[aarch64_rust-normpath+serde-devel.sha256sum] = "b41b19620e674623971f345f3bafb9215f17b02ef2a70314e207dcdb0471f7a2"

URI_aarch64_rust-normpath-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-normpath-devel-1.5.1-1.el10_2.noarch.rpm;name=aarch64_rust-normpath-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-normpath-devel}"
SRC_URI[aarch64_rust-normpath-devel.sha256sum] = "d335a423f73227031bede673d033e69cc7a8555d9bac36963da3b673e6fbbc57"

RDEPENDS:rust-normpath+default-devel = " \
 cargo \
 rust-normpath-devel \
 "
RDEPENDS:rust-normpath+localization-devel = " \
 cargo \
 rust-normpath-devel \
 "
RDEPENDS:rust-normpath+serde-devel = " \
 cargo \
 rust-normpath-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-normpath-devel = " \
 cargo \
 rust \
 "
