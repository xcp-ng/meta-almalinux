# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-incremental"
PV = "24.7.2"
PR = "1.el10_0"
PACKAGES = " \
 python3-incremental \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-incremental-24.7.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9053dd0f45fc0adecc252a3978ca4f2928401e57f92237d1dec3cb5d8b98a1ef"

URI_x86_64_v2_python3-incremental = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-incremental-24.7.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-incremental;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-incremental}"
SRC_URI[x86_64_v2_python3-incremental.sha256sum] = "fdad9a2ff37c85f6ab50147031c1a9488a361440349311aaae88a647bbc96cd1"

URI_aarch64_python3-incremental = "${EPEL_MIRROR}/aarch64/Packages/p/python3-incremental-24.7.2-1.el10_0.noarch.rpm;name=aarch64_python3-incremental;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-incremental}"
SRC_URI[aarch64_python3-incremental.sha256sum] = "f39ed6b265b9cf007ad7b9194ecfcd8b985262d3ca0424031c5a4e146acaa10e"

RDEPENDS:python3-incremental = " \
 python3 \
 python3-setuptools \
 "
