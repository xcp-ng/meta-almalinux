# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "image-builder"
PV = "83.0.0"
PR = "1.el10"
PACKAGES = " \
 image-builder \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/image-builder-83.0.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "15da76b770c9d5dae931eda96141957cb6d86ec7afabcd116e63dbd3506791cf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/image-builder-83.0.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_image-builder;unpack=0"
SRC_URI[x86_64_v2_image-builder.sha256sum] = "c4973174784ba4065f986552d08b52ac8b5758bc1e500f17f5431bcdfa998504"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/image-builder-83.0.0-1.el10.aarch64.rpm;name=aarch64_image-builder;unpack=0"
SRC_URI[aarch64_image-builder.sha256sum] = "f7491d113225a0cd28c20edbf97aefb739ceb5bbd153364b5dc8779b8bb176ba"

RDEPENDS:image-builder = " \
 glibc \
 libvirt-libs \
 libxcrypt \
 osbuild \
 osbuild-depsolve-dnf \
 osbuild-luks2 \
 osbuild-lvm2 \
 osbuild-ostree \
 "
