# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mbox-importer"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 mbox-importer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mbox-importer-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce763ff19e382b9345220f457f3a1b91feff64805523ad3ae0e9a20627bb8bee"

URI_x86_64_v2_mbox-importer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mbox-importer-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mbox-importer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mbox-importer}"
SRC_URI[x86_64_v2_mbox-importer.sha256sum] = "c2afd58f390e1ddc7257c2dcc6878d2ed3ce7a5bacd9623603d8a44a31c18364"

URI_aarch64_mbox-importer = "${EPEL_MIRROR}/aarch64/Packages/m/mbox-importer-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_mbox-importer;unpack=0"
SRC_URI:append = " ${URI_aarch64_mbox-importer}"
SRC_URI[aarch64_mbox-importer.sha256sum] = "3927371c6911009f69a21ead2fa1fff416a1355388f45f621b26add404254131"

RDEPENDS:mbox-importer = " \
 akonadi-server \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kidentitymanagement \
 libgcc \
 libstdc++ \
 mailcommon \
 mailimporter \
 mailimporter-akonadi \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
