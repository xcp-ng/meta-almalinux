# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jaxb-dtd-parser"
PV = "1.5.1"
PR = "6.el10"
PACKAGES = " \
 jaxb-dtd-parser \
 jaxb-dtd-parser-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/jaxb-dtd-parser-1.5.1-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a027826abdbefe71484137926c717e30b71e81f51b9416dedb635d4d4c878d8a"

URI_x86_64_v2_jaxb-dtd-parser = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/jaxb-dtd-parser-1.5.1-6.el10.noarch.rpm;name=x86_64_v2_jaxb-dtd-parser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jaxb-dtd-parser}"
SRC_URI[x86_64_v2_jaxb-dtd-parser.sha256sum] = "40d901a33a9be99010c5d25f0389986078625e0eb92ab278de9bb561cc539099"

URI_x86_64_v2_jaxb-dtd-parser-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jaxb-dtd-parser-javadoc-1.5.1-6.el10.noarch.rpm;name=x86_64_v2_jaxb-dtd-parser-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jaxb-dtd-parser-javadoc}"
SRC_URI[x86_64_v2_jaxb-dtd-parser-javadoc.sha256sum] = "49201b150bdbc7da5686eedac5d7292b70b6713c2b38efce08a42682c02ec555"

URI_aarch64_jaxb-dtd-parser = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/jaxb-dtd-parser-1.5.1-6.el10.noarch.rpm;name=aarch64_jaxb-dtd-parser;unpack=0"
SRC_URI:append = " ${URI_aarch64_jaxb-dtd-parser}"
SRC_URI[aarch64_jaxb-dtd-parser.sha256sum] = "40d901a33a9be99010c5d25f0389986078625e0eb92ab278de9bb561cc539099"

URI_aarch64_jaxb-dtd-parser-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jaxb-dtd-parser-javadoc-1.5.1-6.el10.noarch.rpm;name=aarch64_jaxb-dtd-parser-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_jaxb-dtd-parser-javadoc}"
SRC_URI[aarch64_jaxb-dtd-parser-javadoc.sha256sum] = "49201b150bdbc7da5686eedac5d7292b70b6713c2b38efce08a42682c02ec555"

RDEPENDS:jaxb-dtd-parser = " \
 javapackages-filesystem \
 "
RDEPENDS:jaxb-dtd-parser-javadoc = " \
 javapackages-filesystem \
 "
