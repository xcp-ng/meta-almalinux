# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-macros-backend"
PV = "0.25.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-pyo3-macros-backend+default-devel \
 rust-pyo3-macros-backend+experimental-async-devel \
 rust-pyo3-macros-backend+experimental-inspect-devel \
 rust-pyo3-macros-backend-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-macros-backend-0.25.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b9d318486af1993261e312097ca4bd2966e8323d38d3097cbf94302fa810fd1"

URI_x86_64_v2_rust-pyo3-macros-backend+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend+default-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend+default-devel.sha256sum] = "c987358c7b7a55428af7df12d6e73bfa7d599599d9ccf453ed2c284bffa954e8"

URI_x86_64_v2_rust-pyo3-macros-backend+experimental-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend+experimental-async-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend+experimental-async-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend+experimental-async-devel.sha256sum] = "8770052163bb14bc1b633ad8b7a04eea4d81c46d2a00439c4b4adfb342e2ab48"

URI_x86_64_v2_rust-pyo3-macros-backend+experimental-inspect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend+experimental-inspect-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend+experimental-inspect-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend+experimental-inspect-devel.sha256sum] = "aa81693b98ad723a06654994ff87fe9abc971b6a1ea9ac64b55a6b06a4e01e13"

URI_x86_64_v2_rust-pyo3-macros-backend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend-devel.sha256sum] = "136763e780b32bbaffa82078dfccb08c3d2ec6fcca96eff42876c5486d73d1db"

URI_aarch64_rust-pyo3-macros-backend+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend+default-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-macros-backend+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend+default-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend+default-devel.sha256sum] = "f285a8ba656fae80d5446f375acf759bb19dc2772b21d4349a7e5835213ef64c"

URI_aarch64_rust-pyo3-macros-backend+experimental-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend+experimental-async-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-macros-backend+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend+experimental-async-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend+experimental-async-devel.sha256sum] = "a9b50ebdff23ef9897b835b5d8d0f08a302d5d6a0a5f3dffe0688c6e03ceac2a"

URI_aarch64_rust-pyo3-macros-backend+experimental-inspect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend+experimental-inspect-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-macros-backend+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend+experimental-inspect-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend+experimental-inspect-devel.sha256sum] = "d0b761798b96180b605c708ccba173a06fb0024ffb9a3f31665ba410e2ef60a6"

URI_aarch64_rust-pyo3-macros-backend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-macros-backend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend-devel.sha256sum] = "ad54a554c1626631b233143cda9a7a7687cc43066af77916e9ae68586ecf617a"

RDEPENDS:rust-pyo3-macros-backend+default-devel = " \
 cargo \
 rust-pyo3-macros-backend-devel \
 "
RDEPENDS:rust-pyo3-macros-backend+experimental-async-devel = " \
 cargo \
 rust-pyo3-macros-backend-devel \
 "
RDEPENDS:rust-pyo3-macros-backend+experimental-inspect-devel = " \
 cargo \
 rust-pyo3-macros-backend-devel \
 "
RDEPENDS:rust-pyo3-macros-backend-devel = " \
 cargo \
 rust \
 rust-heck+default-devel \
 rust-proc-macro2-devel \
 rust-pyo3-build-config+default-devel \
 rust-pyo3-build-config+resolve-config-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn-devel \
 "
