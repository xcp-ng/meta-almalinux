# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "csdiff"
PV = "3.5.2"
PR = "1.el10_0"
PACKAGES = " \
 csdiff \
 csdiff-static \
 python3-csdiff \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/csdiff-3.5.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48aa3e421f9cda8ba480dad6e28546702a4b481dbb501234bacd1fedcfadd7cb"

URI_x86_64_v2_csdiff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csdiff-3.5.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_csdiff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csdiff}"
SRC_URI[x86_64_v2_csdiff.sha256sum] = "08487604d2b3fe532acccdf87c13075a2178550487e6384bf94cfc6638d13b8a"

URI_x86_64_v2_csdiff-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csdiff-static-3.5.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_csdiff-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csdiff-static}"
SRC_URI[x86_64_v2_csdiff-static.sha256sum] = "1b8d75e6edc55694c02490811192ce6cef5c446f6adad6365a737e748d64eb78"

URI_x86_64_v2_python3-csdiff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-csdiff-3.5.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-csdiff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-csdiff}"
SRC_URI[x86_64_v2_python3-csdiff.sha256sum] = "518f57165a43e95e796bcb62b2ce15a9929dc8abaf4d4f01b06dfc27739c7749"

URI_aarch64_csdiff = "${EPEL_MIRROR}/aarch64/Packages/c/csdiff-3.5.2-1.el10_0.aarch64.rpm;name=aarch64_csdiff;unpack=0"
SRC_URI:append = " ${URI_aarch64_csdiff}"
SRC_URI[aarch64_csdiff.sha256sum] = "73440028119c4366a5c0829359602620a40380ef2eefd17ed789dd3be6a30fb7"

URI_aarch64_csdiff-static = "${EPEL_MIRROR}/aarch64/Packages/c/csdiff-static-3.5.2-1.el10_0.aarch64.rpm;name=aarch64_csdiff-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_csdiff-static}"
SRC_URI[aarch64_csdiff-static.sha256sum] = "fe422cc5de48cce0b4cca829ac03530bd9176ae354e2441d404ced2813ccef77"

URI_aarch64_python3-csdiff = "${EPEL_MIRROR}/aarch64/Packages/p/python3-csdiff-3.5.2-1.el10_0.aarch64.rpm;name=aarch64_python3-csdiff;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-csdiff}"
SRC_URI[aarch64_python3-csdiff.sha256sum] = "f9fa93d1d75fa223642ea6b63b3641f5f11d5c33ef71916e1c4e4493b94dcf65"

RDEPENDS:csdiff = " \
 boost-filesystem \
 boost-program-options \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
RDEPENDS:csdiff-static = " \
 "
RDEPENDS:python3-csdiff = " \
 boost-filesystem \
 boost-python3 \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
