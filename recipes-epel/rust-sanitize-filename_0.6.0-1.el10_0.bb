# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sanitize-filename"
PV = "0.6.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-sanitize-filename+default-devel \
 rust-sanitize-filename-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sanitize-filename-0.6.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f01d829355e255263e4b8dea362944b6aeaa4341c6d5315a1b5cdb575488ac12"

URI_x86_64_v2_rust-sanitize-filename+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sanitize-filename+default-devel-0.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sanitize-filename+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sanitize-filename+default-devel}"
SRC_URI[x86_64_v2_rust-sanitize-filename+default-devel.sha256sum] = "cb798766f542fe6640f672189cf9fba46d25802716bced57c1dc950c578c71ce"

URI_x86_64_v2_rust-sanitize-filename-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sanitize-filename-devel-0.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sanitize-filename-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sanitize-filename-devel}"
SRC_URI[x86_64_v2_rust-sanitize-filename-devel.sha256sum] = "4f24a2b4c423027d7acb16d0ebdee1d2415645d647f2d8f39a1e87244a6d0a89"

URI_aarch64_rust-sanitize-filename+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sanitize-filename+default-devel-0.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-sanitize-filename+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sanitize-filename+default-devel}"
SRC_URI[aarch64_rust-sanitize-filename+default-devel.sha256sum] = "b95922f501a81b8860ce6b8531f282ed3f0b05e292459c10e2663c165dc2f4a9"

URI_aarch64_rust-sanitize-filename-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sanitize-filename-devel-0.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-sanitize-filename-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sanitize-filename-devel}"
SRC_URI[aarch64_rust-sanitize-filename-devel.sha256sum] = "c9fffcfb9d037285e4d5a22100373eb873f3f4d12f121c86f253598eac68c6eb"

RDEPENDS:rust-sanitize-filename+default-devel = " \
 cargo \
 rust-sanitize-filename-devel \
 "
RDEPENDS:rust-sanitize-filename-devel = " \
 cargo \
 rust \
 rust-regex+std-devel \
 rust-regex+unicode-case-devel \
 rust-regex-devel \
 "
