# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-html5lib"
PE = "1"
PV = "1.1"
PR = "25.el10_0"
PACKAGES = " \
 python3-html5lib \
 python3-html5lib+all \
 python3-html5lib+chardet \
 python3-html5lib+genshi \
 python3-html5lib+lxml \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-html5lib-1.1-25.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5453a088f01e8a9c20ef78606608bb82b749fd4516b3c12689e24d8ff3a8b13d"

URI_x86_64_v2_python3-html5lib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-html5lib-1.1-25.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-html5lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-html5lib}"
SRC_URI[x86_64_v2_python3-html5lib.sha256sum] = "b40b45cf8bb7a3b206d4a3449035a64ed9c777abb65d4ccdf8a38c92d0e861f2"

URI_x86_64_v2_python3-html5lib+all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-html5lib+all-1.1-25.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-html5lib+all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-html5lib+all}"
SRC_URI[x86_64_v2_python3-html5lib+all.sha256sum] = "869608096e60f1d25eeba491da9d724a05731a408163cd7eef08a5628261eabd"

URI_x86_64_v2_python3-html5lib+chardet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-html5lib+chardet-1.1-25.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-html5lib+chardet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-html5lib+chardet}"
SRC_URI[x86_64_v2_python3-html5lib+chardet.sha256sum] = "4e09b203e69a1651678df9c71a0d6084143195689cc68dc9bb26682f24cb6897"

URI_x86_64_v2_python3-html5lib+genshi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-html5lib+genshi-1.1-25.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-html5lib+genshi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-html5lib+genshi}"
SRC_URI[x86_64_v2_python3-html5lib+genshi.sha256sum] = "50f36ab8bb531b0cedf7f409bfe613b6e765185597b9c14425c69cab3643be6c"

URI_x86_64_v2_python3-html5lib+lxml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-html5lib+lxml-1.1-25.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-html5lib+lxml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-html5lib+lxml}"
SRC_URI[x86_64_v2_python3-html5lib+lxml.sha256sum] = "70b7c26a6efc9ba707b63fdf8ccc875017b990a0d2710afa8f202558358b4b2e"

URI_aarch64_python3-html5lib = "${EPEL_MIRROR}/aarch64/Packages/p/python3-html5lib-1.1-25.el10_0.noarch.rpm;name=aarch64_python3-html5lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-html5lib}"
SRC_URI[aarch64_python3-html5lib.sha256sum] = "d0a6ff0517cda426ece6f274bc3cfc9b592c1002be1c1cb72744e65c7391f7c1"

URI_aarch64_python3-html5lib+all = "${EPEL_MIRROR}/aarch64/Packages/p/python3-html5lib+all-1.1-25.el10_0.noarch.rpm;name=aarch64_python3-html5lib+all;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-html5lib+all}"
SRC_URI[aarch64_python3-html5lib+all.sha256sum] = "b4374d7d695a150085b58b50e9d16039f7cf09ef44f32bf609c2e12643653755"

URI_aarch64_python3-html5lib+chardet = "${EPEL_MIRROR}/aarch64/Packages/p/python3-html5lib+chardet-1.1-25.el10_0.noarch.rpm;name=aarch64_python3-html5lib+chardet;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-html5lib+chardet}"
SRC_URI[aarch64_python3-html5lib+chardet.sha256sum] = "7c9bb4af04d686ab2929be9917fd332dfbfa6ac2d2a3b7a3eeb7fd67c0f0bf99"

URI_aarch64_python3-html5lib+genshi = "${EPEL_MIRROR}/aarch64/Packages/p/python3-html5lib+genshi-1.1-25.el10_0.noarch.rpm;name=aarch64_python3-html5lib+genshi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-html5lib+genshi}"
SRC_URI[aarch64_python3-html5lib+genshi.sha256sum] = "0238e3085bccc5a36cbd3508bcd06ddda88da084c92c7bfb3fd268340f2d2c1e"

URI_aarch64_python3-html5lib+lxml = "${EPEL_MIRROR}/aarch64/Packages/p/python3-html5lib+lxml-1.1-25.el10_0.noarch.rpm;name=aarch64_python3-html5lib+lxml;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-html5lib+lxml}"
SRC_URI[aarch64_python3-html5lib+lxml.sha256sum] = "cc53372b08acc69f8e78ff926cd4bfe99612929d886ccb1ce8da42e5c77fe400"

RDEPENDS:python3-html5lib = " \
 python3 \
 python3-six \
 python3-webencodings \
 "
RDEPENDS:python3-html5lib+all = " \
 python3 \
 python3-chardet \
 python3-genshi \
 python3-html5lib \
 python3-lxml \
 "
RDEPENDS:python3-html5lib+chardet = " \
 python3 \
 python3-chardet \
 python3-html5lib \
 "
RDEPENDS:python3-html5lib+genshi = " \
 python3 \
 python3-genshi \
 python3-html5lib \
 "
RDEPENDS:python3-html5lib+lxml = " \
 python3 \
 python3-html5lib \
 python3-lxml \
 "
