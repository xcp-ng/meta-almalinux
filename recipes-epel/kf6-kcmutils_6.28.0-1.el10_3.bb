# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcmutils"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kcmutils \
 kf6-kcmutils-devel \
 kf6-kcmutils-doc \
 kf6-kcmutils-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kcmutils-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d54d5113fbdc2e17a228ec3d8503ad5f497ad07ff98c2d3993c2eb31fb7e2d7d"

URI_x86_64_v2_kf6-kcmutils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcmutils-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcmutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcmutils}"
SRC_URI[x86_64_v2_kf6-kcmutils.sha256sum] = "555d355a32d4c9367e21fd0b0d7cd8aaf751a8859dc69775b1883171905d43b3"

URI_x86_64_v2_kf6-kcmutils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcmutils-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcmutils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcmutils-devel}"
SRC_URI[x86_64_v2_kf6-kcmutils-devel.sha256sum] = "e8d2213ddaa067a685545676182e47e6c226666b2c3ff353e79709d6df0be01c"

URI_x86_64_v2_kf6-kcmutils-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcmutils-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcmutils-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcmutils-doc}"
SRC_URI[x86_64_v2_kf6-kcmutils-doc.sha256sum] = "b820f1e7b81f1e5d69d80b24509655f868e220ea7780d4ef74ada9eac9425f3a"

URI_x86_64_v2_kf6-kcmutils-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcmutils-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcmutils-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcmutils-html}"
SRC_URI[x86_64_v2_kf6-kcmutils-html.sha256sum] = "8b7548c21314a18e9ebb48eec21acd5ed4f9ce46a4681096e7f691188b5f955e"

URI_aarch64_kf6-kcmutils = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcmutils-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kcmutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcmutils}"
SRC_URI[aarch64_kf6-kcmutils.sha256sum] = "599be0fb3b2018e34731c02fedc2b735a1eba7723ce4b62ea80e107897a6a61c"

URI_aarch64_kf6-kcmutils-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcmutils-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kcmutils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcmutils-devel}"
SRC_URI[aarch64_kf6-kcmutils-devel.sha256sum] = "c05aae17f6a0a0df10fe9345a1a9d1dbd009bc2c59d1ede1b366d0b18e6b6996"

URI_aarch64_kf6-kcmutils-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcmutils-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kcmutils-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcmutils-doc}"
SRC_URI[aarch64_kf6-kcmutils-doc.sha256sum] = "0137bdd89de1ee896e3cb867cea342474c9cf4264ee3e26602be2b9ca337285b"

URI_aarch64_kf6-kcmutils-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcmutils-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kcmutils-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcmutils-html}"
SRC_URI[aarch64_kf6-kcmutils-html.sha256sum] = "8b524b91e5f4c0ab795d2a3944b6f6d4585772368b78b0a7789dea4b55adcb8c"

RDEPENDS:kf6-kcmutils = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kitemviews \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kcmutils-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kcmutils \
 kf6-kconfigwidgets-devel \
 kf6-kservice-devel \
 qt6-qtbase \
 qt6-qtdeclarative-devel \
 "
RDEPENDS:kf6-kcmutils-doc = " \
 "
RDEPENDS:kf6-kcmutils-html = " \
 "
