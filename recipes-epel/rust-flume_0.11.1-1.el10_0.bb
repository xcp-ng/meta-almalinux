# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-flume"
PV = "0.11.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-flume+async-devel \
 rust-flume+default-devel \
 rust-flume+eventual-fairness-devel \
 rust-flume+futures-core-devel \
 rust-flume+futures-sink-devel \
 rust-flume+nanorand-devel \
 rust-flume+select-devel \
 rust-flume+spin-devel \
 rust-flume-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-flume-0.11.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cd92d77fddec9b7ab162e0a8250ae3fda7b24328dfe53799e990cf3ee21cd2fe"

URI_x86_64_v2_rust-flume+async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flume+async-devel-0.11.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flume+async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flume+async-devel}"
SRC_URI[x86_64_v2_rust-flume+async-devel.sha256sum] = "3c8ff19433c357ef43002d0c2e3dea49558dcc5c798a46c7e0312b4cc3a59601"

URI_x86_64_v2_rust-flume+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flume+default-devel-0.11.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flume+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flume+default-devel}"
SRC_URI[x86_64_v2_rust-flume+default-devel.sha256sum] = "8ba8530770734d2ff8c3ad9ee1cf2214084524540375b59e74408e108c1d9416"

URI_x86_64_v2_rust-flume+eventual-fairness-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flume+eventual-fairness-devel-0.11.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flume+eventual-fairness-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flume+eventual-fairness-devel}"
SRC_URI[x86_64_v2_rust-flume+eventual-fairness-devel.sha256sum] = "0b06b9560f64aaf79ac906f5b976fecac4b717b27e04397ee989387d6fb26f34"

URI_x86_64_v2_rust-flume+futures-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flume+futures-core-devel-0.11.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flume+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flume+futures-core-devel}"
SRC_URI[x86_64_v2_rust-flume+futures-core-devel.sha256sum] = "db41d58bfad96926125ac2826c923466681c67f8aca7e9e8dc763489e806cd7b"

URI_x86_64_v2_rust-flume+futures-sink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flume+futures-sink-devel-0.11.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flume+futures-sink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flume+futures-sink-devel}"
SRC_URI[x86_64_v2_rust-flume+futures-sink-devel.sha256sum] = "9b44365611e0dc2ae9ca556130ad72f958f8d8b6e479244ad63d85a17acfb320"

URI_x86_64_v2_rust-flume+nanorand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flume+nanorand-devel-0.11.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flume+nanorand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flume+nanorand-devel}"
SRC_URI[x86_64_v2_rust-flume+nanorand-devel.sha256sum] = "bed35dee32d05510c36f131737900c3dc948fafd2a83f01cc7f9b9a2ad477315"

URI_x86_64_v2_rust-flume+select-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flume+select-devel-0.11.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flume+select-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flume+select-devel}"
SRC_URI[x86_64_v2_rust-flume+select-devel.sha256sum] = "6b158521a43ba259bcd8291a99f82c79166dff4b014bace43eac94333374b4ca"

URI_x86_64_v2_rust-flume+spin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flume+spin-devel-0.11.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flume+spin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flume+spin-devel}"
SRC_URI[x86_64_v2_rust-flume+spin-devel.sha256sum] = "2337d7536bb9cc182016a5a362afbbeb31dd8ff70497a9dc858aee2230bb33ee"

URI_x86_64_v2_rust-flume-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flume-devel-0.11.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flume-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flume-devel}"
SRC_URI[x86_64_v2_rust-flume-devel.sha256sum] = "6a6f79d1fd23d521310be49e289eb1ca8d4b57ea7e1f2b8616dcaf3a187b7563"

URI_aarch64_rust-flume+async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flume+async-devel-0.11.1-1.el10_0.noarch.rpm;name=aarch64_rust-flume+async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flume+async-devel}"
SRC_URI[aarch64_rust-flume+async-devel.sha256sum] = "52077efb99b9ade067dc46b0d3b940e84bf65b363548aa64b80ae6318d504b87"

URI_aarch64_rust-flume+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flume+default-devel-0.11.1-1.el10_0.noarch.rpm;name=aarch64_rust-flume+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flume+default-devel}"
SRC_URI[aarch64_rust-flume+default-devel.sha256sum] = "07c6afb716f21f2a83410d49a68279de6fe2551f143a6bbe60e9592dc89caba0"

URI_aarch64_rust-flume+eventual-fairness-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flume+eventual-fairness-devel-0.11.1-1.el10_0.noarch.rpm;name=aarch64_rust-flume+eventual-fairness-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flume+eventual-fairness-devel}"
SRC_URI[aarch64_rust-flume+eventual-fairness-devel.sha256sum] = "345dd7f44dcd4f1382ab27696c2c1fa40d4c5eb575087c109dce6595894daf40"

URI_aarch64_rust-flume+futures-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flume+futures-core-devel-0.11.1-1.el10_0.noarch.rpm;name=aarch64_rust-flume+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flume+futures-core-devel}"
SRC_URI[aarch64_rust-flume+futures-core-devel.sha256sum] = "b7f4a140028df0c7285aa2e4072479c98591d34ae2792b65fd5c768552537690"

URI_aarch64_rust-flume+futures-sink-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flume+futures-sink-devel-0.11.1-1.el10_0.noarch.rpm;name=aarch64_rust-flume+futures-sink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flume+futures-sink-devel}"
SRC_URI[aarch64_rust-flume+futures-sink-devel.sha256sum] = "1cbe072501e2eb099acd4ddc8b8525da792741b8334df405107d4e6beeeb71ec"

URI_aarch64_rust-flume+nanorand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flume+nanorand-devel-0.11.1-1.el10_0.noarch.rpm;name=aarch64_rust-flume+nanorand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flume+nanorand-devel}"
SRC_URI[aarch64_rust-flume+nanorand-devel.sha256sum] = "fbafc2246dc2ccbfe7e329a70fc4fc834dead92ece126e89c859b45f397d30e8"

URI_aarch64_rust-flume+select-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flume+select-devel-0.11.1-1.el10_0.noarch.rpm;name=aarch64_rust-flume+select-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flume+select-devel}"
SRC_URI[aarch64_rust-flume+select-devel.sha256sum] = "ef9f75e587daef74e1e3228d2e136cb26bbe0607a747570439a8a583ecc16e92"

URI_aarch64_rust-flume+spin-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flume+spin-devel-0.11.1-1.el10_0.noarch.rpm;name=aarch64_rust-flume+spin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flume+spin-devel}"
SRC_URI[aarch64_rust-flume+spin-devel.sha256sum] = "3801073bb4e0e3cbfbbde680ec4ad5cafcdcfdf6e27982c89e90deb7341cc3c6"

URI_aarch64_rust-flume-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flume-devel-0.11.1-1.el10_0.noarch.rpm;name=aarch64_rust-flume-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flume-devel}"
SRC_URI[aarch64_rust-flume-devel.sha256sum] = "45252aaf83edb85203ee89873568d63bfe9737e21aeac907df2578acb24c64c6"

RDEPENDS:rust-flume+async-devel = " \
 cargo \
 rust-flume+futures-core-devel \
 rust-flume+futures-sink-devel \
 rust-flume-devel \
 "
RDEPENDS:rust-flume+default-devel = " \
 cargo \
 rust-flume+async-devel \
 rust-flume+eventual-fairness-devel \
 rust-flume+select-devel \
 rust-flume-devel \
 "
RDEPENDS:rust-flume+eventual-fairness-devel = " \
 cargo \
 rust-flume+nanorand-devel \
 rust-flume+select-devel \
 rust-flume-devel \
 "
RDEPENDS:rust-flume+futures-core-devel = " \
 cargo \
 rust-flume-devel \
 rust-futures-core-devel \
 "
RDEPENDS:rust-flume+futures-sink-devel = " \
 cargo \
 rust-flume-devel \
 rust-futures-sink-devel \
 "
RDEPENDS:rust-flume+nanorand-devel = " \
 cargo \
 rust-flume-devel \
 rust-nanorand+default-devel \
 rust-nanorand+getrandom-devel \
 "
RDEPENDS:rust-flume+select-devel = " \
 cargo \
 rust-flume-devel \
 "
RDEPENDS:rust-flume+spin-devel = " \
 cargo \
 rust-flume-devel \
 "
RDEPENDS:rust-flume-devel = " \
 cargo \
 rust-spin0.9+default-devel \
 rust-spin0.9+mutex-devel \
 "
