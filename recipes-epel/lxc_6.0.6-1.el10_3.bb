# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lxc"
PV = "6.0.6"
PR = "1.el10_3"
PACKAGES = " \
 lxc \
 lxc-devel \
 lxc-doc \
 lxc-libs \
 lxc-templates \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lxc-6.0.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f61869ed89e7e29a0cf69bfdc6240ccff2e32dd58969f6e3d439b02525f6cce"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - lxc-devel: pkgconfig(libcap)
# - lxc-libs: libcap.so.2()(64bit)
# - lxc: libcap.so.2()(64bit)

URI_x86_64_v2_lxc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lxc-6.0.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lxc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lxc}"
SRC_URI[x86_64_v2_lxc.sha256sum] = "b9493fedf1b331cb18beefcc41224cbafca72870008d23a46bcb813b600f39d2"

URI_x86_64_v2_lxc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lxc-devel-6.0.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lxc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lxc-devel}"
SRC_URI[x86_64_v2_lxc-devel.sha256sum] = "40ec2935c90d7cd531318defcb363cde0e309abb6d90a3a620ee99398bdf28b4"

URI_x86_64_v2_lxc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lxc-doc-6.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_lxc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lxc-doc}"
SRC_URI[x86_64_v2_lxc-doc.sha256sum] = "dc009d00899ecfa9660789dc6227860da0a73be2d93140032fcd4e7c71ab2b53"

URI_x86_64_v2_lxc-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lxc-libs-6.0.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lxc-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lxc-libs}"
SRC_URI[x86_64_v2_lxc-libs.sha256sum] = "50a4a34feb2824f39a5ecf4d062620c05d2eb8d4dc4aa63350bf60a313769d1d"

URI_x86_64_v2_lxc-templates = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lxc-templates-6.0.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lxc-templates;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lxc-templates}"
SRC_URI[x86_64_v2_lxc-templates.sha256sum] = "6d033ef4e1279b516ef5fc880d1d433065210cc37e65e10b45f9d52488fff557"

URI_aarch64_lxc = "${EPEL_MIRROR}/aarch64/Packages/l/lxc-6.0.6-1.el10_3.aarch64.rpm;name=aarch64_lxc;unpack=0"
SRC_URI:append = " ${URI_aarch64_lxc}"
SRC_URI[aarch64_lxc.sha256sum] = "2b2788fa198cd96ff75907b62ca010e241b2564ba01b5d0e247d8fe0c91adfd1"

URI_aarch64_lxc-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lxc-devel-6.0.6-1.el10_3.aarch64.rpm;name=aarch64_lxc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lxc-devel}"
SRC_URI[aarch64_lxc-devel.sha256sum] = "5b1405a618840c965266eedacfee6137a8619a1ef5a4d4d9d49350da3f02def9"

URI_aarch64_lxc-doc = "${EPEL_MIRROR}/aarch64/Packages/l/lxc-doc-6.0.6-1.el10_3.noarch.rpm;name=aarch64_lxc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_lxc-doc}"
SRC_URI[aarch64_lxc-doc.sha256sum] = "7962c00d462e3d7a67a525afd4d7fc2fbe6f6afb823c3301ea301d4f00685b2a"

URI_aarch64_lxc-libs = "${EPEL_MIRROR}/aarch64/Packages/l/lxc-libs-6.0.6-1.el10_3.aarch64.rpm;name=aarch64_lxc-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_lxc-libs}"
SRC_URI[aarch64_lxc-libs.sha256sum] = "3ea817cfc900e05a4558ae222634b44b4754f709fc637f4f267cadad64f00dce"

URI_aarch64_lxc-templates = "${EPEL_MIRROR}/aarch64/Packages/l/lxc-templates-6.0.6-1.el10_3.aarch64.rpm;name=aarch64_lxc-templates;unpack=0"
SRC_URI:append = " ${URI_aarch64_lxc-templates}"
SRC_URI[aarch64_lxc-templates.sha256sum] = "752fdeb39743e747c0611fd2deb1409b8148b8e1db778aaeb8b1f7dfd7faebfa"

RDEPENDS:lxc:x86_64_v2 = " \
 bash \
 dbus-libs \
 glibc \
 libcap \
 libgcc \
 libseccomp \
 libselinux \
 lxc-libs \
 lxcfs \
 openssl \
 openssl-libs \
 rsync \
"
RDEPENDS:lxc:aarch64 = " \
 bash \
 dbus-libs \
 glibc \
 libgcc \
 libseccomp \
 libselinux \
 lxc-libs \
 lxcfs \
 openssl \
 openssl-libs \
 rsync \
"
RDEPENDS:lxc-devel:x86_64_v2 = " \
 dbus-devel \
 libcap-devel \
 libseccomp-devel \
 libselinux-devel \
 lxc-libs \
 openssl-devel \
 pkgconf-pkg-config \
"
RDEPENDS:lxc-devel:aarch64 = " \
 dbus-devel \
 libseccomp-devel \
 libselinux-devel \
 lxc-libs \
 openssl-devel \
 pkgconf-pkg-config \
"
RDEPENDS:lxc-doc = " \
 "
RDEPENDS:lxc-libs:x86_64_v2 = " \
 bash \
 dbus-libs \
 glibc \
 libcap \
 libgcc \
 libseccomp \
 libselinux \
 openssl-libs \
 pam-libs \
 rsync \
 systemd \
"
RDEPENDS:lxc-libs:aarch64 = " \
 bash \
 dbus-libs \
 glibc \
 libgcc \
 libseccomp \
 libselinux \
 openssl-libs \
 pam-libs \
 rsync \
 systemd \
"
RDEPENDS:lxc-templates = " \
 bash \
 lxc-libs \
 wget \
 "
