# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdesdk-thumbnailers"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kdesdk-thumbnailers \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kdesdk-thumbnailers-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "411f0c47177b6e69a71975d30eda5437220e077de5bcce6a835a0d874944b824"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdesdk-thumbnailers-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdesdk-thumbnailers;unpack=0"
SRC_URI[x86_64_v2_kdesdk-thumbnailers.sha256sum] = "63c7595eb670bb8b659fe64bcc2341f894bf6df50d9b7735e8eb2215c0c8ee59"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kdesdk-thumbnailers-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kdesdk-thumbnailers;unpack=0"
SRC_URI[aarch64_kdesdk-thumbnailers.sha256sum] = "b3e6f9f3796eb166ffc8e11db3b7e3b2154f1d84750a45e35cfff1956bbb2c31"

RDEPENDS:kdesdk-thumbnailers = " \
 gettext-libs \
 glibc \
 kf6-kcoreaddons \
 kf6-kio-gui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
