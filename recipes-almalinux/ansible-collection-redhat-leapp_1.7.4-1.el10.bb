# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansible-collection-redhat-leapp"
PV = "1.7.4"
PR = "1.el10"
PACKAGES = " \
 ansible-collection-redhat-leapp \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ansible-collection-redhat-leapp-1.7.4-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "29a3e0fb4e2308edfe445c1bb13fb6624f3bb9557a50acafd5f562f124431794"

URI_x86_64_v2_ansible-collection-redhat-leapp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ansible-collection-redhat-leapp-1.7.4-1.el10.noarch.rpm;name=x86_64_v2_ansible-collection-redhat-leapp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-collection-redhat-leapp}"
SRC_URI[x86_64_v2_ansible-collection-redhat-leapp.sha256sum] = "8b991c66944606df48079d6c9dfec2fe7e17e512ab2211b6239386e2d229b8c0"

URI_aarch64_ansible-collection-redhat-leapp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ansible-collection-redhat-leapp-1.7.4-1.el10.noarch.rpm;name=aarch64_ansible-collection-redhat-leapp;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-collection-redhat-leapp}"
SRC_URI[aarch64_ansible-collection-redhat-leapp.sha256sum] = "8b991c66944606df48079d6c9dfec2fe7e17e512ab2211b6239386e2d229b8c0"

RDEPENDS:ansible-collection-redhat-leapp = " \
 ansible-core \
 bash \
 rhel-system-roles \
 "
