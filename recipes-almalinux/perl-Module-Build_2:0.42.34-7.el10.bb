# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Module-Build"
PE = "2"
PV = "0.42.34"
PR = "7.el10"
PACKAGES = " \
 perl-Module-Build \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Module-Build-0.42.34-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "691695adbbd2d5b3919864a855f7a132a8166fa4f91cd7bfce6728e7b6ae81ad"

URI_x86_64_v2_perl-Module-Build = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Module-Build-0.42.34-7.el10.noarch.rpm;name=x86_64_v2_perl-Module-Build;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Module-Build}"
SRC_URI[x86_64_v2_perl-Module-Build.sha256sum] = "5a3ae36574d432531f5738b4db075b970b352014c25de2347c7346fa9f032ac1"

URI_aarch64_perl-Module-Build = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Module-Build-0.42.34-7.el10.noarch.rpm;name=aarch64_perl-Module-Build;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Module-Build}"
SRC_URI[aarch64_perl-Module-Build.sha256sum] = "5a3ae36574d432531f5738b4db075b970b352014c25de2347c7346fa9f032ac1"

RDEPENDS:perl-Module-Build = " \
 perl-CPAN-Meta \
 perl-Carp \
 perl-Data-Dumper \
 perl-ExtUtils-Install \
 perl-ExtUtils-MakeMaker \
 perl-ExtUtils-Manifest \
 perl-ExtUtils-ParseXS \
 perl-File-Basename \
 perl-File-Compare \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-Getopt-Long \
 perl-Module-Build \
 perl-Module-Metadata \
 perl-PathTools \
 perl-Perl-OSType \
 perl-Pod-Html \
 perl-Software-License \
 perl-Test-Harness \
 perl-Text-ParseWords \
 perl-inc-latest \
 perl-interpreter \
 perl-libs \
 perl-podlators \
 perl-version \
 "
