# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-responses"
PV = "0.25.7"
PR = "1.el10_0"
PACKAGES = " \
 python3-responses \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-responses-0.25.7-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c2684981c6f6270d2d72064a2d0a976853027047d835c72a69491fdc928c364"

URI_x86_64_v2_python3-responses = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-responses-0.25.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-responses;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-responses}"
SRC_URI[x86_64_v2_python3-responses.sha256sum] = "4fa30c6ef7aed02bf58a363f396a3dfaa333427d50182d0e82b0b71a74710fed"

URI_aarch64_python3-responses = "${EPEL_MIRROR}/aarch64/Packages/p/python3-responses-0.25.7-1.el10_0.noarch.rpm;name=aarch64_python3-responses;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-responses}"
SRC_URI[aarch64_python3-responses.sha256sum] = "633e6149c2cbadfc6856bc033ca147b2d4753f8f7f43190d556c8385705c9adf"

RDEPENDS:python3-responses = " \
 python3 \
 python3-pyyaml \
 python3-requests \
 python3-urllib3 \
 "
