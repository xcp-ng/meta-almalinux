# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mediainfo"
PV = "25.07"
PR = "1.el10_2"
PACKAGES = " \
 mediainfo \
 mediainfo-gui \
 mediainfo-qt \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mediainfo-25.07-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6ab42aa082b7b6af8c2cac16feb1a2cd94c6309cc28e3734ece7ec5a12724946"

URI_x86_64_v2_mediainfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mediainfo-25.07-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mediainfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mediainfo}"
SRC_URI[x86_64_v2_mediainfo.sha256sum] = "5d73d943927a69e64db8905f2250c2337a7cbd4fdfd9aaaa6057fba71fa6ac18"

URI_x86_64_v2_mediainfo-gui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mediainfo-gui-25.07-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mediainfo-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mediainfo-gui}"
SRC_URI[x86_64_v2_mediainfo-gui.sha256sum] = "0371053cd3b74e022dc4bea9f24317f978b4d1fd1c8c710de1c8479556a239f4"

URI_x86_64_v2_mediainfo-qt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mediainfo-qt-25.07-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mediainfo-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mediainfo-qt}"
SRC_URI[x86_64_v2_mediainfo-qt.sha256sum] = "e2ba82d4797e24ae27f4bb3882473840d073734cf520e08b54b3e2ad2ad365b7"

URI_aarch64_mediainfo = "${EPEL_MIRROR}/aarch64/Packages/m/mediainfo-25.07-1.el10_2.aarch64.rpm;name=aarch64_mediainfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_mediainfo}"
SRC_URI[aarch64_mediainfo.sha256sum] = "4ff86135b1412137d58b33c752a4589bc89fc049a36adf03e320663f53ba80ee"

URI_aarch64_mediainfo-gui = "${EPEL_MIRROR}/aarch64/Packages/m/mediainfo-gui-25.07-1.el10_2.aarch64.rpm;name=aarch64_mediainfo-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_mediainfo-gui}"
SRC_URI[aarch64_mediainfo-gui.sha256sum] = "dc809ec73002e281532439d6b59f0093eea6bda6e3c714099705a6bd627770ac"

URI_aarch64_mediainfo-qt = "${EPEL_MIRROR}/aarch64/Packages/m/mediainfo-qt-25.07-1.el10_2.aarch64.rpm;name=aarch64_mediainfo-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_mediainfo-qt}"
SRC_URI[aarch64_mediainfo-qt.sha256sum] = "17e9db46c624736a8b2631650defa9962c2bbef1fc3b133075e00809ad7ce8e5"

RDEPENDS:mediainfo = " \
 glibc \
 libgcc \
 libmediainfo \
 libstdc++ \
 libzen \
 "
RDEPENDS:mediainfo-gui = " \
 glibc \
 hicolor-icon-theme \
 libgcc \
 libmediainfo \
 libstdc++ \
 libzen \
 wxBase \
 wxGTK \
 "
RDEPENDS:mediainfo-qt = " \
 glibc \
 libgcc \
 libmediainfo \
 libstdc++ \
 libzen \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
