# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-yasna"
PV = "0.5.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-yasna+bit-vec-devel \
 rust-yasna+default-devel \
 rust-yasna+num-bigint-devel \
 rust-yasna+std-devel \
 rust-yasna+time-devel \
 rust-yasna-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-yasna-0.5.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6e51584b23b2aa7f8eebf5643b0490a13f2e86d58e1aadfa15b89f469decc88"

URI_x86_64_v2_rust-yasna+bit-vec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yasna+bit-vec-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yasna+bit-vec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yasna+bit-vec-devel}"
SRC_URI[x86_64_v2_rust-yasna+bit-vec-devel.sha256sum] = "c8b707124aaeec748031bc8cbac2b37e022ae297e65519631c48ffdd5f3106a4"

URI_x86_64_v2_rust-yasna+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yasna+default-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yasna+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yasna+default-devel}"
SRC_URI[x86_64_v2_rust-yasna+default-devel.sha256sum] = "a4f5531b02cbafa72233dbdb982f257b0f33cdebde25aa36574616805f054f73"

URI_x86_64_v2_rust-yasna+num-bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yasna+num-bigint-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yasna+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yasna+num-bigint-devel}"
SRC_URI[x86_64_v2_rust-yasna+num-bigint-devel.sha256sum] = "c7cbc8091c15d47b75fac180895b95480df425386658a9bac148e35db1116e3f"

URI_x86_64_v2_rust-yasna+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yasna+std-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yasna+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yasna+std-devel}"
SRC_URI[x86_64_v2_rust-yasna+std-devel.sha256sum] = "a5f3f2acf0fde2ea8d2780b5f8f43606a3fae9347d0068d2af809257bdf92afb"

URI_x86_64_v2_rust-yasna+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yasna+time-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yasna+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yasna+time-devel}"
SRC_URI[x86_64_v2_rust-yasna+time-devel.sha256sum] = "c6402a0686bb2657a2c1803539ff3e38eb37ca96d6530972d0874748fec47d18"

URI_x86_64_v2_rust-yasna-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yasna-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yasna-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yasna-devel}"
SRC_URI[x86_64_v2_rust-yasna-devel.sha256sum] = "1a8cf8e112e8b5c8b287cf909b72128cc9e209c5eee2b5b89868632ecce1f3f0"

URI_aarch64_rust-yasna+bit-vec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yasna+bit-vec-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-yasna+bit-vec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yasna+bit-vec-devel}"
SRC_URI[aarch64_rust-yasna+bit-vec-devel.sha256sum] = "bf11e37c66989bfea7b2ceed1c654ecd84eba1e3e43d4973d056397f83a94d39"

URI_aarch64_rust-yasna+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yasna+default-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-yasna+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yasna+default-devel}"
SRC_URI[aarch64_rust-yasna+default-devel.sha256sum] = "5933dd636759cf5174c8a9f04f0445102e4540845ae8b1a045789293f87c6a40"

URI_aarch64_rust-yasna+num-bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yasna+num-bigint-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-yasna+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yasna+num-bigint-devel}"
SRC_URI[aarch64_rust-yasna+num-bigint-devel.sha256sum] = "46def942db5ab81daf2c970dc4e6eebcd71e5e61586284a5052024a1e42eb0be"

URI_aarch64_rust-yasna+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yasna+std-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-yasna+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yasna+std-devel}"
SRC_URI[aarch64_rust-yasna+std-devel.sha256sum] = "f8f46446b8ae78342df3950b11a6ad8d756c5373e088a7e20afd4d0f401ac824"

URI_aarch64_rust-yasna+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yasna+time-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-yasna+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yasna+time-devel}"
SRC_URI[aarch64_rust-yasna+time-devel.sha256sum] = "10a69da53265c4ed8e7ce92c1d99e24ea0316ba89399bdd9c58942cc4c8698c4"

URI_aarch64_rust-yasna-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yasna-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-yasna-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yasna-devel}"
SRC_URI[aarch64_rust-yasna-devel.sha256sum] = "8ca74b2606ce95924b835db435bfb2807dbffb8dc7d5749c701f90fea3fc39e7"

RDEPENDS:rust-yasna+bit-vec-devel = " \
 cargo \
 rust-bit-vec0.6+std-devel \
 rust-bit-vec0.6-devel \
 rust-yasna-devel \
 "
RDEPENDS:rust-yasna+default-devel = " \
 cargo \
 rust-yasna-devel \
 "
RDEPENDS:rust-yasna+num-bigint-devel = " \
 cargo \
 rust-num-bigint+default-devel \
 rust-yasna-devel \
 "
RDEPENDS:rust-yasna+std-devel = " \
 cargo \
 rust-yasna-devel \
 "
RDEPENDS:rust-yasna+time-devel = " \
 cargo \
 rust-time+std-devel \
 rust-time-devel \
 rust-yasna-devel \
 "
RDEPENDS:rust-yasna-devel = " \
 cargo \
 "
