# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-shallow"
PV = "0.5.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-shallow+default-devel \
 rust-gix-shallow+serde-devel \
 rust-gix-shallow-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-shallow-0.5.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a16dbe8cdf52af59340adeee79c08a7fe6b7ab77352dfcb32127af60d98ab705"

URI_x86_64_v2_rust-gix-shallow+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-shallow+default-devel-0.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-shallow+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-shallow+default-devel}"
SRC_URI[x86_64_v2_rust-gix-shallow+default-devel.sha256sum] = "b5a91a5b886f2f89531cef6150d2d265fd20a14f57f4dddd0427248af6cc9b8e"

URI_x86_64_v2_rust-gix-shallow+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-shallow+serde-devel-0.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-shallow+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-shallow+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-shallow+serde-devel.sha256sum] = "572d094c4d97a1875a98ce88124ec3de78e1b70cea3aaa755b96de3446a4ad1c"

URI_x86_64_v2_rust-gix-shallow-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-shallow-devel-0.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-shallow-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-shallow-devel}"
SRC_URI[x86_64_v2_rust-gix-shallow-devel.sha256sum] = "29eb90b474a3f2bc7ed52318b80f6686fbbe00bc93f42092d66a395f784a4e12"

URI_aarch64_rust-gix-shallow+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-shallow+default-devel-0.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-shallow+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-shallow+default-devel}"
SRC_URI[aarch64_rust-gix-shallow+default-devel.sha256sum] = "234fe20b35d2cab28989e129c643c24b8399e215254a94d694f33e0b51abceea"

URI_aarch64_rust-gix-shallow+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-shallow+serde-devel-0.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-shallow+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-shallow+serde-devel}"
SRC_URI[aarch64_rust-gix-shallow+serde-devel.sha256sum] = "0750b10e39cf1f307dbf2a0b4db90a11df30b401f04160fe38582d669fcac769"

URI_aarch64_rust-gix-shallow-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-shallow-devel-0.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-shallow-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-shallow-devel}"
SRC_URI[aarch64_rust-gix-shallow-devel.sha256sum] = "eab54fb14d8eea4f6f3ec9047d655ccf6c8f6f71fa4dd93fd6d93da8bf07e44c"

RDEPENDS:rust-gix-shallow+default-devel = " \
 cargo \
 rust-gix-shallow-devel \
 "
RDEPENDS:rust-gix-shallow+serde-devel = " \
 cargo \
 rust-gix-hash+serde-devel \
 rust-gix-shallow-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-shallow-devel = " \
 cargo \
 rust \
 rust-bstr-devel \
 rust-gix-hash+default-devel \
 rust-gix-lock+default-devel \
 rust-thiserror+default-devel \
 "
