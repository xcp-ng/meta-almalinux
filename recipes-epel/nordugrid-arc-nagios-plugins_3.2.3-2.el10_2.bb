# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nordugrid-arc-nagios-plugins"
PV = "3.2.3"
PR = "2.el10_2"
PACKAGES = " \
 nordugrid-arc-nagios-plugins \
 nordugrid-arc-nagios-plugins-doc \
 nordugrid-arc-nagios-plugins-egi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nordugrid-arc-nagios-plugins-3.2.3-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2472e66aabf2ce41b442be2177685a2cbeb35b10b93b03d6ea8c4f8fbc56e944"

URI_x86_64_v2_nordugrid-arc-nagios-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc-nagios-plugins-3.2.3-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc-nagios-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc-nagios-plugins}"
SRC_URI[x86_64_v2_nordugrid-arc-nagios-plugins.sha256sum] = "3d37bfc97b7c003a24594b215ea6d1f24c82d7d32307ae46cf871b309464e0f7"

URI_x86_64_v2_nordugrid-arc-nagios-plugins-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc-nagios-plugins-doc-3.2.3-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc-nagios-plugins-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc-nagios-plugins-doc}"
SRC_URI[x86_64_v2_nordugrid-arc-nagios-plugins-doc.sha256sum] = "6a311bbfdb3659fae29123f9705f04c4f4817ba1acd005c602d0215c16ddb7e5"

URI_x86_64_v2_nordugrid-arc-nagios-plugins-egi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc-nagios-plugins-egi-3.2.3-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc-nagios-plugins-egi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc-nagios-plugins-egi}"
SRC_URI[x86_64_v2_nordugrid-arc-nagios-plugins-egi.sha256sum] = "a35d2c0f15cbb61409905f45603835aa31ac0a0a640129cfbe8939c04ae8f906"

URI_aarch64_nordugrid-arc-nagios-plugins = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc-nagios-plugins-3.2.3-2.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc-nagios-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc-nagios-plugins}"
SRC_URI[aarch64_nordugrid-arc-nagios-plugins.sha256sum] = "c12c8771d9d2daa556aa51880e6bb6e533652c88dcd6ce15a0be6f04c1b3562c"

URI_aarch64_nordugrid-arc-nagios-plugins-doc = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc-nagios-plugins-doc-3.2.3-2.el10_2.noarch.rpm;name=aarch64_nordugrid-arc-nagios-plugins-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc-nagios-plugins-doc}"
SRC_URI[aarch64_nordugrid-arc-nagios-plugins-doc.sha256sum] = "06501cba6d08b7503d932e2eb4512d771e9822d15a6e3cc0f2591c8ca9f2674c"

URI_aarch64_nordugrid-arc-nagios-plugins-egi = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc-nagios-plugins-egi-3.2.3-2.el10_2.noarch.rpm;name=aarch64_nordugrid-arc-nagios-plugins-egi;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc-nagios-plugins-egi}"
SRC_URI[aarch64_nordugrid-arc-nagios-plugins-egi.sha256sum] = "4bfae3f3355e89a29f952e72811ad0a4cb4e818258bf9bd13462ec26e99546ef"

RDEPENDS:nordugrid-arc-nagios-plugins = " \
 nagios-common \
 nordugrid-arc7-client \
 nordugrid-arc7-plugins-needed \
 python3 \
 python3-cryptography \
 python3-jinja2 \
 python3-ldap \
 "
RDEPENDS:nordugrid-arc-nagios-plugins-doc = " \
 "
RDEPENDS:nordugrid-arc-nagios-plugins-egi = " \
 nordugrid-arc-nagios-plugins \
 nordugrid-arc7-plugins-gridftp \
 "
