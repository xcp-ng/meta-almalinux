# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "luajit"
PV = "2.1.1720049189"
PR = "1.el10_0"
PACKAGES = " \
 luajit \
 luajit-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/luajit-2.1.1720049189-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b7ee5eb21ea9085ba22d6fedb139b2e897ebb8e92f7e9a81c623d0197c713d1"

URI_x86_64_v2_luajit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/luajit-2.1.1720049189-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_luajit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_luajit}"
SRC_URI[x86_64_v2_luajit.sha256sum] = "71dab01bf98833678ba0e052cd90503550c1fb9515e577c78ebb95d7951ce11a"

URI_x86_64_v2_luajit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/luajit-devel-2.1.1720049189-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_luajit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_luajit-devel}"
SRC_URI[x86_64_v2_luajit-devel.sha256sum] = "ca81764fd509063734546cca9bfb1ee3ac53e85f996fe9c5f8bdd36cf31379ca"

URI_aarch64_luajit = "${EPEL_MIRROR}/aarch64/Packages/l/luajit-2.1.1720049189-1.el10_0.aarch64.rpm;name=aarch64_luajit;unpack=0"
SRC_URI:append = " ${URI_aarch64_luajit}"
SRC_URI[aarch64_luajit.sha256sum] = "ad8fd92c3ce929a08d36bef087a6960e81c7190078c00e6ca499b7429324a702"

URI_aarch64_luajit-devel = "${EPEL_MIRROR}/aarch64/Packages/l/luajit-devel-2.1.1720049189-1.el10_0.aarch64.rpm;name=aarch64_luajit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_luajit-devel}"
SRC_URI[aarch64_luajit-devel.sha256sum] = "9ab6114413a1355b4a6fa85eba26536a4f1befd2dabc698f2178f65d39545329"

RDEPENDS:luajit = " \
 glibc \
 libgcc \
 "
RDEPENDS:luajit-devel = " \
 luajit \
 pkgconf-pkg-config \
 "
