# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mcf"
PV = "0.6.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-mcf+alloc-devel \
 rust-mcf+base64-devel \
 rust-mcf+default-devel \
 rust-mcf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mcf-0.6.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2bd851151d8ddaa6453de5aaed85bf84f16916f86c63935be639bb940240bc2e"

URI_x86_64_v2_rust-mcf+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mcf+alloc-devel-0.6.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mcf+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mcf+alloc-devel}"
SRC_URI[x86_64_v2_rust-mcf+alloc-devel.sha256sum] = "c9d7d895d5052be3f7677fc17531f5bfa52122fdf0abcf08bfa63ed2d1b05e92"

URI_x86_64_v2_rust-mcf+base64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mcf+base64-devel-0.6.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mcf+base64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mcf+base64-devel}"
SRC_URI[x86_64_v2_rust-mcf+base64-devel.sha256sum] = "3041a2cada62301682ec3e2d9bd0bc959de7b1b18092ee8f41b402c5364a5070"

URI_x86_64_v2_rust-mcf+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mcf+default-devel-0.6.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mcf+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mcf+default-devel}"
SRC_URI[x86_64_v2_rust-mcf+default-devel.sha256sum] = "6d1c4f4774bdb9b7a92add396a94c05983fc409939c9d8e5ba90dc05fc57f116"

URI_x86_64_v2_rust-mcf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mcf-devel-0.6.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mcf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mcf-devel}"
SRC_URI[x86_64_v2_rust-mcf-devel.sha256sum] = "7492079a75b21e8f57858e406a6ce5f96605b68e68213776662050203565fff5"

URI_aarch64_rust-mcf+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mcf+alloc-devel-0.6.0-1.el10_3.noarch.rpm;name=aarch64_rust-mcf+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mcf+alloc-devel}"
SRC_URI[aarch64_rust-mcf+alloc-devel.sha256sum] = "6051d85a3dffc936412d20d0e5a996fd8b5f5226be00e4952f90930287ba901a"

URI_aarch64_rust-mcf+base64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mcf+base64-devel-0.6.0-1.el10_3.noarch.rpm;name=aarch64_rust-mcf+base64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mcf+base64-devel}"
SRC_URI[aarch64_rust-mcf+base64-devel.sha256sum] = "e3d5e147062bca92b603604e69cf671ee74865686675ac29a26d588d4c490c9f"

URI_aarch64_rust-mcf+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mcf+default-devel-0.6.0-1.el10_3.noarch.rpm;name=aarch64_rust-mcf+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mcf+default-devel}"
SRC_URI[aarch64_rust-mcf+default-devel.sha256sum] = "8fc82360de13050ce325745927df842492b5203d029227461f08c823071cc0e2"

URI_aarch64_rust-mcf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mcf-devel-0.6.0-1.el10_3.noarch.rpm;name=aarch64_rust-mcf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mcf-devel}"
SRC_URI[aarch64_rust-mcf-devel.sha256sum] = "218768fbd501d62bd77977f75e4828f5d1a2fe71acfe0d973d1f4f9766246fa3"

RDEPENDS:rust-mcf+alloc-devel = " \
 cargo \
 rust-base64ct+alloc-devel \
 rust-base64ct+default-devel \
 rust-mcf-devel \
 "
RDEPENDS:rust-mcf+base64-devel = " \
 cargo \
 rust-base64ct+default-devel \
 rust-mcf-devel \
 "
RDEPENDS:rust-mcf+default-devel = " \
 cargo \
 rust-mcf+alloc-devel \
 rust-mcf+base64-devel \
 rust-mcf-devel \
 "
RDEPENDS:rust-mcf-devel = " \
 cargo \
 rust \
 "
