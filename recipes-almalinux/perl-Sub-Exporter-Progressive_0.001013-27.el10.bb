# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sub-Exporter-Progressive"
PV = "0.001013"
PR = "27.el10"
PACKAGES = " \
 perl-Sub-Exporter-Progressive \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Sub-Exporter-Progressive-0.001013-27.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "401218e87c17bd29c1982405892a3989a3a0af381d42ea600dccba21a1805b6a"

URI_x86_64_v2_perl-Sub-Exporter-Progressive = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Sub-Exporter-Progressive-0.001013-27.el10.noarch.rpm;name=x86_64_v2_perl-Sub-Exporter-Progressive;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sub-Exporter-Progressive}"
SRC_URI[x86_64_v2_perl-Sub-Exporter-Progressive.sha256sum] = "d2351f70c32b95e0fd397c3084f033284a3db6651512bc0cc947d04ae9e97b39"

URI_aarch64_perl-Sub-Exporter-Progressive = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Sub-Exporter-Progressive-0.001013-27.el10.noarch.rpm;name=aarch64_perl-Sub-Exporter-Progressive;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sub-Exporter-Progressive}"
SRC_URI[aarch64_perl-Sub-Exporter-Progressive.sha256sum] = "d2351f70c32b95e0fd397c3084f033284a3db6651512bc0cc947d04ae9e97b39"

RDEPENDS:perl-Sub-Exporter-Progressive = " \
 perl-Carp \
 perl-Exporter \
 perl-Sub-Exporter \
 perl-libs \
 "
