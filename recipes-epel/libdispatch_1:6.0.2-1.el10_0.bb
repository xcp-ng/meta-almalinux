# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdispatch"
PE = "1"
PV = "6.0.2"
PR = "1.el10_0"
PACKAGES = " \
 libdispatch \
 libdispatch-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libdispatch-6.0.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5637262f1d60e7492875afd3a2ba52ac1af287706276853943052c6c270d6bf2"

URI_x86_64_v2_libdispatch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdispatch-6.0.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdispatch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdispatch}"
SRC_URI[x86_64_v2_libdispatch.sha256sum] = "c2073a6c9c1414029b77a32fa7dff5a2adb8c7f5d7a39b037086c8a4eabf7e08"

URI_x86_64_v2_libdispatch-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdispatch-devel-6.0.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdispatch-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdispatch-devel}"
SRC_URI[x86_64_v2_libdispatch-devel.sha256sum] = "546b186405a78685a88ba1b4e93810760f4a0b0c09587f2c59285b857222d370"

URI_aarch64_libdispatch = "${EPEL_MIRROR}/aarch64/Packages/l/libdispatch-6.0.2-1.el10_0.aarch64.rpm;name=aarch64_libdispatch;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdispatch}"
SRC_URI[aarch64_libdispatch.sha256sum] = "b369dcbd547f79dab46205f0a79a1dc2a9584bc655d8b5f666076074b0fb4d9d"

URI_aarch64_libdispatch-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libdispatch-devel-6.0.2-1.el10_0.aarch64.rpm;name=aarch64_libdispatch-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdispatch-devel}"
SRC_URI[aarch64_libdispatch-devel.sha256sum] = "b15c7400e47325cae22867886da279c5b283902398ad6793fe3adae7ff1c7f1a"

RDEPENDS:libdispatch = " \
 glibc \
 "
RDEPENDS:libdispatch-devel = " \
 libdispatch \
 "
