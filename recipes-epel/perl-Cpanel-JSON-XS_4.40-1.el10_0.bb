# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Cpanel-JSON-XS"
PV = "4.40"
PR = "1.el10_0"
PACKAGES = " \
 perl-Cpanel-JSON-XS \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Cpanel-JSON-XS-4.40-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b08d3c1aaac3f0f7df326bbd0a21ad97004f421d4f88be300b6d7beaeb9be1ba"

URI_x86_64_v2_perl-Cpanel-JSON-XS = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Cpanel-JSON-XS-4.40-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Cpanel-JSON-XS;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Cpanel-JSON-XS}"
SRC_URI[x86_64_v2_perl-Cpanel-JSON-XS.sha256sum] = "5af7f7651c7883f4c2bc6500a3e7d6c90013a2d4366a0b0e292cdc70f9e60414"

URI_aarch64_perl-Cpanel-JSON-XS = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Cpanel-JSON-XS-4.40-1.el10_0.aarch64.rpm;name=aarch64_perl-Cpanel-JSON-XS;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Cpanel-JSON-XS}"
SRC_URI[aarch64_perl-Cpanel-JSON-XS.sha256sum] = "94b1250ffe9da310dc710b1ecbf72643e61176f24f010b8ab0044047619534a3"

RDEPENDS:perl-Cpanel-JSON-XS = " \
 glibc \
 perl-Carp \
 perl-Cpanel-JSON-XS \
 perl-Encode \
 perl-Exporter \
 perl-Getopt-Long \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-overload \
 "
