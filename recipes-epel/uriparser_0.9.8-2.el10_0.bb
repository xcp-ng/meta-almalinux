# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "uriparser"
PV = "0.9.8"
PR = "2.el10_0"
PACKAGES:x86_64_v2 = " \
 uriparser \
 uriparser-devel \
 uriparser-doc \
"
PACKAGES:aarch64 = " \
 mingw32-uriparser \
 mingw64-uriparser \
 uriparser \
 uriparser-devel \
 uriparser-doc \
"

URI_src = "${EPELSRC_MIRROR}/Packages/u/uriparser-0.9.8-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "965a532d20727085acb1d0f98af7bc98dec39dd91a24c6b24b42fa3747ab4cb3"

URI_x86_64_v2_uriparser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uriparser-0.9.8-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uriparser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uriparser}"
SRC_URI[x86_64_v2_uriparser.sha256sum] = "d7034e520c4ab7c754550fcb7215678553278f0f45b0d93deee178a24c0bf890"

URI_x86_64_v2_uriparser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uriparser-devel-0.9.8-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uriparser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uriparser-devel}"
SRC_URI[x86_64_v2_uriparser-devel.sha256sum] = "7f4e860fce618594a5faf4b5df188c1f77d41cbf795a3b97c5d6512d6cbe285a"

URI_x86_64_v2_uriparser-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uriparser-doc-0.9.8-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_uriparser-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uriparser-doc}"
SRC_URI[x86_64_v2_uriparser-doc.sha256sum] = "925f2c4ae4ccd5eff227043c571a988318bc3d657d1ebcc857abda2861c6dc68"

URI_aarch64_mingw32-uriparser = "${EPEL_MIRROR}/aarch64/Packages/m/mingw32-uriparser-0.9.8-2.el10_0.noarch.rpm;name=aarch64_mingw32-uriparser;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw32-uriparser}"
SRC_URI[aarch64_mingw32-uriparser.sha256sum] = "8dc5783342e4e4a7f44939cb02ffbaebc448da22ef2f8197d45b4090fe5aab69"

URI_aarch64_mingw64-uriparser = "${EPEL_MIRROR}/aarch64/Packages/m/mingw64-uriparser-0.9.8-2.el10_0.noarch.rpm;name=aarch64_mingw64-uriparser;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw64-uriparser}"
SRC_URI[aarch64_mingw64-uriparser.sha256sum] = "be99b7d70e3df9a6df9baf419a6cda3b62df0234489d49aac7fce99d28333513"

URI_aarch64_uriparser = "${EPEL_MIRROR}/aarch64/Packages/u/uriparser-0.9.8-2.el10_0.aarch64.rpm;name=aarch64_uriparser;unpack=0"
SRC_URI:append = " ${URI_aarch64_uriparser}"
SRC_URI[aarch64_uriparser.sha256sum] = "fb6980550d67b4ff39baed9183a1c5c7c3b8b45e20e2d9836447043f1338886a"

URI_aarch64_uriparser-devel = "${EPEL_MIRROR}/aarch64/Packages/u/uriparser-devel-0.9.8-2.el10_0.aarch64.rpm;name=aarch64_uriparser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_uriparser-devel}"
SRC_URI[aarch64_uriparser-devel.sha256sum] = "fe30013676f2c2d48b91013e6a53015efeaff4fee07c626ff834620e7032d4a5"

URI_aarch64_uriparser-doc = "${EPEL_MIRROR}/aarch64/Packages/u/uriparser-doc-0.9.8-2.el10_0.noarch.rpm;name=aarch64_uriparser-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_uriparser-doc}"
SRC_URI[aarch64_uriparser-doc.sha256sum] = "491b220090f1c2ba5c9eeaeb424cbd271eed70158c41844a3d41cd1d368cf3e4"

RDEPENDS:uriparser = " \
 glibc \
 "
RDEPENDS:uriparser-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 uriparser \
 "
RDEPENDS:uriparser-doc = " \
 "
RDEPENDS:mingw32-uriparser = " \
 mingw32-crt \
 mingw32-filesystem \
 "
RDEPENDS:mingw64-uriparser = " \
 mingw64-crt \
 mingw64-filesystem \
 "
