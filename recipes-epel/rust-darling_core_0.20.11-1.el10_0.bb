# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-darling_core"
PV = "0.20.11"
PR = "1.el10_0"
PACKAGES = " \
 rust-darling_core+default-devel \
 rust-darling_core+diagnostics-devel \
 rust-darling_core+strsim-devel \
 rust-darling_core+suggestions-devel \
 rust-darling_core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-darling_core-0.20.11-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2954b3293c466b7eafe226de6a00ede666a9819ea8cb0082b0ffcca97562cb03"

URI_x86_64_v2_rust-darling_core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling_core+default-devel-0.20.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling_core+default-devel}"
SRC_URI[x86_64_v2_rust-darling_core+default-devel.sha256sum] = "bf3db8cccc257bb53f11041afa7c861323124636de019ab31c71193f8ae1945f"

URI_x86_64_v2_rust-darling_core+diagnostics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling_core+diagnostics-devel-0.20.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling_core+diagnostics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling_core+diagnostics-devel}"
SRC_URI[x86_64_v2_rust-darling_core+diagnostics-devel.sha256sum] = "64ff77ca8afe77fb4e32ed1550d5fa4f19169c5439c89f713c1b5de49b9ab1ea"

URI_x86_64_v2_rust-darling_core+strsim-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling_core+strsim-devel-0.20.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling_core+strsim-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling_core+strsim-devel}"
SRC_URI[x86_64_v2_rust-darling_core+strsim-devel.sha256sum] = "16bfc7f6d6bf547d5231f33480a97b313b95e4da37f8fd50dfef0abdecb140ed"

URI_x86_64_v2_rust-darling_core+suggestions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling_core+suggestions-devel-0.20.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling_core+suggestions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling_core+suggestions-devel}"
SRC_URI[x86_64_v2_rust-darling_core+suggestions-devel.sha256sum] = "5a2bf74abc90cecb6273a91a069be929ccad4d6b1bf7ec600838a0119de29b37"

URI_x86_64_v2_rust-darling_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling_core-devel-0.20.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling_core-devel}"
SRC_URI[x86_64_v2_rust-darling_core-devel.sha256sum] = "51aa7ec5aef94574d1b643d98027e6ed7e22bed39f5f9fa4c4012e1780cfcc13"

URI_aarch64_rust-darling_core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling_core+default-devel-0.20.11-1.el10_0.noarch.rpm;name=aarch64_rust-darling_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling_core+default-devel}"
SRC_URI[aarch64_rust-darling_core+default-devel.sha256sum] = "ec59f7a96cb3aaadb7d01e53420159cd85994e645aea96641c5e1af69caad7a8"

URI_aarch64_rust-darling_core+diagnostics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling_core+diagnostics-devel-0.20.11-1.el10_0.noarch.rpm;name=aarch64_rust-darling_core+diagnostics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling_core+diagnostics-devel}"
SRC_URI[aarch64_rust-darling_core+diagnostics-devel.sha256sum] = "5a228ac0d66bb9f2b1b1cb8c88b9e3ea8a02d616f5a5e9becdaf5c39ccb53d3a"

URI_aarch64_rust-darling_core+strsim-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling_core+strsim-devel-0.20.11-1.el10_0.noarch.rpm;name=aarch64_rust-darling_core+strsim-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling_core+strsim-devel}"
SRC_URI[aarch64_rust-darling_core+strsim-devel.sha256sum] = "14fa11c342f49e18e740250dea75d1b89420bd68131d053daaa834235c77ee3a"

URI_aarch64_rust-darling_core+suggestions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling_core+suggestions-devel-0.20.11-1.el10_0.noarch.rpm;name=aarch64_rust-darling_core+suggestions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling_core+suggestions-devel}"
SRC_URI[aarch64_rust-darling_core+suggestions-devel.sha256sum] = "7807b738a8e6f97a228402052c7daae0f7f6881bcc2feb6d57dc1e1d82349a6a"

URI_aarch64_rust-darling_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling_core-devel-0.20.11-1.el10_0.noarch.rpm;name=aarch64_rust-darling_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling_core-devel}"
SRC_URI[aarch64_rust-darling_core-devel.sha256sum] = "2a608e91b20218236b53fb1c37b79105b553b3ef90d6387279f07ec037039bb0"

RDEPENDS:rust-darling_core+default-devel = " \
 cargo \
 rust-darling_core-devel \
 "
RDEPENDS:rust-darling_core+diagnostics-devel = " \
 cargo \
 rust-darling_core-devel \
 "
RDEPENDS:rust-darling_core+strsim-devel = " \
 cargo \
 rust-darling_core-devel \
 rust-strsim+default-devel \
 "
RDEPENDS:rust-darling_core+suggestions-devel = " \
 cargo \
 rust-darling_core+strsim-devel \
 rust-darling_core-devel \
 "
RDEPENDS:rust-darling_core-devel = " \
 cargo \
 rust \
 rust-fnv+default-devel \
 rust-ident_case+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 "
