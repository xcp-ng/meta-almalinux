# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-proto-plus"
PV = "1.22.3"
PR = "7.el10_1"
PACKAGES = " \
 python3-proto-plus \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-proto-plus-1.22.3-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f642facb898f32084befc02b7fde89c323a650cf0243bdd22ee33d3df66882a"

URI_x86_64_v2_python3-proto-plus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-proto-plus-1.22.3-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-proto-plus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-proto-plus}"
SRC_URI[x86_64_v2_python3-proto-plus.sha256sum] = "192310151eae9a3998da9188ce383e47e74b9217f0f5bb6a367ec166e980d97e"

URI_aarch64_python3-proto-plus = "${EPEL_MIRROR}/aarch64/Packages/p/python3-proto-plus-1.22.3-7.el10_1.noarch.rpm;name=aarch64_python3-proto-plus;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-proto-plus}"
SRC_URI[aarch64_python3-proto-plus.sha256sum] = "07bd792bafdaea0889332e9fa13dd41f23f3ac89cafd4c6a40cc6c5f8b30d753"

RDEPENDS:python3-proto-plus = " \
 python3 \
 python3-protobuf \
 "
