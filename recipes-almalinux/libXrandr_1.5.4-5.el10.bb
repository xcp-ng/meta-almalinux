# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libXrandr"
PV = "1.5.4"
PR = "5.el10"
PACKAGES = " \
 libXrandr \
 libXrandr-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libXrandr-1.5.4-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c8abc0a257075f00e19c6a5ad499c585ae4297bf8abf754f2a6648bdef9001d7"

URI_x86_64_v2_libXrandr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libXrandr-1.5.4-5.el10.x86_64_v2.rpm;name=x86_64_v2_libXrandr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXrandr}"
SRC_URI[x86_64_v2_libXrandr.sha256sum] = "7753b7d50fec767f3cc9b34cf80a3dbb15ff4a11970707e407780baedca32ec1"

URI_x86_64_v2_libXrandr-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libXrandr-devel-1.5.4-5.el10.x86_64_v2.rpm;name=x86_64_v2_libXrandr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXrandr-devel}"
SRC_URI[x86_64_v2_libXrandr-devel.sha256sum] = "0c906178f77e69474faa658ee2b847b11ff38cd05f8802c0002319184d42884c"

URI_aarch64_libXrandr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libXrandr-1.5.4-5.el10.aarch64.rpm;name=aarch64_libXrandr;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXrandr}"
SRC_URI[aarch64_libXrandr.sha256sum] = "8c1d5fc1cc40c92abd92c4a17d8cdf05ea4828aff46346d98811210ef0c579e0"

URI_aarch64_libXrandr-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libXrandr-devel-1.5.4-5.el10.aarch64.rpm;name=aarch64_libXrandr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXrandr-devel}"
SRC_URI[aarch64_libXrandr-devel.sha256sum] = "9f11fb8af8f374cad00dc17338a0c77f26c34abc6c91f3ddc2d1839b0ff11941"

RDEPENDS:libXrandr = " \
 glibc \
 libX11 \
 libXext \
 libXrender \
 "
RDEPENDS:libXrandr-devel = " \
 libX11-devel \
 libXext-devel \
 libXrandr \
 libXrender-devel \
 pkgconf-pkg-config \
 xorg-x11-proto-devel \
 "
