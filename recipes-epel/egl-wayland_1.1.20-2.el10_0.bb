# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "egl-wayland"
PV = "1.1.20"
PR = "2.el10_0"
PACKAGES = " \
 egl-wayland \
 egl-wayland-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/egl-wayland-1.1.20-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a9cae998cc3516d86240ac2788e4e28d5352667953db33dfdcdf242a2636f8b"

URI_x86_64_v2_egl-wayland = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/egl-wayland-1.1.20-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_egl-wayland;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_egl-wayland}"
SRC_URI[x86_64_v2_egl-wayland.sha256sum] = "19977f9da1396527822f42caac39067cfd27688dea2bc93210e0ef8360bc0bdb"

URI_x86_64_v2_egl-wayland-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/egl-wayland-devel-1.1.20-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_egl-wayland-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_egl-wayland-devel}"
SRC_URI[x86_64_v2_egl-wayland-devel.sha256sum] = "8f9d11dc6d0d66fbe86e2dcbadcda5a387028b72eff52cac01757c1d0640c581"

URI_aarch64_egl-wayland = "${EPEL_MIRROR}/aarch64/Packages/e/egl-wayland-1.1.20-2.el10_0.aarch64.rpm;name=aarch64_egl-wayland;unpack=0"
SRC_URI:append = " ${URI_aarch64_egl-wayland}"
SRC_URI[aarch64_egl-wayland.sha256sum] = "2a36043fd95409721a9aca136e2baa0778aa8d9a3ac8a7c90d144aaddec0a051"

URI_aarch64_egl-wayland-devel = "${EPEL_MIRROR}/aarch64/Packages/e/egl-wayland-devel-1.1.20-2.el10_0.aarch64.rpm;name=aarch64_egl-wayland-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_egl-wayland-devel}"
SRC_URI[aarch64_egl-wayland-devel.sha256sum] = "fd152b3f8ab33c3a4cf3c6674d4d7f2cd4c973144f7c9ea7824c935ce26dd8ec"

RDEPENDS:egl-wayland = " \
 glibc \
 libdrm \
 libglvnd-egl \
 libwayland-client \
 libwayland-server \
 "
RDEPENDS:egl-wayland-devel = " \
 egl-wayland \
 eglexternalplatform-devel \
 pkgconf-pkg-config \
 "
