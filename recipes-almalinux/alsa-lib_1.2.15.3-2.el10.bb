# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "alsa-lib"
PV = "1.2.15.3"
PR = "2.el10"
PACKAGES = " \
 alsa-lib \
 alsa-lib-devel \
 alsa-ucm \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/alsa-lib-1.2.15.3-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6a392269ee7792e48e91cd2a3207754317e4a077d85f5017d840eb68a1915408"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/alsa-lib-1.2.15.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_alsa-lib;unpack=0"
SRC_URI[x86_64_v2_alsa-lib.sha256sum] = "700b2a13ad77a6f13b791e08ed16cf47555a4d5c392098952b892440902d0097"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/alsa-lib-devel-1.2.15.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_alsa-lib-devel;unpack=0"
SRC_URI[x86_64_v2_alsa-lib-devel.sha256sum] = "1c6d620db6233f4aae29bf07cb97817d3747594f40103b0352977947373afd80"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/alsa-ucm-1.2.15.3-2.el10.noarch.rpm;name=x86_64_v2_alsa-ucm;unpack=0"
SRC_URI[x86_64_v2_alsa-ucm.sha256sum] = "2b923bcca43b6795808e1c2a5a5336d9d5a305439ed1f20dde2ede949e864a19"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/alsa-lib-1.2.15.3-2.el10.aarch64.rpm;name=aarch64_alsa-lib;unpack=0"
SRC_URI[aarch64_alsa-lib.sha256sum] = "5b551b4ed930af2529f1bae5f3544d5c6b875dc6ff59ef943a3471480344df0d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/alsa-lib-devel-1.2.15.3-2.el10.aarch64.rpm;name=aarch64_alsa-lib-devel;unpack=0"
SRC_URI[aarch64_alsa-lib-devel.sha256sum] = "cee349eeed8a8b7a5d6334e6eafe86cd3dbb9eb8ebe50befb73f3dc2a2cacaab"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/alsa-ucm-1.2.15.3-2.el10.noarch.rpm;name=aarch64_alsa-ucm;unpack=0"
SRC_URI[aarch64_alsa-ucm.sha256sum] = "2b923bcca43b6795808e1c2a5a5336d9d5a305439ed1f20dde2ede949e864a19"

RDEPENDS:alsa-lib = " \
 glibc \
 "
RDEPENDS:alsa-lib-devel = " \
 alsa-lib \
 alsa-lib-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:alsa-ucm = " \
 alsa-lib \
 "
