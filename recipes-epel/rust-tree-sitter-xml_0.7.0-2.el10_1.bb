# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-xml"
PV = "0.7.0"
PR = "2.el10_1"
PACKAGES = " \
 rust-tree-sitter-xml+default-devel \
 rust-tree-sitter-xml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-xml-0.7.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c3cadc56c0ee685802bff17b0223d7076455e5baff107279af660e6ada062ab"

URI_x86_64_v2_rust-tree-sitter-xml+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-xml+default-devel-0.7.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-xml+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-xml+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-xml+default-devel.sha256sum] = "6c8d1893e8108a8b4403639dc8bf1d30aecf2679328a3f9b3c7a2f63445bc2c5"

URI_x86_64_v2_rust-tree-sitter-xml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-xml-devel-0.7.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-xml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-xml-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-xml-devel.sha256sum] = "10ca7f9160ef559814cf97aeefc3b054e8bdbd41c799c8853102d731b5a8ef76"

URI_aarch64_rust-tree-sitter-xml+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-xml+default-devel-0.7.0-2.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-xml+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-xml+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-xml+default-devel.sha256sum] = "c13bc278dc5ed6347d8f95d598f0c28ae4d2c68148c489e2ec28fe01bbf6d52c"

URI_aarch64_rust-tree-sitter-xml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-xml-devel-0.7.0-2.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-xml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-xml-devel}"
SRC_URI[aarch64_rust-tree-sitter-xml-devel.sha256sum] = "8e99b8c83f4a179d37ccbe8c3456f1cf589fda67f00988ba7e1c688299fdf68c"

RDEPENDS:rust-tree-sitter-xml+default-devel = " \
 cargo \
 rust-tree-sitter-xml-devel \
 "
RDEPENDS:rust-tree-sitter-xml-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
