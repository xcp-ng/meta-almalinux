# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libyang"
PV = "2.1.148"
PR = "2.el10"
PACKAGES = " \
 libyang \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libyang-2.1.148-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "02b2f71d6db81bd1427227dad969f502117460a7521b9d07f096fcace1a043ed"

URI_x86_64_v2_libyang = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libyang-2.1.148-2.el10.x86_64_v2.rpm;name=x86_64_v2_libyang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libyang}"
SRC_URI[x86_64_v2_libyang.sha256sum] = "46eb22214aba42f6a730cda93dffb413cf85ee9bd7fbd3038c55f0f78753fdc8"

URI_aarch64_libyang = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libyang-2.1.148-2.el10.aarch64.rpm;name=aarch64_libyang;unpack=0"
SRC_URI:append = " ${URI_aarch64_libyang}"
SRC_URI[aarch64_libyang.sha256sum] = "f5f5005eeec43970870fe61706bf989aeedc7e347c0eb036c78c533f447fd5d5"

RDEPENDS:libyang = " \
 glibc \
 pcre2 \
 "
