# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kolf"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kolf \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kolf-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "11e8152337057da4a3bb83cfa36cf5fc42fa07a90936fb0ea5185a91b32d413e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kolf-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kolf;unpack=0"
SRC_URI[x86_64_v2_kolf.sha256sum] = "67ac8c3ce4a20c569f21102b7c66497d0a897d438a3e2ff20870bab2086b0ff4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kolf-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kolf;unpack=0"
SRC_URI[aarch64_kolf.sha256sum] = "7399e3f037954eb64ed497d4f87a706509f5350fff372624aca1f3884428860d"

RDEPENDS:kolf = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
