# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "audex"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 audex \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/audex-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "58247b351f66b288048ed8a0561100b726235d0e0c8411ef930d6a8a2531ba57"

URI_x86_64_v2_audex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/audex-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_audex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audex}"
SRC_URI[x86_64_v2_audex.sha256sum] = "4b202e22210249449405ee5102c115805be5fd171dc10f31a3a05de4421e102a"

URI_aarch64_audex = "${EPEL_MIRROR}/aarch64/Packages/a/audex-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_audex;unpack=0"
SRC_URI:append = " ${URI_aarch64_audex}"
SRC_URI[aarch64_audex.sha256sum] = "696376e57d9c15d7f953465d8ec6e92542cc827d39a1864f4e8756d26ad12e3f"

RDEPENDS:audex = " \
 glibc \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-solid \
 libcdio-paranoia \
 libkcddb \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
