# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "konversation"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 konversation \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/konversation-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "21e32c213ab105e07f88e3d63413fd558e03e8d58fee77e65d0ae9a0168fa02d"

URI_x86_64_v2_konversation = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konversation-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konversation;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_konversation}"
SRC_URI[x86_64_v2_konversation.sha256sum] = "1d1e82b7a527300e103026e21346418317941a9573cc9460dbbf4b6e712345f1"

URI_aarch64_konversation = "${EPEL_MIRROR}/aarch64/Packages/k/konversation-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_konversation;unpack=0"
SRC_URI:append = " ${URI_aarch64_konversation}"
SRC_URI[aarch64_konversation.sha256sum] = "f2d38c5417df3c635a55f40a87ecaad75a931da76204ed8ebf7c4c13f0095508"

RDEPENDS:konversation = " \
 bash \
 glibc \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kidletime \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kparts \
 kf6-kstatusnotifieritem \
 kf6-ktextwidgets \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 perl-interpreter \
 python3 \
 qca-qt6 \
 qca-qt6-ossl \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 "
