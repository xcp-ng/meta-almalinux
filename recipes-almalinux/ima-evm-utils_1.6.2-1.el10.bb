# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ima-evm-utils"
PV = "1.6.2"
PR = "1.el10"
PACKAGES = " \
 ima-evm-utils \
 ima-evm-utils-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/ima-evm-utils-1.6.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2b71bab3dddfacf7fd669a1327d20e2287361c2374767d36837bba7f7b69153"

URI_x86_64_v2_ima-evm-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ima-evm-utils-1.6.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_ima-evm-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ima-evm-utils}"
SRC_URI[x86_64_v2_ima-evm-utils.sha256sum] = "6e04502f7de9220145d62d303883cd64886a746e943a7a108f8d11971639ac24"

URI_x86_64_v2_ima-evm-utils-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ima-evm-utils-devel-1.6.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_ima-evm-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ima-evm-utils-devel}"
SRC_URI[x86_64_v2_ima-evm-utils-devel.sha256sum] = "b8ea7d892490a2a7171ce26120e0fe2b740e48b0ee9d4019fb2235d40ac72ea1"

URI_aarch64_ima-evm-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ima-evm-utils-1.6.2-1.el10.aarch64.rpm;name=aarch64_ima-evm-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_ima-evm-utils}"
SRC_URI[aarch64_ima-evm-utils.sha256sum] = "1b4efafb12ad0c3acad4c98aa4f201d2c6365ad6c09e3eed2bd58d0f7855e313"

URI_aarch64_ima-evm-utils-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ima-evm-utils-devel-1.6.2-1.el10.aarch64.rpm;name=aarch64_ima-evm-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ima-evm-utils-devel}"
SRC_URI[aarch64_ima-evm-utils-devel.sha256sum] = "e2453bdbe3ad2f50dd2f8fc69c474103ebdfdd810adaa4fd7f9007cdbb7b4afc"

RDEPENDS:ima-evm-utils = " \
 attr \
 bash \
 glibc \
 keyutils \
 keyutils-libs \
 openssl-libs \
 tpm2-tss \
 "
RDEPENDS:ima-evm-utils-devel = " \
 ima-evm-utils \
 "
