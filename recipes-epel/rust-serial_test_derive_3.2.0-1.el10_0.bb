# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serial_test_derive"
PV = "3.2.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-serial_test_derive+async-devel \
 rust-serial_test_derive+default-devel \
 rust-serial_test_derive+test_logging-devel \
 rust-serial_test_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serial_test_derive-3.2.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "54dad09d3ed7ffca1ab72113668b77a3374745c1550e8635499dc695eb41f11d"

URI_x86_64_v2_rust-serial_test_derive+async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test_derive+async-devel-3.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test_derive+async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test_derive+async-devel}"
SRC_URI[x86_64_v2_rust-serial_test_derive+async-devel.sha256sum] = "8e4eeeb682906120747b02ff584d6e3012baf448444fa5aeaf98b2f5f87510b3"

URI_x86_64_v2_rust-serial_test_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test_derive+default-devel-3.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test_derive+default-devel}"
SRC_URI[x86_64_v2_rust-serial_test_derive+default-devel.sha256sum] = "7f428dd95d69f97a3884b3f7104ba5bc844bf56e75d7556f36be8b64134a351f"

URI_x86_64_v2_rust-serial_test_derive+test_logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test_derive+test_logging-devel-3.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test_derive+test_logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test_derive+test_logging-devel}"
SRC_URI[x86_64_v2_rust-serial_test_derive+test_logging-devel.sha256sum] = "468b7b42429b768b3d081dd871ca9dae23ede6a756338fd7ff4d342368676a80"

URI_x86_64_v2_rust-serial_test_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test_derive-devel-3.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test_derive-devel}"
SRC_URI[x86_64_v2_rust-serial_test_derive-devel.sha256sum] = "25ea26d560191faae6b7327ca4cdcaba965864200d2a7af422b4126ba2562b4b"

URI_aarch64_rust-serial_test_derive+async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test_derive+async-devel-3.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-serial_test_derive+async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test_derive+async-devel}"
SRC_URI[aarch64_rust-serial_test_derive+async-devel.sha256sum] = "c79543645043bab068e6278448392f1d81f1f2c92188bd24bd2f6335c29ed7dd"

URI_aarch64_rust-serial_test_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test_derive+default-devel-3.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-serial_test_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test_derive+default-devel}"
SRC_URI[aarch64_rust-serial_test_derive+default-devel.sha256sum] = "06f5739a7f63173888f48381542444fb59d7d79c84db578749a8481531a319c5"

URI_aarch64_rust-serial_test_derive+test_logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test_derive+test_logging-devel-3.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-serial_test_derive+test_logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test_derive+test_logging-devel}"
SRC_URI[aarch64_rust-serial_test_derive+test_logging-devel.sha256sum] = "dc555c7e7224092a201f6cff1ea29c8f957577acff5031b095ae1b9bebb3a030"

URI_aarch64_rust-serial_test_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test_derive-devel-3.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-serial_test_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test_derive-devel}"
SRC_URI[aarch64_rust-serial_test_derive-devel.sha256sum] = "cf9fd093e46c8b9d696ac21e3ac58e11f251ed23eac85800c31c6f84cec0f1d2"

RDEPENDS:rust-serial_test_derive+async-devel = " \
 cargo \
 rust-serial_test_derive-devel \
 "
RDEPENDS:rust-serial_test_derive+default-devel = " \
 cargo \
 rust-serial_test_derive-devel \
 "
RDEPENDS:rust-serial_test_derive+test_logging-devel = " \
 cargo \
 rust-serial_test_derive-devel \
 "
RDEPENDS:rust-serial_test_derive-devel = " \
 cargo \
 rust-proc-macro2+proc-macro-devel \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn-devel \
 "
