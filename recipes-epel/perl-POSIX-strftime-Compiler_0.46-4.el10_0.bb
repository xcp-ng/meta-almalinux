# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-POSIX-strftime-Compiler"
PV = "0.46"
PR = "4.el10_0"
PACKAGES = " \
 perl-POSIX-strftime-Compiler \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-POSIX-strftime-Compiler-0.46-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bff1271b25a3b5268c2368a5ed1dddc0bf4150586d3aaa7294841163ed12bf91"

URI_x86_64_v2_perl-POSIX-strftime-Compiler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-POSIX-strftime-Compiler-0.46-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-POSIX-strftime-Compiler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-POSIX-strftime-Compiler}"
SRC_URI[x86_64_v2_perl-POSIX-strftime-Compiler.sha256sum] = "6c520a81f8e7d368aa0595c2bc4926885ae861ebbfc67b1c8e37f7de4c68a94d"

URI_aarch64_perl-POSIX-strftime-Compiler = "${EPEL_MIRROR}/aarch64/Packages/p/perl-POSIX-strftime-Compiler-0.46-4.el10_0.noarch.rpm;name=aarch64_perl-POSIX-strftime-Compiler;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-POSIX-strftime-Compiler}"
SRC_URI[aarch64_perl-POSIX-strftime-Compiler.sha256sum] = "63c795cd70a26c5cede04ebe56cc1a7285223f1eb316902c708ec9691fe0eb75"

RDEPENDS:perl-POSIX-strftime-Compiler = " \
 perl-Carp \
 perl-Exporter \
 perl-POSIX \
 perl-Time-Local \
 perl-base \
 perl-constant \
 perl-libs \
 "
