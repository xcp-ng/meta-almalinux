# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-deprecation"
PV = "2.1.0"
PR = "16.el10_0"
PACKAGES = " \
 python3-deprecation \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-deprecation-2.1.0-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d51ce14b88b0830b58e25886ff93c2e1cf85b47ea13f6a395c67180cbe3fb3f4"

URI_x86_64_v2_python3-deprecation = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-deprecation-2.1.0-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-deprecation;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-deprecation}"
SRC_URI[x86_64_v2_python3-deprecation.sha256sum] = "642f1798908daa428e945403abf441e51271baeb8ad9fcde9711cc4c991285b2"

URI_aarch64_python3-deprecation = "${EPEL_MIRROR}/aarch64/Packages/p/python3-deprecation-2.1.0-16.el10_0.noarch.rpm;name=aarch64_python3-deprecation;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-deprecation}"
SRC_URI[aarch64_python3-deprecation.sha256sum] = "5f854c380aa553579f9c799f2bd06fac56b4a0ab3e7259a7116565083a6c8b18"

RDEPENDS:python3-deprecation = " \
 python3 \
 python3-packaging \
 "
