# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-smartstring"
PV = "1.0.1"
PR = "9.el10_2"
PACKAGES = " \
 rust-smartstring+arbitrary-devel \
 rust-smartstring+default-devel \
 rust-smartstring+proptest-devel \
 rust-smartstring+serde-devel \
 rust-smartstring+std-devel \
 rust-smartstring+test-devel \
 rust-smartstring-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-smartstring-1.0.1-9.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "441ced76a6e8ee50089e96abfa2c5d908c9b99afbcfa4fc675ea1e9e7177920b"

URI_x86_64_v2_rust-smartstring+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smartstring+arbitrary-devel-1.0.1-9.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smartstring+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smartstring+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-smartstring+arbitrary-devel.sha256sum] = "c63e1d03baa59618b1c593f92cb7495a5506c6aae09dc4dd7735d1bc0eac05b9"

URI_x86_64_v2_rust-smartstring+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smartstring+default-devel-1.0.1-9.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smartstring+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smartstring+default-devel}"
SRC_URI[x86_64_v2_rust-smartstring+default-devel.sha256sum] = "1c08b959d4bb63b5fe3b8e10b6921fcbeba003af07386449aae546f75169d95b"

URI_x86_64_v2_rust-smartstring+proptest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smartstring+proptest-devel-1.0.1-9.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smartstring+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smartstring+proptest-devel}"
SRC_URI[x86_64_v2_rust-smartstring+proptest-devel.sha256sum] = "96592815b9ecbd4d51b1b3c82bb459c8e9f3c5751e7846278ef5b1d594f33b6d"

URI_x86_64_v2_rust-smartstring+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smartstring+serde-devel-1.0.1-9.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smartstring+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smartstring+serde-devel}"
SRC_URI[x86_64_v2_rust-smartstring+serde-devel.sha256sum] = "e726177ac2048cfbefae84d26d7d99bf6171846f65f0574f46642cde32948a05"

URI_x86_64_v2_rust-smartstring+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smartstring+std-devel-1.0.1-9.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smartstring+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smartstring+std-devel}"
SRC_URI[x86_64_v2_rust-smartstring+std-devel.sha256sum] = "c5cc47ab92947b328702315be54361c36a7e7ce7b60f730485db69a64b1335f5"

URI_x86_64_v2_rust-smartstring+test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smartstring+test-devel-1.0.1-9.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smartstring+test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smartstring+test-devel}"
SRC_URI[x86_64_v2_rust-smartstring+test-devel.sha256sum] = "26a70a994ae4c874be83c2802388c5b3ad9728db25460ce4d171753293641d82"

URI_x86_64_v2_rust-smartstring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smartstring-devel-1.0.1-9.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smartstring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smartstring-devel}"
SRC_URI[x86_64_v2_rust-smartstring-devel.sha256sum] = "1ec09d0e674afc6a2a141fa315d3c5ef320666cd2b30ee10b890640729846464"

URI_aarch64_rust-smartstring+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smartstring+arbitrary-devel-1.0.1-9.el10_2.noarch.rpm;name=aarch64_rust-smartstring+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smartstring+arbitrary-devel}"
SRC_URI[aarch64_rust-smartstring+arbitrary-devel.sha256sum] = "c395a5087b47063c1914ee8a0d64e8c15131e1b2aa09292e408db7dae9dc3752"

URI_aarch64_rust-smartstring+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smartstring+default-devel-1.0.1-9.el10_2.noarch.rpm;name=aarch64_rust-smartstring+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smartstring+default-devel}"
SRC_URI[aarch64_rust-smartstring+default-devel.sha256sum] = "e40709ffecf95f61b9a6a5261281531bf71ca2e497f9d4ea07935b642ee9535f"

URI_aarch64_rust-smartstring+proptest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smartstring+proptest-devel-1.0.1-9.el10_2.noarch.rpm;name=aarch64_rust-smartstring+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smartstring+proptest-devel}"
SRC_URI[aarch64_rust-smartstring+proptest-devel.sha256sum] = "9bff51bb51919ba1fa62901ef554e974c09011fe19bac0b82cd92547b139e527"

URI_aarch64_rust-smartstring+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smartstring+serde-devel-1.0.1-9.el10_2.noarch.rpm;name=aarch64_rust-smartstring+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smartstring+serde-devel}"
SRC_URI[aarch64_rust-smartstring+serde-devel.sha256sum] = "407af17bfe46942bcfc21f70b641fd5feb3757bd396bedb3f772585a2d89d048"

URI_aarch64_rust-smartstring+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smartstring+std-devel-1.0.1-9.el10_2.noarch.rpm;name=aarch64_rust-smartstring+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smartstring+std-devel}"
SRC_URI[aarch64_rust-smartstring+std-devel.sha256sum] = "8c5d39ee380305c55e9aa5bafda9d8e354093b644385e7d2565ab80972f11ac2"

URI_aarch64_rust-smartstring+test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smartstring+test-devel-1.0.1-9.el10_2.noarch.rpm;name=aarch64_rust-smartstring+test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smartstring+test-devel}"
SRC_URI[aarch64_rust-smartstring+test-devel.sha256sum] = "0b784eaf1218c43a25cdf6532504ee5881461f81d888e53e2d73434e9c3aa9ed"

URI_aarch64_rust-smartstring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smartstring-devel-1.0.1-9.el10_2.noarch.rpm;name=aarch64_rust-smartstring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smartstring-devel}"
SRC_URI[aarch64_rust-smartstring-devel.sha256sum] = "bfd64239db993df8d68777810df24bd4789312620be21824621dcbc2c577f623"

RDEPENDS:rust-smartstring+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-smartstring-devel \
 "
RDEPENDS:rust-smartstring+default-devel = " \
 cargo \
 rust-smartstring+std-devel \
 rust-smartstring-devel \
 "
RDEPENDS:rust-smartstring+proptest-devel = " \
 cargo \
 rust-proptest+default-devel \
 rust-smartstring-devel \
 "
RDEPENDS:rust-smartstring+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-smartstring-devel \
 "
RDEPENDS:rust-smartstring+std-devel = " \
 cargo \
 rust-smartstring-devel \
 "
RDEPENDS:rust-smartstring+test-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-smartstring+arbitrary-devel \
 rust-smartstring+std-devel \
 rust-smartstring-devel \
 "
RDEPENDS:rust-smartstring-devel = " \
 cargo \
 rust \
 rust-autocfg+default-devel \
 rust-static_assertions+default-devel \
 rust-version_check+default-devel \
 "
