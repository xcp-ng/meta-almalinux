# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-shell-extension-caffeine"
PV = "58"
PR = "1.el10_2"
PACKAGES = " \
 gnome-shell-extension-caffeine \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gnome-shell-extension-caffeine-58-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "93b225dd971854147f3d5f13e15894620079c7059e6e24b488dffa9fe98197b2"

URI_x86_64_v2_gnome-shell-extension-caffeine = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnome-shell-extension-caffeine-58-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_gnome-shell-extension-caffeine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-caffeine}"
SRC_URI[x86_64_v2_gnome-shell-extension-caffeine.sha256sum] = "fb74335b346864551378464bdfb10580930a59ef57748f3b464fc276ed3e96cb"

URI_aarch64_gnome-shell-extension-caffeine = "${EPEL_MIRROR}/aarch64/Packages/g/gnome-shell-extension-caffeine-58-1.el10_2.noarch.rpm;name=aarch64_gnome-shell-extension-caffeine;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-caffeine}"
SRC_URI[aarch64_gnome-shell-extension-caffeine.sha256sum] = "ed23a1ed70ab3bbae5de5185d046e150e0345e76a4dfb4928eaa20250a125fcb"

RDEPENDS:gnome-shell-extension-caffeine = " \
 gnome-shell-extension-common \
 "
