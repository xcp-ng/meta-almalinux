# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-azure-storage-blob"
PV = "12.28.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-azure-storage-blob \
 python3-azure-storage-blob+aio \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-azure-storage-blob-12.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f77f29ae575155da0a08ebab3b10aadf160449f2f5473ca1e9ff3a625582e502"

URI_x86_64_v2_python3-azure-storage-blob = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-azure-storage-blob-12.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-azure-storage-blob;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-azure-storage-blob}"
SRC_URI[x86_64_v2_python3-azure-storage-blob.sha256sum] = "edc166cadcaaefd695425bb805daf3e42e3071031a7e48f952e767c6e70eb8e7"

URI_x86_64_v2_python3-azure-storage-blob+aio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-azure-storage-blob+aio-12.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-azure-storage-blob+aio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-azure-storage-blob+aio}"
SRC_URI[x86_64_v2_python3-azure-storage-blob+aio.sha256sum] = "79a293bae6dd7c2cb670799155a189ea8da413802c748bca20e2d86fc3cc6070"

URI_aarch64_python3-azure-storage-blob = "${EPEL_MIRROR}/aarch64/Packages/p/python3-azure-storage-blob-12.28.0-1.el10_3.noarch.rpm;name=aarch64_python3-azure-storage-blob;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-azure-storage-blob}"
SRC_URI[aarch64_python3-azure-storage-blob.sha256sum] = "d14ef18ab70cd2a9d3538bede589e066a8fbdc1e612e85a2c40034262bfa5805"

URI_aarch64_python3-azure-storage-blob+aio = "${EPEL_MIRROR}/aarch64/Packages/p/python3-azure-storage-blob+aio-12.28.0-1.el10_3.noarch.rpm;name=aarch64_python3-azure-storage-blob+aio;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-azure-storage-blob+aio}"
SRC_URI[aarch64_python3-azure-storage-blob+aio.sha256sum] = "16395fab95552a1e482a182acd6d8cf08388a1a00ba8e1dd825be04df69893f2"

RDEPENDS:python3-azure-storage-blob = " \
 python3 \
 python3-azure-core \
 python3-cryptography \
 python3-isodate \
 python3-typing-extensions \
 "
RDEPENDS:python3-azure-storage-blob+aio = " \
 python3 \
 python3-azure-core \
 python3-azure-core+aio \
 python3-azure-storage-blob \
 "
