# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-desktop"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 plasma-desktop \
 plasma-desktop-doc \
 sddm-breeze \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-desktop-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12df060e7b7527fbfb4e6dd6927e62ac240a8e441de6e44e423a5ce553b8a54b"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - sddm-breeze: kde-settings-sddm

URI_x86_64_v2_plasma-desktop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-desktop-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-desktop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-desktop}"
SRC_URI[x86_64_v2_plasma-desktop.sha256sum] = "1c3d838aa713ec938615b2bfb4cc0e5e371a8a15ba5ffb918ffcaca8fd02c9b1"

URI_x86_64_v2_plasma-desktop-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-desktop-doc-6.6.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-desktop-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-desktop-doc}"
SRC_URI[x86_64_v2_plasma-desktop-doc.sha256sum] = "39e306e6318205429815213615b4831e4ad2017aec076ab2b722ce4a1cb70c4c"

URI_x86_64_v2_sddm-breeze = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sddm-breeze-6.6.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_sddm-breeze;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sddm-breeze}"
SRC_URI[x86_64_v2_sddm-breeze.sha256sum] = "dc67c3f6754a2f8b7eaabc460c9a5917947c4667d45cb7cc7c30dad62d45f495"

URI_aarch64_plasma-desktop = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-desktop-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-desktop;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-desktop}"
SRC_URI[aarch64_plasma-desktop.sha256sum] = "15bb8bebb91b66ed76a4a79df3400598f141e70a72cace2580e407148a937082"

URI_aarch64_plasma-desktop-doc = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-desktop-doc-6.6.4-1.el10_2.noarch.rpm;name=aarch64_plasma-desktop-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-desktop-doc}"
SRC_URI[aarch64_plasma-desktop-doc.sha256sum] = "59f84bb04dcf1392b440c0136855bfd4b8b9ca47a3d644aa9331cca566fdf2e9"

URI_aarch64_sddm-breeze = "${EPEL_MIRROR}/aarch64/Packages/s/sddm-breeze-6.6.4-1.el10_2.noarch.rpm;name=aarch64_sddm-breeze;unpack=0"
SRC_URI:append = " ${URI_aarch64_sddm-breeze}"
SRC_URI[aarch64_sddm-breeze.sha256sum] = "d7dd5f6658e44d4cbf6d96e0019f3fbdf50ffd5c75341fc0d91f385c0c0e1d14"

RDEPENDS:plasma-desktop = " \
 PackageKit-Qt6 \
 accountsservice \
 glib2 \
 glibc \
 ibus-libs \
 kaccounts-integration-qt6 \
 kde-cli-tools \
 kf6-attica \
 kf6-baloo-libs \
 kf6-kauth \
 kf6-kbookmarks \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kjobwidgets \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kpackage \
 kf6-krunner \
 kf6-kservice \
 kf6-ksvg \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-qqc2-desktop-style \
 kf6-solid \
 kf6-sonnet \
 kio-extras \
 kmenuedit \
 kpipewire \
 kwin \
 kwrited \
 libX11 \
 libXi \
 libaccounts-qt6 \
 libcanberra \
 libksysguard \
 libkworkspace6 \
 libplasma \
 libstdc++ \
 libwacom \
 libwayland-client \
 libxcb \
 libxkbcommon \
 libxkbfile \
 plasma-activities \
 plasma-activities-stats \
 plasma-integration \
 plasma-systemsettings \
 plasma-workspace \
 plasma-workspace-libs \
 plasma5support \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtlocation \
 sdl2-compat \
 signon-plugin-oauth2 \
 systemd-libs \
 xcb-util-keysyms \
 xdg-utils \
 "
RDEPENDS:plasma-desktop-doc = " \
 "
RDEPENDS:sddm-breeze:x86_64_v2 = " \
 kf6-kimageformats \
 libplasma \
 plasma-workspace \
 qt6-qtvirtualkeyboard \
 virtual/desktop-backgrounds-compat \
"
RDEPENDS:sddm-breeze:aarch64 = " \
 kde-settings-sddm \
 kf6-kimageformats \
 libplasma \
 plasma-workspace \
 qt6-qtvirtualkeyboard \
 virtual/desktop-backgrounds-compat \
"
