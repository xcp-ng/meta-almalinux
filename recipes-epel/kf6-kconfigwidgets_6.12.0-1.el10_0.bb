# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kconfigwidgets"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kconfigwidgets \
 kf6-kconfigwidgets-devel \
 kf6-kconfigwidgets-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kconfigwidgets-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c8d35f172321529885f9ef673e0d2b85ca92eedafb1a9daa206d36d8a908e5a"

URI_x86_64_v2_kf6-kconfigwidgets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfigwidgets-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kconfigwidgets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kconfigwidgets}"
SRC_URI[x86_64_v2_kf6-kconfigwidgets.sha256sum] = "cfc83471841a5f1b142e65e464683b8859825446dbd0f04268bce0a1300a20cd"

URI_x86_64_v2_kf6-kconfigwidgets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfigwidgets-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kconfigwidgets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kconfigwidgets-devel}"
SRC_URI[x86_64_v2_kf6-kconfigwidgets-devel.sha256sum] = "7c775f132f15e9a1517d87578dd1c8812ef645feeff702633d2e5223415ba869"

URI_x86_64_v2_kf6-kconfigwidgets-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfigwidgets-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kconfigwidgets-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kconfigwidgets-doc}"
SRC_URI[x86_64_v2_kf6-kconfigwidgets-doc.sha256sum] = "2f5529ec85d8ed22bd8b0ff895c7cec9d3bae09d1642270cad9b9ed56d8af24c"

URI_aarch64_kf6-kconfigwidgets = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfigwidgets-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kconfigwidgets;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kconfigwidgets}"
SRC_URI[aarch64_kf6-kconfigwidgets.sha256sum] = "3502c4321c42e6ac1f5bccaf00f8fe46c5358f5dab8f8e5136150fa2c5d13d17"

URI_aarch64_kf6-kconfigwidgets-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfigwidgets-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kconfigwidgets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kconfigwidgets-devel}"
SRC_URI[aarch64_kf6-kconfigwidgets-devel.sha256sum] = "66c94b27bc25b08700099f0e82d2361c5f21ddf67d95e7a45bed50598523a07c"

URI_aarch64_kf6-kconfigwidgets-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfigwidgets-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kconfigwidgets-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kconfigwidgets-doc}"
SRC_URI[aarch64_kf6-kconfigwidgets-doc.sha256sum] = "e333accb4bfd88e6e20d4c955cd9c4a53826fd70eaf003fe01acdfd62bf25123"

RDEPENDS:kf6-kconfigwidgets = " \
 glibc \
 kf6-filesystem \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kconfigwidgets-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kauth-devel \
 kf6-kcodecs-devel \
 kf6-kcolorscheme-devel \
 kf6-kconfig-devel \
 kf6-kconfigwidgets \
 kf6-kwidgetsaddons-devel \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kconfigwidgets-doc = " \
 "
