# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "stringtemplate"
PV = "3.2.1"
PR = "42.el10_3"
PACKAGES = " \
 stringtemplate \
 stringtemplate-javadoc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/stringtemplate-3.2.1-42.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "76a3f0f522dbc85176067a8b035e6200288d9768ef7db412586c369f79b240dc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stringtemplate-3.2.1-42.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_stringtemplate;unpack=0"
SRC_URI[x86_64_v2_stringtemplate.sha256sum] = "edeaa4b87182ad39cfbcb5e31bd6df5d80ac8786911fcccf5582f1289e249237"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stringtemplate-javadoc-3.2.1-42.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_stringtemplate-javadoc;unpack=0"
SRC_URI[x86_64_v2_stringtemplate-javadoc.sha256sum] = "ffadef5feb1cae8876e4a69faff44fcedc096b8d40747fbac5c5885a20ee6757"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/stringtemplate-3.2.1-42.el10_3.noarch.rpm;name=aarch64_stringtemplate;unpack=0"
SRC_URI[aarch64_stringtemplate.sha256sum] = "14f7489ea0488465ef2518134cf39c08b1bd8144b57fe53f6012cb3555f29fdd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/stringtemplate-javadoc-3.2.1-42.el10_3.noarch.rpm;name=aarch64_stringtemplate-javadoc;unpack=0"
SRC_URI[aarch64_stringtemplate-javadoc.sha256sum] = "7dbda45ac545a194efef4c34aea0df73b6d5a38b0b9ee8d3e8f48c34a97adc69"

RDEPENDS:stringtemplate = " \
 antlr-tool \
 javapackages-filesystem \
 "
RDEPENDS:stringtemplate-javadoc = " \
 javapackages-filesystem \
 virtual/java-javadoc \
 "
