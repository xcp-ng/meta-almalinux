# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-json-logger"
PV = "4.1.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-json-logger \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-json-logger-4.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f4c0efd23d95d1abf13b299a74bf497ce1b74f20fee598894f13af832aafe71f"

URI_x86_64_v2_python3-json-logger = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-json-logger-4.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-json-logger;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-json-logger}"
SRC_URI[x86_64_v2_python3-json-logger.sha256sum] = "e62fb09a03b851ce9a0fb65f2531760bc4f36a3766e3e836ac52d17de2cdaa4b"

URI_aarch64_python3-json-logger = "${EPEL_MIRROR}/aarch64/Packages/p/python3-json-logger-4.1.0-1.el10_2.noarch.rpm;name=aarch64_python3-json-logger;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-json-logger}"
SRC_URI[aarch64_python3-json-logger.sha256sum] = "4dfe8f79398e0f361551f9bd83887fbcf9f66fe65f7349bcdc5d8104940614c8"

RDEPENDS:python3-json-logger = " \
 python3 \
 "
