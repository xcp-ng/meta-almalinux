# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gzip"
PV = "1.13"
PR = "4.el10_2"
PACKAGES = " \
 gzip \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/gzip-1.13-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "03c4fcfffe341fdce17be483b04d3bb1997976ab12a07b7b08a88edbcea16902"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/gzip-1.13-4.el10_2.x86_64_v2.rpm;name=x86_64_v2_gzip;unpack=0"
SRC_URI[x86_64_v2_gzip.sha256sum] = "b4d7e20d83319b9cc41e19776f6c6f904ca2a983b36c29b9e9d2d6eab01f2b03"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/gzip-1.13-4.el10_2.aarch64.rpm;name=aarch64_gzip;unpack=0"
SRC_URI[aarch64_gzip.sha256sum] = "5606020bf53d11907a658794c18a1a5d6299c64035ea18cce2b0f563ab82a9f3"

RDEPENDS:gzip = " \
 bash \
 glibc \
 virtual/coreutils \
 "
