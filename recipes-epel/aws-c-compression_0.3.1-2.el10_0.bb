# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aws-c-compression"
PV = "0.3.1"
PR = "2.el10_0"
PACKAGES = " \
 aws-c-compression \
 aws-c-compression-devel \
 aws-c-compression-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aws-c-compression-0.3.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "366863c9ab4a520bf4d377b17b91d184faec22ab98dc945aee2fd620dbf5d2d8"

URI_x86_64_v2_aws-c-compression = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-compression-0.3.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-compression;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-compression}"
SRC_URI[x86_64_v2_aws-c-compression.sha256sum] = "d446e8c57ad003acf561d6267ccd21383239c0447372ed865ab539aceb7256a0"

URI_x86_64_v2_aws-c-compression-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-compression-devel-0.3.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-compression-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-compression-devel}"
SRC_URI[x86_64_v2_aws-c-compression-devel.sha256sum] = "0b178062209391961563f69322df8deeb3d26f470311dc345588d1fc90078bf3"

URI_x86_64_v2_aws-c-compression-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-compression-libs-0.3.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-compression-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-compression-libs}"
SRC_URI[x86_64_v2_aws-c-compression-libs.sha256sum] = "d266fa6318b0a0350eb051ba85963c3ab3af1d5540dd140fc778851303f39708"

URI_aarch64_aws-c-compression = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-compression-0.3.1-2.el10_0.aarch64.rpm;name=aarch64_aws-c-compression;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-compression}"
SRC_URI[aarch64_aws-c-compression.sha256sum] = "f179fc08fac1d7f1ddd673b865ff56695eb708a4c41530fb0966c469ec4b665e"

URI_aarch64_aws-c-compression-devel = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-compression-devel-0.3.1-2.el10_0.aarch64.rpm;name=aarch64_aws-c-compression-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-compression-devel}"
SRC_URI[aarch64_aws-c-compression-devel.sha256sum] = "d04a82b0623856660222344f333c7934932f01c4697e0e1701f196cc56978cd9"

URI_aarch64_aws-c-compression-libs = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-compression-libs-0.3.1-2.el10_0.aarch64.rpm;name=aarch64_aws-c-compression-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-compression-libs}"
SRC_URI[aarch64_aws-c-compression-libs.sha256sum] = "519d0d0633183939b507570664b78fbd0f25fd7215b59f0a3427ffcae781b229"

RDEPENDS:aws-c-compression = " \
 aws-c-common-libs \
 "
RDEPENDS:aws-c-compression-devel = " \
 aws-c-common-devel \
 aws-c-compression \
 aws-c-compression-libs \
 cmake-filesystem \
 "
RDEPENDS:aws-c-compression-libs = " \
 aws-c-common-libs \
 aws-c-compression \
 glibc \
 "
