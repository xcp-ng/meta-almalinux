# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num_enum_derive"
PV = "0.7.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-num_enum_derive+complex-expressions-devel \
 rust-num_enum_derive+default-devel \
 rust-num_enum_derive+external_doc-devel \
 rust-num_enum_derive+proc-macro-crate-devel \
 rust-num_enum_derive+std-devel \
 rust-num_enum_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-num_enum_derive-0.7.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a4c7a9b5c3296067f9db9a66c923fbaeb96e646231c72b11363ec12334d07765"

URI_x86_64_v2_rust-num_enum_derive+complex-expressions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num_enum_derive+complex-expressions-devel-0.7.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num_enum_derive+complex-expressions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num_enum_derive+complex-expressions-devel}"
SRC_URI[x86_64_v2_rust-num_enum_derive+complex-expressions-devel.sha256sum] = "134acfeef0807ef88c71a675e170117fff070b360db653baeb25ad446d507b79"

URI_x86_64_v2_rust-num_enum_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num_enum_derive+default-devel-0.7.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num_enum_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num_enum_derive+default-devel}"
SRC_URI[x86_64_v2_rust-num_enum_derive+default-devel.sha256sum] = "a02cb651ebef93d48adbf17cd23bfca97590d584bbc9519dd2fe34edbba6c88c"

URI_x86_64_v2_rust-num_enum_derive+external_doc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num_enum_derive+external_doc-devel-0.7.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num_enum_derive+external_doc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num_enum_derive+external_doc-devel}"
SRC_URI[x86_64_v2_rust-num_enum_derive+external_doc-devel.sha256sum] = "3a1f73d7dec343f691ad3c660d1a3b7d719265c8639e7d2bd4df49dc8d8989e7"

URI_x86_64_v2_rust-num_enum_derive+proc-macro-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num_enum_derive+proc-macro-crate-devel-0.7.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num_enum_derive+proc-macro-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num_enum_derive+proc-macro-crate-devel}"
SRC_URI[x86_64_v2_rust-num_enum_derive+proc-macro-crate-devel.sha256sum] = "6887144437c94eecf2e32cb45fbca19f1c7c3402199f2dda21c9540b0307ea23"

URI_x86_64_v2_rust-num_enum_derive+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num_enum_derive+std-devel-0.7.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num_enum_derive+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num_enum_derive+std-devel}"
SRC_URI[x86_64_v2_rust-num_enum_derive+std-devel.sha256sum] = "4f3124a5b9dc0d92ced857ec079f170da0668f19c16b149b0c24bbb4709660d4"

URI_x86_64_v2_rust-num_enum_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num_enum_derive-devel-0.7.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num_enum_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num_enum_derive-devel}"
SRC_URI[x86_64_v2_rust-num_enum_derive-devel.sha256sum] = "f3a1f49a484f450b6eb8920e9c1787e3030d8ee3a30bfb088be216110f1651e3"

URI_aarch64_rust-num_enum_derive+complex-expressions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num_enum_derive+complex-expressions-devel-0.7.6-1.el10_3.noarch.rpm;name=aarch64_rust-num_enum_derive+complex-expressions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num_enum_derive+complex-expressions-devel}"
SRC_URI[aarch64_rust-num_enum_derive+complex-expressions-devel.sha256sum] = "40bea9747299e9eeecb12e34c84eafa12d323e0d8327e92ae371424f68b8d2a3"

URI_aarch64_rust-num_enum_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num_enum_derive+default-devel-0.7.6-1.el10_3.noarch.rpm;name=aarch64_rust-num_enum_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num_enum_derive+default-devel}"
SRC_URI[aarch64_rust-num_enum_derive+default-devel.sha256sum] = "2f0c17b242ceca2e6ecae3839d97c020d49bc141616f7f279d3c07ef60b9ccc8"

URI_aarch64_rust-num_enum_derive+external_doc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num_enum_derive+external_doc-devel-0.7.6-1.el10_3.noarch.rpm;name=aarch64_rust-num_enum_derive+external_doc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num_enum_derive+external_doc-devel}"
SRC_URI[aarch64_rust-num_enum_derive+external_doc-devel.sha256sum] = "def47bd2ad14f050c162d7816fa71cdc5e026fadbbbc63814ba4d7a64626bc14"

URI_aarch64_rust-num_enum_derive+proc-macro-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num_enum_derive+proc-macro-crate-devel-0.7.6-1.el10_3.noarch.rpm;name=aarch64_rust-num_enum_derive+proc-macro-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num_enum_derive+proc-macro-crate-devel}"
SRC_URI[aarch64_rust-num_enum_derive+proc-macro-crate-devel.sha256sum] = "1f2932996be3a4279e41604cd4eee4c2a8b7a1bc2618b642b2d959b76e5bf61d"

URI_aarch64_rust-num_enum_derive+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num_enum_derive+std-devel-0.7.6-1.el10_3.noarch.rpm;name=aarch64_rust-num_enum_derive+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num_enum_derive+std-devel}"
SRC_URI[aarch64_rust-num_enum_derive+std-devel.sha256sum] = "d7621099990dc7bd833a686eeb0ed258028c3aa7d7c5af0747d85b2f6337c4b0"

URI_aarch64_rust-num_enum_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num_enum_derive-devel-0.7.6-1.el10_3.noarch.rpm;name=aarch64_rust-num_enum_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num_enum_derive-devel}"
SRC_URI[aarch64_rust-num_enum_derive-devel.sha256sum] = "ecdd03357e479cf327637386d77292d89db72c39c83c7220d547b3c008187bb8"

RDEPENDS:rust-num_enum_derive+complex-expressions-devel = " \
 cargo \
 rust-num_enum_derive-devel \
 rust-syn2+full-devel \
 "
RDEPENDS:rust-num_enum_derive+default-devel = " \
 cargo \
 rust-num_enum_derive+std-devel \
 rust-num_enum_derive-devel \
 "
RDEPENDS:rust-num_enum_derive+external_doc-devel = " \
 cargo \
 rust-num_enum_derive-devel \
 "
RDEPENDS:rust-num_enum_derive+proc-macro-crate-devel = " \
 cargo \
 rust-num_enum_derive-devel \
 rust-proc-macro-crate+default-devel \
 "
RDEPENDS:rust-num_enum_derive+std-devel = " \
 cargo \
 rust-num_enum_derive+proc-macro-crate-devel \
 rust-num_enum_derive-devel \
 "
RDEPENDS:rust-num_enum_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+derive-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+parsing-devel \
 "
