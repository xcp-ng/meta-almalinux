# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dpdk"
PE = "2"
PV = "25.11"
PR = "1.el10"
PACKAGES = " \
 dpdk \
 dpdk-devel \
 dpdk-doc \
 dpdk-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dpdk-25.11-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5fbdea3b7e7317451951bf9f5729994895d60429e4207604aead09b0f90c99b4"

URI_x86_64_v2_dpdk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dpdk-25.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_dpdk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dpdk}"
SRC_URI[x86_64_v2_dpdk.sha256sum] = "47f15ce09773b17845238814bd193a32107dc06696196149960db8413b991537"

URI_x86_64_v2_dpdk-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dpdk-devel-25.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_dpdk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dpdk-devel}"
SRC_URI[x86_64_v2_dpdk-devel.sha256sum] = "d191612ca9e481e2952dfe630b92b30d5fc61c86b1cbed69a0bd7375ec3b89e3"

URI_x86_64_v2_dpdk-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dpdk-doc-25.11-1.el10.noarch.rpm;name=x86_64_v2_dpdk-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dpdk-doc}"
SRC_URI[x86_64_v2_dpdk-doc.sha256sum] = "57586d64c17995c169b7d2d3426c9845f7cef7f59c7591e49b3cf8a24adb8bd7"

URI_x86_64_v2_dpdk-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dpdk-tools-25.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_dpdk-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dpdk-tools}"
SRC_URI[x86_64_v2_dpdk-tools.sha256sum] = "038eb58881f706f49c245c039917514222a14598497daba5ed58c438513ce5f8"

URI_aarch64_dpdk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dpdk-25.11-1.el10.aarch64.rpm;name=aarch64_dpdk;unpack=0"
SRC_URI:append = " ${URI_aarch64_dpdk}"
SRC_URI[aarch64_dpdk.sha256sum] = "54b164335ccaa454468fb806533f23b7286eae42d1c91efdf8c21fc3a116b5c8"

URI_aarch64_dpdk-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dpdk-devel-25.11-1.el10.aarch64.rpm;name=aarch64_dpdk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dpdk-devel}"
SRC_URI[aarch64_dpdk-devel.sha256sum] = "3905abf5e40c0dec20e809f1fe86976133b104435776d523b05ee2b67a004d10"

URI_aarch64_dpdk-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dpdk-doc-25.11-1.el10.noarch.rpm;name=aarch64_dpdk-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_dpdk-doc}"
SRC_URI[aarch64_dpdk-doc.sha256sum] = "57586d64c17995c169b7d2d3426c9845f7cef7f59c7591e49b3cf8a24adb8bd7"

URI_aarch64_dpdk-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dpdk-tools-25.11-1.el10.aarch64.rpm;name=aarch64_dpdk-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_dpdk-tools}"
SRC_URI[aarch64_dpdk-tools.sha256sum] = "097c2470cc24ce16c9172fd40927d447b3017e42ad111dfd9775efe51dd4d796"

RDEPENDS:dpdk = " \
 glibc \
 libarchive \
 libibverbs \
 numactl-libs \
 "
RDEPENDS:dpdk-devel = " \
 bash \
 dpdk \
 dpdk-devel \
 libarchive-devel \
 pkgconf-pkg-config \
 python3 \
 rdma-core-devel \
 "
RDEPENDS:dpdk-doc = " \
 "
RDEPENDS:dpdk-tools = " \
 dpdk \
 findutils \
 iproute \
 kmod \
 pciutils \
 python3 \
 "
