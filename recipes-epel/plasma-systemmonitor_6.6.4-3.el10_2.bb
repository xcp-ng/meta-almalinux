# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-systemmonitor"
PV = "6.6.4"
PR = "3.el10_2"
PACKAGES = " \
 plasma-systemmonitor \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-systemmonitor-6.6.4-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0391695ff2a97c3f521cc11278a8a87b08d4f17b01b2fd0c4cf10e7c2abdc8c6"

URI_x86_64_v2_plasma-systemmonitor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-systemmonitor-6.6.4-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-systemmonitor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-systemmonitor}"
SRC_URI[x86_64_v2_plasma-systemmonitor.sha256sum] = "e08ce64449e6ed55bc4aee31a499aa0852317002ce649b981bb81943ca67d771"

URI_aarch64_plasma-systemmonitor = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-systemmonitor-6.6.4-3.el10_2.aarch64.rpm;name=aarch64_plasma-systemmonitor;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-systemmonitor}"
SRC_URI[aarch64_plasma-systemmonitor.sha256sum] = "0f8eaed727971579d6b1f047471d7589a9c9643fefab4ae2ddd6583f9138002b"

RDEPENDS:plasma-systemmonitor = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-knewstuff \
 kf6-kquickcharts \
 kf6-kservice \
 kf6-kwindowsystem \
 ksystemstats \
 libksysguard \
 libstdc++ \
 python3 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
