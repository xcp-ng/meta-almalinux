# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Module-Manifest"
PV = "1.09"
PR = "17.el10_0"
PACKAGES = " \
 perl-Module-Manifest \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Module-Manifest-1.09-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fda8ca24e058bc57c683861de69924c05d501105a990c8867adabb72073a5b67"

URI_x86_64_v2_perl-Module-Manifest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Module-Manifest-1.09-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Module-Manifest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Module-Manifest}"
SRC_URI[x86_64_v2_perl-Module-Manifest.sha256sum] = "2bdc4b51c4ef316eb16cc4e42593f59811064a381e03833dd19894c9228e8480"

URI_aarch64_perl-Module-Manifest = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Module-Manifest-1.09-17.el10_0.noarch.rpm;name=aarch64_perl-Module-Manifest;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Module-Manifest}"
SRC_URI[aarch64_perl-Module-Manifest.sha256sum] = "7a0c1c7ec8b4b687475be89cbd3f1f1c0193a7eaeba8e42f767f87a73b46ef66"

RDEPENDS:perl-Module-Manifest = " \
 perl-Carp \
 perl-File-Basename \
 perl-Params-Util \
 perl-PathTools \
 perl-libs \
 "
