# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nginx-mod-headers-more"
PV = "0.39"
PR = "1.el10_0"
PACKAGES = " \
 nginx-mod-headers-more \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nginx-mod-headers-more-0.39-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4b2a1a18bd3243826011c91e6757ba98030f4c584bf364601e09f4bb0fa746af"

URI_x86_64_v2_nginx-mod-headers-more = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nginx-mod-headers-more-0.39-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-headers-more;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-headers-more}"
SRC_URI[x86_64_v2_nginx-mod-headers-more.sha256sum] = "db104176df6b663f7ba9cc289ad512f290f051c0be5edd58caaa06742ed9689c"

URI_aarch64_nginx-mod-headers-more = "${EPEL_MIRROR}/aarch64/Packages/n/nginx-mod-headers-more-0.39-1.el10_0.aarch64.rpm;name=aarch64_nginx-mod-headers-more;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-headers-more}"
SRC_URI[aarch64_nginx-mod-headers-more.sha256sum] = "cf4800723a3dfaec2ec6d1dc5fdad1778be7137c6849c13c7ae85c6edd36e899"

RDEPENDS:nginx-mod-headers-more = " \
 glibc \
 nginx \
 "
