# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-faccess"
PV = "0.2.4"
PR = "9.el10_1"
PACKAGES = " \
 rust-faccess+default-devel \
 rust-faccess-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-faccess-0.2.4-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c4ecb08c44fb626d51e4a18f03d56cffc484673208ef9c504609c22f9b32abcf"

URI_x86_64_v2_rust-faccess+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-faccess+default-devel-0.2.4-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-faccess+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-faccess+default-devel}"
SRC_URI[x86_64_v2_rust-faccess+default-devel.sha256sum] = "5719f6d1fe59385843145b18d14809003ed76c7f1010aa0552fc409dfdcc3a2e"

URI_x86_64_v2_rust-faccess-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-faccess-devel-0.2.4-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-faccess-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-faccess-devel}"
SRC_URI[x86_64_v2_rust-faccess-devel.sha256sum] = "1a61d4bceb1712e00b1cd9891586e7936ddc03e29258df5883607388de5f0930"

URI_aarch64_rust-faccess+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-faccess+default-devel-0.2.4-9.el10_1.noarch.rpm;name=aarch64_rust-faccess+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-faccess+default-devel}"
SRC_URI[aarch64_rust-faccess+default-devel.sha256sum] = "aee2964a1d6f3307df0d90501a1e9659232d9145ea7ab991539912ddba3643c0"

URI_aarch64_rust-faccess-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-faccess-devel-0.2.4-9.el10_1.noarch.rpm;name=aarch64_rust-faccess-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-faccess-devel}"
SRC_URI[aarch64_rust-faccess-devel.sha256sum] = "5aabdb27803f8c1735b2e7b0995791a89cf3936da149c3707171a4f104285a3e"

RDEPENDS:rust-faccess+default-devel = " \
 cargo \
 rust-faccess-devel \
 "
RDEPENDS:rust-faccess-devel = " \
 cargo \
 rust-bitflags1+default-devel \
 rust-libc+default-devel \
 "
