# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-linked-hash-map"
PV = "0.5.6"
PR = "7.el10_0"
PACKAGES = " \
 rust-linked-hash-map+default-devel \
 rust-linked-hash-map+heapsize-devel \
 rust-linked-hash-map+heapsize_impl-devel \
 rust-linked-hash-map+nightly-devel \
 rust-linked-hash-map+serde-devel \
 rust-linked-hash-map+serde_impl-devel \
 rust-linked-hash-map-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-linked-hash-map-0.5.6-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0dd58f12b6879be7a0bc81d04e7728ba8fd4c3cbe602371a1d3bf0a609ceaaa5"

URI_x86_64_v2_rust-linked-hash-map+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linked-hash-map+default-devel-0.5.6-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linked-hash-map+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linked-hash-map+default-devel}"
SRC_URI[x86_64_v2_rust-linked-hash-map+default-devel.sha256sum] = "e8d4dd461947ea47915d217a231d22c85691d2b8f7d9d2bf120ee6041f098674"

URI_x86_64_v2_rust-linked-hash-map+heapsize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linked-hash-map+heapsize-devel-0.5.6-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linked-hash-map+heapsize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linked-hash-map+heapsize-devel}"
SRC_URI[x86_64_v2_rust-linked-hash-map+heapsize-devel.sha256sum] = "ac07da13d09ecdd5f888c07b33de364205780b745d2709149007303dfc517ed2"

URI_x86_64_v2_rust-linked-hash-map+heapsize_impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linked-hash-map+heapsize_impl-devel-0.5.6-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linked-hash-map+heapsize_impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linked-hash-map+heapsize_impl-devel}"
SRC_URI[x86_64_v2_rust-linked-hash-map+heapsize_impl-devel.sha256sum] = "b60149758ab366512e70cce33e713ba7d5dc2f0b2b1cb64fa9e00510b7352d74"

URI_x86_64_v2_rust-linked-hash-map+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linked-hash-map+nightly-devel-0.5.6-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linked-hash-map+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linked-hash-map+nightly-devel}"
SRC_URI[x86_64_v2_rust-linked-hash-map+nightly-devel.sha256sum] = "871824437992d8d92a5806f3806a85c88d44f0c5f3faf92f65294629bfe348ff"

URI_x86_64_v2_rust-linked-hash-map+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linked-hash-map+serde-devel-0.5.6-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linked-hash-map+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linked-hash-map+serde-devel}"
SRC_URI[x86_64_v2_rust-linked-hash-map+serde-devel.sha256sum] = "69a98a0c90649973a3caf5fd504650826488333e9e8fb84b275ad7099f070976"

URI_x86_64_v2_rust-linked-hash-map+serde_impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linked-hash-map+serde_impl-devel-0.5.6-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linked-hash-map+serde_impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linked-hash-map+serde_impl-devel}"
SRC_URI[x86_64_v2_rust-linked-hash-map+serde_impl-devel.sha256sum] = "539b8fa254dd41608871a67aa7892238ef0ca050a0590de418077a76f7351469"

URI_x86_64_v2_rust-linked-hash-map-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linked-hash-map-devel-0.5.6-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linked-hash-map-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linked-hash-map-devel}"
SRC_URI[x86_64_v2_rust-linked-hash-map-devel.sha256sum] = "6bbb7b2842d84fb074eb42fcaf09c80af254c93dbb2834e4baa9eb3da404df41"

URI_aarch64_rust-linked-hash-map+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linked-hash-map+default-devel-0.5.6-7.el10_0.noarch.rpm;name=aarch64_rust-linked-hash-map+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linked-hash-map+default-devel}"
SRC_URI[aarch64_rust-linked-hash-map+default-devel.sha256sum] = "a0b5edefc3989dc08841614d36a179125bf9317356ce4044d4ac33e8d2ba0051"

URI_aarch64_rust-linked-hash-map+heapsize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linked-hash-map+heapsize-devel-0.5.6-7.el10_0.noarch.rpm;name=aarch64_rust-linked-hash-map+heapsize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linked-hash-map+heapsize-devel}"
SRC_URI[aarch64_rust-linked-hash-map+heapsize-devel.sha256sum] = "099a126bda25a84b439016463d6b063d00c5d051b4e60d6fe2cbfe8cfab0158d"

URI_aarch64_rust-linked-hash-map+heapsize_impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linked-hash-map+heapsize_impl-devel-0.5.6-7.el10_0.noarch.rpm;name=aarch64_rust-linked-hash-map+heapsize_impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linked-hash-map+heapsize_impl-devel}"
SRC_URI[aarch64_rust-linked-hash-map+heapsize_impl-devel.sha256sum] = "71d51645f15eb4086814742eb0688d669d34f0826350581c91c8825237f853c8"

URI_aarch64_rust-linked-hash-map+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linked-hash-map+nightly-devel-0.5.6-7.el10_0.noarch.rpm;name=aarch64_rust-linked-hash-map+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linked-hash-map+nightly-devel}"
SRC_URI[aarch64_rust-linked-hash-map+nightly-devel.sha256sum] = "3f989be8b011a69f8531e6905626a353b3ab59af3365c181f2a66c0f8e17261e"

URI_aarch64_rust-linked-hash-map+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linked-hash-map+serde-devel-0.5.6-7.el10_0.noarch.rpm;name=aarch64_rust-linked-hash-map+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linked-hash-map+serde-devel}"
SRC_URI[aarch64_rust-linked-hash-map+serde-devel.sha256sum] = "1563fd7156c7883a5954da4a4e7702a7b2ea95f9c1cc35b981fdb696a4966783"

URI_aarch64_rust-linked-hash-map+serde_impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linked-hash-map+serde_impl-devel-0.5.6-7.el10_0.noarch.rpm;name=aarch64_rust-linked-hash-map+serde_impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linked-hash-map+serde_impl-devel}"
SRC_URI[aarch64_rust-linked-hash-map+serde_impl-devel.sha256sum] = "43dd437490295d7dd5b36c336c1b14f6e700b6d2d94868731831141ff6cf6bd2"

URI_aarch64_rust-linked-hash-map-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linked-hash-map-devel-0.5.6-7.el10_0.noarch.rpm;name=aarch64_rust-linked-hash-map-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linked-hash-map-devel}"
SRC_URI[aarch64_rust-linked-hash-map-devel.sha256sum] = "b71bc5e67439462b31df4127d9d1dacb73fd06e1c358a0a32a2fc83969a2f274"

RDEPENDS:rust-linked-hash-map+default-devel = " \
 cargo \
 rust-linked-hash-map-devel \
 "
RDEPENDS:rust-linked-hash-map+heapsize-devel = " \
 cargo \
 rust-heapsize+default-devel \
 rust-linked-hash-map-devel \
 "
RDEPENDS:rust-linked-hash-map+heapsize_impl-devel = " \
 cargo \
 rust-linked-hash-map+heapsize-devel \
 rust-linked-hash-map-devel \
 "
RDEPENDS:rust-linked-hash-map+nightly-devel = " \
 cargo \
 rust-linked-hash-map-devel \
 "
RDEPENDS:rust-linked-hash-map+serde-devel = " \
 cargo \
 rust-linked-hash-map-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-linked-hash-map+serde_impl-devel = " \
 cargo \
 rust-linked-hash-map+serde-devel \
 rust-linked-hash-map-devel \
 "
RDEPENDS:rust-linked-hash-map-devel = " \
 cargo \
 "
