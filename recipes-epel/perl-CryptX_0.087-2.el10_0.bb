# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-CryptX"
PV = "0.087"
PR = "2.el10_0"
PACKAGES = " \
 perl-CryptX \
 perl-CryptX-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-CryptX-0.087-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9bd750a7e64d56360fd83dda9f7a0293aab9363865c59bb1f319f654080f5d49"

URI_x86_64_v2_perl-CryptX = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-CryptX-0.087-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-CryptX;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-CryptX}"
SRC_URI[x86_64_v2_perl-CryptX.sha256sum] = "ad1e5adecba8dc455bb739341d6768d3d9b1a1f34216ab2f5d7dd58190e670f2"

URI_x86_64_v2_perl-CryptX-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-CryptX-tests-0.087-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-CryptX-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-CryptX-tests}"
SRC_URI[x86_64_v2_perl-CryptX-tests.sha256sum] = "f7e1d7c0b3edb230fad37e8d825a3a44a6850b233f98d6bd75bc8d7ccb9d0cc4"

URI_aarch64_perl-CryptX = "${EPEL_MIRROR}/aarch64/Packages/p/perl-CryptX-0.087-2.el10_0.aarch64.rpm;name=aarch64_perl-CryptX;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-CryptX}"
SRC_URI[aarch64_perl-CryptX.sha256sum] = "49f0da557b7a8be52c9f04cd2ad377a23d5289fb8c3adfdbfc0dbe61a3d5d43b"

URI_aarch64_perl-CryptX-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-CryptX-tests-0.087-2.el10_0.noarch.rpm;name=aarch64_perl-CryptX-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-CryptX-tests}"
SRC_URI[aarch64_perl-CryptX-tests.sha256sum] = "72f6d63522b77a6bef588b97e235499ef3cda02fab59f5308a137c5162dfeab4"

RDEPENDS:perl-CryptX = " \
 glibc \
 perl-Carp \
 perl-CryptX \
 perl-Exporter \
 perl-base \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-CryptX-tests = " \
 bash \
 perl-CryptX \
 perl-Data-Dumper \
 perl-File-Find \
 perl-JSON \
 perl-Math-BigInt \
 perl-Math-Complex \
 perl-Storable \
 perl-Test \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 virtual/coreutils \
 "
