# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fabtests"
PV = "2.3.1"
PR = "1.el10"
PACKAGES = " \
 fabtests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/fabtests-2.3.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "176bda4c5d54182b29dcbb23085e36480a776b4b734e6bab7ab5a7f9b4a36b5c"

URI_x86_64_v2_fabtests = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/fabtests-2.3.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_fabtests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fabtests}"
SRC_URI[x86_64_v2_fabtests.sha256sum] = "59185b228e1b46b99fbc6b85eb7c7a6a4f1ca7556173850ae2014e7d1ebe934c"

URI_aarch64_fabtests = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/fabtests-2.3.1-1.el10.aarch64.rpm;name=aarch64_fabtests;unpack=0"
SRC_URI:append = " ${URI_aarch64_fabtests}"
SRC_URI[aarch64_fabtests.sha256sum] = "ef476115451bcd6cbafdbfa2af4e371fb1dff45576da5a38cbb1570108e77090"

RDEPENDS:fabtests = " \
 bash \
 glibc \
 libfabric \
 python3 \
 python3-pytest \
 ruby \
 "
