# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "govulncheck"
PV = "1.1.4"
PR = "1.20260218gita9cf566.el10_3"
PACKAGES = " \
 govulncheck \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/govulncheck-1.1.4-1.20260218gita9cf566.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f4f50ddb77f6c283a0ef652d690c6bea030f7a7b95a19a93e44ec06936454dc0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/govulncheck-1.1.4-1.20260218gita9cf566.el10_3.aarch64.rpm;name=aarch64_govulncheck;unpack=0"
SRC_URI[aarch64_govulncheck.sha256sum] = "51a3605e5587bf445f52094aa6ce338747a4f3a22788a06a92022be25ccd7d38"

RDEPENDS:govulncheck = " \
 glibc \
 "
