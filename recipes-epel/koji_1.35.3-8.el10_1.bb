# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "koji"
PV = "1.35.3"
PR = "8.el10_1"
PACKAGES = " \
 koji \
 koji-builder \
 koji-builder-plugins \
 koji-hub \
 koji-hub-plugins \
 koji-utils \
 koji-vm \
 koji-web \
 python3-koji \
 python3-koji-cli-plugins \
 python3-koji-hub \
 python3-koji-hub-plugins \
 python3-koji-web \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/koji-1.35.3-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "13187332e4c920e0736b9fe1830761ff91a9ca8c99a85ce3cd82518d18c1f83c"

URI_x86_64_v2_koji = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-1.35.3-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_koji;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji}"
SRC_URI[x86_64_v2_koji.sha256sum] = "a33281286a41f114896ed334b08b27861502f3a70c691eac6db67cd7a3f1db39"

URI_x86_64_v2_koji-builder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-builder-1.35.3-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_koji-builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-builder}"
SRC_URI[x86_64_v2_koji-builder.sha256sum] = "584558ad1c5111d8e73a42d430ecb3387041ccec8c28afc114069215b62ff58a"

URI_x86_64_v2_koji-builder-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-builder-plugins-1.35.3-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_koji-builder-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-builder-plugins}"
SRC_URI[x86_64_v2_koji-builder-plugins.sha256sum] = "d49974b51194e60a1bece825c069681f58a46a57ce54e0f572b2bff652b1e923"

URI_x86_64_v2_koji-hub = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-hub-1.35.3-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_koji-hub;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-hub}"
SRC_URI[x86_64_v2_koji-hub.sha256sum] = "50cc8309fe66c5ddc87544a264ec6e4a369b0d5ab9c1f524575b28436e6eac69"

URI_x86_64_v2_koji-hub-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-hub-plugins-1.35.3-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_koji-hub-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-hub-plugins}"
SRC_URI[x86_64_v2_koji-hub-plugins.sha256sum] = "b0b092f7dd142ff8d84abc0ba931d1e4857555cf60f73f4a4642a19b0b842a6e"

URI_x86_64_v2_koji-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-utils-1.35.3-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_koji-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-utils}"
SRC_URI[x86_64_v2_koji-utils.sha256sum] = "10b9140b05a62c5b5ab5d8a8aaa9641728111d05b3efe6f63da6719b6ba884eb"

URI_x86_64_v2_koji-vm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-vm-1.35.3-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_koji-vm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-vm}"
SRC_URI[x86_64_v2_koji-vm.sha256sum] = "6ad212f7f55df7d6457b0c246823241d8be0506424e87cef7d96d9ddbc3fb073"

URI_x86_64_v2_koji-web = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-web-1.35.3-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_koji-web;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-web}"
SRC_URI[x86_64_v2_koji-web.sha256sum] = "15d45d8de34a747dc62c59f9e6eaec354710a69e2bdcb2ee3127161bcda28ebd"

URI_x86_64_v2_python3-koji = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-koji-1.35.3-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-koji;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-koji}"
SRC_URI[x86_64_v2_python3-koji.sha256sum] = "99929c2651e136d2926b80d254d76268605c5487e685eb089a109d1bce57c243"

URI_x86_64_v2_python3-koji-cli-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-koji-cli-plugins-1.35.3-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-koji-cli-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-koji-cli-plugins}"
SRC_URI[x86_64_v2_python3-koji-cli-plugins.sha256sum] = "ad8993f37c6ebc9a0b8c7cd25af53d6c69ba058894e98e460634fed52b5d8441"

URI_x86_64_v2_python3-koji-hub = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-koji-hub-1.35.3-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-koji-hub;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-koji-hub}"
SRC_URI[x86_64_v2_python3-koji-hub.sha256sum] = "d320049f9b93681be858a02547bf0fedc5cc3f60f6eab2c49923504aac94bd8f"

URI_x86_64_v2_python3-koji-hub-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-koji-hub-plugins-1.35.3-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-koji-hub-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-koji-hub-plugins}"
SRC_URI[x86_64_v2_python3-koji-hub-plugins.sha256sum] = "eb8f37cdb4ef98e068cdb963b90217d3f0cf9ae8f3f76566592b4b19a613359e"

URI_x86_64_v2_python3-koji-web = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-koji-web-1.35.3-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-koji-web;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-koji-web}"
SRC_URI[x86_64_v2_python3-koji-web.sha256sum] = "7c384182cdcacd797e1d0eba766387dfc5b0b65c96af74b8c827464228964251"

URI_aarch64_koji = "${EPEL_MIRROR}/aarch64/Packages/k/koji-1.35.3-8.el10_1.noarch.rpm;name=aarch64_koji;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji}"
SRC_URI[aarch64_koji.sha256sum] = "3fb6a0f1bc8e967a4834a4501427b347034b4499b93031cd7b2b93ec0633e02d"

URI_aarch64_koji-builder = "${EPEL_MIRROR}/aarch64/Packages/k/koji-builder-1.35.3-8.el10_1.noarch.rpm;name=aarch64_koji-builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-builder}"
SRC_URI[aarch64_koji-builder.sha256sum] = "81b64707d56aaa4bca04b85e232e458585253e4f06fa2b5b867b91a719c2bdc4"

URI_aarch64_koji-builder-plugins = "${EPEL_MIRROR}/aarch64/Packages/k/koji-builder-plugins-1.35.3-8.el10_1.noarch.rpm;name=aarch64_koji-builder-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-builder-plugins}"
SRC_URI[aarch64_koji-builder-plugins.sha256sum] = "a9c0a4aaebe34b8c7d6e4de952b3c8568b34ee83e6d1704195875075464e30ea"

URI_aarch64_koji-hub = "${EPEL_MIRROR}/aarch64/Packages/k/koji-hub-1.35.3-8.el10_1.noarch.rpm;name=aarch64_koji-hub;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-hub}"
SRC_URI[aarch64_koji-hub.sha256sum] = "ba4bf83297523a55c05d1c2ff00093593e2533dca58cc190f84644f165cde26c"

URI_aarch64_koji-hub-plugins = "${EPEL_MIRROR}/aarch64/Packages/k/koji-hub-plugins-1.35.3-8.el10_1.noarch.rpm;name=aarch64_koji-hub-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-hub-plugins}"
SRC_URI[aarch64_koji-hub-plugins.sha256sum] = "2f905a2e892e2a65a6f44267a4aad87f8cbe4340ebe775d69f28bddf22fb8e3d"

URI_aarch64_koji-utils = "${EPEL_MIRROR}/aarch64/Packages/k/koji-utils-1.35.3-8.el10_1.noarch.rpm;name=aarch64_koji-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-utils}"
SRC_URI[aarch64_koji-utils.sha256sum] = "7dd474ffb93cfffc9b2ed3aaa131b525326accfd5ebee8d1fb74a924629fee3a"

URI_aarch64_koji-vm = "${EPEL_MIRROR}/aarch64/Packages/k/koji-vm-1.35.3-8.el10_1.noarch.rpm;name=aarch64_koji-vm;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-vm}"
SRC_URI[aarch64_koji-vm.sha256sum] = "d5a6d0fdf4b383b80f672eb5adba76f2ca0ca9c5305fc253c4209401d3e87b41"

URI_aarch64_koji-web = "${EPEL_MIRROR}/aarch64/Packages/k/koji-web-1.35.3-8.el10_1.noarch.rpm;name=aarch64_koji-web;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-web}"
SRC_URI[aarch64_koji-web.sha256sum] = "facc0a0310f200e1782df33cbd5da5424cb9884d3a287f1b496e951754aee18c"

URI_aarch64_python3-koji = "${EPEL_MIRROR}/aarch64/Packages/p/python3-koji-1.35.3-8.el10_1.noarch.rpm;name=aarch64_python3-koji;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-koji}"
SRC_URI[aarch64_python3-koji.sha256sum] = "8ced54f8832ddb30e824f72fc0510cdbee53ae0abf9ac1ddb0e45a8953f63005"

URI_aarch64_python3-koji-cli-plugins = "${EPEL_MIRROR}/aarch64/Packages/p/python3-koji-cli-plugins-1.35.3-8.el10_1.noarch.rpm;name=aarch64_python3-koji-cli-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-koji-cli-plugins}"
SRC_URI[aarch64_python3-koji-cli-plugins.sha256sum] = "6a8e2f6e8091dc02799294fdcf07d110c6ca1f1fbd044f6667fb74d7399bfd9a"

URI_aarch64_python3-koji-hub = "${EPEL_MIRROR}/aarch64/Packages/p/python3-koji-hub-1.35.3-8.el10_1.noarch.rpm;name=aarch64_python3-koji-hub;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-koji-hub}"
SRC_URI[aarch64_python3-koji-hub.sha256sum] = "6d2e605d50144d8798ced45884a793bfd69bb2bf2b85635d23c358271f4a239a"

URI_aarch64_python3-koji-hub-plugins = "${EPEL_MIRROR}/aarch64/Packages/p/python3-koji-hub-plugins-1.35.3-8.el10_1.noarch.rpm;name=aarch64_python3-koji-hub-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-koji-hub-plugins}"
SRC_URI[aarch64_python3-koji-hub-plugins.sha256sum] = "90ea3949213beb63409d5cd1101acec5c58146998cb2382a5d2bdb5cefcc113c"

URI_aarch64_python3-koji-web = "${EPEL_MIRROR}/aarch64/Packages/p/python3-koji-web-1.35.3-8.el10_1.noarch.rpm;name=aarch64_python3-koji-web;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-koji-web}"
SRC_URI[aarch64_python3-koji-web.sha256sum] = "6dcd26788177b29ebae28c7cf295f510e4905296d618ad905cc2985791e8080e"

RDEPENDS:koji = " \
 python3 \
 python3-koji \
 python3-libcomps \
 "
RDEPENDS:koji-builder = " \
 bash \
 createrepo_c \
 git-core \
 mock \
 python3 \
 python3-cheetah \
 python3-koji \
 python3-librepo \
 python3-multilib \
 python3-pycdio \
 squashfs-tools \
 subversion \
 systemd \
 "
RDEPENDS:koji-builder-plugins = " \
 koji \
 koji-builder \
 "
RDEPENDS:koji-hub = " \
 koji \
 python3 \
 python3-koji-hub \
 "
RDEPENDS:koji-hub-plugins = " \
 python3-koji-hub-plugins \
 "
RDEPENDS:koji-utils = " \
 bash \
 koji \
 python3 \
 python3-psycopg2 \
 systemd \
 "
RDEPENDS:koji-vm = " \
 bash \
 koji \
 python3 \
 python3-libvirt \
 python3-libxml2 \
 qemu-img \
 systemd \
 virt-install \
 "
RDEPENDS:koji-web = " \
 koji \
 python3-koji-web \
 "
RDEPENDS:python3-koji = " \
 python3 \
 python3-dateutil \
 python3-defusedxml \
 python3-requests \
 python3-requests-gssapi \
 python3-rpm \
 python3-six \
 "
RDEPENDS:python3-koji-cli-plugins = " \
 python3 \
 python3-koji \
 "
RDEPENDS:python3-koji-hub = " \
 httpd \
 mod_auth_gssapi \
 python3 \
 python3-koji \
 python3-mod_wsgi \
 python3-psycopg2 \
 "
RDEPENDS:python3-koji-hub-plugins = " \
 cpio \
 python3-koji-hub \
 python3-qpid-proton \
 "
RDEPENDS:python3-koji-web = " \
 httpd \
 mod_auth_gssapi \
 python3-cheetah \
 python3-koji \
 python3-mod_wsgi \
 python3-psycopg2 \
 "
