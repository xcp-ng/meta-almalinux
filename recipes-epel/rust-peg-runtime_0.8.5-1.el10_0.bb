# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-peg-runtime"
PV = "0.8.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-peg-runtime+default-devel \
 rust-peg-runtime+std-devel \
 rust-peg-runtime+unstable-devel \
 rust-peg-runtime-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-peg-runtime-0.8.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "346afbe197c0cff102dd13f36c4047502953c2f92730e78c5925d5a8b56ebffe"

URI_x86_64_v2_rust-peg-runtime+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-peg-runtime+default-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-peg-runtime+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-peg-runtime+default-devel}"
SRC_URI[x86_64_v2_rust-peg-runtime+default-devel.sha256sum] = "566707dd1f288a4c04aa56122a12b15fbad58e91e1d1f7aff0d4d7d1256f7764"

URI_x86_64_v2_rust-peg-runtime+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-peg-runtime+std-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-peg-runtime+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-peg-runtime+std-devel}"
SRC_URI[x86_64_v2_rust-peg-runtime+std-devel.sha256sum] = "6a21e2ea9bf438dbe534a67088b0cff0d7696defddb30e70c89bdc370c0c7587"

URI_x86_64_v2_rust-peg-runtime+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-peg-runtime+unstable-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-peg-runtime+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-peg-runtime+unstable-devel}"
SRC_URI[x86_64_v2_rust-peg-runtime+unstable-devel.sha256sum] = "95dec955a58ca092e2458e27dbfdf2749eb1dc29eca375250d0ecd7374a8ada8"

URI_x86_64_v2_rust-peg-runtime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-peg-runtime-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-peg-runtime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-peg-runtime-devel}"
SRC_URI[x86_64_v2_rust-peg-runtime-devel.sha256sum] = "a7462aed2dbf229ed805631523c59bbfb84f5845096887fed256249b02271d0d"

URI_aarch64_rust-peg-runtime+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-peg-runtime+default-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-peg-runtime+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-peg-runtime+default-devel}"
SRC_URI[aarch64_rust-peg-runtime+default-devel.sha256sum] = "809dc0c7d0bd599cc8d645beebc11b7fcd847cb5e4c25d0a2459e9e4b4e11f94"

URI_aarch64_rust-peg-runtime+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-peg-runtime+std-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-peg-runtime+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-peg-runtime+std-devel}"
SRC_URI[aarch64_rust-peg-runtime+std-devel.sha256sum] = "080c6aa70704e15e2580841c7fd550ea23366fa6867e8e0693cdf5fa51a347ea"

URI_aarch64_rust-peg-runtime+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-peg-runtime+unstable-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-peg-runtime+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-peg-runtime+unstable-devel}"
SRC_URI[aarch64_rust-peg-runtime+unstable-devel.sha256sum] = "2fade710e9a324b91c5f50799e7feb9f3811a277daed9e949c75676f571fb563"

URI_aarch64_rust-peg-runtime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-peg-runtime-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-peg-runtime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-peg-runtime-devel}"
SRC_URI[aarch64_rust-peg-runtime-devel.sha256sum] = "a7f9feb8e82f8f7816878b638e9ad6d61acfacd146e221516dedb959ae8f4516"

RDEPENDS:rust-peg-runtime+default-devel = " \
 cargo \
 rust-peg-runtime-devel \
 "
RDEPENDS:rust-peg-runtime+std-devel = " \
 cargo \
 rust-peg-runtime-devel \
 "
RDEPENDS:rust-peg-runtime+unstable-devel = " \
 cargo \
 rust-peg-runtime-devel \
 "
RDEPENDS:rust-peg-runtime-devel = " \
 cargo \
 "
