# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sexpp"
PV = "0.9.2"
PR = "1.el10_0"
PACKAGES = " \
 libsexpp \
 libsexpp-devel \
 sexpp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sexpp-0.9.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "616702921f466446568d78ba0995f8dc55f3d779f6417625ffa61b14f55f1bfc"

URI_x86_64_v2_libsexpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsexpp-0.9.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libsexpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsexpp}"
SRC_URI[x86_64_v2_libsexpp.sha256sum] = "664b343ad6ee431ce732cf702cda6f4f73e22434132286f6a6ae25c082e4c55b"

URI_x86_64_v2_libsexpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsexpp-devel-0.9.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libsexpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsexpp-devel}"
SRC_URI[x86_64_v2_libsexpp-devel.sha256sum] = "9c60670cdd576cadd9478c36a64da73ea4dfb37fabb678c656138f5085b933fb"

URI_x86_64_v2_sexpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sexpp-0.9.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sexpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sexpp}"
SRC_URI[x86_64_v2_sexpp.sha256sum] = "f9eb5c783d7cea1a2a969010ce701f866e49d0c5e087d1a3044466a0e51ef842"

URI_aarch64_libsexpp = "${EPEL_MIRROR}/aarch64/Packages/l/libsexpp-0.9.2-1.el10_0.aarch64.rpm;name=aarch64_libsexpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsexpp}"
SRC_URI[aarch64_libsexpp.sha256sum] = "b42f7b08357c1a02a1206c809ef075c8f9a5dd0ca762cdc1b31f96a9233428e0"

URI_aarch64_libsexpp-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libsexpp-devel-0.9.2-1.el10_0.aarch64.rpm;name=aarch64_libsexpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsexpp-devel}"
SRC_URI[aarch64_libsexpp-devel.sha256sum] = "382da56bc83f9c8ac6523dd12805a8e2faa5ec93f425414d7dedc38cf9356c4c"

URI_aarch64_sexpp = "${EPEL_MIRROR}/aarch64/Packages/s/sexpp-0.9.2-1.el10_0.aarch64.rpm;name=aarch64_sexpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_sexpp}"
SRC_URI[aarch64_sexpp.sha256sum] = "218005b1328e7cb60abe8d078a5f0d0407caff86f5634c4c1deefd1f91246f01"

RDEPENDS:libsexpp = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libsexpp-devel = " \
 libsexpp \
 pkgconf-pkg-config \
 "
RDEPENDS:sexpp = " \
 glibc \
 libgcc \
 libsexpp \
 libstdc++ \
 "
