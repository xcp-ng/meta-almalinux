# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gfal2-util"
PV = "1.9.1"
PR = "1.el10_2"
PACKAGES = " \
 gfal2-util-scripts \
 python3-gfal2-util \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gfal2-util-1.9.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c930f9987b0aae40e9015ea2dc276a044eeb7117dfb61537ac7184013279fc42"

URI_x86_64_v2_gfal2-util-scripts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-util-scripts-1.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_gfal2-util-scripts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-util-scripts}"
SRC_URI[x86_64_v2_gfal2-util-scripts.sha256sum] = "5839efcd11d2c7a39e4db7d790b05c0a8b34febb7a4bd7a7976b42149c1759c7"

URI_x86_64_v2_python3-gfal2-util = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gfal2-util-1.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-gfal2-util;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gfal2-util}"
SRC_URI[x86_64_v2_python3-gfal2-util.sha256sum] = "376ed024a5ca22e2ecdfb128c81680db9aad3001f5d1f8139c67bc9ce96cd8ab"

URI_aarch64_gfal2-util-scripts = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-util-scripts-1.9.1-1.el10_2.noarch.rpm;name=aarch64_gfal2-util-scripts;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-util-scripts}"
SRC_URI[aarch64_gfal2-util-scripts.sha256sum] = "f5ea79f51a9555905400209fc482268fe41dc3dc35436b48c08ad7b3a6b41817"

URI_aarch64_python3-gfal2-util = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gfal2-util-1.9.1-1.el10_2.noarch.rpm;name=aarch64_python3-gfal2-util;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gfal2-util}"
SRC_URI[aarch64_python3-gfal2-util.sha256sum] = "35d15d47ae3435dc9eb2d6ea07a96377db49931f8ed20923d2d6668f6be05159"

RDEPENDS:gfal2-util-scripts = " \
 bash \
 python3-gfal2-util \
 "
RDEPENDS:python3-gfal2-util = " \
 gfal2-plugin-file \
 gfal2-util-scripts \
 python3 \
 python3-gfal2 \
 "
