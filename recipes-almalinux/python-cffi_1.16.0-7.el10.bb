# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cffi"
PV = "1.16.0"
PR = "7.el10"
PACKAGES = " \
 python3-cffi \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python-cffi-1.16.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5917cf38c447dc9dd6432280a96540c37a574fcef4ca9c3077070d365aff85ba"

URI_x86_64_v2_python3-cffi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-cffi-1.16.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_python3-cffi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cffi}"
SRC_URI[x86_64_v2_python3-cffi.sha256sum] = "51879dadbf8008fbdd0cdee067a7031d6a4f8147d5fc543384b1e4fe482cf51c"

URI_aarch64_python3-cffi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-cffi-1.16.0-7.el10.aarch64.rpm;name=aarch64_python3-cffi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cffi}"
SRC_URI[aarch64_python3-cffi.sha256sum] = "4a99de5ba70035b2d69bba32438d6e704c88008fbecf7c55674cfbedc995b40d"

RDEPENDS:python3-cffi = " \
 glibc \
 libffi \
 python3 \
 python3-pycparser \
 "
