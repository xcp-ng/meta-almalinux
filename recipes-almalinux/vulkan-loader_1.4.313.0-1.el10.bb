# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vulkan-loader"
PV = "1.4.313.0"
PR = "1.el10"
PACKAGES = " \
 vulkan-loader \
 vulkan-loader-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/vulkan-loader-1.4.313.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7d2752bc457013d97de143ffeb511f68750973b5aca10dd3aa0ab07962508193"

URI_x86_64_v2_vulkan-loader = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vulkan-loader-1.4.313.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_vulkan-loader;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vulkan-loader}"
SRC_URI[x86_64_v2_vulkan-loader.sha256sum] = "296e4d186d3f2a851508f0fa5fadc693703496347107dddcb0f614f4bacbe68d"

URI_x86_64_v2_vulkan-loader-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vulkan-loader-devel-1.4.313.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_vulkan-loader-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vulkan-loader-devel}"
SRC_URI[x86_64_v2_vulkan-loader-devel.sha256sum] = "7844a6299e5f7ace034ecf1bfef3b72f973b9cdc4c65ba0e05e92ac5ebb471ff"

URI_aarch64_vulkan-loader = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vulkan-loader-1.4.313.0-1.el10.aarch64.rpm;name=aarch64_vulkan-loader;unpack=0"
SRC_URI:append = " ${URI_aarch64_vulkan-loader}"
SRC_URI[aarch64_vulkan-loader.sha256sum] = "32f45f68b16023f5c0ed95e34b18176211a57e8a9ec05340018baccfc7c3072f"

URI_aarch64_vulkan-loader-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vulkan-loader-devel-1.4.313.0-1.el10.aarch64.rpm;name=aarch64_vulkan-loader-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vulkan-loader-devel}"
SRC_URI[aarch64_vulkan-loader-devel.sha256sum] = "58a3cf45b09e65647dd4a1bafe3577aa4868b47c7c0f84f964e5fcd414dd1aa3"

RDEPENDS:vulkan-loader:x86_64_v2 = " \
 glibc \
 mesa-vulkan-drivers \
"
RDEPENDS:vulkan-loader:aarch64 = " \
 glibc \
"
RDEPENDS:vulkan-loader-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 vulkan-headers \
 vulkan-loader \
 "
