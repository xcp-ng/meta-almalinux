# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fs-err"
PV = "3.2.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-fs-err+default-devel \
 rust-fs-err+expose_original_error-devel \
 rust-fs-err+tokio-devel \
 rust-fs-err-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fs-err-3.2.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d8fbd6148d7cd1c004f13c7351b22707c6dd9b833c5d25bf952af4df3d71ee2e"

URI_x86_64_v2_rust-fs-err+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fs-err+default-devel-3.2.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fs-err+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fs-err+default-devel}"
SRC_URI[x86_64_v2_rust-fs-err+default-devel.sha256sum] = "d37e8909be26d6736a769bc3d66bd5f63747460afcc3832ed93fce8301048c0a"

URI_x86_64_v2_rust-fs-err+expose_original_error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fs-err+expose_original_error-devel-3.2.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fs-err+expose_original_error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fs-err+expose_original_error-devel}"
SRC_URI[x86_64_v2_rust-fs-err+expose_original_error-devel.sha256sum] = "62ca267e7a31fd69322658480aa6cc1a76f395228fa7e2a02f275f5d655b631e"

URI_x86_64_v2_rust-fs-err+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fs-err+tokio-devel-3.2.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fs-err+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fs-err+tokio-devel}"
SRC_URI[x86_64_v2_rust-fs-err+tokio-devel.sha256sum] = "7ff75320fd08b1036207ef36393c2d3ef4de8e99f428928d3a70eabe2885e279"

URI_x86_64_v2_rust-fs-err-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fs-err-devel-3.2.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fs-err-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fs-err-devel}"
SRC_URI[x86_64_v2_rust-fs-err-devel.sha256sum] = "6e670fc8d2ae6a69be6c1a2ff4b2618912779c55e5e2a12ca04f38d9636e92ec"

URI_aarch64_rust-fs-err+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fs-err+default-devel-3.2.2-1.el10_1.noarch.rpm;name=aarch64_rust-fs-err+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fs-err+default-devel}"
SRC_URI[aarch64_rust-fs-err+default-devel.sha256sum] = "03d18f33ae8030d4ddc1cf772136c9494a6e78475a708533cde47d22ecab9c48"

URI_aarch64_rust-fs-err+expose_original_error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fs-err+expose_original_error-devel-3.2.2-1.el10_1.noarch.rpm;name=aarch64_rust-fs-err+expose_original_error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fs-err+expose_original_error-devel}"
SRC_URI[aarch64_rust-fs-err+expose_original_error-devel.sha256sum] = "0afaa1be0c3e798911b83225965770c80e0b3dc2a3ffe218ba4811ab9f916d5a"

URI_aarch64_rust-fs-err+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fs-err+tokio-devel-3.2.2-1.el10_1.noarch.rpm;name=aarch64_rust-fs-err+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fs-err+tokio-devel}"
SRC_URI[aarch64_rust-fs-err+tokio-devel.sha256sum] = "6f3a93b4c452c86866dc130e28e939505fe534bf9e8e3ee8857d144b4c4d0881"

URI_aarch64_rust-fs-err-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fs-err-devel-3.2.2-1.el10_1.noarch.rpm;name=aarch64_rust-fs-err-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fs-err-devel}"
SRC_URI[aarch64_rust-fs-err-devel.sha256sum] = "3e3702e5099ec5f3c15809973637818e70a21b50e6e92c4dd3dda8554385cf37"

RDEPENDS:rust-fs-err+default-devel = " \
 cargo \
 rust-fs-err-devel \
 "
RDEPENDS:rust-fs-err+expose_original_error-devel = " \
 cargo \
 rust-fs-err-devel \
 "
RDEPENDS:rust-fs-err+tokio-devel = " \
 cargo \
 rust-fs-err-devel \
 rust-tokio+fs-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-fs-err-devel = " \
 cargo \
 rust-autocfg+default-devel \
 "
