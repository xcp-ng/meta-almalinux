# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "baloo-widgets"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 baloo-widgets \
 baloo-widgets-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/baloo-widgets-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3feb53f91b823c79c960f94e418854721269e923959ff7a5b8c4213f82444ae3"

URI_x86_64_v2_baloo-widgets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baloo-widgets-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baloo-widgets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baloo-widgets}"
SRC_URI[x86_64_v2_baloo-widgets.sha256sum] = "919d15a1c5b9874ae9ad6078e2e3ae8c31bc750a8ad314507a9d2e2a0886e9a5"

URI_x86_64_v2_baloo-widgets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baloo-widgets-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baloo-widgets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baloo-widgets-devel}"
SRC_URI[x86_64_v2_baloo-widgets-devel.sha256sum] = "a5a520a1e326f6d3e449f940a2d6d4ee65970f705f2fe4d5345ef05862817e35"

URI_aarch64_baloo-widgets = "${EPEL_MIRROR}/aarch64/Packages/b/baloo-widgets-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_baloo-widgets;unpack=0"
SRC_URI:append = " ${URI_aarch64_baloo-widgets}"
SRC_URI[aarch64_baloo-widgets.sha256sum] = "76c10d57b227b84e2aaa1e9fe4143848de43c556db22b540a3248ec817f588f1"

URI_aarch64_baloo-widgets-devel = "${EPEL_MIRROR}/aarch64/Packages/b/baloo-widgets-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_baloo-widgets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_baloo-widgets-devel}"
SRC_URI[aarch64_baloo-widgets-devel.sha256sum] = "98f092eb5017a8b23ce043935f660485088ec4f0106e3dc799cb952b0b7754fb"

RDEPENDS:baloo-widgets = " \
 glibc \
 kf6-baloo-libs \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kservice \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:baloo-widgets-devel = " \
 baloo-widgets \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kf6-kio-devel \
 qt6-qtbase-devel \
 "
