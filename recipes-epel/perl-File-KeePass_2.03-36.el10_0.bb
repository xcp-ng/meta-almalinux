# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-File-KeePass"
PV = "2.03"
PR = "36.el10_0"
PACKAGES = " \
 perl-File-KeePass \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-File-KeePass-2.03-36.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7d1f6e8b144d05b46f0d1a566b8ef22c5c4fba1bdbdaf1c59272e00ad9f5e8c0"

URI_x86_64_v2_perl-File-KeePass = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-File-KeePass-2.03-36.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-File-KeePass;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-KeePass}"
SRC_URI[x86_64_v2_perl-File-KeePass.sha256sum] = "2b54cebaede42eaf722483e49bb69a0e4bb0d8bcdc20d987e307fc6df2e189b6"

URI_aarch64_perl-File-KeePass = "${EPEL_MIRROR}/aarch64/Packages/p/perl-File-KeePass-2.03-36.el10_0.noarch.rpm;name=aarch64_perl-File-KeePass;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-KeePass}"
SRC_URI[aarch64_perl-File-KeePass.sha256sum] = "74af24045be8bb7450b5d4cac2433b9b671eff4801c14a358a3fc8e86c3659c9"

RDEPENDS:perl-File-KeePass = " \
 perl-Compress-Raw-Zlib \
 perl-Crypt-Rijndael \
 perl-Digest-SHA \
 perl-MIME-Base64 \
 perl-XML-Parser \
 perl-constant \
 perl-libs \
 "
