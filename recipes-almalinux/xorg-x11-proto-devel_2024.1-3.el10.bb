# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xorg-x11-proto-devel"
PV = "2024.1"
PR = "3.el10"
PACKAGES = " \
 xorg-x11-proto-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xorg-x11-proto-devel-2024.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "00f666339881d5664776e94bc605a2bd6851102a1c143cda3769f4d3d0373605"

URI_x86_64_v2_xorg-x11-proto-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xorg-x11-proto-devel-2024.1-3.el10.noarch.rpm;name=x86_64_v2_xorg-x11-proto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xorg-x11-proto-devel}"
SRC_URI[x86_64_v2_xorg-x11-proto-devel.sha256sum] = "2bea35b7beb98d163c08e8c37bf95788ac663edee1a96ef0a653ce6e9b96c30e"

URI_aarch64_xorg-x11-proto-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xorg-x11-proto-devel-2024.1-3.el10.noarch.rpm;name=aarch64_xorg-x11-proto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xorg-x11-proto-devel}"
SRC_URI[aarch64_xorg-x11-proto-devel.sha256sum] = "2bea35b7beb98d163c08e8c37bf95788ac663edee1a96ef0a653ce6e9b96c30e"

RDEPENDS:xorg-x11-proto-devel = " \
 pkgconf-pkg-config \
 xorg-x11-proto-devel \
 "
