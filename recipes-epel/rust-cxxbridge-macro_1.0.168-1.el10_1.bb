# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cxxbridge-macro"
PV = "1.0.168"
PR = "1.el10_1"
PACKAGES = " \
 rust-cxxbridge-macro+clang-ast-devel \
 rust-cxxbridge-macro+default-devel \
 rust-cxxbridge-macro+flate2-devel \
 rust-cxxbridge-macro+serde-devel \
 rust-cxxbridge-macro+serde_derive-devel \
 rust-cxxbridge-macro+serde_json-devel \
 rust-cxxbridge-macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cxxbridge-macro-1.0.168-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "41ca2738063fe2538ae53558d150724b9ff4443dbac29ca12b375ca14f32ccdb"

URI_x86_64_v2_rust-cxxbridge-macro+clang-ast-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-macro+clang-ast-devel-1.0.168-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-macro+clang-ast-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-macro+clang-ast-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-macro+clang-ast-devel.sha256sum] = "880657e9e4422a86627e75d622ea412b83790bada110113bd6acf6f2f4a93396"

URI_x86_64_v2_rust-cxxbridge-macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-macro+default-devel-1.0.168-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-macro+default-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-macro+default-devel.sha256sum] = "a6ac8eecb1a454aa0f20f9dbbbe19203e2cb097d756e2d88808d1667f70cdc44"

URI_x86_64_v2_rust-cxxbridge-macro+flate2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-macro+flate2-devel-1.0.168-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-macro+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-macro+flate2-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-macro+flate2-devel.sha256sum] = "995bbe3d21b2d554caa0c89f10d9b4a9a61fd1013edc0750a4fe123e72626c52"

URI_x86_64_v2_rust-cxxbridge-macro+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-macro+serde-devel-1.0.168-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-macro+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-macro+serde-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-macro+serde-devel.sha256sum] = "705442725fada1b3f726cd4c7f56ea08fbcc231817a0289ca49d62e46a12fac6"

URI_x86_64_v2_rust-cxxbridge-macro+serde_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-macro+serde_derive-devel-1.0.168-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-macro+serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-macro+serde_derive-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-macro+serde_derive-devel.sha256sum] = "797726b61761dd0cea0f8fccdb6ed2964045d80213b45d62f71a890b73448f99"

URI_x86_64_v2_rust-cxxbridge-macro+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-macro+serde_json-devel-1.0.168-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-macro+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-macro+serde_json-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-macro+serde_json-devel.sha256sum] = "a65819f2d1cfb809b9d40c7abfedcbea97739e1f53e8edd17fa9428cd00bc350"

URI_x86_64_v2_rust-cxxbridge-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-macro-devel-1.0.168-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-macro-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-macro-devel.sha256sum] = "c68d24ac4a1ec36f37c3e0fc944103441d60044faaab7bf620ddf745e34b238f"

URI_aarch64_rust-cxxbridge-macro+clang-ast-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-macro+clang-ast-devel-1.0.168-1.el10_1.noarch.rpm;name=aarch64_rust-cxxbridge-macro+clang-ast-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-macro+clang-ast-devel}"
SRC_URI[aarch64_rust-cxxbridge-macro+clang-ast-devel.sha256sum] = "de62f799db0f86b6d9d904c2f53ce26512ddd756e164184540d1130433d17276"

URI_aarch64_rust-cxxbridge-macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-macro+default-devel-1.0.168-1.el10_1.noarch.rpm;name=aarch64_rust-cxxbridge-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-macro+default-devel}"
SRC_URI[aarch64_rust-cxxbridge-macro+default-devel.sha256sum] = "b33e116c8b00cae90fdc3d909da3ccc8cd35e8f52a828a934195595bfdde03a5"

URI_aarch64_rust-cxxbridge-macro+flate2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-macro+flate2-devel-1.0.168-1.el10_1.noarch.rpm;name=aarch64_rust-cxxbridge-macro+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-macro+flate2-devel}"
SRC_URI[aarch64_rust-cxxbridge-macro+flate2-devel.sha256sum] = "d33e8a2f3806d8888a87756228db3a491a78f9d770279b3aa69ea7667af1e2aa"

URI_aarch64_rust-cxxbridge-macro+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-macro+serde-devel-1.0.168-1.el10_1.noarch.rpm;name=aarch64_rust-cxxbridge-macro+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-macro+serde-devel}"
SRC_URI[aarch64_rust-cxxbridge-macro+serde-devel.sha256sum] = "0ddeb0cf34331f311916bf5ccd67f3f29b77403eacd8cda0c31aac406eecd411"

URI_aarch64_rust-cxxbridge-macro+serde_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-macro+serde_derive-devel-1.0.168-1.el10_1.noarch.rpm;name=aarch64_rust-cxxbridge-macro+serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-macro+serde_derive-devel}"
SRC_URI[aarch64_rust-cxxbridge-macro+serde_derive-devel.sha256sum] = "93d4392b42f2dc2a48157130f96527d2c2a60ddb67532ebd772c793d48a7d739"

URI_aarch64_rust-cxxbridge-macro+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-macro+serde_json-devel-1.0.168-1.el10_1.noarch.rpm;name=aarch64_rust-cxxbridge-macro+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-macro+serde_json-devel}"
SRC_URI[aarch64_rust-cxxbridge-macro+serde_json-devel.sha256sum] = "10297ee97f85a7425180f02accf165bdb197bc1a7a964da9b3da36abb68b2976"

URI_aarch64_rust-cxxbridge-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-macro-devel-1.0.168-1.el10_1.noarch.rpm;name=aarch64_rust-cxxbridge-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-macro-devel}"
SRC_URI[aarch64_rust-cxxbridge-macro-devel.sha256sum] = "3b9b2976e020ee90726e90325b3ca0730f3fc2f215416ef22cb1b7b003c656e7"

RDEPENDS:rust-cxxbridge-macro+clang-ast-devel = " \
 cargo \
 rust-clang-ast+default-devel \
 rust-cxxbridge-macro-devel \
 "
RDEPENDS:rust-cxxbridge-macro+default-devel = " \
 cargo \
 rust-cxxbridge-macro-devel \
 "
RDEPENDS:rust-cxxbridge-macro+flate2-devel = " \
 cargo \
 rust-cxxbridge-macro-devel \
 rust-flate2+default-devel \
 "
RDEPENDS:rust-cxxbridge-macro+serde-devel = " \
 cargo \
 rust-cxxbridge-macro-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-cxxbridge-macro+serde_derive-devel = " \
 cargo \
 rust-cxxbridge-macro-devel \
 rust-serde_derive+default-devel \
 "
RDEPENDS:rust-cxxbridge-macro+serde_json-devel = " \
 cargo \
 rust-cxxbridge-macro-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-cxxbridge-macro-devel = " \
 cargo \
 rust \
 rust-indexmap+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-rustversion+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
