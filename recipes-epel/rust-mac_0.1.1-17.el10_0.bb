# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mac"
PV = "0.1.1"
PR = "17.el10_0"
PACKAGES = " \
 rust-mac+default-devel \
 rust-mac-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mac-0.1.1-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "29d445063bb1cc837fe4ba4bbe7c4f58ec15a5427f6a2e6adc20c8d2ee9e1f80"

URI_x86_64_v2_rust-mac+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mac+default-devel-0.1.1-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mac+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mac+default-devel}"
SRC_URI[x86_64_v2_rust-mac+default-devel.sha256sum] = "b00a99c19bc37fc798b422b4b3774b5f9ff1ae2cac8e46937e9b949b2885d338"

URI_x86_64_v2_rust-mac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mac-devel-0.1.1-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mac-devel}"
SRC_URI[x86_64_v2_rust-mac-devel.sha256sum] = "7923781741f7c089ad4aa9482bf394924144a0199eb698c5107248d1a441b555"

URI_aarch64_rust-mac+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mac+default-devel-0.1.1-17.el10_0.noarch.rpm;name=aarch64_rust-mac+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mac+default-devel}"
SRC_URI[aarch64_rust-mac+default-devel.sha256sum] = "03b02552aacb524bb8346054c9a5567cccbe95a0022683b728fe9dbb1023a657"

URI_aarch64_rust-mac-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mac-devel-0.1.1-17.el10_0.noarch.rpm;name=aarch64_rust-mac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mac-devel}"
SRC_URI[aarch64_rust-mac-devel.sha256sum] = "57b56a3b661911c4f8d8d2daa40bea21ea3d48243a9f556fd3dd0bc7dd3d51b4"

RDEPENDS:rust-mac+default-devel = " \
 cargo \
 rust-mac-devel \
 "
RDEPENDS:rust-mac-devel = " \
 cargo \
 "
