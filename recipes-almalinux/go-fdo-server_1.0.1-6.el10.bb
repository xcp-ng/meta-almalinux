# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "go-fdo-server"
PV = "1.0.1"
PR = "6.el10"
PACKAGES = " \
 go-fdo-server \
 go-fdo-server-manufacturer \
 go-fdo-server-owner \
 go-fdo-server-rendezvous \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/go-fdo-server-1.0.1-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8b14269735bfd58d1ac1fb0af045248d7805ab5bbec47e74117712237e3b05b0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-fdo-server-1.0.1-6.el10.x86_64_v2.rpm;name=x86_64_v2_go-fdo-server;unpack=0"
SRC_URI[x86_64_v2_go-fdo-server.sha256sum] = "b7706ada80881336e81f182a73ac0a05e6d910c017923583cb8943fc1d9d8cc4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-fdo-server-manufacturer-1.0.1-6.el10.noarch.rpm;name=x86_64_v2_go-fdo-server-manufacturer;unpack=0"
SRC_URI[x86_64_v2_go-fdo-server-manufacturer.sha256sum] = "eaa8e119199400004e9b4b0d98664f60afb37c956801c19245ade04637df8489"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-fdo-server-owner-1.0.1-6.el10.noarch.rpm;name=x86_64_v2_go-fdo-server-owner;unpack=0"
SRC_URI[x86_64_v2_go-fdo-server-owner.sha256sum] = "c4b346a38f03eceae948112ae2aa5b590af98dde1442be502bc7cda5a2e323d8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-fdo-server-rendezvous-1.0.1-6.el10.noarch.rpm;name=x86_64_v2_go-fdo-server-rendezvous;unpack=0"
SRC_URI[x86_64_v2_go-fdo-server-rendezvous.sha256sum] = "d2450f4348c7bb57107ef13d8c331c594a4a6fc5a9db2b960b6b433d6bc795f9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-fdo-server-1.0.1-6.el10.aarch64.rpm;name=aarch64_go-fdo-server;unpack=0"
SRC_URI[aarch64_go-fdo-server.sha256sum] = "959b2dd3c9e8c633b43bbb0432aa6b76d80ca7cba0148fcec0366a1a93561896"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-fdo-server-manufacturer-1.0.1-6.el10.noarch.rpm;name=aarch64_go-fdo-server-manufacturer;unpack=0"
SRC_URI[aarch64_go-fdo-server-manufacturer.sha256sum] = "eaa8e119199400004e9b4b0d98664f60afb37c956801c19245ade04637df8489"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-fdo-server-owner-1.0.1-6.el10.noarch.rpm;name=aarch64_go-fdo-server-owner;unpack=0"
SRC_URI[aarch64_go-fdo-server-owner.sha256sum] = "c4b346a38f03eceae948112ae2aa5b590af98dde1442be502bc7cda5a2e323d8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-fdo-server-rendezvous-1.0.1-6.el10.noarch.rpm;name=aarch64_go-fdo-server-rendezvous;unpack=0"
SRC_URI[aarch64_go-fdo-server-rendezvous.sha256sum] = "d2450f4348c7bb57107ef13d8c331c594a4a6fc5a9db2b960b6b433d6bc795f9"

RDEPENDS:go-fdo-server = " \
 bash \
 glibc \
 shadow-utils \
 "
RDEPENDS:go-fdo-server-manufacturer = " \
 bash \
 go-fdo-server \
 openssl \
 "
RDEPENDS:go-fdo-server-owner = " \
 bash \
 go-fdo-server \
 "
RDEPENDS:go-fdo-server-rendezvous = " \
 bash \
 go-fdo-server \
 "
