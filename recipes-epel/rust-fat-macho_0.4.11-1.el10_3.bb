# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fat-macho"
PV = "0.4.11"
PR = "1.el10_3"
PACKAGES = " \
 rust-fat-macho+bitcode-devel \
 rust-fat-macho+default-devel \
 rust-fat-macho+llvm-bitcode-devel \
 rust-fat-macho-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fat-macho-0.4.11-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9767e29330e75a1068ac7f8414efe692d72daf3722b18e64f0aa1c09f8d070a0"

URI_x86_64_v2_rust-fat-macho+bitcode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fat-macho+bitcode-devel-0.4.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fat-macho+bitcode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fat-macho+bitcode-devel}"
SRC_URI[x86_64_v2_rust-fat-macho+bitcode-devel.sha256sum] = "2c1b528e489c4272359fe995016d25928b6bcab1242e378e1ddb3bb959fefcaa"

URI_x86_64_v2_rust-fat-macho+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fat-macho+default-devel-0.4.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fat-macho+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fat-macho+default-devel}"
SRC_URI[x86_64_v2_rust-fat-macho+default-devel.sha256sum] = "db1e6f67af12105d319024fc3e47e41e38255585352b25992c024c7282422149"

URI_x86_64_v2_rust-fat-macho+llvm-bitcode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fat-macho+llvm-bitcode-devel-0.4.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fat-macho+llvm-bitcode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fat-macho+llvm-bitcode-devel}"
SRC_URI[x86_64_v2_rust-fat-macho+llvm-bitcode-devel.sha256sum] = "c161928549adc91be4324e03e6406ce96e08054c9b4d2b85025b39ff5a416c22"

URI_x86_64_v2_rust-fat-macho-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fat-macho-devel-0.4.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fat-macho-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fat-macho-devel}"
SRC_URI[x86_64_v2_rust-fat-macho-devel.sha256sum] = "27f8b39986befacfd6c674304d8ffbf68d325f9f52f680799fce104491db837f"

URI_aarch64_rust-fat-macho+bitcode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fat-macho+bitcode-devel-0.4.11-1.el10_3.noarch.rpm;name=aarch64_rust-fat-macho+bitcode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fat-macho+bitcode-devel}"
SRC_URI[aarch64_rust-fat-macho+bitcode-devel.sha256sum] = "781c5a80abc491881563192d715c1c0c1ceb158fca0e24df34713df518ff269f"

URI_aarch64_rust-fat-macho+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fat-macho+default-devel-0.4.11-1.el10_3.noarch.rpm;name=aarch64_rust-fat-macho+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fat-macho+default-devel}"
SRC_URI[aarch64_rust-fat-macho+default-devel.sha256sum] = "fca6c9ecacf0f865bb1772735c6c6d8f3038c838eede2c98529b9edc53dbbf2e"

URI_aarch64_rust-fat-macho+llvm-bitcode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fat-macho+llvm-bitcode-devel-0.4.11-1.el10_3.noarch.rpm;name=aarch64_rust-fat-macho+llvm-bitcode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fat-macho+llvm-bitcode-devel}"
SRC_URI[aarch64_rust-fat-macho+llvm-bitcode-devel.sha256sum] = "4f690011b2b2d358e28e527eb52a7ae5e29e4d2ea693b3d4a8eea751410184c7"

URI_aarch64_rust-fat-macho-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fat-macho-devel-0.4.11-1.el10_3.noarch.rpm;name=aarch64_rust-fat-macho-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fat-macho-devel}"
SRC_URI[aarch64_rust-fat-macho-devel.sha256sum] = "695d3b09b56088682f1b81072198f256dda2ac17bf0de1e24fcaca37a90b0bc7"

RDEPENDS:rust-fat-macho+bitcode-devel = " \
 cargo \
 rust-fat-macho+llvm-bitcode-devel \
 rust-fat-macho-devel \
 "
RDEPENDS:rust-fat-macho+default-devel = " \
 cargo \
 rust-fat-macho+bitcode-devel \
 rust-fat-macho-devel \
 "
RDEPENDS:rust-fat-macho+llvm-bitcode-devel = " \
 cargo \
 rust-fat-macho-devel \
 rust-llvm-bitcode+default-devel \
 "
RDEPENDS:rust-fat-macho-devel = " \
 cargo \
 rust-goblin+default-devel \
 "
