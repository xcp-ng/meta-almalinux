# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reflink-copy"
PV = "0.1.29"
PR = "1.el10_1"
PACKAGES = " \
 rust-reflink-copy+default-devel \
 rust-reflink-copy+tracing-devel \
 rust-reflink-copy-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reflink-copy-0.1.29-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e46b32d17c1a8eca98a642906b6af0fa5f134136371fa9a02d18e85ffbfe29d2"

URI_x86_64_v2_rust-reflink-copy+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reflink-copy+default-devel-0.1.29-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reflink-copy+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reflink-copy+default-devel}"
SRC_URI[x86_64_v2_rust-reflink-copy+default-devel.sha256sum] = "e8a754bc9754d54dedeb6116752b5fabacffe53bad47ef030ff3eaefed0fb20c"

URI_x86_64_v2_rust-reflink-copy+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reflink-copy+tracing-devel-0.1.29-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reflink-copy+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reflink-copy+tracing-devel}"
SRC_URI[x86_64_v2_rust-reflink-copy+tracing-devel.sha256sum] = "f7b37b376fcc3b212d36a506d43b1e77ead591288c56b3e1ef2cba3c0ecfd92c"

URI_x86_64_v2_rust-reflink-copy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reflink-copy-devel-0.1.29-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reflink-copy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reflink-copy-devel}"
SRC_URI[x86_64_v2_rust-reflink-copy-devel.sha256sum] = "c76a6cf7dbb71e1c2799229c01d3dfaafe155fee5053474acfe9d29a4bd92fde"

URI_aarch64_rust-reflink-copy+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reflink-copy+default-devel-0.1.29-1.el10_1.noarch.rpm;name=aarch64_rust-reflink-copy+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reflink-copy+default-devel}"
SRC_URI[aarch64_rust-reflink-copy+default-devel.sha256sum] = "f4fbb3c05c42043a79eaf0efb9de2b0905cd9e3ea4df895e66d72e06afe8f19f"

URI_aarch64_rust-reflink-copy+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reflink-copy+tracing-devel-0.1.29-1.el10_1.noarch.rpm;name=aarch64_rust-reflink-copy+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reflink-copy+tracing-devel}"
SRC_URI[aarch64_rust-reflink-copy+tracing-devel.sha256sum] = "f1899847cf0aa48d2404334f2aa0bb4d3cc39a8d8d90626b6fe504d80b8754e5"

URI_aarch64_rust-reflink-copy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reflink-copy-devel-0.1.29-1.el10_1.noarch.rpm;name=aarch64_rust-reflink-copy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reflink-copy-devel}"
SRC_URI[aarch64_rust-reflink-copy-devel.sha256sum] = "1c5ef63395186b97760da838ec07caf276cdb063f5eb24961dc37e0acf6c6ab5"

RDEPENDS:rust-reflink-copy+default-devel = " \
 cargo \
 rust-reflink-copy-devel \
 "
RDEPENDS:rust-reflink-copy+tracing-devel = " \
 cargo \
 rust-reflink-copy-devel \
 rust-tracing-attributes+default-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-reflink-copy-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 rust-rustix+fs-devel \
 rust-rustix+std-devel \
 rust-rustix-devel \
 "
