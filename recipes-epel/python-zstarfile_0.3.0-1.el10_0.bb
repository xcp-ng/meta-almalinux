# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-zstarfile"
PV = "0.3.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-zstarfile \
 python3-zstarfile+all \
 python3-zstarfile+lz4 \
 python3-zstarfile+zstandard \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-zstarfile-0.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c74e2679d4195c8a9574611b8de9ae66deaecf02b48e1d43a417021cbee20cce"

URI_x86_64_v2_python3-zstarfile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-zstarfile-0.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-zstarfile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-zstarfile}"
SRC_URI[x86_64_v2_python3-zstarfile.sha256sum] = "771b0259c48d6c2f8bddcb7e4bbf819f2a8b84f9441cda4b3126afcfc37ccd69"

URI_x86_64_v2_python3-zstarfile+all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-zstarfile+all-0.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-zstarfile+all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-zstarfile+all}"
SRC_URI[x86_64_v2_python3-zstarfile+all.sha256sum] = "af34a44c48a0cf0489612f7687b8199b72ad23f910fe8ed6f121c7369983d16b"

URI_x86_64_v2_python3-zstarfile+lz4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-zstarfile+lz4-0.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-zstarfile+lz4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-zstarfile+lz4}"
SRC_URI[x86_64_v2_python3-zstarfile+lz4.sha256sum] = "e225fe3f53fb5f77d8c098d2514eb97a8b377fc81a98d8f47f5ea955cfd88db7"

URI_x86_64_v2_python3-zstarfile+zstandard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-zstarfile+zstandard-0.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-zstarfile+zstandard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-zstarfile+zstandard}"
SRC_URI[x86_64_v2_python3-zstarfile+zstandard.sha256sum] = "31fef4ff86aaaff0afdb606abe1c5102b065c0753e9edc8f117f7343d37c25c3"

URI_aarch64_python3-zstarfile = "${EPEL_MIRROR}/aarch64/Packages/p/python3-zstarfile-0.3.0-1.el10_0.noarch.rpm;name=aarch64_python3-zstarfile;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-zstarfile}"
SRC_URI[aarch64_python3-zstarfile.sha256sum] = "958de2deded13ed44e3e67dd991f16b0c8e580d62e53427384ad558a2b4290b5"

URI_aarch64_python3-zstarfile+all = "${EPEL_MIRROR}/aarch64/Packages/p/python3-zstarfile+all-0.3.0-1.el10_0.noarch.rpm;name=aarch64_python3-zstarfile+all;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-zstarfile+all}"
SRC_URI[aarch64_python3-zstarfile+all.sha256sum] = "81386d3570cdbaad67f85438966d62c9426d3d292db99c1d89eaf0e935d930ae"

URI_aarch64_python3-zstarfile+lz4 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-zstarfile+lz4-0.3.0-1.el10_0.noarch.rpm;name=aarch64_python3-zstarfile+lz4;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-zstarfile+lz4}"
SRC_URI[aarch64_python3-zstarfile+lz4.sha256sum] = "df1b08139a5f9ed2bc797b88e5e7add717d2f8126f7c42eee43ceb4ee45a3de3"

URI_aarch64_python3-zstarfile+zstandard = "${EPEL_MIRROR}/aarch64/Packages/p/python3-zstarfile+zstandard-0.3.0-1.el10_0.noarch.rpm;name=aarch64_python3-zstarfile+zstandard;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-zstarfile+zstandard}"
SRC_URI[aarch64_python3-zstarfile+zstandard.sha256sum] = "3b5ae082ffbbb19442f6bda61332cb6257cde59e2726bc4f38ba4becc746aa08"

RDEPENDS:python3-zstarfile = " \
 python3 \
 "
RDEPENDS:python3-zstarfile+all = " \
 python3 \
 python3-zstarfile \
 python3-zstarfile+lz4 \
 python3-zstarfile+zstandard \
 "
RDEPENDS:python3-zstarfile+lz4 = " \
 python3 \
 python3-lz4 \
 python3-zstarfile \
 "
RDEPENDS:python3-zstarfile+zstandard = " \
 python3 \
 python3-pyzstd \
 python3-zstarfile \
 "
