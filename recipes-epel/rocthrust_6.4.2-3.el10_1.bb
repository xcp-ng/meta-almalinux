# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocthrust"
PV = "6.4.2"
PR = "3.el10_1"
PACKAGES:x86_64_v2 = " \
 rocthrust-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocthrust-6.4.2-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90b3b60509d10b4614084b024f4c7f86e6cc5b794652c744ea2b37394e63af62"

URI_x86_64_v2_rocthrust-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocthrust-devel-6.4.2-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocthrust-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocthrust-devel}"
SRC_URI[x86_64_v2_rocthrust-devel.sha256sum] = "3c9346c1d3d3a54eda9751f0007819a2a5542915002595d8003b84f9f8f27748"

RDEPENDS:rocthrust-devel = " \
 cmake-filesystem \
 "
