# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-anstyle-hyperlink"
PV = "1.0.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-anstyle-hyperlink+default-devel \
 rust-anstyle-hyperlink+file-devel \
 rust-anstyle-hyperlink+std-devel \
 rust-anstyle-hyperlink-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-anstyle-hyperlink-1.0.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "59af17440383e3359a4fced13028693c50eed91f3de9b8f2cea9e18f673ef924"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-hyperlink+default-devel-1.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-hyperlink+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-anstyle-hyperlink+default-devel.sha256sum] = "531828ef1c38bd8d7167629f56cd87ffccaaf2b5c6321e59b72942d8cc1a8423"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-hyperlink+file-devel-1.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-hyperlink+file-devel;unpack=0"
SRC_URI[x86_64_v2_rust-anstyle-hyperlink+file-devel.sha256sum] = "af0565ce9801a55b6948e5904d7fa4e5d56f125cbe60036daf9292b14867469d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-hyperlink+std-devel-1.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-hyperlink+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-anstyle-hyperlink+std-devel.sha256sum] = "64dc7855d0841bf810d1900602792060317023702405665949f6530af8092267"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-hyperlink-devel-1.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-hyperlink-devel;unpack=0"
SRC_URI[x86_64_v2_rust-anstyle-hyperlink-devel.sha256sum] = "ce705c097ff317b97b77b0b26c75ceadcff5ede9ec827f0042a34c0cf9507d46"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-hyperlink+default-devel-1.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-anstyle-hyperlink+default-devel;unpack=0"
SRC_URI[aarch64_rust-anstyle-hyperlink+default-devel.sha256sum] = "1cec06f8f3758f7347e9f9821f63c923de4b9a675670ac47943d8833bdb9c0e9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-hyperlink+file-devel-1.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-anstyle-hyperlink+file-devel;unpack=0"
SRC_URI[aarch64_rust-anstyle-hyperlink+file-devel.sha256sum] = "83d685a516cd29b8676c9c716e1da72067bcb59a8ad03283b9392daf6702986d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-hyperlink+std-devel-1.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-anstyle-hyperlink+std-devel;unpack=0"
SRC_URI[aarch64_rust-anstyle-hyperlink+std-devel.sha256sum] = "0e0397deb59c20dc6175ed3f08063f66c919adce8ed884e5bd214b96c172561d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-hyperlink-devel-1.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-anstyle-hyperlink-devel;unpack=0"
SRC_URI[aarch64_rust-anstyle-hyperlink-devel.sha256sum] = "499c23e901d8748daedeefb954b3f4d3c116eb416d594c2d1d87a686d6daea51"

RDEPENDS:rust-anstyle-hyperlink+default-devel = " \
 cargo \
 rust-anstyle-hyperlink+std-devel \
 rust-anstyle-hyperlink-devel \
 "
RDEPENDS:rust-anstyle-hyperlink+file-devel = " \
 cargo \
 rust-anstyle-hyperlink+std-devel \
 rust-anstyle-hyperlink-devel \
 rust-libc+default-devel \
 rust-percent-encoding+default-devel \
 "
RDEPENDS:rust-anstyle-hyperlink+std-devel = " \
 cargo \
 rust-anstyle-hyperlink-devel \
 "
RDEPENDS:rust-anstyle-hyperlink-devel = " \
 cargo \
 rust \
 "
