# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-AnyEvent"
PV = "7.17"
PR = "15.el10_0"
PACKAGES = " \
 perl-AnyEvent \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-AnyEvent-7.17-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0bc7d27e640766277d5eed841740899547b55699cf87aa4ccac2a220127257a5"

URI_x86_64_v2_perl-AnyEvent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-AnyEvent-7.17-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-AnyEvent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-AnyEvent}"
SRC_URI[x86_64_v2_perl-AnyEvent.sha256sum] = "8782073000f9f75d2e49a5a9e1b863c61b57a073a6a80a645ba02e6f78f2c4e1"

URI_aarch64_perl-AnyEvent = "${EPEL_MIRROR}/aarch64/Packages/p/perl-AnyEvent-7.17-15.el10_0.aarch64.rpm;name=aarch64_perl-AnyEvent;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-AnyEvent}"
SRC_URI[aarch64_perl-AnyEvent.sha256sum] = "8da1c633fb97073c3da34cc7852544eefa1d106b3323569115d6f8f2f6441085"

RDEPENDS:perl-AnyEvent = " \
 perl-AnyEvent \
 perl-B \
 perl-Carp \
 perl-Errno \
 perl-Exporter \
 perl-File-Temp \
 perl-Net-SSLeay \
 perl-POSIX \
 perl-Scalar-List-Utils \
 perl-Socket \
 perl-Time-HiRes \
 perl-base \
 perl-libs \
 perl-overload \
 "
