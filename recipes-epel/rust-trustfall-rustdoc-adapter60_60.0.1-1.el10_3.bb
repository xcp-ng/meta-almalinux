# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-trustfall-rustdoc-adapter60"
PV = "60.0.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-trustfall-rustdoc-adapter60+default-devel \
 rust-trustfall-rustdoc-adapter60+rayon-devel \
 rust-trustfall-rustdoc-adapter60+rustc-hash-devel \
 rust-trustfall-rustdoc-adapter60-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-trustfall-rustdoc-adapter60-60.0.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "28615e70b227cf55c089b7c1bed10e792d623318436112b052335dda4e9d7c3e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trustfall-rustdoc-adapter60+default-devel-60.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trustfall-rustdoc-adapter60+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trustfall-rustdoc-adapter60+default-devel.sha256sum] = "ea8d38da79f644b016aa4241c4df27a6d3776437b11e28564df7145797566b89"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trustfall-rustdoc-adapter60+rayon-devel-60.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trustfall-rustdoc-adapter60+rayon-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trustfall-rustdoc-adapter60+rayon-devel.sha256sum] = "c68b4c5e0c91e0244f33acb38bba583ef9ea9693c8258a7843a3cda3ffb0edd3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trustfall-rustdoc-adapter60+rustc-hash-devel-60.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trustfall-rustdoc-adapter60+rustc-hash-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trustfall-rustdoc-adapter60+rustc-hash-devel.sha256sum] = "ee598acb6704f5cc944cf35909d06498dfc168d19564c1acec7d925ecba2c409"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trustfall-rustdoc-adapter60-devel-60.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trustfall-rustdoc-adapter60-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trustfall-rustdoc-adapter60-devel.sha256sum] = "0fa449e9d1d0c48af6f5c9cd7b7a41f12563b7f571715b9231efb6a6a10f1d35"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trustfall-rustdoc-adapter60+default-devel-60.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-trustfall-rustdoc-adapter60+default-devel;unpack=0"
SRC_URI[aarch64_rust-trustfall-rustdoc-adapter60+default-devel.sha256sum] = "26e1ced5eca6280ecb22caa069fbb8d624a0c9e8fed25feb813c314824f8861d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trustfall-rustdoc-adapter60+rayon-devel-60.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-trustfall-rustdoc-adapter60+rayon-devel;unpack=0"
SRC_URI[aarch64_rust-trustfall-rustdoc-adapter60+rayon-devel.sha256sum] = "7375caec359ac81a2eb19ae2e7aa297a56e16e96b7e446691569200a6a4c93cb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trustfall-rustdoc-adapter60+rustc-hash-devel-60.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-trustfall-rustdoc-adapter60+rustc-hash-devel;unpack=0"
SRC_URI[aarch64_rust-trustfall-rustdoc-adapter60+rustc-hash-devel.sha256sum] = "a237028c1a69fd511d2fe29bf7b654dc8716ef1dce5e35360286da2c03f8b4aa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trustfall-rustdoc-adapter60-devel-60.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-trustfall-rustdoc-adapter60-devel;unpack=0"
SRC_URI[aarch64_rust-trustfall-rustdoc-adapter60-devel.sha256sum] = "3fae9863c94399b07aa48cc49cc661997ea2bab6d459625df0c2cef787ca7700"

RDEPENDS:rust-trustfall-rustdoc-adapter60+default-devel = " \
 cargo \
 rust-trustfall-rustdoc-adapter60-devel \
 "
RDEPENDS:rust-trustfall-rustdoc-adapter60+rayon-devel = " \
 cargo \
 rust-rayon+default-devel \
 rust-trustfall-rustdoc-adapter60-devel \
 "
RDEPENDS:rust-trustfall-rustdoc-adapter60+rustc-hash-devel = " \
 cargo \
 rust-rustc-hash+default-devel \
 rust-rustdoc-types0.60+rustc-hash-devel \
 rust-trustfall-rustdoc-adapter60-devel \
 "
RDEPENDS:rust-trustfall-rustdoc-adapter60-devel = " \
 bash \
 cargo \
 rust \
 rust-cargo_metadata+default-devel \
 rust-cargo_toml+default-devel \
 rust-cargo_toml+features-devel \
 rust-indexmap+default-devel \
 rust-rustdoc-types0.60+default-devel \
 rust-trustfall+default-devel \
 "
