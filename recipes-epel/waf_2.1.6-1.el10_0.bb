# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "waf"
PV = "2.1.6"
PR = "1.el10_0"
PACKAGES = " \
 waf \
 waf-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/w/waf-2.1.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "946f2a71eebcbf6f9e30fd3397d7cd7364cc31b731bd736e7c807d53c1639b10"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/waf-2.1.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_waf;unpack=0"
SRC_URI[x86_64_v2_waf.sha256sum] = "568b3145e2bb988807c7cadc937a03fa6ed9e99be7496fa24329f490649d16e2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/waf-doc-2.1.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_waf-doc;unpack=0"
SRC_URI[x86_64_v2_waf-doc.sha256sum] = "5b53b5de0ab8b0fde600c95798cb1919270c2e96865750bf4cc5209645bba9de"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/waf-2.1.6-1.el10_0.noarch.rpm;name=aarch64_waf;unpack=0"
SRC_URI[aarch64_waf.sha256sum] = "68cdc1aed9180f6bd1c1c5981f47b53e148d3bd2288827ce3c69967424907420"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/waf-doc-2.1.6-1.el10_0.noarch.rpm;name=aarch64_waf-doc;unpack=0"
SRC_URI[aarch64_waf-doc.sha256sum] = "94e09ef4dc58ac84f96af4642da82d1a8516a49ef99418303c280c03b48618e9"

RDEPENDS:waf = " \
 python3 \
 "
RDEPENDS:waf-doc = " \
 waf \
 "
