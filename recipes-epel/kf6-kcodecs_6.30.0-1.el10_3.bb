# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcodecs"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kcodecs \
 kf6-kcodecs-devel \
 kf6-kcodecs-doc \
 kf6-kcodecs-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kcodecs-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "730d3c61003726ae8f1e296c87022d645011c23e1653d2dbc986b58ba348eee7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcodecs-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcodecs;unpack=0"
SRC_URI[x86_64_v2_kf6-kcodecs.sha256sum] = "376b41a9738816a00a681d031fba27bb2f86f53f41619f240b77587fafe5e7dc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcodecs-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcodecs-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kcodecs-devel.sha256sum] = "400770fe47bc9ed4cf99beda4632471e1e0e7e4bc95ca3f6b003eb97fd1a4900"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcodecs-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcodecs-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kcodecs-doc.sha256sum] = "4eef8c298c8b754d081a6ea88e5d24f026871d76fcc4b249b25a5318f3ab0146"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcodecs-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcodecs-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kcodecs-html.sha256sum] = "7b9e08036dc1a3f3c8b4ae8d0444ce178f2aab6fd62408f0192dbaf8abf99524"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcodecs-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kcodecs;unpack=0"
SRC_URI[aarch64_kf6-kcodecs.sha256sum] = "ec21ffd4dbb5452e7f10175252e61c87608263a76a9736650a4168da3fabbe4f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcodecs-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kcodecs-devel;unpack=0"
SRC_URI[aarch64_kf6-kcodecs-devel.sha256sum] = "89eee964d813b4a8bc68995b941896d4b270f31d20f7c126e7d2cb5d6572f228"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcodecs-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kcodecs-doc;unpack=0"
SRC_URI[aarch64_kf6-kcodecs-doc.sha256sum] = "7f882439ec439d46da8a678f6d91c5fad3387b022ded9c5335c83e1a15abc53a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcodecs-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kcodecs-html;unpack=0"
SRC_URI[aarch64_kf6-kcodecs-html.sha256sum] = "8a9d0854da848f0f2bafbabc36238f93a6801bb2bcd137791bda47a17ea4a140"

RDEPENDS:kf6-kcodecs = " \
 glibc \
 kf6-filesystem \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kcodecs-devel = " \
 cmake-filesystem \
 kf6-kcodecs \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kcodecs-doc = " \
 "
RDEPENDS:kf6-kcodecs-html = " \
 "
