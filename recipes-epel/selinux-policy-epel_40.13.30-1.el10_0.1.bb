# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "selinux-policy-epel"
PV = "40.13.30"
PR = "1.el10_0.1"
PACKAGES = " \
 selinux-policy-epel \
 selinux-policy-epel-mls \
 selinux-policy-epel-targeted \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/selinux-policy-epel-40.13.30-1.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b41e174f1e326923f82cbce37256ba6cd53ee7a1a2663ceda68d3d4e75f7b166"

URI_x86_64_v2_selinux-policy-epel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/selinux-policy-epel-40.13.30-1.el10_0.1.alma_altarch.1.noarch.rpm;name=x86_64_v2_selinux-policy-epel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy-epel}"
SRC_URI[x86_64_v2_selinux-policy-epel.sha256sum] = "259ddd965a1a37bcabefec34d260a8bedc8f335c78c12802ba21963a3a276f83"

URI_x86_64_v2_selinux-policy-epel-mls = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/selinux-policy-epel-mls-40.13.30-1.el10_0.1.alma_altarch.1.noarch.rpm;name=x86_64_v2_selinux-policy-epel-mls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy-epel-mls}"
SRC_URI[x86_64_v2_selinux-policy-epel-mls.sha256sum] = "59e9050e37a7352c5f713a68b16fcb52f774e1475a3d253133c09f2fde5fbd04"

URI_x86_64_v2_selinux-policy-epel-targeted = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/selinux-policy-epel-targeted-40.13.30-1.el10_0.1.alma_altarch.1.noarch.rpm;name=x86_64_v2_selinux-policy-epel-targeted;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy-epel-targeted}"
SRC_URI[x86_64_v2_selinux-policy-epel-targeted.sha256sum] = "622036ca98e7514859d6c688effbc7c947ca0772bd0c5d2b5252a051191ada31"

URI_aarch64_selinux-policy-epel = "${EPEL_MIRROR}/aarch64/Packages/s/selinux-policy-epel-40.13.30-1.el10_0.1.noarch.rpm;name=aarch64_selinux-policy-epel;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy-epel}"
SRC_URI[aarch64_selinux-policy-epel.sha256sum] = "3eedcc3a93ef17fb34cc0980ade1b843270133382802b64c7f7baff73bf9ab2a"

URI_aarch64_selinux-policy-epel-mls = "${EPEL_MIRROR}/aarch64/Packages/s/selinux-policy-epel-mls-40.13.30-1.el10_0.1.noarch.rpm;name=aarch64_selinux-policy-epel-mls;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy-epel-mls}"
SRC_URI[aarch64_selinux-policy-epel-mls.sha256sum] = "7f23a844dcf6873e6c0377a048f3fd04e70a68b913b3786b526fd8e43fd2a10f"

URI_aarch64_selinux-policy-epel-targeted = "${EPEL_MIRROR}/aarch64/Packages/s/selinux-policy-epel-targeted-40.13.30-1.el10_0.1.noarch.rpm;name=aarch64_selinux-policy-epel-targeted;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy-epel-targeted}"
SRC_URI[aarch64_selinux-policy-epel-targeted.sha256sum] = "3788d28ac5dc403a46eaea7729e2ed6c140571d6a2a3715cf2e73143b97c6dff"

RDEPENDS:selinux-policy-epel = " \
 selinux-policy-epel-mls \
 selinux-policy-epel-targeted \
 "
RDEPENDS:selinux-policy-epel-mls = " \
 bash \
 selinux-policy-mls \
 "
RDEPENDS:selinux-policy-epel-targeted = " \
 bash \
 selinux-policy-targeted \
 "
