# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Image-Sane"
PV = "5"
PR = "23.el10_1"
PACKAGES = " \
 perl-Image-Sane \
 perl-Image-Sane-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Image-Sane-5-23.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb9e454d712fc448f9e5df3358ff0128a5d7abd14e6a4305ec666dd6e58739c2"

URI_x86_64_v2_perl-Image-Sane = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Image-Sane-5-23.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Image-Sane;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Image-Sane}"
SRC_URI[x86_64_v2_perl-Image-Sane.sha256sum] = "4c9dc58d17f20f09fcb1bea4e2bfe16444897412d2681409b130b948210a8112"

URI_x86_64_v2_perl-Image-Sane-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Image-Sane-tests-5-23.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Image-Sane-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Image-Sane-tests}"
SRC_URI[x86_64_v2_perl-Image-Sane-tests.sha256sum] = "b954f98caedbb403ed5e45fa3e8ee1eb4a63b6ed567182899e8b8d0424b39943"

URI_aarch64_perl-Image-Sane = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Image-Sane-5-23.el10_1.aarch64.rpm;name=aarch64_perl-Image-Sane;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Image-Sane}"
SRC_URI[aarch64_perl-Image-Sane.sha256sum] = "62fa09ddc4bf4953ea8ff7a57a6ba9b3c7e501703513bbff62bd395235d73ab6"

URI_aarch64_perl-Image-Sane-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Image-Sane-tests-5-23.el10_1.noarch.rpm;name=aarch64_perl-Image-Sane-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Image-Sane-tests}"
SRC_URI[aarch64_perl-Image-Sane-tests.sha256sum] = "bc660beea93d803e287b10e0119792218605270c2044254a484e21343822e608"

RDEPENDS:perl-Image-Sane = " \
 glibc \
 perl-Exception-Class \
 perl-Exporter \
 perl-Readonly \
 perl-base \
 perl-libs \
 sane-backends-libs \
 "
RDEPENDS:perl-Image-Sane-tests = " \
 ImageMagick \
 bash \
 perl-English \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-IO \
 perl-Image-Sane \
 perl-Readonly \
 perl-Test-Harness \
 perl-Test-Requires \
 perl-Test-Simple \
 perl-Try-Tiny \
 perl-interpreter \
 perl-libs \
 perl-sigtrap \
 sane-backends \
 sane-backends-drivers-scanners \
 virtual/coreutils \
 "
