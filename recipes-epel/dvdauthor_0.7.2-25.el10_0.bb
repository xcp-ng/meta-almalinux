# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dvdauthor"
PV = "0.7.2"
PR = "25.el10_0"
PACKAGES = " \
 dvdauthor \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dvdauthor-0.7.2-25.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f4a8d6d16e20317e16b2f473e433118efe154eff4ff12180ff1b81f08ad9c90"

URI_x86_64_v2_dvdauthor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dvdauthor-0.7.2-25.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dvdauthor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dvdauthor}"
SRC_URI[x86_64_v2_dvdauthor.sha256sum] = "70db36da868c96b678ebf0bb144e49e0c9992470c5f857ddf7c6bd5b0ba7f76d"

URI_aarch64_dvdauthor = "${EPEL_MIRROR}/aarch64/Packages/d/dvdauthor-0.7.2-25.el10_0.aarch64.rpm;name=aarch64_dvdauthor;unpack=0"
SRC_URI:append = " ${URI_aarch64_dvdauthor}"
SRC_URI[aarch64_dvdauthor.sha256sum] = "ca5d5c6459781b527afb72f9f72dfe343d9b86aad4bf9ac27aca1a09c1669427"

RDEPENDS:dvdauthor = " \
 ImageMagick-libs \
 bash \
 fontconfig \
 freetype \
 fribidi \
 glibc \
 libdvdread \
 libpng \
 libxml2 \
 "
