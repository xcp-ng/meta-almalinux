# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num-integer"
PV = "0.1.46"
PR = "4.el10_1"
PACKAGES = " \
 rust-num-integer+default-devel \
 rust-num-integer+i128-devel \
 rust-num-integer+std-devel \
 rust-num-integer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-num-integer-0.1.46-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4fb09a205ec99523573d08bdee3f7ea50cf5b58fb6ed54bd0ccae535cac26422"

URI_x86_64_v2_rust-num-integer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-integer+default-devel-0.1.46-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-integer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-integer+default-devel}"
SRC_URI[x86_64_v2_rust-num-integer+default-devel.sha256sum] = "5c523d4706d4ba3e08676b493401d9dcfaf0fa6f4e58b901a7733637764703b2"

URI_x86_64_v2_rust-num-integer+i128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-integer+i128-devel-0.1.46-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-integer+i128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-integer+i128-devel}"
SRC_URI[x86_64_v2_rust-num-integer+i128-devel.sha256sum] = "76459d928ed01b3626f3f837d9a079cfcce6808d2aa7d2f8f460e463b7e5dda3"

URI_x86_64_v2_rust-num-integer+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-integer+std-devel-0.1.46-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-integer+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-integer+std-devel}"
SRC_URI[x86_64_v2_rust-num-integer+std-devel.sha256sum] = "747ea9d3d6c3e9a1e9ab38240393151c0638ec5bb89ed2ffd1664c5d59798761"

URI_x86_64_v2_rust-num-integer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-integer-devel-0.1.46-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-integer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-integer-devel}"
SRC_URI[x86_64_v2_rust-num-integer-devel.sha256sum] = "c3dd8b4393eea24002a8e003090a87d5e5f8b146164f39830eb5feb7d16abac9"

URI_aarch64_rust-num-integer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-integer+default-devel-0.1.46-4.el10_1.noarch.rpm;name=aarch64_rust-num-integer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-integer+default-devel}"
SRC_URI[aarch64_rust-num-integer+default-devel.sha256sum] = "3f3a40eae18f49067ec4d04a6e708bb1d4d3055c0e2d42e624a1e6c1f42acf59"

URI_aarch64_rust-num-integer+i128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-integer+i128-devel-0.1.46-4.el10_1.noarch.rpm;name=aarch64_rust-num-integer+i128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-integer+i128-devel}"
SRC_URI[aarch64_rust-num-integer+i128-devel.sha256sum] = "3a2353c45e40bf174b6d721b3eb61010d56ac8721129dcc6bcae6fd2d6f226e9"

URI_aarch64_rust-num-integer+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-integer+std-devel-0.1.46-4.el10_1.noarch.rpm;name=aarch64_rust-num-integer+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-integer+std-devel}"
SRC_URI[aarch64_rust-num-integer+std-devel.sha256sum] = "e5806c754a9571f61375677cb9f2d5796c10f50b4adfa1a7445b382f3c4a01d6"

URI_aarch64_rust-num-integer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-integer-devel-0.1.46-4.el10_1.noarch.rpm;name=aarch64_rust-num-integer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-integer-devel}"
SRC_URI[aarch64_rust-num-integer-devel.sha256sum] = "be42e5b718ac6e3f959a60b595ad9230df6acc0329be4bd1575f56250f4de21d"

RDEPENDS:rust-num-integer+default-devel = " \
 cargo \
 rust-num-integer+std-devel \
 rust-num-integer-devel \
 "
RDEPENDS:rust-num-integer+i128-devel = " \
 cargo \
 rust-num-integer-devel \
 "
RDEPENDS:rust-num-integer+std-devel = " \
 cargo \
 rust-num-integer-devel \
 rust-num-traits+std-devel \
 "
RDEPENDS:rust-num-integer-devel = " \
 cargo \
 rust \
 rust-num-traits+i128-devel \
 rust-num-traits-devel \
 "
