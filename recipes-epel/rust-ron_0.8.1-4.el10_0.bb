# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ron"
PV = "0.8.1"
PR = "4.el10_0"
PACKAGES = " \
 rust-ron+default-devel \
 rust-ron+indexmap-devel \
 rust-ron+integer128-devel \
 rust-ron-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ron-0.8.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ee5fa35a388c28e08ce3a99dacf15b962ffefaf869f594b22540dab7c9927f2"

URI_x86_64_v2_rust-ron+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ron+default-devel-0.8.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ron+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ron+default-devel}"
SRC_URI[x86_64_v2_rust-ron+default-devel.sha256sum] = "385349c70c312b85aebe3d29d4d1684cb113c95b1c2c09d8778d2543b68c79b8"

URI_x86_64_v2_rust-ron+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ron+indexmap-devel-0.8.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ron+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ron+indexmap-devel}"
SRC_URI[x86_64_v2_rust-ron+indexmap-devel.sha256sum] = "f510410d0a55edbe6bc9106d12d717bb2898295431b37676c136e162e5e88a49"

URI_x86_64_v2_rust-ron+integer128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ron+integer128-devel-0.8.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ron+integer128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ron+integer128-devel}"
SRC_URI[x86_64_v2_rust-ron+integer128-devel.sha256sum] = "30b2667a304a4a4248dedef1efbadaf7427316099a46d58427b83a990203a938"

URI_x86_64_v2_rust-ron-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ron-devel-0.8.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ron-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ron-devel}"
SRC_URI[x86_64_v2_rust-ron-devel.sha256sum] = "1919a90e76af451b4d08c926f7858d2ada9feff45c82f40bef8b6401476cf838"

URI_aarch64_rust-ron+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ron+default-devel-0.8.1-4.el10_0.noarch.rpm;name=aarch64_rust-ron+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ron+default-devel}"
SRC_URI[aarch64_rust-ron+default-devel.sha256sum] = "a5f3d72dff32f477647bddde72f3db362ffd39f897667d7a00a019bbaeef9365"

URI_aarch64_rust-ron+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ron+indexmap-devel-0.8.1-4.el10_0.noarch.rpm;name=aarch64_rust-ron+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ron+indexmap-devel}"
SRC_URI[aarch64_rust-ron+indexmap-devel.sha256sum] = "425df2cdf07fefe93bb958c2c8740020a04cc2dd99ac871459a15e81365dba9c"

URI_aarch64_rust-ron+integer128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ron+integer128-devel-0.8.1-4.el10_0.noarch.rpm;name=aarch64_rust-ron+integer128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ron+integer128-devel}"
SRC_URI[aarch64_rust-ron+integer128-devel.sha256sum] = "84a34f5b36e081d3c3bd8a139827346a7a494ea4a11d8ae8425da5880639b268"

URI_aarch64_rust-ron-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ron-devel-0.8.1-4.el10_0.noarch.rpm;name=aarch64_rust-ron-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ron-devel}"
SRC_URI[aarch64_rust-ron-devel.sha256sum] = "80e9fc93bf0b8a48fc650ddb8c30abbb2cd0768fa0676976f3d849265339c3f9"

RDEPENDS:rust-ron+default-devel = " \
 cargo \
 rust-ron-devel \
 "
RDEPENDS:rust-ron+indexmap-devel = " \
 cargo \
 rust-indexmap+default-devel \
 rust-indexmap+serde-devel \
 rust-ron-devel \
 "
RDEPENDS:rust-ron+integer128-devel = " \
 cargo \
 rust-ron-devel \
 "
RDEPENDS:rust-ron-devel = " \
 cargo \
 rust \
 rust-base64+default-devel \
 rust-bitflags+default-devel \
 rust-bitflags+serde-devel \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 "
