# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "elfutils"
PV = "0.194"
PR = "2.el10_2"
PACKAGES = " \
 elfutils \
 elfutils-debuginfod \
 elfutils-debuginfod-client \
 elfutils-debuginfod-client-devel \
 elfutils-default-yama-scope \
 elfutils-devel \
 elfutils-libelf \
 elfutils-libelf-devel \
 elfutils-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/elfutils-0.194-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "def03f1968a9fee4044a525674f35c41dcd3742e3e5dad06f4a52d1b63f361f3"

URI_x86_64_v2_elfutils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/elfutils-0.194-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_elfutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils}"
SRC_URI[x86_64_v2_elfutils.sha256sum] = "d702c4997dbdc50d7534da4cc7809646ff65b524ae5d24f9e2dee787332a4b42"

URI_x86_64_v2_elfutils-debuginfod = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/elfutils-debuginfod-0.194-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_elfutils-debuginfod;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils-debuginfod}"
SRC_URI[x86_64_v2_elfutils-debuginfod.sha256sum] = "6cfae2c459dcd6e1384c436cc91e905ad666ed601f9d99f5bfc6667e9a7af7cc"

URI_x86_64_v2_elfutils-debuginfod-client = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/elfutils-debuginfod-client-0.194-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_elfutils-debuginfod-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils-debuginfod-client}"
SRC_URI[x86_64_v2_elfutils-debuginfod-client.sha256sum] = "e841e11ebbdff5f450a146f7f6e7da312aaa6b555c6a35b38888fb0f8b39df7c"

URI_x86_64_v2_elfutils-debuginfod-client-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/elfutils-debuginfod-client-devel-0.194-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_elfutils-debuginfod-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils-debuginfod-client-devel}"
SRC_URI[x86_64_v2_elfutils-debuginfod-client-devel.sha256sum] = "a6f78324d8e1396fb951dd1038d3fe89493f2eddf11f266e36a30c2c788f4a73"

URI_x86_64_v2_elfutils-default-yama-scope = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/elfutils-default-yama-scope-0.194-2.el10_2.noarch.rpm;name=x86_64_v2_elfutils-default-yama-scope;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils-default-yama-scope}"
SRC_URI[x86_64_v2_elfutils-default-yama-scope.sha256sum] = "d997232a0cd9c450cc41fcdc203ee4c1ee709806259d5ba1b86c86904b37f744"

URI_x86_64_v2_elfutils-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/elfutils-devel-0.194-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_elfutils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils-devel}"
SRC_URI[x86_64_v2_elfutils-devel.sha256sum] = "b8c8b3d7cd96be7fdd03d4d33cd168cf5721b30196771543212086849df88d97"

URI_x86_64_v2_elfutils-libelf = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/elfutils-libelf-0.194-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_elfutils-libelf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils-libelf}"
SRC_URI[x86_64_v2_elfutils-libelf.sha256sum] = "2f8b359460f94f740dd8c61cd6bd11988c2a69a48e059978f3184299bb186880"

URI_x86_64_v2_elfutils-libelf-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/elfutils-libelf-devel-0.194-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_elfutils-libelf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils-libelf-devel}"
SRC_URI[x86_64_v2_elfutils-libelf-devel.sha256sum] = "3268e792b8c179305c6520025e6160a765d003af72205ae8eb7507924579bc3e"

URI_x86_64_v2_elfutils-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/elfutils-libs-0.194-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_elfutils-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils-libs}"
SRC_URI[x86_64_v2_elfutils-libs.sha256sum] = "6d21c45f31c894e9db514e8f88f8da219250368e73e073fe414e1f028e1270f5"

URI_aarch64_elfutils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/elfutils-0.194-2.el10_2.aarch64.rpm;name=aarch64_elfutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils}"
SRC_URI[aarch64_elfutils.sha256sum] = "2918038981a436ea4e3ea7f2b562d961ff57d74daf325c63c6727032ec4452a1"

URI_aarch64_elfutils-debuginfod = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/elfutils-debuginfod-0.194-2.el10_2.aarch64.rpm;name=aarch64_elfutils-debuginfod;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils-debuginfod}"
SRC_URI[aarch64_elfutils-debuginfod.sha256sum] = "a85948a5a73293dc2af7804e4f3cdf3822a126e82580e3e65b473f621b68de57"

URI_aarch64_elfutils-debuginfod-client = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/elfutils-debuginfod-client-0.194-2.el10_2.aarch64.rpm;name=aarch64_elfutils-debuginfod-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils-debuginfod-client}"
SRC_URI[aarch64_elfutils-debuginfod-client.sha256sum] = "4e73f6e424b3ddb69d00237d4f91ac23a5ef40df62f7ad1e2ec6011b9a7a2b6d"

URI_aarch64_elfutils-debuginfod-client-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/elfutils-debuginfod-client-devel-0.194-2.el10_2.aarch64.rpm;name=aarch64_elfutils-debuginfod-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils-debuginfod-client-devel}"
SRC_URI[aarch64_elfutils-debuginfod-client-devel.sha256sum] = "eb3f91fcbc425636208e3404fb676bc45b1592bb17624f5162d8618b54628ee2"

URI_aarch64_elfutils-default-yama-scope = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/elfutils-default-yama-scope-0.194-2.el10_2.noarch.rpm;name=aarch64_elfutils-default-yama-scope;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils-default-yama-scope}"
SRC_URI[aarch64_elfutils-default-yama-scope.sha256sum] = "d997232a0cd9c450cc41fcdc203ee4c1ee709806259d5ba1b86c86904b37f744"

URI_aarch64_elfutils-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/elfutils-devel-0.194-2.el10_2.aarch64.rpm;name=aarch64_elfutils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils-devel}"
SRC_URI[aarch64_elfutils-devel.sha256sum] = "6a4c2dccbd039171f9d867b4b44447fba17bbf42d285e5ef451d5a4cbf57be2d"

URI_aarch64_elfutils-libelf = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/elfutils-libelf-0.194-2.el10_2.aarch64.rpm;name=aarch64_elfutils-libelf;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils-libelf}"
SRC_URI[aarch64_elfutils-libelf.sha256sum] = "ae4e3b143fa86f87a87db1302e3329ded5454cfda24a44b957e126dae8d0494b"

URI_aarch64_elfutils-libelf-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/elfutils-libelf-devel-0.194-2.el10_2.aarch64.rpm;name=aarch64_elfutils-libelf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils-libelf-devel}"
SRC_URI[aarch64_elfutils-libelf-devel.sha256sum] = "e9feaae005b9e193991f162f09a95d2855a718dfbf783d3986099ea4c09d56bc"

URI_aarch64_elfutils-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/elfutils-libs-0.194-2.el10_2.aarch64.rpm;name=aarch64_elfutils-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils-libs}"
SRC_URI[aarch64_elfutils-libs.sha256sum] = "f6219d4afc8891a7b8f7ae34cd68005f343b8aaa12c7408607bcbea9e6f7959f"

RDEPENDS:elfutils = " \
 bash \
 elfutils-debuginfod-client \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libarchive \
 libgcc \
 libstdc++ \
 "
RDEPENDS:elfutils-debuginfod = " \
 bash \
 bsdtar \
 elfutils-debuginfod-client \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 json-c \
 libarchive \
 libgcc \
 libmicrohttpd \
 libstdc++ \
 rpm-libs \
 shadow-utils \
 sqlite-libs \
 systemd \
 xz-libs \
 "
RDEPENDS:elfutils-debuginfod-client = " \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 json-c \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:elfutils-debuginfod-client-devel = " \
 elfutils-debuginfod-client \
 pkgconf-pkg-config \
 "
RDEPENDS:elfutils-default-yama-scope = " \
 bash \
 "
RDEPENDS:elfutils-devel = " \
 elfutils-libelf-devel \
 elfutils-libs \
 libzstd-devel \
 pkgconf-pkg-config \
 xz-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:elfutils-libelf = " \
 glibc \
 libzstd \
 zlib-ng-compat \
 "
RDEPENDS:elfutils-libelf-devel = " \
 elfutils-libelf \
 libzstd-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:elfutils-libs = " \
 bzip2-libs \
 elfutils-default-yama-scope \
 elfutils-libelf \
 glibc \
 libzstd \
 xz-libs \
 zlib-ng-compat \
 "
