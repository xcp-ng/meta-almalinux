# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtsvg"
PV = "6.9.1"
PR = "2.el10_1.2"
PACKAGES = " \
 qt6-qtsvg \
 qt6-qtsvg-devel \
 qt6-qtsvg-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtsvg-6.9.1-2.el10_1.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "612111ca19029b561d973d240dc2e01d7375abb2fbccab82fd7712376cd4904d"

URI_x86_64_v2_qt6-qtsvg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtsvg-6.9.1-2.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_qt6-qtsvg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtsvg}"
SRC_URI[x86_64_v2_qt6-qtsvg.sha256sum] = "5daf77e5de0ef6fce023b4235f09e02d2345616664548db1be34d3d7f0823702"

URI_x86_64_v2_qt6-qtsvg-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtsvg-devel-6.9.1-2.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_qt6-qtsvg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtsvg-devel}"
SRC_URI[x86_64_v2_qt6-qtsvg-devel.sha256sum] = "85081b54754887998e8ece41fa077f017c07813e3a8e09aa88528bb0f8d93235"

URI_x86_64_v2_qt6-qtsvg-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtsvg-examples-6.9.1-2.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_qt6-qtsvg-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtsvg-examples}"
SRC_URI[x86_64_v2_qt6-qtsvg-examples.sha256sum] = "24c0cb9be94f1af1e3effcbb922063f497b4f35a0e07d27ff6ce38117220d5b6"

URI_aarch64_qt6-qtsvg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtsvg-6.9.1-2.el10_1.2.aarch64.rpm;name=aarch64_qt6-qtsvg;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtsvg}"
SRC_URI[aarch64_qt6-qtsvg.sha256sum] = "bc3d2360216d69eb3edaeede9429cde0d513ccbf905e319e9427a702966ddb04"

URI_aarch64_qt6-qtsvg-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtsvg-devel-6.9.1-2.el10_1.2.aarch64.rpm;name=aarch64_qt6-qtsvg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtsvg-devel}"
SRC_URI[aarch64_qt6-qtsvg-devel.sha256sum] = "4ad069325103e97092e2aa6c269afb15367dcb0f3bfa92495d2dd31805e2e5cd"

URI_aarch64_qt6-qtsvg-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtsvg-examples-6.9.1-2.el10_1.2.aarch64.rpm;name=aarch64_qt6-qtsvg-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtsvg-examples}"
SRC_URI[aarch64_qt6-qtsvg-examples.sha256sum] = "ef573249b8cfb0fe734f05b3e8b70df421fa350c220ee0a7ba3ef60f9092b61e"

RDEPENDS:qt6-qtsvg = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 zlib-ng-compat \
 "
RDEPENDS:qt6-qtsvg-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtsvg \
 qt6-qtsvg-devel \
 "
RDEPENDS:qt6-qtsvg-examples = " \
 qt6-qtsvg \
 "
