# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gpm"
PV = "1.20.7"
PR = "48.el10_0"
PACKAGES = " \
 gpm \
 gpm-devel \
 gpm-libs \
 gpm-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gpm-1.20.7-48.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69b59c4a30118f8c8b1f87e32285e3507c660e2f45b2176518df6f998c7161ca"

URI_x86_64_v2_gpm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gpm-1.20.7-48.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpm}"
SRC_URI[x86_64_v2_gpm.sha256sum] = "6d5b074d0b0fb963885ec881778e5d0953b3f5dcb8a659d2fb3de7ab803db9a5"

URI_x86_64_v2_gpm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gpm-devel-1.20.7-48.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gpm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpm-devel}"
SRC_URI[x86_64_v2_gpm-devel.sha256sum] = "a5b4abef9295d7a977e7a9148af60b7b64326f8373cfbefd5186bc3030946528"

URI_x86_64_v2_gpm-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gpm-libs-1.20.7-48.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gpm-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpm-libs}"
SRC_URI[x86_64_v2_gpm-libs.sha256sum] = "6e7ed0473e0067ab382cfddbae3e29987e10b7380c2dc87298c411353e948ce6"

URI_x86_64_v2_gpm-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gpm-static-1.20.7-48.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gpm-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpm-static}"
SRC_URI[x86_64_v2_gpm-static.sha256sum] = "ba25c285e60c387959708fdbc7c43d8ea07dd1ad5237bf81a3d20ee4b8705cb2"

URI_aarch64_gpm = "${EPEL_MIRROR}/aarch64/Packages/g/gpm-1.20.7-48.el10_0.aarch64.rpm;name=aarch64_gpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpm}"
SRC_URI[aarch64_gpm.sha256sum] = "db3f7cff76d54c0ed5a4e15618185f86e17b9ee88aaa6e2af64b7b3971e27164"

URI_aarch64_gpm-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gpm-devel-1.20.7-48.el10_0.aarch64.rpm;name=aarch64_gpm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpm-devel}"
SRC_URI[aarch64_gpm-devel.sha256sum] = "38f5ff4d01c366e4118d0dbbcbe4f194caf8febcad3d6dc0ce0ad5f3c4bdc29b"

URI_aarch64_gpm-libs = "${EPEL_MIRROR}/aarch64/Packages/g/gpm-libs-1.20.7-48.el10_0.aarch64.rpm;name=aarch64_gpm-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpm-libs}"
SRC_URI[aarch64_gpm-libs.sha256sum] = "fe19fad9ed0989fc8473f2d8f9ec031748713b9f067b132ffb2aac8abd08c62c"

URI_aarch64_gpm-static = "${EPEL_MIRROR}/aarch64/Packages/g/gpm-static-1.20.7-48.el10_0.aarch64.rpm;name=aarch64_gpm-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpm-static}"
SRC_URI[aarch64_gpm-static.sha256sum] = "44842bca37d027f8b7a984970157bfd272bd0a1d92024ec7c3805339b429544c"

RDEPENDS:gpm = " \
 bash \
 glibc \
 gpm-libs \
 info \
 linuxconsoletools \
 "
RDEPENDS:gpm-devel = " \
 gpm \
 gpm-libs \
 "
RDEPENDS:gpm-libs = " \
 glibc \
 "
RDEPENDS:gpm-static = " \
 gpm \
 "
