# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-executor"
PV = "0.3.33"
PR = "1.el10_3"
PACKAGES = " \
 rust-futures-executor+default-devel \
 rust-futures-executor+std-devel \
 rust-futures-executor+thread-pool-devel \
 rust-futures-executor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-executor-0.3.33-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e700cce7040699feb67e3e83808f04da36e1a0bb462877bf43becedc73c93a25"

URI_x86_64_v2_rust-futures-executor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-executor+default-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-executor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-executor+default-devel}"
SRC_URI[x86_64_v2_rust-futures-executor+default-devel.sha256sum] = "fcf21864f3bed49806ca86dc1bbe5e1f9874102b7a1980147e0833d78dea1c5f"

URI_x86_64_v2_rust-futures-executor+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-executor+std-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-executor+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-executor+std-devel}"
SRC_URI[x86_64_v2_rust-futures-executor+std-devel.sha256sum] = "ca6754854101fabe60fd0cd878a0953ad41985b38531f8430dbf1b5391df8e13"

URI_x86_64_v2_rust-futures-executor+thread-pool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-executor+thread-pool-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-executor+thread-pool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-executor+thread-pool-devel}"
SRC_URI[x86_64_v2_rust-futures-executor+thread-pool-devel.sha256sum] = "bb0802bb5910c01aa85a8db7326ac128477860fc535e4f257b67f0ff9645ff46"

URI_x86_64_v2_rust-futures-executor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-executor-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-executor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-executor-devel}"
SRC_URI[x86_64_v2_rust-futures-executor-devel.sha256sum] = "143f0dc445623c4a85b87650d1f4fe09fae153aa63c78aad2b7a27107745aa70"

URI_aarch64_rust-futures-executor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-executor+default-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-executor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-executor+default-devel}"
SRC_URI[aarch64_rust-futures-executor+default-devel.sha256sum] = "d9ed81bdfa951cb5fb28466ea86270896ad98f7d5fdb656b6f8cced7236b569c"

URI_aarch64_rust-futures-executor+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-executor+std-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-executor+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-executor+std-devel}"
SRC_URI[aarch64_rust-futures-executor+std-devel.sha256sum] = "4e7eae38b2682c956dbc0ea138313c161f93648cbc85d60aa892dcd50a8b5f6a"

URI_aarch64_rust-futures-executor+thread-pool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-executor+thread-pool-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-executor+thread-pool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-executor+thread-pool-devel}"
SRC_URI[aarch64_rust-futures-executor+thread-pool-devel.sha256sum] = "440e49b73247114834ce476a06618a83892d0ffd7c6853c1eaee9e8a9cfac045"

URI_aarch64_rust-futures-executor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-executor-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-executor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-executor-devel}"
SRC_URI[aarch64_rust-futures-executor-devel.sha256sum] = "2c962142347835d64e1b96afc7d76f9343f2b6acb83e7fa9a99f3d7f57012a7b"

RDEPENDS:rust-futures-executor+default-devel = " \
 cargo \
 rust-futures-executor+std-devel \
 rust-futures-executor-devel \
 "
RDEPENDS:rust-futures-executor+std-devel = " \
 cargo \
 rust-futures-core+std-devel \
 rust-futures-executor-devel \
 rust-futures-task+std-devel \
 rust-futures-util+std-devel \
 "
RDEPENDS:rust-futures-executor+thread-pool-devel = " \
 cargo \
 rust-futures-executor+std-devel \
 rust-futures-executor-devel \
 "
RDEPENDS:rust-futures-executor-devel = " \
 cargo \
 rust \
 rust-futures-core-devel \
 rust-futures-task-devel \
 rust-futures-util-devel \
 "
