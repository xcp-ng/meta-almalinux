# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-trybuild"
PV = "1.0.120"
PR = "1.el10_3"
PACKAGES = " \
 rust-trybuild+default-devel \
 rust-trybuild+diff-devel \
 rust-trybuild-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-trybuild-1.0.120-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf10f4c2994f2f08b904bad5cdd381945921cb21215f8df90ba7f3c18c2c8fbb"

URI_x86_64_v2_rust-trybuild+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trybuild+default-devel-1.0.120-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trybuild+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trybuild+default-devel}"
SRC_URI[x86_64_v2_rust-trybuild+default-devel.sha256sum] = "3cd6c72c3a029fbee6bb324a2867a4e88d9ab6981421439d056f8f3736703760"

URI_x86_64_v2_rust-trybuild+diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trybuild+diff-devel-1.0.120-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trybuild+diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trybuild+diff-devel}"
SRC_URI[x86_64_v2_rust-trybuild+diff-devel.sha256sum] = "9d1b6321bed8531c9d9648e6c650ec4dcf90a867c651550ad7e999e755343e03"

URI_x86_64_v2_rust-trybuild-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trybuild-devel-1.0.120-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trybuild-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trybuild-devel}"
SRC_URI[x86_64_v2_rust-trybuild-devel.sha256sum] = "94933f3ace5e499114aed36a308123bb7a69856654fdfb4f9fdb45c72e926ef0"

URI_aarch64_rust-trybuild+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trybuild+default-devel-1.0.120-1.el10_3.noarch.rpm;name=aarch64_rust-trybuild+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trybuild+default-devel}"
SRC_URI[aarch64_rust-trybuild+default-devel.sha256sum] = "969afc4572dbd13a4a6e9d0f64eb21e12d3129448fb48e8c6386f6aa6fd262a8"

URI_aarch64_rust-trybuild+diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trybuild+diff-devel-1.0.120-1.el10_3.noarch.rpm;name=aarch64_rust-trybuild+diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trybuild+diff-devel}"
SRC_URI[aarch64_rust-trybuild+diff-devel.sha256sum] = "2430fe0541a18d2da39ee2836467afbea77fd3ecd9fc94e6885031c015729139"

URI_aarch64_rust-trybuild-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trybuild-devel-1.0.120-1.el10_3.noarch.rpm;name=aarch64_rust-trybuild-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trybuild-devel}"
SRC_URI[aarch64_rust-trybuild-devel.sha256sum] = "73f1e3a7c65e1f87aa73ce8fedcc3004dec52631dc5146d81a570e34a8a12faf"

RDEPENDS:rust-trybuild+default-devel = " \
 cargo \
 rust-trybuild-devel \
 "
RDEPENDS:rust-trybuild+diff-devel = " \
 cargo \
 rust-dissimilar+default-devel \
 rust-trybuild-devel \
 "
RDEPENDS:rust-trybuild-devel = " \
 cargo \
 rust \
 rust-glob+default-devel \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 rust-serde_json+default-devel \
 rust-target-triple+default-devel \
 rust-termcolor+default-devel \
 rust-toml+default-devel \
 "
