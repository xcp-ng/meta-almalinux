# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-channel"
PV = "0.3.34"
PR = "1.el10_3"
PACKAGES = " \
 rust-futures-channel+alloc-devel \
 rust-futures-channel+cfg-target-has-atomic-devel \
 rust-futures-channel+default-devel \
 rust-futures-channel+futures-sink-devel \
 rust-futures-channel+sink-devel \
 rust-futures-channel+std-devel \
 rust-futures-channel+unstable-devel \
 rust-futures-channel-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-futures-channel-0.3.34-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "33634c18f8b3480e7f175be0cea2378d281e0ed69b2b85f03a2c65ece8361a42"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-channel+alloc-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-channel+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-channel+alloc-devel.sha256sum] = "76628e6bd38b30e1654a0c8b16d65d1996d8689718b73744cc6b54611cfddfa2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-channel+cfg-target-has-atomic-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-channel+cfg-target-has-atomic-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-channel+cfg-target-has-atomic-devel.sha256sum] = "b15ff0263590f4bca17034e4028f1b721bf14c9cbc97be6476fde0809afbed7d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-channel+default-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-channel+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-channel+default-devel.sha256sum] = "35a43301a14ab422073c4386f45500f06c5b226454f71f4e4303ad373204ec44"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-channel+futures-sink-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-channel+futures-sink-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-channel+futures-sink-devel.sha256sum] = "7f591c5c1d5bd1142f654f71d1947f8629e90c29e605d676dfbb60ad4d6f1161"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-channel+sink-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-channel+sink-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-channel+sink-devel.sha256sum] = "a446b86ffb60f9c1f300d51b94b45ead697d1ac2328beacbeeb468d3fdcbc4a7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-channel+std-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-channel+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-channel+std-devel.sha256sum] = "bafbe34b455fb3caeffb30f36352f356017aaa973941ca60ea0cc3dc87f9b53e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-channel+unstable-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-channel+unstable-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-channel+unstable-devel.sha256sum] = "ac1b3a35c8bc4aa3c3fc2e4e8a2b075d9f0db66f4339ad18197d9ede9418374e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-channel-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-channel-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-channel-devel.sha256sum] = "ff1198ac4d026b24eddfebe67cb8d4ff98b503aa335e019da623249244f17a16"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-channel+alloc-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-channel+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-futures-channel+alloc-devel.sha256sum] = "5233ff27e3f7d313bde05285be68e85045d7ac3477e3e80d60468403d4318050"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-channel+cfg-target-has-atomic-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-channel+cfg-target-has-atomic-devel;unpack=0"
SRC_URI[aarch64_rust-futures-channel+cfg-target-has-atomic-devel.sha256sum] = "2fa15fddd57d54822ce29eae9abf0666231bce5dad61e971a4db1b7ff8667241"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-channel+default-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-channel+default-devel;unpack=0"
SRC_URI[aarch64_rust-futures-channel+default-devel.sha256sum] = "95298d9963a8697c0eb8d15721bcf1db2c3ab7cecc4296e697e3a961fbc0cf02"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-channel+futures-sink-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-channel+futures-sink-devel;unpack=0"
SRC_URI[aarch64_rust-futures-channel+futures-sink-devel.sha256sum] = "014827b862a6518c404025160c06e96d97e8f5bd9de8f6f3abc758d920e7956f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-channel+sink-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-channel+sink-devel;unpack=0"
SRC_URI[aarch64_rust-futures-channel+sink-devel.sha256sum] = "93e6ba48dd49d7b5db5887d24253aafa54275993dc9ffa25f417ee79805674b3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-channel+std-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-channel+std-devel;unpack=0"
SRC_URI[aarch64_rust-futures-channel+std-devel.sha256sum] = "1e6a11f29d02a9981ecb3d844008632ca23d156de5f435257098fc6186840bae"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-channel+unstable-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-channel+unstable-devel;unpack=0"
SRC_URI[aarch64_rust-futures-channel+unstable-devel.sha256sum] = "eabfc8f384ad9722ebf82b0fec0f844936b17103dcda24346e886a72145bfb71"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-channel-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-channel-devel;unpack=0"
SRC_URI[aarch64_rust-futures-channel-devel.sha256sum] = "818d185ebee6204ecf931abe0594f48c477f40216ab82c6448eaa3591843f24a"

RDEPENDS:rust-futures-channel+alloc-devel = " \
 cargo \
 rust-futures-channel-devel \
 rust-futures-core+alloc-devel \
 "
RDEPENDS:rust-futures-channel+cfg-target-has-atomic-devel = " \
 cargo \
 rust-futures-channel-devel \
 "
RDEPENDS:rust-futures-channel+default-devel = " \
 cargo \
 rust-futures-channel+std-devel \
 rust-futures-channel-devel \
 "
RDEPENDS:rust-futures-channel+futures-sink-devel = " \
 cargo \
 rust-futures-channel-devel \
 rust-futures-sink-devel \
 "
RDEPENDS:rust-futures-channel+sink-devel = " \
 cargo \
 rust-futures-channel+futures-sink-devel \
 rust-futures-channel-devel \
 "
RDEPENDS:rust-futures-channel+std-devel = " \
 cargo \
 rust-futures-channel+alloc-devel \
 rust-futures-channel-devel \
 rust-futures-core+std-devel \
 "
RDEPENDS:rust-futures-channel+unstable-devel = " \
 cargo \
 rust-futures-channel-devel \
 "
RDEPENDS:rust-futures-channel-devel = " \
 cargo \
 rust \
 rust-futures-core-devel \
 "
