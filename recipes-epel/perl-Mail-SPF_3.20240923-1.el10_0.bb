# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Mail-SPF"
PV = "3.20240923"
PR = "1.el10_0"
PACKAGES = " \
 perl-Mail-SPF \
 perl-Mail-SPF-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Mail-SPF-3.20240923-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4d1e11b0bf8be57baadb72da941cc6b3ec6472eb7b3a0ed1643cdf325b93dbd6"

URI_x86_64_v2_perl-Mail-SPF = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Mail-SPF-3.20240923-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Mail-SPF;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Mail-SPF}"
SRC_URI[x86_64_v2_perl-Mail-SPF.sha256sum] = "0c2189fbd513b9f6f23880d2021c5c487d2458bda819dca97187cbd5cfe48f5c"

URI_x86_64_v2_perl-Mail-SPF-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Mail-SPF-tests-3.20240923-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Mail-SPF-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Mail-SPF-tests}"
SRC_URI[x86_64_v2_perl-Mail-SPF-tests.sha256sum] = "bc009a38556768718346e6ac06de8da55c98aad22025ea4a57b799e847cb679d"

URI_aarch64_perl-Mail-SPF = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Mail-SPF-3.20240923-1.el10_0.noarch.rpm;name=aarch64_perl-Mail-SPF;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Mail-SPF}"
SRC_URI[aarch64_perl-Mail-SPF.sha256sum] = "81280ec7866da474be5a95a76d222533cce75c4720aa59e1f91df5a6bea4b63a"

URI_aarch64_perl-Mail-SPF-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Mail-SPF-tests-3.20240923-1.el10_0.noarch.rpm;name=aarch64_perl-Mail-SPF-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Mail-SPF-tests}"
SRC_URI[aarch64_perl-Mail-SPF-tests.sha256sum] = "1ec38ce62571bc2a975c97e0febad4b1e9858b4a57f54302da2a9a793161858a"

RDEPENDS:perl-Mail-SPF = " \
 alternatives \
 bash \
 perl-Error \
 perl-Getopt-Long \
 perl-IO \
 perl-Mail-SPF \
 perl-Net-DNS \
 perl-NetAddr-IP \
 perl-Socket \
 perl-Sys-Hostname \
 perl-URI \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-Mail-SPF-tests = " \
 bash \
 perl-Error \
 perl-Mail-SPF \
 perl-Net-DNS \
 perl-Net-DNS-Resolver-Programmable \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-constant \
 perl-interpreter \
 perl-libs \
 "
