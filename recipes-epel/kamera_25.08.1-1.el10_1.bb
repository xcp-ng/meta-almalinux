# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kamera"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kamera \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kamera-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff826e6d9dba74af2cbb3a57fb29b16a088c5d9913fea7ee4b90c3a12b7c6ca7"

URI_x86_64_v2_kamera = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kamera-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kamera;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kamera}"
SRC_URI[x86_64_v2_kamera.sha256sum] = "529bb49c327dc79da3d36f407c70a4a579099ab6f09686c43212efda11558521"

URI_aarch64_kamera = "${EPEL_MIRROR}/aarch64/Packages/k/kamera-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kamera;unpack=0"
SRC_URI:append = " ${URI_aarch64_kamera}"
SRC_URI[aarch64_kamera.sha256sum] = "d7e155df5f29d651785fc4237afebcc676643382d93e1b2af7bc5a209a4401d5"

RDEPENDS:kamera = " \
 glibc \
 kde-cli-tools \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgphoto2 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
