# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mac_address"
PV = "1.1.8"
PR = "3.el10_3"
PACKAGES = " \
 rust-mac_address+default-devel \
 rust-mac_address+serde-devel \
 rust-mac_address-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mac_address-1.1.8-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b327e8f224510ea24e82f8fd879ea28380940cc442d0dc86fa4eacc6f81d019"

URI_x86_64_v2_rust-mac_address+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mac_address+default-devel-1.1.8-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mac_address+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mac_address+default-devel}"
SRC_URI[x86_64_v2_rust-mac_address+default-devel.sha256sum] = "bfd817fbd49a9d7ba0ad53627ccabfa5e78d5c809dc86bd3d995d94244edd4be"

URI_x86_64_v2_rust-mac_address+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mac_address+serde-devel-1.1.8-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mac_address+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mac_address+serde-devel}"
SRC_URI[x86_64_v2_rust-mac_address+serde-devel.sha256sum] = "1fc19de7b3b1c03a4675a9c4c1f81338d98047021fd26fe8a9c9bb0cf8937d1e"

URI_x86_64_v2_rust-mac_address-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mac_address-devel-1.1.8-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mac_address-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mac_address-devel}"
SRC_URI[x86_64_v2_rust-mac_address-devel.sha256sum] = "2b50b509ddb5e1a3b52ee2c80227c1bff833c414fb1613e6d8c55d9a7259a208"

URI_aarch64_rust-mac_address+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mac_address+default-devel-1.1.8-3.el10_3.noarch.rpm;name=aarch64_rust-mac_address+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mac_address+default-devel}"
SRC_URI[aarch64_rust-mac_address+default-devel.sha256sum] = "c4b2934cfd1f8bb8b9fc5842b15e19dede6a0e5eebc35874763f7a0a2d87b277"

URI_aarch64_rust-mac_address+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mac_address+serde-devel-1.1.8-3.el10_3.noarch.rpm;name=aarch64_rust-mac_address+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mac_address+serde-devel}"
SRC_URI[aarch64_rust-mac_address+serde-devel.sha256sum] = "2886cb291b094a1641bfbfddd33686649960205e47576b034eded153d7836f46"

URI_aarch64_rust-mac_address-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mac_address-devel-1.1.8-3.el10_3.noarch.rpm;name=aarch64_rust-mac_address-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mac_address-devel}"
SRC_URI[aarch64_rust-mac_address-devel.sha256sum] = "cccc918d25d5756dbe0847819202b047647cc8e65533d14b8cfb88df77a78a6a"

RDEPENDS:rust-mac_address+default-devel = " \
 cargo \
 rust-mac_address-devel \
 "
RDEPENDS:rust-mac_address+serde-devel = " \
 cargo \
 rust-mac_address-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-mac_address-devel = " \
 cargo \
 rust-nix0.29+default-devel \
 rust-nix0.29+net-devel \
 "
