# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zig"
PV = "0.16.0"
PR = "1.el10_2"
PACKAGES:x86_64_v2 = " \
 zig \
 zig-doc \
 zig-libs \
 zig-rpm-macros \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/z/zig-0.16.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e60705bedfc872d2b2704ccf74b8df64fa940620edf20c94ab052a00e2c063cc"

URI_x86_64_v2_zig = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zig-0.16.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zig}"
SRC_URI[x86_64_v2_zig.sha256sum] = "e55c1867d6fafe2ea8b42019fac61cc1596a47e42619e4562e4842b7296e8b8c"

URI_x86_64_v2_zig-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zig-doc-0.16.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_zig-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zig-doc}"
SRC_URI[x86_64_v2_zig-doc.sha256sum] = "e8ad6d506e9a555a00cbd49999d141f7b2faf6633ad0bceeedb78cec0a87d465"

URI_x86_64_v2_zig-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zig-libs-0.16.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_zig-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zig-libs}"
SRC_URI[x86_64_v2_zig-libs.sha256sum] = "35afaae500437d68d59ecf62a3a9854b3c20ffe72aecb412e783d63c2f67762f"

URI_x86_64_v2_zig-rpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zig-rpm-macros-0.16.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_zig-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zig-rpm-macros}"
SRC_URI[x86_64_v2_zig-rpm-macros.sha256sum] = "9e432b0571d58e21c12c87b3cf20e6b051386c40db3850820a292f97bbe78700"

RDEPENDS:zig = " \
 clang-libs \
 glibc \
 libstdc++ \
 lld-libs \
 llvm-libs \
 zig-libs \
 "
RDEPENDS:zig-doc = " \
 zig \
 "
RDEPENDS:zig-libs = " \
 "
RDEPENDS:zig-rpm-macros = " \
 rpm \
 "
