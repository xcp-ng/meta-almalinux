# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kitemmodels"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kitemmodels \
 kf6-kitemmodels-devel \
 kf6-kitemmodels-doc \
 kf6-kitemmodels-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kitemmodels-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63b2b46e82e446333ec895c8b60b08a67715d18cd7a93ffb139bac1d5357b300"

URI_x86_64_v2_kf6-kitemmodels = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemmodels-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kitemmodels;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kitemmodels}"
SRC_URI[x86_64_v2_kf6-kitemmodels.sha256sum] = "c053f6e2e7eda14e8f96f158f7d91087efe74076764ed0f90d47a6bd31cec48a"

URI_x86_64_v2_kf6-kitemmodels-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemmodels-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kitemmodels-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kitemmodels-devel}"
SRC_URI[x86_64_v2_kf6-kitemmodels-devel.sha256sum] = "54e457e1cb247340967e6578c52ad53afe838f7c587acbe073e87e35b558e520"

URI_x86_64_v2_kf6-kitemmodels-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemmodels-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kitemmodels-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kitemmodels-doc}"
SRC_URI[x86_64_v2_kf6-kitemmodels-doc.sha256sum] = "a05fc837daf16f1b9ecc0b4dc5dc1a9980b03d4c2ce1cacb24dfac2726e892bc"

URI_x86_64_v2_kf6-kitemmodels-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemmodels-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kitemmodels-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kitemmodels-html}"
SRC_URI[x86_64_v2_kf6-kitemmodels-html.sha256sum] = "41eac03412e68d9d2e97426ed0d2b26c516f09b5d8f60798cdacbea815a94ce7"

URI_aarch64_kf6-kitemmodels = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemmodels-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kitemmodels;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kitemmodels}"
SRC_URI[aarch64_kf6-kitemmodels.sha256sum] = "04ce1ddd23f8e874a3d52ff0913170ffefaaac2785395a176c1f2c7158094619"

URI_aarch64_kf6-kitemmodels-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemmodels-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kitemmodels-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kitemmodels-devel}"
SRC_URI[aarch64_kf6-kitemmodels-devel.sha256sum] = "d272c1a5562b5904d52fbc9f55a66fa0914a8701e4167d5a3f69d0713a122404"

URI_aarch64_kf6-kitemmodels-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemmodels-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kitemmodels-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kitemmodels-doc}"
SRC_URI[aarch64_kf6-kitemmodels-doc.sha256sum] = "c3f059d84e1949d7ee27f2dd1b10e53b5d70c93a18280aba16fd9bc0e24b99f3"

URI_aarch64_kf6-kitemmodels-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemmodels-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kitemmodels-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kitemmodels-html}"
SRC_URI[aarch64_kf6-kitemmodels-html.sha256sum] = "44898232341e5e38fb66d9eb39ac3ac64c4b29a01ef59e2ea9f3598e2410f405"

RDEPENDS:kf6-kitemmodels = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kitemmodels-devel = " \
 cmake-filesystem \
 kf6-kitemmodels \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kitemmodels-doc = " \
 "
RDEPENDS:kf6-kitemmodels-html = " \
 "
