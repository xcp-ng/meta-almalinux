# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-bluez-qt"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-bluez-qt \
 kf6-bluez-qt-devel \
 kf6-bluez-qt-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-bluez-qt-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e109d86d11156574f6304f9650f1d615675349a10db787dc95827e211a840a7"

URI_x86_64_v2_kf6-bluez-qt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-bluez-qt-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-bluez-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-bluez-qt}"
SRC_URI[x86_64_v2_kf6-bluez-qt.sha256sum] = "07437eb7f6ecca58018f1b45d5727db52e8d3f939589a6e35647e93d0eddfb52"

URI_x86_64_v2_kf6-bluez-qt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-bluez-qt-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-bluez-qt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-bluez-qt-devel}"
SRC_URI[x86_64_v2_kf6-bluez-qt-devel.sha256sum] = "ce0e661577acfd17c41ee7d35be8a940dd91857f914dfc8f04a9753ffa32cccb"

URI_x86_64_v2_kf6-bluez-qt-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-bluez-qt-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-bluez-qt-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-bluez-qt-doc}"
SRC_URI[x86_64_v2_kf6-bluez-qt-doc.sha256sum] = "13667ebe91d391d2b264c69d4345d0e12dd9fdcd6a3fac58d3d35d7409690f54"

URI_aarch64_kf6-bluez-qt = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-bluez-qt-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-bluez-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-bluez-qt}"
SRC_URI[aarch64_kf6-bluez-qt.sha256sum] = "6b799c00603fef251838a3dee5652718c88ea067bf2d449a57d44857a7fc26e1"

URI_aarch64_kf6-bluez-qt-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-bluez-qt-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-bluez-qt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-bluez-qt-devel}"
SRC_URI[aarch64_kf6-bluez-qt-devel.sha256sum] = "d99c579219df56c2cbf4d84fa78c6be8c3e54960b10559da7e81c6db5cdf273d"

URI_aarch64_kf6-bluez-qt-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-bluez-qt-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-bluez-qt-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-bluez-qt-doc}"
SRC_URI[aarch64_kf6-bluez-qt-doc.sha256sum] = "af6e9fa57d5759a5ec17c87c8767344d6c9c3ac70b1f8e4cb06c7b3593dadc74"

RDEPENDS:kf6-bluez-qt = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-bluez-qt-devel = " \
 cmake-filesystem \
 kf6-bluez-qt \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-bluez-qt-doc = " \
 "
