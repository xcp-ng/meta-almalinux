# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-subtle"
PV = "2.6.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-subtle+const-generics-devel \
 rust-subtle+core_hint_black_box-devel \
 rust-subtle+default-devel \
 rust-subtle+i128-devel \
 rust-subtle+nightly-devel \
 rust-subtle+std-devel \
 rust-subtle-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-subtle-2.6.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "99496b503968ddf17430705fa0d23f20a40e60305b95ac11dc5bcfb902cff8be"

URI_x86_64_v2_rust-subtle+const-generics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-subtle+const-generics-devel-2.6.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-subtle+const-generics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-subtle+const-generics-devel}"
SRC_URI[x86_64_v2_rust-subtle+const-generics-devel.sha256sum] = "8aa4bf934de5ab13cad6b992738157a08921cb11e8269a8ab6921869ece358be"

URI_x86_64_v2_rust-subtle+core_hint_black_box-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-subtle+core_hint_black_box-devel-2.6.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-subtle+core_hint_black_box-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-subtle+core_hint_black_box-devel}"
SRC_URI[x86_64_v2_rust-subtle+core_hint_black_box-devel.sha256sum] = "65634a5875b5802457f09a3d9fe7869508add2f8ee27e06ce10f9469dd43037e"

URI_x86_64_v2_rust-subtle+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-subtle+default-devel-2.6.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-subtle+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-subtle+default-devel}"
SRC_URI[x86_64_v2_rust-subtle+default-devel.sha256sum] = "2512b95545966aa87c94b52e7d22fcf97b82202590a4967d888b23d66ab44856"

URI_x86_64_v2_rust-subtle+i128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-subtle+i128-devel-2.6.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-subtle+i128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-subtle+i128-devel}"
SRC_URI[x86_64_v2_rust-subtle+i128-devel.sha256sum] = "75362f9010dfce0d508be9e0eedff7546b0373596f32a926b2765dd55e681b5b"

URI_x86_64_v2_rust-subtle+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-subtle+nightly-devel-2.6.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-subtle+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-subtle+nightly-devel}"
SRC_URI[x86_64_v2_rust-subtle+nightly-devel.sha256sum] = "d55e86ce37c1fff773c72971ed76e90cd993cbd7ed2a0904dbca58f4d7dff90d"

URI_x86_64_v2_rust-subtle+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-subtle+std-devel-2.6.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-subtle+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-subtle+std-devel}"
SRC_URI[x86_64_v2_rust-subtle+std-devel.sha256sum] = "d958038382d9c72a70cc118c7f77ca68a0d3a5c36f32123c14f49e2a51febe49"

URI_x86_64_v2_rust-subtle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-subtle-devel-2.6.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-subtle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-subtle-devel}"
SRC_URI[x86_64_v2_rust-subtle-devel.sha256sum] = "2013dcc3c4f572ea4199ccd3b17a08f483eca29c31b1d7455ef11339f3c5a2bc"

URI_aarch64_rust-subtle+const-generics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-subtle+const-generics-devel-2.6.1-2.el10_0.noarch.rpm;name=aarch64_rust-subtle+const-generics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-subtle+const-generics-devel}"
SRC_URI[aarch64_rust-subtle+const-generics-devel.sha256sum] = "06fc2927a4be18d2b27f99991664777de3d0b6e1ee211bf98bcdf25dcddf343a"

URI_aarch64_rust-subtle+core_hint_black_box-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-subtle+core_hint_black_box-devel-2.6.1-2.el10_0.noarch.rpm;name=aarch64_rust-subtle+core_hint_black_box-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-subtle+core_hint_black_box-devel}"
SRC_URI[aarch64_rust-subtle+core_hint_black_box-devel.sha256sum] = "d4d30881ea47b06093349b785674c2de54a7955bef6dfd01a317255e2c0ef3d4"

URI_aarch64_rust-subtle+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-subtle+default-devel-2.6.1-2.el10_0.noarch.rpm;name=aarch64_rust-subtle+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-subtle+default-devel}"
SRC_URI[aarch64_rust-subtle+default-devel.sha256sum] = "8022ffdf299827f09186f86299af1087307e58b314111c463909fd734a5dd38b"

URI_aarch64_rust-subtle+i128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-subtle+i128-devel-2.6.1-2.el10_0.noarch.rpm;name=aarch64_rust-subtle+i128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-subtle+i128-devel}"
SRC_URI[aarch64_rust-subtle+i128-devel.sha256sum] = "40bbf60f07dee228628d781997f6bec4379f5df3e586884555ef52e73cc48e48"

URI_aarch64_rust-subtle+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-subtle+nightly-devel-2.6.1-2.el10_0.noarch.rpm;name=aarch64_rust-subtle+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-subtle+nightly-devel}"
SRC_URI[aarch64_rust-subtle+nightly-devel.sha256sum] = "8140d917e5605d9b409a9f3bce8eab3f27650f5586a10542999490b89cb67379"

URI_aarch64_rust-subtle+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-subtle+std-devel-2.6.1-2.el10_0.noarch.rpm;name=aarch64_rust-subtle+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-subtle+std-devel}"
SRC_URI[aarch64_rust-subtle+std-devel.sha256sum] = "010a6b3259e43ea04a82a0d5899e70dc4615c229f177ad902363b16dd80dfa7a"

URI_aarch64_rust-subtle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-subtle-devel-2.6.1-2.el10_0.noarch.rpm;name=aarch64_rust-subtle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-subtle-devel}"
SRC_URI[aarch64_rust-subtle-devel.sha256sum] = "38b926d995e6f471236ffc42d2a3ae107b7aa98fb305afcca5fea53376680e88"

RDEPENDS:rust-subtle+const-generics-devel = " \
 cargo \
 rust-subtle-devel \
 "
RDEPENDS:rust-subtle+core_hint_black_box-devel = " \
 cargo \
 rust-subtle-devel \
 "
RDEPENDS:rust-subtle+default-devel = " \
 cargo \
 rust-subtle+i128-devel \
 rust-subtle+std-devel \
 rust-subtle-devel \
 "
RDEPENDS:rust-subtle+i128-devel = " \
 cargo \
 rust-subtle-devel \
 "
RDEPENDS:rust-subtle+nightly-devel = " \
 cargo \
 rust-subtle-devel \
 "
RDEPENDS:rust-subtle+std-devel = " \
 cargo \
 rust-subtle-devel \
 "
RDEPENDS:rust-subtle-devel = " \
 cargo \
 "
