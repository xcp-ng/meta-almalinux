# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-ftp-control"
PV = "9.10"
PR = "4.el10_0"
PACKAGES = " \
 globus-ftp-control \
 globus-ftp-control-devel \
 globus-ftp-control-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-ftp-control-9.10-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "35bd968ed8cbc112af3a9f91fcd2e29484d850314d522e8ef351f99dfa43c905"

URI_x86_64_v2_globus-ftp-control = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-ftp-control-9.10-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-ftp-control;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-ftp-control}"
SRC_URI[x86_64_v2_globus-ftp-control.sha256sum] = "35a1dc2dff98f51e360da43f28bddf6ef1cbe6e908ea547c4f4c453ac4af84ee"

URI_x86_64_v2_globus-ftp-control-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-ftp-control-devel-9.10-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-ftp-control-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-ftp-control-devel}"
SRC_URI[x86_64_v2_globus-ftp-control-devel.sha256sum] = "6a8ed44afc8476ecc973ff03afd923f871116ad2c7044d43ca31b9a5cc691e79"

URI_x86_64_v2_globus-ftp-control-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-ftp-control-doc-9.10-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-ftp-control-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-ftp-control-doc}"
SRC_URI[x86_64_v2_globus-ftp-control-doc.sha256sum] = "fcbbb76779c4b5ffb45b998ea1c6758e0278e448bcaf666d2f7308c8f6ce398d"

URI_aarch64_globus-ftp-control = "${EPEL_MIRROR}/aarch64/Packages/g/globus-ftp-control-9.10-4.el10_0.aarch64.rpm;name=aarch64_globus-ftp-control;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-ftp-control}"
SRC_URI[aarch64_globus-ftp-control.sha256sum] = "3bd805f38cb07026cf7a5e51446da441ab148162116cabc8676bdc9d95131d59"

URI_aarch64_globus-ftp-control-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-ftp-control-devel-9.10-4.el10_0.aarch64.rpm;name=aarch64_globus-ftp-control-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-ftp-control-devel}"
SRC_URI[aarch64_globus-ftp-control-devel.sha256sum] = "9b76233d510867d27b43af18b1ee4e6c4dec0d753794c88f039a1294825f4c33"

URI_aarch64_globus-ftp-control-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-ftp-control-doc-9.10-4.el10_0.noarch.rpm;name=aarch64_globus-ftp-control-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-ftp-control-doc}"
SRC_URI[aarch64_globus-ftp-control-doc.sha256sum] = "05e126413544d1c1bdd0b01d95881ce8ac607a74c02d4c74b88df519673e1d87"

RDEPENDS:globus-ftp-control = " \
 glibc \
 globus-common \
 globus-gss-assist \
 globus-gssapi-error \
 globus-gssapi-gsi \
 globus-io \
 globus-xio \
 globus-xio-gsi-driver \
 "
RDEPENDS:globus-ftp-control-devel = " \
 globus-common-devel \
 globus-ftp-control \
 globus-gss-assist-devel \
 globus-gssapi-error-devel \
 globus-gssapi-gsi-devel \
 globus-io-devel \
 globus-xio-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-ftp-control-doc = " \
 "
