# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "units"
PV = "2.22"
PR = "10.el10"
PACKAGES = " \
 units \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/units-2.22-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b136ed4a64545d39a7a38a2f72bbac3b2dbeaf9b2f7190f990d9039908f8df0"

URI_x86_64_v2_units = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/units-2.22-10.el10.x86_64_v2.rpm;name=x86_64_v2_units;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_units}"
SRC_URI[x86_64_v2_units.sha256sum] = "31039aaca88a5da11d0f2d477aca914b7f5b815e1d068f62f9371e74b9adfd24"

URI_aarch64_units = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/units-2.22-10.el10.aarch64.rpm;name=aarch64_units;unpack=0"
SRC_URI:append = " ${URI_aarch64_units}"
SRC_URI[aarch64_units.sha256sum] = "27c13c63dfc0f089609469bbbe87f2a00ac9823ebfb7187f9c45b336317b5aee"

RDEPENDS:units = " \
 glibc \
 python3 \
 readline \
 "
