# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ciborium"
PV = "0.2.2"
PR = "6.el10_3"
PACKAGES = " \
 rust-ciborium+default-devel \
 rust-ciborium+std-devel \
 rust-ciborium-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ciborium-0.2.2-6.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c48c15367f6b68d8a80136c37165698045a1846b17cfae64d4d2b8c59dfbada7"

URI_x86_64_v2_rust-ciborium+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ciborium+default-devel-0.2.2-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ciborium+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ciborium+default-devel}"
SRC_URI[x86_64_v2_rust-ciborium+default-devel.sha256sum] = "f84bd5e6ac42b6781896eccbeefcefa075d9be48b78dc26e184db056e0dc808f"

URI_x86_64_v2_rust-ciborium+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ciborium+std-devel-0.2.2-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ciborium+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ciborium+std-devel}"
SRC_URI[x86_64_v2_rust-ciborium+std-devel.sha256sum] = "918140bfb1ce1de62a5e2ebb0ab1f867710f8393d8a158724c05efa37c2a3b6b"

URI_x86_64_v2_rust-ciborium-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ciborium-devel-0.2.2-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ciborium-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ciborium-devel}"
SRC_URI[x86_64_v2_rust-ciborium-devel.sha256sum] = "b6f3d8a58ee96011f979511641bfb88bda4da38232d7aaea46031790b0e7b735"

URI_aarch64_rust-ciborium+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ciborium+default-devel-0.2.2-6.el10_3.noarch.rpm;name=aarch64_rust-ciborium+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ciborium+default-devel}"
SRC_URI[aarch64_rust-ciborium+default-devel.sha256sum] = "6436bef6bc615a95beb7d96be5c63a7e84e92c515150da767f1ee406fb03eea6"

URI_aarch64_rust-ciborium+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ciborium+std-devel-0.2.2-6.el10_3.noarch.rpm;name=aarch64_rust-ciborium+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ciborium+std-devel}"
SRC_URI[aarch64_rust-ciborium+std-devel.sha256sum] = "8a805046d7496afdbeab49d3ad6b5cc075b9c74bc5694d9e3741456f52a18513"

URI_aarch64_rust-ciborium-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ciborium-devel-0.2.2-6.el10_3.noarch.rpm;name=aarch64_rust-ciborium-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ciborium-devel}"
SRC_URI[aarch64_rust-ciborium-devel.sha256sum] = "8d5ccd4e624d734254a5fec551a3b308c7e511d5304026ce2ba87352c4253d0e"

RDEPENDS:rust-ciborium+default-devel = " \
 cargo \
 rust-ciborium+std-devel \
 rust-ciborium-devel \
 "
RDEPENDS:rust-ciborium+std-devel = " \
 cargo \
 rust-ciborium-devel \
 rust-ciborium-io+std-devel \
 rust-serde+std-devel \
 "
RDEPENDS:rust-ciborium-devel = " \
 cargo \
 rust \
 rust-ciborium-io+alloc-devel \
 rust-ciborium-io+default-devel \
 rust-ciborium-ll+default-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
