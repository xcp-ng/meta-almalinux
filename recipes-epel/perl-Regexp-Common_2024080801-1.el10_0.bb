# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Regexp-Common"
PV = "2024080801"
PR = "1.el10_0"
PACKAGES = " \
 perl-Regexp-Common \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Regexp-Common-2024080801-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "53f1b42d9e3e700a925b836da408ede4ef7ace91822ac401f7ba8e96ffced7cf"

URI_x86_64_v2_perl-Regexp-Common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Regexp-Common-2024080801-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Regexp-Common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Regexp-Common}"
SRC_URI[x86_64_v2_perl-Regexp-Common.sha256sum] = "36c3d975f6e635dfdbba5c6a03d05593eb5386576951bfd5a1445322b5a20d80"

URI_aarch64_perl-Regexp-Common = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Regexp-Common-2024080801-1.el10_0.noarch.rpm;name=aarch64_perl-Regexp-Common;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Regexp-Common}"
SRC_URI[aarch64_perl-Regexp-Common.sha256sum] = "f5646bb14b97ae10601d7a2e6218ce265ab07eedab73e67588484b1d7df0dd88"

RDEPENDS:perl-Regexp-Common = " \
 perl-Carp \
 perl-Exporter \
 perl-Regexp-Common \
 perl-libs \
 perl-overload \
 "
