# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-brotli-decompressor"
PV = "4.0.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-brotli-decompressor+alloc-stdlib-devel \
 rust-brotli-decompressor+default-devel \
 rust-brotli-decompressor+disable-timer-devel \
 rust-brotli-decompressor+ffi-api-devel \
 rust-brotli-decompressor+pass-through-ffi-panics-devel \
 rust-brotli-decompressor+seccomp-devel \
 rust-brotli-decompressor+std-devel \
 rust-brotli-decompressor+unsafe-devel \
 rust-brotli-decompressor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-brotli-decompressor-4.0.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b06e323676ad11b74dbff1d23dc4bed8145f8aead563e0622a305c4a78317a64"

URI_x86_64_v2_rust-brotli-decompressor+alloc-stdlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+alloc-stdlib-devel-4.0.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+alloc-stdlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli-decompressor+alloc-stdlib-devel}"
SRC_URI[x86_64_v2_rust-brotli-decompressor+alloc-stdlib-devel.sha256sum] = "4226de725d57d988ead91dda8ae58fb31d59fcd452d7ad47e012afeb450f2e69"

URI_x86_64_v2_rust-brotli-decompressor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+default-devel-4.0.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli-decompressor+default-devel}"
SRC_URI[x86_64_v2_rust-brotli-decompressor+default-devel.sha256sum] = "82ae1bc7a55fbcd6498788326cd3f0a3b69753749f112dc2b11901a430e9328d"

URI_x86_64_v2_rust-brotli-decompressor+disable-timer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+disable-timer-devel-4.0.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+disable-timer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli-decompressor+disable-timer-devel}"
SRC_URI[x86_64_v2_rust-brotli-decompressor+disable-timer-devel.sha256sum] = "d5ba789fc0073c2457fc3a3b8e94f8278da1f23f71eeaeff57d0636315e9e642"

URI_x86_64_v2_rust-brotli-decompressor+ffi-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+ffi-api-devel-4.0.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+ffi-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli-decompressor+ffi-api-devel}"
SRC_URI[x86_64_v2_rust-brotli-decompressor+ffi-api-devel.sha256sum] = "73889de01173632b6956a47fbb007bf6c5d530aa5eb6f7e3971b1c0f2057ef49"

URI_x86_64_v2_rust-brotli-decompressor+pass-through-ffi-panics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+pass-through-ffi-panics-devel-4.0.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+pass-through-ffi-panics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli-decompressor+pass-through-ffi-panics-devel}"
SRC_URI[x86_64_v2_rust-brotli-decompressor+pass-through-ffi-panics-devel.sha256sum] = "3edadcc186d1dd614687bc8a1fc163e0e2ac038ad4ac96d45d446c4c8b45f7dc"

URI_x86_64_v2_rust-brotli-decompressor+seccomp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+seccomp-devel-4.0.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+seccomp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli-decompressor+seccomp-devel}"
SRC_URI[x86_64_v2_rust-brotli-decompressor+seccomp-devel.sha256sum] = "8ed18dff6953c16f46c95c8c087821dba66f8faec1d405ccfe6f68c905abc311"

URI_x86_64_v2_rust-brotli-decompressor+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+std-devel-4.0.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli-decompressor+std-devel}"
SRC_URI[x86_64_v2_rust-brotli-decompressor+std-devel.sha256sum] = "a1ed8509f04ed6d6400bafb6fa7ff0dea12307fa00231ae11530f590b2fbda52"

URI_x86_64_v2_rust-brotli-decompressor+unsafe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+unsafe-devel-4.0.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+unsafe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli-decompressor+unsafe-devel}"
SRC_URI[x86_64_v2_rust-brotli-decompressor+unsafe-devel.sha256sum] = "ae7709430ca4fddc675bbe062ea548f76a2882ce4337c50ea85cd6fb97db87c8"

URI_x86_64_v2_rust-brotli-decompressor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor-devel-4.0.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli-decompressor-devel}"
SRC_URI[x86_64_v2_rust-brotli-decompressor-devel.sha256sum] = "bfe1bce7878ce0f47900171fcb5ecc102558c43fc24e3486dad1bd03a0f4ac03"

URI_aarch64_rust-brotli-decompressor+alloc-stdlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+alloc-stdlib-devel-4.0.3-1.el10_0.noarch.rpm;name=aarch64_rust-brotli-decompressor+alloc-stdlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli-decompressor+alloc-stdlib-devel}"
SRC_URI[aarch64_rust-brotli-decompressor+alloc-stdlib-devel.sha256sum] = "03c2d9de4f52637005ac010480ce7195a5c58b68c8aede093d1498496c33e73d"

URI_aarch64_rust-brotli-decompressor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+default-devel-4.0.3-1.el10_0.noarch.rpm;name=aarch64_rust-brotli-decompressor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli-decompressor+default-devel}"
SRC_URI[aarch64_rust-brotli-decompressor+default-devel.sha256sum] = "212e8f5c107264369f36ad223dea1c63d029598f56fd2fb76026b117b024ab14"

URI_aarch64_rust-brotli-decompressor+disable-timer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+disable-timer-devel-4.0.3-1.el10_0.noarch.rpm;name=aarch64_rust-brotli-decompressor+disable-timer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli-decompressor+disable-timer-devel}"
SRC_URI[aarch64_rust-brotli-decompressor+disable-timer-devel.sha256sum] = "639e10cad3e5864da2fa1c32af371c225205d020a6964e94dcd3a13760361619"

URI_aarch64_rust-brotli-decompressor+ffi-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+ffi-api-devel-4.0.3-1.el10_0.noarch.rpm;name=aarch64_rust-brotli-decompressor+ffi-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli-decompressor+ffi-api-devel}"
SRC_URI[aarch64_rust-brotli-decompressor+ffi-api-devel.sha256sum] = "7d315888e5cb653f9b11d38833408fca4edb3bfc673a806c36eca5f533988574"

URI_aarch64_rust-brotli-decompressor+pass-through-ffi-panics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+pass-through-ffi-panics-devel-4.0.3-1.el10_0.noarch.rpm;name=aarch64_rust-brotli-decompressor+pass-through-ffi-panics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli-decompressor+pass-through-ffi-panics-devel}"
SRC_URI[aarch64_rust-brotli-decompressor+pass-through-ffi-panics-devel.sha256sum] = "c89375d0ae3d5ac00d380ee67ae6b062a006f0b16e2dc24c7dd3ef8a1505cdcc"

URI_aarch64_rust-brotli-decompressor+seccomp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+seccomp-devel-4.0.3-1.el10_0.noarch.rpm;name=aarch64_rust-brotli-decompressor+seccomp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli-decompressor+seccomp-devel}"
SRC_URI[aarch64_rust-brotli-decompressor+seccomp-devel.sha256sum] = "4ae42d987bfeb9ee68140f8fd8baf06cfca9c1dae535ba818c2a35579161a4e2"

URI_aarch64_rust-brotli-decompressor+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+std-devel-4.0.3-1.el10_0.noarch.rpm;name=aarch64_rust-brotli-decompressor+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli-decompressor+std-devel}"
SRC_URI[aarch64_rust-brotli-decompressor+std-devel.sha256sum] = "dd05d8a60388d77614f2272ff3e1b41fe1a16c4a4fb8f701fe424b6b8de295eb"

URI_aarch64_rust-brotli-decompressor+unsafe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+unsafe-devel-4.0.3-1.el10_0.noarch.rpm;name=aarch64_rust-brotli-decompressor+unsafe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli-decompressor+unsafe-devel}"
SRC_URI[aarch64_rust-brotli-decompressor+unsafe-devel.sha256sum] = "38d5040b9ed71c6e45e7ef6ad92a686491e7f59ca179e3352904594e27db2529"

URI_aarch64_rust-brotli-decompressor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor-devel-4.0.3-1.el10_0.noarch.rpm;name=aarch64_rust-brotli-decompressor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli-decompressor-devel}"
SRC_URI[aarch64_rust-brotli-decompressor-devel.sha256sum] = "0c0e449176827d5e98fc708b682577990204cbc022d89925f2baf3a4f8b51c1c"

RDEPENDS:rust-brotli-decompressor+alloc-stdlib-devel = " \
 cargo \
 rust-alloc-stdlib+default-devel \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+default-devel = " \
 cargo \
 rust-brotli-decompressor+std-devel \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+disable-timer-devel = " \
 cargo \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+ffi-api-devel = " \
 cargo \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+pass-through-ffi-panics-devel = " \
 cargo \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+seccomp-devel = " \
 cargo \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+std-devel = " \
 cargo \
 rust-brotli-decompressor+alloc-stdlib-devel \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+unsafe-devel = " \
 cargo \
 rust-alloc-no-stdlib+unsafe-devel \
 rust-alloc-stdlib+default-devel \
 rust-alloc-stdlib+unsafe-devel \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor-devel = " \
 cargo \
 rust-alloc-no-stdlib+default-devel \
 "
