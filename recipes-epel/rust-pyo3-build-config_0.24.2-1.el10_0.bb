# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-build-config"
PV = "0.24.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-pyo3-build-config+abi3-devel \
 rust-pyo3-build-config+abi3-py310-devel \
 rust-pyo3-build-config+abi3-py311-devel \
 rust-pyo3-build-config+abi3-py312-devel \
 rust-pyo3-build-config+abi3-py313-devel \
 rust-pyo3-build-config+abi3-py37-devel \
 rust-pyo3-build-config+abi3-py38-devel \
 rust-pyo3-build-config+abi3-py39-devel \
 rust-pyo3-build-config+default-devel \
 rust-pyo3-build-config+extension-module-devel \
 rust-pyo3-build-config+resolve-config-devel \
 rust-pyo3-build-config-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-build-config-0.24.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c36959e30c4eb9d65196f7b03b1f12460837b4891899087a3c72f3aa01a0bfa1"

URI_x86_64_v2_rust-pyo3-build-config+abi3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+abi3-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+abi3-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+abi3-devel.sha256sum] = "e25c0b6f0fbb7dd5fe3609d1336b9a14d5208a75d94020639bf02a97d083b592"

URI_x86_64_v2_rust-pyo3-build-config+abi3-py310-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+abi3-py310-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+abi3-py310-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+abi3-py310-devel.sha256sum] = "90fc20e83bc686623fba8b031730bde8721b0f54468eb53235aa4051b07b73c6"

URI_x86_64_v2_rust-pyo3-build-config+abi3-py311-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+abi3-py311-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+abi3-py311-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+abi3-py311-devel.sha256sum] = "4885dba8e4dcf73dff2887a902c42a3ebf5e4e15c527ecb35fb2f1563473c915"

URI_x86_64_v2_rust-pyo3-build-config+abi3-py312-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+abi3-py312-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+abi3-py312-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+abi3-py312-devel.sha256sum] = "735dd7e25acfcec7c3d5fe039a20aaeb1d222075ce0fd5237677cc3da3493188"

URI_x86_64_v2_rust-pyo3-build-config+abi3-py313-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+abi3-py313-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+abi3-py313-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+abi3-py313-devel.sha256sum] = "db9e85bf519fdc38b3f997378f5fa24179cd2d9be6c181daff28d7c85685c0c6"

URI_x86_64_v2_rust-pyo3-build-config+abi3-py37-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+abi3-py37-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+abi3-py37-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+abi3-py37-devel.sha256sum] = "e202de3aae84cb2d43bc8d700bf564e0c56d8a29ea04f22a3da6673463bce526"

URI_x86_64_v2_rust-pyo3-build-config+abi3-py38-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+abi3-py38-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+abi3-py38-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+abi3-py38-devel.sha256sum] = "d71b902603bd2ad18ef83e74ec88574fdad84c2b0e98c247b63134b695c511d0"

URI_x86_64_v2_rust-pyo3-build-config+abi3-py39-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+abi3-py39-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+abi3-py39-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+abi3-py39-devel.sha256sum] = "86c0c4960bee7b92253b69d3c750e80d607b2a60bc97501d4d511f36f3fc53f2"

URI_x86_64_v2_rust-pyo3-build-config+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+default-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+default-devel.sha256sum] = "d6bcd42346fb211828ec9c0c397b05220399675616df31c8a10bba96ab77789f"

URI_x86_64_v2_rust-pyo3-build-config+extension-module-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+extension-module-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+extension-module-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+extension-module-devel.sha256sum] = "b257eabe8c52900203186f721901a0c9ace25a473ae6f28f5580e287a9a272ee"

URI_x86_64_v2_rust-pyo3-build-config+resolve-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+resolve-config-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+resolve-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+resolve-config-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+resolve-config-devel.sha256sum] = "3258cea0c6b7450f73021044913965b5816518bd6f33cde9700f5de64e76d69a"

URI_x86_64_v2_rust-pyo3-build-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config-devel.sha256sum] = "d8acba3938d4f04c8c5a61704ecade7e86d433646dc61e828c7307c34b4e1d92"

URI_aarch64_rust-pyo3-build-config+abi3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+abi3-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+abi3-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+abi3-devel.sha256sum] = "b83afb106231705913990b1fb14896d527f654e525603393d7834de503f298a3"

URI_aarch64_rust-pyo3-build-config+abi3-py310-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+abi3-py310-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+abi3-py310-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+abi3-py310-devel.sha256sum] = "83b076b0673996f12f2978afb3146b362fbb239a5a4c5101f8507e9a7e7ff076"

URI_aarch64_rust-pyo3-build-config+abi3-py311-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+abi3-py311-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+abi3-py311-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+abi3-py311-devel.sha256sum] = "190e5075163bc592f631593f41e8939c775dcdf9f4d1deb2d53fb74dc0d97bcc"

URI_aarch64_rust-pyo3-build-config+abi3-py312-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+abi3-py312-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+abi3-py312-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+abi3-py312-devel.sha256sum] = "558100d789ce99941ca16d0a827fe1d08f9200f6817f5be7100e0b9ac67ecd7b"

URI_aarch64_rust-pyo3-build-config+abi3-py313-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+abi3-py313-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+abi3-py313-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+abi3-py313-devel.sha256sum] = "2b6773e07de3e4b8d78a2ee3af5533ab26e04e3648f692e3e023fcad89464c5f"

URI_aarch64_rust-pyo3-build-config+abi3-py37-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+abi3-py37-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+abi3-py37-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+abi3-py37-devel.sha256sum] = "84f0efe100884a6ed51cff95c4f1ce16d098176c3711dba0b46e3ea7377ff67a"

URI_aarch64_rust-pyo3-build-config+abi3-py38-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+abi3-py38-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+abi3-py38-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+abi3-py38-devel.sha256sum] = "883d91c4f01ffc7dc06facc9efef95dd20b1bf2131678027da932aa6688b313c"

URI_aarch64_rust-pyo3-build-config+abi3-py39-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+abi3-py39-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+abi3-py39-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+abi3-py39-devel.sha256sum] = "9d94732ffa2251356f9c0848e1dcc5c3df465e032f8195523d7e7d6d0d514121"

URI_aarch64_rust-pyo3-build-config+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+default-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+default-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+default-devel.sha256sum] = "c88334da50bbac94333bd04ec1a43fce6cd7163ee7416d810c3e9db0ff27a8f3"

URI_aarch64_rust-pyo3-build-config+extension-module-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+extension-module-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+extension-module-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+extension-module-devel.sha256sum] = "ceaaf12d6cf4364ba3822fadd606cf0601170a1fac0b2035f6cf46cecb6ffb8d"

URI_aarch64_rust-pyo3-build-config+resolve-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+resolve-config-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config+resolve-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+resolve-config-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+resolve-config-devel.sha256sum] = "95a942db9b762730361e6e4e2d9badb2abf98a3e17aacc551483b69dc615e6e8"

URI_aarch64_rust-pyo3-build-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config-devel}"
SRC_URI[aarch64_rust-pyo3-build-config-devel.sha256sum] = "d7fdc5e012e3232ea067473687800b01482d0c616f5fead49d04baf657181672"

RDEPENDS:rust-pyo3-build-config+abi3-devel = " \
 cargo \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+abi3-py310-devel = " \
 cargo \
 rust-pyo3-build-config+abi3-py311-devel \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+abi3-py311-devel = " \
 cargo \
 rust-pyo3-build-config+abi3-py312-devel \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+abi3-py312-devel = " \
 cargo \
 rust-pyo3-build-config+abi3-py313-devel \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+abi3-py313-devel = " \
 cargo \
 rust-pyo3-build-config+abi3-devel \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+abi3-py37-devel = " \
 cargo \
 rust-pyo3-build-config+abi3-py38-devel \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+abi3-py38-devel = " \
 cargo \
 rust-pyo3-build-config+abi3-py39-devel \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+abi3-py39-devel = " \
 cargo \
 rust-pyo3-build-config+abi3-py310-devel \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+default-devel = " \
 cargo \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+extension-module-devel = " \
 cargo \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+resolve-config-devel = " \
 cargo \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config-devel = " \
 cargo \
 python3 \
 rust \
 rust-once_cell+default-devel \
 rust-target-lexicon+default-devel \
 "
