# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "filezilla"
PV = "3.69.3"
PR = "1.el10_1"
PACKAGES = " \
 filezilla \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/filezilla-3.69.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4b6a5bf02066f090b42b6a217f9369d6d741b32ac3d2dca597e1a7022b23b6e5"

URI_x86_64_v2_filezilla = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/filezilla-3.69.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_filezilla;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_filezilla}"
SRC_URI[x86_64_v2_filezilla.sha256sum] = "cfac4ec5a58df8dd7af9d4a9db2607db2acf3d5236a24aff7c5f7aa0225c6b9d"

URI_aarch64_filezilla = "${EPEL_MIRROR}/aarch64/Packages/f/filezilla-3.69.3-1.el10_1.aarch64.rpm;name=aarch64_filezilla;unpack=0"
SRC_URI:append = " ${URI_aarch64_filezilla}"
SRC_URI[aarch64_filezilla.sha256sum] = "21efe97fa456984549c29b6573663d7ed28b7ff473c2fec4ac741691b64a6100"

RDEPENDS:filezilla = " \
 dbus-libs \
 glibc \
 gtk3 \
 libfilezilla \
 libgcc \
 libstdc++ \
 nettle \
 pugixml \
 sqlite-libs \
 wxBase \
 wxGTK \
 xdg-utils \
 "
