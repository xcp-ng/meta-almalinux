# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Any-Moose"
PV = "0.27"
PR = "27.el10_0"
PACKAGES = " \
 perl-Any-Moose \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Any-Moose-0.27-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4aba8df6071f1ad952b465fb19d49e3ceac06a443999aa0dead95a31c2b99205"

URI_x86_64_v2_perl-Any-Moose = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Any-Moose-0.27-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Any-Moose;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Any-Moose}"
SRC_URI[x86_64_v2_perl-Any-Moose.sha256sum] = "cfe7ae2fe987f38bd57a3af5c3d2258d723ee21ecf801614397d5aa22e3e3378"

URI_aarch64_perl-Any-Moose = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Any-Moose-0.27-27.el10_0.noarch.rpm;name=aarch64_perl-Any-Moose;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Any-Moose}"
SRC_URI[aarch64_perl-Any-Moose.sha256sum] = "5c2a39575e683d6f036aa51ee1e44691d7cd5d42ff5c037b3fdf009201db297d"

RDEPENDS:perl-Any-Moose = " \
 perl-Carp \
 perl-libs \
 virtual/perl_Any-Moose__ge_0.40 \
 "
