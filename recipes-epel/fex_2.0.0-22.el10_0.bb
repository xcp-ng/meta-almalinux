# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fex"
PV = "2.0.0"
PR = "22.el10_0"
PACKAGES = " \
 fex \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fex-2.0.0-22.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "17fa5e4db76c960c10b46e089c45b08559bfee3b62cb150a9c9269568be56462"

URI_x86_64_v2_fex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fex-2.0.0-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fex}"
SRC_URI[x86_64_v2_fex.sha256sum] = "927fed33c834d2dec24aa65ebab87f19b4710f562e1a93d713718440e36eee2d"

URI_aarch64_fex = "${EPEL_MIRROR}/aarch64/Packages/f/fex-2.0.0-22.el10_0.aarch64.rpm;name=aarch64_fex;unpack=0"
SRC_URI:append = " ${URI_aarch64_fex}"
SRC_URI[aarch64_fex.sha256sum] = "96f4bb8a62a5c9e4ccc95867f3dcfc55493d2fe6c22947261d02fc455cfd6bed"

RDEPENDS:fex = " \
 glibc \
 "
