# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lskat"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 lskat \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/lskat-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "19e3762fc841cebdd9df0e63813eba697db0a3a770742438a821265cdbd59544"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lskat-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lskat;unpack=0"
SRC_URI[x86_64_v2_lskat.sha256sum] = "b69b6c9cd0403367b96a3e9322573c6857b1a82f517986d118734223420ec2c9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lskat-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_lskat;unpack=0"
SRC_URI[aarch64_lskat.sha256sum] = "eec96e5ee1a38acedb2a046f5f89018c842f4d673a429d2c04baf90df8b635a4"

RDEPENDS:lskat = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
