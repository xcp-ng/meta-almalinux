# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_pcg"
PV = "0.10.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-rand_pcg+default-devel \
 rust-rand_pcg+serde-devel \
 rust-rand_pcg-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_pcg-0.10.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "741f77374130a0e4baf0ad5b1ec111ac8bbd3a4436f7bff64a863374b0e2a75a"

URI_x86_64_v2_rust-rand_pcg+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_pcg+default-devel-0.10.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_pcg+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_pcg+default-devel}"
SRC_URI[x86_64_v2_rust-rand_pcg+default-devel.sha256sum] = "808cfb8f59d1d2408a680bc7facaa72aa94fb99bede2b6a1cd0b66ca33c849db"

URI_x86_64_v2_rust-rand_pcg+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_pcg+serde-devel-0.10.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_pcg+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_pcg+serde-devel}"
SRC_URI[x86_64_v2_rust-rand_pcg+serde-devel.sha256sum] = "035579c921fc74ca27b7969c2a1fce288e3042efb2b76a769f4bc62a6c05b107"

URI_x86_64_v2_rust-rand_pcg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_pcg-devel-0.10.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_pcg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_pcg-devel}"
SRC_URI[x86_64_v2_rust-rand_pcg-devel.sha256sum] = "c19deda6d56b16ad320ae66649437eec73d3fe7b20f09381f30b3570ede70911"

URI_aarch64_rust-rand_pcg+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_pcg+default-devel-0.10.2-1.el10_3.noarch.rpm;name=aarch64_rust-rand_pcg+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_pcg+default-devel}"
SRC_URI[aarch64_rust-rand_pcg+default-devel.sha256sum] = "76c66758da3c1d4cd736294ead2dc4e0bdf0792094a16f18f3d3f60a876f8f82"

URI_aarch64_rust-rand_pcg+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_pcg+serde-devel-0.10.2-1.el10_3.noarch.rpm;name=aarch64_rust-rand_pcg+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_pcg+serde-devel}"
SRC_URI[aarch64_rust-rand_pcg+serde-devel.sha256sum] = "0ae7e7281b7517b7e29a902cac03b07e371f124b7fd7183fbe57f8c920695bb3"

URI_aarch64_rust-rand_pcg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_pcg-devel-0.10.2-1.el10_3.noarch.rpm;name=aarch64_rust-rand_pcg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_pcg-devel}"
SRC_URI[aarch64_rust-rand_pcg-devel.sha256sum] = "ee056e824fc106b9ace4e71e2bdedd4c15fbc564d2aee84fc63fc65cb13b3ffb"

RDEPENDS:rust-rand_pcg+default-devel = " \
 cargo \
 rust-rand_pcg-devel \
 "
RDEPENDS:rust-rand_pcg+serde-devel = " \
 cargo \
 rust-rand_pcg-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand_pcg-devel = " \
 cargo \
 rust \
 rust-rand_core+default-devel \
 "
