# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-vault"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 plasma-vault \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-vault-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6641402831e99b6dacbd3828768c8ae4fc3553dbe46bfc3389fb99154647b25"

URI_x86_64_v2_plasma-vault = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-vault-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-vault;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-vault}"
SRC_URI[x86_64_v2_plasma-vault.sha256sum] = "4aa9b54db4d9da59f3ead53b727b1a7cb7380a7b85212f4189a63108d181c5e6"

URI_aarch64_plasma-vault = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-vault-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-vault;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-vault}"
SRC_URI[aarch64_plasma-vault.sha256sum] = "57299040df4afaefe16c0c4ee22fce10ac29d81535eddc6c9ea2c7c2e2217f6b"

RDEPENDS:plasma-vault = " \
 glibc \
 gocryptfs \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libgcc \
 libksysguard \
 libplasma \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
