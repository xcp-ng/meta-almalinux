# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bcrypt"
PV = "0.17.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-bcrypt+alloc-devel \
 rust-bcrypt+default-devel \
 rust-bcrypt+getrandom-devel \
 rust-bcrypt+std-devel \
 rust-bcrypt+zeroize-devel \
 rust-bcrypt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bcrypt-0.17.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c738b4b35d52765890d7cfb5dc421b616ea35143ac22d034a493f7f8f85d4f3b"

URI_x86_64_v2_rust-bcrypt+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bcrypt+alloc-devel-0.17.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bcrypt+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bcrypt+alloc-devel}"
SRC_URI[x86_64_v2_rust-bcrypt+alloc-devel.sha256sum] = "6146f7af1749e08862b504a161559da16cfee6effa2d4c9f16c8d06bce5ba4e3"

URI_x86_64_v2_rust-bcrypt+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bcrypt+default-devel-0.17.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bcrypt+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bcrypt+default-devel}"
SRC_URI[x86_64_v2_rust-bcrypt+default-devel.sha256sum] = "0c5c1ad4c10281ea81c5bf447bb948a4cba5f860b96ac968a9d8714b0abe9c73"

URI_x86_64_v2_rust-bcrypt+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bcrypt+getrandom-devel-0.17.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bcrypt+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bcrypt+getrandom-devel}"
SRC_URI[x86_64_v2_rust-bcrypt+getrandom-devel.sha256sum] = "57dde83fcae6c95dec569b2283ae2bcf9ec9e48861173a3a36b688f6030a0548"

URI_x86_64_v2_rust-bcrypt+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bcrypt+std-devel-0.17.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bcrypt+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bcrypt+std-devel}"
SRC_URI[x86_64_v2_rust-bcrypt+std-devel.sha256sum] = "dd9934ba7208b917726b56db34b28fc14c74d7002b4ada8cdd6faeecd07845b1"

URI_x86_64_v2_rust-bcrypt+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bcrypt+zeroize-devel-0.17.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bcrypt+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bcrypt+zeroize-devel}"
SRC_URI[x86_64_v2_rust-bcrypt+zeroize-devel.sha256sum] = "b80f161b8d432de767034dd708e7d7593054bb65a123ba82c458e3ebbce4cb87"

URI_x86_64_v2_rust-bcrypt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bcrypt-devel-0.17.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bcrypt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bcrypt-devel}"
SRC_URI[x86_64_v2_rust-bcrypt-devel.sha256sum] = "b5edbc0b40c881729fe41ed8af1356277cf148984bd46d23abb7ece976f7ed3d"

URI_aarch64_rust-bcrypt+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bcrypt+alloc-devel-0.17.1-1.el10_2.noarch.rpm;name=aarch64_rust-bcrypt+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bcrypt+alloc-devel}"
SRC_URI[aarch64_rust-bcrypt+alloc-devel.sha256sum] = "6d065d7f68745c6548bd25239d6b22ed50e623ffb8d3bd76391f60f54fe2ce20"

URI_aarch64_rust-bcrypt+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bcrypt+default-devel-0.17.1-1.el10_2.noarch.rpm;name=aarch64_rust-bcrypt+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bcrypt+default-devel}"
SRC_URI[aarch64_rust-bcrypt+default-devel.sha256sum] = "4ecad006a22f1e0310efd8705e3c1eaf6c0a6be21e8da377ee361d3927035949"

URI_aarch64_rust-bcrypt+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bcrypt+getrandom-devel-0.17.1-1.el10_2.noarch.rpm;name=aarch64_rust-bcrypt+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bcrypt+getrandom-devel}"
SRC_URI[aarch64_rust-bcrypt+getrandom-devel.sha256sum] = "ce5a07016d12d5b357a866a24fae48cc4c3e834f296b9db6cff623d0f919ff71"

URI_aarch64_rust-bcrypt+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bcrypt+std-devel-0.17.1-1.el10_2.noarch.rpm;name=aarch64_rust-bcrypt+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bcrypt+std-devel}"
SRC_URI[aarch64_rust-bcrypt+std-devel.sha256sum] = "f66a4f4f865c469ff13033c12c5994e4f3f5f526b82de063aa9414c84b6c2f61"

URI_aarch64_rust-bcrypt+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bcrypt+zeroize-devel-0.17.1-1.el10_2.noarch.rpm;name=aarch64_rust-bcrypt+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bcrypt+zeroize-devel}"
SRC_URI[aarch64_rust-bcrypt+zeroize-devel.sha256sum] = "90fd17f127c539d04db3703147b4f84ec0575f8dcf4c9344d95f2ed50a5fee80"

URI_aarch64_rust-bcrypt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bcrypt-devel-0.17.1-1.el10_2.noarch.rpm;name=aarch64_rust-bcrypt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bcrypt-devel}"
SRC_URI[aarch64_rust-bcrypt-devel.sha256sum] = "89165cf64768118065302a64011bb90a95b485c01fa7ff6e83a2e34471acdbfd"

RDEPENDS:rust-bcrypt+alloc-devel = " \
 cargo \
 rust-base64_0.22+alloc-devel \
 rust-bcrypt+getrandom-devel \
 rust-bcrypt-devel \
 "
RDEPENDS:rust-bcrypt+default-devel = " \
 cargo \
 rust-bcrypt+std-devel \
 rust-bcrypt+zeroize-devel \
 rust-bcrypt-devel \
 "
RDEPENDS:rust-bcrypt+getrandom-devel = " \
 cargo \
 rust-bcrypt-devel \
 rust-getrandom0.3-devel \
 "
RDEPENDS:rust-bcrypt+std-devel = " \
 cargo \
 rust-base64_0.22+std-devel \
 rust-bcrypt-devel \
 rust-getrandom0.3+std-devel \
 rust-getrandom0.3-devel \
 "
RDEPENDS:rust-bcrypt+zeroize-devel = " \
 cargo \
 rust-bcrypt-devel \
 rust-zeroize+default-devel \
 "
RDEPENDS:rust-bcrypt-devel = " \
 cargo \
 rust-base64_0.22-devel \
 rust-blowfish0.9+bcrypt-devel \
 rust-blowfish0.9+default-devel \
 rust-subtle-devel \
 "
