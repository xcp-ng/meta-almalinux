# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "llvm20"
PV = "20.1.8"
PR = "9.el10_3"
PACKAGES = " \
 clang20 \
 clang20-analyzer \
 clang20-devel \
 clang20-libs \
 clang20-resource-filesystem \
 clang20-tools-extra \
 clang20-tools-extra-devel \
 compiler-rt20 \
 git-clang-format20 \
 libomp20 \
 libomp20-devel \
 lld20 \
 lld20-devel \
 lld20-libs \
 lldb20 \
 lldb20-devel \
 llvm20 \
 llvm20-cmake-utils \
 llvm20-devel \
 llvm20-doc \
 llvm20-filesystem \
 llvm20-googletest \
 llvm20-libs \
 llvm20-static \
 llvm20-test \
 llvm20-toolset \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/llvm20-20.1.8-9.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e98dbb7251c6820eb49908517b97bb2bf3f91990e4a449e01b0cd64bd330ae13"

URI_x86_64_v2_clang20 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clang20-20.1.8-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clang20;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang20}"
SRC_URI[x86_64_v2_clang20.sha256sum] = "c31adcc49d45714bb47d75d5e9e389c5cb30f121d722499bd3a771f3cb563d2a"

URI_x86_64_v2_clang20-analyzer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clang20-analyzer-20.1.8-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clang20-analyzer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang20-analyzer}"
SRC_URI[x86_64_v2_clang20-analyzer.sha256sum] = "125b2dd40ebacc42c95cd5847d738862d03928034e13c02746f6d6120a55716a"

URI_x86_64_v2_clang20-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clang20-devel-20.1.8-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clang20-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang20-devel}"
SRC_URI[x86_64_v2_clang20-devel.sha256sum] = "a62adf9f1d926cdb5206915ec067a996d2fdd83bb672bae7c4ec03d9c4d21d8a"

URI_x86_64_v2_clang20-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clang20-libs-20.1.8-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clang20-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang20-libs}"
SRC_URI[x86_64_v2_clang20-libs.sha256sum] = "6cd67ddb5eb7ac4c7f59146294f2f877950c2f6460e3153a35c98a7f0ce746da"

URI_x86_64_v2_clang20-resource-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clang20-resource-filesystem-20.1.8-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clang20-resource-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang20-resource-filesystem}"
SRC_URI[x86_64_v2_clang20-resource-filesystem.sha256sum] = "97fc53d17a3424419aa67e49229b33316b3c837039aabf4153289c0f920e1ab6"

URI_x86_64_v2_clang20-tools-extra = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clang20-tools-extra-20.1.8-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clang20-tools-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang20-tools-extra}"
SRC_URI[x86_64_v2_clang20-tools-extra.sha256sum] = "c45b07223c3ab3a8f35ea927c22d5a8804e78659557668e5f089a9fa8f431f19"

URI_x86_64_v2_clang20-tools-extra-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clang20-tools-extra-devel-20.1.8-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clang20-tools-extra-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang20-tools-extra-devel}"
SRC_URI[x86_64_v2_clang20-tools-extra-devel.sha256sum] = "b3f9d9d02c9196420436286bc408c65b1588b820d7a53b806bbb06f5bad35f2e"

URI_x86_64_v2_compiler-rt20 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/compiler-rt20-20.1.8-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_compiler-rt20;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_compiler-rt20}"
SRC_URI[x86_64_v2_compiler-rt20.sha256sum] = "fcd24ca4d61f253969b04637157551896a65bf83be9fed640c7bbbb65b1600b0"

URI_x86_64_v2_git-clang-format20 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/git-clang-format20-20.1.8-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_git-clang-format20;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-clang-format20}"
SRC_URI[x86_64_v2_git-clang-format20.sha256sum] = "5830e163915db792316f0800010c5cffe424dc6a34d476178114ce7b9948edb4"

URI_x86_64_v2_libomp20 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libomp20-20.1.8-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libomp20;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libomp20}"
SRC_URI[x86_64_v2_libomp20.sha256sum] = "9578452b86fae190e333aa8da6dbf75e53215a977922ce47423018bfbda5fe76"
RPROVIDES:libomp20:x86_64_v2 = "virtual/libomp.so_VERSION__64bit_ virtual/libomp.so___64bit_"

URI_x86_64_v2_libomp20-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libomp20-devel-20.1.8-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libomp20-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libomp20-devel}"
SRC_URI[x86_64_v2_libomp20-devel.sha256sum] = "5413ebc940d7af21ceb4765043afbe08317105294b3f71c820bcc72797ae884d"

URI_x86_64_v2_lld20 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lld20-20.1.8-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lld20;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lld20}"
SRC_URI[x86_64_v2_lld20.sha256sum] = "7209a8d87b98bbb8248f811492295fa3571b1e541fdf4e10533f4865a4356e80"

URI_x86_64_v2_lld20-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lld20-devel-20.1.8-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lld20-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lld20-devel}"
SRC_URI[x86_64_v2_lld20-devel.sha256sum] = "2d171512c0bf419eda5ca72655b25cc569f590eb463ecadb0c6578419ead9f0d"

URI_x86_64_v2_lld20-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lld20-libs-20.1.8-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lld20-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lld20-libs}"
SRC_URI[x86_64_v2_lld20-libs.sha256sum] = "af581a2522f1e962a88cec11b62e8fd526b84a463c83b5a8ce4e656f6209263f"

URI_x86_64_v2_lldb20 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lldb20-20.1.8-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lldb20;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lldb20}"
SRC_URI[x86_64_v2_lldb20.sha256sum] = "22106dd0486fdedefc372d7909cd739d36198ee7d180ea12bf7ab5da1481c52e"

URI_x86_64_v2_lldb20-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lldb20-devel-20.1.8-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lldb20-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lldb20-devel}"
SRC_URI[x86_64_v2_lldb20-devel.sha256sum] = "4502813fc398f5ddeb592f9f03c9fa3da87d2425e01ddb0b5bdfdbb6d7029667"

URI_x86_64_v2_llvm20 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm20-20.1.8-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm20;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm20}"
SRC_URI[x86_64_v2_llvm20.sha256sum] = "1f07a8e8b8e3c78ec34f6d2d2fc8e458f40c80ce851ce9c3b8a1b23b399adb39"

URI_x86_64_v2_llvm20-cmake-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm20-cmake-utils-20.1.8-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm20-cmake-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm20-cmake-utils}"
SRC_URI[x86_64_v2_llvm20-cmake-utils.sha256sum] = "0eeb41e3cabf384ad5d34ac9cd6fcedf1cbae6526f5c6ddc34ba8d5352ab32d2"

URI_x86_64_v2_llvm20-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm20-devel-20.1.8-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm20-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm20-devel}"
SRC_URI[x86_64_v2_llvm20-devel.sha256sum] = "06c99d4589213da75ad08d07decac9b4ed0ad3cb9dcedb2fc965bd00eb7eb838"

URI_x86_64_v2_llvm20-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm20-doc-20.1.8-9.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_llvm20-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm20-doc}"
SRC_URI[x86_64_v2_llvm20-doc.sha256sum] = "43fee183cb7397e9c7ebdaef503db9e9fe29e7d5fa244d1cf9b7fa22b92f5fcf"

URI_x86_64_v2_llvm20-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm20-filesystem-20.1.8-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm20-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm20-filesystem}"
SRC_URI[x86_64_v2_llvm20-filesystem.sha256sum] = "2cb3c0bd60324e84c4c3d9ca393d79115660679f05679a426f09a8f604c635c8"

URI_x86_64_v2_llvm20-googletest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm20-googletest-20.1.8-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm20-googletest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm20-googletest}"
SRC_URI[x86_64_v2_llvm20-googletest.sha256sum] = "c770f4232ce1b89a1f8e9fba5308a1c517e6d408c37986c266df47a5a2cb8d2b"

URI_x86_64_v2_llvm20-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm20-libs-20.1.8-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm20-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm20-libs}"
SRC_URI[x86_64_v2_llvm20-libs.sha256sum] = "29e6e83ba824aacf867be97774072c68c8e97b15a18c06e4654c53ab56406b15"

URI_x86_64_v2_llvm20-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm20-static-20.1.8-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm20-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm20-static}"
SRC_URI[x86_64_v2_llvm20-static.sha256sum] = "1857bf1193427937ed2302fb07eb9153fe1f2cb46248b4ef27d04a9f6a4c1e49"

URI_x86_64_v2_llvm20-test = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm20-test-20.1.8-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm20-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm20-test}"
SRC_URI[x86_64_v2_llvm20-test.sha256sum] = "021730dfde7bee032ed9436be7b641a3c9ee20a68635e36b1deab46a9fd54630"

URI_x86_64_v2_llvm20-toolset = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm20-toolset-20.1.8-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm20-toolset;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm20-toolset}"
SRC_URI[x86_64_v2_llvm20-toolset.sha256sum] = "375b49afa0a8ebffd2e41fe6ee399a9a6aafc3a0a8026d9be965ff5e84b12b55"

URI_aarch64_clang20 = "${EPEL_MIRROR}/aarch64/Packages/c/clang20-20.1.8-9.el10_3.aarch64.rpm;name=aarch64_clang20;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang20}"
SRC_URI[aarch64_clang20.sha256sum] = "20b9c9ed309829e3be59b6dd92b07d94a48291c255c269e7db99391224e8b07c"

URI_aarch64_clang20-analyzer = "${EPEL_MIRROR}/aarch64/Packages/c/clang20-analyzer-20.1.8-9.el10_3.aarch64.rpm;name=aarch64_clang20-analyzer;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang20-analyzer}"
SRC_URI[aarch64_clang20-analyzer.sha256sum] = "5e7a26f5f43f3d88fadf721af2140e5237e76b7331b55a098731dda5c6b1441d"

URI_aarch64_clang20-devel = "${EPEL_MIRROR}/aarch64/Packages/c/clang20-devel-20.1.8-9.el10_3.aarch64.rpm;name=aarch64_clang20-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang20-devel}"
SRC_URI[aarch64_clang20-devel.sha256sum] = "0d265b6a8a09b2810ed94d1b1539b8fc8a815c8a613b1cbf0702db6b675503cd"

URI_aarch64_clang20-libs = "${EPEL_MIRROR}/aarch64/Packages/c/clang20-libs-20.1.8-9.el10_3.aarch64.rpm;name=aarch64_clang20-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang20-libs}"
SRC_URI[aarch64_clang20-libs.sha256sum] = "bef915c79be3494a0ca93420272607c6fa0cf984b0f3c4d971787647e3320e11"

URI_aarch64_clang20-resource-filesystem = "${EPEL_MIRROR}/aarch64/Packages/c/clang20-resource-filesystem-20.1.8-9.el10_3.aarch64.rpm;name=aarch64_clang20-resource-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang20-resource-filesystem}"
SRC_URI[aarch64_clang20-resource-filesystem.sha256sum] = "6032e5b4405e513acda956855700177ff8b7ba8a1c3785fc60c457d55aa1b62c"

URI_aarch64_clang20-tools-extra = "${EPEL_MIRROR}/aarch64/Packages/c/clang20-tools-extra-20.1.8-9.el10_3.aarch64.rpm;name=aarch64_clang20-tools-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang20-tools-extra}"
SRC_URI[aarch64_clang20-tools-extra.sha256sum] = "349f9ecbc1f5b670c059e42c38400691a364805fa1a21b682f47ac7e8e30c59b"

URI_aarch64_clang20-tools-extra-devel = "${EPEL_MIRROR}/aarch64/Packages/c/clang20-tools-extra-devel-20.1.8-9.el10_3.aarch64.rpm;name=aarch64_clang20-tools-extra-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang20-tools-extra-devel}"
SRC_URI[aarch64_clang20-tools-extra-devel.sha256sum] = "8e12d9852f6255131d950348fd16949ab0b03104bcf1dd3b03c93df45cac6bbf"

URI_aarch64_compiler-rt20 = "${EPEL_MIRROR}/aarch64/Packages/c/compiler-rt20-20.1.8-9.el10_3.aarch64.rpm;name=aarch64_compiler-rt20;unpack=0"
SRC_URI:append = " ${URI_aarch64_compiler-rt20}"
SRC_URI[aarch64_compiler-rt20.sha256sum] = "9c152eed08d2d6e53d13c9dc8cb4b41c936a4cacf0b9e3c0085d873ded1f6ef9"

URI_aarch64_git-clang-format20 = "${EPEL_MIRROR}/aarch64/Packages/g/git-clang-format20-20.1.8-9.el10_3.aarch64.rpm;name=aarch64_git-clang-format20;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-clang-format20}"
SRC_URI[aarch64_git-clang-format20.sha256sum] = "c6ed79dcd4f343ede9dba36b962269fc071f051bc164fe919b80995519cedaa0"

URI_aarch64_libomp20 = "${EPEL_MIRROR}/aarch64/Packages/l/libomp20-20.1.8-9.el10_3.aarch64.rpm;name=aarch64_libomp20;unpack=0"
SRC_URI:append = " ${URI_aarch64_libomp20}"
SRC_URI[aarch64_libomp20.sha256sum] = "bf9ce80b40af54fd46a42fd390d2a61c6e6f338d636b92abbfff8147e0a9ab33"

URI_aarch64_libomp20-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libomp20-devel-20.1.8-9.el10_3.aarch64.rpm;name=aarch64_libomp20-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libomp20-devel}"
SRC_URI[aarch64_libomp20-devel.sha256sum] = "fa7c37759ff944bba67aae333277a6414fb514ee9081dd85c99dc1f48a9f69ca"

URI_aarch64_lld20 = "${EPEL_MIRROR}/aarch64/Packages/l/lld20-20.1.8-9.el10_3.aarch64.rpm;name=aarch64_lld20;unpack=0"
SRC_URI:append = " ${URI_aarch64_lld20}"
SRC_URI[aarch64_lld20.sha256sum] = "300cd014285d9e1c01c86c1471d9062fd899fd0546fcad9ba4eb943a39356ef6"

URI_aarch64_lld20-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lld20-devel-20.1.8-9.el10_3.aarch64.rpm;name=aarch64_lld20-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lld20-devel}"
SRC_URI[aarch64_lld20-devel.sha256sum] = "351501be0bffda0b24bca8517223a6b70e34354b5d7a0e68d14a59716c17cdab"

URI_aarch64_lld20-libs = "${EPEL_MIRROR}/aarch64/Packages/l/lld20-libs-20.1.8-9.el10_3.aarch64.rpm;name=aarch64_lld20-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_lld20-libs}"
SRC_URI[aarch64_lld20-libs.sha256sum] = "49238afd9e2f9a9d32d558c1fd54d5fb906c0a690b6e400b289777dd20f32db2"

URI_aarch64_lldb20 = "${EPEL_MIRROR}/aarch64/Packages/l/lldb20-20.1.8-9.el10_3.aarch64.rpm;name=aarch64_lldb20;unpack=0"
SRC_URI:append = " ${URI_aarch64_lldb20}"
SRC_URI[aarch64_lldb20.sha256sum] = "66e25d2943d5e8dfc05d7b271d0aa736e4ac128df01d453681597113ece8ecdc"

URI_aarch64_lldb20-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lldb20-devel-20.1.8-9.el10_3.aarch64.rpm;name=aarch64_lldb20-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lldb20-devel}"
SRC_URI[aarch64_lldb20-devel.sha256sum] = "6838d9d70fc214bcba85d9523dee2bb0f8723326c7615a9f18e317e9b4f26b63"

URI_aarch64_llvm20 = "${EPEL_MIRROR}/aarch64/Packages/l/llvm20-20.1.8-9.el10_3.aarch64.rpm;name=aarch64_llvm20;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm20}"
SRC_URI[aarch64_llvm20.sha256sum] = "9d3ba3942b3c6d1aa46bbcc0e91fb28cb3f98f28fe2c2bed86a43418ec35f262"

URI_aarch64_llvm20-cmake-utils = "${EPEL_MIRROR}/aarch64/Packages/l/llvm20-cmake-utils-20.1.8-9.el10_3.aarch64.rpm;name=aarch64_llvm20-cmake-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm20-cmake-utils}"
SRC_URI[aarch64_llvm20-cmake-utils.sha256sum] = "06e7d03f0803514cec67c3ae5024d2ec82da91d428a404f68c20f7f74423ad09"

URI_aarch64_llvm20-devel = "${EPEL_MIRROR}/aarch64/Packages/l/llvm20-devel-20.1.8-9.el10_3.aarch64.rpm;name=aarch64_llvm20-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm20-devel}"
SRC_URI[aarch64_llvm20-devel.sha256sum] = "0e30ffbe798c76990bb871939c9da1e2c9c3650843751784efb7c1d2ef98a5e9"

URI_aarch64_llvm20-doc = "${EPEL_MIRROR}/aarch64/Packages/l/llvm20-doc-20.1.8-9.el10_3.noarch.rpm;name=aarch64_llvm20-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm20-doc}"
SRC_URI[aarch64_llvm20-doc.sha256sum] = "7b41c4b9cda6977e70d63c5b1bce4e0e86734265250ac93302bacdca96e4f06b"

URI_aarch64_llvm20-filesystem = "${EPEL_MIRROR}/aarch64/Packages/l/llvm20-filesystem-20.1.8-9.el10_3.aarch64.rpm;name=aarch64_llvm20-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm20-filesystem}"
SRC_URI[aarch64_llvm20-filesystem.sha256sum] = "7048faebca76ee8518efd9a132e975b70c87a0218833b74a4dd54d4735668ffa"

URI_aarch64_llvm20-googletest = "${EPEL_MIRROR}/aarch64/Packages/l/llvm20-googletest-20.1.8-9.el10_3.aarch64.rpm;name=aarch64_llvm20-googletest;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm20-googletest}"
SRC_URI[aarch64_llvm20-googletest.sha256sum] = "14ad6096c7e0f5e921d821000746fa86dbd40f6ff3bc626e95f2242f7b8e4c7b"

URI_aarch64_llvm20-libs = "${EPEL_MIRROR}/aarch64/Packages/l/llvm20-libs-20.1.8-9.el10_3.aarch64.rpm;name=aarch64_llvm20-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm20-libs}"
SRC_URI[aarch64_llvm20-libs.sha256sum] = "d3d29a9cc46db0734250a5f94e1870cd4c8855c68439a3e3f912ee4c0b3c7d8f"

URI_aarch64_llvm20-static = "${EPEL_MIRROR}/aarch64/Packages/l/llvm20-static-20.1.8-9.el10_3.aarch64.rpm;name=aarch64_llvm20-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm20-static}"
SRC_URI[aarch64_llvm20-static.sha256sum] = "19d262825221b9c477a50dc7cb8afa359a128058757aef784a6f24bfbdd51fd1"

URI_aarch64_llvm20-test = "${EPEL_MIRROR}/aarch64/Packages/l/llvm20-test-20.1.8-9.el10_3.aarch64.rpm;name=aarch64_llvm20-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm20-test}"
SRC_URI[aarch64_llvm20-test.sha256sum] = "ce5bc738e1bd8e91601d392d09938fc8bbae6c0ba42c6891d0971826e0a3b48f"

URI_aarch64_llvm20-toolset = "${EPEL_MIRROR}/aarch64/Packages/l/llvm20-toolset-20.1.8-9.el10_3.aarch64.rpm;name=aarch64_llvm20-toolset;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm20-toolset}"
SRC_URI[aarch64_llvm20-toolset.sha256sum] = "2f419d46f2037f9a3e24c52a5e21fd42c871cc1565943e83685d14c43853fce0"

RDEPENDS:clang20 = " \
 clang20-libs \
 gcc-c++ \
 glibc \
 libgcc \
 libstdc++ \
 libstdc++-devel \
 llvm20-libs \
 "
RDEPENDS:clang20-analyzer = " \
 clang20 \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-FindBin \
 perl-Hash-Util \
 perl-PathTools \
 perl-Sys-Hostname \
 perl-Term-ANSIColor \
 perl-Text-ParseWords \
 perl-interpreter \
 perl-lib \
 perl-libs \
 python3 \
 "
RDEPENDS:clang20-devel = " \
 clang20 \
 clang20-libs \
 clang20-tools-extra \
 glibc \
 libgcc \
 libstdc++ \
 llvm20-devel \
 "
RDEPENDS:clang20-libs = " \
 clang20-resource-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 llvm20-libs \
 "
RDEPENDS:clang20-resource-filesystem = " \
 "
RDEPENDS:clang20-tools-extra = " \
 clang20-libs \
 emacs-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 libxml2 \
 llvm20-libs \
 python3 \
 "
RDEPENDS:clang20-tools-extra-devel = " \
 clang20-tools-extra \
 "
RDEPENDS:compiler-rt20 = " \
 clang20-resource-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
RDEPENDS:git-clang-format20 = " \
 clang20-tools-extra \
 git \
 python3 \
 "
RDEPENDS:libomp20 = " \
 elfutils-libelf \
 glibc \
 libffi \
 libgcc \
 libstdc++ \
 llvm20-libs \
 "
RDEPENDS:libomp20-devel = " \
 clang20-resource-filesystem \
 libomp20 \
 "
RDEPENDS:lld20 = " \
 alternatives \
 glibc \
 libgcc \
 libstdc++ \
 lld20-libs \
 llvm20-libs \
 "
RDEPENDS:lld20-devel = " \
 lld20-libs \
 "
RDEPENDS:lld20-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 llvm20-libs \
 zlib-ng-compat \
 "
RDEPENDS:lldb20 = " \
 clang20-libs \
 glibc \
 libedit \
 libgcc \
 libstdc++ \
 libxml2 \
 llvm20-libs \
 ncurses-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:lldb20-devel = " \
 lldb20 \
 "
RDEPENDS:llvm20 = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 llvm20-libs \
 python3 \
 zlib-ng-compat \
 "
RDEPENDS:llvm20-cmake-utils = " \
 llvm20-filesystem \
 "
RDEPENDS:llvm20-devel = " \
 alternatives \
 bash \
 glibc \
 libedit-devel \
 libgcc \
 libstdc++ \
 libzstd-devel \
 llvm20 \
 llvm20-googletest \
 llvm20-libs \
 llvm20-static \
 llvm20-test \
 "
RDEPENDS:llvm20-doc = " \
 llvm20 \
 "
RDEPENDS:llvm20-filesystem = " \
 "
RDEPENDS:llvm20-googletest = " \
 llvm20-filesystem \
 "
RDEPENDS:llvm20-libs = " \
 glibc \
 libedit \
 libffi \
 libgcc \
 libstdc++ \
 libxml2 \
 libzstd \
 llvm20-filesystem \
 zlib-ng-compat \
 "
RDEPENDS:llvm20-static = " \
 llvm20-filesystem \
 "
RDEPENDS:llvm20-test = " \
 glibc \
 libgcc \
 libstdc++ \
 llvm20 \
 llvm20-libs \
 "
RDEPENDS:llvm20-toolset = " \
 clang20 \
 lld20 \
 llvm20 \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/libomp.so_VERSION__64bit_ rpm/virtual/libomp.so___64bit_"
