# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "strace"
PV = "6.12"
PR = "1.el10"
PACKAGES = " \
 strace \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/strace-6.12-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fcc271716f9bcfc8f3a4b0793de3c47ac1961a032ef9025ad0284d314bc1851d"

URI_x86_64_v2_strace = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/strace-6.12-1.el10.x86_64_v2.rpm;name=x86_64_v2_strace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_strace}"
SRC_URI[x86_64_v2_strace.sha256sum] = "7f3a71aad68f05411d4f36c52fa54624ea508c136ced6bf055cb9f89aa0b69e6"

URI_aarch64_strace = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/strace-6.12-1.el10.aarch64.rpm;name=aarch64_strace;unpack=0"
SRC_URI:append = " ${URI_aarch64_strace}"
SRC_URI[aarch64_strace.sha256sum] = "b353d5c9ca7ab98cdd36df485627de2ce6342508b5a39a7fbebb6997ad13260a"

RDEPENDS:strace = " \
 bash \
 elfutils-libs \
 glibc \
 libselinux \
 "
