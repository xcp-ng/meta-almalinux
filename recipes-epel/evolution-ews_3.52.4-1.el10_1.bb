# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "evolution-ews"
PV = "3.52.4"
PR = "1.el10_1"
PACKAGES = " \
 evolution-ews \
 evolution-ews-langpacks \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/evolution-ews-3.52.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a3a18ad5a039a07852dd3b45a9bce4012ab49c89cb96673cc918456f4adc0076"

URI_x86_64_v2_evolution-ews = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/evolution-ews-3.52.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_evolution-ews;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_evolution-ews}"
SRC_URI[x86_64_v2_evolution-ews.sha256sum] = "3c7bbfbde1a7c0f0580c6c6b660bc9d14403d6721c52bc0aa4f175fcd7f22405"

URI_x86_64_v2_evolution-ews-langpacks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/evolution-ews-langpacks-3.52.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_evolution-ews-langpacks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_evolution-ews-langpacks}"
SRC_URI[x86_64_v2_evolution-ews-langpacks.sha256sum] = "bce91770740f9ec9ed43800122d67d860a3ba9a7201159e8e349ae5163cd47eb"

URI_aarch64_evolution-ews = "${EPEL_MIRROR}/aarch64/Packages/e/evolution-ews-3.52.4-1.el10_1.aarch64.rpm;name=aarch64_evolution-ews;unpack=0"
SRC_URI:append = " ${URI_aarch64_evolution-ews}"
SRC_URI[aarch64_evolution-ews.sha256sum] = "492ce60e49eef0f786eedb9d536f8d736bace596f8e77496f70a0751270e72e6"

URI_aarch64_evolution-ews-langpacks = "${EPEL_MIRROR}/aarch64/Packages/e/evolution-ews-langpacks-3.52.4-1.el10_1.noarch.rpm;name=aarch64_evolution-ews-langpacks;unpack=0"
SRC_URI:append = " ${URI_aarch64_evolution-ews-langpacks}"
SRC_URI[aarch64_evolution-ews-langpacks.sha256sum] = "08bd8619a849cc4068b79b0e49defd7184f1b000bef986d139010e593e3f17d3"

RDEPENDS:evolution-ews = " \
 evolution \
 evolution-data-server \
 evolution-ews-langpacks \
 glib2 \
 glibc \
 gtk3 \
 json-glib \
 libgcc \
 libical-glib \
 libmspack \
 libsoup3 \
 libxml2 \
 pango \
 "
RDEPENDS:evolution-ews-langpacks = " \
 evolution-ews \
 "
