# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-oslo-serialization"
PV = "5.9.1"
PR = "2.el10_3"
PACKAGES = " \
 python-oslo-serialization-doc \
 python3-oslo-serialization \
 python3-oslo-serialization-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-oslo-serialization-5.9.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f1a76d06ccb593c308211d7a3fde0d0faf0d514d722bd33da4498cec0378d51"

URI_x86_64_v2_python-oslo-serialization-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-oslo-serialization-doc-5.9.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-oslo-serialization-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-oslo-serialization-doc}"
SRC_URI[x86_64_v2_python-oslo-serialization-doc.sha256sum] = "62bae6005084fd10526b3586f3e9a800986dade63c8845219daefd4b1b5ece75"

URI_x86_64_v2_python3-oslo-serialization = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-oslo-serialization-5.9.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-oslo-serialization;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-oslo-serialization}"
SRC_URI[x86_64_v2_python3-oslo-serialization.sha256sum] = "016b0e18cf1a13206208bb67f415c8333e9c3ae04fca55fb9c25377f89025f41"

URI_x86_64_v2_python3-oslo-serialization-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-oslo-serialization-tests-5.9.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-oslo-serialization-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-oslo-serialization-tests}"
SRC_URI[x86_64_v2_python3-oslo-serialization-tests.sha256sum] = "be9168e3bcd9e0ea433bb3b2d9bd507317ab26335ddf1cc2c41e281ec4475fa8"

URI_aarch64_python-oslo-serialization-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-oslo-serialization-doc-5.9.1-2.el10_3.noarch.rpm;name=aarch64_python-oslo-serialization-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-oslo-serialization-doc}"
SRC_URI[aarch64_python-oslo-serialization-doc.sha256sum] = "227cd736fc5a9a867bf7728d441e66a397c773a17e031d75cc63d2cc3631bf39"

URI_aarch64_python3-oslo-serialization = "${EPEL_MIRROR}/aarch64/Packages/p/python3-oslo-serialization-5.9.1-2.el10_3.noarch.rpm;name=aarch64_python3-oslo-serialization;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-oslo-serialization}"
SRC_URI[aarch64_python3-oslo-serialization.sha256sum] = "5dc50ede17661b7b58aee5b60239a8b5e3114ec3b915ad229fa0b71d370236bc"

URI_aarch64_python3-oslo-serialization-tests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-oslo-serialization-tests-5.9.1-2.el10_3.noarch.rpm;name=aarch64_python3-oslo-serialization-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-oslo-serialization-tests}"
SRC_URI[aarch64_python3-oslo-serialization-tests.sha256sum] = "7d27be5a01cef5a3fa5506ef6e7126934d4ffac376a82e3a2a9ae3f98666a902"

RDEPENDS:python-oslo-serialization-doc = " \
 python3-oslo-serialization \
 "
RDEPENDS:python3-oslo-serialization = " \
 python3 \
 python3-msgpack \
 python3-oslo-utils \
 "
RDEPENDS:python3-oslo-serialization-tests = " \
 python3 \
 python3-oslo-serialization \
 "
