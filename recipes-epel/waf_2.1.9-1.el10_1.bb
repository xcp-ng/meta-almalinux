# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "waf"
PV = "2.1.9"
PR = "1.el10_1"
PACKAGES = " \
 waf \
 waf-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/waf-2.1.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "89fdcf8a49b93687e13ef3360fdcfa19d46b33b222d6c0a5611056ed7c92b46b"

URI_x86_64_v2_waf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/waf-2.1.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_waf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_waf}"
SRC_URI[x86_64_v2_waf.sha256sum] = "ee575ca5d25226199c73dd5dda9dc84a3f37ace2d342ab930845a8f44ebaed3d"

URI_x86_64_v2_waf-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/waf-doc-2.1.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_waf-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_waf-doc}"
SRC_URI[x86_64_v2_waf-doc.sha256sum] = "9075b974cf8c7bab453fcfb4979b3fef0413206e592a81f1ac1d6fce06640de2"

URI_aarch64_waf = "${EPEL_MIRROR}/aarch64/Packages/w/waf-2.1.9-1.el10_1.noarch.rpm;name=aarch64_waf;unpack=0"
SRC_URI:append = " ${URI_aarch64_waf}"
SRC_URI[aarch64_waf.sha256sum] = "b30882ca5048b2a9ef8c4fe2818a7c91182f728764af4193e9a24a8262781075"

URI_aarch64_waf-doc = "${EPEL_MIRROR}/aarch64/Packages/w/waf-doc-2.1.9-1.el10_1.noarch.rpm;name=aarch64_waf-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_waf-doc}"
SRC_URI[aarch64_waf-doc.sha256sum] = "38930e510f5a7de1a250f6dbdcf18fcd56f75b1f4e9e2d9a63b14d7a4807db30"

RDEPENDS:waf = " \
 python3 \
 "
RDEPENDS:waf-doc = " \
 waf \
 "
