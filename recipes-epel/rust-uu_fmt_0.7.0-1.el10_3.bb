# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_fmt"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_fmt+default-devel \
 rust-uu_fmt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_fmt-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8610451895d3f16bc2a1b26327bea4e9fd08c27760a51493cee52fa24847c2f9"

URI_x86_64_v2_rust-uu_fmt+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_fmt+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_fmt+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_fmt+default-devel}"
SRC_URI[x86_64_v2_rust-uu_fmt+default-devel.sha256sum] = "365bb4cc71ba15b475c887481bf7643d4c73dd052128497b5d90e2f1bb435dc3"

URI_x86_64_v2_rust-uu_fmt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_fmt-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_fmt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_fmt-devel}"
SRC_URI[x86_64_v2_rust-uu_fmt-devel.sha256sum] = "c72d7df31ee806ba778e9ea36e7ed6b1919b84f4f660b9d2bdd4a10d0e2c54e6"

URI_aarch64_rust-uu_fmt+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_fmt+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_fmt+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_fmt+default-devel}"
SRC_URI[aarch64_rust-uu_fmt+default-devel.sha256sum] = "11b99b49bd3a0be2f23b334f5712e16d76d7c4ff11e246ac87dce95ae60cbfc1"

URI_aarch64_rust-uu_fmt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_fmt-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_fmt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_fmt-devel}"
SRC_URI[aarch64_rust-uu_fmt-devel.sha256sum] = "3566722ed5d7715b232723401ca1ebd23ce8b9e3c598bab620fbda25baa8dbe8"

RDEPENDS:rust-uu_fmt+default-devel = " \
 cargo \
 rust-uu_fmt-devel \
 "
RDEPENDS:rust-uu_fmt-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-thiserror+default-devel \
 rust-unicode-width+default-devel \
 rust-uucore+default-devel \
 "
