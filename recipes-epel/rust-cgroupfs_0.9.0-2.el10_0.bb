# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cgroupfs"
PV = "0.9.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-cgroupfs+default-devel \
 rust-cgroupfs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cgroupfs-0.9.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "08d0d890951c2960fdc311aaf4edcac76fbefec7e29f0e2c51957e6dafa4f3dd"

URI_x86_64_v2_rust-cgroupfs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cgroupfs+default-devel-0.9.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cgroupfs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cgroupfs+default-devel}"
SRC_URI[x86_64_v2_rust-cgroupfs+default-devel.sha256sum] = "ba7a3f22c94684524b412bf8085565ae07f73cf5e88e97ceaf12fe4fe3d0e12d"

URI_x86_64_v2_rust-cgroupfs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cgroupfs-devel-0.9.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cgroupfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cgroupfs-devel}"
SRC_URI[x86_64_v2_rust-cgroupfs-devel.sha256sum] = "3191ce7a305be72e313966e24a0d6d7ceb6e65f83b602eaf09a248ff18231d37"

URI_aarch64_rust-cgroupfs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cgroupfs+default-devel-0.9.0-2.el10_0.noarch.rpm;name=aarch64_rust-cgroupfs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cgroupfs+default-devel}"
SRC_URI[aarch64_rust-cgroupfs+default-devel.sha256sum] = "b732ecf01dccba71232d121c7d4d0202637464067640d086618441c3359ba2b1"

URI_aarch64_rust-cgroupfs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cgroupfs-devel-0.9.0-2.el10_0.noarch.rpm;name=aarch64_rust-cgroupfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cgroupfs-devel}"
SRC_URI[aarch64_rust-cgroupfs-devel.sha256sum] = "afc0162ad42960d2205cb3452199de5da66713f409c42bb5d92da3d43db2dbf5"

RDEPENDS:rust-cgroupfs+default-devel = " \
 cargo \
 rust-cgroupfs-devel \
 "
RDEPENDS:rust-cgroupfs-devel = " \
 cargo \
 rust-below-common+default-devel \
 rust-nix+default-devel \
 rust-nix+dir-devel \
 rust-nix+event-devel \
 rust-nix+hostname-devel \
 rust-nix+inotify-devel \
 rust-nix+ioctl-devel \
 rust-nix+mman-devel \
 rust-nix+mount-devel \
 rust-nix+net-devel \
 rust-nix+poll-devel \
 rust-nix+ptrace-devel \
 rust-nix+reboot-devel \
 rust-nix+resource-devel \
 rust-nix+sched-devel \
 rust-nix+signal-devel \
 rust-nix+term-devel \
 rust-nix+time-devel \
 rust-nix+user-devel \
 rust-nix+zerocopy-devel \
 rust-openat+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-thiserror+default-devel \
 "
