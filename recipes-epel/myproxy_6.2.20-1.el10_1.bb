# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "myproxy"
PV = "6.2.20"
PR = "1.el10_1"
PACKAGES = " \
 myproxy \
 myproxy-admin \
 myproxy-devel \
 myproxy-doc \
 myproxy-libs \
 myproxy-server \
 myproxy-voms \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/myproxy-6.2.20-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15796336e71bde63a72563e4dde2edf530094647d883c54a2c941a7e6e9888ae"

URI_x86_64_v2_myproxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/myproxy-6.2.20-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_myproxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_myproxy}"
SRC_URI[x86_64_v2_myproxy.sha256sum] = "b6860a336645660bad0b5c09a1b54a5dba54804877c41d00afbb83cc86209fb8"

URI_x86_64_v2_myproxy-admin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/myproxy-admin-6.2.20-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_myproxy-admin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_myproxy-admin}"
SRC_URI[x86_64_v2_myproxy-admin.sha256sum] = "a2a6cb1886497a3d8f453ba1294fe9513b07b17d768a8fac62e78b29223bbcb2"

URI_x86_64_v2_myproxy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/myproxy-devel-6.2.20-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_myproxy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_myproxy-devel}"
SRC_URI[x86_64_v2_myproxy-devel.sha256sum] = "a2e1dfbd9cd6af41c361c667da45cdc6124b7f035c9189b9388ec395bc85288f"

URI_x86_64_v2_myproxy-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/myproxy-doc-6.2.20-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_myproxy-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_myproxy-doc}"
SRC_URI[x86_64_v2_myproxy-doc.sha256sum] = "43f090a2571c5d19556f74eb72bfb32ad6dff306efe72a090b974e98dfbc50c6"

URI_x86_64_v2_myproxy-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/myproxy-libs-6.2.20-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_myproxy-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_myproxy-libs}"
SRC_URI[x86_64_v2_myproxy-libs.sha256sum] = "98ad6ce1b6235d3c5840e1bf86fbb4adb855357950ab1ca62f3c76215b480861"

URI_x86_64_v2_myproxy-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/myproxy-server-6.2.20-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_myproxy-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_myproxy-server}"
SRC_URI[x86_64_v2_myproxy-server.sha256sum] = "ff1f1675e73e73af6be6c86197ee3277dd71700011e320a7e3aee8b7e45a90f5"

URI_x86_64_v2_myproxy-voms = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/myproxy-voms-6.2.20-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_myproxy-voms;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_myproxy-voms}"
SRC_URI[x86_64_v2_myproxy-voms.sha256sum] = "a50da464118ebf6d74a3cfa07908c7f294a4a93e73c930660bad43a1314e9754"

URI_aarch64_myproxy = "${EPEL_MIRROR}/aarch64/Packages/m/myproxy-6.2.20-1.el10_1.aarch64.rpm;name=aarch64_myproxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_myproxy}"
SRC_URI[aarch64_myproxy.sha256sum] = "0f3491f47459dba77f2757862157649f6048422b4c440171ca4f394c7323b092"

URI_aarch64_myproxy-admin = "${EPEL_MIRROR}/aarch64/Packages/m/myproxy-admin-6.2.20-1.el10_1.aarch64.rpm;name=aarch64_myproxy-admin;unpack=0"
SRC_URI:append = " ${URI_aarch64_myproxy-admin}"
SRC_URI[aarch64_myproxy-admin.sha256sum] = "b6e325aa6ff9b2ea155b998aa90c71ee21c9a111d294878f65298dc9b5283c15"

URI_aarch64_myproxy-devel = "${EPEL_MIRROR}/aarch64/Packages/m/myproxy-devel-6.2.20-1.el10_1.aarch64.rpm;name=aarch64_myproxy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_myproxy-devel}"
SRC_URI[aarch64_myproxy-devel.sha256sum] = "28a6becc9958e00ad5c12e7499e46973827da340b02c1f00b56f61a7c78c9de4"

URI_aarch64_myproxy-doc = "${EPEL_MIRROR}/aarch64/Packages/m/myproxy-doc-6.2.20-1.el10_1.noarch.rpm;name=aarch64_myproxy-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_myproxy-doc}"
SRC_URI[aarch64_myproxy-doc.sha256sum] = "6de5efb0a96f4b7d354cc1bf49d06d49ea09aeba90c9c0a4249e7479186a6128"

URI_aarch64_myproxy-libs = "${EPEL_MIRROR}/aarch64/Packages/m/myproxy-libs-6.2.20-1.el10_1.aarch64.rpm;name=aarch64_myproxy-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_myproxy-libs}"
SRC_URI[aarch64_myproxy-libs.sha256sum] = "9a9f1df38fdeb2802aadaaf6c0035db2c494f103071579114de33025aa21845a"

URI_aarch64_myproxy-server = "${EPEL_MIRROR}/aarch64/Packages/m/myproxy-server-6.2.20-1.el10_1.aarch64.rpm;name=aarch64_myproxy-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_myproxy-server}"
SRC_URI[aarch64_myproxy-server.sha256sum] = "7b19306d4b16fa752f2afe58eb178c4b033d82205b95eca1a3cdc4c28bf1de24"

URI_aarch64_myproxy-voms = "${EPEL_MIRROR}/aarch64/Packages/m/myproxy-voms-6.2.20-1.el10_1.aarch64.rpm;name=aarch64_myproxy-voms;unpack=0"
SRC_URI:append = " ${URI_aarch64_myproxy-voms}"
SRC_URI[aarch64_myproxy-voms.sha256sum] = "405884ac647b6a12c95081a8756c0c27349e5255c81738447a92bdff78d8bf4e"

RDEPENDS:myproxy = " \
 glibc \
 globus-common \
 globus-gsi-cert-utils \
 globus-gsi-sysconfig \
 myproxy-libs \
 openssl-libs \
 "
RDEPENDS:myproxy-admin = " \
 glibc \
 globus-gsi-cert-utils-progs \
 myproxy \
 myproxy-libs \
 myproxy-server \
 perl-Data-Dumper \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Temp \
 perl-File-stat \
 perl-Getopt-Long \
 perl-IPC-Open3 \
 perl-Pod-Usage \
 perl-Socket \
 perl-Time-Local \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:myproxy-devel = " \
 globus-common-devel \
 globus-gsi-callback-devel \
 globus-gsi-cert-utils-devel \
 globus-gsi-credential-devel \
 globus-gsi-proxy-core-devel \
 globus-gsi-sysconfig-devel \
 globus-gss-assist-devel \
 globus-gssapi-gsi-devel \
 myproxy-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:myproxy-doc = " \
 "
RDEPENDS:myproxy-libs = " \
 cyrus-sasl-lib \
 glibc \
 globus-common \
 globus-gsi-callback \
 globus-gsi-cert-utils \
 globus-gsi-credential \
 globus-gsi-proxy-core \
 globus-gsi-sysconfig \
 globus-gss-assist \
 globus-gssapi-gsi \
 globus-proxy-utils \
 openldap \
 openssl-libs \
 pam-libs \
 "
RDEPENDS:myproxy-server = " \
 bash \
 glibc \
 myproxy-libs \
 shadow-utils \
 systemd \
 "
RDEPENDS:myproxy-voms = " \
 glibc \
 globus-gssapi-gsi \
 myproxy-libs \
 openssl-libs \
 virtual/voms-clients \
 voms \
 "
