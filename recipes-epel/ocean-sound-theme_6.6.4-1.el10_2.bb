# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ocean-sound-theme"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 ocean-sound-theme \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/ocean-sound-theme-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f04bc07fd062b0a69ee60f64e0eabae44113280eeddcb63981a9c6dfe56a489a"

URI_x86_64_v2_ocean-sound-theme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ocean-sound-theme-6.6.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ocean-sound-theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ocean-sound-theme}"
SRC_URI[x86_64_v2_ocean-sound-theme.sha256sum] = "be0345ec8f12e4b5f0b3731bb73469a7d759b447ec88d516c414aa02a42491a3"

URI_aarch64_ocean-sound-theme = "${EPEL_MIRROR}/aarch64/Packages/o/ocean-sound-theme-6.6.4-1.el10_2.noarch.rpm;name=aarch64_ocean-sound-theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_ocean-sound-theme}"
SRC_URI[aarch64_ocean-sound-theme.sha256sum] = "0699defe2c47b577ec8cb78e0a6da12b76eff71d66865534675a98c3f9c2ed92"

RDEPENDS:ocean-sound-theme = " \
 kf6-filesystem \
 "
