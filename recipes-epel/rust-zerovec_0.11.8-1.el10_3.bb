# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerovec"
PV = "0.11.8"
PR = "1.el10_3"
PACKAGES = " \
 rust-zerovec+alloc-devel \
 rust-zerovec+databake-devel \
 rust-zerovec+default-devel \
 rust-zerovec+derive-devel \
 rust-zerovec+hashmap-devel \
 rust-zerovec+schemars-devel \
 rust-zerovec+serde-devel \
 rust-zerovec+std-devel \
 rust-zerovec+yoke-devel \
 rust-zerovec-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-zerovec-0.11.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4240b8a24e32fa5eb47ed1ebbf8042d1bf9b9bd8759edeef1f36ffed3e340202"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+alloc-devel-0.11.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerovec+alloc-devel.sha256sum] = "c12115fe6f49f7702217079a0b4ee84048b8ca35e64c29ef2af07b3d41cce796"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+databake-devel-0.11.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+databake-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerovec+databake-devel.sha256sum] = "b87bf5ac8141f626c0370d1232a7f25beb2da8fe10fea730a6dcd734697d340e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+default-devel-0.11.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerovec+default-devel.sha256sum] = "0845de16f7e6e8a686458a8c9f835adfc1821ad368d1af018ed5c2e6e1a75c7b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+derive-devel-0.11.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+derive-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerovec+derive-devel.sha256sum] = "aa220ed6d4fd4ff2f371bef9c7a5584344fd5dec77a7ac73c3835fd9321a8a5c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+hashmap-devel-0.11.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+hashmap-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerovec+hashmap-devel.sha256sum] = "a28df80fed9fa9e853ebcc3a14dfa6a99cd256a350fe3943834a92e2ffa4d643"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+schemars-devel-0.11.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+schemars-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerovec+schemars-devel.sha256sum] = "803b872d61517ed86ac9b1a6432fbc5bbe11a318e33478a459ac19d6b5ed8163"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+serde-devel-0.11.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerovec+serde-devel.sha256sum] = "5a976d9e66cdd3bc183f01c84a7962fb9590a662ce660559b038c549017c0487"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+std-devel-0.11.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerovec+std-devel.sha256sum] = "7b19555614c4cc7d85298563674c83d93f2cd5aea97e973c1c299ab69c374152"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec+yoke-devel-0.11.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec+yoke-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerovec+yoke-devel.sha256sum] = "27256878ad0477ba7c99c661821f92a778dcf267722c8e069cf83e6d0da1ee9a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec-devel-0.11.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerovec-devel.sha256sum] = "ba922d5094dba0de9d5d39af29b564bcb3bedb8a4efeb84e2d971d7501665fd4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+alloc-devel-0.11.8-1.el10_3.noarch.rpm;name=aarch64_rust-zerovec+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-zerovec+alloc-devel.sha256sum] = "2fac7e028b801417a70239b36e5ab3ad2139eaf1fb69e3073a364132555fc6d3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+databake-devel-0.11.8-1.el10_3.noarch.rpm;name=aarch64_rust-zerovec+databake-devel;unpack=0"
SRC_URI[aarch64_rust-zerovec+databake-devel.sha256sum] = "d6298db243aa5d4602b7800f109510977e74876616b60f367466d0e72b3b90d0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+default-devel-0.11.8-1.el10_3.noarch.rpm;name=aarch64_rust-zerovec+default-devel;unpack=0"
SRC_URI[aarch64_rust-zerovec+default-devel.sha256sum] = "9239fb0ae173123794cf18a0144c854b1974c151aa20b92511a43194ccffcd3c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+derive-devel-0.11.8-1.el10_3.noarch.rpm;name=aarch64_rust-zerovec+derive-devel;unpack=0"
SRC_URI[aarch64_rust-zerovec+derive-devel.sha256sum] = "64aef5334b7045154db11abec72b04579ad4fb48413a6c373e5f18663489227b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+hashmap-devel-0.11.8-1.el10_3.noarch.rpm;name=aarch64_rust-zerovec+hashmap-devel;unpack=0"
SRC_URI[aarch64_rust-zerovec+hashmap-devel.sha256sum] = "39c88c4f97c727ee463daa143bf8bf7dcef2f96b1d47b636239e546110012986"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+schemars-devel-0.11.8-1.el10_3.noarch.rpm;name=aarch64_rust-zerovec+schemars-devel;unpack=0"
SRC_URI[aarch64_rust-zerovec+schemars-devel.sha256sum] = "4f9fd0c350ed62ed1c68a967ad571e8ddd20c5ea15c7a6bb92ae5c9b9c9662fd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+serde-devel-0.11.8-1.el10_3.noarch.rpm;name=aarch64_rust-zerovec+serde-devel;unpack=0"
SRC_URI[aarch64_rust-zerovec+serde-devel.sha256sum] = "dfdfe048a8d87e02e4c429c53f070a31991a9bb5e16677598c47b1ccfae651d8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+std-devel-0.11.8-1.el10_3.noarch.rpm;name=aarch64_rust-zerovec+std-devel;unpack=0"
SRC_URI[aarch64_rust-zerovec+std-devel.sha256sum] = "41bffaee97b6012f4173ed61aab0849f4f418e9853314728889b39d83414e16e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec+yoke-devel-0.11.8-1.el10_3.noarch.rpm;name=aarch64_rust-zerovec+yoke-devel;unpack=0"
SRC_URI[aarch64_rust-zerovec+yoke-devel.sha256sum] = "438f6c9124789fa7a3bb03cf7ceb57116c83d903170f04f81f2551b87cb18485"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec-devel-0.11.8-1.el10_3.noarch.rpm;name=aarch64_rust-zerovec-devel;unpack=0"
SRC_URI[aarch64_rust-zerovec-devel.sha256sum] = "c636c331720aa180500688d57f20887f54f05b1ffa13d95b1c384f975babc9d5"

RDEPENDS:rust-zerovec+alloc-devel = " \
 cargo \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+databake-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+default-devel = " \
 cargo \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+derive-devel = " \
 cargo \
 rust-zerovec-derive-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+hashmap-devel = " \
 cargo \
 rust-twox-hash+xxhash64-devel \
 rust-twox-hash-devel \
 rust-zerovec+alloc-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+schemars-devel = " \
 cargo \
 rust-schemars-devel \
 rust-zerovec+alloc-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+serde-devel = " \
 cargo \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+std-devel = " \
 cargo \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec+yoke-devel = " \
 cargo \
 rust-yoke-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerovec-devel = " \
 cargo \
 rust \
 rust-zerofrom-devel \
 "
