# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lolcat"
PV = "1.5"
PR = "4.el10_2"
PACKAGES = " \
 lolcat \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/lolcat-1.5-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b031b227927927190443b03e2b73c847583ab4d1d9aaa7ac3e701595c0826ca5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lolcat-1.5-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lolcat;unpack=0"
SRC_URI[x86_64_v2_lolcat.sha256sum] = "d6adc516f0d7bb9814945bf14a443a7cf729dcc89f059f9ef4ac9a914b5b83a9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lolcat-1.5-4.el10_2.aarch64.rpm;name=aarch64_lolcat;unpack=0"
SRC_URI[aarch64_lolcat.sha256sum] = "6713548123ca5ba527787457768a87bf26feb33023654fbdb72bc304245dcf5a"

RDEPENDS:lolcat = " \
 glibc \
 "
