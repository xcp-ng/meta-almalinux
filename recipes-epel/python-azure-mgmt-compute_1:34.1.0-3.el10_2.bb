# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-azure-mgmt-compute"
PE = "1"
PV = "34.1.0"
PR = "3.el10_2"
PACKAGES = " \
 python3-azure-mgmt-compute \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-azure-mgmt-compute-34.1.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9529a86cb197d90d3b92ecec043356567c18368d64cfc81288847d3a52f37e5f"

URI_x86_64_v2_python3-azure-mgmt-compute = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-azure-mgmt-compute-34.1.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-azure-mgmt-compute;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-azure-mgmt-compute}"
SRC_URI[x86_64_v2_python3-azure-mgmt-compute.sha256sum] = "7b2db7cee9a552d0fc80dd2fb2d5212a1c0040a47864a7597dd61f49532b1545"

URI_aarch64_python3-azure-mgmt-compute = "${EPEL_MIRROR}/aarch64/Packages/p/python3-azure-mgmt-compute-34.1.0-3.el10_2.noarch.rpm;name=aarch64_python3-azure-mgmt-compute;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-azure-mgmt-compute}"
SRC_URI[aarch64_python3-azure-mgmt-compute.sha256sum] = "0482f7c5d227574d8be56953d36214770dbaeba202054ba40cd6a2f1550203b1"

RDEPENDS:python3-azure-mgmt-compute = " \
 python3 \
 python3-azure-common \
 python3-azure-mgmt-core \
 python3-isodate \
 python3-typing-extensions \
 "
