# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-Portability-Files"
PV = "0.10"
PR = "19.el10_0"
PACKAGES = " \
 perl-Test-Portability-Files \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Test-Portability-Files-0.10-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "320466d9f2d6a63de0ec813a6990c6756331dc3c00884c2ba9896af6ff8156c5"

URI_x86_64_v2_perl-Test-Portability-Files = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-Portability-Files-0.10-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-Portability-Files;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-Portability-Files}"
SRC_URI[x86_64_v2_perl-Test-Portability-Files.sha256sum] = "f8ff4e4440eeb059e096e136a0c2b3b12051252abcdaf928c2331a7b670844e8"

URI_aarch64_perl-Test-Portability-Files = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-Portability-Files-0.10-19.el10_0.noarch.rpm;name=aarch64_perl-Test-Portability-Files;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-Portability-Files}"
SRC_URI[aarch64_perl-Test-Portability-Files.sha256sum] = "e80f6cb92987c4829b6741e7846114f05f11308fba47659c3a0334dd479f46d6"

RDEPENDS:perl-Test-Portability-Files = " \
 perl-Exporter \
 perl-ExtUtils-Manifest \
 perl-File-Basename \
 perl-File-Find \
 perl-PathTools \
 perl-Test-Simple \
 perl-libs \
 "
