# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-macros"
PV = "0.29.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-pyo3-macros+default-devel \
 rust-pyo3-macros+experimental-async-devel \
 rust-pyo3-macros+experimental-inspect-devel \
 rust-pyo3-macros+multiple-pymethods-devel \
 rust-pyo3-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-macros-0.29.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c73b60c1638895488cfe8b504f27ca4aa1902ed24907160e66ea8a6f89d5f24d"

URI_x86_64_v2_rust-pyo3-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros+default-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros+default-devel.sha256sum] = "61c3add7a9684c4d381b5dc8163beddaec82af0f1ff6b8319258b67248ce06df"

URI_x86_64_v2_rust-pyo3-macros+experimental-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros+experimental-async-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros+experimental-async-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros+experimental-async-devel.sha256sum] = "bc121fbea0b4b59b11802769010129a6c3cc39884590b87d6d63345627e7f9c7"

URI_x86_64_v2_rust-pyo3-macros+experimental-inspect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros+experimental-inspect-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros+experimental-inspect-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros+experimental-inspect-devel.sha256sum] = "cb9adf3ddfc39ac6be41107b7ec29d799a850bc50ff5ec61b2ac51521e2bd228"

URI_x86_64_v2_rust-pyo3-macros+multiple-pymethods-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros+multiple-pymethods-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros+multiple-pymethods-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros+multiple-pymethods-devel.sha256sum] = "3ad794414ec9b72c3fbeb8d9cb770304d03ee5d91921bcc37c7b09559e4eaaa1"

URI_x86_64_v2_rust-pyo3-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-devel.sha256sum] = "ab65255b6e8e448fa7974d8d896b5e7a3f6164a31ce23798586ad1ba753a84f2"

URI_aarch64_rust-pyo3-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros+default-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros+default-devel}"
SRC_URI[aarch64_rust-pyo3-macros+default-devel.sha256sum] = "56f2b636b4050c4ba015c2c7cc6c490178e37cfe45fedf5928c906f703701f29"

URI_aarch64_rust-pyo3-macros+experimental-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros+experimental-async-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-macros+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros+experimental-async-devel}"
SRC_URI[aarch64_rust-pyo3-macros+experimental-async-devel.sha256sum] = "160fa4e6d0e1a774f59c5790495e4fb6968147acc67300bb0f1b3b10291bb3d7"

URI_aarch64_rust-pyo3-macros+experimental-inspect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros+experimental-inspect-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-macros+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros+experimental-inspect-devel}"
SRC_URI[aarch64_rust-pyo3-macros+experimental-inspect-devel.sha256sum] = "3c1824bc5028a19a60e7ed16d153fb05c27a63096c8be17ac23f86d211b17821"

URI_aarch64_rust-pyo3-macros+multiple-pymethods-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros+multiple-pymethods-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-macros+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros+multiple-pymethods-devel}"
SRC_URI[aarch64_rust-pyo3-macros+multiple-pymethods-devel.sha256sum] = "8ad45251c112ea0cb114940f335b01aa64c9ad3d266925914596227bcbd7bd77"

URI_aarch64_rust-pyo3-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-devel}"
SRC_URI[aarch64_rust-pyo3-macros-devel.sha256sum] = "d1ace756e46a4ccee368c8b4861f6921cbc1d48a6ae58da1c6006bff59fe4714"

RDEPENDS:rust-pyo3-macros+default-devel = " \
 cargo \
 rust-pyo3-macros-devel \
 "
RDEPENDS:rust-pyo3-macros+experimental-async-devel = " \
 cargo \
 rust-pyo3-macros-backend+experimental-async-devel \
 rust-pyo3-macros-devel \
 "
RDEPENDS:rust-pyo3-macros+experimental-inspect-devel = " \
 cargo \
 rust-pyo3-macros-backend+experimental-inspect-devel \
 rust-pyo3-macros-devel \
 "
RDEPENDS:rust-pyo3-macros+multiple-pymethods-devel = " \
 cargo \
 rust-pyo3-macros-devel \
 "
RDEPENDS:rust-pyo3-macros-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 rust-pyo3-macros-backend+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+full-devel \
 "
