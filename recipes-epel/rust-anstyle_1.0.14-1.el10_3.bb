# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-anstyle"
PV = "1.0.14"
PR = "1.el10_3"
PACKAGES = " \
 rust-anstyle+default-devel \
 rust-anstyle+std-devel \
 rust-anstyle-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-anstyle-1.0.14-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "77f84c20fc23d66816813d73566cf93fe351a424e82632844689b111009255b4"

URI_x86_64_v2_rust-anstyle+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle+default-devel-1.0.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle+default-devel}"
SRC_URI[x86_64_v2_rust-anstyle+default-devel.sha256sum] = "b337c46b9b0441099fd77451627bedabe6a1698bf4a8e04cbce67be271e220f8"

URI_x86_64_v2_rust-anstyle+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle+std-devel-1.0.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle+std-devel}"
SRC_URI[x86_64_v2_rust-anstyle+std-devel.sha256sum] = "1b14b00d57b351025663ba77779e0582c9cfdd55bcc4fd945c920fe297cab282"

URI_x86_64_v2_rust-anstyle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-devel-1.0.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-devel}"
SRC_URI[x86_64_v2_rust-anstyle-devel.sha256sum] = "eea5a5772ac7d730cd23265a661d6ca3c8f4dbee86890d6fc04688b3b7aaa190"

URI_aarch64_rust-anstyle+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle+default-devel-1.0.14-1.el10_3.noarch.rpm;name=aarch64_rust-anstyle+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle+default-devel}"
SRC_URI[aarch64_rust-anstyle+default-devel.sha256sum] = "fa3a20b5487124e6b8a38b4447e6c32eae6c008f952d1f76061584d4d5b23ab2"

URI_aarch64_rust-anstyle+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle+std-devel-1.0.14-1.el10_3.noarch.rpm;name=aarch64_rust-anstyle+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle+std-devel}"
SRC_URI[aarch64_rust-anstyle+std-devel.sha256sum] = "4195afb065689d174cc8db9483bcd5a46f337113e0a57590809d64ad1142511a"

URI_aarch64_rust-anstyle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-devel-1.0.14-1.el10_3.noarch.rpm;name=aarch64_rust-anstyle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-devel}"
SRC_URI[aarch64_rust-anstyle-devel.sha256sum] = "18bdda9b3e4abcc1dde88ba4c956270c11c62e25d2d5e6b4665871ba74eac30c"

RDEPENDS:rust-anstyle+default-devel = " \
 cargo \
 rust-anstyle+std-devel \
 rust-anstyle-devel \
 "
RDEPENDS:rust-anstyle+std-devel = " \
 cargo \
 rust-anstyle-devel \
 "
RDEPENDS:rust-anstyle-devel = " \
 cargo \
 rust \
 "
