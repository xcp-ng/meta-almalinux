# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-language-c99"
PV = "0.2.0"
PR = "4.el10_0"
PACKAGES = " \
 ghc-language-c99 \
 ghc-language-c99-devel \
 ghc-language-c99-doc \
 ghc-language-c99-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-language-c99-0.2.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "97299f4be1234d6d1c38341cc40dae7685751a0dff3ba7139b12c4a2fc2cfe11"

URI_x86_64_v2_ghc-language-c99 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-language-c99-0.2.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-language-c99;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-language-c99}"
SRC_URI[x86_64_v2_ghc-language-c99.sha256sum] = "cb1add37692c5059186680318ae4b481c2fd174e6a1eafd15d03cab5d2d409fd"

URI_x86_64_v2_ghc-language-c99-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-language-c99-devel-0.2.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-language-c99-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-language-c99-devel}"
SRC_URI[x86_64_v2_ghc-language-c99-devel.sha256sum] = "245678d018a530d3e1f15ddc0fb627aff84f3633987f543df84c9cd29b6879f7"

URI_x86_64_v2_ghc-language-c99-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-language-c99-doc-0.2.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-language-c99-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-language-c99-doc}"
SRC_URI[x86_64_v2_ghc-language-c99-doc.sha256sum] = "8e988436d62e081a0f95f69f79e08fac88a76d4a2c85cd2b9d4dbcdd1a04d400"

URI_x86_64_v2_ghc-language-c99-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-language-c99-prof-0.2.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-language-c99-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-language-c99-prof}"
SRC_URI[x86_64_v2_ghc-language-c99-prof.sha256sum] = "103ce425d385765faa1dd04e1bf46f35cc24dd66d8220167ceba2a9d8113c112"

URI_aarch64_ghc-language-c99 = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-language-c99-0.2.0-4.el10_0.aarch64.rpm;name=aarch64_ghc-language-c99;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-language-c99}"
SRC_URI[aarch64_ghc-language-c99.sha256sum] = "209e6afc3c5714ede796a1bdcca77b24312663720de2ce845217d5550321fe65"

URI_aarch64_ghc-language-c99-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-language-c99-devel-0.2.0-4.el10_0.aarch64.rpm;name=aarch64_ghc-language-c99-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-language-c99-devel}"
SRC_URI[aarch64_ghc-language-c99-devel.sha256sum] = "f969823427dba577a5ddeb67995c92021375640fe412f24ae833ab137f675119"

URI_aarch64_ghc-language-c99-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-language-c99-doc-0.2.0-4.el10_0.noarch.rpm;name=aarch64_ghc-language-c99-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-language-c99-doc}"
SRC_URI[aarch64_ghc-language-c99-doc.sha256sum] = "1a9c4f6827ab9aed437bdce030daa1a3a72a4eb2cf7bb84f77bd348c3acab24e"

URI_aarch64_ghc-language-c99-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-language-c99-prof-0.2.0-4.el10_0.aarch64.rpm;name=aarch64_ghc-language-c99-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-language-c99-prof}"
SRC_URI[aarch64_ghc-language-c99-prof.sha256sum] = "b6818ca50841e2e133fed4056a0c62d1b74f291ba2018e899c3f1aec64c334c6"

RDEPENDS:ghc-language-c99 = " \
 ghc-array \
 ghc-base \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-pretty \
 glibc \
 gmp \
 "
RDEPENDS:ghc-language-c99-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-language-c99 \
 ghc-pretty-devel \
 "
RDEPENDS:ghc-language-c99-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-language-c99-prof = " \
 ghc-base-prof \
 ghc-language-c99-devel \
 ghc-pretty-prof \
 "
