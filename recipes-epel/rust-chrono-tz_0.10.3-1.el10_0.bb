# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-chrono-tz"
PV = "0.10.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-chrono-tz+arbitrary-devel \
 rust-chrono-tz+case-insensitive-devel \
 rust-chrono-tz+default-devel \
 rust-chrono-tz+filter-by-regex-devel \
 rust-chrono-tz+serde-devel \
 rust-chrono-tz+std-devel \
 rust-chrono-tz-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-chrono-tz-0.10.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5932ede82657cbeb9294fd4fd4268657688e2f9a1377bc4b24c64388952f4924"

URI_x86_64_v2_rust-chrono-tz+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-tz+arbitrary-devel-0.10.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-tz+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-tz+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-chrono-tz+arbitrary-devel.sha256sum] = "88b37a6b9827cc34f6b60edc03409699c23d32a438bc563db2153cbfc1c937c0"

URI_x86_64_v2_rust-chrono-tz+case-insensitive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-tz+case-insensitive-devel-0.10.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-tz+case-insensitive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-tz+case-insensitive-devel}"
SRC_URI[x86_64_v2_rust-chrono-tz+case-insensitive-devel.sha256sum] = "b4f3ad0b956d9e75a9fa19db1c0f4f1c1a2a40a918a9c0b73e63f38edc786021"

URI_x86_64_v2_rust-chrono-tz+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-tz+default-devel-0.10.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-tz+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-tz+default-devel}"
SRC_URI[x86_64_v2_rust-chrono-tz+default-devel.sha256sum] = "2d9f779bca6824a4f476c92bf1550e0b84fdf5dd2d738c7497c25862f9f2a3a6"

URI_x86_64_v2_rust-chrono-tz+filter-by-regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-tz+filter-by-regex-devel-0.10.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-tz+filter-by-regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-tz+filter-by-regex-devel}"
SRC_URI[x86_64_v2_rust-chrono-tz+filter-by-regex-devel.sha256sum] = "a7d77d38738a89d4d87d9ad377f3577b8ea40e286ddcc9a90c9f16d847af5f50"

URI_x86_64_v2_rust-chrono-tz+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-tz+serde-devel-0.10.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-tz+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-tz+serde-devel}"
SRC_URI[x86_64_v2_rust-chrono-tz+serde-devel.sha256sum] = "2cc3998af87f56226be944f3ad405a66b6ce68d7d592cc3346ffd4b65d8ca3fe"

URI_x86_64_v2_rust-chrono-tz+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-tz+std-devel-0.10.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-tz+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-tz+std-devel}"
SRC_URI[x86_64_v2_rust-chrono-tz+std-devel.sha256sum] = "8dc26b13d0bfac82eec3cb693342f55900b27c43893e7a1d95fc80889a505ab4"

URI_x86_64_v2_rust-chrono-tz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-tz-devel-0.10.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-tz-devel}"
SRC_URI[x86_64_v2_rust-chrono-tz-devel.sha256sum] = "610d1a4b594605271052ad81fe8602bcfd835fff87d216ae3f2e8b936cfce516"

URI_aarch64_rust-chrono-tz+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-tz+arbitrary-devel-0.10.3-1.el10_0.noarch.rpm;name=aarch64_rust-chrono-tz+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-tz+arbitrary-devel}"
SRC_URI[aarch64_rust-chrono-tz+arbitrary-devel.sha256sum] = "1a3b7bd59cd53de28d34b41358ef13291a5e5d058edb92b30ad096d8338a1754"

URI_aarch64_rust-chrono-tz+case-insensitive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-tz+case-insensitive-devel-0.10.3-1.el10_0.noarch.rpm;name=aarch64_rust-chrono-tz+case-insensitive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-tz+case-insensitive-devel}"
SRC_URI[aarch64_rust-chrono-tz+case-insensitive-devel.sha256sum] = "ff66a7def3589258ac6d0d45af0459ae88558a3940649674092de3606ea2ecc9"

URI_aarch64_rust-chrono-tz+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-tz+default-devel-0.10.3-1.el10_0.noarch.rpm;name=aarch64_rust-chrono-tz+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-tz+default-devel}"
SRC_URI[aarch64_rust-chrono-tz+default-devel.sha256sum] = "78bfad2790de9e8b012fd046b042b5ea35742b8ed15635505b778776224cdea5"

URI_aarch64_rust-chrono-tz+filter-by-regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-tz+filter-by-regex-devel-0.10.3-1.el10_0.noarch.rpm;name=aarch64_rust-chrono-tz+filter-by-regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-tz+filter-by-regex-devel}"
SRC_URI[aarch64_rust-chrono-tz+filter-by-regex-devel.sha256sum] = "720406b43117237821a7688bce923fbdb5f84901f94c989892ea9fe69c19b7d7"

URI_aarch64_rust-chrono-tz+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-tz+serde-devel-0.10.3-1.el10_0.noarch.rpm;name=aarch64_rust-chrono-tz+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-tz+serde-devel}"
SRC_URI[aarch64_rust-chrono-tz+serde-devel.sha256sum] = "ef03cd2c24158d16b4f1526cb1db93593f0af75b32a5d41649786c9156a7e0b2"

URI_aarch64_rust-chrono-tz+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-tz+std-devel-0.10.3-1.el10_0.noarch.rpm;name=aarch64_rust-chrono-tz+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-tz+std-devel}"
SRC_URI[aarch64_rust-chrono-tz+std-devel.sha256sum] = "14855ee97e58f3b7913830469a38fef31fb4ddaac0d923b706744311ba959141"

URI_aarch64_rust-chrono-tz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-tz-devel-0.10.3-1.el10_0.noarch.rpm;name=aarch64_rust-chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-tz-devel}"
SRC_URI[aarch64_rust-chrono-tz-devel.sha256sum] = "669c079355622b817728d1f73d7a907b2098f2d7bcbb469a237519ebae2c2272"

RDEPENDS:rust-chrono-tz+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-chrono-tz-devel \
 "
RDEPENDS:rust-chrono-tz+case-insensitive-devel = " \
 cargo \
 rust-chrono-tz-devel \
 rust-phf+uncased-devel \
 rust-uncased-devel \
 "
RDEPENDS:rust-chrono-tz+default-devel = " \
 cargo \
 rust-chrono-tz+std-devel \
 rust-chrono-tz-devel \
 "
RDEPENDS:rust-chrono-tz+filter-by-regex-devel = " \
 cargo \
 rust-chrono-tz-devel \
 "
RDEPENDS:rust-chrono-tz+serde-devel = " \
 cargo \
 rust-chrono-tz-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-chrono-tz+std-devel = " \
 cargo \
 rust-chrono-tz-devel \
 "
RDEPENDS:rust-chrono-tz-devel = " \
 cargo \
 rust \
 rust-chrono-devel \
 rust-chrono-tz-build+default-devel \
 rust-phf-devel \
 "
