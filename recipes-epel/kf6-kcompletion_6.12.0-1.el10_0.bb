# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcompletion"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kcompletion \
 kf6-kcompletion-devel \
 kf6-kcompletion-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kcompletion-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2c23d85725247ad248ab9f7bf8480527a93ced4cb3136ce59e27dd10780405df"

URI_x86_64_v2_kf6-kcompletion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcompletion-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcompletion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcompletion}"
SRC_URI[x86_64_v2_kf6-kcompletion.sha256sum] = "8c32ba4ef5fd5ea904cd8293a97dc2e3a0520d891820648eed161d187fb99ee7"

URI_x86_64_v2_kf6-kcompletion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcompletion-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcompletion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcompletion-devel}"
SRC_URI[x86_64_v2_kf6-kcompletion-devel.sha256sum] = "fac41ca7c30de7b00b9a37f4eab741e9e81e5fce82ee576dd2d4619741f54bbc"

URI_x86_64_v2_kf6-kcompletion-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcompletion-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcompletion-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcompletion-doc}"
SRC_URI[x86_64_v2_kf6-kcompletion-doc.sha256sum] = "2af7f0e3283c67aa5222e70ab6c17045af4d2401646096df00a6d713a1bce791"

URI_aarch64_kf6-kcompletion = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcompletion-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kcompletion;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcompletion}"
SRC_URI[aarch64_kf6-kcompletion.sha256sum] = "d91e85d0f5b76d12dcbddf92ff201c81e04f26762c91f5682d3a73f17f57ab74"

URI_aarch64_kf6-kcompletion-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcompletion-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kcompletion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcompletion-devel}"
SRC_URI[aarch64_kf6-kcompletion-devel.sha256sum] = "f912d399515ce4d0093189fbb4ed53f45ca7903ea2ab8821b7d6decc472be912"

URI_aarch64_kf6-kcompletion-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcompletion-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kcompletion-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcompletion-doc}"
SRC_URI[aarch64_kf6-kcompletion-doc.sha256sum] = "61f2a51c50387a404da797ad233946f77382fea73caed3f1631f1d9da1878c1c"

RDEPENDS:kf6-kcompletion = " \
 glibc \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kcompletion-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kcompletion \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kcompletion-doc = " \
 "
