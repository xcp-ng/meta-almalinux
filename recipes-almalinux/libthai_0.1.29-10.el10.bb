# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libthai"
PV = "0.1.29"
PR = "10.el10"
PACKAGES = " \
 libthai \
 libthai-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libthai-0.1.29-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1e6c1e4dd0ae81b2fc86b578cb5cb36580ee96bf723a7526aa2b4045d133e05"

URI_x86_64_v2_libthai = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libthai-0.1.29-10.el10.x86_64_v2.rpm;name=x86_64_v2_libthai;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libthai}"
SRC_URI[x86_64_v2_libthai.sha256sum] = "6979d0fb44801e8de1274632775f2db9d5ea3828dc6bcfee3ad595b2864ef26f"

URI_x86_64_v2_libthai-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libthai-devel-0.1.29-10.el10.x86_64_v2.rpm;name=x86_64_v2_libthai-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libthai-devel}"
SRC_URI[x86_64_v2_libthai-devel.sha256sum] = "448cbf10fa3494edc44771296453a4b7f4486e4bb48595a216be81d29a5f2003"

URI_aarch64_libthai = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libthai-0.1.29-10.el10.aarch64.rpm;name=aarch64_libthai;unpack=0"
SRC_URI:append = " ${URI_aarch64_libthai}"
SRC_URI[aarch64_libthai.sha256sum] = "a62df1a68ae95aaf67e4ee05c2e434e3b2ac0620ff0bce5a2252d7f34853f798"

URI_aarch64_libthai-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libthai-devel-0.1.29-10.el10.aarch64.rpm;name=aarch64_libthai-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libthai-devel}"
SRC_URI[aarch64_libthai-devel.sha256sum] = "9ca154c475ab5f0ab40d005ab5e127c1c40358981aa229e1ea348fec32a589a3"

RDEPENDS:libthai = " \
 glibc \
 libdatrie \
 "
RDEPENDS:libthai-devel = " \
 libdatrie-devel \
 libthai \
 pkgconf-pkg-config \
 "
