# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-backtrace"
PV = "0.3.75"
PR = "1.el10_1"
PACKAGES = " \
 rust-backtrace+cpp_demangle-devel \
 rust-backtrace+default-devel \
 rust-backtrace+dl_iterate_phdr-devel \
 rust-backtrace+ruzstd-devel \
 rust-backtrace+serde-devel \
 rust-backtrace+serialize-serde-devel \
 rust-backtrace+std-devel \
 rust-backtrace-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-backtrace-0.3.75-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d17389ff697a53971a30398130281e38c224fea4ea28c6c8dabe43f462e94b9f"

URI_x86_64_v2_rust-backtrace+cpp_demangle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backtrace+cpp_demangle-devel-0.3.75-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backtrace+cpp_demangle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backtrace+cpp_demangle-devel}"
SRC_URI[x86_64_v2_rust-backtrace+cpp_demangle-devel.sha256sum] = "2f2019ae9a4ecd69030d93565631435eac24130e5fda834fad90861b37e06650"

URI_x86_64_v2_rust-backtrace+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backtrace+default-devel-0.3.75-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backtrace+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backtrace+default-devel}"
SRC_URI[x86_64_v2_rust-backtrace+default-devel.sha256sum] = "e457b1a7d4cb8377f64e3e32445d2862c22d3978c91b1b60fd77d5c947c844fe"

URI_x86_64_v2_rust-backtrace+dl_iterate_phdr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backtrace+dl_iterate_phdr-devel-0.3.75-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backtrace+dl_iterate_phdr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backtrace+dl_iterate_phdr-devel}"
SRC_URI[x86_64_v2_rust-backtrace+dl_iterate_phdr-devel.sha256sum] = "2f1a646faf7d0726ea7c2a71316684639a809063880ecd5dbea7a88e1b2d148a"

URI_x86_64_v2_rust-backtrace+ruzstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backtrace+ruzstd-devel-0.3.75-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backtrace+ruzstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backtrace+ruzstd-devel}"
SRC_URI[x86_64_v2_rust-backtrace+ruzstd-devel.sha256sum] = "12ff993b200d60982927c2c6e4c57b0aef034f628526e48ff5024031e84dc695"

URI_x86_64_v2_rust-backtrace+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backtrace+serde-devel-0.3.75-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backtrace+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backtrace+serde-devel}"
SRC_URI[x86_64_v2_rust-backtrace+serde-devel.sha256sum] = "7c5c063baa2631537e14ec62ac993e07aec4178975f3df31afec20a7fe5431f8"

URI_x86_64_v2_rust-backtrace+serialize-serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backtrace+serialize-serde-devel-0.3.75-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backtrace+serialize-serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backtrace+serialize-serde-devel}"
SRC_URI[x86_64_v2_rust-backtrace+serialize-serde-devel.sha256sum] = "c449d48a305b40e9e2a00a967a2273af519a4020847929ba662bf0badf189c25"

URI_x86_64_v2_rust-backtrace+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backtrace+std-devel-0.3.75-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backtrace+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backtrace+std-devel}"
SRC_URI[x86_64_v2_rust-backtrace+std-devel.sha256sum] = "f9000633d57b193afd29b497c6e051ab022ac77057c1a5bf0fc2e6ba9abade90"

URI_x86_64_v2_rust-backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backtrace-devel-0.3.75-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backtrace-devel}"
SRC_URI[x86_64_v2_rust-backtrace-devel.sha256sum] = "5c4044f1189e6b77d786a10f2e07978615344932efefc0402aa8b22470e4efd4"

URI_aarch64_rust-backtrace+cpp_demangle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backtrace+cpp_demangle-devel-0.3.75-1.el10_1.noarch.rpm;name=aarch64_rust-backtrace+cpp_demangle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backtrace+cpp_demangle-devel}"
SRC_URI[aarch64_rust-backtrace+cpp_demangle-devel.sha256sum] = "8e5767ba83165ede6e89cb0d42f5c964892144a2618c8b47365711f048ffecee"

URI_aarch64_rust-backtrace+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backtrace+default-devel-0.3.75-1.el10_1.noarch.rpm;name=aarch64_rust-backtrace+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backtrace+default-devel}"
SRC_URI[aarch64_rust-backtrace+default-devel.sha256sum] = "5fe48bb401211170d54081e16ecd76857f4862d8d9fcdc1a0d6a2a9ff5675dc1"

URI_aarch64_rust-backtrace+dl_iterate_phdr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backtrace+dl_iterate_phdr-devel-0.3.75-1.el10_1.noarch.rpm;name=aarch64_rust-backtrace+dl_iterate_phdr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backtrace+dl_iterate_phdr-devel}"
SRC_URI[aarch64_rust-backtrace+dl_iterate_phdr-devel.sha256sum] = "da2723cc7ad97afaaa8fe5e8b8b68ed8c656432c406fa971cb23f528ab5330ab"

URI_aarch64_rust-backtrace+ruzstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backtrace+ruzstd-devel-0.3.75-1.el10_1.noarch.rpm;name=aarch64_rust-backtrace+ruzstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backtrace+ruzstd-devel}"
SRC_URI[aarch64_rust-backtrace+ruzstd-devel.sha256sum] = "c2a244be35268678b91038ed92959e0bbdd3594a8624a800a0b4672a8e22f2a9"

URI_aarch64_rust-backtrace+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backtrace+serde-devel-0.3.75-1.el10_1.noarch.rpm;name=aarch64_rust-backtrace+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backtrace+serde-devel}"
SRC_URI[aarch64_rust-backtrace+serde-devel.sha256sum] = "e97383bebab53101a795257458f062db5a77840db3ac49707aed97ff31f240b3"

URI_aarch64_rust-backtrace+serialize-serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backtrace+serialize-serde-devel-0.3.75-1.el10_1.noarch.rpm;name=aarch64_rust-backtrace+serialize-serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backtrace+serialize-serde-devel}"
SRC_URI[aarch64_rust-backtrace+serialize-serde-devel.sha256sum] = "0f97abfb40c7a651595bf16361e2e6fbf5d8fd5d49aeeb3210b03ce5371111e9"

URI_aarch64_rust-backtrace+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backtrace+std-devel-0.3.75-1.el10_1.noarch.rpm;name=aarch64_rust-backtrace+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backtrace+std-devel}"
SRC_URI[aarch64_rust-backtrace+std-devel.sha256sum] = "199be71140d9f8b81469fab901982e792d1abaed55a0d41ed4bf60986545c086"

URI_aarch64_rust-backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backtrace-devel-0.3.75-1.el10_1.noarch.rpm;name=aarch64_rust-backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backtrace-devel}"
SRC_URI[aarch64_rust-backtrace-devel.sha256sum] = "e24ba516573bde906214ed06519e2ea6481cacf4bc7c0ea3e204fd5e8897727c"

RDEPENDS:rust-backtrace+cpp_demangle-devel = " \
 cargo \
 rust-backtrace-devel \
 rust-cpp_demangle+alloc-devel \
 rust-cpp_demangle-devel \
 "
RDEPENDS:rust-backtrace+default-devel = " \
 cargo \
 rust-backtrace+std-devel \
 rust-backtrace-devel \
 "
RDEPENDS:rust-backtrace+dl_iterate_phdr-devel = " \
 cargo \
 rust-backtrace-devel \
 "
RDEPENDS:rust-backtrace+ruzstd-devel = " \
 cargo \
 rust-backtrace-devel \
 rust-ruzstd0.7-devel \
 "
RDEPENDS:rust-backtrace+serde-devel = " \
 cargo \
 rust-backtrace-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-backtrace+serialize-serde-devel = " \
 cargo \
 rust-backtrace+serde-devel \
 rust-backtrace-devel \
 "
RDEPENDS:rust-backtrace+std-devel = " \
 cargo \
 rust-backtrace-devel \
 "
RDEPENDS:rust-backtrace-devel = " \
 cargo \
 rust \
 rust-addr2line-devel \
 rust-cfg-if+default-devel \
 rust-libc-devel \
 rust-miniz_oxide-devel \
 rust-object0.36+archive-devel \
 rust-object0.36+elf-devel \
 rust-object0.36+macho-devel \
 rust-object0.36+pe-devel \
 rust-object0.36+read_core-devel \
 rust-object0.36+unaligned-devel \
 rust-object0.36+xcoff-devel \
 rust-object0.36-devel \
 rust-rustc-demangle+default-devel \
 "
