# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "prosody"
PV = "13.0.2"
PR = "1.el10_0"
PACKAGES = " \
 prosody \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/prosody-13.0.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "08c98a763ae504babdf6e2a25a3fff3f978ee23d308904ad51e61c28e9b17ef2"

URI_x86_64_v2_prosody = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/prosody-13.0.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_prosody;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_prosody}"
SRC_URI[x86_64_v2_prosody.sha256sum] = "0eb2d30dfca3a7f061916253feaa004daa0150159b010371717ac54253a5a083"

URI_aarch64_prosody = "${EPEL_MIRROR}/aarch64/Packages/p/prosody-13.0.2-1.el10_0.aarch64.rpm;name=aarch64_prosody;unpack=0"
SRC_URI:append = " ${URI_aarch64_prosody}"
SRC_URI[aarch64_prosody.sha256sum] = "ee26a5c5f8c10b9936eeec95607741dd4d348f08f407b1e94878ecde438cd496"

RDEPENDS:prosody = " \
 bash \
 glibc \
 libicu \
 lua \
 lua-expat \
 lua-filesystem \
 lua-libs \
 lua-sec \
 lua-socket \
 openssl \
 openssl-libs \
 shadow-utils \
 systemd \
 "
