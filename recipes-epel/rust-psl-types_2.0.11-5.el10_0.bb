# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-psl-types"
PV = "2.0.11"
PR = "5.el10_0"
PACKAGES = " \
 rust-psl-types+default-devel \
 rust-psl-types-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-psl-types-2.0.11-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ecc0f3625c852765c5a0f07601f78726f80819c19c4e98568ce083c92dafd4e5"

URI_x86_64_v2_rust-psl-types+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-psl-types+default-devel-2.0.11-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-psl-types+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-psl-types+default-devel}"
SRC_URI[x86_64_v2_rust-psl-types+default-devel.sha256sum] = "107a1c7cea2a53ef8e52cce5f0a6a7529ce2f4b8d84127e46fc21a06ed1f341a"

URI_x86_64_v2_rust-psl-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-psl-types-devel-2.0.11-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-psl-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-psl-types-devel}"
SRC_URI[x86_64_v2_rust-psl-types-devel.sha256sum] = "e98aa9a68593e84392bf4570219388d89498b84d61d2ac88040b8888f31f7986"

URI_aarch64_rust-psl-types+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-psl-types+default-devel-2.0.11-5.el10_0.noarch.rpm;name=aarch64_rust-psl-types+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-psl-types+default-devel}"
SRC_URI[aarch64_rust-psl-types+default-devel.sha256sum] = "0a028891ebabbb9b7f0dc4b736c90d225ea5b6f606cfb972745cf444228e178a"

URI_aarch64_rust-psl-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-psl-types-devel-2.0.11-5.el10_0.noarch.rpm;name=aarch64_rust-psl-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-psl-types-devel}"
SRC_URI[aarch64_rust-psl-types-devel.sha256sum] = "7cb3430ca4421c65995383d1df89becbf7cf50da98095200b55a4cc2e1edbb8a"

RDEPENDS:rust-psl-types+default-devel = " \
 cargo \
 rust-psl-types-devel \
 "
RDEPENDS:rust-psl-types-devel = " \
 cargo \
 "
