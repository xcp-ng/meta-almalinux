# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zvariant_utils"
PV = "3.2.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-zvariant_utils+default-devel \
 rust-zvariant_utils+gvariant-devel \
 rust-zvariant_utils-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zvariant_utils-3.2.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a449f134558527dadde142fb0c2973d4541a1b7f630fa0a9a4fc1a6c3db4cd6e"

URI_x86_64_v2_rust-zvariant_utils+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant_utils+default-devel-3.2.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant_utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant_utils+default-devel}"
SRC_URI[x86_64_v2_rust-zvariant_utils+default-devel.sha256sum] = "a9d0c43e96230d3277abeece2b457ecae38a0492e4d7974be12feb2d61b549b7"

URI_x86_64_v2_rust-zvariant_utils+gvariant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant_utils+gvariant-devel-3.2.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant_utils+gvariant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant_utils+gvariant-devel}"
SRC_URI[x86_64_v2_rust-zvariant_utils+gvariant-devel.sha256sum] = "e44e5afa0910bf7d7839115ee8165ce1acd65430ca9d252fd5abfb3f3f3adb70"

URI_x86_64_v2_rust-zvariant_utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant_utils-devel-3.2.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant_utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant_utils-devel}"
SRC_URI[x86_64_v2_rust-zvariant_utils-devel.sha256sum] = "300fd48eae4b31c38800325974ecd31a8fcc95b8256b9fe8e23c077f0ee1181a"

URI_aarch64_rust-zvariant_utils+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant_utils+default-devel-3.2.1-1.el10_1.noarch.rpm;name=aarch64_rust-zvariant_utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant_utils+default-devel}"
SRC_URI[aarch64_rust-zvariant_utils+default-devel.sha256sum] = "eaf2b2c6b19e45348324601f1d80c371663a98c4e05e6d3bb9bda01787369c2b"

URI_aarch64_rust-zvariant_utils+gvariant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant_utils+gvariant-devel-3.2.1-1.el10_1.noarch.rpm;name=aarch64_rust-zvariant_utils+gvariant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant_utils+gvariant-devel}"
SRC_URI[aarch64_rust-zvariant_utils+gvariant-devel.sha256sum] = "0d6f0d6ab017cbc807909b5b3aae6c479501a97a76b69069280f7990de4db560"

URI_aarch64_rust-zvariant_utils-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant_utils-devel-3.2.1-1.el10_1.noarch.rpm;name=aarch64_rust-zvariant_utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant_utils-devel}"
SRC_URI[aarch64_rust-zvariant_utils-devel.sha256sum] = "135fe62351cb7d6c93697098eafebab5c4bcf5a5f44415d6aa61aec78b437e0a"

RDEPENDS:rust-zvariant_utils+default-devel = " \
 cargo \
 rust-zvariant_utils-devel \
 "
RDEPENDS:rust-zvariant_utils+gvariant-devel = " \
 cargo \
 rust-zvariant_utils-devel \
 "
RDEPENDS:rust-zvariant_utils-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-winnow+default-devel \
 "
