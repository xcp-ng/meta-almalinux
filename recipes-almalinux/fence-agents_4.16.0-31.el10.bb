# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fence-agents"
PV = "4.16.0"
PR = "31.el10"
PACKAGES:x86_64_v2 = " \
 fence-agents-aliyun \
 fence-agents-all \
 fence-agents-amt-ws \
 fence-agents-apc \
 fence-agents-apc-snmp \
 fence-agents-aws \
 fence-agents-azure-arm \
 fence-agents-bladecenter \
 fence-agents-brocade \
 fence-agents-cisco-mds \
 fence-agents-cisco-ucs \
 fence-agents-common \
 fence-agents-drac5 \
 fence-agents-eaton-snmp \
 fence-agents-emerson \
 fence-agents-eps \
 fence-agents-gce \
 fence-agents-heuristics-ping \
 fence-agents-hpblade \
 fence-agents-ibm-powervs \
 fence-agents-ibm-vpc \
 fence-agents-ibmblade \
 fence-agents-ifmib \
 fence-agents-ilo-moonshot \
 fence-agents-ilo-mp \
 fence-agents-ilo-ssh \
 fence-agents-ilo2 \
 fence-agents-intelmodular \
 fence-agents-ipdu \
 fence-agents-ipmilan \
 fence-agents-kdump \
 fence-agents-kubevirt \
 fence-agents-lpar \
 fence-agents-mpath \
 fence-agents-nutanix-ahv \
 fence-agents-openstack \
 fence-agents-redfish \
 fence-agents-rhevm \
 fence-agents-rsa \
 fence-agents-rsb \
 fence-agents-sbd \
 fence-agents-scsi \
 fence-agents-virsh \
 fence-agents-vmware-rest \
 fence-agents-vmware-soap \
 fence-agents-wti \
 fence-virt \
 fence-virtd \
 fence-virtd-cpg \
 fence-virtd-libvirt \
 fence-virtd-multicast \
 fence-virtd-serial \
 fence-virtd-tcp \
 ha-cloud-support \
"
PACKAGES:aarch64 = " \
 fence-agents-all \
 fence-agents-amt-ws \
 fence-agents-apc \
 fence-agents-apc-snmp \
 fence-agents-bladecenter \
 fence-agents-brocade \
 fence-agents-cisco-mds \
 fence-agents-cisco-ucs \
 fence-agents-common \
 fence-agents-drac5 \
 fence-agents-eaton-snmp \
 fence-agents-emerson \
 fence-agents-eps \
 fence-agents-heuristics-ping \
 fence-agents-hpblade \
 fence-agents-ibm-powervs \
 fence-agents-ibm-vpc \
 fence-agents-ibmblade \
 fence-agents-ifmib \
 fence-agents-ilo-moonshot \
 fence-agents-ilo-mp \
 fence-agents-ilo-ssh \
 fence-agents-ilo2 \
 fence-agents-intelmodular \
 fence-agents-ipdu \
 fence-agents-ipmilan \
 fence-agents-kdump \
 fence-agents-kubevirt \
 fence-agents-lpar \
 fence-agents-mpath \
 fence-agents-nutanix-ahv \
 fence-agents-redfish \
 fence-agents-rhevm \
 fence-agents-rsa \
 fence-agents-rsb \
 fence-agents-sbd \
 fence-agents-scsi \
 fence-agents-virsh \
 fence-agents-vmware-rest \
 fence-agents-vmware-soap \
 fence-agents-wti \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/fence-agents-4.16.0-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2870a8eeb6ab75c89d9c43ec74f24174de2a1a699ed0f73cd3ac47b65b8d89ea"

URI_x86_64_v2_fence-agents-aliyun = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-aliyun-4.16.0-31.el10.x86_64_v2.rpm;name=x86_64_v2_fence-agents-aliyun;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-aliyun}"
SRC_URI[x86_64_v2_fence-agents-aliyun.sha256sum] = "981125cd6df0fc6b25977743fff60ea0f1c61f30947902af91b1dae89711475d"

URI_x86_64_v2_fence-agents-all = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-all-4.16.0-31.el10.x86_64_v2.rpm;name=x86_64_v2_fence-agents-all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-all}"
SRC_URI[x86_64_v2_fence-agents-all.sha256sum] = "61a5302997905999fa2f78ba7eaf045bce9fecbb18374a808e2955b75dc95d19"

URI_x86_64_v2_fence-agents-amt-ws = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-amt-ws-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-amt-ws;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-amt-ws}"
SRC_URI[x86_64_v2_fence-agents-amt-ws.sha256sum] = "ae84bbf50ccde5f69b735b24d45611cbc87824c190d18d64234400258492bc36"

URI_x86_64_v2_fence-agents-apc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-apc-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-apc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-apc}"
SRC_URI[x86_64_v2_fence-agents-apc.sha256sum] = "a4d2d85a4856695f8e5c7e870ac8bac8d2c0c0d1b15046fa1deb26088fcd6c27"

URI_x86_64_v2_fence-agents-apc-snmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-apc-snmp-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-apc-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-apc-snmp}"
SRC_URI[x86_64_v2_fence-agents-apc-snmp.sha256sum] = "387865d67718b1bbe123b4a720d56a9a761b6fa041a8978a345b0bbc75527e1f"

URI_x86_64_v2_fence-agents-aws = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-aws-4.16.0-31.el10.x86_64_v2.rpm;name=x86_64_v2_fence-agents-aws;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-aws}"
SRC_URI[x86_64_v2_fence-agents-aws.sha256sum] = "852a4b714ebdc125782e1942a04ab8d5142eb3e1cf7cca9bf8880e4ea90e1164"

URI_x86_64_v2_fence-agents-azure-arm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-azure-arm-4.16.0-31.el10.x86_64_v2.rpm;name=x86_64_v2_fence-agents-azure-arm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-azure-arm}"
SRC_URI[x86_64_v2_fence-agents-azure-arm.sha256sum] = "7de7095bc4df906879b1ba77074d14e64c52e262e6efb860b4da8192da666b80"

URI_x86_64_v2_fence-agents-bladecenter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-bladecenter-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-bladecenter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-bladecenter}"
SRC_URI[x86_64_v2_fence-agents-bladecenter.sha256sum] = "0db741194ae0d692141dd53ed10eab530aee5cd49ac1c77003cc5df8643c7ce5"

URI_x86_64_v2_fence-agents-brocade = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-brocade-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-brocade;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-brocade}"
SRC_URI[x86_64_v2_fence-agents-brocade.sha256sum] = "619dc0afa994f747bb056d1f50ec27a9165090d2e049724e232ebbbb340a7f5f"

URI_x86_64_v2_fence-agents-cisco-mds = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-cisco-mds-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-cisco-mds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-cisco-mds}"
SRC_URI[x86_64_v2_fence-agents-cisco-mds.sha256sum] = "45e0e736abca96625c6647c86bb8dd0fdf8e7c0a5088763f3780ed0c343a7fef"

URI_x86_64_v2_fence-agents-cisco-ucs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-cisco-ucs-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-cisco-ucs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-cisco-ucs}"
SRC_URI[x86_64_v2_fence-agents-cisco-ucs.sha256sum] = "e1e58ea06cdffb47b74dc88cc545964c2d53cc7f90b1baf772f1f05ac7299d74"

URI_x86_64_v2_fence-agents-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-common-4.16.0-31.el10.x86_64_v2.rpm;name=x86_64_v2_fence-agents-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-common}"
SRC_URI[x86_64_v2_fence-agents-common.sha256sum] = "3914667dbb0eb61293a6054212d1032e49d7ef686e3efe6cc40703d8e86f1838"

URI_x86_64_v2_fence-agents-drac5 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-drac5-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-drac5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-drac5}"
SRC_URI[x86_64_v2_fence-agents-drac5.sha256sum] = "a59719a32e40d6f5c1f8332070a8a3ce5adaf179cebe0adff86539887ff5cacb"

URI_x86_64_v2_fence-agents-eaton-snmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-eaton-snmp-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-eaton-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-eaton-snmp}"
SRC_URI[x86_64_v2_fence-agents-eaton-snmp.sha256sum] = "0b0999a6a91f22466a5491207a091a28c25bb81a05e2b0936944be7611ba65d3"

URI_x86_64_v2_fence-agents-emerson = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-emerson-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-emerson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-emerson}"
SRC_URI[x86_64_v2_fence-agents-emerson.sha256sum] = "9abf6a433e35acf8d54e055bc5274e0d29ccb70a80d60f2ee1b287fc01b1eedf"

URI_x86_64_v2_fence-agents-eps = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-eps-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-eps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-eps}"
SRC_URI[x86_64_v2_fence-agents-eps.sha256sum] = "36a987eda4f9d6a9d20a1cc39671c839cef8f8cf7a1a2ddfd0f5b776911640a7"

URI_x86_64_v2_fence-agents-gce = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-gce-4.16.0-31.el10.x86_64_v2.rpm;name=x86_64_v2_fence-agents-gce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-gce}"
SRC_URI[x86_64_v2_fence-agents-gce.sha256sum] = "97289fcd11c04d5dc0fb82acd5dd0a1c7fa1b483d048b55f0f5d51080419a613"

URI_x86_64_v2_fence-agents-heuristics-ping = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-heuristics-ping-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-heuristics-ping;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-heuristics-ping}"
SRC_URI[x86_64_v2_fence-agents-heuristics-ping.sha256sum] = "50198c7c834360b6efcd019e35adba68451d1bbad23f6ebbbfa89eac20cb23b8"

URI_x86_64_v2_fence-agents-hpblade = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-hpblade-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-hpblade;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-hpblade}"
SRC_URI[x86_64_v2_fence-agents-hpblade.sha256sum] = "5303459777409ef4b3f4079b68eaab003ca9a185cb67385aecebbe1c24571323"

URI_x86_64_v2_fence-agents-ibm-powervs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ibm-powervs-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-ibm-powervs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ibm-powervs}"
SRC_URI[x86_64_v2_fence-agents-ibm-powervs.sha256sum] = "a3321277669942dcc9fcd3d1f8ceaee127c1467ee3ebee7af79e7a2506d6f1b6"

URI_x86_64_v2_fence-agents-ibm-vpc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ibm-vpc-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-ibm-vpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ibm-vpc}"
SRC_URI[x86_64_v2_fence-agents-ibm-vpc.sha256sum] = "3a4d6106009b03f2132c3ad57eae15587f7f2d1fdb0082fb9948e623dccbb886"

URI_x86_64_v2_fence-agents-ibmblade = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ibmblade-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-ibmblade;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ibmblade}"
SRC_URI[x86_64_v2_fence-agents-ibmblade.sha256sum] = "660970a0c28837224104d51e8c7285b08ca08a1e8122540b90725a8c0c258acd"

URI_x86_64_v2_fence-agents-ifmib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ifmib-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-ifmib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ifmib}"
SRC_URI[x86_64_v2_fence-agents-ifmib.sha256sum] = "2bee898705b712329ad9090ef64bbed93c153f0d67ec7adae77174a4fce06e7a"

URI_x86_64_v2_fence-agents-ilo-moonshot = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ilo-moonshot-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-ilo-moonshot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ilo-moonshot}"
SRC_URI[x86_64_v2_fence-agents-ilo-moonshot.sha256sum] = "69628469403f127fef970ac8d9b38f283246daeb66b4fb9f5ef1b2fa5d7cc2cb"

URI_x86_64_v2_fence-agents-ilo-mp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ilo-mp-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-ilo-mp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ilo-mp}"
SRC_URI[x86_64_v2_fence-agents-ilo-mp.sha256sum] = "ec9c6e5299b3204af714033321de69acfc95469555fd37691498d234da525fb8"

URI_x86_64_v2_fence-agents-ilo-ssh = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ilo-ssh-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-ilo-ssh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ilo-ssh}"
SRC_URI[x86_64_v2_fence-agents-ilo-ssh.sha256sum] = "fb3cae6439435d2216e4e9dc6cc983a76ff67d93835f61fbb7555e7c569ef0a6"

URI_x86_64_v2_fence-agents-ilo2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ilo2-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-ilo2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ilo2}"
SRC_URI[x86_64_v2_fence-agents-ilo2.sha256sum] = "a844a1e65f4df5fcd7a1a55b88d22d1857886636af68ed7fdb6251cbc5373358"

URI_x86_64_v2_fence-agents-intelmodular = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-intelmodular-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-intelmodular;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-intelmodular}"
SRC_URI[x86_64_v2_fence-agents-intelmodular.sha256sum] = "32af484c954d26fb8024e8716dcb133d67e30d32cbec733125d6273e654dea75"

URI_x86_64_v2_fence-agents-ipdu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ipdu-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-ipdu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ipdu}"
SRC_URI[x86_64_v2_fence-agents-ipdu.sha256sum] = "a79d12e5e8af4ea84a8eb4709081695904c6f1e423e9b8e44de85147e4932364"

URI_x86_64_v2_fence-agents-ipmilan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ipmilan-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-ipmilan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-ipmilan}"
SRC_URI[x86_64_v2_fence-agents-ipmilan.sha256sum] = "fb493bad94bfedc5af3b43b075fc3ed7853ef6c4569ff3baf00a0ef76b603250"

URI_x86_64_v2_fence-agents-kdump = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-kdump-4.16.0-31.el10.x86_64_v2.rpm;name=x86_64_v2_fence-agents-kdump;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-kdump}"
SRC_URI[x86_64_v2_fence-agents-kdump.sha256sum] = "b023364b96d77174bfd07dc078cc2843ce1b1db18974dd0fcc4e0f47495537cc"

URI_x86_64_v2_fence-agents-kubevirt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-kubevirt-4.16.0-31.el10.x86_64_v2.rpm;name=x86_64_v2_fence-agents-kubevirt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-kubevirt}"
SRC_URI[x86_64_v2_fence-agents-kubevirt.sha256sum] = "c214d0acd289e889675d16553ea27f871078ddd7debcad922dcc5141ada51fe8"

URI_x86_64_v2_fence-agents-lpar = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-lpar-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-lpar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-lpar}"
SRC_URI[x86_64_v2_fence-agents-lpar.sha256sum] = "a2698cc9c0ed24a4c67e2571591b35a8c8100776b4d5276a7b633391efa157ad"

URI_x86_64_v2_fence-agents-mpath = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-mpath-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-mpath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-mpath}"
SRC_URI[x86_64_v2_fence-agents-mpath.sha256sum] = "4507eabe2b412d366dc7ae15e7dfd3b98b40d5a4bd32870f16b53a9a7f797cd3"

URI_x86_64_v2_fence-agents-nutanix-ahv = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-nutanix-ahv-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-nutanix-ahv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-nutanix-ahv}"
SRC_URI[x86_64_v2_fence-agents-nutanix-ahv.sha256sum] = "20f2ad536af80809679399f0321f814cf9a6d2d23bc574c5fd0b818a93314602"

URI_x86_64_v2_fence-agents-openstack = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-openstack-4.16.0-31.el10.x86_64_v2.rpm;name=x86_64_v2_fence-agents-openstack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-openstack}"
SRC_URI[x86_64_v2_fence-agents-openstack.sha256sum] = "c144bd0f0d97abf5ac62125ed7edf0c80645e3a37f7b085fce753553cc68f23d"

URI_x86_64_v2_fence-agents-redfish = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-redfish-4.16.0-31.el10.x86_64_v2.rpm;name=x86_64_v2_fence-agents-redfish;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-redfish}"
SRC_URI[x86_64_v2_fence-agents-redfish.sha256sum] = "3989d7392f88292fbff9ba4654bd67fd326aeac9fade8bd623765429ca20e821"

URI_x86_64_v2_fence-agents-rhevm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-rhevm-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-rhevm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-rhevm}"
SRC_URI[x86_64_v2_fence-agents-rhevm.sha256sum] = "701d1bbb5f263860ebf689ac2c6f1cae6a0d2718c7ffa859799be6d1027fd376"

URI_x86_64_v2_fence-agents-rsa = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-rsa-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-rsa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-rsa}"
SRC_URI[x86_64_v2_fence-agents-rsa.sha256sum] = "d9873ec5a70baf2f8373742f9ef36726c258168e3ac7ccbab07d1d813bf794b5"

URI_x86_64_v2_fence-agents-rsb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-rsb-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-rsb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-rsb}"
SRC_URI[x86_64_v2_fence-agents-rsb.sha256sum] = "f7ce317ba2ec04256d2906aef581d11c4e4bfbd04b776fa7ce5a49f390787881"

URI_x86_64_v2_fence-agents-sbd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-sbd-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-sbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-sbd}"
SRC_URI[x86_64_v2_fence-agents-sbd.sha256sum] = "4bb0a9b5d92647e3c9375a79fcf25609d179da42b79d59253226258c3ae65215"

URI_x86_64_v2_fence-agents-scsi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-scsi-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-scsi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-scsi}"
SRC_URI[x86_64_v2_fence-agents-scsi.sha256sum] = "527e59fd6cbd99f47198edf3f9ecd78092e1fa0111cd5775dba02877eca2e875"

URI_x86_64_v2_fence-agents-virsh = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-virsh-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-virsh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-virsh}"
SRC_URI[x86_64_v2_fence-agents-virsh.sha256sum] = "f602c467fb6a4d2767bcee3c6d0b3337dc612e40996728f9e68bbe6496bfaa83"

URI_x86_64_v2_fence-agents-vmware-rest = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-vmware-rest-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-vmware-rest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-vmware-rest}"
SRC_URI[x86_64_v2_fence-agents-vmware-rest.sha256sum] = "ed5b9fbdc15c186acf886abdc4e2a0cf24a3ea6e3e80d51a4d839f8eb7bcff30"

URI_x86_64_v2_fence-agents-vmware-soap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-vmware-soap-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-vmware-soap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-vmware-soap}"
SRC_URI[x86_64_v2_fence-agents-vmware-soap.sha256sum] = "2106cd1ff3450a0348743507b537dc2b0d638d52d0c93882ebf4c96343b2aeeb"

URI_x86_64_v2_fence-agents-wti = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-wti-4.16.0-31.el10.noarch.rpm;name=x86_64_v2_fence-agents-wti;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-agents-wti}"
SRC_URI[x86_64_v2_fence-agents-wti.sha256sum] = "1cda814ceea0ee0a689a3a104851eb4de4b9a34bac9b448ba1d83bcd2d56aa87"

URI_x86_64_v2_fence-virt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virt-4.16.0-31.el10.x86_64_v2.rpm;name=x86_64_v2_fence-virt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-virt}"
SRC_URI[x86_64_v2_fence-virt.sha256sum] = "5b68f294b329cedfd322ed5f722e756f915b4f6c5e48e350f3774e268613612e"

URI_x86_64_v2_fence-virtd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-4.16.0-31.el10.x86_64_v2.rpm;name=x86_64_v2_fence-virtd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-virtd}"
SRC_URI[x86_64_v2_fence-virtd.sha256sum] = "2b015543336d7a69db1f852091297406aa77ee7003fe6c6f3fe6214ea1fd0f5d"

URI_x86_64_v2_fence-virtd-cpg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-cpg-4.16.0-31.el10.x86_64_v2.rpm;name=x86_64_v2_fence-virtd-cpg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-virtd-cpg}"
SRC_URI[x86_64_v2_fence-virtd-cpg.sha256sum] = "a26e52232a05bd495657a29a4171ef6697a3b5dbfb0f12a1375f42d6bb7cb5cf"

URI_x86_64_v2_fence-virtd-libvirt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-libvirt-4.16.0-31.el10.x86_64_v2.rpm;name=x86_64_v2_fence-virtd-libvirt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-virtd-libvirt}"
SRC_URI[x86_64_v2_fence-virtd-libvirt.sha256sum] = "6cf6a4e3d32e7e6cee35146b455b53cb4eafd255af8bd3aa3c738eb00e923d92"

URI_x86_64_v2_fence-virtd-multicast = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-multicast-4.16.0-31.el10.x86_64_v2.rpm;name=x86_64_v2_fence-virtd-multicast;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-virtd-multicast}"
SRC_URI[x86_64_v2_fence-virtd-multicast.sha256sum] = "6de9bb11e0edb390c8b47e1cfc19cbb83675a5ed2851a552674ec4f9771bab1e"

URI_x86_64_v2_fence-virtd-serial = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-serial-4.16.0-31.el10.x86_64_v2.rpm;name=x86_64_v2_fence-virtd-serial;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-virtd-serial}"
SRC_URI[x86_64_v2_fence-virtd-serial.sha256sum] = "3963744c8004ff7be0c9e54232179feaf10fb0cee1729da63cea7d18d06b0755"

URI_x86_64_v2_fence-virtd-tcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-tcp-4.16.0-31.el10.x86_64_v2.rpm;name=x86_64_v2_fence-virtd-tcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fence-virtd-tcp}"
SRC_URI[x86_64_v2_fence-virtd-tcp.sha256sum] = "cf2623eae5d0531c97a8aba7a69e360b414a9e303f25f499d0cdd50a27e53688"

URI_x86_64_v2_ha-cloud-support = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ha-cloud-support-4.16.0-31.el10.x86_64_v2.rpm;name=x86_64_v2_ha-cloud-support;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ha-cloud-support}"
SRC_URI[x86_64_v2_ha-cloud-support.sha256sum] = "f0c948cc4cfa68e1e59a6c9ce379c952ddd8d9e3e3110067db78f99e39f97cdf"

URI_aarch64_fence-agents-all = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-all-4.16.0-31.el10.aarch64.rpm;name=aarch64_fence-agents-all;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-all}"
SRC_URI[aarch64_fence-agents-all.sha256sum] = "a7f7c6a2a82b360edb52d4623a7d96854826f5d5bf1187ab4841b9282e4b450a"

URI_aarch64_fence-agents-amt-ws = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-amt-ws-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-amt-ws;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-amt-ws}"
SRC_URI[aarch64_fence-agents-amt-ws.sha256sum] = "ae84bbf50ccde5f69b735b24d45611cbc87824c190d18d64234400258492bc36"

URI_aarch64_fence-agents-apc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-apc-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-apc;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-apc}"
SRC_URI[aarch64_fence-agents-apc.sha256sum] = "a4d2d85a4856695f8e5c7e870ac8bac8d2c0c0d1b15046fa1deb26088fcd6c27"

URI_aarch64_fence-agents-apc-snmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-apc-snmp-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-apc-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-apc-snmp}"
SRC_URI[aarch64_fence-agents-apc-snmp.sha256sum] = "387865d67718b1bbe123b4a720d56a9a761b6fa041a8978a345b0bbc75527e1f"

URI_aarch64_fence-agents-bladecenter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-bladecenter-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-bladecenter;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-bladecenter}"
SRC_URI[aarch64_fence-agents-bladecenter.sha256sum] = "0db741194ae0d692141dd53ed10eab530aee5cd49ac1c77003cc5df8643c7ce5"

URI_aarch64_fence-agents-brocade = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-brocade-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-brocade;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-brocade}"
SRC_URI[aarch64_fence-agents-brocade.sha256sum] = "619dc0afa994f747bb056d1f50ec27a9165090d2e049724e232ebbbb340a7f5f"

URI_aarch64_fence-agents-cisco-mds = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-cisco-mds-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-cisco-mds;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-cisco-mds}"
SRC_URI[aarch64_fence-agents-cisco-mds.sha256sum] = "45e0e736abca96625c6647c86bb8dd0fdf8e7c0a5088763f3780ed0c343a7fef"

URI_aarch64_fence-agents-cisco-ucs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-cisco-ucs-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-cisco-ucs;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-cisco-ucs}"
SRC_URI[aarch64_fence-agents-cisco-ucs.sha256sum] = "e1e58ea06cdffb47b74dc88cc545964c2d53cc7f90b1baf772f1f05ac7299d74"

URI_aarch64_fence-agents-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-common-4.16.0-31.el10.aarch64.rpm;name=aarch64_fence-agents-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-common}"
SRC_URI[aarch64_fence-agents-common.sha256sum] = "ff76a524120ba4d7246dd89c402ded270c78b8d1ce3807701243968ade491fb4"

URI_aarch64_fence-agents-drac5 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-drac5-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-drac5;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-drac5}"
SRC_URI[aarch64_fence-agents-drac5.sha256sum] = "a59719a32e40d6f5c1f8332070a8a3ce5adaf179cebe0adff86539887ff5cacb"

URI_aarch64_fence-agents-eaton-snmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-eaton-snmp-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-eaton-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-eaton-snmp}"
SRC_URI[aarch64_fence-agents-eaton-snmp.sha256sum] = "0b0999a6a91f22466a5491207a091a28c25bb81a05e2b0936944be7611ba65d3"

URI_aarch64_fence-agents-emerson = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-emerson-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-emerson;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-emerson}"
SRC_URI[aarch64_fence-agents-emerson.sha256sum] = "9abf6a433e35acf8d54e055bc5274e0d29ccb70a80d60f2ee1b287fc01b1eedf"

URI_aarch64_fence-agents-eps = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-eps-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-eps;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-eps}"
SRC_URI[aarch64_fence-agents-eps.sha256sum] = "36a987eda4f9d6a9d20a1cc39671c839cef8f8cf7a1a2ddfd0f5b776911640a7"

URI_aarch64_fence-agents-heuristics-ping = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-heuristics-ping-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-heuristics-ping;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-heuristics-ping}"
SRC_URI[aarch64_fence-agents-heuristics-ping.sha256sum] = "50198c7c834360b6efcd019e35adba68451d1bbad23f6ebbbfa89eac20cb23b8"

URI_aarch64_fence-agents-hpblade = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-hpblade-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-hpblade;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-hpblade}"
SRC_URI[aarch64_fence-agents-hpblade.sha256sum] = "5303459777409ef4b3f4079b68eaab003ca9a185cb67385aecebbe1c24571323"

URI_aarch64_fence-agents-ibm-powervs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ibm-powervs-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-ibm-powervs;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ibm-powervs}"
SRC_URI[aarch64_fence-agents-ibm-powervs.sha256sum] = "a3321277669942dcc9fcd3d1f8ceaee127c1467ee3ebee7af79e7a2506d6f1b6"

URI_aarch64_fence-agents-ibm-vpc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ibm-vpc-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-ibm-vpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ibm-vpc}"
SRC_URI[aarch64_fence-agents-ibm-vpc.sha256sum] = "3a4d6106009b03f2132c3ad57eae15587f7f2d1fdb0082fb9948e623dccbb886"

URI_aarch64_fence-agents-ibmblade = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ibmblade-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-ibmblade;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ibmblade}"
SRC_URI[aarch64_fence-agents-ibmblade.sha256sum] = "660970a0c28837224104d51e8c7285b08ca08a1e8122540b90725a8c0c258acd"

URI_aarch64_fence-agents-ifmib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ifmib-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-ifmib;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ifmib}"
SRC_URI[aarch64_fence-agents-ifmib.sha256sum] = "2bee898705b712329ad9090ef64bbed93c153f0d67ec7adae77174a4fce06e7a"

URI_aarch64_fence-agents-ilo-moonshot = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ilo-moonshot-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-ilo-moonshot;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ilo-moonshot}"
SRC_URI[aarch64_fence-agents-ilo-moonshot.sha256sum] = "69628469403f127fef970ac8d9b38f283246daeb66b4fb9f5ef1b2fa5d7cc2cb"

URI_aarch64_fence-agents-ilo-mp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ilo-mp-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-ilo-mp;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ilo-mp}"
SRC_URI[aarch64_fence-agents-ilo-mp.sha256sum] = "ec9c6e5299b3204af714033321de69acfc95469555fd37691498d234da525fb8"

URI_aarch64_fence-agents-ilo-ssh = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ilo-ssh-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-ilo-ssh;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ilo-ssh}"
SRC_URI[aarch64_fence-agents-ilo-ssh.sha256sum] = "fb3cae6439435d2216e4e9dc6cc983a76ff67d93835f61fbb7555e7c569ef0a6"

URI_aarch64_fence-agents-ilo2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ilo2-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-ilo2;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ilo2}"
SRC_URI[aarch64_fence-agents-ilo2.sha256sum] = "a844a1e65f4df5fcd7a1a55b88d22d1857886636af68ed7fdb6251cbc5373358"

URI_aarch64_fence-agents-intelmodular = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-intelmodular-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-intelmodular;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-intelmodular}"
SRC_URI[aarch64_fence-agents-intelmodular.sha256sum] = "32af484c954d26fb8024e8716dcb133d67e30d32cbec733125d6273e654dea75"

URI_aarch64_fence-agents-ipdu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ipdu-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-ipdu;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ipdu}"
SRC_URI[aarch64_fence-agents-ipdu.sha256sum] = "a79d12e5e8af4ea84a8eb4709081695904c6f1e423e9b8e44de85147e4932364"

URI_aarch64_fence-agents-ipmilan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ipmilan-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-ipmilan;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-ipmilan}"
SRC_URI[aarch64_fence-agents-ipmilan.sha256sum] = "fb493bad94bfedc5af3b43b075fc3ed7853ef6c4569ff3baf00a0ef76b603250"

URI_aarch64_fence-agents-kdump = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-kdump-4.16.0-31.el10.aarch64.rpm;name=aarch64_fence-agents-kdump;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-kdump}"
SRC_URI[aarch64_fence-agents-kdump.sha256sum] = "a30500f8ef048ddcbd177c70a04a8d0700d50af8156a0a23cde3f1a80c3f9603"

URI_aarch64_fence-agents-kubevirt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-kubevirt-4.16.0-31.el10.aarch64.rpm;name=aarch64_fence-agents-kubevirt;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-kubevirt}"
SRC_URI[aarch64_fence-agents-kubevirt.sha256sum] = "fe7d7ca3e211b264eb1cf7159f53fab793cb3d9fcbe6ac831d3244a9fc1f5f40"

URI_aarch64_fence-agents-lpar = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-lpar-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-lpar;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-lpar}"
SRC_URI[aarch64_fence-agents-lpar.sha256sum] = "a2698cc9c0ed24a4c67e2571591b35a8c8100776b4d5276a7b633391efa157ad"

URI_aarch64_fence-agents-mpath = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-mpath-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-mpath;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-mpath}"
SRC_URI[aarch64_fence-agents-mpath.sha256sum] = "4507eabe2b412d366dc7ae15e7dfd3b98b40d5a4bd32870f16b53a9a7f797cd3"

URI_aarch64_fence-agents-nutanix-ahv = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-nutanix-ahv-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-nutanix-ahv;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-nutanix-ahv}"
SRC_URI[aarch64_fence-agents-nutanix-ahv.sha256sum] = "20f2ad536af80809679399f0321f814cf9a6d2d23bc574c5fd0b818a93314602"

URI_aarch64_fence-agents-redfish = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-redfish-4.16.0-31.el10.aarch64.rpm;name=aarch64_fence-agents-redfish;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-redfish}"
SRC_URI[aarch64_fence-agents-redfish.sha256sum] = "21f447230e61e6b1f3ceb0a2b19cbdc8a05968e25f15d1050fa00158a7861f2b"

URI_aarch64_fence-agents-rhevm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-rhevm-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-rhevm;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-rhevm}"
SRC_URI[aarch64_fence-agents-rhevm.sha256sum] = "701d1bbb5f263860ebf689ac2c6f1cae6a0d2718c7ffa859799be6d1027fd376"

URI_aarch64_fence-agents-rsa = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-rsa-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-rsa;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-rsa}"
SRC_URI[aarch64_fence-agents-rsa.sha256sum] = "d9873ec5a70baf2f8373742f9ef36726c258168e3ac7ccbab07d1d813bf794b5"

URI_aarch64_fence-agents-rsb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-rsb-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-rsb;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-rsb}"
SRC_URI[aarch64_fence-agents-rsb.sha256sum] = "f7ce317ba2ec04256d2906aef581d11c4e4bfbd04b776fa7ce5a49f390787881"

URI_aarch64_fence-agents-sbd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-sbd-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-sbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-sbd}"
SRC_URI[aarch64_fence-agents-sbd.sha256sum] = "4bb0a9b5d92647e3c9375a79fcf25609d179da42b79d59253226258c3ae65215"

URI_aarch64_fence-agents-scsi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-scsi-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-scsi;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-scsi}"
SRC_URI[aarch64_fence-agents-scsi.sha256sum] = "527e59fd6cbd99f47198edf3f9ecd78092e1fa0111cd5775dba02877eca2e875"

URI_aarch64_fence-agents-virsh = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-virsh-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-virsh;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-virsh}"
SRC_URI[aarch64_fence-agents-virsh.sha256sum] = "f602c467fb6a4d2767bcee3c6d0b3337dc612e40996728f9e68bbe6496bfaa83"

URI_aarch64_fence-agents-vmware-rest = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-vmware-rest-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-vmware-rest;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-vmware-rest}"
SRC_URI[aarch64_fence-agents-vmware-rest.sha256sum] = "ed5b9fbdc15c186acf886abdc4e2a0cf24a3ea6e3e80d51a4d839f8eb7bcff30"

URI_aarch64_fence-agents-vmware-soap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-vmware-soap-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-vmware-soap;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-vmware-soap}"
SRC_URI[aarch64_fence-agents-vmware-soap.sha256sum] = "2106cd1ff3450a0348743507b537dc2b0d638d52d0c93882ebf4c96343b2aeeb"

URI_aarch64_fence-agents-wti = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-wti-4.16.0-31.el10.noarch.rpm;name=aarch64_fence-agents-wti;unpack=0"
SRC_URI:append = " ${URI_aarch64_fence-agents-wti}"
SRC_URI[aarch64_fence-agents-wti.sha256sum] = "1cda814ceea0ee0a689a3a104851eb4de4b9a34bac9b448ba1d83bcd2d56aa87"

RDEPENDS:fence-agents-aliyun = " \
 fence-agents-common \
 ha-cloud-support \
 python3 \
 python3-jmespath \
 "
RDEPENDS:fence-agents-all:x86_64_v2 = " \
 fence-agents-amt-ws \
 fence-agents-apc \
 fence-agents-apc-snmp \
 fence-agents-bladecenter \
 fence-agents-brocade \
 fence-agents-cisco-mds \
 fence-agents-cisco-ucs \
 fence-agents-drac5 \
 fence-agents-eaton-snmp \
 fence-agents-emerson \
 fence-agents-eps \
 fence-agents-heuristics-ping \
 fence-agents-hpblade \
 fence-agents-ibmblade \
 fence-agents-ifmib \
 fence-agents-ilo-moonshot \
 fence-agents-ilo-mp \
 fence-agents-ilo-ssh \
 fence-agents-ilo2 \
 fence-agents-intelmodular \
 fence-agents-ipdu \
 fence-agents-ipmilan \
 fence-agents-kdump \
 fence-agents-mpath \
 fence-agents-redfish \
 fence-agents-rhevm \
 fence-agents-rsa \
 fence-agents-rsb \
 fence-agents-sbd \
 fence-agents-scsi \
 fence-agents-vmware-rest \
 fence-agents-vmware-soap \
 fence-agents-wti \
 fence-virt \
"
RDEPENDS:fence-agents-all:aarch64 = " \
 fence-agents-amt-ws \
 fence-agents-apc \
 fence-agents-apc-snmp \
 fence-agents-bladecenter \
 fence-agents-brocade \
 fence-agents-cisco-mds \
 fence-agents-cisco-ucs \
 fence-agents-drac5 \
 fence-agents-eaton-snmp \
 fence-agents-emerson \
 fence-agents-eps \
 fence-agents-heuristics-ping \
 fence-agents-hpblade \
 fence-agents-ibmblade \
 fence-agents-ifmib \
 fence-agents-ilo-moonshot \
 fence-agents-ilo-mp \
 fence-agents-ilo-ssh \
 fence-agents-ilo2 \
 fence-agents-intelmodular \
 fence-agents-ipdu \
 fence-agents-ipmilan \
 fence-agents-kdump \
 fence-agents-mpath \
 fence-agents-redfish \
 fence-agents-rhevm \
 fence-agents-rsa \
 fence-agents-rsb \
 fence-agents-sbd \
 fence-agents-scsi \
 fence-agents-vmware-rest \
 fence-agents-vmware-soap \
 fence-agents-wti \
"
RDEPENDS:fence-agents-amt-ws = " \
 fence-agents-common \
 openwsman-python3 \
 python3 \
 "
RDEPENDS:fence-agents-apc = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-apc-snmp = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-aws = " \
 fence-agents-common \
 ha-cloud-support \
 python3 \
 "
RDEPENDS:fence-agents-azure-arm = " \
 fence-agents-common \
 ha-cloud-support \
 python3 \
 "
RDEPENDS:fence-agents-bladecenter = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-brocade = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-cisco-mds = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-cisco-ucs = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-common = " \
 glibc \
 openssl-libs \
 pkgconf-pkg-config \
 python3 \
 python3-pexpect \
 python3-ptyprocess \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:fence-agents-drac5 = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-eaton-snmp = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-emerson = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-eps = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-gce = " \
 fence-agents-common \
 ha-cloud-support \
 python3 \
 "
RDEPENDS:fence-agents-heuristics-ping = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-hpblade = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-ibm-powervs = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-ibm-vpc = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-ibmblade = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-ifmib = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-ilo-moonshot = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-ilo-mp = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-ilo-ssh = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-ilo2 = " \
 fence-agents-common \
 gnutls-utils \
 python3 \
 "
RDEPENDS:fence-agents-intelmodular = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-ipdu = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-ipmilan = " \
 fence-agents-common \
 ipmitool \
 python3 \
 "
RDEPENDS:fence-agents-kdump = " \
 fence-agents-common \
 glibc \
 "
RDEPENDS:fence-agents-kubevirt = " \
 fence-agents-common \
 python3 \
 python3-charset-normalizer \
 python3-dateutil \
 python3-oauthlib \
 python3-pyasn1 \
 python3-pyyaml \
 python3-requests \
 python3-requests-oauthlib \
 python3-six \
 python3-urllib3 \
 "
RDEPENDS:fence-agents-lpar = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-mpath = " \
 device-mapper-multipath \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-nutanix-ahv = " \
 fence-agents-common \
 python3 \
 python3-requests \
 "
RDEPENDS:fence-agents-openstack = " \
 fence-agents-common \
 python3 \
 python3-requests \
 "
RDEPENDS:fence-agents-redfish = " \
 fence-agents-common \
 python3 \
 python3-requests \
 "
RDEPENDS:fence-agents-rhevm = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-rsa = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-rsb = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-sbd = " \
 fence-agents-common \
 python3 \
 sbd \
 "
RDEPENDS:fence-agents-scsi = " \
 fence-agents-common \
 python3 \
 sg3_utils \
 "
RDEPENDS:fence-agents-virsh = " \
 fence-agents-common \
 libvirt-client \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-vmware-rest = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-vmware-soap = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-wti = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-virt = " \
 glibc \
 nss \
 systemd \
 "
RDEPENDS:fence-virtd = " \
 glibc \
 libuuid \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:fence-virtd-cpg = " \
 corosynclib \
 fence-virtd \
 glibc \
 libqb \
 libvirt-libs \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:fence-virtd-libvirt = " \
 fence-virtd \
 glibc \
 libvirt \
 libvirt-libs \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:fence-virtd-multicast = " \
 fence-virtd \
 glibc \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:fence-virtd-serial = " \
 fence-virtd \
 glibc \
 libvirt \
 libvirt-libs \
 libxml2 \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:fence-virtd-tcp = " \
 fence-virtd \
 glibc \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:ha-cloud-support = " \
 awscli2 \
 glibc \
 python3-cffi \
 python3-charset-normalizer \
 python3-colorama \
 python3-cryptography \
 python3-dateutil \
 python3-docutils \
 python3-idna \
 python3-jmespath \
 python3-oauthlib \
 python3-packaging \
 python3-protobuf \
 python3-pyasn1 \
 python3-pycparser \
 python3-pyparsing \
 python3-pyyaml \
 python3-requests \
 python3-requests-oauthlib \
 python3-six \
 python3-typing-extensions \
 python3-urllib3 \
 "
