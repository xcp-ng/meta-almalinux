# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kpimtextedit"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kpimtextedit \
 kpimtextedit-devel \
 kpimtextedit-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kpimtextedit-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72ac3fe40e0d0fb3688b184c2ff421ba805dafb5dca75c3611e6da89d31c70d4"

URI_x86_64_v2_kpimtextedit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpimtextedit-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpimtextedit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpimtextedit}"
SRC_URI[x86_64_v2_kpimtextedit.sha256sum] = "55c48454dfe25364c51c68ce06b25f38d9eac8a3871afed00a67b44add75697d"

URI_x86_64_v2_kpimtextedit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpimtextedit-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpimtextedit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpimtextedit-devel}"
SRC_URI[x86_64_v2_kpimtextedit-devel.sha256sum] = "1e7a48c60e1327a944c6dcdf736606feb34ab0a49e1a863032e1fee64ae5a011"

URI_x86_64_v2_kpimtextedit-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpimtextedit-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kpimtextedit-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpimtextedit-doc}"
SRC_URI[x86_64_v2_kpimtextedit-doc.sha256sum] = "15134209887725faaac9b9c78c20616f7b2b00d976b3c47a9b8381223a37f4a0"

URI_aarch64_kpimtextedit = "${EPEL_MIRROR}/aarch64/Packages/k/kpimtextedit-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kpimtextedit;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpimtextedit}"
SRC_URI[aarch64_kpimtextedit.sha256sum] = "91f2b485b9380d40ceef3d6881718a2328accd9f722209b4cc3899ffadb147fb"

URI_aarch64_kpimtextedit-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kpimtextedit-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kpimtextedit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpimtextedit-devel}"
SRC_URI[aarch64_kpimtextedit-devel.sha256sum] = "ccbbb0fbedd25c91d2422c667176666b66b90b5aeca73ff71da0035aa262f820"

URI_aarch64_kpimtextedit-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kpimtextedit-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_kpimtextedit-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpimtextedit-doc}"
SRC_URI[aarch64_kpimtextedit-doc.sha256sum] = "5b5732c9201132fe53f178954bc304e87768045a872b46bd8ffc4e8274f803fe"

RDEPENDS:kpimtextedit = " \
 glibc \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 kf6-syntax-highlighting \
 ktextaddons-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kpimtextedit-devel = " \
 cmake-filesystem \
 kf6-ktextwidgets-devel \
 kpimtextedit \
 "
RDEPENDS:kpimtextedit-doc = " \
 "
