# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vkroots"
PV = "0^20240429git5106d8a"
PR = "1.el10_0"
PACKAGES = " \
 vkroots-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vkroots-0^20240429git5106d8a-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "044cf3f228f3b07549980fbdc419f8a7e8ec9b191b462154793c6460a3b44099"

URI_x86_64_v2_vkroots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vkroots-devel-0^20240429git5106d8a-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vkroots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vkroots-devel}"
SRC_URI[x86_64_v2_vkroots-devel.sha256sum] = "ea61a6d98cd6066715d9fc040287407400e020afcfdc2192dcd9bf45bc0282f8"

URI_aarch64_vkroots-devel = "${EPEL_MIRROR}/aarch64/Packages/v/vkroots-devel-0^20240429git5106d8a-1.el10_0.aarch64.rpm;name=aarch64_vkroots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vkroots-devel}"
SRC_URI[aarch64_vkroots-devel.sha256sum] = "904d222b20df02761be09baafc72345946605dcab89528798032724422631ae0"

RDEPENDS:vkroots-devel = " \
 pkgconf-pkg-config \
 "
