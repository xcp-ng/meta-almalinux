# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-flexmock"
PV = "3.0.2"
PR = "1.el10_1"
PACKAGES = " \
 rubygem-flexmock \
 rubygem-flexmock-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-flexmock-3.0.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b01043ba4a53076384e0f8261a46be78d9764fe93ed04bc448b92b932b881f4"

URI_x86_64_v2_rubygem-flexmock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-flexmock-3.0.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-flexmock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-flexmock}"
SRC_URI[x86_64_v2_rubygem-flexmock.sha256sum] = "f5055f08043314bf527c71fee51b7ac33f4eb4052b7d0e94d50bfc01023580e0"

URI_x86_64_v2_rubygem-flexmock-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-flexmock-doc-3.0.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-flexmock-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-flexmock-doc}"
SRC_URI[x86_64_v2_rubygem-flexmock-doc.sha256sum] = "4d48fe1fb3b99b130c75879b6ef43af0e5d138000b220d39552988c8a17cf91b"

URI_aarch64_rubygem-flexmock = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-flexmock-3.0.2-1.el10_1.noarch.rpm;name=aarch64_rubygem-flexmock;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-flexmock}"
SRC_URI[aarch64_rubygem-flexmock.sha256sum] = "4a98b023a23f169d24f19b9121ead7a238ebb8640c9e8fb4fcb16aa51eafdd60"

URI_aarch64_rubygem-flexmock-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-flexmock-doc-3.0.2-1.el10_1.noarch.rpm;name=aarch64_rubygem-flexmock-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-flexmock-doc}"
SRC_URI[aarch64_rubygem-flexmock-doc.sha256sum] = "a5db78826f68fdab4ad87f38a24ca95cdcf5439eaa80482effe28015a6b131d1"

RDEPENDS:rubygem-flexmock = " \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-flexmock-doc = " \
 rubygem-flexmock \
 "
