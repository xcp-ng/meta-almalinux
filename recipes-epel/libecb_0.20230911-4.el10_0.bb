# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libecb"
PV = "0.20230911"
PR = "4.el10_0"
PACKAGES = " \
 libecb-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libecb-0.20230911-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d821599d90080b8c070bd78bb840050bcfd329608f205f6cbdd9adf02651a446"

URI_x86_64_v2_libecb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libecb-devel-0.20230911-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libecb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libecb-devel}"
SRC_URI[x86_64_v2_libecb-devel.sha256sum] = "b42381c98bdb51912e78dfbd3e8bf87eec16abc35b4026316d6d49179bf26400"

URI_aarch64_libecb-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libecb-devel-0.20230911-4.el10_0.aarch64.rpm;name=aarch64_libecb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libecb-devel}"
SRC_URI[aarch64_libecb-devel.sha256sum] = "f499e179048a936dd1ab06df7e32f5508618f48cf7d0d516cf42e07e796f2483"

RDEPENDS:libecb-devel = " \
 "
