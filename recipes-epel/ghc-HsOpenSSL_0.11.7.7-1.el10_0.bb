# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-HsOpenSSL"
PV = "0.11.7.7"
PR = "1.el10_0"
PACKAGES = " \
 ghc-HsOpenSSL \
 ghc-HsOpenSSL-devel \
 ghc-HsOpenSSL-doc \
 ghc-HsOpenSSL-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-HsOpenSSL-0.11.7.7-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "11fd697dbb31853c2115f192ad6a90b76b673e783f1ebc0eb8db6b645506d641"

URI_x86_64_v2_ghc-HsOpenSSL = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-HsOpenSSL-0.11.7.7-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-HsOpenSSL;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-HsOpenSSL}"
SRC_URI[x86_64_v2_ghc-HsOpenSSL.sha256sum] = "220e0917782ecf0517435189a3db961ea20ecbc335bc810f3284acc0ffe35173"

URI_x86_64_v2_ghc-HsOpenSSL-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-HsOpenSSL-devel-0.11.7.7-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-HsOpenSSL-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-HsOpenSSL-devel}"
SRC_URI[x86_64_v2_ghc-HsOpenSSL-devel.sha256sum] = "893d4c19b83af4e84e8787283064942e9cef110cfc409335e3c22c1d24a39bc5"

URI_x86_64_v2_ghc-HsOpenSSL-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-HsOpenSSL-doc-0.11.7.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-HsOpenSSL-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-HsOpenSSL-doc}"
SRC_URI[x86_64_v2_ghc-HsOpenSSL-doc.sha256sum] = "7db012f93f128b906c8b77060fa0cf1c4963f82619a3fc007212de3b9157c39e"

URI_x86_64_v2_ghc-HsOpenSSL-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-HsOpenSSL-prof-0.11.7.7-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-HsOpenSSL-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-HsOpenSSL-prof}"
SRC_URI[x86_64_v2_ghc-HsOpenSSL-prof.sha256sum] = "7426d2dcfb6dc0d3b6f589abffdbfed5c3e4bc555c1a402c16be2addf50defcc"

URI_aarch64_ghc-HsOpenSSL = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-HsOpenSSL-0.11.7.7-1.el10_0.aarch64.rpm;name=aarch64_ghc-HsOpenSSL;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-HsOpenSSL}"
SRC_URI[aarch64_ghc-HsOpenSSL.sha256sum] = "adc81cd3bb4fc5a5b6f5fd4b6cbc473ebd79f1d06edfbc8eadf8825b14661027"

URI_aarch64_ghc-HsOpenSSL-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-HsOpenSSL-devel-0.11.7.7-1.el10_0.aarch64.rpm;name=aarch64_ghc-HsOpenSSL-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-HsOpenSSL-devel}"
SRC_URI[aarch64_ghc-HsOpenSSL-devel.sha256sum] = "68ebd7a7a214d978c3002d06dffc966ded54c18dcef1be1cc627da01cb4d31d7"

URI_aarch64_ghc-HsOpenSSL-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-HsOpenSSL-doc-0.11.7.7-1.el10_0.noarch.rpm;name=aarch64_ghc-HsOpenSSL-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-HsOpenSSL-doc}"
SRC_URI[aarch64_ghc-HsOpenSSL-doc.sha256sum] = "110dc0bd9ab5cc8548ff01ef4b92c27ec6597679c32ee94f7af3b613d7f9b854"

URI_aarch64_ghc-HsOpenSSL-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-HsOpenSSL-prof-0.11.7.7-1.el10_0.aarch64.rpm;name=aarch64_ghc-HsOpenSSL-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-HsOpenSSL-prof}"
SRC_URI[aarch64_ghc-HsOpenSSL-prof.sha256sum] = "d926d6745ae49a0f2fed880b2e0d89f8d0089672f6bb12ed57a950303f07197a"

RDEPENDS:ghc-HsOpenSSL = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-network \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 openssl-libs \
 "
RDEPENDS:ghc-HsOpenSSL-devel = " \
 ghc-HsOpenSSL \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-network-devel \
 ghc-time-devel \
 openssl-devel \
 "
RDEPENDS:ghc-HsOpenSSL-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-HsOpenSSL-prof = " \
 ghc-HsOpenSSL-devel \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-network-prof \
 ghc-time-prof \
 "
