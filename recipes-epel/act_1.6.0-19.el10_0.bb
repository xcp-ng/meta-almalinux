# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "act"
PV = "1.6.0"
PR = "19.el10_0"
PACKAGES = " \
 act \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/act-1.6.0-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3b944a703dca11ee1cecec13b56a8f61d524bd8a1e66c59cc82899cdc2c12ed"

URI_x86_64_v2_act = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/act-1.6.0-19.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_act;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_act}"
SRC_URI[x86_64_v2_act.sha256sum] = "4cd4f4935bbe03487164262409d7bbc6e1d62d42ce8b0706f7079d71834a9489"

URI_aarch64_act = "${EPEL_MIRROR}/aarch64/Packages/a/act-1.6.0-19.el10_0.aarch64.rpm;name=aarch64_act;unpack=0"
SRC_URI:append = " ${URI_aarch64_act}"
SRC_URI[aarch64_act.sha256sum] = "b5808fda7cb9de7faebce793bafd304121ec5729fadd56807ea176b79cb302df"

RDEPENDS:act = " \
 glibc \
 "
