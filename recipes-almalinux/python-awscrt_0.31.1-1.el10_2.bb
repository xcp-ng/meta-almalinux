# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-awscrt"
PV = "0.31.1"
PR = "1.el10_2"
PACKAGES = " \
 python3-awscrt \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-awscrt-0.31.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2253182e5472b921c2daeccf6a659a62837a3948f250e1527a83f2ec52934c55"

URI_x86_64_v2_python3-awscrt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-awscrt-0.31.1-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3-awscrt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-awscrt}"
SRC_URI[x86_64_v2_python3-awscrt.sha256sum] = "8f1aabb43dea944ab747488b20b3586fde56ed70e3cabd09fb28024740d7d589"

URI_aarch64_python3-awscrt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-awscrt-0.31.1-1.el10_2.aarch64.rpm;name=aarch64_python3-awscrt;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-awscrt}"
SRC_URI[aarch64_python3-awscrt.sha256sum] = "122fb807c032b5ca7f8eda2db63805687c77f1d0d4d77d289dbe354241c0522e"

RDEPENDS:python3-awscrt = " \
 glibc \
 libgcc \
 openssl-libs \
 python3 \
 "
