# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-humantime"
PV = "2.4.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-humantime+default-devel \
 rust-humantime+mu-devel \
 rust-humantime-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-humantime-2.4.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "683565e0533e9b04e607237ceef79495cc48d5a3c946129f658323c2c03daf97"

URI_x86_64_v2_rust-humantime+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-humantime+default-devel-2.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-humantime+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-humantime+default-devel}"
SRC_URI[x86_64_v2_rust-humantime+default-devel.sha256sum] = "354f30b79f92c8c7ab02d34f32650374ccf3f073099a4d116f859244016d11ac"

URI_x86_64_v2_rust-humantime+mu-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-humantime+mu-devel-2.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-humantime+mu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-humantime+mu-devel}"
SRC_URI[x86_64_v2_rust-humantime+mu-devel.sha256sum] = "f630e875933fd60ab16bbc7e8a726ef51abb0e26d64cd9d790bbd5f968784b46"

URI_x86_64_v2_rust-humantime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-humantime-devel-2.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-humantime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-humantime-devel}"
SRC_URI[x86_64_v2_rust-humantime-devel.sha256sum] = "7c14f9308ce7004c271a347c1688d36081e6f5838a0f1e5b630f03aabb73c6ac"

URI_aarch64_rust-humantime+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-humantime+default-devel-2.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-humantime+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-humantime+default-devel}"
SRC_URI[aarch64_rust-humantime+default-devel.sha256sum] = "cb080c66cc8ecea7945df35bd88eb3f6b6b817c7ced8739e109de0c9966d74b6"

URI_aarch64_rust-humantime+mu-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-humantime+mu-devel-2.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-humantime+mu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-humantime+mu-devel}"
SRC_URI[aarch64_rust-humantime+mu-devel.sha256sum] = "e4a7c18fecdc219f81781aba78f062aaf28220536ee919f16313ee1f4f428f81"

URI_aarch64_rust-humantime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-humantime-devel-2.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-humantime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-humantime-devel}"
SRC_URI[aarch64_rust-humantime-devel.sha256sum] = "f330944b8de4fed6378076a4362051913aa9aaecd655ffa8402c6a374302cf23"

RDEPENDS:rust-humantime+default-devel = " \
 cargo \
 rust-humantime-devel \
 "
RDEPENDS:rust-humantime+mu-devel = " \
 cargo \
 rust-humantime-devel \
 "
RDEPENDS:rust-humantime-devel = " \
 cargo \
 rust \
 "
