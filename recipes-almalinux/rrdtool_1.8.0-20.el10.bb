# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rrdtool"
PV = "1.8.0"
PR = "20.el10"
PACKAGES = " \
 python3-rrdtool \
 rrdtool \
 rrdtool-devel \
 rrdtool-doc \
 rrdtool-lua \
 rrdtool-perl \
 rrdtool-ruby \
 rrdtool-tcl \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rrdtool-1.8.0-20.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d60705ce1e2ac267626e58c8f5f4d0b120eb0a83aa77ec6f282770bd6d8df15f"

URI_x86_64_v2_python3-rrdtool = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-rrdtool-1.8.0-20.el10.x86_64_v2.rpm;name=x86_64_v2_python3-rrdtool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rrdtool}"
SRC_URI[x86_64_v2_python3-rrdtool.sha256sum] = "7cdeba3e5c5af5b71f2c2f49d6b1d84e69e2f5c13198769cbceeb1073759a94a"

URI_x86_64_v2_rrdtool = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rrdtool-1.8.0-20.el10.x86_64_v2.rpm;name=x86_64_v2_rrdtool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rrdtool}"
SRC_URI[x86_64_v2_rrdtool.sha256sum] = "36bbf31fb821c7a93bda1be8ff34bd4040f7e2e5fe96c5da1e181df3682d97e0"

URI_x86_64_v2_rrdtool-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rrdtool-devel-1.8.0-20.el10.x86_64_v2.rpm;name=x86_64_v2_rrdtool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rrdtool-devel}"
SRC_URI[x86_64_v2_rrdtool-devel.sha256sum] = "1541b2324b82a682de72d182414a18e0460e2eeb0ebea6a5f0ffc2c6493ce64a"

URI_x86_64_v2_rrdtool-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rrdtool-doc-1.8.0-20.el10.x86_64_v2.rpm;name=x86_64_v2_rrdtool-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rrdtool-doc}"
SRC_URI[x86_64_v2_rrdtool-doc.sha256sum] = "afc3ad22c37cfb4ee750c9a7f51f4027f473132c64299a9771c942ca95c1971c"

URI_x86_64_v2_rrdtool-lua = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rrdtool-lua-1.8.0-20.el10.x86_64_v2.rpm;name=x86_64_v2_rrdtool-lua;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rrdtool-lua}"
SRC_URI[x86_64_v2_rrdtool-lua.sha256sum] = "bc8e50151e3390a177283b07ec11b5fdf67f668553db530e8cb6136c73460688"

URI_x86_64_v2_rrdtool-perl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rrdtool-perl-1.8.0-20.el10.x86_64_v2.rpm;name=x86_64_v2_rrdtool-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rrdtool-perl}"
SRC_URI[x86_64_v2_rrdtool-perl.sha256sum] = "2d765863b1ae9fa7de51a64d4011af622d61164a01825374b064620be883c891"

URI_x86_64_v2_rrdtool-ruby = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rrdtool-ruby-1.8.0-20.el10.x86_64_v2.rpm;name=x86_64_v2_rrdtool-ruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rrdtool-ruby}"
SRC_URI[x86_64_v2_rrdtool-ruby.sha256sum] = "82939ac5af99f6a0f87bf6a64ea0c6f8ade9fb03cfb85ab28cf24b340efe9756"

URI_x86_64_v2_rrdtool-tcl = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rrdtool-tcl-1.8.0-20.el10.x86_64_v2.rpm;name=x86_64_v2_rrdtool-tcl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rrdtool-tcl}"
SRC_URI[x86_64_v2_rrdtool-tcl.sha256sum] = "325a3de1417911e07686a3e2f0b777e6a6f2853e6f1ba1ea48f44864bdbb9fdb"

URI_aarch64_python3-rrdtool = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-rrdtool-1.8.0-20.el10.aarch64.rpm;name=aarch64_python3-rrdtool;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rrdtool}"
SRC_URI[aarch64_python3-rrdtool.sha256sum] = "f98f5157c8dd34ae06129efdafc9ec400e889aa77b9eb5e6fc5f94e8a346d072"

URI_aarch64_rrdtool = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rrdtool-1.8.0-20.el10.aarch64.rpm;name=aarch64_rrdtool;unpack=0"
SRC_URI:append = " ${URI_aarch64_rrdtool}"
SRC_URI[aarch64_rrdtool.sha256sum] = "8f1dc7a42c8033e20a20467a81f7280e66075b6ad2e9b29ad8f16973accc9768"

URI_aarch64_rrdtool-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rrdtool-devel-1.8.0-20.el10.aarch64.rpm;name=aarch64_rrdtool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rrdtool-devel}"
SRC_URI[aarch64_rrdtool-devel.sha256sum] = "0d086d79839ec2b20ae34e4476763c413fb47ff85d07259caebaf7955843c230"

URI_aarch64_rrdtool-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rrdtool-doc-1.8.0-20.el10.aarch64.rpm;name=aarch64_rrdtool-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rrdtool-doc}"
SRC_URI[aarch64_rrdtool-doc.sha256sum] = "2df590d40d96edcd1e4da962727c520a070515c0f208108421a5c054c5ff512d"

URI_aarch64_rrdtool-lua = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rrdtool-lua-1.8.0-20.el10.aarch64.rpm;name=aarch64_rrdtool-lua;unpack=0"
SRC_URI:append = " ${URI_aarch64_rrdtool-lua}"
SRC_URI[aarch64_rrdtool-lua.sha256sum] = "4931c45292da5ca2f67648c7efaf755c2819b16bf1cd4c53b291cb755340324c"

URI_aarch64_rrdtool-perl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rrdtool-perl-1.8.0-20.el10.aarch64.rpm;name=aarch64_rrdtool-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_rrdtool-perl}"
SRC_URI[aarch64_rrdtool-perl.sha256sum] = "c112fcb161f7d3960bf7336f4ce2d631d014187878a5dede685be653875bc295"

URI_aarch64_rrdtool-ruby = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rrdtool-ruby-1.8.0-20.el10.aarch64.rpm;name=aarch64_rrdtool-ruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_rrdtool-ruby}"
SRC_URI[aarch64_rrdtool-ruby.sha256sum] = "98c8e86663e06a440a970dd628f5017b4a088024a80690f2e1b8f398c6b3ba5f"

URI_aarch64_rrdtool-tcl = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rrdtool-tcl-1.8.0-20.el10.aarch64.rpm;name=aarch64_rrdtool-tcl;unpack=0"
SRC_URI:append = " ${URI_aarch64_rrdtool-tcl}"
SRC_URI[aarch64_rrdtool-tcl.sha256sum] = "812d70f5c6257543a0fd58ceb32c99902ba6ded05641028c7e1c55e1e908c2c3"

RDEPENDS:python3-rrdtool = " \
 glibc \
 python3 \
 rrdtool \
 "
RDEPENDS:rrdtool = " \
 bash \
 cairo \
 dejavu-sans-mono-fonts \
 glib2 \
 glibc \
 harfbuzz \
 libpng \
 libxml2 \
 pango \
 systemd \
 "
RDEPENDS:rrdtool-devel = " \
 pkgconf-pkg-config \
 rrdtool \
 "
RDEPENDS:rrdtool-doc = " \
 "
RDEPENDS:rrdtool-lua = " \
 cairo \
 glib2 \
 glibc \
 harfbuzz \
 libpng \
 libxml2 \
 lua-libs \
 pango \
 rrdtool \
 "
RDEPENDS:rrdtool-perl = " \
 glibc \
 perl-Carp \
 perl-DynaLoader \
 perl-Fcntl \
 perl-IO \
 perl-IPC-Open3 \
 perl-libs \
 perl-vars \
 rrdtool \
 "
RDEPENDS:rrdtool-ruby = " \
 glibc \
 rrdtool \
 ruby-libs \
 "
RDEPENDS:rrdtool-tcl = " \
 glibc \
 rrdtool \
 tcl \
 "
