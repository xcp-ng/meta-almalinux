# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures"
PV = "0.3.31"
PR = "2.el10_0"
PACKAGES = " \
 rust-futures+alloc-devel \
 rust-futures+async-await-devel \
 rust-futures+bilock-devel \
 rust-futures+cfg-target-has-atomic-devel \
 rust-futures+default-devel \
 rust-futures+executor-devel \
 rust-futures+futures-executor-devel \
 rust-futures+std-devel \
 rust-futures+thread-pool-devel \
 rust-futures+unstable-devel \
 rust-futures+write-all-vectored-devel \
 rust-futures-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-0.3.31-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e36e9987c5291d53e435c324650e2b72dd63f03b4d427e9bd791bebdd250ed0"

URI_x86_64_v2_rust-futures+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+alloc-devel-0.3.31-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+alloc-devel}"
SRC_URI[x86_64_v2_rust-futures+alloc-devel.sha256sum] = "9e33bea2d085f4f6d67d709326dd1621379af5374d7b8203ade1e11b60d70217"

URI_x86_64_v2_rust-futures+async-await-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+async-await-devel-0.3.31-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+async-await-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+async-await-devel}"
SRC_URI[x86_64_v2_rust-futures+async-await-devel.sha256sum] = "a8100fe10a8b351c82a2f744837e363fa5f19a95d58e605345d974917f794928"

URI_x86_64_v2_rust-futures+bilock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+bilock-devel-0.3.31-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+bilock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+bilock-devel}"
SRC_URI[x86_64_v2_rust-futures+bilock-devel.sha256sum] = "54f1b734036e0054665fc3a755c114eb28b754451d7a1137ce93fbb7ce9076e5"

URI_x86_64_v2_rust-futures+cfg-target-has-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+cfg-target-has-atomic-devel-0.3.31-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+cfg-target-has-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+cfg-target-has-atomic-devel}"
SRC_URI[x86_64_v2_rust-futures+cfg-target-has-atomic-devel.sha256sum] = "1bcac0ee0629415fa614ae6bdb8ff5d7b1c00e65eac21f800e08e42f556783a2"

URI_x86_64_v2_rust-futures+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+default-devel-0.3.31-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+default-devel}"
SRC_URI[x86_64_v2_rust-futures+default-devel.sha256sum] = "5e344461f4972f923c2aceaa5db0da94cb1a6d20dc9888fa1a33a7ac1cc9ac03"

URI_x86_64_v2_rust-futures+executor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+executor-devel-0.3.31-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+executor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+executor-devel}"
SRC_URI[x86_64_v2_rust-futures+executor-devel.sha256sum] = "386c177ffaeddd00daa01f2afa552545e2762aebcaee6194c5a5a7f817b09654"

URI_x86_64_v2_rust-futures+futures-executor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+futures-executor-devel-0.3.31-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+futures-executor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+futures-executor-devel}"
SRC_URI[x86_64_v2_rust-futures+futures-executor-devel.sha256sum] = "ff306ac96cf3c3cdc4811c9d79152b38fe823431536501792e6c4d940051e24e"

URI_x86_64_v2_rust-futures+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+std-devel-0.3.31-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+std-devel}"
SRC_URI[x86_64_v2_rust-futures+std-devel.sha256sum] = "729d9b560e6b51991ac38404cf554546e137586ebaefd85f874a3130d3164452"

URI_x86_64_v2_rust-futures+thread-pool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+thread-pool-devel-0.3.31-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+thread-pool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+thread-pool-devel}"
SRC_URI[x86_64_v2_rust-futures+thread-pool-devel.sha256sum] = "f515b34a49d9b44b46d5961c29a948b27541dab6a03f4af7470ffbfa2135a525"

URI_x86_64_v2_rust-futures+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+unstable-devel-0.3.31-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+unstable-devel}"
SRC_URI[x86_64_v2_rust-futures+unstable-devel.sha256sum] = "8f965137d6c22d362f85b851041312a9b439391cc284f0269c0db80084c2a47d"

URI_x86_64_v2_rust-futures+write-all-vectored-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures+write-all-vectored-devel-0.3.31-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures+write-all-vectored-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures+write-all-vectored-devel}"
SRC_URI[x86_64_v2_rust-futures+write-all-vectored-devel.sha256sum] = "8d5d06ccefcf4450939df2fe6876b5ac9c84c07ab48c497af257eaef000c5208"

URI_x86_64_v2_rust-futures-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-devel-0.3.31-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-devel}"
SRC_URI[x86_64_v2_rust-futures-devel.sha256sum] = "96fef966cd4aa5d7d56690f5dd1b014a65e3c28bc20e6e6605bc7fd1c6beed25"

URI_aarch64_rust-futures+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+alloc-devel-0.3.31-2.el10_0.noarch.rpm;name=aarch64_rust-futures+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+alloc-devel}"
SRC_URI[aarch64_rust-futures+alloc-devel.sha256sum] = "91bb42ca3980e7280c414cdb32c9e5cb916ceaf197f824f3206920b5b65eb538"

URI_aarch64_rust-futures+async-await-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+async-await-devel-0.3.31-2.el10_0.noarch.rpm;name=aarch64_rust-futures+async-await-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+async-await-devel}"
SRC_URI[aarch64_rust-futures+async-await-devel.sha256sum] = "596088b5e414cd8b1297611694f86789ca92f2ca86edc8ab419a736ac838250e"

URI_aarch64_rust-futures+bilock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+bilock-devel-0.3.31-2.el10_0.noarch.rpm;name=aarch64_rust-futures+bilock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+bilock-devel}"
SRC_URI[aarch64_rust-futures+bilock-devel.sha256sum] = "7b7ee1c7fd41fe215a23e1b460b74a9921d7f87809c0f0042b044185c478713f"

URI_aarch64_rust-futures+cfg-target-has-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+cfg-target-has-atomic-devel-0.3.31-2.el10_0.noarch.rpm;name=aarch64_rust-futures+cfg-target-has-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+cfg-target-has-atomic-devel}"
SRC_URI[aarch64_rust-futures+cfg-target-has-atomic-devel.sha256sum] = "7628b07541245d62c6c4d0c48b57595a014a46c6916c743403be195fd9314978"

URI_aarch64_rust-futures+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+default-devel-0.3.31-2.el10_0.noarch.rpm;name=aarch64_rust-futures+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+default-devel}"
SRC_URI[aarch64_rust-futures+default-devel.sha256sum] = "10dc5103a7abb05dae9aa724e7bb85b6e33399d7b57e177a9e8b50a689aad923"

URI_aarch64_rust-futures+executor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+executor-devel-0.3.31-2.el10_0.noarch.rpm;name=aarch64_rust-futures+executor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+executor-devel}"
SRC_URI[aarch64_rust-futures+executor-devel.sha256sum] = "b7ba3917878ae91d011255f8cab7bfd57f9feb842c0faf1dd27520c27643da35"

URI_aarch64_rust-futures+futures-executor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+futures-executor-devel-0.3.31-2.el10_0.noarch.rpm;name=aarch64_rust-futures+futures-executor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+futures-executor-devel}"
SRC_URI[aarch64_rust-futures+futures-executor-devel.sha256sum] = "abc4767090d755e34cd3d4a3d3c28bda30c7f1788ac394d9d9fa2f44fd0c020c"

URI_aarch64_rust-futures+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+std-devel-0.3.31-2.el10_0.noarch.rpm;name=aarch64_rust-futures+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+std-devel}"
SRC_URI[aarch64_rust-futures+std-devel.sha256sum] = "57eb72bd61f8d0717400bbdb997be8111674c2189b5a27c725ee47c3932048bc"

URI_aarch64_rust-futures+thread-pool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+thread-pool-devel-0.3.31-2.el10_0.noarch.rpm;name=aarch64_rust-futures+thread-pool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+thread-pool-devel}"
SRC_URI[aarch64_rust-futures+thread-pool-devel.sha256sum] = "77a2f8260b900099c24196299ca889a17015d5a45b14e001fe170fe87c133d4e"

URI_aarch64_rust-futures+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+unstable-devel-0.3.31-2.el10_0.noarch.rpm;name=aarch64_rust-futures+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+unstable-devel}"
SRC_URI[aarch64_rust-futures+unstable-devel.sha256sum] = "4914806c152a19f714864971d14509fd9362c3f5ba5fc572981ad533e76b84d0"

URI_aarch64_rust-futures+write-all-vectored-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures+write-all-vectored-devel-0.3.31-2.el10_0.noarch.rpm;name=aarch64_rust-futures+write-all-vectored-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures+write-all-vectored-devel}"
SRC_URI[aarch64_rust-futures+write-all-vectored-devel.sha256sum] = "2b2cecf0002ea41fbae44796be2045a7f664768b543a64199a49c89639b4f5e7"

URI_aarch64_rust-futures-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-devel-0.3.31-2.el10_0.noarch.rpm;name=aarch64_rust-futures-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-devel}"
SRC_URI[aarch64_rust-futures-devel.sha256sum] = "90f17a119ef5391cf7d8f38705688ce6626c67b8831115b2545e167e1c8a8c00"

RDEPENDS:rust-futures+alloc-devel = " \
 cargo \
 rust-futures-channel+alloc-devel \
 rust-futures-core+alloc-devel \
 rust-futures-devel \
 rust-futures-sink+alloc-devel \
 rust-futures-task+alloc-devel \
 rust-futures-util+alloc-devel \
 "
RDEPENDS:rust-futures+async-await-devel = " \
 cargo \
 rust-futures-devel \
 rust-futures-util+async-await-devel \
 rust-futures-util+async-await-macro-devel \
 "
RDEPENDS:rust-futures+bilock-devel = " \
 cargo \
 rust-futures-devel \
 rust-futures-util+bilock-devel \
 "
RDEPENDS:rust-futures+cfg-target-has-atomic-devel = " \
 cargo \
 rust-futures-devel \
 "
RDEPENDS:rust-futures+default-devel = " \
 cargo \
 rust-futures+async-await-devel \
 rust-futures+executor-devel \
 rust-futures+std-devel \
 rust-futures-devel \
 "
RDEPENDS:rust-futures+executor-devel = " \
 cargo \
 rust-futures+std-devel \
 rust-futures-devel \
 rust-futures-executor+std-devel \
 rust-futures-executor-devel \
 "
RDEPENDS:rust-futures+futures-executor-devel = " \
 cargo \
 rust-futures-devel \
 rust-futures-executor-devel \
 "
RDEPENDS:rust-futures+std-devel = " \
 cargo \
 rust-futures+alloc-devel \
 rust-futures-core+std-devel \
 rust-futures-devel \
 rust-futures-io+std-devel \
 rust-futures-sink+std-devel \
 rust-futures-task+std-devel \
 rust-futures-util+channel-devel \
 rust-futures-util+io-devel \
 rust-futures-util+std-devel \
 "
RDEPENDS:rust-futures+thread-pool-devel = " \
 cargo \
 rust-futures+executor-devel \
 rust-futures-devel \
 rust-futures-executor+thread-pool-devel \
 rust-futures-executor-devel \
 "
RDEPENDS:rust-futures+unstable-devel = " \
 cargo \
 rust-futures-channel+unstable-devel \
 rust-futures-core+unstable-devel \
 rust-futures-devel \
 rust-futures-io+unstable-devel \
 rust-futures-task+unstable-devel \
 rust-futures-util+unstable-devel \
 "
RDEPENDS:rust-futures+write-all-vectored-devel = " \
 cargo \
 rust-futures-devel \
 rust-futures-util+write-all-vectored-devel \
 "
RDEPENDS:rust-futures-devel = " \
 cargo \
 rust \
 rust-futures-channel+sink-devel \
 rust-futures-channel-devel \
 rust-futures-core-devel \
 rust-futures-io-devel \
 rust-futures-sink-devel \
 rust-futures-task-devel \
 rust-futures-util+sink-devel \
 rust-futures-util-devel \
 "
