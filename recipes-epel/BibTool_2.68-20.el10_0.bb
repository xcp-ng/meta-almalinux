# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "BibTool"
PV = "2.68"
PR = "20.el10_0"
PACKAGES = " \
 BibTool \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/BibTool-2.68-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8f6dd15b6313758171b856a4598c2557ee457bd2d40972cf7a4d4b115fc6b8d"

URI_x86_64_v2_BibTool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/BibTool-2.68-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_BibTool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_BibTool}"
SRC_URI[x86_64_v2_BibTool.sha256sum] = "7bab1747bc795a07735c8eadd5d2967e5017603369b8ee7abd0cf0be63c92885"

URI_aarch64_BibTool = "${EPEL_MIRROR}/aarch64/Packages/b/BibTool-2.68-20.el10_0.aarch64.rpm;name=aarch64_BibTool;unpack=0"
SRC_URI:append = " ${URI_aarch64_BibTool}"
SRC_URI[aarch64_BibTool.sha256sum] = "4b1fbe251f27a05bbe77979f51edaa699c9408f06da0b696cab21233e28ce1c4"

RDEPENDS:BibTool = " \
 glibc \
 "
