# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua-mmdb"
PV = "0.2"
PR = "14.el10_1"
PACKAGES = " \
 lua-mmdb \
 lua5.1-mmdb \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lua-mmdb-0.2-14.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f22852d916530e22a66809ea47c44f29d310d5742a35727ff9e1857c75a572d"

URI_x86_64_v2_lua-mmdb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua-mmdb-0.2-14.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lua-mmdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-mmdb}"
SRC_URI[x86_64_v2_lua-mmdb.sha256sum] = "b7011a5acd001e7dbffab421165bad94602b80e8463c60add743885d48415d1c"

URI_x86_64_v2_lua5.1-mmdb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua5.1-mmdb-0.2-14.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lua5.1-mmdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua5.1-mmdb}"
SRC_URI[x86_64_v2_lua5.1-mmdb.sha256sum] = "160680d1e041fef14bad8f779c8a0376cbf178460b99d8a83ed5ea11556c8478"

URI_aarch64_lua-mmdb = "${EPEL_MIRROR}/aarch64/Packages/l/lua-mmdb-0.2-14.el10_1.noarch.rpm;name=aarch64_lua-mmdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-mmdb}"
SRC_URI[aarch64_lua-mmdb.sha256sum] = "7a2bf6a7ce9993e37c9da73d805c5f5bf9b1a6c2f36cf0463119d60e84fafa85"

URI_aarch64_lua5.1-mmdb = "${EPEL_MIRROR}/aarch64/Packages/l/lua5.1-mmdb-0.2-14.el10_1.noarch.rpm;name=aarch64_lua5.1-mmdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua5.1-mmdb}"
SRC_URI[aarch64_lua5.1-mmdb.sha256sum] = "aa2f4cbf96c3da797c3a27ce97cb6bafddcfee05a5ddd826cf1da580add53c1c"

RDEPENDS:lua-mmdb = " \
 "
RDEPENDS:lua5.1-mmdb = " \
 lua5.1-compat53 \
 "
