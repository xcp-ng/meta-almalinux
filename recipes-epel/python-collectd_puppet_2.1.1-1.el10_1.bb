# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-collectd_puppet"
PV = "2.1.1"
PR = "1.el10_1"
PACKAGES = " \
 python3-collectd_puppet \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-collectd_puppet-2.1.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce56ebe5be8263f3bda61488bb487efe9ae32c65cbda8834dde1871baf307648"

URI_x86_64_v2_python3-collectd_puppet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-collectd_puppet-2.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-collectd_puppet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-collectd_puppet}"
SRC_URI[x86_64_v2_python3-collectd_puppet.sha256sum] = "93c820670460c4e77b839c1c99eb19ccac38ea4324ebb003b8b7dba6b6bc842a"

URI_aarch64_python3-collectd_puppet = "${EPEL_MIRROR}/aarch64/Packages/p/python3-collectd_puppet-2.1.1-1.el10_1.noarch.rpm;name=aarch64_python3-collectd_puppet;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-collectd_puppet}"
SRC_URI[aarch64_python3-collectd_puppet.sha256sum] = "3a0e05887ded3e5d3bc7c2ef172bfc4921d92728463869b753a1a93ea71b36dc"

RDEPENDS:python3-collectd_puppet = " \
 python3 \
 python3-pyyaml \
 "
