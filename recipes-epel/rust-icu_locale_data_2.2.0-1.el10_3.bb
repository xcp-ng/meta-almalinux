# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_locale_data"
PV = "2.2.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-icu_locale_data+default-devel \
 rust-icu_locale_data-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_locale_data-2.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c26b5cfb9da2ff46755ab101efff80fe327c50dc821cc78aae02db0b9948e5a1"

URI_x86_64_v2_rust-icu_locale_data+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locale_data+default-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locale_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locale_data+default-devel}"
SRC_URI[x86_64_v2_rust-icu_locale_data+default-devel.sha256sum] = "7be5ea3d52b28e63b7c008493c6f29d9544bb7f4e12ff0d1a43f99ddfaba6c12"

URI_x86_64_v2_rust-icu_locale_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locale_data-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locale_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locale_data-devel}"
SRC_URI[x86_64_v2_rust-icu_locale_data-devel.sha256sum] = "ccbd063ca55bdf6560c2ac5122c47081a39674e075840d148534e3e0191aa0a3"

URI_aarch64_rust-icu_locale_data+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locale_data+default-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_locale_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locale_data+default-devel}"
SRC_URI[aarch64_rust-icu_locale_data+default-devel.sha256sum] = "a68b6b3354d04454f9a3e751581ab672845a42e6e96d1306a38ae99589712c39"

URI_aarch64_rust-icu_locale_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locale_data-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_locale_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locale_data-devel}"
SRC_URI[aarch64_rust-icu_locale_data-devel.sha256sum] = "e2e885d6fe442151cc477a3f31ebc6d7f4461206741726de64b14f02bb58f43b"

RDEPENDS:rust-icu_locale_data+default-devel = " \
 cargo \
 rust-icu_locale_data-devel \
 "
RDEPENDS:rust-icu_locale_data-devel = " \
 cargo \
 rust \
 "
