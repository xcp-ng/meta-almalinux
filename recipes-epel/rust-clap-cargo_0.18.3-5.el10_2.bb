# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap-cargo"
PV = "0.18.3"
PR = "5.el10_2"
PACKAGES = " \
 rust-clap-cargo+cargo_metadata-devel \
 rust-clap-cargo+clap-devel \
 rust-clap-cargo+default-devel \
 rust-clap-cargo+testing_colors-devel \
 rust-clap-cargo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap-cargo-0.18.3-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "692560388cb7ae66fbe5face29701d7fccdbc2a7582a2acd317d2ddeb3d32368"

URI_x86_64_v2_rust-clap-cargo+cargo_metadata-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap-cargo+cargo_metadata-devel-0.18.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap-cargo+cargo_metadata-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap-cargo+cargo_metadata-devel}"
SRC_URI[x86_64_v2_rust-clap-cargo+cargo_metadata-devel.sha256sum] = "1ca26d7a83d57f882ca2eeced64de790f8798963265c8eb01392be5a0e7a339a"

URI_x86_64_v2_rust-clap-cargo+clap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap-cargo+clap-devel-0.18.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap-cargo+clap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap-cargo+clap-devel}"
SRC_URI[x86_64_v2_rust-clap-cargo+clap-devel.sha256sum] = "db049f6bf4f9085bcf177b5f7a045744c56e0eb5133f2e3391564ddd5812eaad"

URI_x86_64_v2_rust-clap-cargo+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap-cargo+default-devel-0.18.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap-cargo+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap-cargo+default-devel}"
SRC_URI[x86_64_v2_rust-clap-cargo+default-devel.sha256sum] = "ca9643ccebfe0d3a55b24bceeb3ea7c38ae57ae6b35f590fdbffd04815efb7a5"

URI_x86_64_v2_rust-clap-cargo+testing_colors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap-cargo+testing_colors-devel-0.18.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap-cargo+testing_colors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap-cargo+testing_colors-devel}"
SRC_URI[x86_64_v2_rust-clap-cargo+testing_colors-devel.sha256sum] = "8de9100e5b357c5e7b71236101dd93f6742ab6c4a287728ddb6d76c0d647f6da"

URI_x86_64_v2_rust-clap-cargo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap-cargo-devel-0.18.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap-cargo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap-cargo-devel}"
SRC_URI[x86_64_v2_rust-clap-cargo-devel.sha256sum] = "440ffe4a7ba02c129eeacd8cba8b62b445cfe31a0e78f3ee75750f25952f06c4"

URI_aarch64_rust-clap-cargo+cargo_metadata-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap-cargo+cargo_metadata-devel-0.18.3-5.el10_2.noarch.rpm;name=aarch64_rust-clap-cargo+cargo_metadata-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap-cargo+cargo_metadata-devel}"
SRC_URI[aarch64_rust-clap-cargo+cargo_metadata-devel.sha256sum] = "2f71c6ccaa3c9f64a0dec80b9d11bad60ad1eac5e7182af78e91cf2e91d256f9"

URI_aarch64_rust-clap-cargo+clap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap-cargo+clap-devel-0.18.3-5.el10_2.noarch.rpm;name=aarch64_rust-clap-cargo+clap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap-cargo+clap-devel}"
SRC_URI[aarch64_rust-clap-cargo+clap-devel.sha256sum] = "79c60d9b960db5cf552d8884d34b9fd20c70ed337b20a99507377a30473eda96"

URI_aarch64_rust-clap-cargo+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap-cargo+default-devel-0.18.3-5.el10_2.noarch.rpm;name=aarch64_rust-clap-cargo+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap-cargo+default-devel}"
SRC_URI[aarch64_rust-clap-cargo+default-devel.sha256sum] = "6dfe5984c2d1551f2615244a0e518c02aab6124022715f380313c9e8a38b8acb"

URI_aarch64_rust-clap-cargo+testing_colors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap-cargo+testing_colors-devel-0.18.3-5.el10_2.noarch.rpm;name=aarch64_rust-clap-cargo+testing_colors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap-cargo+testing_colors-devel}"
SRC_URI[aarch64_rust-clap-cargo+testing_colors-devel.sha256sum] = "64e07125c6664dfb8c7f0c48fa3299e53f7952e90ff4fcfee9f3fc763ef2dbae"

URI_aarch64_rust-clap-cargo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap-cargo-devel-0.18.3-5.el10_2.noarch.rpm;name=aarch64_rust-clap-cargo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap-cargo-devel}"
SRC_URI[aarch64_rust-clap-cargo-devel.sha256sum] = "40c4ad9ccb7df840abf527c20af167168deedac255bbc16f0274969160153d41"

RDEPENDS:rust-clap-cargo+cargo_metadata-devel = " \
 cargo \
 rust-cargo_metadata+default-devel \
 rust-clap-cargo-devel \
 rust-serde+default-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-clap-cargo+clap-devel = " \
 cargo \
 rust-clap+derive-devel \
 rust-clap+std-devel \
 rust-clap-cargo-devel \
 rust-clap-devel \
 "
RDEPENDS:rust-clap-cargo+default-devel = " \
 cargo \
 rust-clap-cargo+clap-devel \
 rust-clap-cargo-devel \
 "
RDEPENDS:rust-clap-cargo+testing_colors-devel = " \
 cargo \
 rust-clap-cargo-devel \
 "
RDEPENDS:rust-clap-cargo-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 "
