# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kplotting"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kplotting \
 kf6-kplotting-devel \
 kf6-kplotting-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kplotting-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7092e2a8ccb99b4350acc590f1b76abe08a1df878d865ae88dc45bce3db922f"

URI_x86_64_v2_kf6-kplotting = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kplotting-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kplotting;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kplotting}"
SRC_URI[x86_64_v2_kf6-kplotting.sha256sum] = "fd1d64fbd6cc54c490820f9a0f92234f4bfa000e94a2b10bcca976c25aeaeca5"

URI_x86_64_v2_kf6-kplotting-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kplotting-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kplotting-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kplotting-devel}"
SRC_URI[x86_64_v2_kf6-kplotting-devel.sha256sum] = "f6dbd9a3f66d4e5fd1e80febe9245b2d320b13e91984c25596ebd3721a13f028"

URI_x86_64_v2_kf6-kplotting-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kplotting-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kplotting-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kplotting-doc}"
SRC_URI[x86_64_v2_kf6-kplotting-doc.sha256sum] = "a0e5a57ff9227943a2cf9cd99902daa447e37f5ccff57d1ab0eb7f15ba291d65"

URI_aarch64_kf6-kplotting = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kplotting-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kplotting;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kplotting}"
SRC_URI[aarch64_kf6-kplotting.sha256sum] = "ecbd7504bdfdaabc8df4c416c2ad74874b0d6b3f1fc717ba6f44ca3673fbb47b"

URI_aarch64_kf6-kplotting-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kplotting-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kplotting-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kplotting-devel}"
SRC_URI[aarch64_kf6-kplotting-devel.sha256sum] = "482411f44e4948a071e60a98474b8872102d38c08e2e07f8adf3fbf7c200812c"

URI_aarch64_kf6-kplotting-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kplotting-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kplotting-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kplotting-doc}"
SRC_URI[aarch64_kf6-kplotting-doc.sha256sum] = "386a618ab9c1b821fce2e59e5dd5ee0eb538d0f5f3ec0745c45cdc7b0fac9c68"

RDEPENDS:kf6-kplotting = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kplotting-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kplotting \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kplotting-doc = " \
 "
