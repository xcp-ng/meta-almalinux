# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Graphics-TIFF"
PV = "21"
PR = "4.el10_0"
PACKAGES = " \
 perl-Graphics-TIFF \
 perl-Graphics-TIFF-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Graphics-TIFF-21-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "407482ec198fb39788ee57b476ca56a299a9a6f31e33b1e5f743b3b1308a90a2"

URI_x86_64_v2_perl-Graphics-TIFF = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Graphics-TIFF-21-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Graphics-TIFF;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Graphics-TIFF}"
SRC_URI[x86_64_v2_perl-Graphics-TIFF.sha256sum] = "b19e38583984adb985b807fef2ea5c547808094ce7aff0da9ed6cf222fa8e146"

URI_x86_64_v2_perl-Graphics-TIFF-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Graphics-TIFF-tests-21-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Graphics-TIFF-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Graphics-TIFF-tests}"
SRC_URI[x86_64_v2_perl-Graphics-TIFF-tests.sha256sum] = "3f130cbf81ac4638952c0b6509902b2c0c64efd2cbabdc8d2d5722affdabaa31"

URI_aarch64_perl-Graphics-TIFF = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Graphics-TIFF-21-4.el10_0.aarch64.rpm;name=aarch64_perl-Graphics-TIFF;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Graphics-TIFF}"
SRC_URI[aarch64_perl-Graphics-TIFF.sha256sum] = "755dce7dd9861937b81699357d97116111f80919893ccb895df04de4d187fe13"

URI_aarch64_perl-Graphics-TIFF-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Graphics-TIFF-tests-21-4.el10_0.noarch.rpm;name=aarch64_perl-Graphics-TIFF-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Graphics-TIFF-tests}"
SRC_URI[aarch64_perl-Graphics-TIFF-tests.sha256sum] = "6f2ffd8c75209de41d91cc535b576f71e945285eaf4f5dee3ff5c11636c2f4cc"

RDEPENDS:perl-Graphics-TIFF = " \
 glibc \
 libtiff \
 perl-Exporter \
 perl-Readonly \
 perl-base \
 perl-libs \
 "
RDEPENDS:perl-Graphics-TIFF-tests = " \
 ImageMagick \
 ImageMagick-perl \
 bash \
 perl-English \
 perl-File-Temp \
 perl-Graphics-TIFF \
 perl-IPC-Cmd \
 perl-PathTools \
 perl-Readonly \
 perl-Test-Deep \
 perl-Test-Harness \
 perl-Test-Requires \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
