# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-macros-backend0.26"
PV = "0.26.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-pyo3-macros-backend0.26+default-devel \
 rust-pyo3-macros-backend0.26+experimental-async-devel \
 rust-pyo3-macros-backend0.26+experimental-inspect-devel \
 rust-pyo3-macros-backend0.26-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-macros-backend0.26-0.26.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "681fdeb2f8da7b3071144670c94e057b90ac2e5d8d35c5c0ad72fb9b3403b0a7"

URI_x86_64_v2_rust-pyo3-macros-backend0.26+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend0.26+default-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend0.26+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend0.26+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend0.26+default-devel.sha256sum] = "4886a5582153d6e461a67666919758b1a745bf0ec7d92085b6b1f554bfaf0c34"

URI_x86_64_v2_rust-pyo3-macros-backend0.26+experimental-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend0.26+experimental-async-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend0.26+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend0.26+experimental-async-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend0.26+experimental-async-devel.sha256sum] = "839c5f7d46d79946920a47f489ecd3d493d2ab7f81945c5c488e8a1a1cf37674"

URI_x86_64_v2_rust-pyo3-macros-backend0.26+experimental-inspect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend0.26+experimental-inspect-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend0.26+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend0.26+experimental-inspect-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend0.26+experimental-inspect-devel.sha256sum] = "e2f858352155f60ff61bfeccb0f2d6390ab88e9286c757589fb26037b616cf3d"

URI_x86_64_v2_rust-pyo3-macros-backend0.26-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend0.26-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend0.26-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend0.26-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend0.26-devel.sha256sum] = "3fd465335a1e50b3a1a5dc9b133913bd2225ea9919e0703487b24cdc314a13b2"

URI_aarch64_rust-pyo3-macros-backend0.26+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend0.26+default-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-macros-backend0.26+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend0.26+default-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend0.26+default-devel.sha256sum] = "c4229f8a98175f94d9bc1c55adebcb88ce7a701d57d524c54615a99bd9940a86"

URI_aarch64_rust-pyo3-macros-backend0.26+experimental-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend0.26+experimental-async-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-macros-backend0.26+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend0.26+experimental-async-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend0.26+experimental-async-devel.sha256sum] = "b05071a764c3609d5bc359038423edc7f5c8c35ab12bcba131dd5c3caae643b8"

URI_aarch64_rust-pyo3-macros-backend0.26+experimental-inspect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend0.26+experimental-inspect-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-macros-backend0.26+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend0.26+experimental-inspect-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend0.26+experimental-inspect-devel.sha256sum] = "4e99feb52c1ee56d6a656aa6b781c793782320812dec75da044c40f64b23191f"

URI_aarch64_rust-pyo3-macros-backend0.26-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend0.26-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-macros-backend0.26-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend0.26-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend0.26-devel.sha256sum] = "4c44bf83ea87fbad1dbed2f87405311322e47661abf84c7fe32f5b836bf3e152"

RDEPENDS:rust-pyo3-macros-backend0.26+default-devel = " \
 cargo \
 rust-pyo3-macros-backend0.26-devel \
 "
RDEPENDS:rust-pyo3-macros-backend0.26+experimental-async-devel = " \
 cargo \
 rust-pyo3-macros-backend0.26-devel \
 "
RDEPENDS:rust-pyo3-macros-backend0.26+experimental-inspect-devel = " \
 cargo \
 rust-pyo3-macros-backend0.26-devel \
 "
RDEPENDS:rust-pyo3-macros-backend0.26-devel = " \
 cargo \
 rust \
 rust-heck+default-devel \
 rust-proc-macro2-devel \
 rust-pyo3-build-config0.26+default-devel \
 rust-pyo3-build-config0.26+resolve-config-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+visit-mut-devel \
 rust-syn-devel \
 "
