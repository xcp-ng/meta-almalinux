# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-flake8"
PV = "6.1.0"
PR = "9.el10_1"
PACKAGES = " \
 python3-flake8 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-flake8-6.1.0-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f0ff6d16c88d3c860cbfc947b83ba6b48150a1605fc0f23bbd64ff8563b76c70"

URI_x86_64_v2_python3-flake8 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-flake8-6.1.0-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-flake8;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-flake8}"
SRC_URI[x86_64_v2_python3-flake8.sha256sum] = "a365a1338f72111b85779c787756a4a4000d6ee449623c716a5d854359f16a20"

URI_aarch64_python3-flake8 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-flake8-6.1.0-9.el10_1.noarch.rpm;name=aarch64_python3-flake8;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-flake8}"
SRC_URI[aarch64_python3-flake8.sha256sum] = "4f9cab46d8889d289fb821f0761bcf29a091f54d9031d0eb45eb32ea529fa000"

RDEPENDS:python3-flake8 = " \
 python3 \
 python3-mccabe \
 python3-pycodestyle \
 python3-pyflakes \
 "
