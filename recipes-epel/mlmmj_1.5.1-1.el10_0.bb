# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mlmmj"
PV = "1.5.1"
PR = "1.el10_0"
PACKAGES = " \
 mlmmj \
 mlmmj-selinux \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mlmmj-1.5.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6d7a65879b7e7e1734065aa6f4f6def34df990bc298bd36f485ace739f22efed"

URI_x86_64_v2_mlmmj = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mlmmj-1.5.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mlmmj;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mlmmj}"
SRC_URI[x86_64_v2_mlmmj.sha256sum] = "f9202457958eb34ef546448cf56a38b3517a9e7883e3a926ff40df2fd6d9e44e"

URI_x86_64_v2_mlmmj-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mlmmj-selinux-1.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mlmmj-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mlmmj-selinux}"
SRC_URI[x86_64_v2_mlmmj-selinux.sha256sum] = "0adbd0aa2e91438a3039b37c535d897dee83f2a6e5a64822f1a648cfdb9121b7"

URI_aarch64_mlmmj = "${EPEL_MIRROR}/aarch64/Packages/m/mlmmj-1.5.1-1.el10_0.aarch64.rpm;name=aarch64_mlmmj;unpack=0"
SRC_URI:append = " ${URI_aarch64_mlmmj}"
SRC_URI[aarch64_mlmmj.sha256sum] = "c8ee21500de7c2609573008aa7cb17aefa34878ec7a4a4c2562889bd58491bf0"

URI_aarch64_mlmmj-selinux = "${EPEL_MIRROR}/aarch64/Packages/m/mlmmj-selinux-1.5.1-1.el10_0.noarch.rpm;name=aarch64_mlmmj-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_mlmmj-selinux}"
SRC_URI[aarch64_mlmmj-selinux.sha256sum] = "56810ada28a2a3c34e0918108e4b3b6df2a74cf0e8e911578e2ed5c3f711f5c2"

RDEPENDS:mlmmj = " \
 bash \
 glibc \
 "
RDEPENDS:mlmmj-selinux = " \
 bash \
 mlmmj \
 selinux-policy-targeted \
 "
