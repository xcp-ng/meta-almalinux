# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-doc-comment"
PV = "0.3.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-doc-comment+default-devel \
 rust-doc-comment+no_core-devel \
 rust-doc-comment+old_macros-devel \
 rust-doc-comment-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-doc-comment-0.3.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "61acb057c092e3fe5ac702c27a3c083635fb50f005aaf222902ce863bc5dae92"

URI_x86_64_v2_rust-doc-comment+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-doc-comment+default-devel-0.3.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-doc-comment+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-doc-comment+default-devel}"
SRC_URI[x86_64_v2_rust-doc-comment+default-devel.sha256sum] = "da54fe55bc9e5ccc3172250034a07191b0405df779f74d10db5c99bb26304e05"

URI_x86_64_v2_rust-doc-comment+no_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-doc-comment+no_core-devel-0.3.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-doc-comment+no_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-doc-comment+no_core-devel}"
SRC_URI[x86_64_v2_rust-doc-comment+no_core-devel.sha256sum] = "f8021918eea5d9dfb4b287eb339c4b24ca992728a5f1be924a6387d440139e62"

URI_x86_64_v2_rust-doc-comment+old_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-doc-comment+old_macros-devel-0.3.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-doc-comment+old_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-doc-comment+old_macros-devel}"
SRC_URI[x86_64_v2_rust-doc-comment+old_macros-devel.sha256sum] = "54e9f240b916900c4987c0e648df625764b2784281194baa6982a688132c7158"

URI_x86_64_v2_rust-doc-comment-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-doc-comment-devel-0.3.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-doc-comment-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-doc-comment-devel}"
SRC_URI[x86_64_v2_rust-doc-comment-devel.sha256sum] = "86e563584294645bdae32bddae861226a1e7bfa8fa8ba28a867606917ea41ed0"

URI_aarch64_rust-doc-comment+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-doc-comment+default-devel-0.3.4-1.el10_2.noarch.rpm;name=aarch64_rust-doc-comment+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-doc-comment+default-devel}"
SRC_URI[aarch64_rust-doc-comment+default-devel.sha256sum] = "207c568a7d720905547b0266016f5736eb2ae273e2a2bfd421fafab2799da9e8"

URI_aarch64_rust-doc-comment+no_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-doc-comment+no_core-devel-0.3.4-1.el10_2.noarch.rpm;name=aarch64_rust-doc-comment+no_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-doc-comment+no_core-devel}"
SRC_URI[aarch64_rust-doc-comment+no_core-devel.sha256sum] = "b85665a0373d159242b5ab9b2aadac691d26b01f9b91f0a6c8ff41a040b5c627"

URI_aarch64_rust-doc-comment+old_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-doc-comment+old_macros-devel-0.3.4-1.el10_2.noarch.rpm;name=aarch64_rust-doc-comment+old_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-doc-comment+old_macros-devel}"
SRC_URI[aarch64_rust-doc-comment+old_macros-devel.sha256sum] = "d01f743a9c25d2cdea26241a27f606c7d096fb7a3016dd167905f91a62595daa"

URI_aarch64_rust-doc-comment-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-doc-comment-devel-0.3.4-1.el10_2.noarch.rpm;name=aarch64_rust-doc-comment-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-doc-comment-devel}"
SRC_URI[aarch64_rust-doc-comment-devel.sha256sum] = "c6e6dc5ea4f9042f154e81e246643c8134c8306d040f7d488290685f9db0b84b"

RDEPENDS:rust-doc-comment+default-devel = " \
 cargo \
 rust-doc-comment-devel \
 "
RDEPENDS:rust-doc-comment+no_core-devel = " \
 cargo \
 rust-doc-comment-devel \
 "
RDEPENDS:rust-doc-comment+old_macros-devel = " \
 cargo \
 rust-doc-comment-devel \
 "
RDEPENDS:rust-doc-comment-devel = " \
 cargo \
 "
