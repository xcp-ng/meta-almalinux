# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fslock"
PV = "0.2.1"
PR = "7.el10_0"
PACKAGES = " \
 rust-fslock+default-devel \
 rust-fslock+std-devel \
 rust-fslock-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fslock-0.2.1-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12512cb9dfd28f93d50351cc0f471a27fa31a2727f5d977457f19c9a85dc7182"

URI_x86_64_v2_rust-fslock+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fslock+default-devel-0.2.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fslock+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fslock+default-devel}"
SRC_URI[x86_64_v2_rust-fslock+default-devel.sha256sum] = "106fa5423f36b2be482b6b59444729acf130e355a18c0be116a22573b948d7a3"

URI_x86_64_v2_rust-fslock+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fslock+std-devel-0.2.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fslock+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fslock+std-devel}"
SRC_URI[x86_64_v2_rust-fslock+std-devel.sha256sum] = "bc16ae3c145a1ebe0df05e45d225709c701306b04339aa2ee48658a7252ddc28"

URI_x86_64_v2_rust-fslock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fslock-devel-0.2.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fslock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fslock-devel}"
SRC_URI[x86_64_v2_rust-fslock-devel.sha256sum] = "94fe9e3ac05a65f8c2aeac78c4a20dc1e9eda267ba328690213bf3eb3bd054f0"

URI_aarch64_rust-fslock+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fslock+default-devel-0.2.1-7.el10_0.noarch.rpm;name=aarch64_rust-fslock+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fslock+default-devel}"
SRC_URI[aarch64_rust-fslock+default-devel.sha256sum] = "e87789f32d10600726d8e982d3768ba7905a88b8fc7faed0f686b3e8f986c158"

URI_aarch64_rust-fslock+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fslock+std-devel-0.2.1-7.el10_0.noarch.rpm;name=aarch64_rust-fslock+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fslock+std-devel}"
SRC_URI[aarch64_rust-fslock+std-devel.sha256sum] = "4d3cae9c6ac8a5c5cd02cf7181fc04d50a47ad7526a8b30a993317935b7375c4"

URI_aarch64_rust-fslock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fslock-devel-0.2.1-7.el10_0.noarch.rpm;name=aarch64_rust-fslock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fslock-devel}"
SRC_URI[aarch64_rust-fslock-devel.sha256sum] = "a416299f4e38329e91530acd5864fc6d32201f69d05ee31a0b8e2879cccf4166"

RDEPENDS:rust-fslock+default-devel = " \
 cargo \
 rust-fslock+std-devel \
 rust-fslock-devel \
 "
RDEPENDS:rust-fslock+std-devel = " \
 cargo \
 rust-fslock-devel \
 "
RDEPENDS:rust-fslock-devel = " \
 cargo \
 rust-libc-devel \
 "
