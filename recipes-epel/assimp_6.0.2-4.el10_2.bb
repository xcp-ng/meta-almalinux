# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "assimp"
PV = "6.0.2"
PR = "4.el10_2"
PACKAGES = " \
 assimp \
 assimp-devel \
 assimp-doc \
 python3-assimp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/assimp-6.0.2-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "58957e377ee467bccf5cd4f5f40c4fb695e37f95d094c80aa7438ce60193dad3"

URI_x86_64_v2_assimp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/assimp-6.0.2-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_assimp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_assimp}"
SRC_URI[x86_64_v2_assimp.sha256sum] = "2f40de4e8229ce98bb0f7d393d131ace5e27e440f7eddf0f7a3efb232e6851d3"

URI_x86_64_v2_assimp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/assimp-devel-6.0.2-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_assimp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_assimp-devel}"
SRC_URI[x86_64_v2_assimp-devel.sha256sum] = "e2c177a6d42a65703f3f553a3401209b93d903dd94496027b2e3d6f33364d1b9"

URI_x86_64_v2_assimp-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/assimp-doc-6.0.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_assimp-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_assimp-doc}"
SRC_URI[x86_64_v2_assimp-doc.sha256sum] = "5fd6bde94a3566987848fa6ec5d0693e4af3e8fdf3c2a36f31a465af2b1f3c22"

URI_x86_64_v2_python3-assimp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-assimp-6.0.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-assimp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-assimp}"
SRC_URI[x86_64_v2_python3-assimp.sha256sum] = "ff0ec81de32b19f787d0e5cac30d85242b908e21676b70c464ce74dc298195b6"

URI_aarch64_assimp = "${EPEL_MIRROR}/aarch64/Packages/a/assimp-6.0.2-4.el10_2.aarch64.rpm;name=aarch64_assimp;unpack=0"
SRC_URI:append = " ${URI_aarch64_assimp}"
SRC_URI[aarch64_assimp.sha256sum] = "20998da72bacf7d721aa73faa4567c13be4d19651a869dca336e49f18c0e936e"

URI_aarch64_assimp-devel = "${EPEL_MIRROR}/aarch64/Packages/a/assimp-devel-6.0.2-4.el10_2.aarch64.rpm;name=aarch64_assimp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_assimp-devel}"
SRC_URI[aarch64_assimp-devel.sha256sum] = "bf2a973b6e3213fade4181f1eb2a2d57796e0a6681876909d70d83ea4752e9a3"

URI_aarch64_assimp-doc = "${EPEL_MIRROR}/aarch64/Packages/a/assimp-doc-6.0.2-4.el10_2.noarch.rpm;name=aarch64_assimp-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_assimp-doc}"
SRC_URI[aarch64_assimp-doc.sha256sum] = "306e3407c79fe7a950673b72bf00f2efd22d37faea8ef77aab46fd68d605c432"

URI_aarch64_python3-assimp = "${EPEL_MIRROR}/aarch64/Packages/p/python3-assimp-6.0.2-4.el10_2.noarch.rpm;name=aarch64_python3-assimp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-assimp}"
SRC_URI[aarch64_python3-assimp.sha256sum] = "f6a0e2ce56cce5b6afc61a75c90ffedfb025128a1d7abf5732d7247e4d44fdba"

RDEPENDS:assimp = " \
 glibc \
 libgcc \
 libstdc++ \
 poly2tri \
 pugixml \
 zlib-ng-compat \
 "
RDEPENDS:assimp-devel = " \
 assimp \
 cmake-filesystem \
 pkgconf-pkg-config \
 poly2tri-devel \
 pugixml-devel \
 "
RDEPENDS:assimp-doc = " \
 "
RDEPENDS:python3-assimp = " \
 assimp \
 python3 \
 "
