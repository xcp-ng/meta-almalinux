# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-oauth"
PV = "2.0.10"
PR = "1.el10_2"
PACKAGES = " \
 php-pecl-oauth \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-oauth-2.0.10-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed5472a0c74a00738340f74006f767f4885b6d3f7ae4bc25b1242f43472c85a5"

URI_x86_64_v2_php-pecl-oauth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-oauth-2.0.10-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-oauth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-oauth}"
SRC_URI[x86_64_v2_php-pecl-oauth.sha256sum] = "c35aa7e281d152181a3524beb6a02ff28177593641ea75845f49777b3d793ff7"

URI_aarch64_php-pecl-oauth = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-oauth-2.0.10-1.el10_2.aarch64.rpm;name=aarch64_php-pecl-oauth;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-oauth}"
SRC_URI[aarch64_php-pecl-oauth.sha256sum] = "e150f60d9e6b310928f0d733e869fdc34396135e5209289d74e076d76d894451"

RDEPENDS:php-pecl-oauth = " \
 glibc \
 php-common \
 virtual/libcurl.so.4___64bit_ \
 "
