# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-html5ever0.29"
PV = "0.29.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-html5ever0.29+default-devel \
 rust-html5ever0.29+trace_tokenizer-devel \
 rust-html5ever0.29-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-html5ever0.29-0.29.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "050de8dfef6321047322c14e02c794e91d79e6a99b9afc7fbbf1a2314745b193"

URI_x86_64_v2_rust-html5ever0.29+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html5ever0.29+default-devel-0.29.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html5ever0.29+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html5ever0.29+default-devel}"
SRC_URI[x86_64_v2_rust-html5ever0.29+default-devel.sha256sum] = "8f20890f08825f9c025d094b4d09ee9e17248f1d41b41f81f543ddac3ef432c0"

URI_x86_64_v2_rust-html5ever0.29+trace_tokenizer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html5ever0.29+trace_tokenizer-devel-0.29.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html5ever0.29+trace_tokenizer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html5ever0.29+trace_tokenizer-devel}"
SRC_URI[x86_64_v2_rust-html5ever0.29+trace_tokenizer-devel.sha256sum] = "91047bbed4eed4e66e60303427ec031f9b566c5fe4b3a8636c82b0ea63479590"

URI_x86_64_v2_rust-html5ever0.29-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html5ever0.29-devel-0.29.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html5ever0.29-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html5ever0.29-devel}"
SRC_URI[x86_64_v2_rust-html5ever0.29-devel.sha256sum] = "6eb4b48575670883ea0000fad70ee9b106b3348cf00164e2f6b263028cfa9149"

URI_aarch64_rust-html5ever0.29+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html5ever0.29+default-devel-0.29.0-1.el10_2.noarch.rpm;name=aarch64_rust-html5ever0.29+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html5ever0.29+default-devel}"
SRC_URI[aarch64_rust-html5ever0.29+default-devel.sha256sum] = "c9a68b9e67448f5a7ad10e6b0586dd45dd608cfd7f86b0a16156365581f572a6"

URI_aarch64_rust-html5ever0.29+trace_tokenizer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html5ever0.29+trace_tokenizer-devel-0.29.0-1.el10_2.noarch.rpm;name=aarch64_rust-html5ever0.29+trace_tokenizer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html5ever0.29+trace_tokenizer-devel}"
SRC_URI[aarch64_rust-html5ever0.29+trace_tokenizer-devel.sha256sum] = "da37ac1dfa28c574da5f646a45d376ced29f39676121c63fe4f2a1e3f229c969"

URI_aarch64_rust-html5ever0.29-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html5ever0.29-devel-0.29.0-1.el10_2.noarch.rpm;name=aarch64_rust-html5ever0.29-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html5ever0.29-devel}"
SRC_URI[aarch64_rust-html5ever0.29-devel.sha256sum] = "a69ec4a56e4d3c6058baac7d0d7aa722fd485ef85370c007773a77e3d47cec7e"

RDEPENDS:rust-html5ever0.29+default-devel = " \
 cargo \
 rust-html5ever0.29-devel \
 "
RDEPENDS:rust-html5ever0.29+trace_tokenizer-devel = " \
 cargo \
 rust-html5ever0.29-devel \
 "
RDEPENDS:rust-html5ever0.29-devel = " \
 cargo \
 rust-log+default-devel \
 rust-mac+default-devel \
 rust-markup5ever0.14+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+fold-devel \
 rust-syn+full-devel \
 "
