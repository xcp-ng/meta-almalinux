# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kdeclarative"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kdeclarative \
 kf6-kdeclarative-devel \
 kf6-kdeclarative-doc \
 kf6-kdeclarative-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kdeclarative-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bce37e834d08f73d97fc7aace05de8e0ba2ea7ecde2cb0992e94590d1e9a78b6"

URI_x86_64_v2_kf6-kdeclarative = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdeclarative-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdeclarative;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdeclarative}"
SRC_URI[x86_64_v2_kf6-kdeclarative.sha256sum] = "32155e7f634b28772c7332c1b1ccae017a6d11f681dffd3494ee172bdc3ef016"

URI_x86_64_v2_kf6-kdeclarative-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdeclarative-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdeclarative-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdeclarative-devel}"
SRC_URI[x86_64_v2_kf6-kdeclarative-devel.sha256sum] = "f57b4ef7d18ecaebc0d26509b4089bb34129d8ce267befcce66c31ce8bf2f22e"

URI_x86_64_v2_kf6-kdeclarative-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdeclarative-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdeclarative-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdeclarative-doc}"
SRC_URI[x86_64_v2_kf6-kdeclarative-doc.sha256sum] = "9dd62de45f065148f039f3b00b5294fa2d7974031d9028bf7abaeb203e6e0e99"

URI_x86_64_v2_kf6-kdeclarative-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdeclarative-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdeclarative-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdeclarative-html}"
SRC_URI[x86_64_v2_kf6-kdeclarative-html.sha256sum] = "788dd2389734d83a80bba88aa2a0c0c2bcf401992ed4886dd3c6ef0127cbad9e"

URI_aarch64_kf6-kdeclarative = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdeclarative-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kdeclarative;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdeclarative}"
SRC_URI[aarch64_kf6-kdeclarative.sha256sum] = "b2f41efd9ffbefc16624d02f2f7dba846b288ec22e9bd7c46d81b8a924bf9847"

URI_aarch64_kf6-kdeclarative-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdeclarative-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kdeclarative-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdeclarative-devel}"
SRC_URI[aarch64_kf6-kdeclarative-devel.sha256sum] = "cf4582c09fad005e96ef7a548a77b535e7057976e90c294273e7780ad6fe6cb9"

URI_aarch64_kf6-kdeclarative-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdeclarative-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kdeclarative-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdeclarative-doc}"
SRC_URI[aarch64_kf6-kdeclarative-doc.sha256sum] = "bf60859da2057bc2a925492c5f54850b1319beea631f09e16fae2f1b8900e7ea"

URI_aarch64_kf6-kdeclarative-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdeclarative-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kdeclarative-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdeclarative-html}"
SRC_URI[aarch64_kf6-kdeclarative-html.sha256sum] = "61fdf7e37f8e7ff46de95750cd807ccc812a6cb93a680a1d803de41a90444956"

RDEPENDS:kf6-kdeclarative = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kdeclarative-devel = " \
 cmake-filesystem \
 kf6-kconfig-devel \
 kf6-kdeclarative \
 kf6-kpackage-devel \
 qt6-qtdeclarative-devel \
 "
RDEPENDS:kf6-kdeclarative-doc = " \
 "
RDEPENDS:kf6-kdeclarative-html = " \
 "
