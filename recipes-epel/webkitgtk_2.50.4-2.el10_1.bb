# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "webkitgtk"
PV = "2.50.4"
PR = "2.el10_1"
PACKAGES = " \
 javascriptcoregtk4.1 \
 javascriptcoregtk4.1-devel \
 javascriptcoregtk6.0 \
 javascriptcoregtk6.0-devel \
 webkit2gtk4.1 \
 webkit2gtk4.1-devel \
 webkit2gtk4.1-doc \
 webkitgtk6.0 \
 webkitgtk6.0-devel \
 webkitgtk6.0-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/webkitgtk-2.50.4-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "228303c72b847ba47d1479b28ea60d3a7f760e9a847c14133f5515a3813c537a"

URI_x86_64_v2_javascriptcoregtk4.1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/javascriptcoregtk4.1-2.50.4-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_javascriptcoregtk4.1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_javascriptcoregtk4.1}"
SRC_URI[x86_64_v2_javascriptcoregtk4.1.sha256sum] = "eff3b547ee8c077d3b42518470f10c399107e5037e734142ebd8868ec8d08a77"

URI_x86_64_v2_javascriptcoregtk4.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/javascriptcoregtk4.1-devel-2.50.4-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_javascriptcoregtk4.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_javascriptcoregtk4.1-devel}"
SRC_URI[x86_64_v2_javascriptcoregtk4.1-devel.sha256sum] = "2ec58c732d35404ff0c2e1c71e7c9855cd0db7f81d74b4fcd2f117204f341f08"

URI_x86_64_v2_javascriptcoregtk6.0 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/javascriptcoregtk6.0-2.50.4-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_javascriptcoregtk6.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_javascriptcoregtk6.0}"
SRC_URI[x86_64_v2_javascriptcoregtk6.0.sha256sum] = "9d6a7ff44474e2e34ba4937141fbffc02134822a2fcf61d7ae4066720f51c79e"

URI_x86_64_v2_javascriptcoregtk6.0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/javascriptcoregtk6.0-devel-2.50.4-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_javascriptcoregtk6.0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_javascriptcoregtk6.0-devel}"
SRC_URI[x86_64_v2_javascriptcoregtk6.0-devel.sha256sum] = "56bf19aed0d2b1e5cf4a3586ffe456685971717707463c3d600dcd6817d15a82"

URI_x86_64_v2_webkit2gtk4.1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/webkit2gtk4.1-2.50.4-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_webkit2gtk4.1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_webkit2gtk4.1}"
SRC_URI[x86_64_v2_webkit2gtk4.1.sha256sum] = "09c70ba9d4d222dd0032fe7cd451c26c374d16ab73b31dd921e9f0e7ae93f372"

URI_x86_64_v2_webkit2gtk4.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/webkit2gtk4.1-devel-2.50.4-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_webkit2gtk4.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_webkit2gtk4.1-devel}"
SRC_URI[x86_64_v2_webkit2gtk4.1-devel.sha256sum] = "0691a7e7ff81ba204f92402ba8e2e7c4b1e1710dd4f60aaf69cfef8d8afe66c8"

URI_x86_64_v2_webkit2gtk4.1-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/webkit2gtk4.1-doc-2.50.4-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_webkit2gtk4.1-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_webkit2gtk4.1-doc}"
SRC_URI[x86_64_v2_webkit2gtk4.1-doc.sha256sum] = "978ad68217c106fadefad94e330af09793efda29d72d69526433d5ca2e019b1c"

URI_x86_64_v2_webkitgtk6.0 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/webkitgtk6.0-2.50.4-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_webkitgtk6.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_webkitgtk6.0}"
SRC_URI[x86_64_v2_webkitgtk6.0.sha256sum] = "0f91e84af436246f404e566858bde576901df3ba64e208409025f2169f9b93d0"

URI_x86_64_v2_webkitgtk6.0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/webkitgtk6.0-devel-2.50.4-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_webkitgtk6.0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_webkitgtk6.0-devel}"
SRC_URI[x86_64_v2_webkitgtk6.0-devel.sha256sum] = "c48a966ce28b78572ea0f99ec55a8a04e8bd3478408eb3a14cba5cc402de5104"

URI_x86_64_v2_webkitgtk6.0-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/webkitgtk6.0-doc-2.50.4-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_webkitgtk6.0-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_webkitgtk6.0-doc}"
SRC_URI[x86_64_v2_webkitgtk6.0-doc.sha256sum] = "7b52f90642ab5f87d8c781a7e12e3e23c6535d17d1b4390545053fb6fde96c00"

URI_aarch64_javascriptcoregtk4.1 = "${EPEL_MIRROR}/aarch64/Packages/j/javascriptcoregtk4.1-2.50.4-2.el10_1.aarch64.rpm;name=aarch64_javascriptcoregtk4.1;unpack=0"
SRC_URI:append = " ${URI_aarch64_javascriptcoregtk4.1}"
SRC_URI[aarch64_javascriptcoregtk4.1.sha256sum] = "df55a29a4ac485186d83f7536497e198f89907a625ee97018884a5ca730f07cd"

URI_aarch64_javascriptcoregtk4.1-devel = "${EPEL_MIRROR}/aarch64/Packages/j/javascriptcoregtk4.1-devel-2.50.4-2.el10_1.aarch64.rpm;name=aarch64_javascriptcoregtk4.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_javascriptcoregtk4.1-devel}"
SRC_URI[aarch64_javascriptcoregtk4.1-devel.sha256sum] = "37ece80a289857af603d7be6660736807e2f896b37e55bf097c3f34f1f3f3f9d"

URI_aarch64_javascriptcoregtk6.0 = "${EPEL_MIRROR}/aarch64/Packages/j/javascriptcoregtk6.0-2.50.4-2.el10_1.aarch64.rpm;name=aarch64_javascriptcoregtk6.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_javascriptcoregtk6.0}"
SRC_URI[aarch64_javascriptcoregtk6.0.sha256sum] = "f979aa6b98efa19cd650b4cd3ee7e211e9638694540478098826c90a7f68a4f3"

URI_aarch64_javascriptcoregtk6.0-devel = "${EPEL_MIRROR}/aarch64/Packages/j/javascriptcoregtk6.0-devel-2.50.4-2.el10_1.aarch64.rpm;name=aarch64_javascriptcoregtk6.0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_javascriptcoregtk6.0-devel}"
SRC_URI[aarch64_javascriptcoregtk6.0-devel.sha256sum] = "bd8ac05aec46d5b347754711c0dbc5166fd242e2a6811d7863ea2c3576a23898"

URI_aarch64_webkit2gtk4.1 = "${EPEL_MIRROR}/aarch64/Packages/w/webkit2gtk4.1-2.50.4-2.el10_1.aarch64.rpm;name=aarch64_webkit2gtk4.1;unpack=0"
SRC_URI:append = " ${URI_aarch64_webkit2gtk4.1}"
SRC_URI[aarch64_webkit2gtk4.1.sha256sum] = "7e285d752675b277e095b6bb59dc238ce4cff85b8346a1d207afd13e4c027529"

URI_aarch64_webkit2gtk4.1-devel = "${EPEL_MIRROR}/aarch64/Packages/w/webkit2gtk4.1-devel-2.50.4-2.el10_1.aarch64.rpm;name=aarch64_webkit2gtk4.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_webkit2gtk4.1-devel}"
SRC_URI[aarch64_webkit2gtk4.1-devel.sha256sum] = "f987fc3aed6b8bc0bcc0a8940b7f625e4bb60381eade0ab3fc8c35258c6771c4"

URI_aarch64_webkit2gtk4.1-doc = "${EPEL_MIRROR}/aarch64/Packages/w/webkit2gtk4.1-doc-2.50.4-2.el10_1.noarch.rpm;name=aarch64_webkit2gtk4.1-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_webkit2gtk4.1-doc}"
SRC_URI[aarch64_webkit2gtk4.1-doc.sha256sum] = "a770795bad4cf84d4a5a714cce96935116183504a5d2fe5fb45d57b45b72a2df"

URI_aarch64_webkitgtk6.0 = "${EPEL_MIRROR}/aarch64/Packages/w/webkitgtk6.0-2.50.4-2.el10_1.aarch64.rpm;name=aarch64_webkitgtk6.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_webkitgtk6.0}"
SRC_URI[aarch64_webkitgtk6.0.sha256sum] = "7c6f5b26fd85ce65e8e3c3b1c7f5acd2d2408b69ed2bc2e14a7cc5ddd6f42812"

URI_aarch64_webkitgtk6.0-devel = "${EPEL_MIRROR}/aarch64/Packages/w/webkitgtk6.0-devel-2.50.4-2.el10_1.aarch64.rpm;name=aarch64_webkitgtk6.0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_webkitgtk6.0-devel}"
SRC_URI[aarch64_webkitgtk6.0-devel.sha256sum] = "5b8cbc411aa46e1df4776c7e2793e04bae132ce4fc388166a5d1785ef573da43"

URI_aarch64_webkitgtk6.0-doc = "${EPEL_MIRROR}/aarch64/Packages/w/webkitgtk6.0-doc-2.50.4-2.el10_1.noarch.rpm;name=aarch64_webkitgtk6.0-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_webkitgtk6.0-doc}"
SRC_URI[aarch64_webkitgtk6.0-doc.sha256sum] = "69cbca1e00fc6d8fa46e92380b2492fbbededfa961938fb71e1c6d145e3a2cda"

RDEPENDS:javascriptcoregtk4.1 = " \
 glib2 \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 systemd-libs \
 "
RDEPENDS:javascriptcoregtk4.1-devel = " \
 glib2-devel \
 glibc \
 javascriptcoregtk4.1 \
 libstdc++ \
 pkgconf-pkg-config \
 "
RDEPENDS:javascriptcoregtk6.0 = " \
 glib2 \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 systemd-libs \
 "
RDEPENDS:javascriptcoregtk6.0-devel = " \
 glib2-devel \
 glibc \
 javascriptcoregtk6.0 \
 libstdc++ \
 pkgconf-pkg-config \
 "
RDEPENDS:webkit2gtk4.1:x86_64_v2 = " \
 atk \
 bubblewrap \
 cairo \
 enchant2 \
 expat \
 flite \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 gtk3 \
 harfbuzz \
 harfbuzz-icu \
 hyphen \
 javascriptcoregtk4.1 \
 lcms2 \
 libX11 \
 libavif \
 libdrm \
 libepoxy \
 libgcrypt \
 libglvnd-gles \
 libicu \
 libjpeg-turbo \
 libjxl \
 libmanette \
 libpng \
 libseccomp \
 libsecret \
 libsoup3 \
 libstdc++ \
 libtasn1 \
 libwayland-client \
 libwayland-server \
 libwebp \
 libxml2 \
 libxslt \
 mesa-libgbm \
 pango \
 sqlite-libs \
 systemd-libs \
 woff2 \
 xdg-dbus-proxy \
 zlib-ng-compat \
"
RDEPENDS:webkit2gtk4.1:aarch64 = " \
 atk \
 bubblewrap \
 cairo \
 enchant2 \
 expat \
 flite \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 gtk3 \
 harfbuzz \
 harfbuzz-icu \
 hyphen \
 javascriptcoregtk4.1 \
 lcms2 \
 libX11 \
 libavif \
 libdrm \
 libepoxy \
 libgcc \
 libgcrypt \
 libglvnd-gles \
 libicu \
 libjpeg-turbo \
 libjxl \
 libmanette \
 libpng \
 libseccomp \
 libsecret \
 libsoup3 \
 libstdc++ \
 libtasn1 \
 libwayland-client \
 libwayland-server \
 libwebp \
 libxml2 \
 libxslt \
 mesa-libgbm \
 pango \
 sqlite-libs \
 systemd-libs \
 woff2 \
 xdg-dbus-proxy \
 zlib-ng-compat \
"
RDEPENDS:webkit2gtk4.1-devel = " \
 cairo \
 glib2 \
 glib2-devel \
 glibc \
 gstreamer1 \
 gtk3 \
 gtk3-devel \
 javascriptcoregtk4.1 \
 javascriptcoregtk4.1-devel \
 libsoup3-devel \
 pkgconf-pkg-config \
 webkit2gtk4.1 \
 "
RDEPENDS:webkit2gtk4.1-doc = " \
 webkit2gtk4.1 \
 "
RDEPENDS:webkitgtk6.0:x86_64_v2 = " \
 bubblewrap \
 cairo \
 enchant2 \
 expat \
 flite \
 fontconfig \
 freetype \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 gtk4 \
 harfbuzz \
 harfbuzz-icu \
 hyphen \
 javascriptcoregtk6.0 \
 lcms2 \
 libX11 \
 libavif \
 libdrm \
 libepoxy \
 libgcrypt \
 libglvnd-gles \
 libicu \
 libjpeg-turbo \
 libjxl \
 libmanette \
 libpng \
 libseccomp \
 libsecret \
 libsoup3 \
 libstdc++ \
 libtasn1 \
 libwayland-client \
 libwayland-server \
 libwebp \
 libxml2 \
 libxslt \
 mesa-libgbm \
 pango \
 sqlite-libs \
 systemd-libs \
 woff2 \
 xdg-dbus-proxy \
 zlib-ng-compat \
"
RDEPENDS:webkitgtk6.0:aarch64 = " \
 bubblewrap \
 cairo \
 enchant2 \
 expat \
 flite \
 fontconfig \
 freetype \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 gtk4 \
 harfbuzz \
 harfbuzz-icu \
 hyphen \
 javascriptcoregtk6.0 \
 lcms2 \
 libX11 \
 libavif \
 libdrm \
 libepoxy \
 libgcc \
 libgcrypt \
 libglvnd-gles \
 libicu \
 libjpeg-turbo \
 libjxl \
 libmanette \
 libpng \
 libseccomp \
 libsecret \
 libsoup3 \
 libstdc++ \
 libtasn1 \
 libwayland-client \
 libwayland-server \
 libwebp \
 libxml2 \
 libxslt \
 mesa-libgbm \
 pango \
 sqlite-libs \
 systemd-libs \
 woff2 \
 xdg-dbus-proxy \
 zlib-ng-compat \
"
RDEPENDS:webkitgtk6.0-devel = " \
 glib2 \
 glib2-devel \
 glibc \
 gstreamer1 \
 gtk4 \
 gtk4-devel \
 javascriptcoregtk6.0 \
 javascriptcoregtk6.0-devel \
 libsoup3-devel \
 pkgconf-pkg-config \
 webkitgtk6.0 \
 "
RDEPENDS:webkitgtk6.0-doc = " \
 webkitgtk6.0 \
 "
