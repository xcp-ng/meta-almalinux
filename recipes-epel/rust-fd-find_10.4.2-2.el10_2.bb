# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fd-find"
PV = "10.4.2"
PR = "2.el10_2"
PACKAGES = " \
 fd-find \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-fd-find-10.4.2-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "26698698b77cd7fea8d17dcf656aaecf77d1eb24f4d76b577c10625c11ad0399"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fd-find-10.4.2-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fd-find;unpack=0"
SRC_URI[x86_64_v2_fd-find.sha256sum] = "89c0aef07ed355bf7f71e35dc625217f21a150b58ebaa8c019640c6510f3e6c7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/fd-find-10.4.2-2.el10_2.aarch64.rpm;name=aarch64_fd-find;unpack=0"
SRC_URI[aarch64_fd-find.sha256sum] = "f3d0366ee2676236af0867a36637f4f49f26c487a2fa7ade261e0636b0b23e0a"

RDEPENDS:fd-find = " \
 glibc \
 jemalloc \
 libgcc \
 "
