# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-cryptohash-sha1"
PV = "0.11.101.0"
PR = "12.el10_0"
PACKAGES = " \
 ghc-cryptohash-sha1 \
 ghc-cryptohash-sha1-devel \
 ghc-cryptohash-sha1-doc \
 ghc-cryptohash-sha1-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-cryptohash-sha1-0.11.101.0-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "753dc91d460d07a64076b05b5c97b916888203de221fd3b5d2d149dc504e912c"

URI_x86_64_v2_ghc-cryptohash-sha1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cryptohash-sha1-0.11.101.0-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cryptohash-sha1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cryptohash-sha1}"
SRC_URI[x86_64_v2_ghc-cryptohash-sha1.sha256sum] = "015c12c8afb480911fe0c692113fc69b7d0de7584499a7a64672fd9eb95c05cc"

URI_x86_64_v2_ghc-cryptohash-sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cryptohash-sha1-devel-0.11.101.0-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cryptohash-sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cryptohash-sha1-devel}"
SRC_URI[x86_64_v2_ghc-cryptohash-sha1-devel.sha256sum] = "94b333215aff5db2dbe3002d2aef407267a381d78621d08e30687b4bd7bd3abb"

URI_x86_64_v2_ghc-cryptohash-sha1-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cryptohash-sha1-doc-0.11.101.0-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-cryptohash-sha1-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cryptohash-sha1-doc}"
SRC_URI[x86_64_v2_ghc-cryptohash-sha1-doc.sha256sum] = "46717be7213d6c55d1d5ba67c31e50d86c88d1c4d1c814e3c95e7a659a0f075d"

URI_x86_64_v2_ghc-cryptohash-sha1-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cryptohash-sha1-prof-0.11.101.0-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cryptohash-sha1-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cryptohash-sha1-prof}"
SRC_URI[x86_64_v2_ghc-cryptohash-sha1-prof.sha256sum] = "3c4382e94af159a218908bb04cf8d6d26d5b6254ab0ba804bc8b6845a8960481"

URI_aarch64_ghc-cryptohash-sha1 = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cryptohash-sha1-0.11.101.0-12.el10_0.aarch64.rpm;name=aarch64_ghc-cryptohash-sha1;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cryptohash-sha1}"
SRC_URI[aarch64_ghc-cryptohash-sha1.sha256sum] = "8cd31cfb8d8c42d0d071582960c2d1ef9e93a95fce07b281fbea653eb1f2d450"

URI_aarch64_ghc-cryptohash-sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cryptohash-sha1-devel-0.11.101.0-12.el10_0.aarch64.rpm;name=aarch64_ghc-cryptohash-sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cryptohash-sha1-devel}"
SRC_URI[aarch64_ghc-cryptohash-sha1-devel.sha256sum] = "164e298a0971d3ca70b5047804a9afe6dca3401417897003d9072a6909559d67"

URI_aarch64_ghc-cryptohash-sha1-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cryptohash-sha1-doc-0.11.101.0-12.el10_0.noarch.rpm;name=aarch64_ghc-cryptohash-sha1-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cryptohash-sha1-doc}"
SRC_URI[aarch64_ghc-cryptohash-sha1-doc.sha256sum] = "8c4464091c719827138e83f1c1f61fd4ba4daab1f99132376d08088c7c1e772c"

URI_aarch64_ghc-cryptohash-sha1-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cryptohash-sha1-prof-0.11.101.0-12.el10_0.aarch64.rpm;name=aarch64_ghc-cryptohash-sha1-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cryptohash-sha1-prof}"
SRC_URI[aarch64_ghc-cryptohash-sha1-prof.sha256sum] = "dc09a7f3c13928e14010f20d9b0bfdc7a3910bfc3a4a6d7bb22539247126ea38"

RDEPENDS:ghc-cryptohash-sha1 = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-cryptohash-sha1-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-cryptohash-sha1 \
 "
RDEPENDS:ghc-cryptohash-sha1-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-cryptohash-sha1-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-cryptohash-sha1-devel \
 "
