# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ff"
PV = "0.13.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-ff+alloc-devel \
 rust-ff+bits-devel \
 rust-ff+bitvec-devel \
 rust-ff+byteorder-devel \
 rust-ff+default-devel \
 rust-ff+std-devel \
 rust-ff-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ff-0.13.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "35c7787b027026a1b114871861f6f18ad0aaf73e9a6e49e79a32dc5664db009f"

URI_x86_64_v2_rust-ff+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ff+alloc-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ff+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ff+alloc-devel}"
SRC_URI[x86_64_v2_rust-ff+alloc-devel.sha256sum] = "04ec0be1373eb4c1d753b5fca10e6b8a875584c398818f1a12b0f985ae292692"

URI_x86_64_v2_rust-ff+bits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ff+bits-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ff+bits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ff+bits-devel}"
SRC_URI[x86_64_v2_rust-ff+bits-devel.sha256sum] = "e37151d40774d49ca3324d2d360f674f6722b40634b6f2d4daab417f182e6291"

URI_x86_64_v2_rust-ff+bitvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ff+bitvec-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ff+bitvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ff+bitvec-devel}"
SRC_URI[x86_64_v2_rust-ff+bitvec-devel.sha256sum] = "d62e98000f04994925ed7e93fd34f3399565cf39e5a68258c57b5bfe624f174d"

URI_x86_64_v2_rust-ff+byteorder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ff+byteorder-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ff+byteorder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ff+byteorder-devel}"
SRC_URI[x86_64_v2_rust-ff+byteorder-devel.sha256sum] = "2e1be49ce91316cf95a85119324bdd6ea14f9380af573749da22ea083b85b247"

URI_x86_64_v2_rust-ff+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ff+default-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ff+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ff+default-devel}"
SRC_URI[x86_64_v2_rust-ff+default-devel.sha256sum] = "1ee1a58dc78574d2251d25291ad44cc938fcbb9bd69038122297f7e403d39d90"

URI_x86_64_v2_rust-ff+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ff+std-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ff+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ff+std-devel}"
SRC_URI[x86_64_v2_rust-ff+std-devel.sha256sum] = "fc8804104033e39719a3218e28fc4689a60031b8b728ce93c07a2a6031e6b449"

URI_x86_64_v2_rust-ff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ff-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ff-devel}"
SRC_URI[x86_64_v2_rust-ff-devel.sha256sum] = "a1782911da21f312632bea59c3c536b2245fd551736dcfcb9e3825111a5da738"

URI_aarch64_rust-ff+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ff+alloc-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-ff+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ff+alloc-devel}"
SRC_URI[aarch64_rust-ff+alloc-devel.sha256sum] = "a9d54986ff0b81a629b46a970fe5305b07fbfa599e74c09faf7ef0c726690518"

URI_aarch64_rust-ff+bits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ff+bits-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-ff+bits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ff+bits-devel}"
SRC_URI[aarch64_rust-ff+bits-devel.sha256sum] = "07a9fa5a064cdb521870538460872eff82c3f0be8830dd2bb692df0a269a8949"

URI_aarch64_rust-ff+bitvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ff+bitvec-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-ff+bitvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ff+bitvec-devel}"
SRC_URI[aarch64_rust-ff+bitvec-devel.sha256sum] = "debf30b0f7f1d45c7839c63b174cf6b34966db4986e002b78d861b7c273a65a3"

URI_aarch64_rust-ff+byteorder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ff+byteorder-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-ff+byteorder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ff+byteorder-devel}"
SRC_URI[aarch64_rust-ff+byteorder-devel.sha256sum] = "ceaaf5312251bc0ce7ef814f0f2e5bc3c8c18950aee162a501d3e6698a7b9025"

URI_aarch64_rust-ff+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ff+default-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-ff+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ff+default-devel}"
SRC_URI[aarch64_rust-ff+default-devel.sha256sum] = "028e8c84bfb226c6b14555392ae5b2094948b336d1cf14dba25ee957cc5ae7fe"

URI_aarch64_rust-ff+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ff+std-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-ff+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ff+std-devel}"
SRC_URI[aarch64_rust-ff+std-devel.sha256sum] = "8e3a29f7176800b26265266d70d99faa9150f2926418d5d83d9d0a3c8031d991"

URI_aarch64_rust-ff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ff-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-ff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ff-devel}"
SRC_URI[aarch64_rust-ff-devel.sha256sum] = "e65086c8a10919f4f6e0ba9ec65ce4e9f1255817fb641cfeededbb82c07a0cdb"

RDEPENDS:rust-ff+alloc-devel = " \
 cargo \
 rust-ff-devel \
 "
RDEPENDS:rust-ff+bits-devel = " \
 cargo \
 rust-ff+bitvec-devel \
 rust-ff-devel \
 "
RDEPENDS:rust-ff+bitvec-devel = " \
 cargo \
 rust-bitvec-devel \
 rust-ff-devel \
 "
RDEPENDS:rust-ff+byteorder-devel = " \
 cargo \
 rust-byteorder-devel \
 rust-ff-devel \
 "
RDEPENDS:rust-ff+default-devel = " \
 cargo \
 rust-ff+bits-devel \
 rust-ff+std-devel \
 rust-ff-devel \
 "
RDEPENDS:rust-ff+std-devel = " \
 cargo \
 rust-ff+alloc-devel \
 rust-ff-devel \
 "
RDEPENDS:rust-ff-devel = " \
 cargo \
 rust \
 rust-rand_core0.6-devel \
 rust-subtle+i128-devel \
 rust-subtle-devel \
 "
