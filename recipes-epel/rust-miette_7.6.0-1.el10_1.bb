# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-miette"
PV = "7.6.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-miette+default-devel \
 rust-miette+derive-devel \
 rust-miette+fancy-base-devel \
 rust-miette+fancy-devel \
 rust-miette+fancy-no-backtrace-devel \
 rust-miette+fancy-no-syscall-devel \
 rust-miette+no-format-args-capture-devel \
 rust-miette+serde-devel \
 rust-miette+syntect-highlighter-devel \
 rust-miette-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-miette-7.6.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "38c369d733781bc388896a223fcb67c310caba4e25e2be7e9c9244942098d13d"

URI_x86_64_v2_rust-miette+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miette+default-devel-7.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miette+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miette+default-devel}"
SRC_URI[x86_64_v2_rust-miette+default-devel.sha256sum] = "747fa92abe52f14fa4d619298b7c3185533dc3aa4281fabf1679b967d8646393"

URI_x86_64_v2_rust-miette+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miette+derive-devel-7.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miette+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miette+derive-devel}"
SRC_URI[x86_64_v2_rust-miette+derive-devel.sha256sum] = "dbcc4efd67345e24ecac8b9501497fee3d8c6b458d104b710940662e44d6f315"

URI_x86_64_v2_rust-miette+fancy-base-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miette+fancy-base-devel-7.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miette+fancy-base-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miette+fancy-base-devel}"
SRC_URI[x86_64_v2_rust-miette+fancy-base-devel.sha256sum] = "002bc260e580f131e0d2ceb75cce995d13ed68075b675b7bcb3f283488e40055"

URI_x86_64_v2_rust-miette+fancy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miette+fancy-devel-7.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miette+fancy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miette+fancy-devel}"
SRC_URI[x86_64_v2_rust-miette+fancy-devel.sha256sum] = "7fba756f86ff7755d8b669aae70e37757b2a1928a015b88158d130a548e5c920"

URI_x86_64_v2_rust-miette+fancy-no-backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miette+fancy-no-backtrace-devel-7.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miette+fancy-no-backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miette+fancy-no-backtrace-devel}"
SRC_URI[x86_64_v2_rust-miette+fancy-no-backtrace-devel.sha256sum] = "bdd58ad8e0290ad2939c493f9a4c55ce50c54d4ae720079fc823e25b6d7b9714"

URI_x86_64_v2_rust-miette+fancy-no-syscall-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miette+fancy-no-syscall-devel-7.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miette+fancy-no-syscall-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miette+fancy-no-syscall-devel}"
SRC_URI[x86_64_v2_rust-miette+fancy-no-syscall-devel.sha256sum] = "204b6e280bc9d6381fcc8b2a17e42e7462adab7d2d495beadbeb895ef9c33c68"

URI_x86_64_v2_rust-miette+no-format-args-capture-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miette+no-format-args-capture-devel-7.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miette+no-format-args-capture-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miette+no-format-args-capture-devel}"
SRC_URI[x86_64_v2_rust-miette+no-format-args-capture-devel.sha256sum] = "f35e00cac9cb3161c7716a23396995a006ed3fb6f39ac6095f08227ea790b558"

URI_x86_64_v2_rust-miette+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miette+serde-devel-7.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miette+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miette+serde-devel}"
SRC_URI[x86_64_v2_rust-miette+serde-devel.sha256sum] = "30d90c3eef3f3d90bbe7d0f56035c90a8e6359bdf48681e93c8349edb7e53052"

URI_x86_64_v2_rust-miette+syntect-highlighter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miette+syntect-highlighter-devel-7.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miette+syntect-highlighter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miette+syntect-highlighter-devel}"
SRC_URI[x86_64_v2_rust-miette+syntect-highlighter-devel.sha256sum] = "8fa7191029fc2e6dd72823530323c60a1ff9284ddde342018c0dce65d49b5949"

URI_x86_64_v2_rust-miette-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miette-devel-7.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miette-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miette-devel}"
SRC_URI[x86_64_v2_rust-miette-devel.sha256sum] = "5f584baab24c2431a7e1e5b2c89ddf93ec012ecf066eea3ef9c1c0c0fbf604f3"

URI_aarch64_rust-miette+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miette+default-devel-7.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-miette+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miette+default-devel}"
SRC_URI[aarch64_rust-miette+default-devel.sha256sum] = "9d4ea8bc101c3eb0eab105bbedd623295575c74265e945ec15a0ef3fcd84308f"

URI_aarch64_rust-miette+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miette+derive-devel-7.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-miette+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miette+derive-devel}"
SRC_URI[aarch64_rust-miette+derive-devel.sha256sum] = "9b76ee23ee76b35dfa0c09b98eb9d53ed36215b2d81b740b81a38c587f2b5e0a"

URI_aarch64_rust-miette+fancy-base-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miette+fancy-base-devel-7.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-miette+fancy-base-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miette+fancy-base-devel}"
SRC_URI[aarch64_rust-miette+fancy-base-devel.sha256sum] = "6c40124d2a94b7342bb132b56e0256163be08451f1ae6ab201e185d5874a4d5e"

URI_aarch64_rust-miette+fancy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miette+fancy-devel-7.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-miette+fancy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miette+fancy-devel}"
SRC_URI[aarch64_rust-miette+fancy-devel.sha256sum] = "bea2c1372985c104eece0acbc846641805ebff4f2702113d40b41a1603e095a9"

URI_aarch64_rust-miette+fancy-no-backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miette+fancy-no-backtrace-devel-7.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-miette+fancy-no-backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miette+fancy-no-backtrace-devel}"
SRC_URI[aarch64_rust-miette+fancy-no-backtrace-devel.sha256sum] = "a64b97db39f4de29df77d4368ffd68baf0d3644e0285c7a66962b977bb210a48"

URI_aarch64_rust-miette+fancy-no-syscall-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miette+fancy-no-syscall-devel-7.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-miette+fancy-no-syscall-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miette+fancy-no-syscall-devel}"
SRC_URI[aarch64_rust-miette+fancy-no-syscall-devel.sha256sum] = "f49b28d00865ca04d36c1bafd660c893e81d7427404bc35f6413e1f862f93ba3"

URI_aarch64_rust-miette+no-format-args-capture-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miette+no-format-args-capture-devel-7.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-miette+no-format-args-capture-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miette+no-format-args-capture-devel}"
SRC_URI[aarch64_rust-miette+no-format-args-capture-devel.sha256sum] = "82d24443dae055810c6e5c7ffbe0b4bae6180214bbbb4d44eca624435bd6b444"

URI_aarch64_rust-miette+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miette+serde-devel-7.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-miette+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miette+serde-devel}"
SRC_URI[aarch64_rust-miette+serde-devel.sha256sum] = "fe77ebc9b46cdbd2b76a31bd5e639cd67ac83c0b5d284dff50f4bde96b3d6350"

URI_aarch64_rust-miette+syntect-highlighter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miette+syntect-highlighter-devel-7.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-miette+syntect-highlighter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miette+syntect-highlighter-devel}"
SRC_URI[aarch64_rust-miette+syntect-highlighter-devel.sha256sum] = "9880028f2201b521f3683b4e8e079729722ec093903f9e1f852010a9065def69"

URI_aarch64_rust-miette-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miette-devel-7.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-miette-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miette-devel}"
SRC_URI[aarch64_rust-miette-devel.sha256sum] = "d8068398d56fb5a2a492a92ff07ee677e25971cafcb9dd429e5481560a478593"

RDEPENDS:rust-miette+default-devel = " \
 cargo \
 rust-miette+derive-devel \
 rust-miette-devel \
 "
RDEPENDS:rust-miette+derive-devel = " \
 cargo \
 rust-miette-derive+default-devel \
 rust-miette-devel \
 "
RDEPENDS:rust-miette+fancy-base-devel = " \
 cargo \
 rust-miette-devel \
 rust-owo-colors+default-devel \
 rust-textwrap+unicode-linebreak-devel \
 rust-textwrap+unicode-width-devel \
 rust-textwrap-devel \
 "
RDEPENDS:rust-miette+fancy-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-backtrace-ext+default-devel \
 rust-miette+fancy-no-backtrace-devel \
 rust-miette-devel \
 "
RDEPENDS:rust-miette+fancy-no-backtrace-devel = " \
 cargo \
 rust-miette+fancy-base-devel \
 rust-miette-devel \
 rust-supports-color+default-devel \
 rust-supports-hyperlinks+default-devel \
 rust-supports-unicode+default-devel \
 rust-terminal_size+default-devel \
 "
RDEPENDS:rust-miette+fancy-no-syscall-devel = " \
 cargo \
 rust-miette+fancy-base-devel \
 rust-miette-devel \
 "
RDEPENDS:rust-miette+no-format-args-capture-devel = " \
 cargo \
 rust-miette-devel \
 "
RDEPENDS:rust-miette+serde-devel = " \
 cargo \
 rust-miette-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-miette+syntect-highlighter-devel = " \
 cargo \
 rust-miette+fancy-no-backtrace-devel \
 rust-miette-devel \
 rust-syntect+default-devel \
 "
RDEPENDS:rust-miette-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-unicode-width0.1+default-devel \
 "
