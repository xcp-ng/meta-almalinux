# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-DBD-MySQL"
PV = "5.007"
PR = "4.el10"
PACKAGES = " \
 perl-DBD-MySQL \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-DBD-MySQL-5.007-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "044be0633d025f4dad85783c7f35671f604b2e1d9307e9840cced1e754714755"

URI_x86_64_v2_perl-DBD-MySQL = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-DBD-MySQL-5.007-4.el10.x86_64_v2.rpm;name=x86_64_v2_perl-DBD-MySQL;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-DBD-MySQL}"
SRC_URI[x86_64_v2_perl-DBD-MySQL.sha256sum] = "54839d473702ff86226699cf1d4487294c2e6334b8ad2f16c0db629fb02db369"

URI_aarch64_perl-DBD-MySQL = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-DBD-MySQL-5.007-4.el10.aarch64.rpm;name=aarch64_perl-DBD-MySQL;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-DBD-MySQL}"
SRC_URI[aarch64_perl-DBD-MySQL.sha256sum] = "13b03a554f52b8c4732b14a6de5e94c0be8411aefbef3893ec0c37feb4a43af0"

RDEPENDS:perl-DBD-MySQL = " \
 glibc \
 mysql8.4-libs \
 perl-Carp \
 perl-DBD-MySQL \
 perl-DBI \
 perl-DynaLoader \
 perl-libs \
 "
