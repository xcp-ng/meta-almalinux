# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-udev"
PV = "0.9.3"
PR = "4.el10_3"
PACKAGES = " \
 rust-udev+default-devel \
 rust-udev+hwdb-devel \
 rust-udev+mio-devel \
 rust-udev+mio10-devel \
 rust-udev+send-devel \
 rust-udev+sync-devel \
 rust-udev-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-udev-0.9.3-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a3bf7ad9064c6a3354112bc6092b2c149c5cd9c6878e44ba5a471b2bb77957ab"

URI_x86_64_v2_rust-udev+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-udev+default-devel-0.9.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-udev+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-udev+default-devel}"
SRC_URI[x86_64_v2_rust-udev+default-devel.sha256sum] = "8bd9bdfef12ea7d3db4de303e0d33fbc0c43f2095a07cf70b8578f295ce10661"

URI_x86_64_v2_rust-udev+hwdb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-udev+hwdb-devel-0.9.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-udev+hwdb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-udev+hwdb-devel}"
SRC_URI[x86_64_v2_rust-udev+hwdb-devel.sha256sum] = "90b1ea67632d4e5ed2bc0dd2094a22675b413a1ddb6c1988e4c8a3980c241e95"

URI_x86_64_v2_rust-udev+mio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-udev+mio-devel-0.9.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-udev+mio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-udev+mio-devel}"
SRC_URI[x86_64_v2_rust-udev+mio-devel.sha256sum] = "f5276901c01205ad03e9eb087248141d3c2a7abe658b37a8e6c60dfedd6b002d"

URI_x86_64_v2_rust-udev+mio10-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-udev+mio10-devel-0.9.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-udev+mio10-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-udev+mio10-devel}"
SRC_URI[x86_64_v2_rust-udev+mio10-devel.sha256sum] = "543ee871f06ec24a2c3da5ed182082efe2b4a6f56b2359b828f8429e7f454bd7"

URI_x86_64_v2_rust-udev+send-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-udev+send-devel-0.9.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-udev+send-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-udev+send-devel}"
SRC_URI[x86_64_v2_rust-udev+send-devel.sha256sum] = "69b5d3d00ba94fe911b5afff10dadfa0e2890953072e8fe9057e6e9bf324227e"

URI_x86_64_v2_rust-udev+sync-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-udev+sync-devel-0.9.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-udev+sync-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-udev+sync-devel}"
SRC_URI[x86_64_v2_rust-udev+sync-devel.sha256sum] = "468654ac2c55908094379f91d5ffc9368c803eb441fc1d662baa666274d1a1ce"

URI_x86_64_v2_rust-udev-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-udev-devel-0.9.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-udev-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-udev-devel}"
SRC_URI[x86_64_v2_rust-udev-devel.sha256sum] = "60ddc8726c3eb67e726a541c204d6290d8f1056bd9c84e79705d77b6284d0c24"

URI_aarch64_rust-udev+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-udev+default-devel-0.9.3-4.el10_3.noarch.rpm;name=aarch64_rust-udev+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-udev+default-devel}"
SRC_URI[aarch64_rust-udev+default-devel.sha256sum] = "f0f9848ad4b1b814f30e05bb45ef99f2f9a5d0177e3478645b8e572c93392551"

URI_aarch64_rust-udev+hwdb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-udev+hwdb-devel-0.9.3-4.el10_3.noarch.rpm;name=aarch64_rust-udev+hwdb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-udev+hwdb-devel}"
SRC_URI[aarch64_rust-udev+hwdb-devel.sha256sum] = "293587da93455d6e232ba893d5737e3a0f1010546d885022579f0cfed88251ca"

URI_aarch64_rust-udev+mio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-udev+mio-devel-0.9.3-4.el10_3.noarch.rpm;name=aarch64_rust-udev+mio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-udev+mio-devel}"
SRC_URI[aarch64_rust-udev+mio-devel.sha256sum] = "ec74063461907d95a9ee989a8bc3e4eef5191f73828fae05001ca26c911c826e"

URI_aarch64_rust-udev+mio10-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-udev+mio10-devel-0.9.3-4.el10_3.noarch.rpm;name=aarch64_rust-udev+mio10-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-udev+mio10-devel}"
SRC_URI[aarch64_rust-udev+mio10-devel.sha256sum] = "e20285760250034c633002f74f5cc93b02a814d4d60941bbef77a1c9fef72b10"

URI_aarch64_rust-udev+send-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-udev+send-devel-0.9.3-4.el10_3.noarch.rpm;name=aarch64_rust-udev+send-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-udev+send-devel}"
SRC_URI[aarch64_rust-udev+send-devel.sha256sum] = "082248f4ac10c3348015e4f9e15acc218fb54b705ab9d5bac80a661552691f77"

URI_aarch64_rust-udev+sync-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-udev+sync-devel-0.9.3-4.el10_3.noarch.rpm;name=aarch64_rust-udev+sync-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-udev+sync-devel}"
SRC_URI[aarch64_rust-udev+sync-devel.sha256sum] = "306e2782ddbe5a1d064e065e678628ffa26aa290f2dd52d6a8eeb03458a133dc"

URI_aarch64_rust-udev-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-udev-devel-0.9.3-4.el10_3.noarch.rpm;name=aarch64_rust-udev-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-udev-devel}"
SRC_URI[aarch64_rust-udev-devel.sha256sum] = "8b1a277d13fc0674e7568623edefefa0dfea0691849011a73cbafa914082b967"

RDEPENDS:rust-udev+default-devel = " \
 cargo \
 rust-udev-devel \
 "
RDEPENDS:rust-udev+hwdb-devel = " \
 cargo \
 rust-udev-devel \
 "
RDEPENDS:rust-udev+mio-devel = " \
 cargo \
 rust-udev+mio10-devel \
 rust-udev-devel \
 "
RDEPENDS:rust-udev+mio10-devel = " \
 cargo \
 rust-mio+default-devel \
 rust-mio+os-ext-devel \
 rust-udev-devel \
 "
RDEPENDS:rust-udev+send-devel = " \
 cargo \
 rust-udev-devel \
 "
RDEPENDS:rust-udev+sync-devel = " \
 cargo \
 rust-udev+send-devel \
 rust-udev-devel \
 "
RDEPENDS:rust-udev-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-libudev-sys+default-devel \
 rust-pkg-config+default-devel \
 "
