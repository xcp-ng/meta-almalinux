# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wordpress"
PV = "6.9.7"
PR = "1.el10_2"
PACKAGES = " \
 wordpress \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/wordpress-6.9.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5bacee287fe6abf859d572dc492cbb86a5ab19db47b12e4b9d49a0ef47aa0f09"

URI_x86_64_v2_wordpress = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wordpress-6.9.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_wordpress;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wordpress}"
SRC_URI[x86_64_v2_wordpress.sha256sum] = "0972b5d4c7b82980d9e78ceeb6bf259f9559aa1925bcc39d70fc2e43d90d92c0"

URI_aarch64_wordpress = "${EPEL_MIRROR}/aarch64/Packages/w/wordpress-6.9.7-1.el10_2.noarch.rpm;name=aarch64_wordpress;unpack=0"
SRC_URI:append = " ${URI_aarch64_wordpress}"
SRC_URI[aarch64_wordpress.sha256sum] = "bbfb04b829056941066d36c11a204e343d82909d3cf07157b9b3c6aab8e90596"

RDEPENDS:wordpress = " \
 ca-certificates \
 httpd \
 httpd-filesystem \
 nginx-filesystem \
 virtual/php-ctype \
 virtual/php-curl \
 virtual/php-dom \
 virtual/php-exif \
 virtual/php-fileinfo \
 virtual/php-filter \
 virtual/php-gd \
 virtual/php-gettext \
 virtual/php-iconv \
 virtual/php-intl \
 virtual/php-json \
 virtual/php-libxml \
 virtual/php-mbstring \
 virtual/php-mysqli \
 virtual/php-openssl \
 virtual/php-simplexml \
 virtual/php-sodium \
 virtual/php-xml \
 virtual/php-xmlreader \
 virtual/php-zip \
 virtual/php-zlib \
 virtual/php_httpd_ \
 virtual/php_language__ge_7.2 \
 virtual/webserver \
 "
