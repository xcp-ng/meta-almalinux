# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tango-icon-theme"
PV = "0.8.90"
PR = "32.el10_2"
PACKAGES = " \
 tango-icon-theme \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tango-icon-theme-0.8.90-32.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3114739289756fc779b3ff8a2a6738acd6b30f5c5cfc919ab2bd581f194b9547"

URI_x86_64_v2_tango-icon-theme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tango-icon-theme-0.8.90-32.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_tango-icon-theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tango-icon-theme}"
SRC_URI[x86_64_v2_tango-icon-theme.sha256sum] = "aac449a0716d4074b2577d3d8c576fed67675072e121daccd1eb803a38d3afbe"

URI_aarch64_tango-icon-theme = "${EPEL_MIRROR}/aarch64/Packages/t/tango-icon-theme-0.8.90-32.el10_2.noarch.rpm;name=aarch64_tango-icon-theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_tango-icon-theme}"
SRC_URI[aarch64_tango-icon-theme.sha256sum] = "a7c6f993b34d124fc43096af605a0796edc177983fda0603b63d209773476f14"

RDEPENDS:tango-icon-theme = " \
 bash \
 "
