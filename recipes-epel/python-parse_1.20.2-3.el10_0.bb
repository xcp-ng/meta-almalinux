# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-parse"
PV = "1.20.2"
PR = "3.el10_0"
PACKAGES = " \
 python3-parse \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-parse-1.20.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0de0f1ef6393ce12b8875a9b439b7b40777ef45be78270c7e0d833184c2cf07b"

URI_x86_64_v2_python3-parse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-parse-1.20.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-parse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-parse}"
SRC_URI[x86_64_v2_python3-parse.sha256sum] = "c832a36f39f281fd85675bacdb6577042024859fe42799e64b210234b03e29a3"

URI_aarch64_python3-parse = "${EPEL_MIRROR}/aarch64/Packages/p/python3-parse-1.20.2-3.el10_0.noarch.rpm;name=aarch64_python3-parse;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-parse}"
SRC_URI[aarch64_python3-parse.sha256sum] = "5c272df660d11908b879a4ab5ee1b81cecba72c0501331aa4d115b222d428976"

RDEPENDS:python3-parse = " \
 python3 \
 "
