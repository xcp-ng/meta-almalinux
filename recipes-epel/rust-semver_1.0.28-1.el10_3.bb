# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-semver"
PV = "1.0.28"
PR = "1.el10_3"
PACKAGES = " \
 rust-semver+default-devel \
 rust-semver+serde-devel \
 rust-semver+std-devel \
 rust-semver-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-semver-1.0.28-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a2855421354764c466af215970d2e604d2425985df3de40f692729bbeeb54e9"

URI_x86_64_v2_rust-semver+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-semver+default-devel-1.0.28-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-semver+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-semver+default-devel}"
SRC_URI[x86_64_v2_rust-semver+default-devel.sha256sum] = "056b5b874c5e319a05e2ff60f86d1ca8826d2361bda8e6efe292a1366ce50903"

URI_x86_64_v2_rust-semver+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-semver+serde-devel-1.0.28-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-semver+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-semver+serde-devel}"
SRC_URI[x86_64_v2_rust-semver+serde-devel.sha256sum] = "90bbdadb6c682ae240c287b9259fb8e79a46500c3c10ef9bde4ca2bdcf256b0c"

URI_x86_64_v2_rust-semver+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-semver+std-devel-1.0.28-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-semver+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-semver+std-devel}"
SRC_URI[x86_64_v2_rust-semver+std-devel.sha256sum] = "2576ae407f0604ef2e53b0c21e62178efb096692f517fb1a19678068ad02b687"

URI_x86_64_v2_rust-semver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-semver-devel-1.0.28-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-semver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-semver-devel}"
SRC_URI[x86_64_v2_rust-semver-devel.sha256sum] = "2a4539728d192f1140884fd0552729cdfdb66092b72889325a4d4417161e7151"

URI_aarch64_rust-semver+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-semver+default-devel-1.0.28-1.el10_3.noarch.rpm;name=aarch64_rust-semver+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-semver+default-devel}"
SRC_URI[aarch64_rust-semver+default-devel.sha256sum] = "11ef7f72f47c7f036824005032969d227507ae1f03398ff9716a0f48a25d8f78"

URI_aarch64_rust-semver+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-semver+serde-devel-1.0.28-1.el10_3.noarch.rpm;name=aarch64_rust-semver+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-semver+serde-devel}"
SRC_URI[aarch64_rust-semver+serde-devel.sha256sum] = "671d56ab9d3229775cba93d0d8bbb6080f68e53310fe4f649a73aa68f84fda2a"

URI_aarch64_rust-semver+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-semver+std-devel-1.0.28-1.el10_3.noarch.rpm;name=aarch64_rust-semver+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-semver+std-devel}"
SRC_URI[aarch64_rust-semver+std-devel.sha256sum] = "e101a97a377025282cce0039cb76162996f48773b81afd8c7a07b2919b47269a"

URI_aarch64_rust-semver-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-semver-devel-1.0.28-1.el10_3.noarch.rpm;name=aarch64_rust-semver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-semver-devel}"
SRC_URI[aarch64_rust-semver-devel.sha256sum] = "fe5205a501e607e828f5f7352684ce9dbc191c2245badefb426607bb0efab91e"

RDEPENDS:rust-semver+default-devel = " \
 cargo \
 rust-semver+std-devel \
 rust-semver-devel \
 "
RDEPENDS:rust-semver+serde-devel = " \
 cargo \
 rust-semver-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-semver+std-devel = " \
 cargo \
 rust-semver-devel \
 "
RDEPENDS:rust-semver-devel = " \
 cargo \
 rust \
 "
