# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "git-tools"
PV = "2022.12"
PR = "1.el10_1"
PACKAGES = " \
 git-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/git-tools-2022.12-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b58a9c50f6c0820b65a0d2289c2b0036ef29b1c7712cdf1a40de1e7a56637ad3"

URI_x86_64_v2_git-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/git-tools-2022.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_git-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-tools}"
SRC_URI[x86_64_v2_git-tools.sha256sum] = "b3921864386e226d577429ad6f5fd64486f3cdb10af74e1db059521aed3fd40b"

URI_aarch64_git-tools = "${EPEL_MIRROR}/aarch64/Packages/g/git-tools-2022.12-1.el10_1.noarch.rpm;name=aarch64_git-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-tools}"
SRC_URI[aarch64_git-tools.sha256sum] = "45b60bff755095741a215e2c2c9229344eb21741c108105559e33913abd0637f"

RDEPENDS:git-tools = " \
 bash \
 git \
 python3 \
 "
