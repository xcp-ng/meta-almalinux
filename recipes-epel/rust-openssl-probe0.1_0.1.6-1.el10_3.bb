# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-openssl-probe0.1"
PV = "0.1.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-openssl-probe0.1+default-devel \
 rust-openssl-probe0.1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-openssl-probe0.1-0.1.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca392e8dc6bc76afce512ca18c672cc7056296aa4702f818fc35df525874a475"

URI_x86_64_v2_rust-openssl-probe0.1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl-probe0.1+default-devel-0.1.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl-probe0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl-probe0.1+default-devel}"
SRC_URI[x86_64_v2_rust-openssl-probe0.1+default-devel.sha256sum] = "850c690c92c31f79d040f6859c17ffa25dd803e8eb31da705d40b5c3f202479b"

URI_x86_64_v2_rust-openssl-probe0.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl-probe0.1-devel-0.1.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl-probe0.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl-probe0.1-devel}"
SRC_URI[x86_64_v2_rust-openssl-probe0.1-devel.sha256sum] = "04614b5a9be3113f5f0a6ab8e82b7a57046b6c8bd9f1a38dd97eb335546f4bf2"

URI_aarch64_rust-openssl-probe0.1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl-probe0.1+default-devel-0.1.6-1.el10_3.noarch.rpm;name=aarch64_rust-openssl-probe0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl-probe0.1+default-devel}"
SRC_URI[aarch64_rust-openssl-probe0.1+default-devel.sha256sum] = "6c6f36f6057781b98744465c90bc8b0739ec216bfd02ae2d03c9f8703f4abc84"

URI_aarch64_rust-openssl-probe0.1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl-probe0.1-devel-0.1.6-1.el10_3.noarch.rpm;name=aarch64_rust-openssl-probe0.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl-probe0.1-devel}"
SRC_URI[aarch64_rust-openssl-probe0.1-devel.sha256sum] = "10234450e639fc7fc96211bddffc2951ccdae5bdd0bd7cec1f99211d98bbb94c"

RDEPENDS:rust-openssl-probe0.1+default-devel = " \
 cargo \
 rust-openssl-probe0.1-devel \
 "
RDEPENDS:rust-openssl-probe0.1-devel = " \
 cargo \
 rust \
 "
