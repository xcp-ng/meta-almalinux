# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bit-vec0.6"
PV = "0.6.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-bit-vec0.6+default-devel \
 rust-bit-vec0.6+serde-devel \
 rust-bit-vec0.6+serde_no_std-devel \
 rust-bit-vec0.6+serde_std-devel \
 rust-bit-vec0.6+std-devel \
 rust-bit-vec0.6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bit-vec0.6-0.6.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d4aa6c66f16298d8b066598e0e1334bf3f4716563a087ee9d13735449fbe9fdd"

URI_x86_64_v2_rust-bit-vec0.6+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bit-vec0.6+default-devel-0.6.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bit-vec0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bit-vec0.6+default-devel}"
SRC_URI[x86_64_v2_rust-bit-vec0.6+default-devel.sha256sum] = "3a5a3c866c828f627fdab14434e70db672cfc4f957c7b4dca726c2389ec663ee"

URI_x86_64_v2_rust-bit-vec0.6+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bit-vec0.6+serde-devel-0.6.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bit-vec0.6+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bit-vec0.6+serde-devel}"
SRC_URI[x86_64_v2_rust-bit-vec0.6+serde-devel.sha256sum] = "0e7c218ed4024f8c5c325db3281ff4701076a2d740671caf40fe7aa28cf29be2"

URI_x86_64_v2_rust-bit-vec0.6+serde_no_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bit-vec0.6+serde_no_std-devel-0.6.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bit-vec0.6+serde_no_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bit-vec0.6+serde_no_std-devel}"
SRC_URI[x86_64_v2_rust-bit-vec0.6+serde_no_std-devel.sha256sum] = "52c21a34f41e6acbe683b5baa72bc53980512537d28b2cd802b40e6565d505cf"

URI_x86_64_v2_rust-bit-vec0.6+serde_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bit-vec0.6+serde_std-devel-0.6.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bit-vec0.6+serde_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bit-vec0.6+serde_std-devel}"
SRC_URI[x86_64_v2_rust-bit-vec0.6+serde_std-devel.sha256sum] = "84e89bb40eaa48c7fab0fdd62bc51f8ddb502a6bca7437b2d326540715bfafed"

URI_x86_64_v2_rust-bit-vec0.6+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bit-vec0.6+std-devel-0.6.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bit-vec0.6+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bit-vec0.6+std-devel}"
SRC_URI[x86_64_v2_rust-bit-vec0.6+std-devel.sha256sum] = "f92962d0c1f5b7d1d70b9a1904a4905bb04bca7d06b64026530b4f03e03b8d1b"

URI_x86_64_v2_rust-bit-vec0.6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bit-vec0.6-devel-0.6.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bit-vec0.6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bit-vec0.6-devel}"
SRC_URI[x86_64_v2_rust-bit-vec0.6-devel.sha256sum] = "a9eab06a2c0892ba04278cd7f4b9980844937d14027aa8d290715a210a5d5771"

URI_aarch64_rust-bit-vec0.6+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bit-vec0.6+default-devel-0.6.3-1.el10_0.noarch.rpm;name=aarch64_rust-bit-vec0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bit-vec0.6+default-devel}"
SRC_URI[aarch64_rust-bit-vec0.6+default-devel.sha256sum] = "49cbf4c7926a297c98dbfc9207ec3b84e2a97fe09491c3ada4189cc7b44d8e8d"

URI_aarch64_rust-bit-vec0.6+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bit-vec0.6+serde-devel-0.6.3-1.el10_0.noarch.rpm;name=aarch64_rust-bit-vec0.6+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bit-vec0.6+serde-devel}"
SRC_URI[aarch64_rust-bit-vec0.6+serde-devel.sha256sum] = "da111ebd5f82514530453ab52ed98c8488ce17372fbc91f5ed25fd519ab1caac"

URI_aarch64_rust-bit-vec0.6+serde_no_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bit-vec0.6+serde_no_std-devel-0.6.3-1.el10_0.noarch.rpm;name=aarch64_rust-bit-vec0.6+serde_no_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bit-vec0.6+serde_no_std-devel}"
SRC_URI[aarch64_rust-bit-vec0.6+serde_no_std-devel.sha256sum] = "0cdeddc42a6195f8f11128da09f55f73d2465d3c28007d77dba96a537f401402"

URI_aarch64_rust-bit-vec0.6+serde_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bit-vec0.6+serde_std-devel-0.6.3-1.el10_0.noarch.rpm;name=aarch64_rust-bit-vec0.6+serde_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bit-vec0.6+serde_std-devel}"
SRC_URI[aarch64_rust-bit-vec0.6+serde_std-devel.sha256sum] = "5f84d3d82d7a04e5dfbc521fef0645027c29893f409a8f2bf8f2fd2e4aa09664"

URI_aarch64_rust-bit-vec0.6+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bit-vec0.6+std-devel-0.6.3-1.el10_0.noarch.rpm;name=aarch64_rust-bit-vec0.6+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bit-vec0.6+std-devel}"
SRC_URI[aarch64_rust-bit-vec0.6+std-devel.sha256sum] = "f63200629708d0528e27657be45a44b391a18dbcb5ad27285f6a4c41ffc0df93"

URI_aarch64_rust-bit-vec0.6-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bit-vec0.6-devel-0.6.3-1.el10_0.noarch.rpm;name=aarch64_rust-bit-vec0.6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bit-vec0.6-devel}"
SRC_URI[aarch64_rust-bit-vec0.6-devel.sha256sum] = "0418f1d3df94bf888193acdcfa894b795284a70c7e201666902ce9df2477062d"

RDEPENDS:rust-bit-vec0.6+default-devel = " \
 cargo \
 rust-bit-vec0.6+std-devel \
 rust-bit-vec0.6-devel \
 "
RDEPENDS:rust-bit-vec0.6+serde-devel = " \
 cargo \
 rust-bit-vec0.6-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-bit-vec0.6+serde_no_std-devel = " \
 cargo \
 rust-bit-vec0.6-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-bit-vec0.6+serde_std-devel = " \
 cargo \
 rust-bit-vec0.6+std-devel \
 rust-bit-vec0.6-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-bit-vec0.6+std-devel = " \
 cargo \
 rust-bit-vec0.6-devel \
 "
RDEPENDS:rust-bit-vec0.6-devel = " \
 cargo \
 "
