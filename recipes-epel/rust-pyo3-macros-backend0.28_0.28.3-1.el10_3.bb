# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-macros-backend0.28"
PV = "0.28.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-pyo3-macros-backend0.28+default-devel \
 rust-pyo3-macros-backend0.28+experimental-async-devel \
 rust-pyo3-macros-backend0.28+experimental-inspect-devel \
 rust-pyo3-macros-backend0.28-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-macros-backend0.28-0.28.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "13f492b3dadfd0c0f225a9792f0086be4bf895c488b6f8a97b250ea1c0442c9f"

URI_x86_64_v2_rust-pyo3-macros-backend0.28+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend0.28+default-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend0.28+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend0.28+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend0.28+default-devel.sha256sum] = "24692b388e7a3106585b2250f6af5ac033824703b6ed892bf28687483daaadf9"

URI_x86_64_v2_rust-pyo3-macros-backend0.28+experimental-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend0.28+experimental-async-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend0.28+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend0.28+experimental-async-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend0.28+experimental-async-devel.sha256sum] = "dbb7e704a05d2e2541049117d76b8a9e3ec2dd59512aa52330059b0fa6544e19"

URI_x86_64_v2_rust-pyo3-macros-backend0.28+experimental-inspect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend0.28+experimental-inspect-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend0.28+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend0.28+experimental-inspect-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend0.28+experimental-inspect-devel.sha256sum] = "fef31bfd4208ff6dd88405edae01294932037d6f8adc4654969acc68691987cf"

URI_x86_64_v2_rust-pyo3-macros-backend0.28-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend0.28-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend0.28-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend0.28-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend0.28-devel.sha256sum] = "efed9197d677fd96d525f0ba9eff671137cf73388468a518bd02ff4211a6dff0"

URI_aarch64_rust-pyo3-macros-backend0.28+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend0.28+default-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-macros-backend0.28+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend0.28+default-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend0.28+default-devel.sha256sum] = "a6e381d1d4b52f779546be423d8f171c02b8e49e8e75e5833360234eeff03822"

URI_aarch64_rust-pyo3-macros-backend0.28+experimental-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend0.28+experimental-async-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-macros-backend0.28+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend0.28+experimental-async-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend0.28+experimental-async-devel.sha256sum] = "c74db95c288d8ac605216439477d699896a77b8e60e18661da8a257be4831214"

URI_aarch64_rust-pyo3-macros-backend0.28+experimental-inspect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend0.28+experimental-inspect-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-macros-backend0.28+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend0.28+experimental-inspect-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend0.28+experimental-inspect-devel.sha256sum] = "e7262b62c6680b1ab923aabc2487b47a9cba9d18010fed2b0a8d2f8bfd473797"

URI_aarch64_rust-pyo3-macros-backend0.28-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend0.28-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-macros-backend0.28-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend0.28-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend0.28-devel.sha256sum] = "873adaf5dabcb0096645f7aebd8eba6bd1b5e07c3f9a8c81fc9bc8d0e1770999"

RDEPENDS:rust-pyo3-macros-backend0.28+default-devel = " \
 cargo \
 rust-pyo3-macros-backend0.28-devel \
 "
RDEPENDS:rust-pyo3-macros-backend0.28+experimental-async-devel = " \
 cargo \
 rust-pyo3-macros-backend0.28-devel \
 "
RDEPENDS:rust-pyo3-macros-backend0.28+experimental-inspect-devel = " \
 cargo \
 rust-pyo3-macros-backend0.28-devel \
 "
RDEPENDS:rust-pyo3-macros-backend0.28-devel = " \
 cargo \
 rust \
 rust-heck+default-devel \
 rust-proc-macro2-devel \
 rust-pyo3-build-config0.28+default-devel \
 rust-pyo3-build-config0.28+resolve-config-devel \
 rust-quote-devel \
 rust-syn2+clone-impls-devel \
 rust-syn2+derive-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+full-devel \
 rust-syn2+parsing-devel \
 rust-syn2+printing-devel \
 rust-syn2+visit-mut-devel \
 rust-syn2-devel \
 "
