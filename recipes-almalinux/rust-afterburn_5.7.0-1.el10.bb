# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-afterburn"
PV = "5.7.0"
PR = "1.el10"
PACKAGES = " \
 afterburn \
 afterburn-dracut \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rust-afterburn-5.7.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "21f674bbbc70c02c5c0ab06feadd00a3948a39d49efa07a7267818c5e3cdf792"

URI_x86_64_v2_afterburn = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/afterburn-5.7.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_afterburn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_afterburn}"
SRC_URI[x86_64_v2_afterburn.sha256sum] = "30fc8c9ffcc851dc1fe6cc325e3857e1cc64ef5956dc05896d2422af731397e5"

URI_x86_64_v2_afterburn-dracut = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/afterburn-dracut-5.7.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_afterburn-dracut;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_afterburn-dracut}"
SRC_URI[x86_64_v2_afterburn-dracut.sha256sum] = "33a50c12c94eb9580a60887d638d88d9ca4cd5ba7e4ff6336d8e86ad917a950e"

URI_aarch64_afterburn = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/afterburn-5.7.0-1.el10.aarch64.rpm;name=aarch64_afterburn;unpack=0"
SRC_URI:append = " ${URI_aarch64_afterburn}"
SRC_URI[aarch64_afterburn.sha256sum] = "21f503db30d173f4e35d7efaf872f47200cb0fc88219379c4a7a5a82526ee172"

URI_aarch64_afterburn-dracut = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/afterburn-dracut-5.7.0-1.el10.aarch64.rpm;name=aarch64_afterburn-dracut;unpack=0"
SRC_URI:append = " ${URI_aarch64_afterburn-dracut}"
SRC_URI[aarch64_afterburn-dracut.sha256sum] = "e37add4a9592e8d9819909c38f372ba6595cfdc0742f79ebf1b09d5f24ce0b43"

RDEPENDS:afterburn = " \
 bash \
 glibc \
 libgcc \
 openssl-libs \
 systemd \
 "
RDEPENDS:afterburn-dracut = " \
 afterburn \
 bash \
 dracut \
 dracut-network \
 "
