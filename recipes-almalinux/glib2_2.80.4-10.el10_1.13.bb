# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glib2"
PV = "2.80.4"
PR = "10.el10_1.13"
PACKAGES = " \
 glib2 \
 glib2-devel \
 glib2-doc \
 glib2-static \
 glib2-tests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/glib2-2.80.4-10.el10_1.13.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ebb21ea8c14c9c8f7624c4f52e0aa8da88ad436508e51e312397fdacadda465a"

URI_x86_64_v2_glib2 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glib2-2.80.4-10.el10_1.13.x86_64_v2.rpm;name=x86_64_v2_glib2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glib2}"
SRC_URI[x86_64_v2_glib2.sha256sum] = "2b5b01db7a09f730a045554c8e4a16b15ac4c0d7469084d7d92f761e456151f0"

URI_x86_64_v2_glib2-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glib2-devel-2.80.4-10.el10_1.13.x86_64_v2.rpm;name=x86_64_v2_glib2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glib2-devel}"
SRC_URI[x86_64_v2_glib2-devel.sha256sum] = "3836da98f9fbe25da09c0110cf4c302f8defe251ecfc825aa57e848c7c007fe9"

URI_x86_64_v2_glib2-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/glib2-doc-2.80.4-10.el10_1.13.x86_64_v2.rpm;name=x86_64_v2_glib2-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glib2-doc}"
SRC_URI[x86_64_v2_glib2-doc.sha256sum] = "ec5441dba992b8b631e03aa76dd672ee65fc0cb9dbb1bc11f00017d6512a7984"

URI_x86_64_v2_glib2-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/glib2-static-2.80.4-10.el10_1.13.x86_64_v2.rpm;name=x86_64_v2_glib2-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glib2-static}"
SRC_URI[x86_64_v2_glib2-static.sha256sum] = "47baada0c78221480d23b79e81ec5278ae6536302e7a593af41b50868b7275a9"

URI_x86_64_v2_glib2-tests = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glib2-tests-2.80.4-10.el10_1.13.x86_64_v2.rpm;name=x86_64_v2_glib2-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glib2-tests}"
SRC_URI[x86_64_v2_glib2-tests.sha256sum] = "864982039469fc713687a4298c5222502870bd1b45d1029fc3e815d36b3940fc"

URI_aarch64_glib2 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glib2-2.80.4-10.el10_1.13.aarch64.rpm;name=aarch64_glib2;unpack=0"
SRC_URI:append = " ${URI_aarch64_glib2}"
SRC_URI[aarch64_glib2.sha256sum] = "cadbe2fb099aec1038bf604383745b2e4aa0ca655c7ae5f26751b09705fb17ac"

URI_aarch64_glib2-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glib2-devel-2.80.4-10.el10_1.13.aarch64.rpm;name=aarch64_glib2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_glib2-devel}"
SRC_URI[aarch64_glib2-devel.sha256sum] = "99b0e20d1b2feecfbb461803ee72b812f8f187acbe2ad15a9bfbd9f3c23a39d1"

URI_aarch64_glib2-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/glib2-doc-2.80.4-10.el10_1.13.aarch64.rpm;name=aarch64_glib2-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glib2-doc}"
SRC_URI[aarch64_glib2-doc.sha256sum] = "f720884267115d1e57a5cccbdf6c965d7f06e4f0aeffb118b092c6562486b298"

URI_aarch64_glib2-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/glib2-static-2.80.4-10.el10_1.13.aarch64.rpm;name=aarch64_glib2-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_glib2-static}"
SRC_URI[aarch64_glib2-static.sha256sum] = "5493c36ca5b5e8b166e0a21a7bd94769166ccf33ef75b2aa441a5bc2fb8b802d"

URI_aarch64_glib2-tests = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glib2-tests-2.80.4-10.el10_1.13.aarch64.rpm;name=aarch64_glib2-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_glib2-tests}"
SRC_URI[aarch64_glib2-tests.sha256sum] = "d980305115e29f93c91c5a46c8fd3c350114b8e8748fb441e09ae82dfd0578da"

RDEPENDS:glib2:x86_64_v2 = " \
 bash \
 glibc \
 gnutls \
 libffi \
 libmount \
 libselinux \
 pcre2 \
 zlib-ng-compat \
"
RDEPENDS:glib2:aarch64 = " \
 bash \
 glibc \
 gnutls \
 libffi \
 libgcc \
 libmount \
 libselinux \
 pcre2 \
 zlib-ng-compat \
"
RDEPENDS:glib2-devel = " \
 bash \
 elfutils-libelf \
 glib2 \
 glib2-devel \
 glibc \
 libffi \
 libffi-devel \
 libmount-devel \
 libselinux-devel \
 pcre2-devel \
 pkgconf-pkg-config \
 python3 \
 python3-packaging \
 sysprof-capture-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:glib2-doc = " \
 glib2 \
 "
RDEPENDS:glib2-static = " \
 glib2-devel \
 pcre2-static \
 sysprof-capture-devel \
 "
RDEPENDS:glib2-tests = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 pcre2 \
 python3 \
 "
