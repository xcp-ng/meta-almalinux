# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-event-listener"
PV = "5.4.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-event-listener+critical-section-devel \
 rust-event-listener+default-devel \
 rust-event-listener+parking-devel \
 rust-event-listener+portable-atomic-devel \
 rust-event-listener+portable-atomic-util-devel \
 rust-event-listener+portable_atomic_crate-devel \
 rust-event-listener+std-devel \
 rust-event-listener-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-event-listener-5.4.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aef2502f2302f10906f1b2601c457e5c5a64d07e28276c55ca0af5153a3b47a5"

URI_x86_64_v2_rust-event-listener+critical-section-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener+critical-section-devel-5.4.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener+critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener+critical-section-devel}"
SRC_URI[x86_64_v2_rust-event-listener+critical-section-devel.sha256sum] = "b02fcc52f6c792e85855079e6aff71aac209f589b822a56b6aa15e8622b5377c"

URI_x86_64_v2_rust-event-listener+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener+default-devel-5.4.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener+default-devel}"
SRC_URI[x86_64_v2_rust-event-listener+default-devel.sha256sum] = "2c78320f5731689673e526421684efbe3c4cbd21ed4aea81ffbdc5ef9fe24541"

URI_x86_64_v2_rust-event-listener+parking-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener+parking-devel-5.4.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener+parking-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener+parking-devel}"
SRC_URI[x86_64_v2_rust-event-listener+parking-devel.sha256sum] = "32489f688adb620b8763cdd2569c9be1456d22b4a4e8b13e968c38a841ffabf5"

URI_x86_64_v2_rust-event-listener+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener+portable-atomic-devel-5.4.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-event-listener+portable-atomic-devel.sha256sum] = "3226f2f2f24677d322277011c8c9b98ce6c4c8a1423acbeace243c87acbbf069"

URI_x86_64_v2_rust-event-listener+portable-atomic-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener+portable-atomic-util-devel-5.4.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener+portable-atomic-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener+portable-atomic-util-devel}"
SRC_URI[x86_64_v2_rust-event-listener+portable-atomic-util-devel.sha256sum] = "f4aca7db599c3c0ae2924b9c4af151eac77b746655d52a8695cc3501dc6f2409"

URI_x86_64_v2_rust-event-listener+portable_atomic_crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener+portable_atomic_crate-devel-5.4.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener+portable_atomic_crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener+portable_atomic_crate-devel}"
SRC_URI[x86_64_v2_rust-event-listener+portable_atomic_crate-devel.sha256sum] = "f7801b0215b296e9d253f4d5ae4792ba215fff64d162c4f03ef0905b5f4d8088"

URI_x86_64_v2_rust-event-listener+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener+std-devel-5.4.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener+std-devel}"
SRC_URI[x86_64_v2_rust-event-listener+std-devel.sha256sum] = "1f57ce783ebc247c68036d2d5607b4064100b4108a3ab03d2ddbcfcf19b905c9"

URI_x86_64_v2_rust-event-listener-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener-devel-5.4.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener-devel}"
SRC_URI[x86_64_v2_rust-event-listener-devel.sha256sum] = "bdf147f8bfcf589fb3f78f4cbf46f25c072628d71159d8c65ee466f93329e05a"

URI_aarch64_rust-event-listener+critical-section-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener+critical-section-devel-5.4.2-1.el10_3.noarch.rpm;name=aarch64_rust-event-listener+critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener+critical-section-devel}"
SRC_URI[aarch64_rust-event-listener+critical-section-devel.sha256sum] = "ecdb88bca7219bb62c565b08e4167590ac14c5b5eeba9331d056fb2317bcb378"

URI_aarch64_rust-event-listener+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener+default-devel-5.4.2-1.el10_3.noarch.rpm;name=aarch64_rust-event-listener+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener+default-devel}"
SRC_URI[aarch64_rust-event-listener+default-devel.sha256sum] = "76e2593217bcffccebc59516b9f9fd15fdf53fcb00139d09b3f5e7867c8d426f"

URI_aarch64_rust-event-listener+parking-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener+parking-devel-5.4.2-1.el10_3.noarch.rpm;name=aarch64_rust-event-listener+parking-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener+parking-devel}"
SRC_URI[aarch64_rust-event-listener+parking-devel.sha256sum] = "cbf273fc497963e85907dd27ff3cd0c860b950da75a001df87669e6ed11cb5b5"

URI_aarch64_rust-event-listener+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener+portable-atomic-devel-5.4.2-1.el10_3.noarch.rpm;name=aarch64_rust-event-listener+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener+portable-atomic-devel}"
SRC_URI[aarch64_rust-event-listener+portable-atomic-devel.sha256sum] = "382e013243aea9dcc1c9e3e19e3dea1a1c6b22d44856b79d3370acb01a6dd944"

URI_aarch64_rust-event-listener+portable-atomic-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener+portable-atomic-util-devel-5.4.2-1.el10_3.noarch.rpm;name=aarch64_rust-event-listener+portable-atomic-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener+portable-atomic-util-devel}"
SRC_URI[aarch64_rust-event-listener+portable-atomic-util-devel.sha256sum] = "c69a8353da1bd45923dcf64d6e14e0aa9c4a2ce6845e9d580a961753d4dbfb5f"

URI_aarch64_rust-event-listener+portable_atomic_crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener+portable_atomic_crate-devel-5.4.2-1.el10_3.noarch.rpm;name=aarch64_rust-event-listener+portable_atomic_crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener+portable_atomic_crate-devel}"
SRC_URI[aarch64_rust-event-listener+portable_atomic_crate-devel.sha256sum] = "2c4819ed706b55b20ebc5942696807f9acbe7004fd17cbe1036cda164fbce735"

URI_aarch64_rust-event-listener+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener+std-devel-5.4.2-1.el10_3.noarch.rpm;name=aarch64_rust-event-listener+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener+std-devel}"
SRC_URI[aarch64_rust-event-listener+std-devel.sha256sum] = "78fa6921837b1d7a59c4e21f58fff92cd2f6ee43b20b03097d72a1f9b89fab5f"

URI_aarch64_rust-event-listener-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener-devel-5.4.2-1.el10_3.noarch.rpm;name=aarch64_rust-event-listener-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener-devel}"
SRC_URI[aarch64_rust-event-listener-devel.sha256sum] = "6479767e00dfdef10aaad512d0ebeb1c0da6719cc5cb02fa30dd4608cf3c87ab"

RDEPENDS:rust-event-listener+critical-section-devel = " \
 cargo \
 rust-critical-section-devel \
 rust-event-listener-devel \
 "
RDEPENDS:rust-event-listener+default-devel = " \
 cargo \
 rust-event-listener+std-devel \
 rust-event-listener-devel \
 "
RDEPENDS:rust-event-listener+parking-devel = " \
 cargo \
 rust-event-listener-devel \
 rust-parking+default-devel \
 "
RDEPENDS:rust-event-listener+portable-atomic-devel = " \
 cargo \
 rust-event-listener+portable-atomic-util-devel \
 rust-event-listener+portable_atomic_crate-devel \
 rust-event-listener-devel \
 "
RDEPENDS:rust-event-listener+portable-atomic-util-devel = " \
 cargo \
 rust-event-listener-devel \
 rust-portable-atomic-util+alloc-devel \
 rust-portable-atomic-util-devel \
 "
RDEPENDS:rust-event-listener+portable_atomic_crate-devel = " \
 cargo \
 rust-event-listener-devel \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-event-listener+std-devel = " \
 cargo \
 rust-event-listener+parking-devel \
 rust-event-listener-devel \
 "
RDEPENDS:rust-event-listener-devel = " \
 cargo \
 rust \
 rust-pin-project-lite+default-devel \
 "
