# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-IO-Pipely"
PV = "0.006"
PR = "8.el10_0"
PACKAGES = " \
 perl-IO-Pipely \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-IO-Pipely-0.006-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "603949d3ebfcd30d7daa9a689bee2e35964dc1ddef851ecfb352de067c8c96c2"

URI_x86_64_v2_perl-IO-Pipely = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-IO-Pipely-0.006-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-IO-Pipely;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-IO-Pipely}"
SRC_URI[x86_64_v2_perl-IO-Pipely.sha256sum] = "c738f3f6a78bbdae098dda53b2d2091df42e038e3cfc9ec3e91821815578fc28"

URI_aarch64_perl-IO-Pipely = "${EPEL_MIRROR}/aarch64/Packages/p/perl-IO-Pipely-0.006-8.el10_0.noarch.rpm;name=aarch64_perl-IO-Pipely;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-IO-Pipely}"
SRC_URI[aarch64_perl-IO-Pipely.sha256sum] = "21e041695262ed21a811310cee06100541cc81f2af3a8eae26ee42618add22fa"

RDEPENDS:perl-IO-Pipely = " \
 perl-Errno \
 perl-Exporter \
 perl-Fcntl \
 perl-IO \
 perl-Symbol \
 perl-base \
 perl-libs \
 "
