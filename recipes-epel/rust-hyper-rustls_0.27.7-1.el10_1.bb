# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hyper-rustls"
PV = "0.27.7"
PR = "1.el10_1"
PACKAGES = " \
 rust-hyper-rustls+default-devel \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+http2-devel \
 rust-hyper-rustls+log-devel \
 rust-hyper-rustls+logging-devel \
 rust-hyper-rustls+native-tokio-devel \
 rust-hyper-rustls+ring-devel \
 rust-hyper-rustls+rustls-native-certs-devel \
 rust-hyper-rustls+tls12-devel \
 rust-hyper-rustls+webpki-roots-devel \
 rust-hyper-rustls+webpki-tokio-devel \
 rust-hyper-rustls-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hyper-rustls-0.27.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b359d9dc6c61e068f621938008d16ea0fd19ba9550f56c9c1eb1f190682e2469"

URI_x86_64_v2_rust-hyper-rustls+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+default-devel-0.27.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-rustls+default-devel}"
SRC_URI[x86_64_v2_rust-hyper-rustls+default-devel.sha256sum] = "4d65c77a3cf168f35ed1af7398e8c6e4e5c44028154ee21f059a20454b793e29"

URI_x86_64_v2_rust-hyper-rustls+http1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+http1-devel-0.27.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+http1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-rustls+http1-devel}"
SRC_URI[x86_64_v2_rust-hyper-rustls+http1-devel.sha256sum] = "d9b7b6153880bd6928d6fe4b955a87f2846b9f25c10e3c5f5d2414343572e119"

URI_x86_64_v2_rust-hyper-rustls+http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+http2-devel-0.27.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-rustls+http2-devel}"
SRC_URI[x86_64_v2_rust-hyper-rustls+http2-devel.sha256sum] = "085cf7006f866249ce9700da2d904f1e75a89d896c0adc59ec2553f99fe4d8cb"

URI_x86_64_v2_rust-hyper-rustls+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+log-devel-0.27.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-rustls+log-devel}"
SRC_URI[x86_64_v2_rust-hyper-rustls+log-devel.sha256sum] = "a41a965860e2101e60ae2f95a82b349d5f29398f5649258b8c2319658920fa19"

URI_x86_64_v2_rust-hyper-rustls+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+logging-devel-0.27.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-rustls+logging-devel}"
SRC_URI[x86_64_v2_rust-hyper-rustls+logging-devel.sha256sum] = "e0e00f22cefb20ba923612c01948871d3ac0efc26cc85d3610f8ee4208b5baaf"

URI_x86_64_v2_rust-hyper-rustls+native-tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+native-tokio-devel-0.27.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+native-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-rustls+native-tokio-devel}"
SRC_URI[x86_64_v2_rust-hyper-rustls+native-tokio-devel.sha256sum] = "7c96ed171b3561803c1a4137d9d63a6c38579a46ebf0a6627759f2c3261df902"

URI_x86_64_v2_rust-hyper-rustls+ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+ring-devel-0.27.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-rustls+ring-devel}"
SRC_URI[x86_64_v2_rust-hyper-rustls+ring-devel.sha256sum] = "87f65cead3e96c17cd66933faa545b7f687f1c706c65b84adcb497d0ad14ab05"

URI_x86_64_v2_rust-hyper-rustls+rustls-native-certs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+rustls-native-certs-devel-0.27.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-rustls+rustls-native-certs-devel}"
SRC_URI[x86_64_v2_rust-hyper-rustls+rustls-native-certs-devel.sha256sum] = "8b6b10233fb4cd538a1ea315d344e881330a2d466348053f19c4e65cccc378ad"

URI_x86_64_v2_rust-hyper-rustls+tls12-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+tls12-devel-0.27.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+tls12-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-rustls+tls12-devel}"
SRC_URI[x86_64_v2_rust-hyper-rustls+tls12-devel.sha256sum] = "3323a615e01aea416baaf5c250c448f5716827080006288da28a5fe947734b7c"

URI_x86_64_v2_rust-hyper-rustls+webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+webpki-roots-devel-0.27.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-rustls+webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-hyper-rustls+webpki-roots-devel.sha256sum] = "a719baa713893c9c15bc20ace3739e03858c1a60668a79fde891b49b8fabdaeb"

URI_x86_64_v2_rust-hyper-rustls+webpki-tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+webpki-tokio-devel-0.27.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+webpki-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-rustls+webpki-tokio-devel}"
SRC_URI[x86_64_v2_rust-hyper-rustls+webpki-tokio-devel.sha256sum] = "bb571256bae9776a53487db8eff94eb40253aa08846709f525708d4f32a79bb2"

URI_x86_64_v2_rust-hyper-rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls-devel-0.27.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-rustls-devel}"
SRC_URI[x86_64_v2_rust-hyper-rustls-devel.sha256sum] = "f3f48415aa6423a23d31bc07e2ebac9da6be6df2c729eeaedacf713fe0f3d3d8"

URI_aarch64_rust-hyper-rustls+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+default-devel-0.27.7-1.el10_1.noarch.rpm;name=aarch64_rust-hyper-rustls+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-rustls+default-devel}"
SRC_URI[aarch64_rust-hyper-rustls+default-devel.sha256sum] = "0a86ef0721db76139eaa7ffeba0e1bb88ffb44949e1ae434478745a5b89960f3"

URI_aarch64_rust-hyper-rustls+http1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+http1-devel-0.27.7-1.el10_1.noarch.rpm;name=aarch64_rust-hyper-rustls+http1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-rustls+http1-devel}"
SRC_URI[aarch64_rust-hyper-rustls+http1-devel.sha256sum] = "a09d0bfbc970589448c48aecf1d6b51de374d36ad5d01058d3aadb64535e5460"

URI_aarch64_rust-hyper-rustls+http2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+http2-devel-0.27.7-1.el10_1.noarch.rpm;name=aarch64_rust-hyper-rustls+http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-rustls+http2-devel}"
SRC_URI[aarch64_rust-hyper-rustls+http2-devel.sha256sum] = "8283d1220d78abb5c50d06b186a12db684a1c8347251bbd07627832c7e01a525"

URI_aarch64_rust-hyper-rustls+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+log-devel-0.27.7-1.el10_1.noarch.rpm;name=aarch64_rust-hyper-rustls+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-rustls+log-devel}"
SRC_URI[aarch64_rust-hyper-rustls+log-devel.sha256sum] = "2194d1dbce1e5b102f3abc075c48b8114444c7a38a7e47b0c3db7901e2beaf88"

URI_aarch64_rust-hyper-rustls+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+logging-devel-0.27.7-1.el10_1.noarch.rpm;name=aarch64_rust-hyper-rustls+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-rustls+logging-devel}"
SRC_URI[aarch64_rust-hyper-rustls+logging-devel.sha256sum] = "ab06f445699ade94ee4a723e601025a526e6f50aa6e7dabff0d5c74be7447465"

URI_aarch64_rust-hyper-rustls+native-tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+native-tokio-devel-0.27.7-1.el10_1.noarch.rpm;name=aarch64_rust-hyper-rustls+native-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-rustls+native-tokio-devel}"
SRC_URI[aarch64_rust-hyper-rustls+native-tokio-devel.sha256sum] = "6e8ec54fb5473e57b4b0cc1d1af43274958a550fc1c87ac7eb9cbceead0d07e8"

URI_aarch64_rust-hyper-rustls+ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+ring-devel-0.27.7-1.el10_1.noarch.rpm;name=aarch64_rust-hyper-rustls+ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-rustls+ring-devel}"
SRC_URI[aarch64_rust-hyper-rustls+ring-devel.sha256sum] = "8d1fa430d462dddc98c52ff7c2ec3d0ef35a88b591772cfd0a73afeb28bc54ce"

URI_aarch64_rust-hyper-rustls+rustls-native-certs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+rustls-native-certs-devel-0.27.7-1.el10_1.noarch.rpm;name=aarch64_rust-hyper-rustls+rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-rustls+rustls-native-certs-devel}"
SRC_URI[aarch64_rust-hyper-rustls+rustls-native-certs-devel.sha256sum] = "2df0a1e4dc1322e8a6a04f22514346952218be86081cdaa78343174d4e8c1875"

URI_aarch64_rust-hyper-rustls+tls12-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+tls12-devel-0.27.7-1.el10_1.noarch.rpm;name=aarch64_rust-hyper-rustls+tls12-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-rustls+tls12-devel}"
SRC_URI[aarch64_rust-hyper-rustls+tls12-devel.sha256sum] = "e01d0d2518d948dfcc878a6367dab958cb3ec3d204f8efaa4d866473b0edb158"

URI_aarch64_rust-hyper-rustls+webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+webpki-roots-devel-0.27.7-1.el10_1.noarch.rpm;name=aarch64_rust-hyper-rustls+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-rustls+webpki-roots-devel}"
SRC_URI[aarch64_rust-hyper-rustls+webpki-roots-devel.sha256sum] = "673e7cb84f5c0be3a03c1fef94393e2fc74ab5f0eff1590e7e79d789423b12a8"

URI_aarch64_rust-hyper-rustls+webpki-tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+webpki-tokio-devel-0.27.7-1.el10_1.noarch.rpm;name=aarch64_rust-hyper-rustls+webpki-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-rustls+webpki-tokio-devel}"
SRC_URI[aarch64_rust-hyper-rustls+webpki-tokio-devel.sha256sum] = "019a6a093cb6e56509ff39456fa75af3d1c150d633dcae11f3adfe730c5769bc"

URI_aarch64_rust-hyper-rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls-devel-0.27.7-1.el10_1.noarch.rpm;name=aarch64_rust-hyper-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-rustls-devel}"
SRC_URI[aarch64_rust-hyper-rustls-devel.sha256sum] = "f38aa6bd9a9d4b05e748be6938365c27cd2faa5a2f508cdcaed5ee8ac0e4955e"

RDEPENDS:rust-hyper-rustls+default-devel = " \
 cargo \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+logging-devel \
 rust-hyper-rustls+native-tokio-devel \
 rust-hyper-rustls+ring-devel \
 rust-hyper-rustls+tls12-devel \
 rust-hyper-rustls-devel \
 "
RDEPENDS:rust-hyper-rustls+http1-devel = " \
 cargo \
 rust-hyper-rustls-devel \
 rust-hyper-util+http1-devel \
 "
RDEPENDS:rust-hyper-rustls+http2-devel = " \
 cargo \
 rust-hyper-rustls-devel \
 rust-hyper-util+http2-devel \
 "
RDEPENDS:rust-hyper-rustls+log-devel = " \
 cargo \
 rust-hyper-rustls-devel \
 rust-log+default-devel \
 "
RDEPENDS:rust-hyper-rustls+logging-devel = " \
 cargo \
 rust-hyper-rustls+log-devel \
 rust-hyper-rustls-devel \
 rust-rustls+logging-devel \
 rust-tokio-rustls+logging-devel \
 "
RDEPENDS:rust-hyper-rustls+native-tokio-devel = " \
 cargo \
 rust-hyper-rustls+rustls-native-certs-devel \
 rust-hyper-rustls-devel \
 "
RDEPENDS:rust-hyper-rustls+ring-devel = " \
 cargo \
 rust-hyper-rustls-devel \
 rust-rustls+ring-devel \
 "
RDEPENDS:rust-hyper-rustls+rustls-native-certs-devel = " \
 cargo \
 rust-hyper-rustls-devel \
 rust-rustls-native-certs+default-devel \
 "
RDEPENDS:rust-hyper-rustls+tls12-devel = " \
 cargo \
 rust-hyper-rustls-devel \
 rust-rustls+tls12-devel \
 rust-tokio-rustls+tls12-devel \
 "
RDEPENDS:rust-hyper-rustls+webpki-roots-devel = " \
 cargo \
 rust-hyper-rustls-devel \
 rust-webpki-roots+default-devel \
 "
RDEPENDS:rust-hyper-rustls+webpki-tokio-devel = " \
 cargo \
 rust-hyper-rustls+webpki-roots-devel \
 rust-hyper-rustls-devel \
 "
RDEPENDS:rust-hyper-rustls-devel = " \
 bash \
 cargo \
 rust \
 rust-http+default-devel \
 rust-hyper-devel \
 rust-hyper-util+client-legacy-devel \
 rust-hyper-util+tokio-devel \
 rust-hyper-util-devel \
 rust-rustls-devel \
 rust-rustls-pki-types+default-devel \
 rust-tokio+default-devel \
 rust-tokio-rustls-devel \
 rust-tower-service+default-devel \
 "
