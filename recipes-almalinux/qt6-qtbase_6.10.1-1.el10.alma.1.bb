# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtbase"
PV = "6.10.1"
PR = "1.el10.alma.1"
PACKAGES = " \
 qt6-qtbase \
 qt6-qtbase-common \
 qt6-qtbase-devel \
 qt6-qtbase-examples \
 qt6-qtbase-gui \
 qt6-qtbase-mysql \
 qt6-qtbase-odbc \
 qt6-qtbase-postgresql \
 qt6-qtbase-private-devel \
 qt6-qtbase-static \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtbase-6.10.1-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0f3a2233860b27af8865b2cdd6b5eefb9e06568fbc2f15c4a440727ef8f96d1d"

URI_x86_64_v2_qt6-qtbase = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtbase-6.10.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qt6-qtbase;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtbase}"
SRC_URI[x86_64_v2_qt6-qtbase.sha256sum] = "19394fd3a175fc8bc3945f340bb9a83ac87bb5637a765b6792403cb65a9fc3a4"

URI_x86_64_v2_qt6-qtbase-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtbase-common-6.10.1-1.el10.alma.1.noarch.rpm;name=x86_64_v2_qt6-qtbase-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtbase-common}"
SRC_URI[x86_64_v2_qt6-qtbase-common.sha256sum] = "7ed36c5a2ae24d194ae1ee7147a7f545ebd9c0cd8c9c99872cd54882a62db123"

URI_x86_64_v2_qt6-qtbase-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtbase-devel-6.10.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qt6-qtbase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtbase-devel}"
SRC_URI[x86_64_v2_qt6-qtbase-devel.sha256sum] = "6dd98b53d5f6b0480cdf9a019b213364959e8b4852f937b7f8e78f7178554a3a"

URI_x86_64_v2_qt6-qtbase-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtbase-examples-6.10.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qt6-qtbase-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtbase-examples}"
SRC_URI[x86_64_v2_qt6-qtbase-examples.sha256sum] = "193b3d0b712e750250f9d14c57ad9624b7ca3c735cb9b0c333bc89072b791581"

URI_x86_64_v2_qt6-qtbase-gui = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtbase-gui-6.10.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qt6-qtbase-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtbase-gui}"
SRC_URI[x86_64_v2_qt6-qtbase-gui.sha256sum] = "1ec859bc934a703fcf3c3cedeb23032c263e426ee1570a49e3ef7790e3554cf3"

URI_x86_64_v2_qt6-qtbase-mysql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtbase-mysql-6.10.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qt6-qtbase-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtbase-mysql}"
SRC_URI[x86_64_v2_qt6-qtbase-mysql.sha256sum] = "e9b08e5cc6da6cb75f54e932e090607988869d1596194736e03b3f2dcde6a679"

URI_x86_64_v2_qt6-qtbase-odbc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtbase-odbc-6.10.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qt6-qtbase-odbc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtbase-odbc}"
SRC_URI[x86_64_v2_qt6-qtbase-odbc.sha256sum] = "96259067f9cb0670b7e8d86cccad4655431e4f064dc640b18dfce13c10b61065"

URI_x86_64_v2_qt6-qtbase-postgresql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtbase-postgresql-6.10.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qt6-qtbase-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtbase-postgresql}"
SRC_URI[x86_64_v2_qt6-qtbase-postgresql.sha256sum] = "1b0373291ef8974b6de8de362fabc161e4ff4db5690bec95777942c6c345b384"

URI_x86_64_v2_qt6-qtbase-private-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtbase-private-devel-6.10.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qt6-qtbase-private-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtbase-private-devel}"
SRC_URI[x86_64_v2_qt6-qtbase-private-devel.sha256sum] = "6b635f9f6e6eb16c76f39378f31d16877f7f6a78683b72d31c523bcf86d2d30b"

URI_x86_64_v2_qt6-qtbase-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtbase-static-6.10.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qt6-qtbase-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtbase-static}"
SRC_URI[x86_64_v2_qt6-qtbase-static.sha256sum] = "603739e037b0dfdedf4dfbffbe653d3cf2c31a2c3689eb7eb22512012380be05"

URI_aarch64_qt6-qtbase = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtbase-6.10.1-1.el10.alma.1.aarch64.rpm;name=aarch64_qt6-qtbase;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtbase}"
SRC_URI[aarch64_qt6-qtbase.sha256sum] = "640e202c3174e585ca5f58e8b7b784f2cdc608cb7401273c4c279d266c5dbcb2"

URI_aarch64_qt6-qtbase-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtbase-common-6.10.1-1.el10.alma.1.noarch.rpm;name=aarch64_qt6-qtbase-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtbase-common}"
SRC_URI[aarch64_qt6-qtbase-common.sha256sum] = "7ed36c5a2ae24d194ae1ee7147a7f545ebd9c0cd8c9c99872cd54882a62db123"

URI_aarch64_qt6-qtbase-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtbase-devel-6.10.1-1.el10.alma.1.aarch64.rpm;name=aarch64_qt6-qtbase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtbase-devel}"
SRC_URI[aarch64_qt6-qtbase-devel.sha256sum] = "d124029356fce22ea0b2ad8a8389a872be18dcab6dce5c9d0ce8ee7decf32c29"

URI_aarch64_qt6-qtbase-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtbase-examples-6.10.1-1.el10.alma.1.aarch64.rpm;name=aarch64_qt6-qtbase-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtbase-examples}"
SRC_URI[aarch64_qt6-qtbase-examples.sha256sum] = "b5cab295172ee3969e1f10800686ad85ee4387921fc6b6295dbb5fc3d041d789"

URI_aarch64_qt6-qtbase-gui = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtbase-gui-6.10.1-1.el10.alma.1.aarch64.rpm;name=aarch64_qt6-qtbase-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtbase-gui}"
SRC_URI[aarch64_qt6-qtbase-gui.sha256sum] = "c5721084fec1632511cc3848f8a2f209f26d2cd9eb83082b2ee657f8d7b1a0db"

URI_aarch64_qt6-qtbase-mysql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtbase-mysql-6.10.1-1.el10.alma.1.aarch64.rpm;name=aarch64_qt6-qtbase-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtbase-mysql}"
SRC_URI[aarch64_qt6-qtbase-mysql.sha256sum] = "394917083b9765b2fdd1f5f403846055e3af80c468c63d2065e31948ed859c0a"

URI_aarch64_qt6-qtbase-odbc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtbase-odbc-6.10.1-1.el10.alma.1.aarch64.rpm;name=aarch64_qt6-qtbase-odbc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtbase-odbc}"
SRC_URI[aarch64_qt6-qtbase-odbc.sha256sum] = "c66d83f69253a152a2a08d069fadbd53f4800943ce791ef6c519346bb36a8d82"

URI_aarch64_qt6-qtbase-postgresql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtbase-postgresql-6.10.1-1.el10.alma.1.aarch64.rpm;name=aarch64_qt6-qtbase-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtbase-postgresql}"
SRC_URI[aarch64_qt6-qtbase-postgresql.sha256sum] = "2297c5bfa915207c3433b8da634d1d3a8c070cfc511250c8ab89154852b5394a"

URI_aarch64_qt6-qtbase-private-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtbase-private-devel-6.10.1-1.el10.alma.1.aarch64.rpm;name=aarch64_qt6-qtbase-private-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtbase-private-devel}"
SRC_URI[aarch64_qt6-qtbase-private-devel.sha256sum] = "ce28f37a517f4fe3e22f5b0ba84b6d9edd555cab7a69c4a339c8522e1236928a"

URI_aarch64_qt6-qtbase-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtbase-static-6.10.1-1.el10.alma.1.aarch64.rpm;name=aarch64_qt6-qtbase-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtbase-static}"
SRC_URI[aarch64_qt6-qtbase-static.sha256sum] = "ff1ef40c2f55c8ab8d1b17d7de76dcb730e4d790d1b3284abb00ee5e09e3258b"

RDEPENDS:qt6-qtbase = " \
 dbus-libs \
 glib2 \
 glibc \
 krb5-libs \
 libbrotli \
 libgcc \
 libicu \
 libproxy \
 libstdc++ \
 libzstd \
 openssl-libs \
 pcre2-utf16 \
 qt6-filesystem \
 qt6-qtbase-common \
 sqlite-libs \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:qt6-qtbase-common = " \
 qt6-qtbase \
 "
RDEPENDS:qt6-qtbase-devel = " \
 bash \
 cmake-filesystem \
 glibc \
 libgcc \
 libglvnd-devel \
 libstdc++ \
 libxkbcommon-devel \
 libzstd \
 pcre2-utf16 \
 pkgconf-pkg-config \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 qt6-qtbase-mysql \
 qt6-qtbase-odbc \
 qt6-qtbase-postgresql \
 qt6-rpm-macros \
 vulkan-loader-devel \
 "
RDEPENDS:qt6-qtbase-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:qt6-qtbase-gui:x86_64_v2 = " \
 bash \
 cups-libs \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 glx-utils \
 harfbuzz \
 libICE \
 libSM \
 libX11 \
 libX11-xcb \
 libdrm \
 libgcc \
 libglvnd-egl \
 libglvnd-glx \
 libglvnd-opengl \
 libinput \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 libxcb \
 libxkbcommon \
 libxkbcommon-x11 \
 mesa-libgbm \
 mtdev \
 qt6-qtbase \
 systemd-libs \
 xcb-util-cursor \
 xcb-util-image \
 xcb-util-keysyms \
 xcb-util-renderutil \
 xcb-util-wm \
 zlib-ng-compat \
"
RDEPENDS:qt6-qtbase-gui:aarch64 = " \
 bash \
 cups-libs \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 glx-utils \
 harfbuzz \
 libICE \
 libSM \
 libX11 \
 libX11-xcb \
 libdrm \
 libglvnd-egl \
 libglvnd-glx \
 libglvnd-opengl \
 libinput \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 libxcb \
 libxkbcommon \
 libxkbcommon-x11 \
 mesa-libgbm \
 mtdev \
 qt6-qtbase \
 systemd-libs \
 xcb-util-cursor \
 xcb-util-image \
 xcb-util-keysyms \
 xcb-util-renderutil \
 xcb-util-wm \
 zlib-ng-compat \
"
RDEPENDS:qt6-qtbase-mysql = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 mariadb-connector-c \
 qt6-qtbase \
 "
RDEPENDS:qt6-qtbase-odbc = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 qt6-qtbase \
 unixODBC \
 "
RDEPENDS:qt6-qtbase-postgresql = " \
 cmake-filesystem \
 glibc \
 libpq \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:qt6-qtbase-private-devel = " \
 cmake-filesystem \
 cups-devel \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:qt6-qtbase-static = " \
 cmake-filesystem \
 fontconfig-devel \
 glib2-devel \
 libinput-devel \
 libxkbcommon-devel \
 qt6-qtbase-devel \
 zlib-ng-compat-devel \
 "
