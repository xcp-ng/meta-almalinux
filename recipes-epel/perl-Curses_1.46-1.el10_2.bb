# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Curses"
PV = "1.46"
PR = "1.el10_2"
PACKAGES = " \
 perl-Curses \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Curses-1.46-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9051141a25544f7ca5836d8b164ea28cf01d89dd3a1b60e899579f8517714d8"

URI_x86_64_v2_perl-Curses = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Curses-1.46-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Curses;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Curses}"
SRC_URI[x86_64_v2_perl-Curses.sha256sum] = "3d74e82574eb7066c5b6776fdc361db9e4bc19f320586bd285d6fecd94b8468e"

URI_aarch64_perl-Curses = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Curses-1.46-1.el10_2.aarch64.rpm;name=aarch64_perl-Curses;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Curses}"
SRC_URI[aarch64_perl-Curses.sha256sum] = "fb63a9d04c95d99cce0dc2a7fa8219559458971dda619be8595505df7d5e844b"

RDEPENDS:perl-Curses = " \
 glibc \
 ncurses-libs \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 "
