# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ase"
PV = "3.29.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-ase \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-ase-3.29.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f2115e014a3bbf6c675e6b3e9082ec9f71777824c55b71f73b1f09a3d7eb2a0"

URI_x86_64_v2_python3-ase = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ase-3.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ase;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ase}"
SRC_URI[x86_64_v2_python3-ase.sha256sum] = "4f50c8800ed4b021fec8642eba50ed293ee666977c087edec2ba0ae322e49e72"

URI_aarch64_python3-ase = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ase-3.29.0-1.el10_3.noarch.rpm;name=aarch64_python3-ase;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ase}"
SRC_URI[aarch64_python3-ase.sha256sum] = "aaf1f92b9ead4eab8434c523887657820610e51d1038b7bc1dc9344d2979521c"

RDEPENDS:python3-ase = " \
 python3 \
 python3-matplotlib \
 python3-numpy \
 python3-scipy \
 python3-typing-extensions \
 "
