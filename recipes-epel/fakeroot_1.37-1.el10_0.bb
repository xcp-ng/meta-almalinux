# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fakeroot"
PV = "1.37"
PR = "1.el10_0"
PACKAGES = " \
 fakeroot \
 fakeroot-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fakeroot-1.37-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b0698ee21fab6d7b940cbfdb010cedeb4844f4996d197ae2730db3c470ea4b87"

URI_x86_64_v2_fakeroot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fakeroot-1.37-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fakeroot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fakeroot}"
SRC_URI[x86_64_v2_fakeroot.sha256sum] = "5b084dc53aafe54e8e38755b3c643aafa2542e0e710cebd13eddf24cce2ffef6"

URI_x86_64_v2_fakeroot-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fakeroot-libs-1.37-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fakeroot-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fakeroot-libs}"
SRC_URI[x86_64_v2_fakeroot-libs.sha256sum] = "efb7e9a8c6cfa50220e38bb0e9ca3d88ec45638ded225923a9b13891ebfa5930"

URI_aarch64_fakeroot = "${EPEL_MIRROR}/aarch64/Packages/f/fakeroot-1.37-1.el10_0.aarch64.rpm;name=aarch64_fakeroot;unpack=0"
SRC_URI:append = " ${URI_aarch64_fakeroot}"
SRC_URI[aarch64_fakeroot.sha256sum] = "29110e615547e9ac705bd8f22b624d481c0317b0a72513acb474de87c8b8f2ba"

URI_aarch64_fakeroot-libs = "${EPEL_MIRROR}/aarch64/Packages/f/fakeroot-libs-1.37-1.el10_0.aarch64.rpm;name=aarch64_fakeroot-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_fakeroot-libs}"
SRC_URI[aarch64_fakeroot-libs.sha256sum] = "2f92d7a517f0278da551e61033c43dd36a56bf6809c2f1d5b3f1731d0fc4c3d4"

RDEPENDS:fakeroot = " \
 alternatives \
 bash \
 fakeroot-libs \
 glibc \
 util-linux \
 virtual//usr/bin/readlink \
 "
RDEPENDS:fakeroot-libs = " \
 glibc \
 "
