# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-Pod-LinkCheck"
PV = "0.008"
PR = "37.el10_0"
PACKAGES = " \
 perl-Test-Pod-LinkCheck \
 perl-Test-Pod-LinkCheck-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Test-Pod-LinkCheck-0.008-37.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "42d0c13ec086ff93e8246a4fefc9c01433614bc9e5603b7a3d14215082252763"

URI_x86_64_v2_perl-Test-Pod-LinkCheck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-Pod-LinkCheck-0.008-37.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-Pod-LinkCheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-Pod-LinkCheck}"
SRC_URI[x86_64_v2_perl-Test-Pod-LinkCheck.sha256sum] = "e59d33a7af366f9c75194cb90bd7f4e2408bbadcd8808f577d248097d50f84f4"

URI_x86_64_v2_perl-Test-Pod-LinkCheck-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-Pod-LinkCheck-tests-0.008-37.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-Pod-LinkCheck-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-Pod-LinkCheck-tests}"
SRC_URI[x86_64_v2_perl-Test-Pod-LinkCheck-tests.sha256sum] = "592aa042972fb68ff13b0879ef4a8911dd79b24e9a0c9e603a31acaf98e931b0"

URI_aarch64_perl-Test-Pod-LinkCheck = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-Pod-LinkCheck-0.008-37.el10_0.noarch.rpm;name=aarch64_perl-Test-Pod-LinkCheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-Pod-LinkCheck}"
SRC_URI[aarch64_perl-Test-Pod-LinkCheck.sha256sum] = "988f483aa2996fb27cee7d256f3244fcee04b7ada6e2f2c0b19113e94aa36d22"

URI_aarch64_perl-Test-Pod-LinkCheck-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-Pod-LinkCheck-tests-0.008-37.el10_0.noarch.rpm;name=aarch64_perl-Test-Pod-LinkCheck-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-Pod-LinkCheck-tests}"
SRC_URI[aarch64_perl-Test-Pod-LinkCheck-tests.sha256sum] = "b8a52e6f1fd99f8a623fc0046f9b398ad95b2af18229577ec8b066695f8c636c"

RDEPENDS:perl-Test-Pod-LinkCheck = " \
 perl-Capture-Tiny \
 perl-Exporter \
 perl-Moose \
 perl-PathTools \
 perl-Pod-Parser \
 perl-Test-Pod \
 perl-Test-Simple \
 perl-libs \
 perl-parent \
 perl-podlinkcheck \
 "
RDEPENDS:perl-Test-Pod-LinkCheck-tests = " \
 bash \
 perl-File-Temp \
 perl-Test-Harness \
 perl-Test-Pod-LinkCheck \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
