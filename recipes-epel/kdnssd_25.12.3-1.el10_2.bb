# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdnssd"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kdnssd \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kdnssd-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a91b11a2b85a089cdb5963daaf5892b3e6b29524496bd8fd927cc6b5bc741bc3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdnssd-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdnssd;unpack=0"
SRC_URI[x86_64_v2_kdnssd.sha256sum] = "925f7b2cfb82e5c4357e483e118d8ceda58a67d43e834f60388a51d837087072"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kdnssd-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kdnssd;unpack=0"
SRC_URI[aarch64_kdnssd.sha256sum] = "8ecafe20f4bf4a143b635540b1d6230300ef6aeb4ef239cb23440f778965cef4"

RDEPENDS:kdnssd = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kdnssd \
 kf6-ki18n \
 kf6-kio-core-libs \
 libstdc++ \
 qt6-qtbase \
 "
