# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkeduvocdocument"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 libkeduvocdocument \
 libkeduvocdocument-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkeduvocdocument-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6625555b3900cab168f49c9f8ca186d85d63e1de5e4bf774a3b0606bf3703800"

URI_x86_64_v2_libkeduvocdocument = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkeduvocdocument-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkeduvocdocument;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkeduvocdocument}"
SRC_URI[x86_64_v2_libkeduvocdocument.sha256sum] = "4f041e1d8031d44c75b7f71e110acd5a730e9bae59d306fef5ed9f569b745e05"

URI_x86_64_v2_libkeduvocdocument-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkeduvocdocument-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkeduvocdocument-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkeduvocdocument-devel}"
SRC_URI[x86_64_v2_libkeduvocdocument-devel.sha256sum] = "6d283413eaadc92c428eccb2cf251274cd9c00d58dd84537d7d451da5d094c0d"

URI_aarch64_libkeduvocdocument = "${EPEL_MIRROR}/aarch64/Packages/l/libkeduvocdocument-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_libkeduvocdocument;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkeduvocdocument}"
SRC_URI[aarch64_libkeduvocdocument.sha256sum] = "ba79a083d7f6f1d442e66023b6e8bdd7007a8c020ce401d99fb7e8aad26f9661"

URI_aarch64_libkeduvocdocument-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkeduvocdocument-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_libkeduvocdocument-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkeduvocdocument-devel}"
SRC_URI[aarch64_libkeduvocdocument-devel.sha256sum] = "988ba9c6e2b215f9ba6336b6cd46d02fc194f05bed977b9f9842ac80582c44ae"

RDEPENDS:libkeduvocdocument = " \
 glibc \
 kdeedu-data \
 kf6-karchive \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:libkeduvocdocument-devel = " \
 cmake-filesystem \
 libkeduvocdocument \
 "
