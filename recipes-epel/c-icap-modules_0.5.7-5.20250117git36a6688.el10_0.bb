# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "c-icap-modules"
PV = "0.5.7"
PR = "5.20250117git36a6688.el10_0"
PACKAGES = " \
 c-icap-modules \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/c-icap-modules-0.5.7-5.20250117git36a6688.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28cbf299018ac9100c7e8556fe5b1498088ed6e227b97e136e4ac3de71b6fb75"

URI_x86_64_v2_c-icap-modules = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/c-icap-modules-0.5.7-5.20250117git36a6688.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_c-icap-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_c-icap-modules}"
SRC_URI[x86_64_v2_c-icap-modules.sha256sum] = "e4076d9ef0f9b8a50db6198f4d9a3da63f7e48c3251a1723ee2d40513db752b7"

URI_aarch64_c-icap-modules = "${EPEL_MIRROR}/aarch64/Packages/c/c-icap-modules-0.5.7-5.20250117git36a6688.el10_0.aarch64.rpm;name=aarch64_c-icap-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_c-icap-modules}"
SRC_URI[aarch64_c-icap-modules.sha256sum] = "a84c1be5443f68316b2db35dc9658f74c875996994753f98e7de6659111df238"

RDEPENDS:c-icap-modules = " \
 c-icap \
 c-icap-libs \
 clamav-lib \
 glibc \
 lmdb-libs \
 "
