# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "intel-gmmlib"
PV = "22.7.2"
PR = "1.el10_0"
PACKAGES = " \
 intel-gmmlib \
 intel-gmmlib-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/intel-gmmlib-22.7.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f82188b671f650fafc1e78116e1a655d30572b252997e9331e857c8ba8547578"

URI_x86_64_v2_intel-gmmlib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-gmmlib-22.7.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-gmmlib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-gmmlib}"
SRC_URI[x86_64_v2_intel-gmmlib.sha256sum] = "d9b17be7b22bace72598763de3cd9bc6542d2547f92797ed99134759dc8909f9"

URI_x86_64_v2_intel-gmmlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-gmmlib-devel-22.7.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-gmmlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-gmmlib-devel}"
SRC_URI[x86_64_v2_intel-gmmlib-devel.sha256sum] = "751250baa0fd6d288ea785a22da4b3a6c3a432ec3a8c76253bf26ff9aebfb538"

URI_aarch64_intel-gmmlib = "${EPEL_MIRROR}/aarch64/Packages/i/intel-gmmlib-22.7.2-1.el10_0.aarch64.rpm;name=aarch64_intel-gmmlib;unpack=0"
SRC_URI:append = " ${URI_aarch64_intel-gmmlib}"
SRC_URI[aarch64_intel-gmmlib.sha256sum] = "0b46e21f499c7b72d5ac7f92a6b9c83b31dc35f2cd28f53348555a0ac6253fc9"

URI_aarch64_intel-gmmlib-devel = "${EPEL_MIRROR}/aarch64/Packages/i/intel-gmmlib-devel-22.7.2-1.el10_0.aarch64.rpm;name=aarch64_intel-gmmlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_intel-gmmlib-devel}"
SRC_URI[aarch64_intel-gmmlib-devel.sha256sum] = "884488deaee6bfb787aade41500d92dea637dcde49bc911a9d05eca910335180"

RDEPENDS:intel-gmmlib = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:intel-gmmlib-devel = " \
 intel-gmmlib \
 pkgconf-pkg-config \
 "
