# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tuptime"
PV = "5.2.6"
PR = "1.el10_1"
PACKAGES = " \
 tuptime \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tuptime-5.2.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "00ca754448d95ab989a1e58c8d6948c7524bcf034e4d230e4dd87f1d4a1c663e"

URI_x86_64_v2_tuptime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tuptime-5.2.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_tuptime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuptime}"
SRC_URI[x86_64_v2_tuptime.sha256sum] = "c2b9004787c04fa278b57f8607529e8bac356bfcfbccf2a8fd7c1b262db13186"

URI_aarch64_tuptime = "${EPEL_MIRROR}/aarch64/Packages/t/tuptime-5.2.6-1.el10_1.noarch.rpm;name=aarch64_tuptime;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuptime}"
SRC_URI[aarch64_tuptime.sha256sum] = "22424c7618faee63087fe39f44e1cf3d8ac192ef164a6370092f71d307631021"

RDEPENDS:tuptime = " \
 bash \
 systemd \
 "
