# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num-derive"
PV = "0.4.2"
PR = "2.el10_0"
PACKAGES = " \
 rust-num-derive+default-devel \
 rust-num-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-num-derive-0.4.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "877f88e0cd41911e07d6d8e1c050ba6e720851b1447ee47133de60c089461945"

URI_x86_64_v2_rust-num-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-derive+default-devel-0.4.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-derive+default-devel}"
SRC_URI[x86_64_v2_rust-num-derive+default-devel.sha256sum] = "b6801ea7108bb3650ca6a688585655bdad6e7d721559df70263060d42f45267d"

URI_x86_64_v2_rust-num-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-derive-devel-0.4.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-derive-devel}"
SRC_URI[x86_64_v2_rust-num-derive-devel.sha256sum] = "e57a53f9916947d79150f7b9ea0896b984a5aa6b7577fb53847b8fffaf1f364b"

URI_aarch64_rust-num-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-derive+default-devel-0.4.2-2.el10_0.noarch.rpm;name=aarch64_rust-num-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-derive+default-devel}"
SRC_URI[aarch64_rust-num-derive+default-devel.sha256sum] = "43b6134a78a15733d083bad39a8d41f2046b6652123b45e2ecd4730cdcada299"

URI_aarch64_rust-num-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-derive-devel-0.4.2-2.el10_0.noarch.rpm;name=aarch64_rust-num-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-derive-devel}"
SRC_URI[aarch64_rust-num-derive-devel.sha256sum] = "87b7aca66b31b20d24ff399e3ccd9030b59a8b168c7c55e3740484f356c56058"

RDEPENDS:rust-num-derive+default-devel = " \
 cargo \
 rust-num-derive-devel \
 "
RDEPENDS:rust-num-derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 "
