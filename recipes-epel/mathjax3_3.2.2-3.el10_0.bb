# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mathjax3"
PV = "3.2.2"
PR = "3.el10_0"
PACKAGES = " \
 mathjax3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mathjax3-3.2.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "591f29fd6cea024cc220ff20d9acce9882e175d1b2df73ccb8ba8c960a7ac367"

URI_x86_64_v2_mathjax3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mathjax3-3.2.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mathjax3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mathjax3}"
SRC_URI[x86_64_v2_mathjax3.sha256sum] = "e2a04572ab37146b90426f7801c159ffec5a0663054e849365895123ee8572f0"

URI_aarch64_mathjax3 = "${EPEL_MIRROR}/aarch64/Packages/m/mathjax3-3.2.2-3.el10_0.noarch.rpm;name=aarch64_mathjax3;unpack=0"
SRC_URI:append = " ${URI_aarch64_mathjax3}"
SRC_URI[aarch64_mathjax3.sha256sum] = "d212ae79d892202931e02451a0a910543ec57c86f1644feeae2deb874f4b17b2"

RDEPENDS:mathjax3 = " \
 web-assets-filesystem \
 "
