# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-index"
PV = "0.38.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-index+default-devel \
 rust-gix-index+document-features-devel \
 rust-gix-index+serde-devel \
 rust-gix-index-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-index-0.38.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "167dc3610f20d18599f5b02e1b299c254e974e54913c69d5a3ca811f94d106c6"

URI_x86_64_v2_rust-gix-index+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-index+default-devel-0.38.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-index+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-index+default-devel}"
SRC_URI[x86_64_v2_rust-gix-index+default-devel.sha256sum] = "8fa7dd0b5c410ba2df5f6a6a468232937a5e7bbb8134f2de2b646ee2cf13e79b"

URI_x86_64_v2_rust-gix-index+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-index+document-features-devel-0.38.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-index+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-index+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-index+document-features-devel.sha256sum] = "ab3d5ed87778a48bb20296da7eff98fba8a1fec59f93f09f8d8921fe9cb3fd81"

URI_x86_64_v2_rust-gix-index+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-index+serde-devel-0.38.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-index+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-index+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-index+serde-devel.sha256sum] = "dacc93e51988a367c849aeafeb828e7c1250f3bcfb9a72ab1277ef770e5c5ea3"

URI_x86_64_v2_rust-gix-index-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-index-devel-0.38.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-index-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-index-devel}"
SRC_URI[x86_64_v2_rust-gix-index-devel.sha256sum] = "a864ae229b0fbeabaf45de5ba8395472d974f8a27875be613c83a54d07655977"

URI_aarch64_rust-gix-index+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-index+default-devel-0.38.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-index+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-index+default-devel}"
SRC_URI[aarch64_rust-gix-index+default-devel.sha256sum] = "869bcd3c2ef6c98895ee9433aedba5bf0821a5813168e12c2dc1b8110a7c3038"

URI_aarch64_rust-gix-index+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-index+document-features-devel-0.38.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-index+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-index+document-features-devel}"
SRC_URI[aarch64_rust-gix-index+document-features-devel.sha256sum] = "8682c77f8664e1500c58d20457df9300eeb1330da872fcc108a8c423b7920abc"

URI_aarch64_rust-gix-index+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-index+serde-devel-0.38.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-index+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-index+serde-devel}"
SRC_URI[aarch64_rust-gix-index+serde-devel.sha256sum] = "aaf18ff8099d2c27a72443e05d072756f868be2079aebb21881e04d5030a4827"

URI_aarch64_rust-gix-index-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-index-devel-0.38.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-index-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-index-devel}"
SRC_URI[aarch64_rust-gix-index-devel.sha256sum] = "6df7eb8ff0b4d96bf47c2ea43c38a7b007ba375a5eaf31bdaf1ac646964d6f6c"

RDEPENDS:rust-gix-index+default-devel = " \
 cargo \
 rust-gix-index-devel \
 "
RDEPENDS:rust-gix-index+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-index-devel \
 "
RDEPENDS:rust-gix-index+serde-devel = " \
 cargo \
 rust-gix-hash+serde-devel \
 rust-gix-index-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-smallvec+serde-devel \
 "
RDEPENDS:rust-gix-index-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-bstr-devel \
 rust-filetime+default-devel \
 rust-fnv+default-devel \
 rust-gix-bitmap+default-devel \
 rust-gix-features+default-devel \
 rust-gix-features+progress-devel \
 rust-gix-features+rustsha1-devel \
 rust-gix-fs+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-lock+default-devel \
 rust-gix-object+default-devel \
 rust-gix-traverse+default-devel \
 rust-gix-utils+default-devel \
 rust-gix-validate+default-devel \
 rust-hashbrown0.14+default-devel \
 rust-itoa+default-devel \
 rust-libc+default-devel \
 rust-memmap2+default-devel \
 rust-rustix+fs-devel \
 rust-rustix+std-devel \
 rust-rustix-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 "
