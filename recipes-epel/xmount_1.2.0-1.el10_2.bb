# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xmount"
PV = "1.2.0"
PR = "1.el10_2"
PACKAGES = " \
 xmount \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xmount-1.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "17aabafc44a38e83d3fb893b9df1a653da4220585721a107f2431c043ef0594f"

URI_x86_64_v2_xmount = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xmount-1.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xmount;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmount}"
SRC_URI[x86_64_v2_xmount.sha256sum] = "c8033a88675551d4980566f5790386438b0aaee88474d107bcab4c0c38716c93"

URI_aarch64_xmount = "${EPEL_MIRROR}/aarch64/Packages/x/xmount-1.2.0-1.el10_2.aarch64.rpm;name=aarch64_xmount;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmount}"
SRC_URI[aarch64_xmount.sha256sum] = "dd9b26f59a8d248c717a9b4f16e205c02854ecd3fd4e35802495c9173fa54ba6"

RDEPENDS:xmount = " \
 afflib \
 fuse-libs \
 glibc \
 libewf \
 zlib-ng-compat \
 "
