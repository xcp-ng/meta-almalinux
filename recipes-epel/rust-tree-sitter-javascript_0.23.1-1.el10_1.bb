# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-javascript"
PV = "0.23.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-tree-sitter-javascript+default-devel \
 rust-tree-sitter-javascript-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-javascript-0.23.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19063b9681dfe803696272bf8c5022b741b8307a947b8a2dd353b9806dbefda8"

URI_x86_64_v2_rust-tree-sitter-javascript+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-javascript+default-devel-0.23.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-javascript+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-javascript+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-javascript+default-devel.sha256sum] = "a260a3ccdc12b6dadad9824455dbadf80ce6b7eebd803c7ba42d47f2cae05231"

URI_x86_64_v2_rust-tree-sitter-javascript-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-javascript-devel-0.23.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-javascript-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-javascript-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-javascript-devel.sha256sum] = "b84284b13a789914c0dd022aaf9fe25eec53b1860a8da1a10a9a0656e5dd6c9d"

URI_aarch64_rust-tree-sitter-javascript+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-javascript+default-devel-0.23.1-1.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-javascript+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-javascript+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-javascript+default-devel.sha256sum] = "17c69f174b7a1b5a4f38730c49d8c849974b74eee5077be742ab527e87ad383c"

URI_aarch64_rust-tree-sitter-javascript-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-javascript-devel-0.23.1-1.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-javascript-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-javascript-devel}"
SRC_URI[aarch64_rust-tree-sitter-javascript-devel.sha256sum] = "a6dac7b80c5865ee2214e49e11fecb5905207f212546e0ab714f371965b6b2b1"

RDEPENDS:rust-tree-sitter-javascript+default-devel = " \
 cargo \
 rust-tree-sitter-javascript-devel \
 "
RDEPENDS:rust-tree-sitter-javascript-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
