# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tango-icon-theme"
PV = "0.8.90"
PR = "32.el10_1"
PACKAGES = " \
 tango-icon-theme \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tango-icon-theme-0.8.90-32.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6858b44213d4e1a9e8ed16f2ccda6d858edaaecacbf149150676b224bd08f7e3"

URI_x86_64_v2_tango-icon-theme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tango-icon-theme-0.8.90-32.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_tango-icon-theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tango-icon-theme}"
SRC_URI[x86_64_v2_tango-icon-theme.sha256sum] = "639a17cb87ea3b404566ce4209fcd428b3f7f5501bc6146cff57bead464c0488"

URI_aarch64_tango-icon-theme = "${EPEL_MIRROR}/aarch64/Packages/t/tango-icon-theme-0.8.90-32.el10_1.noarch.rpm;name=aarch64_tango-icon-theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_tango-icon-theme}"
SRC_URI[aarch64_tango-icon-theme.sha256sum] = "7f7bc2c0678f52d6aee8aff41f038c60f299b182bbefba7ca38e8c27e745c42c"

RDEPENDS:tango-icon-theme = " \
 bash \
 "
