# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubberband"
PV = "3.3.0"
PR = "8.el10_0"
PACKAGES = " \
 rubberband \
 rubberband-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubberband-3.3.0-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e90063a144e0631622c1ea7fa66db3b8120dd79f2ee2184c5b93418cf81ee7f4"

URI_x86_64_v2_rubberband = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubberband-3.3.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rubberband;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubberband}"
SRC_URI[x86_64_v2_rubberband.sha256sum] = "7a6d8fb275ae4bd7da50b28524a9d3dd9f3bb470135bebef8d7f886aa09a8f90"

URI_x86_64_v2_rubberband-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubberband-devel-3.3.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rubberband-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubberband-devel}"
SRC_URI[x86_64_v2_rubberband-devel.sha256sum] = "619b93e145f3c22e7e7ebfda12f4dc8996fb24f0e443cd4efca94eb5876f4dc8"

URI_aarch64_rubberband = "${EPEL_MIRROR}/aarch64/Packages/r/rubberband-3.3.0-8.el10_0.aarch64.rpm;name=aarch64_rubberband;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubberband}"
SRC_URI[aarch64_rubberband.sha256sum] = "dff105b56cbdb1caed97dfac35f7fe72471fb82d84042a884671cd38cbab54a6"

URI_aarch64_rubberband-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rubberband-devel-3.3.0-8.el10_0.aarch64.rpm;name=aarch64_rubberband-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubberband-devel}"
SRC_URI[aarch64_rubberband-devel.sha256sum] = "f78da493ff72cb4dc708a26f2b01a90c315b1e032a59219157acc7fc95646112"

RDEPENDS:rubberband = " \
 fftw-libs-double \
 glibc \
 ladspa \
 libgcc \
 libsamplerate \
 libsndfile \
 libstdc++ \
 lv2 \
 vamp-plugin-sdk \
 "
RDEPENDS:rubberband-devel = " \
 fftw-devel \
 libsamplerate-devel \
 pkgconf-pkg-config \
 rubberband \
 "
