# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cups-browsed"
PE = "1"
PV = "2.0.0"
PR = "9.el10"
PACKAGES = " \
 cups-browsed \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cups-browsed-2.0.0-9.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "73bd6830f8ee6784072ab10c0cf98b18f7f8379b21d08127543606f9027932f5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cups-browsed-2.0.0-9.el10.x86_64_v2.rpm;name=x86_64_v2_cups-browsed;unpack=0"
SRC_URI[x86_64_v2_cups-browsed.sha256sum] = "4b70572e8815051e3344b9ef4633d11b1f37a0fc10d57a77528dc54b06fc6f70"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cups-browsed-2.0.0-9.el10.aarch64.rpm;name=aarch64_cups-browsed;unpack=0"
SRC_URI[aarch64_cups-browsed.sha256sum] = "aaaf8a4dfbf01b0d9a75abdd938d81629f35df75414b023833add06ecc5075f1"

RDEPENDS:cups-browsed = " \
 avahi-glib \
 avahi-libs \
 bash \
 cups-filesystem \
 cups-libs \
 glib2 \
 glibc \
 libcupsfilters \
 libppd \
 systemd \
 "
