# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-nanobind"
PV = "2.10.2"
PR = "1.el10_2"
PACKAGES = " \
 python3-nanobind \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-nanobind-2.10.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "80657db9499be0b1b0eedec70a86a073550aa315d3590067af611d63047eb50b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-nanobind-2.10.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-nanobind;unpack=0"
SRC_URI[x86_64_v2_python3-nanobind.sha256sum] = "1739313a28b506e6883c81296423ff45c0d288b3dc5b3e236446638e0a53563a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-nanobind-2.10.2-1.el10_2.noarch.rpm;name=aarch64_python3-nanobind;unpack=0"
SRC_URI[aarch64_python3-nanobind.sha256sum] = "032130dc048de1cd6f637eda441ae3b99f1f391c864de29da1690787ed7f1c33"

RDEPENDS:python3-nanobind = " \
 python3 \
 robin-map-devel \
 "
