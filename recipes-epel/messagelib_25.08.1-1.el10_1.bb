# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "messagelib"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 messagelib \
 messagelib-devel \
 messagelib-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/messagelib-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e588ba7fe535a606988ae9e98a6e61008ff142ca09a8c327594cb0f687da24cf"

URI_x86_64_v2_messagelib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/messagelib-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_messagelib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_messagelib}"
SRC_URI[x86_64_v2_messagelib.sha256sum] = "0bedab6223e18f5cd2ba941878c8574c68950841a2fc77c9f73d0011732a5f88"

URI_x86_64_v2_messagelib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/messagelib-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_messagelib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_messagelib-devel}"
SRC_URI[x86_64_v2_messagelib-devel.sha256sum] = "96bcc153e576b6fd9f8914a838d1b8c069bedecd08b703a59080ba75208b1e7c"

URI_x86_64_v2_messagelib-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/messagelib-doc-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_messagelib-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_messagelib-doc}"
SRC_URI[x86_64_v2_messagelib-doc.sha256sum] = "513aca303306dabe77708eca95d316700ba38c6cc31d9ce2f48a4b90cdc94355"

URI_aarch64_messagelib = "${EPEL_MIRROR}/aarch64/Packages/m/messagelib-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_messagelib;unpack=0"
SRC_URI:append = " ${URI_aarch64_messagelib}"
SRC_URI[aarch64_messagelib.sha256sum] = "0a34b7998eb07bf6a6cd891c9e0f3d18fdb40048325bd0d2e878020ddc3b0b41"

URI_aarch64_messagelib-devel = "${EPEL_MIRROR}/aarch64/Packages/m/messagelib-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_messagelib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_messagelib-devel}"
SRC_URI[aarch64_messagelib-devel.sha256sum] = "d91b72a06ce9fa1fd5054b1af9ba2b73983e1edf98a11049e345409ac7fc8911"

URI_aarch64_messagelib-doc = "${EPEL_MIRROR}/aarch64/Packages/m/messagelib-doc-25.08.1-1.el10_1.noarch.rpm;name=aarch64_messagelib-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_messagelib-doc}"
SRC_URI[aarch64_messagelib-doc.sha256sum] = "b8033789c643a8473e25b171362dd0eebbdbbacd9ec278a161e721163bb184e1"

RDEPENDS:messagelib = " \
 akonadi-contacts \
 akonadi-mime \
 akonadi-search \
 akonadi-server \
 glibc \
 gpgmepp \
 grantleetheme \
 kf6-karchive \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-kservice \
 kf6-ktexttemplate \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 kf6-syntax-highlighting \
 kidentitymanagement \
 kmailtransport \
 kmbox \
 kmime \
 kpimtextedit \
 ktextaddons-qt6 \
 libgcc \
 libgravatar \
 libkdepim \
 libkleo \
 libstdc++ \
 openssl-libs \
 pimcommon \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:messagelib-devel = " \
 akonadi-mime-devel \
 akonadi-server-devel \
 cmake-filesystem \
 kf6-kcontacts-devel \
 kidentitymanagement-devel \
 kmime-devel \
 libkleo-devel \
 messagelib \
 pimcommon-devel \
 qt6-qtwebengine-devel \
 "
RDEPENDS:messagelib-doc = " \
 "
