# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cloud-init"
PV = "24.4"
PR = "7.el10_2.1.alma.1"
PACKAGES = " \
 cloud-init \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cloud-init-24.4-7.el10_2.1.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d99ae62eda948af12a6ea8ffdcc2c176f9fd23514605c299aef53f225864c245"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cloud-init-24.4-7.el10_2.1.alma.1.noarch.rpm;name=x86_64_v2_cloud-init;unpack=0"
SRC_URI[x86_64_v2_cloud-init.sha256sum] = "7b1d3d3ebcbe7385cf3aabc48314de0f070b7c8c24d9a9a6a78c47c544d7b2b0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cloud-init-24.4-7.el10_2.1.alma.1.noarch.rpm;name=aarch64_cloud-init;unpack=0"
SRC_URI[aarch64_cloud-init.sha256sum] = "7b1d3d3ebcbe7385cf3aabc48314de0f070b7c8c24d9a9a6a78c47c544d7b2b0"

RDEPENDS:cloud-init = " \
 bash \
 dhcpcd \
 e2fsprogs \
 hostname \
 iproute \
 openssl \
 procps-ng \
 python3 \
 python3-configobj \
 python3-jinja2 \
 python3-jsonpatch \
 python3-libselinux \
 python3-oauthlib \
 python3-policycoreutils \
 python3-pyserial \
 python3-pyyaml \
 python3-requests \
 shadow-utils \
 systemd \
 util-linux \
 xfsprogs \
 "
