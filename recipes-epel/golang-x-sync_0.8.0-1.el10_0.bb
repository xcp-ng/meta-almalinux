# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-x-sync"
PV = "0.8.0"
PR = "1.el10_0"
PACKAGES = " \
 golang-x-sync-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/golang-x-sync-0.8.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0b9e251ab5376a0532037b46e44428825b5ba33375c1b5304d5ce70f6bc89b96"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-x-sync-devel-0.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-x-sync-devel;unpack=0"
SRC_URI[x86_64_v2_golang-x-sync-devel.sha256sum] = "5324476fa439e801830fb9f13bffbcc2064da18c62b257f516780c290ac41dcc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-x-sync-devel-0.8.0-1.el10_0.noarch.rpm;name=aarch64_golang-x-sync-devel;unpack=0"
SRC_URI[aarch64_golang-x-sync-devel.sha256sum] = "7ac30e7e112650c74754a86b21b357f99e97199ef4e49450fddbdedd7fac3a6b"

RDEPENDS:golang-x-sync-devel = " \
 go-filesystem \
 "
