# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtspeech"
PV = "5.15.15"
PR = "1.el10_0"
PACKAGES = " \
 qt5-qtspeech \
 qt5-qtspeech-devel \
 qt5-qtspeech-examples \
 qt5-qtspeech-speechd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtspeech-5.15.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bbf750a4b15392aa56fe12c2fa442cddc80825ca89d56284c936eb3c81806206"

URI_x86_64_v2_qt5-qtspeech = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtspeech-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtspeech;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtspeech}"
SRC_URI[x86_64_v2_qt5-qtspeech.sha256sum] = "d5292633d3b2b39c49459ecb70f34906388b405d35086bc97c49076b2f754cb1"

URI_x86_64_v2_qt5-qtspeech-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtspeech-devel-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtspeech-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtspeech-devel}"
SRC_URI[x86_64_v2_qt5-qtspeech-devel.sha256sum] = "a6ac17e42b4c2502dd0614b2615273540d4e14e00df3e191d9908e3c9b109733"

URI_x86_64_v2_qt5-qtspeech-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtspeech-examples-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtspeech-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtspeech-examples}"
SRC_URI[x86_64_v2_qt5-qtspeech-examples.sha256sum] = "fe20c2def652bff98953af0d386b533b1ba351a0c9ebed1da3a0260eeaa4af36"

URI_x86_64_v2_qt5-qtspeech-speechd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtspeech-speechd-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtspeech-speechd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtspeech-speechd}"
SRC_URI[x86_64_v2_qt5-qtspeech-speechd.sha256sum] = "881732e84b03f331c53d40c6ecc9583d4b3a6f1b1e763ae722c709d4cd4937a7"

URI_aarch64_qt5-qtspeech = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtspeech-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtspeech;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtspeech}"
SRC_URI[aarch64_qt5-qtspeech.sha256sum] = "ee57fae65ac27db76394722a1f4fd5070103a13a1f04144931005f225f81b477"

URI_aarch64_qt5-qtspeech-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtspeech-devel-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtspeech-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtspeech-devel}"
SRC_URI[aarch64_qt5-qtspeech-devel.sha256sum] = "362b4e35e9c4c9ad4b670d8c602e28ee3b83e106370e48d4a541743d6adf1c62"

URI_aarch64_qt5-qtspeech-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtspeech-examples-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtspeech-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtspeech-examples}"
SRC_URI[aarch64_qt5-qtspeech-examples.sha256sum] = "718f39cbfb2a4e441dec0454edb622aca6b3ad5920e6bd3741531bbd6cc91b42"

URI_aarch64_qt5-qtspeech-speechd = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtspeech-speechd-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtspeech-speechd;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtspeech-speechd}"
SRC_URI[aarch64_qt5-qtspeech-speechd.sha256sum] = "991ae1b13994f8271164b063b9ab67bb7854959f1ec3fef7469a0b9a68ce9791"

RDEPENDS:qt5-qtspeech = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 "
RDEPENDS:qt5-qtspeech-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtspeech \
 "
RDEPENDS:qt5-qtspeech-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtspeech \
 "
RDEPENDS:qt5-qtspeech-speechd = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtspeech \
 speech-dispatcher-libs \
 "
