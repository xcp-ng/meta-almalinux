# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-chardetng"
PV = "0.1.17"
PR = "6.el10_2"
PACKAGES = " \
 rust-chardetng+arrayvec-devel \
 rust-chardetng+default-devel \
 rust-chardetng+multithreading-devel \
 rust-chardetng+rayon-devel \
 rust-chardetng+testing-only-no-semver-guarantees-do-not-use-devel \
 rust-chardetng-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-chardetng-0.1.17-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1609b426c6a7c50276d25d142b0c5a0e5cab6c1a583ecbd6c6a98578aca9bbae"

URI_x86_64_v2_rust-chardetng+arrayvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chardetng+arrayvec-devel-0.1.17-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chardetng+arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chardetng+arrayvec-devel}"
SRC_URI[x86_64_v2_rust-chardetng+arrayvec-devel.sha256sum] = "81bd67f03d7eee062f48fa2994d8d9b3f6f50caaee716ae6740b6cc30ac813b5"

URI_x86_64_v2_rust-chardetng+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chardetng+default-devel-0.1.17-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chardetng+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chardetng+default-devel}"
SRC_URI[x86_64_v2_rust-chardetng+default-devel.sha256sum] = "2c24ac9880e87940066d27b3845da2a6f6704e07976678c03da45af6c20cc18b"

URI_x86_64_v2_rust-chardetng+multithreading-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chardetng+multithreading-devel-0.1.17-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chardetng+multithreading-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chardetng+multithreading-devel}"
SRC_URI[x86_64_v2_rust-chardetng+multithreading-devel.sha256sum] = "877baf3de1ed83abedff7f59c1e835975fbbbb65a6411535d6a02c6df65d5597"

URI_x86_64_v2_rust-chardetng+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chardetng+rayon-devel-0.1.17-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chardetng+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chardetng+rayon-devel}"
SRC_URI[x86_64_v2_rust-chardetng+rayon-devel.sha256sum] = "4d45f92c7385217920063419d24169eb20d15069896bf5df83924ea42e8f1016"

URI_x86_64_v2_rust-chardetng+testing-only-no-semver-guarantees-do-not-use-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chardetng+testing-only-no-semver-guarantees-do-not-use-devel-0.1.17-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chardetng+testing-only-no-semver-guarantees-do-not-use-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chardetng+testing-only-no-semver-guarantees-do-not-use-devel}"
SRC_URI[x86_64_v2_rust-chardetng+testing-only-no-semver-guarantees-do-not-use-devel.sha256sum] = "7c671ea027c0100c8dc8a386252e53fba67c24789383eb0e467e7582a0e5cb56"

URI_x86_64_v2_rust-chardetng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chardetng-devel-0.1.17-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chardetng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chardetng-devel}"
SRC_URI[x86_64_v2_rust-chardetng-devel.sha256sum] = "210ebde272ee4e887b835e5dff90e74641e3e92a4d5acb874b71766aaeaebe89"

URI_aarch64_rust-chardetng+arrayvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chardetng+arrayvec-devel-0.1.17-6.el10_2.noarch.rpm;name=aarch64_rust-chardetng+arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chardetng+arrayvec-devel}"
SRC_URI[aarch64_rust-chardetng+arrayvec-devel.sha256sum] = "fb683b52df4c4097b062bdaf7c5cb2c6a04ecb7d0a0d854ebbae0db927c154be"

URI_aarch64_rust-chardetng+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chardetng+default-devel-0.1.17-6.el10_2.noarch.rpm;name=aarch64_rust-chardetng+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chardetng+default-devel}"
SRC_URI[aarch64_rust-chardetng+default-devel.sha256sum] = "76b65572da6b5fb6596ab995b7a9784174bfb32c5ba26e22f7bc5c5438231468"

URI_aarch64_rust-chardetng+multithreading-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chardetng+multithreading-devel-0.1.17-6.el10_2.noarch.rpm;name=aarch64_rust-chardetng+multithreading-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chardetng+multithreading-devel}"
SRC_URI[aarch64_rust-chardetng+multithreading-devel.sha256sum] = "992623ea3964f42e637c295ea754b059c7a811fb4d8b6e670e184509a78754bc"

URI_aarch64_rust-chardetng+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chardetng+rayon-devel-0.1.17-6.el10_2.noarch.rpm;name=aarch64_rust-chardetng+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chardetng+rayon-devel}"
SRC_URI[aarch64_rust-chardetng+rayon-devel.sha256sum] = "aef2a28ad3d3ebb185224dc9fe3c28666e9edd195e70634252e3c4a9bb557ff1"

URI_aarch64_rust-chardetng+testing-only-no-semver-guarantees-do-not-use-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chardetng+testing-only-no-semver-guarantees-do-not-use-devel-0.1.17-6.el10_2.noarch.rpm;name=aarch64_rust-chardetng+testing-only-no-semver-guarantees-do-not-use-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chardetng+testing-only-no-semver-guarantees-do-not-use-devel}"
SRC_URI[aarch64_rust-chardetng+testing-only-no-semver-guarantees-do-not-use-devel.sha256sum] = "be7de9acb25efc96b750469ff68731137f7503154854af26f620620bb64e6d9b"

URI_aarch64_rust-chardetng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chardetng-devel-0.1.17-6.el10_2.noarch.rpm;name=aarch64_rust-chardetng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chardetng-devel}"
SRC_URI[aarch64_rust-chardetng-devel.sha256sum] = "4ce673901f0f71add159c6a1f7db66e8fe0d9e7dd7fb3fe9e3b4a6e3ceec53ae"

RDEPENDS:rust-chardetng+arrayvec-devel = " \
 cargo \
 rust-arrayvec+default-devel \
 rust-chardetng-devel \
 "
RDEPENDS:rust-chardetng+default-devel = " \
 cargo \
 rust-chardetng-devel \
 "
RDEPENDS:rust-chardetng+multithreading-devel = " \
 cargo \
 rust-chardetng+arrayvec-devel \
 rust-chardetng+rayon-devel \
 rust-chardetng-devel \
 "
RDEPENDS:rust-chardetng+rayon-devel = " \
 cargo \
 rust-chardetng-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-chardetng+testing-only-no-semver-guarantees-do-not-use-devel = " \
 cargo \
 rust-chardetng-devel \
 "
RDEPENDS:rust-chardetng-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 rust-encoding_rs+alloc-devel \
 rust-encoding_rs-devel \
 rust-memchr-devel \
 "
