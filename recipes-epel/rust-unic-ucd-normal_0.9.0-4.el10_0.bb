# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unic-ucd-normal"
PV = "0.9.0"
PR = "4.el10_0"
PACKAGES = " \
 rust-unic-ucd-normal+default-devel \
 rust-unic-ucd-normal+unic-ucd-category-devel \
 rust-unic-ucd-normal-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unic-ucd-normal-0.9.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "074ea4bc70339957552173ae90d0e04220ce4f1ccc90c3e58916527c5cb8f3e3"

URI_x86_64_v2_rust-unic-ucd-normal+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-ucd-normal+default-devel-0.9.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-ucd-normal+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-ucd-normal+default-devel}"
SRC_URI[x86_64_v2_rust-unic-ucd-normal+default-devel.sha256sum] = "3195b8259b4396943f42f72b694782b24ea03533b2325abe89b9924367385096"

URI_x86_64_v2_rust-unic-ucd-normal+unic-ucd-category-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-ucd-normal+unic-ucd-category-devel-0.9.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-ucd-normal+unic-ucd-category-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-ucd-normal+unic-ucd-category-devel}"
SRC_URI[x86_64_v2_rust-unic-ucd-normal+unic-ucd-category-devel.sha256sum] = "74fc51fdee59df5bb9b459c9c5b8f59d1f13afd377ef093a5076d7126145c8e0"

URI_x86_64_v2_rust-unic-ucd-normal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-ucd-normal-devel-0.9.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-ucd-normal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-ucd-normal-devel}"
SRC_URI[x86_64_v2_rust-unic-ucd-normal-devel.sha256sum] = "8109af8a17a0ac0fafb3bcbec554cb621ca202bda92c4fd1cca1c0d365672514"

URI_aarch64_rust-unic-ucd-normal+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-ucd-normal+default-devel-0.9.0-4.el10_0.noarch.rpm;name=aarch64_rust-unic-ucd-normal+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-ucd-normal+default-devel}"
SRC_URI[aarch64_rust-unic-ucd-normal+default-devel.sha256sum] = "b591327bf31553e690f98a28c23c6db3d0de702e72be14c2c59b53a09a92d972"

URI_aarch64_rust-unic-ucd-normal+unic-ucd-category-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-ucd-normal+unic-ucd-category-devel-0.9.0-4.el10_0.noarch.rpm;name=aarch64_rust-unic-ucd-normal+unic-ucd-category-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-ucd-normal+unic-ucd-category-devel}"
SRC_URI[aarch64_rust-unic-ucd-normal+unic-ucd-category-devel.sha256sum] = "3b0362f6c9ad4a0675b2974d6931256a5b68d30d8610f509122d48777381a0d6"

URI_aarch64_rust-unic-ucd-normal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-ucd-normal-devel-0.9.0-4.el10_0.noarch.rpm;name=aarch64_rust-unic-ucd-normal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-ucd-normal-devel}"
SRC_URI[aarch64_rust-unic-ucd-normal-devel.sha256sum] = "86ab6e7c95988472c047e603b2a0b98b3ad875244a372daa124efa4d46872f89"

RDEPENDS:rust-unic-ucd-normal+default-devel = " \
 cargo \
 rust-unic-ucd-normal-devel \
 "
RDEPENDS:rust-unic-ucd-normal+unic-ucd-category-devel = " \
 cargo \
 rust-unic-ucd-category+default-devel \
 rust-unic-ucd-normal-devel \
 "
RDEPENDS:rust-unic-ucd-normal-devel = " \
 cargo \
 rust-unic-char-property+default-devel \
 rust-unic-char-range+default-devel \
 rust-unic-ucd-hangul+default-devel \
 rust-unic-ucd-version+default-devel \
 "
