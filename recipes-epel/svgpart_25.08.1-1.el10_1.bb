# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "svgpart"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 svgpart \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/svgpart-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6df2add7a836d2e9586b3d02244fad8a98242e623b03e920dbfa3e533acb9b74"

URI_x86_64_v2_svgpart = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/svgpart-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_svgpart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_svgpart}"
SRC_URI[x86_64_v2_svgpart.sha256sum] = "688b72f6904d8f87f93cd7b7c4dbec587acc6d3df9c07a8c255d37bc76c7632d"

URI_aarch64_svgpart = "${EPEL_MIRROR}/aarch64/Packages/s/svgpart-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_svgpart;unpack=0"
SRC_URI:append = " ${URI_aarch64_svgpart}"
SRC_URI[aarch64_svgpart.sha256sum] = "bad3ce9537839464289e0cb2016c7000854fc3b8a143f22b7a98bccc8c609c59"

RDEPENDS:svgpart = " \
 glibc \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kparts \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
