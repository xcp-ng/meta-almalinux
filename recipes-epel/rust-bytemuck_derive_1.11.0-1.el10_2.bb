# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bytemuck_derive"
PV = "1.11.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-bytemuck_derive+default-devel \
 rust-bytemuck_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bytemuck_derive-1.11.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "41d58b7ae5d67f19a53dad72e66b211999073e39d1b089bea67463c9b5d04bd8"

URI_x86_64_v2_rust-bytemuck_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck_derive+default-devel-1.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck_derive+default-devel}"
SRC_URI[x86_64_v2_rust-bytemuck_derive+default-devel.sha256sum] = "5327ce8c043133470ed83876ef44cd5b8cc99bf5117f0f9c15b7c912a388edc4"

URI_x86_64_v2_rust-bytemuck_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck_derive-devel-1.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck_derive-devel}"
SRC_URI[x86_64_v2_rust-bytemuck_derive-devel.sha256sum] = "fca49b73da0d76615ba77d9feb3c26f42b2fe7e7b0cd79af5c41d11d0b1ee86a"

URI_aarch64_rust-bytemuck_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck_derive+default-devel-1.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-bytemuck_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck_derive+default-devel}"
SRC_URI[aarch64_rust-bytemuck_derive+default-devel.sha256sum] = "8c75903a6d8e4100ec4e5951da88acaf8a997b8106682ea4eb9663bad73c711e"

URI_aarch64_rust-bytemuck_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck_derive-devel-1.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-bytemuck_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck_derive-devel}"
SRC_URI[aarch64_rust-bytemuck_derive-devel.sha256sum] = "dac1238d8ea3974ed71a8b69db5b53fac067e1cb3761a96b35b3e0c5ef88804c"

RDEPENDS:rust-bytemuck_derive+default-devel = " \
 cargo \
 rust-bytemuck_derive-devel \
 "
RDEPENDS:rust-bytemuck_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
