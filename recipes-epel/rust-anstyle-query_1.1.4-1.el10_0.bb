# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-anstyle-query"
PV = "1.1.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-anstyle-query+default-devel \
 rust-anstyle-query-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-anstyle-query-1.1.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c8594b31eb4eefdbd8ed57398d5ee0fb2f7eb0c1f02877ddcf3b8314d9a212dc"

URI_x86_64_v2_rust-anstyle-query+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-query+default-devel-1.1.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-query+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-query+default-devel}"
SRC_URI[x86_64_v2_rust-anstyle-query+default-devel.sha256sum] = "c00172f8f5630c56380bfa9506e910b55c84fa24ef23d30fc6b8ad4f704b7c6f"

URI_x86_64_v2_rust-anstyle-query-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-query-devel-1.1.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-query-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-query-devel}"
SRC_URI[x86_64_v2_rust-anstyle-query-devel.sha256sum] = "160fe9446db024f54283b7adc3ea0179ccbbf7d0d3269c9177ab96c591ed7a3a"

URI_aarch64_rust-anstyle-query+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-query+default-devel-1.1.4-1.el10_0.noarch.rpm;name=aarch64_rust-anstyle-query+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-query+default-devel}"
SRC_URI[aarch64_rust-anstyle-query+default-devel.sha256sum] = "73f27175743acc0f00ffb9b100162db17a87a7c1d7c9686242844090a8bed8c9"

URI_aarch64_rust-anstyle-query-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-query-devel-1.1.4-1.el10_0.noarch.rpm;name=aarch64_rust-anstyle-query-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-query-devel}"
SRC_URI[aarch64_rust-anstyle-query-devel.sha256sum] = "6fc01e550fe31d5035ba88f941469877d4d993782395e1e8e0558f9a98c2998b"

RDEPENDS:rust-anstyle-query+default-devel = " \
 cargo \
 rust-anstyle-query-devel \
 "
RDEPENDS:rust-anstyle-query-devel = " \
 cargo \
 rust \
 "
