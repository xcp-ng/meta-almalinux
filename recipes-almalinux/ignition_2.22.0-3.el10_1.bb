# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ignition"
PV = "2.22.0"
PR = "3.el10_1"
PACKAGES = " \
 ignition \
 ignition-edge \
 ignition-grub \
 ignition-validate \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ignition-2.22.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c2d64ff5d359dd51a619a997f183ea3fd2a6d1d0387ff97628f77487edba900"

URI_x86_64_v2_ignition = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ignition-2.22.0-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_ignition;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ignition}"
SRC_URI[x86_64_v2_ignition.sha256sum] = "5b72c14394e17b13e864c455817c2d87f3cac7f3879bf562d9921272a283e389"

URI_x86_64_v2_ignition-edge = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ignition-edge-2.22.0-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_ignition-edge;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ignition-edge}"
SRC_URI[x86_64_v2_ignition-edge.sha256sum] = "30167bd6d2c6ae5cf12be213dec5acc833155f2192213227b3a4745d9ae81829"

URI_x86_64_v2_ignition-grub = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ignition-grub-2.22.0-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_ignition-grub;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ignition-grub}"
SRC_URI[x86_64_v2_ignition-grub.sha256sum] = "0ebab7aa080db4f62def9b120d4fd7dd68db2d1332e342f7f9af116899427e04"

URI_x86_64_v2_ignition-validate = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ignition-validate-2.22.0-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_ignition-validate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ignition-validate}"
SRC_URI[x86_64_v2_ignition-validate.sha256sum] = "d50a266ade667b01c8f22c8d183ab4f2c7895261d147b3ae50db458dc6761230"

URI_aarch64_ignition = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ignition-2.22.0-3.el10_1.aarch64.rpm;name=aarch64_ignition;unpack=0"
SRC_URI:append = " ${URI_aarch64_ignition}"
SRC_URI[aarch64_ignition.sha256sum] = "5bee7cfa38d867062246af1ecd8e38ceaabd40eb0a91ccf6e42f53894bcfc0ef"

URI_aarch64_ignition-edge = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ignition-edge-2.22.0-3.el10_1.aarch64.rpm;name=aarch64_ignition-edge;unpack=0"
SRC_URI:append = " ${URI_aarch64_ignition-edge}"
SRC_URI[aarch64_ignition-edge.sha256sum] = "325c90f26f4617b3282dd87345ba91539e58fb34f55e6b618af3f1a532f034b6"

URI_aarch64_ignition-grub = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ignition-grub-2.22.0-3.el10_1.aarch64.rpm;name=aarch64_ignition-grub;unpack=0"
SRC_URI:append = " ${URI_aarch64_ignition-grub}"
SRC_URI[aarch64_ignition-grub.sha256sum] = "951cf28b1c270725009e5289e4c8b44e5b58b9162089bb53e52cbdd58318fa67"

URI_aarch64_ignition-validate = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ignition-validate-2.22.0-3.el10_1.aarch64.rpm;name=aarch64_ignition-validate;unpack=0"
SRC_URI:append = " ${URI_aarch64_ignition-validate}"
SRC_URI[aarch64_ignition-validate.sha256sum] = "9c9e0d3ca5478baeda947fe8844b03f1dc44cc9172a616fccb407f726de53d0c"

RDEPENDS:ignition = " \
 bash \
 dosfstools \
 dracut \
 dracut-network \
 glibc \
 libblkid \
 libgcc \
 libstdc++ \
 libuuid \
 popt \
 "
RDEPENDS:ignition-edge = " \
 bash \
 "
RDEPENDS:ignition-grub = " \
 "
RDEPENDS:ignition-validate = " \
 glibc \
 "
