# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libtest-mimic"
PV = "0.8.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-libtest-mimic+default-devel \
 rust-libtest-mimic-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libtest-mimic-0.8.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a11a2dbae06e42cbb141c57adef0cb9a20b394d71dbd597144901fbf22ffe0bb"

URI_x86_64_v2_rust-libtest-mimic+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libtest-mimic+default-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libtest-mimic+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libtest-mimic+default-devel}"
SRC_URI[x86_64_v2_rust-libtest-mimic+default-devel.sha256sum] = "bfe97ecc04e8d98645d437ce59e01694eb89853694d6dbf053fd6f522bcf8940"

URI_x86_64_v2_rust-libtest-mimic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libtest-mimic-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libtest-mimic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libtest-mimic-devel}"
SRC_URI[x86_64_v2_rust-libtest-mimic-devel.sha256sum] = "f69da575212aacd9db525aa3dd35b5c7376125110e42c865cbf806935a329940"

URI_aarch64_rust-libtest-mimic+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libtest-mimic+default-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-libtest-mimic+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libtest-mimic+default-devel}"
SRC_URI[aarch64_rust-libtest-mimic+default-devel.sha256sum] = "8870c751eb1132d2fc8cf01d78a4861bf41dd7f513f7a83359b2beffa48cbbf5"

URI_aarch64_rust-libtest-mimic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libtest-mimic-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-libtest-mimic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libtest-mimic-devel}"
SRC_URI[aarch64_rust-libtest-mimic-devel.sha256sum] = "47706cef737ccd946b6d75dd163466777257bbb3709c1d3f2cf039f38559dcf1"

RDEPENDS:rust-libtest-mimic+default-devel = " \
 cargo \
 rust-libtest-mimic-devel \
 "
RDEPENDS:rust-libtest-mimic-devel = " \
 cargo \
 rust \
 rust-anstream+default-devel \
 rust-anstyle+default-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-escape8259+default-devel \
 "
