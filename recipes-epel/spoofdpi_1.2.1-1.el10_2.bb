# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "spoofdpi"
PV = "1.2.1"
PR = "1.el10_2"
PACKAGES = " \
 spoofdpi \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/spoofdpi-1.2.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3be2f153cf038a5c086d986a15188d9f47340410b557026b191daccd0c7ef2d2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/spoofdpi-1.2.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_spoofdpi;unpack=0"
SRC_URI[x86_64_v2_spoofdpi.sha256sum] = "6fbfd5c10012332651db4c18df552b704a8b2b47e4d29319459b7c69319245c3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/spoofdpi-1.2.1-1.el10_2.aarch64.rpm;name=aarch64_spoofdpi;unpack=0"
SRC_URI[aarch64_spoofdpi.sha256sum] = "699a6fc477efec417e18a057b3318bedccececf590e4aa4b00e3056737e9911c"

RDEPENDS:spoofdpi = " \
 glibc \
 libpcap \
 "
