# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_cbor"
PV = "0.11.2"
PR = "8.el10_0"
PACKAGES = " \
 rust-serde_cbor+alloc-devel \
 rust-serde_cbor+default-devel \
 rust-serde_cbor+std-devel \
 rust-serde_cbor+tags-devel \
 rust-serde_cbor+unsealed_read_write-devel \
 rust-serde_cbor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_cbor-0.11.2-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0fa9ff2e39eb27896f13b5718a29fe48a2525f48d7e4dd6b4ffdb363f155708"

URI_x86_64_v2_rust-serde_cbor+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_cbor+alloc-devel-0.11.2-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_cbor+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_cbor+alloc-devel}"
SRC_URI[x86_64_v2_rust-serde_cbor+alloc-devel.sha256sum] = "5123b0ba95cdcdc2c8bd8884bd5e0ef0b35059fd3030ee0ffee6d20ef8a81512"

URI_x86_64_v2_rust-serde_cbor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_cbor+default-devel-0.11.2-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_cbor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_cbor+default-devel}"
SRC_URI[x86_64_v2_rust-serde_cbor+default-devel.sha256sum] = "bc9ad93d19db2ec8281a679148dca05e1b4049a07729411bc793a0c34892b1f3"

URI_x86_64_v2_rust-serde_cbor+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_cbor+std-devel-0.11.2-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_cbor+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_cbor+std-devel}"
SRC_URI[x86_64_v2_rust-serde_cbor+std-devel.sha256sum] = "ba12ebbaef8a62c80f5fd110c035e9a7a63824abae1d0fb4695325bf36878240"

URI_x86_64_v2_rust-serde_cbor+tags-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_cbor+tags-devel-0.11.2-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_cbor+tags-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_cbor+tags-devel}"
SRC_URI[x86_64_v2_rust-serde_cbor+tags-devel.sha256sum] = "2b0b17e0ae7bb2d90654ebf5a1791de9b5f98f4d4ef6ed644553c234ffe0c35c"

URI_x86_64_v2_rust-serde_cbor+unsealed_read_write-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_cbor+unsealed_read_write-devel-0.11.2-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_cbor+unsealed_read_write-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_cbor+unsealed_read_write-devel}"
SRC_URI[x86_64_v2_rust-serde_cbor+unsealed_read_write-devel.sha256sum] = "4541e9eb440cd678376109c9c029247f69ad3308b9c08b74c3922979e104de8a"

URI_x86_64_v2_rust-serde_cbor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_cbor-devel-0.11.2-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_cbor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_cbor-devel}"
SRC_URI[x86_64_v2_rust-serde_cbor-devel.sha256sum] = "08038fbd5a0640e8efa86365508bdf9dbf81771c90cc5efaf1824e9af2981813"

URI_aarch64_rust-serde_cbor+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_cbor+alloc-devel-0.11.2-8.el10_0.noarch.rpm;name=aarch64_rust-serde_cbor+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_cbor+alloc-devel}"
SRC_URI[aarch64_rust-serde_cbor+alloc-devel.sha256sum] = "5e9b39446e40f665a1810e4d4e497608d31f2ba3bb78da3318118e644ae877eb"

URI_aarch64_rust-serde_cbor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_cbor+default-devel-0.11.2-8.el10_0.noarch.rpm;name=aarch64_rust-serde_cbor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_cbor+default-devel}"
SRC_URI[aarch64_rust-serde_cbor+default-devel.sha256sum] = "68026716646ad199bfb44b4af430bb6a6c486d8a6b846851cd9653ec2b63dff1"

URI_aarch64_rust-serde_cbor+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_cbor+std-devel-0.11.2-8.el10_0.noarch.rpm;name=aarch64_rust-serde_cbor+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_cbor+std-devel}"
SRC_URI[aarch64_rust-serde_cbor+std-devel.sha256sum] = "938983b8202cd49ed0354588d6d54db769b1779772df9a7dc3a483c13d13691d"

URI_aarch64_rust-serde_cbor+tags-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_cbor+tags-devel-0.11.2-8.el10_0.noarch.rpm;name=aarch64_rust-serde_cbor+tags-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_cbor+tags-devel}"
SRC_URI[aarch64_rust-serde_cbor+tags-devel.sha256sum] = "3448a4a56e191f932dd428c90e31d0aec043ef34c44c980e426fa064240f444f"

URI_aarch64_rust-serde_cbor+unsealed_read_write-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_cbor+unsealed_read_write-devel-0.11.2-8.el10_0.noarch.rpm;name=aarch64_rust-serde_cbor+unsealed_read_write-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_cbor+unsealed_read_write-devel}"
SRC_URI[aarch64_rust-serde_cbor+unsealed_read_write-devel.sha256sum] = "d8d5505c38a8ee1c9c7577718dea4e3fb15be9ef7a2a4789b14568b02ed5bdf3"

URI_aarch64_rust-serde_cbor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_cbor-devel-0.11.2-8.el10_0.noarch.rpm;name=aarch64_rust-serde_cbor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_cbor-devel}"
SRC_URI[aarch64_rust-serde_cbor-devel.sha256sum] = "faf13bc6f8c4e3c215523b27ad22fbacf646b0ab2419ea186415c11715a02e6a"

RDEPENDS:rust-serde_cbor+alloc-devel = " \
 cargo \
 rust-serde+alloc-devel \
 rust-serde_cbor-devel \
 "
RDEPENDS:rust-serde_cbor+default-devel = " \
 cargo \
 rust-serde_cbor+std-devel \
 rust-serde_cbor-devel \
 "
RDEPENDS:rust-serde_cbor+std-devel = " \
 cargo \
 rust-serde+std-devel \
 rust-serde_cbor-devel \
 "
RDEPENDS:rust-serde_cbor+tags-devel = " \
 cargo \
 rust-serde_cbor-devel \
 "
RDEPENDS:rust-serde_cbor+unsealed_read_write-devel = " \
 cargo \
 rust-serde_cbor-devel \
 "
RDEPENDS:rust-serde_cbor-devel = " \
 cargo \
 rust-half1+default-devel \
 rust-serde-devel \
 "
