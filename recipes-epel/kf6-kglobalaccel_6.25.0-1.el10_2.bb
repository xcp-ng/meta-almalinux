# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kglobalaccel"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kglobalaccel \
 kf6-kglobalaccel-devel \
 kf6-kglobalaccel-doc \
 kf6-kglobalaccel-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kglobalaccel-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c17b4d705aaf98de630eee62c474ad83f4f0f4c359b9e853f315a7bb96aa9ed"

URI_x86_64_v2_kf6-kglobalaccel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kglobalaccel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kglobalaccel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kglobalaccel}"
SRC_URI[x86_64_v2_kf6-kglobalaccel.sha256sum] = "c5da923dcff481da8587d0853e4732cccf60d4c193ad0f83643f054717e523b7"

URI_x86_64_v2_kf6-kglobalaccel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kglobalaccel-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kglobalaccel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kglobalaccel-devel}"
SRC_URI[x86_64_v2_kf6-kglobalaccel-devel.sha256sum] = "5054c60f77abf3e3e3be3015937e2177bcc53918a70e1a96ffd13924e2d06642"

URI_x86_64_v2_kf6-kglobalaccel-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kglobalaccel-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kglobalaccel-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kglobalaccel-doc}"
SRC_URI[x86_64_v2_kf6-kglobalaccel-doc.sha256sum] = "c78552c5968edc887f0e1694d8a6e3e97968d8eb7bc78146ef0265fd064dcf8a"

URI_x86_64_v2_kf6-kglobalaccel-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kglobalaccel-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kglobalaccel-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kglobalaccel-html}"
SRC_URI[x86_64_v2_kf6-kglobalaccel-html.sha256sum] = "e1bc44eb3260ecbb8585af87a9486fd349f3e1367f0c4571f32a87717f2d4f28"

URI_aarch64_kf6-kglobalaccel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kglobalaccel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kglobalaccel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kglobalaccel}"
SRC_URI[aarch64_kf6-kglobalaccel.sha256sum] = "2d2a241d64c2959a3fdc7b8c18afa36a38713f40d2ae2e5af6039e95a317836b"

URI_aarch64_kf6-kglobalaccel-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kglobalaccel-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kglobalaccel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kglobalaccel-devel}"
SRC_URI[aarch64_kf6-kglobalaccel-devel.sha256sum] = "35f21bc6d2e6ce399f307d443a880ee1fca4423251de65cd431c92f6adaa4ce6"

URI_aarch64_kf6-kglobalaccel-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kglobalaccel-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kglobalaccel-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kglobalaccel-doc}"
SRC_URI[aarch64_kf6-kglobalaccel-doc.sha256sum] = "88b0b2ae6b69fc542597ea8c1bf06225ebf0c620e272f686e98eba5470f44c82"

URI_aarch64_kf6-kglobalaccel-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kglobalaccel-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kglobalaccel-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kglobalaccel-html}"
SRC_URI[aarch64_kf6-kglobalaccel-html.sha256sum] = "04d8dcd2d2e46344335c8c471d02894fe83c39d07a392125bf629c7f7aec04e8"

RDEPENDS:kf6-kglobalaccel = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kglobalaccel-devel = " \
 cmake-filesystem \
 kf6-kglobalaccel \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kglobalaccel-doc = " \
 "
RDEPENDS:kf6-kglobalaccel-html = " \
 "
