# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio-macros"
PV = "2.7.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-tokio-macros+default-devel \
 rust-tokio-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-macros-2.7.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1de91fb60c52a7ea263c83a4a9751b310365900a89926b91efe36fd20c0c3e12"

URI_x86_64_v2_rust-tokio-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-macros+default-devel-2.7.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-macros+default-devel}"
SRC_URI[x86_64_v2_rust-tokio-macros+default-devel.sha256sum] = "85f25827b1f0e38d1975e47dda94eaa811166675a3c0f1afb7cb3707ff62f7a6"

URI_x86_64_v2_rust-tokio-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-macros-devel-2.7.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-macros-devel}"
SRC_URI[x86_64_v2_rust-tokio-macros-devel.sha256sum] = "b5a362d1e48c5538e0de0209c34acb1dd5bf1160cd183c078e54c9aebdbc8a5f"

URI_aarch64_rust-tokio-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-macros+default-devel-2.7.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-macros+default-devel}"
SRC_URI[aarch64_rust-tokio-macros+default-devel.sha256sum] = "d3903c1fd3e134c92119025caf041c75fecb6e343fdb363426a49fc645e157fa"

URI_aarch64_rust-tokio-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-macros-devel-2.7.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-macros-devel}"
SRC_URI[aarch64_rust-tokio-macros-devel.sha256sum] = "3231907cb2c7ed525cdd281fd1832e436832b9906f3b56efc16408084ba4f7c8"

RDEPENDS:rust-tokio-macros+default-devel = " \
 cargo \
 rust-tokio-macros-devel \
 "
RDEPENDS:rust-tokio-macros-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
