# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustix0.38"
PV = "0.38.44"
PR = "1.el10_1"
PACKAGES = " \
 rust-rustix0.38+all-apis-devel \
 rust-rustix0.38+alloc-devel \
 rust-rustix0.38+cc-devel \
 rust-rustix0.38+default-devel \
 rust-rustix0.38+event-devel \
 rust-rustix0.38+fs-devel \
 rust-rustix0.38+io_uring-devel \
 rust-rustix0.38+itoa-devel \
 rust-rustix0.38+libc-devel \
 rust-rustix0.38+libc-extra-traits-devel \
 rust-rustix0.38+libc_errno-devel \
 rust-rustix0.38+linux_4_11-devel \
 rust-rustix0.38+linux_latest-devel \
 rust-rustix0.38+mm-devel \
 rust-rustix0.38+mount-devel \
 rust-rustix0.38+net-devel \
 rust-rustix0.38+once_cell-devel \
 rust-rustix0.38+param-devel \
 rust-rustix0.38+pipe-devel \
 rust-rustix0.38+process-devel \
 rust-rustix0.38+procfs-devel \
 rust-rustix0.38+pty-devel \
 rust-rustix0.38+rand-devel \
 rust-rustix0.38+runtime-devel \
 rust-rustix0.38+shm-devel \
 rust-rustix0.38+std-devel \
 rust-rustix0.38+stdio-devel \
 rust-rustix0.38+system-devel \
 rust-rustix0.38+termios-devel \
 rust-rustix0.38+thread-devel \
 rust-rustix0.38+time-devel \
 rust-rustix0.38+try_close-devel \
 rust-rustix0.38+use-explicitly-provided-auxv-devel \
 rust-rustix0.38+use-libc-auxv-devel \
 rust-rustix0.38+use-libc-devel \
 rust-rustix0.38-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustix0.38-0.38.44-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "34c2968dff1949188ad6190e54a0b46f832dae6c2177c4a889162d674a886c2e"

URI_x86_64_v2_rust-rustix0.38+all-apis-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+all-apis-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+all-apis-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+all-apis-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+all-apis-devel.sha256sum] = "ee1a602444a8f53c7400cad00d3440247c3d8e792a4d939ef890099583dac2c8"

URI_x86_64_v2_rust-rustix0.38+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+alloc-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+alloc-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+alloc-devel.sha256sum] = "69d9e8fa463c45ee0f64d8c3114f93963940565d2e2cbe06da9772b07aa35931"

URI_x86_64_v2_rust-rustix0.38+cc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+cc-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+cc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+cc-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+cc-devel.sha256sum] = "042a3b180793eceaa45a19fa55ac636228535776360d1bd82a8cc438a1655c7d"

URI_x86_64_v2_rust-rustix0.38+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+default-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+default-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+default-devel.sha256sum] = "38361529277ed6de30e06916886e11488da20374770e1e0bb1a7d2999ed84162"

URI_x86_64_v2_rust-rustix0.38+event-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+event-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+event-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+event-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+event-devel.sha256sum] = "dbd6d82f90c717edbf275c444c64a9ab144f0f1bf1bd0d031123626f7ea3d696"

URI_x86_64_v2_rust-rustix0.38+fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+fs-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+fs-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+fs-devel.sha256sum] = "64183b48179e47772cedaecb0655d231f455785ca05fee65c7e9a136f4dd5794"

URI_x86_64_v2_rust-rustix0.38+io_uring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+io_uring-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+io_uring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+io_uring-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+io_uring-devel.sha256sum] = "fa85f7525a54873df2244bb403ca63d19f674c740a0b78c4f45d1a7a89127917"

URI_x86_64_v2_rust-rustix0.38+itoa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+itoa-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+itoa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+itoa-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+itoa-devel.sha256sum] = "014d52e1537187de7003094a61ab22c07f9ee091cd4e761ecabd6b1c200207a4"

URI_x86_64_v2_rust-rustix0.38+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+libc-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+libc-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+libc-devel.sha256sum] = "860a8ea49f17f8903fc2b62a866ce6e1c02a22508eafaf603e7eb5153c1dbf3b"

URI_x86_64_v2_rust-rustix0.38+libc-extra-traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+libc-extra-traits-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+libc-extra-traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+libc-extra-traits-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+libc-extra-traits-devel.sha256sum] = "e7a64b518c4fa38b1689274d083dd7a3ee1cce76800b84c12b60e7f6460121a7"

URI_x86_64_v2_rust-rustix0.38+libc_errno-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+libc_errno-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+libc_errno-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+libc_errno-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+libc_errno-devel.sha256sum] = "590a20a331e18f10548cbad1179c965566a6021e1774e1b06c1174676c470512"

URI_x86_64_v2_rust-rustix0.38+linux_4_11-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+linux_4_11-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+linux_4_11-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+linux_4_11-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+linux_4_11-devel.sha256sum] = "de3a9beba3ecd03fd54d7954861c6d0d1dfbcab3abeb20ebcc1eb95063f0eddf"

URI_x86_64_v2_rust-rustix0.38+linux_latest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+linux_latest-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+linux_latest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+linux_latest-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+linux_latest-devel.sha256sum] = "a0ec9ff542a81951cf31e636995dc55503f26cfd5247e6e211bef86ff436c42f"

URI_x86_64_v2_rust-rustix0.38+mm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+mm-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+mm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+mm-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+mm-devel.sha256sum] = "44684ccd3158b27d780a3a6f14e3660d7ceadcf022c21f7a161d4a86bd5bd344"

URI_x86_64_v2_rust-rustix0.38+mount-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+mount-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+mount-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+mount-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+mount-devel.sha256sum] = "1ea5f6e533befe9fed20d3ee787f196755c18ad0a6f58806df301ffa295baa8f"

URI_x86_64_v2_rust-rustix0.38+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+net-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+net-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+net-devel.sha256sum] = "ee3b43a583d6907574f404a8902d90379f6cc069dad25c104508309a23461e78"

URI_x86_64_v2_rust-rustix0.38+once_cell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+once_cell-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+once_cell-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+once_cell-devel.sha256sum] = "0b18d78d3a56863ef4ed055de3376ed667da52935c306add73c1fc14657d0cdc"

URI_x86_64_v2_rust-rustix0.38+param-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+param-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+param-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+param-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+param-devel.sha256sum] = "18d9971b229467e41f250caaaa6c59cf611d67366b3b7fc9ddeac7aacfa9a9ac"

URI_x86_64_v2_rust-rustix0.38+pipe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+pipe-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+pipe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+pipe-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+pipe-devel.sha256sum] = "e4e2e91a1b6a02b3089cfcc8847bda3d200e00ebf116a567bacd7c29b2bd694c"

URI_x86_64_v2_rust-rustix0.38+process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+process-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+process-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+process-devel.sha256sum] = "789f7a4734fdbb2e1f972a6c4197ee40151b0a7fd1e8d6c63b490b97fd5b7f56"

URI_x86_64_v2_rust-rustix0.38+procfs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+procfs-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+procfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+procfs-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+procfs-devel.sha256sum] = "786fb0470d68b8790ba618ef41a06f16ba38f1a464532d13c561a6f01f88d2f9"

URI_x86_64_v2_rust-rustix0.38+pty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+pty-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+pty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+pty-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+pty-devel.sha256sum] = "f02cef58ea28a737032dcb7e8d5f9086a4663af784b7976e331b226045c85ed2"

URI_x86_64_v2_rust-rustix0.38+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+rand-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+rand-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+rand-devel.sha256sum] = "a27e82309e12fb5220966a8f70df129a1f0bf8eab2f25f8ecec05904511549c9"

URI_x86_64_v2_rust-rustix0.38+runtime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+runtime-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+runtime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+runtime-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+runtime-devel.sha256sum] = "dcaba13fb54daceb83fa145be5b0cf834b597d15a17433a5c1fd7fd97867a9c0"

URI_x86_64_v2_rust-rustix0.38+shm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+shm-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+shm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+shm-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+shm-devel.sha256sum] = "b17506fbcfa99c67b875c9a9d7698382b437f4431774684e48d86b27cf89c4a6"

URI_x86_64_v2_rust-rustix0.38+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+std-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+std-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+std-devel.sha256sum] = "547b68024212639164c952f71a035f866322fe948841d6b4814e0ea95bcfd7b1"

URI_x86_64_v2_rust-rustix0.38+stdio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+stdio-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+stdio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+stdio-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+stdio-devel.sha256sum] = "0907bd2dd6a229ebf2c7a276c4c7e0d6eb972b7139bae7d5fa31649d99817a0c"

URI_x86_64_v2_rust-rustix0.38+system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+system-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+system-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+system-devel.sha256sum] = "ad912b131128c7b0217996861885d442d13ccc35604422515cd0e553a004268e"

URI_x86_64_v2_rust-rustix0.38+termios-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+termios-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+termios-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+termios-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+termios-devel.sha256sum] = "f71404c7e618580c84672ab8b35b1b664cf64a010be02cd8f828952f5f768813"

URI_x86_64_v2_rust-rustix0.38+thread-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+thread-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+thread-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+thread-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+thread-devel.sha256sum] = "e008dcfa03a8d18801b9d15ca13ea07768a5614b4450ddcd03da62990196cfbb"

URI_x86_64_v2_rust-rustix0.38+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+time-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+time-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+time-devel.sha256sum] = "fa55e5c37c912f5d80239d2fc51d848d85515d18818a30d708301cb876a058d7"

URI_x86_64_v2_rust-rustix0.38+try_close-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+try_close-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+try_close-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+try_close-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+try_close-devel.sha256sum] = "4a56da50c141547bc2741227b76b3ae069a7245a95d6cc9460a0d81ca568af59"

URI_x86_64_v2_rust-rustix0.38+use-explicitly-provided-auxv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+use-explicitly-provided-auxv-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+use-explicitly-provided-auxv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+use-explicitly-provided-auxv-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+use-explicitly-provided-auxv-devel.sha256sum] = "250966f220d77ce60eeb8dccad9cf2c371919c8cefcd966eff85ef92df8cb60b"

URI_x86_64_v2_rust-rustix0.38+use-libc-auxv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+use-libc-auxv-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+use-libc-auxv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+use-libc-auxv-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+use-libc-auxv-devel.sha256sum] = "71589c553ef87cbc37d6dd61618798553cfeb1dfad65afcdab227e764170a3e2"

URI_x86_64_v2_rust-rustix0.38+use-libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38+use-libc-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38+use-libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38+use-libc-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38+use-libc-devel.sha256sum] = "68e2e7a784eeb9eb94913adbbf42f2704dd142f75e8744d38552ff6e22b93ce6"

URI_x86_64_v2_rust-rustix0.38-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix0.38-devel-0.38.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix0.38-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix0.38-devel}"
SRC_URI[x86_64_v2_rust-rustix0.38-devel.sha256sum] = "59062779a864a766f6d7f943d680aa66ba7c95eec27f21838b9b91012a7eaef2"

URI_aarch64_rust-rustix0.38+all-apis-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+all-apis-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+all-apis-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+all-apis-devel}"
SRC_URI[aarch64_rust-rustix0.38+all-apis-devel.sha256sum] = "e366ef164725bb22e3df92acba739a10eb6a6ac118c99f57e90877b5d1446dc9"

URI_aarch64_rust-rustix0.38+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+alloc-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+alloc-devel}"
SRC_URI[aarch64_rust-rustix0.38+alloc-devel.sha256sum] = "ff4619f9b1c76047f7b4470f6bff93318fec14fefda3b0b80d5aad85c2450c31"

URI_aarch64_rust-rustix0.38+cc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+cc-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+cc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+cc-devel}"
SRC_URI[aarch64_rust-rustix0.38+cc-devel.sha256sum] = "3333471be68f75e3f7ee69ea9963f580496982191f541c73f583506b640365ee"

URI_aarch64_rust-rustix0.38+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+default-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+default-devel}"
SRC_URI[aarch64_rust-rustix0.38+default-devel.sha256sum] = "e0722893fa79bb13fe9f1fe57faa9549c4dded0e9d4689f23aa101882e89e766"

URI_aarch64_rust-rustix0.38+event-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+event-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+event-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+event-devel}"
SRC_URI[aarch64_rust-rustix0.38+event-devel.sha256sum] = "2db7f9229e839d58758424d4d6ff1f1dd56f8a06d1cebf75ba598d593e1b7a31"

URI_aarch64_rust-rustix0.38+fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+fs-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+fs-devel}"
SRC_URI[aarch64_rust-rustix0.38+fs-devel.sha256sum] = "310087e178d11a2233f44a087dfd594b0baae9515c5568b45db9db057f880eee"

URI_aarch64_rust-rustix0.38+io_uring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+io_uring-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+io_uring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+io_uring-devel}"
SRC_URI[aarch64_rust-rustix0.38+io_uring-devel.sha256sum] = "1ad11601b42dcd04e46dfa1e3d6ba5be71c46f275b07b3152c082682ed8e1dfa"

URI_aarch64_rust-rustix0.38+itoa-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+itoa-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+itoa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+itoa-devel}"
SRC_URI[aarch64_rust-rustix0.38+itoa-devel.sha256sum] = "0a66cb32be4f0bbd981bf4698b59ed00a89350c780af1819952ae10eb90ef0aa"

URI_aarch64_rust-rustix0.38+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+libc-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+libc-devel}"
SRC_URI[aarch64_rust-rustix0.38+libc-devel.sha256sum] = "c1b6e21f8f7e37c6171bac3c891e23c28e1c56219152937ff8bd3cedb4651c16"

URI_aarch64_rust-rustix0.38+libc-extra-traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+libc-extra-traits-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+libc-extra-traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+libc-extra-traits-devel}"
SRC_URI[aarch64_rust-rustix0.38+libc-extra-traits-devel.sha256sum] = "216152b56275e1e91d8ed51b6c85edc55dcc7a8385094192df82d7e4f8947b38"

URI_aarch64_rust-rustix0.38+libc_errno-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+libc_errno-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+libc_errno-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+libc_errno-devel}"
SRC_URI[aarch64_rust-rustix0.38+libc_errno-devel.sha256sum] = "e8797111abc01ab196463e2a69de59cd7aca475a297c4f081ea296da35945f61"

URI_aarch64_rust-rustix0.38+linux_4_11-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+linux_4_11-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+linux_4_11-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+linux_4_11-devel}"
SRC_URI[aarch64_rust-rustix0.38+linux_4_11-devel.sha256sum] = "fa6a9e2f9a946b90aae247311b7746b0e073bdcb6db5b7629a32e59687273c27"

URI_aarch64_rust-rustix0.38+linux_latest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+linux_latest-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+linux_latest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+linux_latest-devel}"
SRC_URI[aarch64_rust-rustix0.38+linux_latest-devel.sha256sum] = "198da11083eac7614a01a32bfc80d9b60ad0a60d10122ed195c475612a612a6f"

URI_aarch64_rust-rustix0.38+mm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+mm-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+mm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+mm-devel}"
SRC_URI[aarch64_rust-rustix0.38+mm-devel.sha256sum] = "58e99d1df0e1a8da6402b89638d24e14f1f900bd9f2f0fff54c6412d51db31cf"

URI_aarch64_rust-rustix0.38+mount-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+mount-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+mount-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+mount-devel}"
SRC_URI[aarch64_rust-rustix0.38+mount-devel.sha256sum] = "c2f0603b710ddf1c96a01d59387e3e6a305b9aa194c7ecd590748f5a624a37d2"

URI_aarch64_rust-rustix0.38+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+net-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+net-devel}"
SRC_URI[aarch64_rust-rustix0.38+net-devel.sha256sum] = "b83cc0386be78f63de394b2e226a88fa8c301890bb201a845e87d364d5862ec1"

URI_aarch64_rust-rustix0.38+once_cell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+once_cell-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+once_cell-devel}"
SRC_URI[aarch64_rust-rustix0.38+once_cell-devel.sha256sum] = "d6cb2985108331cdb251197b4499bf515ee7d4c891e39ef3aaad25385d3e67ef"

URI_aarch64_rust-rustix0.38+param-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+param-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+param-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+param-devel}"
SRC_URI[aarch64_rust-rustix0.38+param-devel.sha256sum] = "eac071a96712ff446f4863d0cca5badf8afc492de1fe5747cae85ae6789e434d"

URI_aarch64_rust-rustix0.38+pipe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+pipe-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+pipe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+pipe-devel}"
SRC_URI[aarch64_rust-rustix0.38+pipe-devel.sha256sum] = "6bacc93111373d95c169928527a24a089a9b770e07e0144ecba00caa8f55e7c4"

URI_aarch64_rust-rustix0.38+process-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+process-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+process-devel}"
SRC_URI[aarch64_rust-rustix0.38+process-devel.sha256sum] = "0ca63a9f5056c25b3023d38b93b2bf1075b0c10c30487d5dcbdbedf707b266e2"

URI_aarch64_rust-rustix0.38+procfs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+procfs-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+procfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+procfs-devel}"
SRC_URI[aarch64_rust-rustix0.38+procfs-devel.sha256sum] = "5e5ff9d59dc1f3ebb5a824405840dc5684bd096de9ee6aa51f5af4215a319251"

URI_aarch64_rust-rustix0.38+pty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+pty-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+pty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+pty-devel}"
SRC_URI[aarch64_rust-rustix0.38+pty-devel.sha256sum] = "f06d8efa26352f918f7908ad11e46c1b823d86405754057406711c54c12d7350"

URI_aarch64_rust-rustix0.38+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+rand-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+rand-devel}"
SRC_URI[aarch64_rust-rustix0.38+rand-devel.sha256sum] = "222fde499f944ce1c36869ec9c61e69c1a3aabfaaae699ea933bd9525c05aaa2"

URI_aarch64_rust-rustix0.38+runtime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+runtime-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+runtime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+runtime-devel}"
SRC_URI[aarch64_rust-rustix0.38+runtime-devel.sha256sum] = "de5cbe25f292ab67e0712a53e3f14ca4265171239122547c85a3188b525186ec"

URI_aarch64_rust-rustix0.38+shm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+shm-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+shm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+shm-devel}"
SRC_URI[aarch64_rust-rustix0.38+shm-devel.sha256sum] = "d28092222a1a5b162ef3e09c0fc28e24d5b0441fa76170cf0ce1fbefdb08f939"

URI_aarch64_rust-rustix0.38+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+std-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+std-devel}"
SRC_URI[aarch64_rust-rustix0.38+std-devel.sha256sum] = "41cb12fdfad24f99018e21504678a055b11c78a4babd906f6ad38dd943b599c6"

URI_aarch64_rust-rustix0.38+stdio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+stdio-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+stdio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+stdio-devel}"
SRC_URI[aarch64_rust-rustix0.38+stdio-devel.sha256sum] = "45066287065304b5240b6654d768cbf07a0f2cc9243993dcde8eacf598a90062"

URI_aarch64_rust-rustix0.38+system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+system-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+system-devel}"
SRC_URI[aarch64_rust-rustix0.38+system-devel.sha256sum] = "5dd924ca8c18a9efb0e8d16b6f4cdd3d5c2bdc67c375329578f19c27eaf0b3f4"

URI_aarch64_rust-rustix0.38+termios-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+termios-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+termios-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+termios-devel}"
SRC_URI[aarch64_rust-rustix0.38+termios-devel.sha256sum] = "402d8282bd000e2d207581075bef36f4e3e0bd7e98987521f608224f721f9816"

URI_aarch64_rust-rustix0.38+thread-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+thread-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+thread-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+thread-devel}"
SRC_URI[aarch64_rust-rustix0.38+thread-devel.sha256sum] = "0bbf32a27e2fc0f2573abc4ca7941f3932768d3cb4f441ade937713709caac83"

URI_aarch64_rust-rustix0.38+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+time-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+time-devel}"
SRC_URI[aarch64_rust-rustix0.38+time-devel.sha256sum] = "6a2f870622c9b3a35fc25537d58b6ae64049ab967a8eb9f2977e210284c7eea8"

URI_aarch64_rust-rustix0.38+try_close-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+try_close-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+try_close-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+try_close-devel}"
SRC_URI[aarch64_rust-rustix0.38+try_close-devel.sha256sum] = "27663bc74e53ac0420992822b1f73214a8e23fe943fb96133025484c6a79d89d"

URI_aarch64_rust-rustix0.38+use-explicitly-provided-auxv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+use-explicitly-provided-auxv-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+use-explicitly-provided-auxv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+use-explicitly-provided-auxv-devel}"
SRC_URI[aarch64_rust-rustix0.38+use-explicitly-provided-auxv-devel.sha256sum] = "f0163b2ecf5ffc348e14f12f928d76663cd7bef4c564767af8c024b5d448310a"

URI_aarch64_rust-rustix0.38+use-libc-auxv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+use-libc-auxv-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+use-libc-auxv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+use-libc-auxv-devel}"
SRC_URI[aarch64_rust-rustix0.38+use-libc-auxv-devel.sha256sum] = "4b8119c5c8a845fac4b6e9f444eedc02c3755c6138152248f40d589794df4ef3"

URI_aarch64_rust-rustix0.38+use-libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38+use-libc-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38+use-libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38+use-libc-devel}"
SRC_URI[aarch64_rust-rustix0.38+use-libc-devel.sha256sum] = "2292811b27f7746d2665bc3614b4db48b54afdad764bbb3425165987e6a7a435"

URI_aarch64_rust-rustix0.38-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix0.38-devel-0.38.44-1.el10_1.noarch.rpm;name=aarch64_rust-rustix0.38-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix0.38-devel}"
SRC_URI[aarch64_rust-rustix0.38-devel.sha256sum] = "e58b0c19f63d0773d21ec484ff8bb25211345786adf58a4ffb299696575cc0d7"

RDEPENDS:rust-rustix0.38+all-apis-devel = " \
 cargo \
 rust-rustix0.38+event-devel \
 rust-rustix0.38+fs-devel \
 rust-rustix0.38+io_uring-devel \
 rust-rustix0.38+mm-devel \
 rust-rustix0.38+mount-devel \
 rust-rustix0.38+net-devel \
 rust-rustix0.38+param-devel \
 rust-rustix0.38+pipe-devel \
 rust-rustix0.38+process-devel \
 rust-rustix0.38+procfs-devel \
 rust-rustix0.38+pty-devel \
 rust-rustix0.38+rand-devel \
 rust-rustix0.38+runtime-devel \
 rust-rustix0.38+shm-devel \
 rust-rustix0.38+stdio-devel \
 rust-rustix0.38+system-devel \
 rust-rustix0.38+termios-devel \
 rust-rustix0.38+thread-devel \
 rust-rustix0.38+time-devel \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+alloc-devel = " \
 cargo \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+cc-devel = " \
 cargo \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+default-devel = " \
 cargo \
 rust-rustix0.38+std-devel \
 rust-rustix0.38+use-libc-auxv-devel \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+event-devel = " \
 cargo \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+fs-devel = " \
 cargo \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+io_uring-devel = " \
 cargo \
 rust-linux-raw-sys0.4+io_uring-devel \
 rust-rustix0.38+event-devel \
 rust-rustix0.38+fs-devel \
 rust-rustix0.38+net-devel \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+itoa-devel = " \
 cargo \
 rust-itoa-devel \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+libc-devel = " \
 cargo \
 rust-libc-devel \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+libc-extra-traits-devel = " \
 cargo \
 rust-libc+extra_traits-devel \
 rust-libc-devel \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+libc_errno-devel = " \
 cargo \
 rust-errno-devel \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+linux_4_11-devel = " \
 cargo \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+linux_latest-devel = " \
 cargo \
 rust-rustix0.38+linux_4_11-devel \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+mm-devel = " \
 cargo \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+mount-devel = " \
 cargo \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+net-devel = " \
 cargo \
 rust-linux-raw-sys0.4+if_ether-devel \
 rust-linux-raw-sys0.4+net-devel \
 rust-linux-raw-sys0.4+netlink-devel \
 rust-linux-raw-sys0.4+xdp-devel \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+once_cell-devel = " \
 cargo \
 rust-once_cell+default-devel \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+param-devel = " \
 cargo \
 rust-rustix0.38+fs-devel \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+pipe-devel = " \
 cargo \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+process-devel = " \
 cargo \
 rust-linux-raw-sys0.4+prctl-devel \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+procfs-devel = " \
 cargo \
 rust-rustix0.38+fs-devel \
 rust-rustix0.38+itoa-devel \
 rust-rustix0.38+once_cell-devel \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+pty-devel = " \
 cargo \
 rust-rustix0.38+fs-devel \
 rust-rustix0.38+itoa-devel \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+rand-devel = " \
 cargo \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+runtime-devel = " \
 cargo \
 rust-linux-raw-sys0.4+prctl-devel \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+shm-devel = " \
 cargo \
 rust-rustix0.38+fs-devel \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+std-devel = " \
 cargo \
 rust-bitflags+std-devel \
 rust-errno+std-devel \
 rust-errno-devel \
 rust-libc+std-devel \
 rust-libc-devel \
 rust-rustix0.38+alloc-devel \
 rust-rustix0.38+libc-extra-traits-devel \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+stdio-devel = " \
 cargo \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+system-devel = " \
 cargo \
 rust-linux-raw-sys0.4+system-devel \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+termios-devel = " \
 cargo \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+thread-devel = " \
 cargo \
 rust-linux-raw-sys0.4+prctl-devel \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+time-devel = " \
 cargo \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+try_close-devel = " \
 cargo \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+use-explicitly-provided-auxv-devel = " \
 cargo \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+use-libc-auxv-devel = " \
 cargo \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38+use-libc-devel = " \
 cargo \
 rust-rustix0.38+libc-devel \
 rust-rustix0.38+libc-extra-traits-devel \
 rust-rustix0.38+libc_errno-devel \
 rust-rustix0.38-devel \
 "
RDEPENDS:rust-rustix0.38-devel = " \
 cargo \
 rust \
 rust-bitflags-devel \
 rust-errno-devel \
 rust-libc-devel \
 rust-linux-raw-sys0.4+elf-devel \
 rust-linux-raw-sys0.4+errno-devel \
 rust-linux-raw-sys0.4+general-devel \
 rust-linux-raw-sys0.4+ioctl-devel \
 rust-linux-raw-sys0.4+no_std-devel \
 rust-linux-raw-sys0.4-devel \
 "
