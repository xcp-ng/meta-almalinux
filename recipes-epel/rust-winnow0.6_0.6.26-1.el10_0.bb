# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-winnow0.6"
PV = "0.6.26"
PR = "1.el10_0"
PACKAGES = " \
 rust-winnow0.6+alloc-devel \
 rust-winnow0.6+debug-devel \
 rust-winnow0.6+default-devel \
 rust-winnow0.6+simd-devel \
 rust-winnow0.6+std-devel \
 rust-winnow0.6+unstable-doc-devel \
 rust-winnow0.6+unstable-recover-devel \
 rust-winnow0.6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-winnow0.6-0.6.26-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b32b18cda2a7f62682cbbdd426ed057e5a17388c84fea6bab169fee1127339b3"

URI_x86_64_v2_rust-winnow0.6+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow0.6+alloc-devel-0.6.26-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow0.6+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow0.6+alloc-devel}"
SRC_URI[x86_64_v2_rust-winnow0.6+alloc-devel.sha256sum] = "d955555216c1aa8b4c67d20806dfa15f699b139705a6dddf358f35536c92b850"

URI_x86_64_v2_rust-winnow0.6+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow0.6+debug-devel-0.6.26-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow0.6+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow0.6+debug-devel}"
SRC_URI[x86_64_v2_rust-winnow0.6+debug-devel.sha256sum] = "9d24ea46b9e1dc939be6d75560f16314d7d89277196958355b8e97dd1028d827"

URI_x86_64_v2_rust-winnow0.6+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow0.6+default-devel-0.6.26-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow0.6+default-devel}"
SRC_URI[x86_64_v2_rust-winnow0.6+default-devel.sha256sum] = "bef479eea3a965044e2eaca03de4751d59d68ea729ae36bb0f32e8717262aa01"

URI_x86_64_v2_rust-winnow0.6+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow0.6+simd-devel-0.6.26-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow0.6+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow0.6+simd-devel}"
SRC_URI[x86_64_v2_rust-winnow0.6+simd-devel.sha256sum] = "010378c20b701d0b57d0e4569323a937076e8d8b10cb9422742323afbe34673b"

URI_x86_64_v2_rust-winnow0.6+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow0.6+std-devel-0.6.26-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow0.6+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow0.6+std-devel}"
SRC_URI[x86_64_v2_rust-winnow0.6+std-devel.sha256sum] = "254e9644c95efb8cce7210034b1f031820ab4eb2e8b39f96f9319592725c67b4"

URI_x86_64_v2_rust-winnow0.6+unstable-doc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow0.6+unstable-doc-devel-0.6.26-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow0.6+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow0.6+unstable-doc-devel}"
SRC_URI[x86_64_v2_rust-winnow0.6+unstable-doc-devel.sha256sum] = "1f1e4e43154df9b277b1f6849e673f48c44c0351fa2913c462e17618aaec2f6d"

URI_x86_64_v2_rust-winnow0.6+unstable-recover-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow0.6+unstable-recover-devel-0.6.26-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow0.6+unstable-recover-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow0.6+unstable-recover-devel}"
SRC_URI[x86_64_v2_rust-winnow0.6+unstable-recover-devel.sha256sum] = "5bb9f361d731d4903f190551a01b85a650ed3cd6b95bd6b88ba58c6de14ac3bb"

URI_x86_64_v2_rust-winnow0.6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow0.6-devel-0.6.26-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow0.6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow0.6-devel}"
SRC_URI[x86_64_v2_rust-winnow0.6-devel.sha256sum] = "5c6375267ce2fdfa2e9cc7cc32f4b6e080f59ea3a28484361f34848fb8fcb2b8"

URI_aarch64_rust-winnow0.6+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow0.6+alloc-devel-0.6.26-1.el10_0.noarch.rpm;name=aarch64_rust-winnow0.6+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow0.6+alloc-devel}"
SRC_URI[aarch64_rust-winnow0.6+alloc-devel.sha256sum] = "cfccb5561dbeb4c32a90145b0a04b63b66e7d3bdff624bed361bd0ff3526248d"

URI_aarch64_rust-winnow0.6+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow0.6+debug-devel-0.6.26-1.el10_0.noarch.rpm;name=aarch64_rust-winnow0.6+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow0.6+debug-devel}"
SRC_URI[aarch64_rust-winnow0.6+debug-devel.sha256sum] = "fc55a8ae9a414f290e7417803602c08475f802682040dc752b01fc99f5efde47"

URI_aarch64_rust-winnow0.6+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow0.6+default-devel-0.6.26-1.el10_0.noarch.rpm;name=aarch64_rust-winnow0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow0.6+default-devel}"
SRC_URI[aarch64_rust-winnow0.6+default-devel.sha256sum] = "405fe363f0f2158181e0467bb8c93bdbc3554b0025bf339cffdf169bbafcf813"

URI_aarch64_rust-winnow0.6+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow0.6+simd-devel-0.6.26-1.el10_0.noarch.rpm;name=aarch64_rust-winnow0.6+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow0.6+simd-devel}"
SRC_URI[aarch64_rust-winnow0.6+simd-devel.sha256sum] = "92caddfe540e09da843863b53dee040a4cf89b813f3528403f092e4b01be768f"

URI_aarch64_rust-winnow0.6+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow0.6+std-devel-0.6.26-1.el10_0.noarch.rpm;name=aarch64_rust-winnow0.6+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow0.6+std-devel}"
SRC_URI[aarch64_rust-winnow0.6+std-devel.sha256sum] = "0c6d399ed07862cce20c05fd90ac03ec0a1c15f387eb36389eed4bf443a879f7"

URI_aarch64_rust-winnow0.6+unstable-doc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow0.6+unstable-doc-devel-0.6.26-1.el10_0.noarch.rpm;name=aarch64_rust-winnow0.6+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow0.6+unstable-doc-devel}"
SRC_URI[aarch64_rust-winnow0.6+unstable-doc-devel.sha256sum] = "cfa5fc3eddb7f1c9a29b6b47643415f70b15e864c9f7a89e76e4d7ad4825d37b"

URI_aarch64_rust-winnow0.6+unstable-recover-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow0.6+unstable-recover-devel-0.6.26-1.el10_0.noarch.rpm;name=aarch64_rust-winnow0.6+unstable-recover-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow0.6+unstable-recover-devel}"
SRC_URI[aarch64_rust-winnow0.6+unstable-recover-devel.sha256sum] = "07cace79cfbd059831d328d05a4e935510a9609aea9d59f3113c48fe9042630d"

URI_aarch64_rust-winnow0.6-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow0.6-devel-0.6.26-1.el10_0.noarch.rpm;name=aarch64_rust-winnow0.6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow0.6-devel}"
SRC_URI[aarch64_rust-winnow0.6-devel.sha256sum] = "c4c8a6cde29f7b22559413d9f70062e941f5a7ed38ed3793b7381273f2813ee9"

RDEPENDS:rust-winnow0.6+alloc-devel = " \
 cargo \
 rust-winnow0.6-devel \
 "
RDEPENDS:rust-winnow0.6+debug-devel = " \
 cargo \
 rust-anstream0.3+default-devel \
 rust-anstyle+default-devel \
 rust-is-terminal+default-devel \
 rust-terminal_size+default-devel \
 rust-winnow0.6+std-devel \
 rust-winnow0.6-devel \
 "
RDEPENDS:rust-winnow0.6+default-devel = " \
 cargo \
 rust-winnow0.6+std-devel \
 rust-winnow0.6-devel \
 "
RDEPENDS:rust-winnow0.6+simd-devel = " \
 cargo \
 rust-memchr-devel \
 rust-winnow0.6-devel \
 "
RDEPENDS:rust-winnow0.6+std-devel = " \
 cargo \
 rust-memchr+std-devel \
 rust-memchr-devel \
 rust-winnow0.6+alloc-devel \
 rust-winnow0.6-devel \
 "
RDEPENDS:rust-winnow0.6+unstable-doc-devel = " \
 cargo \
 rust-winnow0.6+alloc-devel \
 rust-winnow0.6+simd-devel \
 rust-winnow0.6+std-devel \
 rust-winnow0.6+unstable-recover-devel \
 rust-winnow0.6-devel \
 "
RDEPENDS:rust-winnow0.6+unstable-recover-devel = " \
 cargo \
 rust-winnow0.6-devel \
 "
RDEPENDS:rust-winnow0.6-devel = " \
 cargo \
 rust \
 "
