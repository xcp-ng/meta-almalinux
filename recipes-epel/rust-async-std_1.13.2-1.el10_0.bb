# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-std"
PV = "1.13.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-async-std+alloc-devel \
 rust-async-std+async-attributes-devel \
 rust-async-std+async-channel-devel \
 rust-async-std+async-global-executor-devel \
 rust-async-std+async-io-devel \
 rust-async-std+async-lock-devel \
 rust-async-std+async-process-devel \
 rust-async-std+attributes-devel \
 rust-async-std+crossbeam-utils-devel \
 rust-async-std+default-devel \
 rust-async-std+docs-devel \
 rust-async-std+futures-core-devel \
 rust-async-std+futures-io-devel \
 rust-async-std+futures-lite-devel \
 rust-async-std+io_safety-devel \
 rust-async-std+log-devel \
 rust-async-std+memchr-devel \
 rust-async-std+once_cell-devel \
 rust-async-std+pin-project-lite-devel \
 rust-async-std+pin-utils-devel \
 rust-async-std+slab-devel \
 rust-async-std+std-devel \
 rust-async-std+tokio1-devel \
 rust-async-std+unstable-devel \
 rust-async-std-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-std-1.13.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f89ba544b63b4c62d6ed02165e215005ee274fd757fd9594f43ccfc6627f6a4a"

URI_x86_64_v2_rust-async-std+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+alloc-devel-1.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+alloc-devel}"
SRC_URI[x86_64_v2_rust-async-std+alloc-devel.sha256sum] = "27d5792718b0ddbc69517747943fc96627b3b3119f24b6e714fa95920a0057ce"

URI_x86_64_v2_rust-async-std+async-attributes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+async-attributes-devel-1.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+async-attributes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+async-attributes-devel}"
SRC_URI[x86_64_v2_rust-async-std+async-attributes-devel.sha256sum] = "e91944cf3573b75a5bb491bba3b355869563fa690c30a01fcf16c50b32301a4e"

URI_x86_64_v2_rust-async-std+async-channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+async-channel-devel-1.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+async-channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+async-channel-devel}"
SRC_URI[x86_64_v2_rust-async-std+async-channel-devel.sha256sum] = "33ac2804b3d6d1d7adf8e2fb61dbfb40c5ff5a9ada2ae1364aa9ddcb11d26099"

URI_x86_64_v2_rust-async-std+async-global-executor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+async-global-executor-devel-1.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+async-global-executor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+async-global-executor-devel}"
SRC_URI[x86_64_v2_rust-async-std+async-global-executor-devel.sha256sum] = "c6b5ce43463f3e4cf66531e8970b6f4f5851bc049b575ef2470c5a92f008a06c"

URI_x86_64_v2_rust-async-std+async-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+async-io-devel-1.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+async-io-devel}"
SRC_URI[x86_64_v2_rust-async-std+async-io-devel.sha256sum] = "4fd43c55a87cfab7a862987aea604c8dacb72ba26dcc5d2501da397057fd5882"

URI_x86_64_v2_rust-async-std+async-lock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+async-lock-devel-1.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+async-lock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+async-lock-devel}"
SRC_URI[x86_64_v2_rust-async-std+async-lock-devel.sha256sum] = "657da93997120235a9a022571c8555d3f4cd5c0281ffeb990e2866e1404b10aa"

URI_x86_64_v2_rust-async-std+async-process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+async-process-devel-1.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+async-process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+async-process-devel}"
SRC_URI[x86_64_v2_rust-async-std+async-process-devel.sha256sum] = "46c1ddaa3bbc482ebf03dad94b065cc41b2a1f7f96d0c162e6e8050fc3f61d1b"

URI_x86_64_v2_rust-async-std+attributes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+attributes-devel-1.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+attributes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+attributes-devel}"
SRC_URI[x86_64_v2_rust-async-std+attributes-devel.sha256sum] = "0a834921abffd27998fd7ad2159e8a28585e5748167781d5a96035ad0b7915a2"

URI_x86_64_v2_rust-async-std+crossbeam-utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+crossbeam-utils-devel-1.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+crossbeam-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+crossbeam-utils-devel}"
SRC_URI[x86_64_v2_rust-async-std+crossbeam-utils-devel.sha256sum] = "307224b6fdb332b0ca33c7751c46cf8f47a6af369a37427a012653f381b7f8dc"

URI_x86_64_v2_rust-async-std+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+default-devel-1.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+default-devel}"
SRC_URI[x86_64_v2_rust-async-std+default-devel.sha256sum] = "4ee5f633a0734f8539e23112a6d88835cab8765b3fad72bdd11158e8ed3df71a"

URI_x86_64_v2_rust-async-std+docs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+docs-devel-1.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+docs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+docs-devel}"
SRC_URI[x86_64_v2_rust-async-std+docs-devel.sha256sum] = "58da507ffe85fc4c5189c1aa96efd2bddccdaf1917978964b27919ad3f0ce4c4"

URI_x86_64_v2_rust-async-std+futures-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+futures-core-devel-1.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+futures-core-devel}"
SRC_URI[x86_64_v2_rust-async-std+futures-core-devel.sha256sum] = "dd2e61e90079547da4b8e04443eeb54dba76aac4b7c410fbc7c361234a2d49f0"

URI_x86_64_v2_rust-async-std+futures-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+futures-io-devel-1.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+futures-io-devel}"
SRC_URI[x86_64_v2_rust-async-std+futures-io-devel.sha256sum] = "ea5431353f8eb37e8b4f13da627d728adda3fcd3f06bbaf83785e27449775dd9"

URI_x86_64_v2_rust-async-std+futures-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+futures-lite-devel-1.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+futures-lite-devel}"
SRC_URI[x86_64_v2_rust-async-std+futures-lite-devel.sha256sum] = "87d9790478759f04ea4bb9a1a22d27f2c0d6bfb66ed73e53617e15790052c05a"

URI_x86_64_v2_rust-async-std+io_safety-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+io_safety-devel-1.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+io_safety-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+io_safety-devel}"
SRC_URI[x86_64_v2_rust-async-std+io_safety-devel.sha256sum] = "4042f1728a5bb6fc20bf5beaebc0fdc9b0ea8e33317409298628be0263a227a0"

URI_x86_64_v2_rust-async-std+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+log-devel-1.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+log-devel}"
SRC_URI[x86_64_v2_rust-async-std+log-devel.sha256sum] = "25c287fc86d9403045a5085013289479df43795b4070fb3ca23a396826c7d457"

URI_x86_64_v2_rust-async-std+memchr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+memchr-devel-1.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+memchr-devel}"
SRC_URI[x86_64_v2_rust-async-std+memchr-devel.sha256sum] = "bf77a0754642eff912c496ff0fa375803fbea95dc64a6bb3bd3d8637cc39cd52"

URI_x86_64_v2_rust-async-std+once_cell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+once_cell-devel-1.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+once_cell-devel}"
SRC_URI[x86_64_v2_rust-async-std+once_cell-devel.sha256sum] = "b96cac88fdc25e487729618292dcf8eea8315b7543a61ae3f3a57d811af48113"

URI_x86_64_v2_rust-async-std+pin-project-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+pin-project-lite-devel-1.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+pin-project-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+pin-project-lite-devel}"
SRC_URI[x86_64_v2_rust-async-std+pin-project-lite-devel.sha256sum] = "ca55491988caf9c14211edff1783e4197d97ce662cd39438cab86458f2b79ac9"

URI_x86_64_v2_rust-async-std+pin-utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+pin-utils-devel-1.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+pin-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+pin-utils-devel}"
SRC_URI[x86_64_v2_rust-async-std+pin-utils-devel.sha256sum] = "804ae8323690dfd7680d50f1596b7308925227e1a690319d92f0965c7a2ab32d"

URI_x86_64_v2_rust-async-std+slab-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+slab-devel-1.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+slab-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+slab-devel}"
SRC_URI[x86_64_v2_rust-async-std+slab-devel.sha256sum] = "1626c837abeef84cadce18f04975de9ea14e05e8d76e5c57fab57de6c975a4d9"

URI_x86_64_v2_rust-async-std+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+std-devel-1.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+std-devel}"
SRC_URI[x86_64_v2_rust-async-std+std-devel.sha256sum] = "4f2a689182ab07f6b3f7e6861ee050d4911c60011064caba86b449afe32dc152"

URI_x86_64_v2_rust-async-std+tokio1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+tokio1-devel-1.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+tokio1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+tokio1-devel}"
SRC_URI[x86_64_v2_rust-async-std+tokio1-devel.sha256sum] = "914ceb9945174e2b88535452b13df9cb9147c9d00478776f73b334cd7ae6e164"

URI_x86_64_v2_rust-async-std+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+unstable-devel-1.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+unstable-devel}"
SRC_URI[x86_64_v2_rust-async-std+unstable-devel.sha256sum] = "518e75ffdb27fa0f51299b2ee3add48ccba339751acf79f255dfbc0ca81f6200"

URI_x86_64_v2_rust-async-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std-devel-1.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std-devel}"
SRC_URI[x86_64_v2_rust-async-std-devel.sha256sum] = "ae090b569f43ddd402cded02e6626b5c87534c3e950b460956070adb63b69cb6"

URI_aarch64_rust-async-std+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+alloc-devel-1.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-async-std+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+alloc-devel}"
SRC_URI[aarch64_rust-async-std+alloc-devel.sha256sum] = "0aa100dc4404e60e066b68a00b59f33075650107d42dc8df2d9003994db42f77"

URI_aarch64_rust-async-std+async-attributes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+async-attributes-devel-1.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-async-std+async-attributes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+async-attributes-devel}"
SRC_URI[aarch64_rust-async-std+async-attributes-devel.sha256sum] = "9c0d158fd48ebad3e0af882d24197411ae581e0aa1c7280187e3281491e71741"

URI_aarch64_rust-async-std+async-channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+async-channel-devel-1.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-async-std+async-channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+async-channel-devel}"
SRC_URI[aarch64_rust-async-std+async-channel-devel.sha256sum] = "94c7567a30073532c686448f6b25a29a09305356463743e671312e85e6b3125e"

URI_aarch64_rust-async-std+async-global-executor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+async-global-executor-devel-1.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-async-std+async-global-executor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+async-global-executor-devel}"
SRC_URI[aarch64_rust-async-std+async-global-executor-devel.sha256sum] = "0e4c0204c593d750ac2022c1b015fddd31dac72f8933b3885f206c2682dfb62b"

URI_aarch64_rust-async-std+async-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+async-io-devel-1.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-async-std+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+async-io-devel}"
SRC_URI[aarch64_rust-async-std+async-io-devel.sha256sum] = "70be007509c9dd10e963199e20b1b594d2d111c3324f7941b7e29bec1681be96"

URI_aarch64_rust-async-std+async-lock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+async-lock-devel-1.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-async-std+async-lock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+async-lock-devel}"
SRC_URI[aarch64_rust-async-std+async-lock-devel.sha256sum] = "2afd9e8540caf0bbe97b943c198ecfc596ab7c7d5978562c52950516c23048b6"

URI_aarch64_rust-async-std+async-process-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+async-process-devel-1.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-async-std+async-process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+async-process-devel}"
SRC_URI[aarch64_rust-async-std+async-process-devel.sha256sum] = "d5ab8a849dc7e2dfe4c9035fe866742ace48ab520a782be5b3b50b76bbf5be10"

URI_aarch64_rust-async-std+attributes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+attributes-devel-1.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-async-std+attributes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+attributes-devel}"
SRC_URI[aarch64_rust-async-std+attributes-devel.sha256sum] = "22a063fc4eea3238bf2fcb2fe6365069accbd1cd43206af801d2648d61a9ec60"

URI_aarch64_rust-async-std+crossbeam-utils-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+crossbeam-utils-devel-1.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-async-std+crossbeam-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+crossbeam-utils-devel}"
SRC_URI[aarch64_rust-async-std+crossbeam-utils-devel.sha256sum] = "05efcfdf4d1e7d58a674d05d15a4a6a4383d898d08069976873f10fd29a7f0a1"

URI_aarch64_rust-async-std+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+default-devel-1.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-async-std+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+default-devel}"
SRC_URI[aarch64_rust-async-std+default-devel.sha256sum] = "0fa1e0da2118e2d1fc2beac724ebe474bf4607b73c2d21527d00b1d068022bfb"

URI_aarch64_rust-async-std+docs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+docs-devel-1.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-async-std+docs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+docs-devel}"
SRC_URI[aarch64_rust-async-std+docs-devel.sha256sum] = "40f56d86f339766137749211b9e22766473caafc545b49e83a6409682ab652f8"

URI_aarch64_rust-async-std+futures-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+futures-core-devel-1.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-async-std+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+futures-core-devel}"
SRC_URI[aarch64_rust-async-std+futures-core-devel.sha256sum] = "329d6935fb9637967de41fd943c150ccff8247630d212a34123779946cf84621"

URI_aarch64_rust-async-std+futures-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+futures-io-devel-1.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-async-std+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+futures-io-devel}"
SRC_URI[aarch64_rust-async-std+futures-io-devel.sha256sum] = "d8043fda937cc140abacdd9f52435df956958cb88379540da6e7a1301b0b3783"

URI_aarch64_rust-async-std+futures-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+futures-lite-devel-1.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-async-std+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+futures-lite-devel}"
SRC_URI[aarch64_rust-async-std+futures-lite-devel.sha256sum] = "00055d8f41d3e0240650f081e7b4d75b00043356fe845ea2b898c655131b7bc0"

URI_aarch64_rust-async-std+io_safety-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+io_safety-devel-1.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-async-std+io_safety-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+io_safety-devel}"
SRC_URI[aarch64_rust-async-std+io_safety-devel.sha256sum] = "8eb96b0edcecce5d0c867a603210a51b252c427ef09ffca2ad6f33f4071da1c4"

URI_aarch64_rust-async-std+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+log-devel-1.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-async-std+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+log-devel}"
SRC_URI[aarch64_rust-async-std+log-devel.sha256sum] = "76a448259fb4c2f04b72e51ec9ac67b8f8e7c6f9f3d23b79abdef78f7c816878"

URI_aarch64_rust-async-std+memchr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+memchr-devel-1.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-async-std+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+memchr-devel}"
SRC_URI[aarch64_rust-async-std+memchr-devel.sha256sum] = "3b7bf8a51a5206951c617eadabe9231229d1bd42fa0489c03df8af066fe80022"

URI_aarch64_rust-async-std+once_cell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+once_cell-devel-1.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-async-std+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+once_cell-devel}"
SRC_URI[aarch64_rust-async-std+once_cell-devel.sha256sum] = "e7877b65a8075033115afcaa07b0fe1fd3e05875cd73bf2378647bd791bdd393"

URI_aarch64_rust-async-std+pin-project-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+pin-project-lite-devel-1.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-async-std+pin-project-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+pin-project-lite-devel}"
SRC_URI[aarch64_rust-async-std+pin-project-lite-devel.sha256sum] = "edcf89132f9bb6e6d07f1da6510c61d3e28da509e542b9ffa28d1e6622a29da4"

URI_aarch64_rust-async-std+pin-utils-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+pin-utils-devel-1.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-async-std+pin-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+pin-utils-devel}"
SRC_URI[aarch64_rust-async-std+pin-utils-devel.sha256sum] = "f6d8cb798499af52211ee4d2dd0094a9b496ddde39331d89d4f5cb38374ff683"

URI_aarch64_rust-async-std+slab-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+slab-devel-1.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-async-std+slab-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+slab-devel}"
SRC_URI[aarch64_rust-async-std+slab-devel.sha256sum] = "db2eb9723ce55e61321a99210d0093cb8ccf2bb1475b14e4d565f315a3b2caa6"

URI_aarch64_rust-async-std+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+std-devel-1.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-async-std+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+std-devel}"
SRC_URI[aarch64_rust-async-std+std-devel.sha256sum] = "cefe9eeaef63d8f935ab44c70659e136fc1bdf23e6e22dd0c96c102c0e2fecd7"

URI_aarch64_rust-async-std+tokio1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+tokio1-devel-1.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-async-std+tokio1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+tokio1-devel}"
SRC_URI[aarch64_rust-async-std+tokio1-devel.sha256sum] = "277d8401454ac4918eec07021b918b0d09a98ef6317f4a0b2c9966c18ac4a7a5"

URI_aarch64_rust-async-std+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+unstable-devel-1.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-async-std+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+unstable-devel}"
SRC_URI[aarch64_rust-async-std+unstable-devel.sha256sum] = "5f279a30d4b2fc8deb4f318ab9bdda3739c005fdbfef5019825810bdaf7c9e30"

URI_aarch64_rust-async-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std-devel-1.13.2-1.el10_0.noarch.rpm;name=aarch64_rust-async-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std-devel}"
SRC_URI[aarch64_rust-async-std-devel.sha256sum] = "d5c7c39e7c2bdf60902bdd724d1cb72086e8f71c62e1a8a0b85fced5f7a355ea"

RDEPENDS:rust-async-std+alloc-devel = " \
 cargo \
 rust-async-std+pin-project-lite-devel \
 rust-async-std-devel \
 rust-futures-core+alloc-devel \
 rust-futures-core-devel \
 "
RDEPENDS:rust-async-std+async-attributes-devel = " \
 cargo \
 rust-async-attributes+default-devel \
 rust-async-std-devel \
 "
RDEPENDS:rust-async-std+async-channel-devel = " \
 cargo \
 rust-async-channel+default-devel \
 rust-async-std-devel \
 "
RDEPENDS:rust-async-std+async-global-executor-devel = " \
 cargo \
 rust-async-global-executor+async-io-devel \
 rust-async-global-executor+default-devel \
 rust-async-std-devel \
 "
RDEPENDS:rust-async-std+async-io-devel = " \
 cargo \
 rust-async-io+default-devel \
 rust-async-std-devel \
 "
RDEPENDS:rust-async-std+async-lock-devel = " \
 cargo \
 rust-async-lock+default-devel \
 rust-async-std-devel \
 "
RDEPENDS:rust-async-std+async-process-devel = " \
 cargo \
 rust-async-process+default-devel \
 rust-async-std-devel \
 "
RDEPENDS:rust-async-std+attributes-devel = " \
 cargo \
 rust-async-std+async-attributes-devel \
 rust-async-std-devel \
 "
RDEPENDS:rust-async-std+crossbeam-utils-devel = " \
 cargo \
 rust-async-std-devel \
 rust-crossbeam-utils+default-devel \
 "
RDEPENDS:rust-async-std+default-devel = " \
 cargo \
 rust-async-std+async-global-executor-devel \
 rust-async-std+async-io-devel \
 rust-async-std+futures-lite-devel \
 rust-async-std+log-devel \
 rust-async-std+pin-project-lite-devel \
 rust-async-std+std-devel \
 rust-async-std-devel \
 "
RDEPENDS:rust-async-std+docs-devel = " \
 cargo \
 rust-async-std+attributes-devel \
 rust-async-std+default-devel \
 rust-async-std+unstable-devel \
 rust-async-std-devel \
 "
RDEPENDS:rust-async-std+futures-core-devel = " \
 cargo \
 rust-async-std-devel \
 rust-futures-core-devel \
 "
RDEPENDS:rust-async-std+futures-io-devel = " \
 cargo \
 rust-async-std-devel \
 rust-futures-io+default-devel \
 "
RDEPENDS:rust-async-std+futures-lite-devel = " \
 cargo \
 rust-async-std-devel \
 rust-futures-lite+default-devel \
 "
RDEPENDS:rust-async-std+io_safety-devel = " \
 cargo \
 rust-async-std-devel \
 "
RDEPENDS:rust-async-std+log-devel = " \
 cargo \
 rust-async-std-devel \
 rust-log+default-devel \
 "
RDEPENDS:rust-async-std+memchr-devel = " \
 cargo \
 rust-async-std-devel \
 rust-memchr+default-devel \
 "
RDEPENDS:rust-async-std+once_cell-devel = " \
 cargo \
 rust-async-std-devel \
 rust-once_cell+default-devel \
 "
RDEPENDS:rust-async-std+pin-project-lite-devel = " \
 cargo \
 rust-async-std-devel \
 rust-pin-project-lite+default-devel \
 "
RDEPENDS:rust-async-std+pin-utils-devel = " \
 cargo \
 rust-async-std-devel \
 rust-pin-utils+default-devel \
 "
RDEPENDS:rust-async-std+slab-devel = " \
 cargo \
 rust-async-std-devel \
 rust-slab+default-devel \
 "
RDEPENDS:rust-async-std+std-devel = " \
 cargo \
 rust-async-std+alloc-devel \
 rust-async-std+async-channel-devel \
 rust-async-std+async-lock-devel \
 rust-async-std+crossbeam-utils-devel \
 rust-async-std+futures-io-devel \
 rust-async-std+memchr-devel \
 rust-async-std+once_cell-devel \
 rust-async-std+pin-utils-devel \
 rust-async-std+slab-devel \
 rust-async-std-devel \
 rust-futures-core+std-devel \
 rust-futures-core-devel \
 "
RDEPENDS:rust-async-std+tokio1-devel = " \
 cargo \
 rust-async-global-executor+async-io-devel \
 rust-async-global-executor+default-devel \
 rust-async-global-executor+tokio-devel \
 rust-async-std-devel \
 "
RDEPENDS:rust-async-std+unstable-devel = " \
 cargo \
 rust-async-std+async-io-devel \
 rust-async-std+async-process-devel \
 rust-async-std+std-devel \
 rust-async-std-devel \
 "
RDEPENDS:rust-async-std-devel = " \
 cargo \
 rust \
 "
