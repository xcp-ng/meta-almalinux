# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyphen-gu"
PE = "1"
PV = "0.7.0"
PR = "27.el10"
PACKAGES = " \
 hyphen-gu \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyphen-gu-0.7.0-27.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43495cf9a1f8c9cb324b6ebdc1db87207f896bee3dbe3dbf9fedc452c4b2b28e"

URI_x86_64_v2_hyphen-gu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-gu-0.7.0-27.el10.noarch.rpm;name=x86_64_v2_hyphen-gu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyphen-gu}"
SRC_URI[x86_64_v2_hyphen-gu.sha256sum] = "f40c2723dc9206e3dfd083cab8e9f723d516ea007e303783eb47529c88884f45"

URI_aarch64_hyphen-gu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-gu-0.7.0-27.el10.noarch.rpm;name=aarch64_hyphen-gu;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyphen-gu}"
SRC_URI[aarch64_hyphen-gu.sha256sum] = "f40c2723dc9206e3dfd083cab8e9f723d516ea007e303783eb47529c88884f45"

RDEPENDS:hyphen-gu = " \
 hyphen \
 "
