# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dragon"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 dragon \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/dragon-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d9c4e8e73f84b0ab0f071e591f23e2319fd78b37c93ac4c34902b1467a35888a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dragon-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dragon;unpack=0"
SRC_URI[x86_64_v2_dragon.sha256sum] = "251beece0f19761e19f0f216d6267ccce9b93ebda05855802d5da98b11970420"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dragon-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_dragon;unpack=0"
SRC_URI[aarch64_dragon.sha256sum] = "1b2aab77c848c24ecc8c9ba4ea070c90e0681f0e721a6825073fa2580cd9e9b1"

RDEPENDS:dragon = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kparts \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-solid \
 libstdc++ \
 phonon-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
