# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "google-droid-fonts"
PV = "20200215"
PR = "22.el10"
PACKAGES = " \
 google-droid-sans-fonts \
 google-droid-sans-mono-fonts \
 google-droid-serif-fonts \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/google-droid-fonts-20200215-22.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19e1af2c27e513029d24bdd4833d7d69813a2600cc7bfe4c11e03a524e019588"

URI_x86_64_v2_google-droid-sans-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/google-droid-sans-fonts-20200215-22.el10.noarch.rpm;name=x86_64_v2_google-droid-sans-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_google-droid-sans-fonts}"
SRC_URI[x86_64_v2_google-droid-sans-fonts.sha256sum] = "fef5bcffb2f9324c00c6f5d616951698d441b9662d771edf78d7b2c7747e2e09"

URI_x86_64_v2_google-droid-sans-mono-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/google-droid-sans-mono-fonts-20200215-22.el10.noarch.rpm;name=x86_64_v2_google-droid-sans-mono-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_google-droid-sans-mono-fonts}"
SRC_URI[x86_64_v2_google-droid-sans-mono-fonts.sha256sum] = "1866d0c7c24dafe4f19f270323418b3c0b8cd4b9001d68247d2ec0e7d3ad5fb6"

URI_x86_64_v2_google-droid-serif-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/google-droid-serif-fonts-20200215-22.el10.noarch.rpm;name=x86_64_v2_google-droid-serif-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_google-droid-serif-fonts}"
SRC_URI[x86_64_v2_google-droid-serif-fonts.sha256sum] = "ec3c2d0456f4774ed22f71f18e1045c8a8ddc771544f5250b7cb783309d62dcb"

URI_aarch64_google-droid-sans-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/google-droid-sans-fonts-20200215-22.el10.noarch.rpm;name=aarch64_google-droid-sans-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_google-droid-sans-fonts}"
SRC_URI[aarch64_google-droid-sans-fonts.sha256sum] = "fef5bcffb2f9324c00c6f5d616951698d441b9662d771edf78d7b2c7747e2e09"

URI_aarch64_google-droid-sans-mono-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/google-droid-sans-mono-fonts-20200215-22.el10.noarch.rpm;name=aarch64_google-droid-sans-mono-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_google-droid-sans-mono-fonts}"
SRC_URI[aarch64_google-droid-sans-mono-fonts.sha256sum] = "1866d0c7c24dafe4f19f270323418b3c0b8cd4b9001d68247d2ec0e7d3ad5fb6"

URI_aarch64_google-droid-serif-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/google-droid-serif-fonts-20200215-22.el10.noarch.rpm;name=aarch64_google-droid-serif-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_google-droid-serif-fonts}"
SRC_URI[aarch64_google-droid-serif-fonts.sha256sum] = "ec3c2d0456f4774ed22f71f18e1045c8a8ddc771544f5250b7cb783309d62dcb"

RDEPENDS:google-droid-sans-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:google-droid-sans-mono-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:google-droid-serif-fonts = " \
 fonts-filesystem \
 "
