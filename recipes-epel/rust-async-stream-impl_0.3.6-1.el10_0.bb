# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-stream-impl"
PV = "0.3.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-async-stream-impl+default-devel \
 rust-async-stream-impl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-stream-impl-0.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a54f5d4895b8972a4ece1213aa24943e8bb45e9d256f9424d8d166a146191f6"

URI_x86_64_v2_rust-async-stream-impl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-stream-impl+default-devel-0.3.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-stream-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-stream-impl+default-devel}"
SRC_URI[x86_64_v2_rust-async-stream-impl+default-devel.sha256sum] = "a1afb345c5078635ea612b25a0ac5f057e5ef490449c7d7409e0a0d8654cc84f"

URI_x86_64_v2_rust-async-stream-impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-stream-impl-devel-0.3.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-stream-impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-stream-impl-devel}"
SRC_URI[x86_64_v2_rust-async-stream-impl-devel.sha256sum] = "8560050ed411b7409c1ea85bf2d53d8b1ff893069c87af935e1650d32b8179e9"

URI_aarch64_rust-async-stream-impl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-stream-impl+default-devel-0.3.6-1.el10_0.noarch.rpm;name=aarch64_rust-async-stream-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-stream-impl+default-devel}"
SRC_URI[aarch64_rust-async-stream-impl+default-devel.sha256sum] = "1d676b9716c86296021c87a879b02a7ede92ca7266ccf1aff9e7207de63fdace"

URI_aarch64_rust-async-stream-impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-stream-impl-devel-0.3.6-1.el10_0.noarch.rpm;name=aarch64_rust-async-stream-impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-stream-impl-devel}"
SRC_URI[aarch64_rust-async-stream-impl-devel.sha256sum] = "1360f5d651ef8d4870ec159d0c36359bd01fce3a0831fb82b847c9ab179d33a9"

RDEPENDS:rust-async-stream-impl+default-devel = " \
 cargo \
 rust-async-stream-impl-devel \
 "
RDEPENDS:rust-async-stream-impl-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 rust-syn+visit-mut-devel \
 "
