# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "net-snmp"
PE = "1"
PV = "5.9.4"
PR = "19.el10"
PACKAGES = " \
 net-snmp \
 net-snmp-agent-libs \
 net-snmp-devel \
 net-snmp-libs \
 net-snmp-perl \
 net-snmp-perl-module \
 net-snmp-utils \
 python3-net-snmp \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/net-snmp-5.9.4-19.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c871d733a67f8d4e8c56489885ad2b95a35df4ac05bc0e1b6bebc4a089f5db89"

URI_x86_64_v2_net-snmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/net-snmp-5.9.4-19.el10.x86_64_v2.rpm;name=x86_64_v2_net-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_net-snmp}"
SRC_URI[x86_64_v2_net-snmp.sha256sum] = "771a1c17a5ec1474fada09745472aa0ef18796d3558f622f7050f5d8c14cd986"

URI_x86_64_v2_net-snmp-agent-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/net-snmp-agent-libs-5.9.4-19.el10.x86_64_v2.rpm;name=x86_64_v2_net-snmp-agent-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_net-snmp-agent-libs}"
SRC_URI[x86_64_v2_net-snmp-agent-libs.sha256sum] = "74a8cf355fa45fb71d0a49aee618e52f77aaf34dbb8883153517d52d497c5ab2"

URI_x86_64_v2_net-snmp-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/net-snmp-devel-5.9.4-19.el10.x86_64_v2.rpm;name=x86_64_v2_net-snmp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_net-snmp-devel}"
SRC_URI[x86_64_v2_net-snmp-devel.sha256sum] = "e1057768e9bd069b4f2746aac425a0d79483e61766fc49044e6df6c4334cb34a"

URI_x86_64_v2_net-snmp-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/net-snmp-libs-5.9.4-19.el10.x86_64_v2.rpm;name=x86_64_v2_net-snmp-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_net-snmp-libs}"
SRC_URI[x86_64_v2_net-snmp-libs.sha256sum] = "bb86e1dd78116476ae48adf5abe6fb4ff64aa7f43201cbcbccfc4bead89226d6"

URI_x86_64_v2_net-snmp-perl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/net-snmp-perl-5.9.4-19.el10.x86_64_v2.rpm;name=x86_64_v2_net-snmp-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_net-snmp-perl}"
SRC_URI[x86_64_v2_net-snmp-perl.sha256sum] = "9fc802d2467cab83d406d352bdc8f40e33e6b6ab61ebe0d424942bacbf1eeb7e"

URI_x86_64_v2_net-snmp-perl-module = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/net-snmp-perl-module-5.9.4-19.el10.x86_64_v2.rpm;name=x86_64_v2_net-snmp-perl-module;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_net-snmp-perl-module}"
SRC_URI[x86_64_v2_net-snmp-perl-module.sha256sum] = "70766843e419336736c6fc7de652605724d9597768ca9cc471204d1f2318030f"

URI_x86_64_v2_net-snmp-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/net-snmp-utils-5.9.4-19.el10.x86_64_v2.rpm;name=x86_64_v2_net-snmp-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_net-snmp-utils}"
SRC_URI[x86_64_v2_net-snmp-utils.sha256sum] = "ec3989bc2347621a1fd5da33a24b5f7114b89a727f37d4077a8bdff363ad54e9"

URI_x86_64_v2_python3-net-snmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-net-snmp-5.9.4-19.el10.x86_64_v2.rpm;name=x86_64_v2_python3-net-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-net-snmp}"
SRC_URI[x86_64_v2_python3-net-snmp.sha256sum] = "c27a40537c1e9961fbeadd1db775ae432fb4268eafadec37172b7c501a86a1ce"

URI_aarch64_net-snmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/net-snmp-5.9.4-19.el10.aarch64.rpm;name=aarch64_net-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_net-snmp}"
SRC_URI[aarch64_net-snmp.sha256sum] = "2dd507b8bd605ddfeb287949b7516ec1c48b5644063f97005bbe65a537d9e70c"

URI_aarch64_net-snmp-agent-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/net-snmp-agent-libs-5.9.4-19.el10.aarch64.rpm;name=aarch64_net-snmp-agent-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_net-snmp-agent-libs}"
SRC_URI[aarch64_net-snmp-agent-libs.sha256sum] = "c08e622870a986a764f33d9d2ae096c9016e82eadaf3175467f6e9acd06b1515"

URI_aarch64_net-snmp-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/net-snmp-devel-5.9.4-19.el10.aarch64.rpm;name=aarch64_net-snmp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_net-snmp-devel}"
SRC_URI[aarch64_net-snmp-devel.sha256sum] = "efc38a91fb4202f2c430c95440b7160c9d9f7b56b5e7f690de8577b4d2b332fc"

URI_aarch64_net-snmp-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/net-snmp-libs-5.9.4-19.el10.aarch64.rpm;name=aarch64_net-snmp-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_net-snmp-libs}"
SRC_URI[aarch64_net-snmp-libs.sha256sum] = "c6fb69585ef2e44873db557156f086b5a197b8c4c6c6f3cfc5d1ea60d040a734"

URI_aarch64_net-snmp-perl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/net-snmp-perl-5.9.4-19.el10.aarch64.rpm;name=aarch64_net-snmp-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_net-snmp-perl}"
SRC_URI[aarch64_net-snmp-perl.sha256sum] = "e7065c910890c73bcf4e94f329828df62ccef9933d43fda2dd65ddc3eab42fb4"

URI_aarch64_net-snmp-perl-module = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/net-snmp-perl-module-5.9.4-19.el10.aarch64.rpm;name=aarch64_net-snmp-perl-module;unpack=0"
SRC_URI:append = " ${URI_aarch64_net-snmp-perl-module}"
SRC_URI[aarch64_net-snmp-perl-module.sha256sum] = "e94be8b7b897ccf3777a7fff8f4820a344caa3939b66e8692339a91882650678"

URI_aarch64_net-snmp-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/net-snmp-utils-5.9.4-19.el10.aarch64.rpm;name=aarch64_net-snmp-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_net-snmp-utils}"
SRC_URI[aarch64_net-snmp-utils.sha256sum] = "bcbd304c417150cb3fdf32b91db3570c86c7c2161b2c80c76554461384716764"

URI_aarch64_python3-net-snmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-net-snmp-5.9.4-19.el10.aarch64.rpm;name=aarch64_python3-net-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-net-snmp}"
SRC_URI[aarch64_python3-net-snmp.sha256sum] = "e87cfb2a1cff8ef66c66317cb5c63d9a1799358c2bb761a28357c54a5b2b1c35"

RDEPENDS:net-snmp = " \
 bash \
 glibc \
 net-snmp-agent-libs \
 net-snmp-libs \
 perl-Data-Dumper \
 perl-File-Copy \
 perl-Getopt-Std \
 perl-IO \
 perl-Term-ReadLine \
 perl-interpreter \
 systemd \
 "
RDEPENDS:net-snmp-agent-libs = " \
 glibc \
 libxcrypt \
 lm_sensors-libs \
 mariadb-connector-c \
 net-snmp-libs \
 openssl-libs \
 perl-libs \
 rpm-libs \
 "
RDEPENDS:net-snmp-devel = " \
 bash \
 elfutils-devel \
 elfutils-libelf-devel \
 lm_sensors-devel \
 net-snmp-agent-libs \
 net-snmp-libs \
 openssl-devel \
 perl-devel \
 pkgconf-pkg-config \
 redhat-rpm-config \
 rpm-devel \
 "
RDEPENDS:net-snmp-libs = " \
 glibc \
 openssl-libs \
 "
RDEPENDS:net-snmp-perl = " \
 bash \
 net-snmp-agent-libs \
 net-snmp-devel \
 net-snmp-libs \
 net-snmp-perl-module \
 perl-Carp \
 perl-Data-Dumper \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Path \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-JSON \
 perl-POSIX \
 perl-PathTools \
 perl-Sys-Hostname \
 perl-interpreter \
 perl-libnet \
 perl-libs \
 perl-vars \
 "
RDEPENDS:net-snmp-perl-module = " \
 glibc \
 net-snmp-agent-libs \
 net-snmp-libs \
 net-snmp-perl-module \
 perl-AutoLoader \
 perl-Carp \
 perl-Data-Dumper \
 perl-DynaLoader \
 perl-Exporter \
 perl-interpreter \
 perl-libs \
 perl-overload \
 perl-vars \
 "
RDEPENDS:net-snmp-utils = " \
 glibc \
 net-snmp-libs \
 openssl-libs \
 "
RDEPENDS:python3-net-snmp = " \
 glibc \
 net-snmp-libs \
 python3 \
 "
