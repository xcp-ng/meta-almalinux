# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libxslt"
PV = "1.1.39"
PR = "8.el10_0"
PACKAGES = " \
 libxslt \
 libxslt-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libxslt-1.1.39-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2950a541961e1a6673e1b8dc59f510b277245cae73da26bd4574e7ce1fe9df56"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libxslt-1.1.39-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_libxslt;unpack=0"
SRC_URI[x86_64_v2_libxslt.sha256sum] = "8e852558cc8407367c283e1d90fd83b66d167af09bf06d17485b8781d40c8d51"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libxslt-devel-1.1.39-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_libxslt-devel;unpack=0"
SRC_URI[x86_64_v2_libxslt-devel.sha256sum] = "d80459dc29a54572a611717d4c0c05d9717474b83a78117d7594b05bd80fbc1c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libxslt-1.1.39-8.el10_0.aarch64.rpm;name=aarch64_libxslt;unpack=0"
SRC_URI[aarch64_libxslt.sha256sum] = "369484b30253f0eedf3a389a1d532fad86a3e4f7379d519e1c3a0e957ccacd09"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libxslt-devel-1.1.39-8.el10_0.aarch64.rpm;name=aarch64_libxslt-devel;unpack=0"
SRC_URI[aarch64_libxslt-devel.sha256sum] = "b3109a9a21c256682a24d303441d6079eebc487e9f021c12a2381a41ec463064"

RDEPENDS:libxslt = " \
 glibc \
 libxml2 \
 "
RDEPENDS:libxslt-devel = " \
 bash \
 libgpg-error-devel \
 libxml2-devel \
 libxslt \
 libxslt-devel \
 pkgconf-pkg-config \
 "
