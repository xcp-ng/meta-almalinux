# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-ktexttemplate"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-ktexttemplate \
 kf6-ktexttemplate-devel \
 kf6-ktexttemplate-doc \
 kf6-ktexttemplate-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-ktexttemplate-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2755b78b1f3c9ab19a88ca51bddef9043059cba8b4cdaaadbe0539153eebab21"

URI_x86_64_v2_kf6-ktexttemplate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexttemplate-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ktexttemplate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktexttemplate}"
SRC_URI[x86_64_v2_kf6-ktexttemplate.sha256sum] = "008dd4274c7ff4d007ea4c04301dd30cc189e270f5ba8419677b6a95d1769611"

URI_x86_64_v2_kf6-ktexttemplate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexttemplate-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ktexttemplate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktexttemplate-devel}"
SRC_URI[x86_64_v2_kf6-ktexttemplate-devel.sha256sum] = "2075d6b063c5efd2ed644d4d80e1c41597aa57c133f7682711a8982de4dee274"

URI_x86_64_v2_kf6-ktexttemplate-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexttemplate-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ktexttemplate-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktexttemplate-doc}"
SRC_URI[x86_64_v2_kf6-ktexttemplate-doc.sha256sum] = "31922fc77ced9fa9b54278b4d8bb0ee80e6ffcd5c7a496b6c5ecaa28cadc14fa"

URI_x86_64_v2_kf6-ktexttemplate-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexttemplate-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ktexttemplate-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktexttemplate-html}"
SRC_URI[x86_64_v2_kf6-ktexttemplate-html.sha256sum] = "91c6f487d9691e77f524547482e9ad3f6d0c761d897ad5b6cd8929e2ceb51a5e"

URI_aarch64_kf6-ktexttemplate = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexttemplate-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-ktexttemplate;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktexttemplate}"
SRC_URI[aarch64_kf6-ktexttemplate.sha256sum] = "67d61b8701aa59062d7ad501c593a0cf32dbdf586fd63dd548ffa51d6c0fe82d"

URI_aarch64_kf6-ktexttemplate-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexttemplate-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-ktexttemplate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktexttemplate-devel}"
SRC_URI[aarch64_kf6-ktexttemplate-devel.sha256sum] = "d71729221ef56f3db5cef5f31002d359894b2ff693031a2ff896cbcf521c6715"

URI_aarch64_kf6-ktexttemplate-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexttemplate-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-ktexttemplate-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktexttemplate-doc}"
SRC_URI[aarch64_kf6-ktexttemplate-doc.sha256sum] = "526bdc955b2d4b4a09e24591e2fc9de38d68fe0e819214ddf5d4ed7745bc9b95"

URI_aarch64_kf6-ktexttemplate-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexttemplate-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-ktexttemplate-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktexttemplate-html}"
SRC_URI[aarch64_kf6-ktexttemplate-html.sha256sum] = "6afa5a0b96be44aa4048eaeece17c18779104633647e3f93f8818be930893cb9"

RDEPENDS:kf6-ktexttemplate = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-ktexttemplate-devel = " \
 cmake-filesystem \
 kf6-ktexttemplate \
 "
RDEPENDS:kf6-ktexttemplate-doc = " \
 "
RDEPENDS:kf6-ktexttemplate-html = " \
 "
