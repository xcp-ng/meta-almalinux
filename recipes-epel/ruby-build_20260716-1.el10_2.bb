# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ruby-build"
PV = "20260716"
PR = "1.el10_2"
PACKAGES = " \
 ruby-build \
 ruby-build-all \
 ruby-build-core \
 ruby-build-jruby \
 ruby-build-mruby \
 ruby-build-others \
 ruby-build-picoruby \
 ruby-build-rbenv \
 ruby-build-ruby \
 ruby-build-truffleruby \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/ruby-build-20260716-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "18a5cdd916dbc9cde9537b521654229496e19afee598177329f5bb9973792041"

URI_x86_64_v2_ruby-build = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-20260716-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-build}"
SRC_URI[x86_64_v2_ruby-build.sha256sum] = "e806f9048b4f457dab53fcf4d3907fa95790ec545a724f993e26bb8941ec0373"

URI_x86_64_v2_ruby-build-all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-all-20260716-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-build-all}"
SRC_URI[x86_64_v2_ruby-build-all.sha256sum] = "1170de38f4adafa85a040642d040d4fafea7b8333e3505095cc120417435d204"

URI_x86_64_v2_ruby-build-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-core-20260716-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-build-core}"
SRC_URI[x86_64_v2_ruby-build-core.sha256sum] = "d6ab1f293b597af1442b560ad738018e5c0eac437fae6b6ab3339d2f0084cf01"

URI_x86_64_v2_ruby-build-jruby = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-jruby-20260716-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-jruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-build-jruby}"
SRC_URI[x86_64_v2_ruby-build-jruby.sha256sum] = "8e4c914a834ce508f3d940b6a5af952311e464c2720c8a4af2e1192392450b8a"

URI_x86_64_v2_ruby-build-mruby = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-mruby-20260716-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-mruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-build-mruby}"
SRC_URI[x86_64_v2_ruby-build-mruby.sha256sum] = "4ccc25446720905e4e0c2bd91dab9e9ac62011ff03ca5c6cbb5f0575d4d43496"

URI_x86_64_v2_ruby-build-others = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-others-20260716-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-others;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-build-others}"
SRC_URI[x86_64_v2_ruby-build-others.sha256sum] = "4bf591484a277e95e98e99af3656b6a27efc6bb3d9ab20a51e0afb96596b2083"

URI_x86_64_v2_ruby-build-picoruby = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-picoruby-20260716-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-picoruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-build-picoruby}"
SRC_URI[x86_64_v2_ruby-build-picoruby.sha256sum] = "45e58d16c16ecc167c9d4e941c8abab3e58948cb7564757989c68921ce0ffade"

URI_x86_64_v2_ruby-build-rbenv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-rbenv-20260716-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-rbenv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-build-rbenv}"
SRC_URI[x86_64_v2_ruby-build-rbenv.sha256sum] = "6168ef5df40fdac524950a1708e2406b61843f2d71f8f07e7aef438995e2793e"

URI_x86_64_v2_ruby-build-ruby = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-ruby-20260716-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-ruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-build-ruby}"
SRC_URI[x86_64_v2_ruby-build-ruby.sha256sum] = "a49fb0ecd063debac040727f8041586ab5147cb6fe5900221417d9131b20820f"

URI_x86_64_v2_ruby-build-truffleruby = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-truffleruby-20260716-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-truffleruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-build-truffleruby}"
SRC_URI[x86_64_v2_ruby-build-truffleruby.sha256sum] = "74b37a3aa013f6d0d4db6778eede7933bebaa048357fd03b1cc7b023a088afd3"

URI_aarch64_ruby-build = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-20260716-1.el10_2.noarch.rpm;name=aarch64_ruby-build;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-build}"
SRC_URI[aarch64_ruby-build.sha256sum] = "39a1ac9fe022a53c19fd0fb8d08d7f933360ffe1d8b77b29536d23cb6c7a2639"

URI_aarch64_ruby-build-all = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-all-20260716-1.el10_2.noarch.rpm;name=aarch64_ruby-build-all;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-build-all}"
SRC_URI[aarch64_ruby-build-all.sha256sum] = "442b1fdbc05d9b746af36cdd1c76866e9fe8942ee3b05fceed152923abb8246c"

URI_aarch64_ruby-build-core = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-core-20260716-1.el10_2.noarch.rpm;name=aarch64_ruby-build-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-build-core}"
SRC_URI[aarch64_ruby-build-core.sha256sum] = "dc411be60185b296e01200c9ef6aff7cd4d7fe1c6a5d09e9ca83e12d3611cddc"

URI_aarch64_ruby-build-jruby = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-jruby-20260716-1.el10_2.noarch.rpm;name=aarch64_ruby-build-jruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-build-jruby}"
SRC_URI[aarch64_ruby-build-jruby.sha256sum] = "55879001e6aba783061ebd210f183a6ae01d960e982e9ad105402ace941ea937"

URI_aarch64_ruby-build-mruby = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-mruby-20260716-1.el10_2.noarch.rpm;name=aarch64_ruby-build-mruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-build-mruby}"
SRC_URI[aarch64_ruby-build-mruby.sha256sum] = "5cd2c31970637152b1625186b7e6e4ad3fddc7330cf9421d86be14d2dcf2e7c4"

URI_aarch64_ruby-build-others = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-others-20260716-1.el10_2.noarch.rpm;name=aarch64_ruby-build-others;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-build-others}"
SRC_URI[aarch64_ruby-build-others.sha256sum] = "7e00473dfaa1b453c193fece82da52284af17d1adf91b66c40cefe32bc83198b"

URI_aarch64_ruby-build-picoruby = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-picoruby-20260716-1.el10_2.noarch.rpm;name=aarch64_ruby-build-picoruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-build-picoruby}"
SRC_URI[aarch64_ruby-build-picoruby.sha256sum] = "946cd04a3799ad8faaaa848a7ad7ef1570f53b706ee5d71e662d9e0d87047a69"

URI_aarch64_ruby-build-rbenv = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-rbenv-20260716-1.el10_2.noarch.rpm;name=aarch64_ruby-build-rbenv;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-build-rbenv}"
SRC_URI[aarch64_ruby-build-rbenv.sha256sum] = "113d8c0c816232771aa060afff5f6dd71f535dc287ee71e8494c70f77c287f57"

URI_aarch64_ruby-build-ruby = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-ruby-20260716-1.el10_2.noarch.rpm;name=aarch64_ruby-build-ruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-build-ruby}"
SRC_URI[aarch64_ruby-build-ruby.sha256sum] = "56854a93dc603ea59e15b56d7d9d922b9f63087b6de0f70b73e46c5c154a6d2e"

URI_aarch64_ruby-build-truffleruby = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-truffleruby-20260716-1.el10_2.noarch.rpm;name=aarch64_ruby-build-truffleruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-build-truffleruby}"
SRC_URI[aarch64_ruby-build-truffleruby.sha256sum] = "4e7f04a7788a5bc24b69637e8e5dd2875d98cec0b558bf46b91ea0efec6d0724"

RDEPENDS:ruby-build = " \
 ruby-build-core \
 "
RDEPENDS:ruby-build-all = " \
 ruby-build \
 ruby-build-core \
 ruby-build-jruby \
 ruby-build-mruby \
 ruby-build-others \
 ruby-build-picoruby \
 ruby-build-ruby \
 ruby-build-truffleruby \
 "
RDEPENDS:ruby-build-core = " \
 bash \
 "
RDEPENDS:ruby-build-jruby = " \
 gcc-c++ \
 java-latest-openjdk-headless \
 make \
 ruby-build-core \
 "
RDEPENDS:ruby-build-mruby = " \
 ruby \
 ruby-build-core \
 rubygem-rake \
 "
RDEPENDS:ruby-build-others = " \
 ruby-build-core \
 "
RDEPENDS:ruby-build-picoruby = " \
 gcc \
 git-core \
 ruby \
 ruby-build-core \
 rubygem-rake \
 "
RDEPENDS:ruby-build-rbenv = " \
 bash \
 rbenv \
 ruby-build \
 "
RDEPENDS:ruby-build-ruby = " \
 gcc \
 libffi-devel \
 libyaml-devel \
 perl-File-Compare \
 perl-File-Copy \
 perl-FindBin \
 perl-IPC-Cmd \
 perl-Time-Piece \
 perl-interpreter \
 perl-lib \
 ruby-build-core \
 zlib-ng-compat-devel \
 "
RDEPENDS:ruby-build-truffleruby = " \
 gcc \
 libyaml-devel \
 ruby-build-core \
 "
