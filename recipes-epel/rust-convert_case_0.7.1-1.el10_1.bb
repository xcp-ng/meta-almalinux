# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-convert_case"
PV = "0.7.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-convert_case+default-devel \
 rust-convert_case+rand-devel \
 rust-convert_case+random-devel \
 rust-convert_case-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-convert_case-0.7.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6371a9c9a8a6367d59c341e8d19cd68d66b70c1f1de5ad554387eb6fb6edcf6a"

URI_x86_64_v2_rust-convert_case+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-convert_case+default-devel-0.7.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-convert_case+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-convert_case+default-devel}"
SRC_URI[x86_64_v2_rust-convert_case+default-devel.sha256sum] = "41b37d38677ba7b3d3e5511505c7490ae87ac1c1c62e571058b401e1d9273615"

URI_x86_64_v2_rust-convert_case+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-convert_case+rand-devel-0.7.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-convert_case+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-convert_case+rand-devel}"
SRC_URI[x86_64_v2_rust-convert_case+rand-devel.sha256sum] = "fae3cc9922bb536b0d83d63fe6decdc5af7f0319854e05fd088d31e215f4e567"

URI_x86_64_v2_rust-convert_case+random-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-convert_case+random-devel-0.7.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-convert_case+random-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-convert_case+random-devel}"
SRC_URI[x86_64_v2_rust-convert_case+random-devel.sha256sum] = "b6582637e3cef51b1e7a836a6669a8573f5810006bc8f1f6e1cdcd77f81cc833"

URI_x86_64_v2_rust-convert_case-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-convert_case-devel-0.7.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-convert_case-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-convert_case-devel}"
SRC_URI[x86_64_v2_rust-convert_case-devel.sha256sum] = "9cd8bc49ae6bab9104baf66e7f30a96124c5d94f1b8e9bf56d3d3d34b1d8b23e"

URI_aarch64_rust-convert_case+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-convert_case+default-devel-0.7.1-1.el10_1.noarch.rpm;name=aarch64_rust-convert_case+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-convert_case+default-devel}"
SRC_URI[aarch64_rust-convert_case+default-devel.sha256sum] = "dbe648ce8c7cfcf2ccfe6f032dc0b1eba6666b643570bad4ec3804cf089fa741"

URI_aarch64_rust-convert_case+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-convert_case+rand-devel-0.7.1-1.el10_1.noarch.rpm;name=aarch64_rust-convert_case+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-convert_case+rand-devel}"
SRC_URI[aarch64_rust-convert_case+rand-devel.sha256sum] = "78cd0d375a2b918fb8b2e0dc53ac5c4ddb2cea6d36e98dee0c2390dc1437ce8e"

URI_aarch64_rust-convert_case+random-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-convert_case+random-devel-0.7.1-1.el10_1.noarch.rpm;name=aarch64_rust-convert_case+random-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-convert_case+random-devel}"
SRC_URI[aarch64_rust-convert_case+random-devel.sha256sum] = "6a3993d65b9b558280098142216f2b0d2d367b60463d8dcb3ab32da94b66d49e"

URI_aarch64_rust-convert_case-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-convert_case-devel-0.7.1-1.el10_1.noarch.rpm;name=aarch64_rust-convert_case-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-convert_case-devel}"
SRC_URI[aarch64_rust-convert_case-devel.sha256sum] = "f7813434fd5b1a60ce135bacd8851b9dfc0d6b9229c121f9e2cabf121f9624b4"

RDEPENDS:rust-convert_case+default-devel = " \
 cargo \
 rust-convert_case-devel \
 "
RDEPENDS:rust-convert_case+rand-devel = " \
 cargo \
 rust-convert_case-devel \
 rust-rand0.8+default-devel \
 "
RDEPENDS:rust-convert_case+random-devel = " \
 cargo \
 rust-convert_case+rand-devel \
 rust-convert_case-devel \
 "
RDEPENDS:rust-convert_case-devel = " \
 cargo \
 rust-unicode-segmentation+default-devel \
 "
