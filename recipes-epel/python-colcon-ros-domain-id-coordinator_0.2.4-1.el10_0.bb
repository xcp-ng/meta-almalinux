# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-ros-domain-id-coordinator"
PV = "0.2.4"
PR = "1.el10_0"
PACKAGES = " \
 python3-colcon-ros-domain-id-coordinator \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-ros-domain-id-coordinator-0.2.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "262ac58ea0d1399ddc2dfa9a8b9afc4560dce17d2bda3f0b444a8ca53403f5b3"

URI_x86_64_v2_python3-colcon-ros-domain-id-coordinator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-ros-domain-id-coordinator-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-ros-domain-id-coordinator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-ros-domain-id-coordinator}"
SRC_URI[x86_64_v2_python3-colcon-ros-domain-id-coordinator.sha256sum] = "8e654565c4871a63e853d8bd6a010bb6907a9728a71ef401d3d4729df813bfe5"

URI_aarch64_python3-colcon-ros-domain-id-coordinator = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-ros-domain-id-coordinator-0.2.4-1.el10_0.noarch.rpm;name=aarch64_python3-colcon-ros-domain-id-coordinator;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-ros-domain-id-coordinator}"
SRC_URI[aarch64_python3-colcon-ros-domain-id-coordinator.sha256sum] = "1b85e29e875bb96eb6eb547bcfa093612c316f83aed446d7e1bbccf50cac5e36"

RDEPENDS:python3-colcon-ros-domain-id-coordinator = " \
 python3 \
 python3-colcon-core \
 "
