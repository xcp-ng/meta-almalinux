# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-which"
PV = "8.0.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-which+default-devel \
 rust-which+real-sys-devel \
 rust-which+regex-devel \
 rust-which+tracing-devel \
 rust-which-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-which-8.0.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "019c336d62c10bd0f950c689512af1b8dcfad19e0e19a8579bff1a4554984544"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-which+default-devel-8.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-which+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-which+default-devel.sha256sum] = "2ddcf4a1ecaa613acda6af2224974e2c01d19da9d8c52f8bcf0cae513f56777e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-which+real-sys-devel-8.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-which+real-sys-devel;unpack=0"
SRC_URI[x86_64_v2_rust-which+real-sys-devel.sha256sum] = "848d37ea9ed1d494382c6b9f767648de1428a0d02b75e06c2d9fc77d15cf6c84"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-which+regex-devel-8.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-which+regex-devel;unpack=0"
SRC_URI[x86_64_v2_rust-which+regex-devel.sha256sum] = "8870d73ef35ab393433385e64347b19fa1ed9705af35e3a3c82c1b3b1b774b03"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-which+tracing-devel-8.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-which+tracing-devel;unpack=0"
SRC_URI[x86_64_v2_rust-which+tracing-devel.sha256sum] = "6c14ed02be0fd704c5e767b8e7bac927d96b9feda8024d583facf8aa3c47cf45"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-which-devel-8.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-which-devel;unpack=0"
SRC_URI[x86_64_v2_rust-which-devel.sha256sum] = "eba2a7eb49301acb84eb0469ee5ca7dc97b566e6ec7a83c35c48fdaa0e48310a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-which+default-devel-8.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-which+default-devel;unpack=0"
SRC_URI[aarch64_rust-which+default-devel.sha256sum] = "9940332d09a07982039b47af0f3634a776f9a3d7495d60347f3b1606792e3740"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-which+real-sys-devel-8.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-which+real-sys-devel;unpack=0"
SRC_URI[aarch64_rust-which+real-sys-devel.sha256sum] = "2e26d1b3d7c1456bd9efb9c9b6000a6c9cd7dc841e53264b0dd46f4989de6959"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-which+regex-devel-8.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-which+regex-devel;unpack=0"
SRC_URI[aarch64_rust-which+regex-devel.sha256sum] = "363af2a9847310dc85ae20fb88b237957b71f2a8a73a662eb28d1f7400ee7154"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-which+tracing-devel-8.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-which+tracing-devel;unpack=0"
SRC_URI[aarch64_rust-which+tracing-devel.sha256sum] = "313bc0b8e91dd94a8903e2cba9179cc4dfaaaf2ee37d09af8d713156f3b1f1e9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-which-devel-8.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-which-devel;unpack=0"
SRC_URI[aarch64_rust-which-devel.sha256sum] = "f2558334ff35984cfade43dee6dc3f99bc1bfb392863f7042daeed3d48605571"

RDEPENDS:rust-which+default-devel = " \
 cargo \
 rust-which+real-sys-devel \
 rust-which-devel \
 "
RDEPENDS:rust-which+real-sys-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-which-devel \
 "
RDEPENDS:rust-which+regex-devel = " \
 cargo \
 rust-regex+default-devel \
 rust-which-devel \
 "
RDEPENDS:rust-which+tracing-devel = " \
 cargo \
 rust-tracing-devel \
 rust-which-devel \
 "
RDEPENDS:rust-which-devel = " \
 cargo \
 rust \
 "
