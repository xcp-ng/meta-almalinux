# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "konqueror"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 konqueror \
 konqueror-devel \
 konqueror-libs \
 kwebenginepart \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/konqueror-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af14a346f3d828718c657776ec649533bb32b7bea8f2fd1aaf437a7535165505"

URI_x86_64_v2_konqueror = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konqueror-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konqueror;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_konqueror}"
SRC_URI[x86_64_v2_konqueror.sha256sum] = "cc29c7314948da28ae36c25666fa816f0d60471c35ce54642800ac5bfed2c248"

URI_x86_64_v2_konqueror-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konqueror-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konqueror-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_konqueror-devel}"
SRC_URI[x86_64_v2_konqueror-devel.sha256sum] = "9274bb54b91f07eec877605d22b4cffe22c4ec823958a182a24d679f14a7be8b"

URI_x86_64_v2_konqueror-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konqueror-libs-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konqueror-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_konqueror-libs}"
SRC_URI[x86_64_v2_konqueror-libs.sha256sum] = "fc50dafce0cd2519a6b66497b21db45d6892dee8ff4811439ef4d7d3a830cc8d"

URI_x86_64_v2_kwebenginepart = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwebenginepart-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwebenginepart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwebenginepart}"
SRC_URI[x86_64_v2_kwebenginepart.sha256sum] = "2573928c5b31099c1523b1fc6ebf3183a055329dabb41a9af2e169d7278c81de"

URI_aarch64_konqueror = "${EPEL_MIRROR}/aarch64/Packages/k/konqueror-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_konqueror;unpack=0"
SRC_URI:append = " ${URI_aarch64_konqueror}"
SRC_URI[aarch64_konqueror.sha256sum] = "176e9f8377fdd3ffa27f17d5edf13930d2c7b7a0ef65a835f05105792f6aae9b"

URI_aarch64_konqueror-devel = "${EPEL_MIRROR}/aarch64/Packages/k/konqueror-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_konqueror-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_konqueror-devel}"
SRC_URI[aarch64_konqueror-devel.sha256sum] = "310f9084b77102905a9bf8e758043eae05ad6c05ed275e0f41c2d41fa95587ff"

URI_aarch64_konqueror-libs = "${EPEL_MIRROR}/aarch64/Packages/k/konqueror-libs-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_konqueror-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_konqueror-libs}"
SRC_URI[aarch64_konqueror-libs.sha256sum] = "59fb439aaf9ad6c5cc2a8ad696e813fb0dfdb1597b8a070c8dc918793fdff230"

URI_aarch64_kwebenginepart = "${EPEL_MIRROR}/aarch64/Packages/k/kwebenginepart-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kwebenginepart;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwebenginepart}"
SRC_URI[aarch64_kwebenginepart.sha256sum] = "0fee5430488d52ce6e4ac8a664e1bdb621f986129b79a61ba75f40049dd46e99"

RDEPENDS:konqueror = " \
 glibc \
 hicolor-icon-theme \
 keditbookmarks \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kparts \
 kf6-kservice \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-sonnet \
 konqueror-libs \
 kwebenginepart \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:konqueror-devel = " \
 cmake-filesystem \
 konqueror \
 konqueror-libs \
 "
RDEPENDS:konqueror-libs = " \
 glibc \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdesu \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-kservice \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-solid \
 konqueror \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 zlib-ng-compat \
 "
RDEPENDS:kwebenginepart = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-kservice \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-sonnet \
 konqueror-libs \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
