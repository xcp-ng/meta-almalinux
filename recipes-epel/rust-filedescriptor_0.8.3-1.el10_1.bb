# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-filedescriptor"
PV = "0.8.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-filedescriptor+default-devel \
 rust-filedescriptor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-filedescriptor-0.8.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8364360e9120c5095bb14400321801d6e1107c7d4cb2fdf34892a190c430bcf7"

URI_x86_64_v2_rust-filedescriptor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-filedescriptor+default-devel-0.8.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-filedescriptor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-filedescriptor+default-devel}"
SRC_URI[x86_64_v2_rust-filedescriptor+default-devel.sha256sum] = "8528cb14a8455ac5c4c7207966d82d19d547feeeddb96b24b2bdae50e6331dee"

URI_x86_64_v2_rust-filedescriptor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-filedescriptor-devel-0.8.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-filedescriptor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-filedescriptor-devel}"
SRC_URI[x86_64_v2_rust-filedescriptor-devel.sha256sum] = "b6d3490335652029a48654f1d4656e698c1d2e713d2304d7f6904f89d1b9636e"

URI_aarch64_rust-filedescriptor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-filedescriptor+default-devel-0.8.3-1.el10_1.noarch.rpm;name=aarch64_rust-filedescriptor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-filedescriptor+default-devel}"
SRC_URI[aarch64_rust-filedescriptor+default-devel.sha256sum] = "a0b434653c6d1af959eea9652455cbacb95b8fb9f5370dd124f574eb83910339"

URI_aarch64_rust-filedescriptor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-filedescriptor-devel-0.8.3-1.el10_1.noarch.rpm;name=aarch64_rust-filedescriptor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-filedescriptor-devel}"
SRC_URI[aarch64_rust-filedescriptor-devel.sha256sum] = "ffe74583dd723f1617f3cf5b3a9fe29bba3bd98ec5f1902453bf3f4e45331d94"

RDEPENDS:rust-filedescriptor+default-devel = " \
 cargo \
 rust-filedescriptor-devel \
 "
RDEPENDS:rust-filedescriptor-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-thiserror1+default-devel \
 "
