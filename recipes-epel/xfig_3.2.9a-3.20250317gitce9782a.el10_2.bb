# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xfig"
PV = "3.2.9a"
PR = "3.20250317gitce9782a.el10_2"
PACKAGES = " \
 xfig \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xfig-3.2.9a-3.20250317gitce9782a.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fcdc0f58ca25504da8eae19df74055a56d148f95917b8fc3b97a154f08356d59"

URI_x86_64_v2_xfig = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xfig-3.2.9a-3.20250317gitce9782a.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xfig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xfig}"
SRC_URI[x86_64_v2_xfig.sha256sum] = "b4f92fbf04e6fca8694c05d9e6d5cd70cf97e6aef2afa20e30d76e80ed9e850d"

URI_aarch64_xfig = "${EPEL_MIRROR}/aarch64/Packages/x/xfig-3.2.9a-3.20250317gitce9782a.el10_2.aarch64.rpm;name=aarch64_xfig;unpack=0"
SRC_URI:append = " ${URI_aarch64_xfig}"
SRC_URI[aarch64_xfig.sha256sum] = "8e7685f299d6dac9c9d04987cfc6d104f6e138378b5c9a1fbc47b697fabbd568"

RDEPENDS:xfig = " \
 Xaw3d \
 fontconfig \
 ghostscript \
 glibc \
 libX11 \
 libXft \
 libXpm \
 libXt \
 libjpeg-turbo \
 libpng \
 libtiff \
 transfig \
 xorg-x11-fonts-misc \
 "
