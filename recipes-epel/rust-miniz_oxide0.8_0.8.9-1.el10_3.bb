# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-miniz_oxide0.8"
PV = "0.8.9"
PR = "1.el10_3"
PACKAGES = " \
 rust-miniz_oxide0.8+block-boundary-devel \
 rust-miniz_oxide0.8+default-devel \
 rust-miniz_oxide0.8+serde-devel \
 rust-miniz_oxide0.8+simd-adler32-devel \
 rust-miniz_oxide0.8+simd-devel \
 rust-miniz_oxide0.8+std-devel \
 rust-miniz_oxide0.8+with-alloc-devel \
 rust-miniz_oxide0.8-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-miniz_oxide0.8-0.8.9-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa38cc09bc288865bf0556e9d81232fde72336f238d634d90b988d44c972385d"

URI_x86_64_v2_rust-miniz_oxide0.8+block-boundary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide0.8+block-boundary-devel-0.8.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide0.8+block-boundary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miniz_oxide0.8+block-boundary-devel}"
SRC_URI[x86_64_v2_rust-miniz_oxide0.8+block-boundary-devel.sha256sum] = "c2e0fe17f7aea1216c7bee4e918f417b45c04d0aa80d65ad4d2841dc74e20e56"

URI_x86_64_v2_rust-miniz_oxide0.8+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide0.8+default-devel-0.8.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miniz_oxide0.8+default-devel}"
SRC_URI[x86_64_v2_rust-miniz_oxide0.8+default-devel.sha256sum] = "545db886beabd3cafaf535b505ae47dfb415f0e081937fc7631a9c741bb02368"

URI_x86_64_v2_rust-miniz_oxide0.8+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide0.8+serde-devel-0.8.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide0.8+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miniz_oxide0.8+serde-devel}"
SRC_URI[x86_64_v2_rust-miniz_oxide0.8+serde-devel.sha256sum] = "5e9315e457156d1d273c25fd3f94acf0654d3cc777b66ab58d769778b92b206f"

URI_x86_64_v2_rust-miniz_oxide0.8+simd-adler32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide0.8+simd-adler32-devel-0.8.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide0.8+simd-adler32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miniz_oxide0.8+simd-adler32-devel}"
SRC_URI[x86_64_v2_rust-miniz_oxide0.8+simd-adler32-devel.sha256sum] = "cb6d2a5e0dcdb474b7fdc1c24351699c19fa567ab048cc96ff54e0f3cebb20a2"

URI_x86_64_v2_rust-miniz_oxide0.8+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide0.8+simd-devel-0.8.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide0.8+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miniz_oxide0.8+simd-devel}"
SRC_URI[x86_64_v2_rust-miniz_oxide0.8+simd-devel.sha256sum] = "502c95cffa3e3320d1003ed319cf601d341cd47835927d80760f9ea59c394ccb"

URI_x86_64_v2_rust-miniz_oxide0.8+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide0.8+std-devel-0.8.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide0.8+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miniz_oxide0.8+std-devel}"
SRC_URI[x86_64_v2_rust-miniz_oxide0.8+std-devel.sha256sum] = "c2df5f88f77babd1a103fe54e658574935b446ddeea5398ccea858f1c38efe62"

URI_x86_64_v2_rust-miniz_oxide0.8+with-alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide0.8+with-alloc-devel-0.8.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide0.8+with-alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miniz_oxide0.8+with-alloc-devel}"
SRC_URI[x86_64_v2_rust-miniz_oxide0.8+with-alloc-devel.sha256sum] = "ecf5b75df40f39e783dfa9d1b570c9242c5a7078a4afeed73f767810c798f4ae"

URI_x86_64_v2_rust-miniz_oxide0.8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide0.8-devel-0.8.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide0.8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miniz_oxide0.8-devel}"
SRC_URI[x86_64_v2_rust-miniz_oxide0.8-devel.sha256sum] = "9728da6ce05fa41b8d439fa59462bed4a9678a8e39ae06facd78631abc06c288"

URI_aarch64_rust-miniz_oxide0.8+block-boundary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide0.8+block-boundary-devel-0.8.9-1.el10_3.noarch.rpm;name=aarch64_rust-miniz_oxide0.8+block-boundary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miniz_oxide0.8+block-boundary-devel}"
SRC_URI[aarch64_rust-miniz_oxide0.8+block-boundary-devel.sha256sum] = "564a371525b8192904c4f6232933cfc5ed31c0889193b15db820f2c3afbff18c"

URI_aarch64_rust-miniz_oxide0.8+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide0.8+default-devel-0.8.9-1.el10_3.noarch.rpm;name=aarch64_rust-miniz_oxide0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miniz_oxide0.8+default-devel}"
SRC_URI[aarch64_rust-miniz_oxide0.8+default-devel.sha256sum] = "a4d445e36d6248b4d19de1a93c97c4e0355c774a37fd0ff6f15007ba75877351"

URI_aarch64_rust-miniz_oxide0.8+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide0.8+serde-devel-0.8.9-1.el10_3.noarch.rpm;name=aarch64_rust-miniz_oxide0.8+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miniz_oxide0.8+serde-devel}"
SRC_URI[aarch64_rust-miniz_oxide0.8+serde-devel.sha256sum] = "4d0cd460fcf2e70f720a92b3bdc6c454d45af3267acc674f36206f9974c7f1d7"

URI_aarch64_rust-miniz_oxide0.8+simd-adler32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide0.8+simd-adler32-devel-0.8.9-1.el10_3.noarch.rpm;name=aarch64_rust-miniz_oxide0.8+simd-adler32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miniz_oxide0.8+simd-adler32-devel}"
SRC_URI[aarch64_rust-miniz_oxide0.8+simd-adler32-devel.sha256sum] = "175d4629f930b8538f818c5d606c7f0ea1dbf79da5051b095cde767376a01e4a"

URI_aarch64_rust-miniz_oxide0.8+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide0.8+simd-devel-0.8.9-1.el10_3.noarch.rpm;name=aarch64_rust-miniz_oxide0.8+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miniz_oxide0.8+simd-devel}"
SRC_URI[aarch64_rust-miniz_oxide0.8+simd-devel.sha256sum] = "c1421c1c7176031a9a4136751d837f509f6d50c3cdbc50e308b643865de84eea"

URI_aarch64_rust-miniz_oxide0.8+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide0.8+std-devel-0.8.9-1.el10_3.noarch.rpm;name=aarch64_rust-miniz_oxide0.8+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miniz_oxide0.8+std-devel}"
SRC_URI[aarch64_rust-miniz_oxide0.8+std-devel.sha256sum] = "0e4cab2cea59699dd4ceb43df2f58fdf65ad05045cf28d0d43920ec8b5bc883e"

URI_aarch64_rust-miniz_oxide0.8+with-alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide0.8+with-alloc-devel-0.8.9-1.el10_3.noarch.rpm;name=aarch64_rust-miniz_oxide0.8+with-alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miniz_oxide0.8+with-alloc-devel}"
SRC_URI[aarch64_rust-miniz_oxide0.8+with-alloc-devel.sha256sum] = "e962cf2defba52dbf44edec59d748d5365963d975ea48712f807bc362351cd50"

URI_aarch64_rust-miniz_oxide0.8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide0.8-devel-0.8.9-1.el10_3.noarch.rpm;name=aarch64_rust-miniz_oxide0.8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miniz_oxide0.8-devel}"
SRC_URI[aarch64_rust-miniz_oxide0.8-devel.sha256sum] = "4274040e59b771a98b472aecf5264c6c8f9471a161f22023d5895481ba43b825"

RDEPENDS:rust-miniz_oxide0.8+block-boundary-devel = " \
 cargo \
 rust-miniz_oxide0.8-devel \
 "
RDEPENDS:rust-miniz_oxide0.8+default-devel = " \
 cargo \
 rust-miniz_oxide0.8+with-alloc-devel \
 rust-miniz_oxide0.8-devel \
 "
RDEPENDS:rust-miniz_oxide0.8+serde-devel = " \
 cargo \
 rust-miniz_oxide0.8-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-miniz_oxide0.8+simd-adler32-devel = " \
 cargo \
 rust-miniz_oxide0.8-devel \
 rust-simd-adler32-devel \
 "
RDEPENDS:rust-miniz_oxide0.8+simd-devel = " \
 cargo \
 rust-miniz_oxide0.8+simd-adler32-devel \
 rust-miniz_oxide0.8-devel \
 "
RDEPENDS:rust-miniz_oxide0.8+std-devel = " \
 cargo \
 rust-miniz_oxide0.8-devel \
 "
RDEPENDS:rust-miniz_oxide0.8+with-alloc-devel = " \
 cargo \
 rust-miniz_oxide0.8-devel \
 "
RDEPENDS:rust-miniz_oxide0.8-devel = " \
 cargo \
 rust-adler2-devel \
 "
