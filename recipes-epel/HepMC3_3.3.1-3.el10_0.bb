# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "HepMC3"
PV = "3.3.1"
PR = "3.el10_0"
PACKAGES = " \
 HepMC3 \
 HepMC3-devel \
 HepMC3-doc \
 HepMC3-interfaces-devel \
 HepMC3-protobufIO \
 HepMC3-protobufIO-devel \
 HepMC3-rootIO \
 HepMC3-rootIO-devel \
 HepMC3-search \
 HepMC3-search-devel \
 python3-HepMC3 \
 python3-HepMC3-protobufIO \
 python3-HepMC3-rootIO \
 python3-HepMC3-search \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/HepMC3-3.3.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eff967323cc8df3eb9b68a6fe6b1fa9e5f32ecc7da9d3129e3c2a69503632b7a"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - HepMC3-rootIO: libCore.so.6.36()(64bit)
# - HepMC3-rootIO: libRIO.so.6.36()(64bit)
# - HepMC3-rootIO: libTree.so.6.36()(64bit)
# - python3-HepMC3-rootIO: libCore.so.6.36()(64bit)

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - HepMC3-rootIO: libCore.so.6.36()(64bit)
# - HepMC3-rootIO: libRIO.so.6.36()(64bit)
# - HepMC3-rootIO: libTree.so.6.36()(64bit)
# - python3-HepMC3-rootIO: libCore.so.6.36()(64bit)

URI_x86_64_v2_HepMC3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-3.3.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3}"
SRC_URI[x86_64_v2_HepMC3.sha256sum] = "50e0eb12e28d448dcaa747a8cf673c8f698884d31a9666c0b446f46c8d42d890"

URI_x86_64_v2_HepMC3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-devel-3.3.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-devel}"
SRC_URI[x86_64_v2_HepMC3-devel.sha256sum] = "e68cacafd49e81014d10107a59a581f90a7cfe9dff0d5c93a6c4bbc432a23df6"

URI_x86_64_v2_HepMC3-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-doc-3.3.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_HepMC3-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-doc}"
SRC_URI[x86_64_v2_HepMC3-doc.sha256sum] = "61a9ce57a78235825d73eb0510ffcb2da7634299f02be0e7a1bcb41b97ac3d82"

URI_x86_64_v2_HepMC3-interfaces-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-interfaces-devel-3.3.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_HepMC3-interfaces-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-interfaces-devel}"
SRC_URI[x86_64_v2_HepMC3-interfaces-devel.sha256sum] = "930065cf96e3ae242ffb9ecef95ae16d9b3a03cc57566993a00a8358ea1b3d14"

URI_x86_64_v2_HepMC3-protobufIO = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-protobufIO-3.3.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC3-protobufIO;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-protobufIO}"
SRC_URI[x86_64_v2_HepMC3-protobufIO.sha256sum] = "10fe82bb58945f4802b9375d54ec1eff0e26b2a491e2796e286e9681dd595b11"

URI_x86_64_v2_HepMC3-protobufIO-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-protobufIO-devel-3.3.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC3-protobufIO-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-protobufIO-devel}"
SRC_URI[x86_64_v2_HepMC3-protobufIO-devel.sha256sum] = "e3d791b9fbd51b03704a8797b1b9dd77126c82999fa6823b8f49a064167af207"

URI_x86_64_v2_HepMC3-rootIO = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-rootIO-3.3.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC3-rootIO;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-rootIO}"
SRC_URI[x86_64_v2_HepMC3-rootIO.sha256sum] = "90a0590c2c0a41f5f1f095410125f00d09e6fad42bdde4962575350453841340"

URI_x86_64_v2_HepMC3-rootIO-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-rootIO-devel-3.3.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC3-rootIO-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-rootIO-devel}"
SRC_URI[x86_64_v2_HepMC3-rootIO-devel.sha256sum] = "966b7bd0af5d595ff81c3d666c3d8c70b89dac8c47b1f097b2ccb88ad6ef1133"

URI_x86_64_v2_HepMC3-search = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-search-3.3.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC3-search;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-search}"
SRC_URI[x86_64_v2_HepMC3-search.sha256sum] = "ecf4e14b2dbcb1d9c145cc10580bb12ea015c6bb6af702138370c00871417713"

URI_x86_64_v2_HepMC3-search-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-search-devel-3.3.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC3-search-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-search-devel}"
SRC_URI[x86_64_v2_HepMC3-search-devel.sha256sum] = "6eb08b43577c023165a912235b12ff815d3e9d03037b5a934ff09048bd3e6ef8"

URI_x86_64_v2_python3-HepMC3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-HepMC3-3.3.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-HepMC3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-HepMC3}"
SRC_URI[x86_64_v2_python3-HepMC3.sha256sum] = "1ed34e8022dc31896f1a3d41720f67010a06cbb4c71424a1ebab06815ca1aff9"

URI_x86_64_v2_python3-HepMC3-protobufIO = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-HepMC3-protobufIO-3.3.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-HepMC3-protobufIO;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-HepMC3-protobufIO}"
SRC_URI[x86_64_v2_python3-HepMC3-protobufIO.sha256sum] = "446e2721222c0340cb34957192581862a1bb5690cf744b296c20760960d9bc5f"

URI_x86_64_v2_python3-HepMC3-rootIO = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-HepMC3-rootIO-3.3.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-HepMC3-rootIO;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-HepMC3-rootIO}"
SRC_URI[x86_64_v2_python3-HepMC3-rootIO.sha256sum] = "ecee6d3f19e0655509ca67ab6ce37f3c92e70c809c56019de5924afc254a08f3"

URI_x86_64_v2_python3-HepMC3-search = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-HepMC3-search-3.3.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-HepMC3-search;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-HepMC3-search}"
SRC_URI[x86_64_v2_python3-HepMC3-search.sha256sum] = "5f24dce6a34d58211d3c5fed305462bf55bfebe31a845455352c9b30c56cbc8e"

URI_aarch64_HepMC3 = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-3.3.1-3.el10_0.aarch64.rpm;name=aarch64_HepMC3;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3}"
SRC_URI[aarch64_HepMC3.sha256sum] = "e3145157b401cef7aeb08443ef232d85deb7d1672ebbde5805a1689c533b24f6"

URI_aarch64_HepMC3-devel = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-devel-3.3.1-3.el10_0.aarch64.rpm;name=aarch64_HepMC3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-devel}"
SRC_URI[aarch64_HepMC3-devel.sha256sum] = "683d5850a1361e73aed6a7412ed8020a6a52a46389e6253556bbdcdd706e0f1f"

URI_aarch64_HepMC3-doc = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-doc-3.3.1-3.el10_0.noarch.rpm;name=aarch64_HepMC3-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-doc}"
SRC_URI[aarch64_HepMC3-doc.sha256sum] = "4a4046e45a71196c8b6c908a249ac3c1977aaec58f9cd0e158d668009b581e29"

URI_aarch64_HepMC3-interfaces-devel = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-interfaces-devel-3.3.1-3.el10_0.noarch.rpm;name=aarch64_HepMC3-interfaces-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-interfaces-devel}"
SRC_URI[aarch64_HepMC3-interfaces-devel.sha256sum] = "b4a81357cfa422a36f74d4b78b2afb441617d3f60f8ce086e3c9d1407a295f60"

URI_aarch64_HepMC3-protobufIO = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-protobufIO-3.3.1-3.el10_0.aarch64.rpm;name=aarch64_HepMC3-protobufIO;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-protobufIO}"
SRC_URI[aarch64_HepMC3-protobufIO.sha256sum] = "b2cb5db7cb4a77138e67de09a1870a15e854dd2ad99d0ed046f25ed772d70d76"

URI_aarch64_HepMC3-protobufIO-devel = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-protobufIO-devel-3.3.1-3.el10_0.aarch64.rpm;name=aarch64_HepMC3-protobufIO-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-protobufIO-devel}"
SRC_URI[aarch64_HepMC3-protobufIO-devel.sha256sum] = "d8131497f40e474ce65b668a76795937b19b7f88e2978831b72f1ade8a493f2f"

URI_aarch64_HepMC3-rootIO = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-rootIO-3.3.1-3.el10_0.aarch64.rpm;name=aarch64_HepMC3-rootIO;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-rootIO}"
SRC_URI[aarch64_HepMC3-rootIO.sha256sum] = "7e2de7c50468be54a06070a3984892adee750e6bbbcdd3b9c9441aa370dcd430"

URI_aarch64_HepMC3-rootIO-devel = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-rootIO-devel-3.3.1-3.el10_0.aarch64.rpm;name=aarch64_HepMC3-rootIO-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-rootIO-devel}"
SRC_URI[aarch64_HepMC3-rootIO-devel.sha256sum] = "1859ce5e32a85d0b2263f1e9d94dc1aa4631a4894f4af5d20fc23335915ab8d3"

URI_aarch64_HepMC3-search = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-search-3.3.1-3.el10_0.aarch64.rpm;name=aarch64_HepMC3-search;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-search}"
SRC_URI[aarch64_HepMC3-search.sha256sum] = "41851c746e1c099eade0dfc007d23ce80b83da53239fbd1df854c78b6fbad2ab"

URI_aarch64_HepMC3-search-devel = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-search-devel-3.3.1-3.el10_0.aarch64.rpm;name=aarch64_HepMC3-search-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-search-devel}"
SRC_URI[aarch64_HepMC3-search-devel.sha256sum] = "532b1f14c27d24dab76ecd665f84c1e6087c19aef82cccffbc82b7b6f707fde9"

URI_aarch64_python3-HepMC3 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-HepMC3-3.3.1-3.el10_0.aarch64.rpm;name=aarch64_python3-HepMC3;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-HepMC3}"
SRC_URI[aarch64_python3-HepMC3.sha256sum] = "f3b48830e4dc61465997f92c1a6c474d7a7d3be30e0a128a2b716e14ac6809cb"

URI_aarch64_python3-HepMC3-protobufIO = "${EPEL_MIRROR}/aarch64/Packages/p/python3-HepMC3-protobufIO-3.3.1-3.el10_0.aarch64.rpm;name=aarch64_python3-HepMC3-protobufIO;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-HepMC3-protobufIO}"
SRC_URI[aarch64_python3-HepMC3-protobufIO.sha256sum] = "2b1b6e3ac576c7d734e8f6d75d46ebeb656ad3063d6b182f0bdaabbbcde30038"

URI_aarch64_python3-HepMC3-rootIO = "${EPEL_MIRROR}/aarch64/Packages/p/python3-HepMC3-rootIO-3.3.1-3.el10_0.aarch64.rpm;name=aarch64_python3-HepMC3-rootIO;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-HepMC3-rootIO}"
SRC_URI[aarch64_python3-HepMC3-rootIO.sha256sum] = "c423c87ec33930d0f03a354a8e9e233edeb33e99c616487b198957a7786bb184"

URI_aarch64_python3-HepMC3-search = "${EPEL_MIRROR}/aarch64/Packages/p/python3-HepMC3-search-3.3.1-3.el10_0.aarch64.rpm;name=aarch64_python3-HepMC3-search;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-HepMC3-search}"
SRC_URI[aarch64_python3-HepMC3-search.sha256sum] = "3e7a03aa428aff0049c6917cdbd96d7faa815156f755c220618031dc451259d7"

RDEPENDS:HepMC3 = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:HepMC3-devel = " \
 HepMC3 \
 bash \
 "
RDEPENDS:HepMC3-doc = " \
 "
RDEPENDS:HepMC3-interfaces-devel = " \
 HepMC3-devel \
 "
RDEPENDS:HepMC3-protobufIO = " \
 HepMC3 \
 glibc \
 libgcc \
 libstdc++ \
 protobuf \
 "
RDEPENDS:HepMC3-protobufIO-devel = " \
 HepMC3-devel \
 HepMC3-protobufIO \
 "
RDEPENDS:HepMC3-rootIO = " \
 HepMC3 \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:HepMC3-rootIO-devel = " \
 HepMC3-devel \
 HepMC3-rootIO \
 "
RDEPENDS:HepMC3-search = " \
 HepMC3 \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:HepMC3-search-devel = " \
 HepMC3-devel \
 HepMC3-search \
 "
RDEPENDS:python3-HepMC3 = " \
 HepMC3 \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
RDEPENDS:python3-HepMC3-protobufIO = " \
 HepMC3 \
 HepMC3-protobufIO \
 glibc \
 libgcc \
 libstdc++ \
 protobuf \
 python3 \
 python3-HepMC3 \
 "
RDEPENDS:python3-HepMC3-rootIO = " \
 HepMC3 \
 HepMC3-rootIO \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-HepMC3 \
 "
RDEPENDS:python3-HepMC3-search = " \
 HepMC3 \
 HepMC3-search \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-HepMC3 \
 "
