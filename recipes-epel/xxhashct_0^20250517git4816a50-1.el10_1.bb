# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xxhashct"
PV = "0^20250517git4816a50"
PR = "1.el10_1"
PACKAGES = " \
 xxhashct-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xxhashct-0^20250517git4816a50-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04d1a1d70795688e83026347565165a747fbda75abe7e518864a3e37294b3807"

URI_x86_64_v2_xxhashct-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xxhashct-devel-0^20250517git4816a50-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_xxhashct-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xxhashct-devel}"
SRC_URI[x86_64_v2_xxhashct-devel.sha256sum] = "dffaad7955f8cb7907a4f25644b33aef292df5ab7ba7a122de9093875e96fa93"

URI_aarch64_xxhashct-devel = "${EPEL_MIRROR}/aarch64/Packages/x/xxhashct-devel-0^20250517git4816a50-1.el10_1.noarch.rpm;name=aarch64_xxhashct-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xxhashct-devel}"
SRC_URI[aarch64_xxhashct-devel.sha256sum] = "8db3c5d55f5926d7e1f78d5d03ed73f84753d0b67eab6d24da3d19c552309fd0"

RDEPENDS:xxhashct-devel = " \
 "
