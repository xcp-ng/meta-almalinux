# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sec1"
PV = "0.7.3"
PR = "4.el10_0"
PACKAGES = " \
 rust-sec1+alloc-devel \
 rust-sec1+default-devel \
 rust-sec1+der-devel \
 rust-sec1+pem-devel \
 rust-sec1+pkcs8-devel \
 rust-sec1+point-devel \
 rust-sec1+serde-devel \
 rust-sec1+std-devel \
 rust-sec1+subtle-devel \
 rust-sec1+zeroize-devel \
 rust-sec1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sec1-0.7.3-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c76af8177fe1175b710f9583cdb377024d98e651e8d3f2cf272ac155e38ff6e"

URI_x86_64_v2_rust-sec1+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sec1+alloc-devel-0.7.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sec1+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sec1+alloc-devel}"
SRC_URI[x86_64_v2_rust-sec1+alloc-devel.sha256sum] = "bcf87ba52b5200dda3451c4bd653cc075d08828a1b222a30525352b118bb99bc"

URI_x86_64_v2_rust-sec1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sec1+default-devel-0.7.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sec1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sec1+default-devel}"
SRC_URI[x86_64_v2_rust-sec1+default-devel.sha256sum] = "aca8fba94804c9719e8e450794856cd2a1cff3e39ca6b1e28f1a71d90386af25"

URI_x86_64_v2_rust-sec1+der-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sec1+der-devel-0.7.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sec1+der-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sec1+der-devel}"
SRC_URI[x86_64_v2_rust-sec1+der-devel.sha256sum] = "00d3a6f9c221c0ca262622c65e4a360477be293f977c96801719e1d0307bdd27"

URI_x86_64_v2_rust-sec1+pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sec1+pem-devel-0.7.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sec1+pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sec1+pem-devel}"
SRC_URI[x86_64_v2_rust-sec1+pem-devel.sha256sum] = "acc3f42e7a83be6ef4a47794a4b79783cb9408fadbb0945fa3ba7f7a423233f8"

URI_x86_64_v2_rust-sec1+pkcs8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sec1+pkcs8-devel-0.7.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sec1+pkcs8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sec1+pkcs8-devel}"
SRC_URI[x86_64_v2_rust-sec1+pkcs8-devel.sha256sum] = "5d00636f8cbae18e01360139752b11d283979307456a085933250f846abcc50b"

URI_x86_64_v2_rust-sec1+point-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sec1+point-devel-0.7.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sec1+point-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sec1+point-devel}"
SRC_URI[x86_64_v2_rust-sec1+point-devel.sha256sum] = "591cc03305a1410e87b03b44dba77b243c687118786645510c87b4a0591cf806"

URI_x86_64_v2_rust-sec1+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sec1+serde-devel-0.7.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sec1+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sec1+serde-devel}"
SRC_URI[x86_64_v2_rust-sec1+serde-devel.sha256sum] = "977b650a49a4d1f26061887c7c0c8d92431e2edd9e13358fd2ef00c9ac4090fe"

URI_x86_64_v2_rust-sec1+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sec1+std-devel-0.7.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sec1+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sec1+std-devel}"
SRC_URI[x86_64_v2_rust-sec1+std-devel.sha256sum] = "ace4828ea5e10be01bb11ffe6971ed162ecb945b5cdb3b2ae6f057fea30e6596"

URI_x86_64_v2_rust-sec1+subtle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sec1+subtle-devel-0.7.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sec1+subtle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sec1+subtle-devel}"
SRC_URI[x86_64_v2_rust-sec1+subtle-devel.sha256sum] = "25ba0a24f8f757db2c60013bdaeec605a24c9efc69a916df0be725787f72074d"

URI_x86_64_v2_rust-sec1+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sec1+zeroize-devel-0.7.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sec1+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sec1+zeroize-devel}"
SRC_URI[x86_64_v2_rust-sec1+zeroize-devel.sha256sum] = "0ad3f068b9c44e74e38faf9f3216f9fa4679a97939ebabda55161bc7837dd1bd"

URI_x86_64_v2_rust-sec1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sec1-devel-0.7.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sec1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sec1-devel}"
SRC_URI[x86_64_v2_rust-sec1-devel.sha256sum] = "0a782b6af32a99ea3518f392ed297b65125fef80e0bc2552a5ff64b045d0a6fe"

URI_aarch64_rust-sec1+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sec1+alloc-devel-0.7.3-4.el10_0.noarch.rpm;name=aarch64_rust-sec1+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sec1+alloc-devel}"
SRC_URI[aarch64_rust-sec1+alloc-devel.sha256sum] = "ca16c640da82c5f46a46afe5f3ebef0278f8a4221626a3d7f5bbc81f30ebbb9c"

URI_aarch64_rust-sec1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sec1+default-devel-0.7.3-4.el10_0.noarch.rpm;name=aarch64_rust-sec1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sec1+default-devel}"
SRC_URI[aarch64_rust-sec1+default-devel.sha256sum] = "76c2d77dcf064991244a37ffd76a46e5fbb486b0ab10fd5fa89b17b93b7d7a47"

URI_aarch64_rust-sec1+der-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sec1+der-devel-0.7.3-4.el10_0.noarch.rpm;name=aarch64_rust-sec1+der-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sec1+der-devel}"
SRC_URI[aarch64_rust-sec1+der-devel.sha256sum] = "7f59c353dbfa7e117d611feec310a3b003e56d3f5ddd3f94dc2d516b3fba1b5c"

URI_aarch64_rust-sec1+pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sec1+pem-devel-0.7.3-4.el10_0.noarch.rpm;name=aarch64_rust-sec1+pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sec1+pem-devel}"
SRC_URI[aarch64_rust-sec1+pem-devel.sha256sum] = "3ca047cf6a9bb8720c2b7e39885e496ea33dbd1eb6ab870e1d6e0e35d963cc80"

URI_aarch64_rust-sec1+pkcs8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sec1+pkcs8-devel-0.7.3-4.el10_0.noarch.rpm;name=aarch64_rust-sec1+pkcs8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sec1+pkcs8-devel}"
SRC_URI[aarch64_rust-sec1+pkcs8-devel.sha256sum] = "374782bffaad2dfa361456c2095544d1a00f537d4728a9b8b42eb80492a505a5"

URI_aarch64_rust-sec1+point-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sec1+point-devel-0.7.3-4.el10_0.noarch.rpm;name=aarch64_rust-sec1+point-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sec1+point-devel}"
SRC_URI[aarch64_rust-sec1+point-devel.sha256sum] = "b09bb2627bc3d1760406714a1e03f66332c4d3b05ede94327798ec3cc889d819"

URI_aarch64_rust-sec1+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sec1+serde-devel-0.7.3-4.el10_0.noarch.rpm;name=aarch64_rust-sec1+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sec1+serde-devel}"
SRC_URI[aarch64_rust-sec1+serde-devel.sha256sum] = "c75313b57cc5e6e1df30fd0a7fc6a3f47c4aa4f60189ca7548029aa528cf945a"

URI_aarch64_rust-sec1+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sec1+std-devel-0.7.3-4.el10_0.noarch.rpm;name=aarch64_rust-sec1+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sec1+std-devel}"
SRC_URI[aarch64_rust-sec1+std-devel.sha256sum] = "c64d9e4fcd1ebb436525935074333419b44dcdc8a594c127317a50bbd04e174f"

URI_aarch64_rust-sec1+subtle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sec1+subtle-devel-0.7.3-4.el10_0.noarch.rpm;name=aarch64_rust-sec1+subtle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sec1+subtle-devel}"
SRC_URI[aarch64_rust-sec1+subtle-devel.sha256sum] = "5b50118254a30366ed35797ebfaac1f1e0f4e88db0b1a8bb3c0035e38cf60888"

URI_aarch64_rust-sec1+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sec1+zeroize-devel-0.7.3-4.el10_0.noarch.rpm;name=aarch64_rust-sec1+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sec1+zeroize-devel}"
SRC_URI[aarch64_rust-sec1+zeroize-devel.sha256sum] = "bca18c13915002dee96844abf24d4835cb81aa41ef1df9fed2cead9822d81b26"

URI_aarch64_rust-sec1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sec1-devel-0.7.3-4.el10_0.noarch.rpm;name=aarch64_rust-sec1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sec1-devel}"
SRC_URI[aarch64_rust-sec1-devel.sha256sum] = "d8d3bd76eb86f7ce64491f49c82690439230552fae85915b1ea609985edb05d7"

RDEPENDS:rust-sec1+alloc-devel = " \
 cargo \
 rust-der+alloc-devel \
 rust-der+default-devel \
 rust-der+oid-devel \
 rust-pkcs8+alloc-devel \
 rust-pkcs8-devel \
 rust-sec1-devel \
 rust-zeroize+alloc-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-sec1+default-devel = " \
 cargo \
 rust-sec1+der-devel \
 rust-sec1+point-devel \
 rust-sec1-devel \
 "
RDEPENDS:rust-sec1+der-devel = " \
 cargo \
 rust-der+default-devel \
 rust-der+oid-devel \
 rust-sec1+zeroize-devel \
 rust-sec1-devel \
 "
RDEPENDS:rust-sec1+pem-devel = " \
 cargo \
 rust-der+default-devel \
 rust-der+oid-devel \
 rust-der+pem-devel \
 rust-pkcs8+pem-devel \
 rust-pkcs8-devel \
 rust-sec1+alloc-devel \
 rust-sec1-devel \
 "
RDEPENDS:rust-sec1+pkcs8-devel = " \
 cargo \
 rust-pkcs8-devel \
 rust-sec1-devel \
 "
RDEPENDS:rust-sec1+point-devel = " \
 cargo \
 rust-base16ct-devel \
 rust-generic-array-devel \
 rust-sec1-devel \
 "
RDEPENDS:rust-sec1+serde-devel = " \
 cargo \
 rust-sec1-devel \
 rust-serdect+alloc-devel \
 rust-serdect-devel \
 "
RDEPENDS:rust-sec1+std-devel = " \
 cargo \
 rust-der+default-devel \
 rust-der+oid-devel \
 rust-der+std-devel \
 rust-sec1+alloc-devel \
 rust-sec1-devel \
 "
RDEPENDS:rust-sec1+subtle-devel = " \
 cargo \
 rust-sec1-devel \
 rust-subtle-devel \
 "
RDEPENDS:rust-sec1+zeroize-devel = " \
 cargo \
 rust-der+default-devel \
 rust-der+oid-devel \
 rust-der+zeroize-devel \
 rust-sec1-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-sec1-devel = " \
 cargo \
 rust \
 "
