# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-asn1_derive"
PV = "0.24.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-asn1_derive+default-devel \
 rust-asn1_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-asn1_derive-0.24.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca9b4168c2252b45b317b658aeef0a8219a3776033887f84d21428f59aa67056"

URI_x86_64_v2_rust-asn1_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1_derive+default-devel-0.24.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1_derive+default-devel}"
SRC_URI[x86_64_v2_rust-asn1_derive+default-devel.sha256sum] = "62fb73dcdf1d676dfe83c139905e378c6b2e43f6e5222951496ee13405cb81d4"

URI_x86_64_v2_rust-asn1_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1_derive-devel-0.24.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1_derive-devel}"
SRC_URI[x86_64_v2_rust-asn1_derive-devel.sha256sum] = "e6b97df8fa9a9bf945f7c3d2090894c1855766568b67ae772caed4c21eefc633"

URI_aarch64_rust-asn1_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1_derive+default-devel-0.24.1-1.el10_3.noarch.rpm;name=aarch64_rust-asn1_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1_derive+default-devel}"
SRC_URI[aarch64_rust-asn1_derive+default-devel.sha256sum] = "68d7eeff0f492dcfdd650af23277b90535ade81add5885624063d7f768ab28f7"

URI_aarch64_rust-asn1_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1_derive-devel-0.24.1-1.el10_3.noarch.rpm;name=aarch64_rust-asn1_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1_derive-devel}"
SRC_URI[aarch64_rust-asn1_derive-devel.sha256sum] = "8c1188afd7b958595ea885163b07491dbf948d7a8c7af96857d8b4157f1e6265"

RDEPENDS:rust-asn1_derive+default-devel = " \
 cargo \
 rust-asn1_derive-devel \
 "
RDEPENDS:rust-asn1_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 "
