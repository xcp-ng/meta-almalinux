# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Tk-EntryCheck"
PV = "0.04"
PR = "39.el10_0"
PACKAGES = " \
 perl-Tk-EntryCheck \
 perl-Tk-EntryCheck-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Tk-EntryCheck-0.04-39.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a0051a4ae37ebbc1dfd9d89223a7256af6f9de54566e7473ce760e5484eea03"

URI_x86_64_v2_perl-Tk-EntryCheck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Tk-EntryCheck-0.04-39.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Tk-EntryCheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Tk-EntryCheck}"
SRC_URI[x86_64_v2_perl-Tk-EntryCheck.sha256sum] = "984f540ce9bd520d198577b989da903e3a06d83845b459529b4801aa31426b1d"

URI_x86_64_v2_perl-Tk-EntryCheck-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Tk-EntryCheck-tests-0.04-39.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Tk-EntryCheck-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Tk-EntryCheck-tests}"
SRC_URI[x86_64_v2_perl-Tk-EntryCheck-tests.sha256sum] = "717727811f4c08ea61386c639098109627367ff39008388686d0ba406296c581"

URI_aarch64_perl-Tk-EntryCheck = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Tk-EntryCheck-0.04-39.el10_0.noarch.rpm;name=aarch64_perl-Tk-EntryCheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Tk-EntryCheck}"
SRC_URI[aarch64_perl-Tk-EntryCheck.sha256sum] = "ffdced3d3d79f3dddcb4cc1d962abdefbbe80fb56c5b18b8a6e325b90a4972dd"

URI_aarch64_perl-Tk-EntryCheck-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Tk-EntryCheck-tests-0.04-39.el10_0.noarch.rpm;name=aarch64_perl-Tk-EntryCheck-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Tk-EntryCheck-tests}"
SRC_URI[aarch64_perl-Tk-EntryCheck-tests.sha256sum] = "28fb62fcf97c2bb1bec46d2b1354b055abddf54e993def3ca502dfadec90df99"

RDEPENDS:perl-Tk-EntryCheck = " \
 perl-Carp \
 perl-Tk \
 perl-base \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-Tk-EntryCheck-tests = " \
 bash \
 mesa-dri-drivers \
 mutter \
 perl-Test \
 perl-Test-Harness \
 perl-Tk \
 perl-Tk-EntryCheck \
 xwayland-run \
 "
