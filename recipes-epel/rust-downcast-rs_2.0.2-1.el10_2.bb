# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-downcast-rs"
PV = "2.0.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-downcast-rs+default-devel \
 rust-downcast-rs+std-devel \
 rust-downcast-rs+sync-devel \
 rust-downcast-rs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-downcast-rs-2.0.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c35420211592b818b12ea042841b97d1afc1e4f00a5ff7114d5a6b43820befe"

URI_x86_64_v2_rust-downcast-rs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-downcast-rs+default-devel-2.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-downcast-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-downcast-rs+default-devel}"
SRC_URI[x86_64_v2_rust-downcast-rs+default-devel.sha256sum] = "9c3a545f5ed2de3a4f32fc25987b382f127c16467849926feb81e028a6fec18f"

URI_x86_64_v2_rust-downcast-rs+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-downcast-rs+std-devel-2.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-downcast-rs+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-downcast-rs+std-devel}"
SRC_URI[x86_64_v2_rust-downcast-rs+std-devel.sha256sum] = "5916478624cf31557713f7b83097f3bf328c58c0ac5ad18c740c06159c01a091"

URI_x86_64_v2_rust-downcast-rs+sync-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-downcast-rs+sync-devel-2.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-downcast-rs+sync-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-downcast-rs+sync-devel}"
SRC_URI[x86_64_v2_rust-downcast-rs+sync-devel.sha256sum] = "d45086c469a5b9947bc621f5417891de0205aea056e8865a7e06eaa693881856"

URI_x86_64_v2_rust-downcast-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-downcast-rs-devel-2.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-downcast-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-downcast-rs-devel}"
SRC_URI[x86_64_v2_rust-downcast-rs-devel.sha256sum] = "47d492e3fa560b0bedd32dc455dbb360e5b5b6216095a118379443689c995d28"

URI_aarch64_rust-downcast-rs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-downcast-rs+default-devel-2.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-downcast-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-downcast-rs+default-devel}"
SRC_URI[aarch64_rust-downcast-rs+default-devel.sha256sum] = "97ba1d1fb2d28ed61be9f4ca39499dab8f15173aeb5e62e2fe253f78d5cf050f"

URI_aarch64_rust-downcast-rs+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-downcast-rs+std-devel-2.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-downcast-rs+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-downcast-rs+std-devel}"
SRC_URI[aarch64_rust-downcast-rs+std-devel.sha256sum] = "7f4dafd6f1dd60d599445bf2795f568186821f5f23acf5975c4f081830075ecd"

URI_aarch64_rust-downcast-rs+sync-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-downcast-rs+sync-devel-2.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-downcast-rs+sync-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-downcast-rs+sync-devel}"
SRC_URI[aarch64_rust-downcast-rs+sync-devel.sha256sum] = "afee12b12a255c4cb5f95e4ec74c92ba6a8c99b9a3b1b00777bca4052feddfa6"

URI_aarch64_rust-downcast-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-downcast-rs-devel-2.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-downcast-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-downcast-rs-devel}"
SRC_URI[aarch64_rust-downcast-rs-devel.sha256sum] = "927d0989ecea5b7f05e847e4e354d7c09ead3430fbec688dd43f5ee8b9d10e7b"

RDEPENDS:rust-downcast-rs+default-devel = " \
 cargo \
 rust-downcast-rs+std-devel \
 rust-downcast-rs+sync-devel \
 rust-downcast-rs-devel \
 "
RDEPENDS:rust-downcast-rs+std-devel = " \
 cargo \
 rust-downcast-rs-devel \
 "
RDEPENDS:rust-downcast-rs+sync-devel = " \
 cargo \
 rust-downcast-rs-devel \
 "
RDEPENDS:rust-downcast-rs-devel = " \
 cargo \
 rust \
 "
