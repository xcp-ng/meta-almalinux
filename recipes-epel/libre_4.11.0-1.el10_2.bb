# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libre"
PV = "4.11.0"
PR = "1.el10_2"
PACKAGES = " \
 libre \
 libre-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libre-4.11.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6f39d9c5c86538bae5e39a98adbfb571483111e67cc9ac6b0e0438643fe33e04"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libre-4.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libre;unpack=0"
SRC_URI[x86_64_v2_libre.sha256sum] = "614d1540fedbc71691c3478a74502b02421afe29fac9fe76a7f60f1cb41f89a5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libre-devel-4.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libre-devel;unpack=0"
SRC_URI[x86_64_v2_libre-devel.sha256sum] = "dff19865f0683c5a7e680ddbd2c028b9522cb984471b630ab4f74f2c74cd0ac6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libre-4.11.0-1.el10_2.aarch64.rpm;name=aarch64_libre;unpack=0"
SRC_URI[aarch64_libre.sha256sum] = "c823578198cea3dad90e30444b0831fd35ad54c807063df0df80cf846374bb54"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libre-devel-4.11.0-1.el10_2.aarch64.rpm;name=aarch64_libre-devel;unpack=0"
SRC_URI[aarch64_libre-devel.sha256sum] = "aa7c9c260c665b86aae56cde3c724e2ea533efde0b657ee2254fedfa0daa9b3b"

RDEPENDS:libre = " \
 glibc \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:libre-devel = " \
 cmake-filesystem \
 libre \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
