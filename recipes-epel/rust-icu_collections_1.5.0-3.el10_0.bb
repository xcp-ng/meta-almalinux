# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_collections"
PV = "1.5.0"
PR = "3.el10_0"
PACKAGES = " \
 rust-icu_collections+databake-devel \
 rust-icu_collections+default-devel \
 rust-icu_collections+serde-devel \
 rust-icu_collections+std-devel \
 rust-icu_collections-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_collections-1.5.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "18d66d9b0c0e9a2e6ed0b566989a6a32c4eed83cf25c1a09dd388da1159a7984"

URI_x86_64_v2_rust-icu_collections+databake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collections+databake-devel-1.5.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collections+databake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collections+databake-devel}"
SRC_URI[x86_64_v2_rust-icu_collections+databake-devel.sha256sum] = "d9f8d1d24631e7004cdd7615cbce40d085586bfc188cf475cb1c6db2dd132578"

URI_x86_64_v2_rust-icu_collections+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collections+default-devel-1.5.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collections+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collections+default-devel}"
SRC_URI[x86_64_v2_rust-icu_collections+default-devel.sha256sum] = "a59c890a26d5c944852fd2d8131f7c470bdeb4aa67d0fdfb92e8c45e436daffc"

URI_x86_64_v2_rust-icu_collections+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collections+serde-devel-1.5.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collections+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collections+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_collections+serde-devel.sha256sum] = "c627a657f99db76a13ed3b1a2d1a643bf241be2ff6fae8e4331937128600f6b6"

URI_x86_64_v2_rust-icu_collections+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collections+std-devel-1.5.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collections+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collections+std-devel}"
SRC_URI[x86_64_v2_rust-icu_collections+std-devel.sha256sum] = "91aa5738cf5286023d050ec7b86ce01d388d8a95525a7a40ad352370b85be55b"

URI_x86_64_v2_rust-icu_collections-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collections-devel-1.5.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collections-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collections-devel}"
SRC_URI[x86_64_v2_rust-icu_collections-devel.sha256sum] = "04c0981d22aea1acfe9e8db78966e6f0b9b69731697750f2fc0097e3a96aa9e8"

URI_aarch64_rust-icu_collections+databake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collections+databake-devel-1.5.0-3.el10_0.noarch.rpm;name=aarch64_rust-icu_collections+databake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collections+databake-devel}"
SRC_URI[aarch64_rust-icu_collections+databake-devel.sha256sum] = "e83565cdc71f9d52f358d36165cf4e482394116c92c4653797de838c3a5577c6"

URI_aarch64_rust-icu_collections+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collections+default-devel-1.5.0-3.el10_0.noarch.rpm;name=aarch64_rust-icu_collections+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collections+default-devel}"
SRC_URI[aarch64_rust-icu_collections+default-devel.sha256sum] = "131e613775f736898f9cdb378a413faa0e62465cd497cdcac1a7b98aa225b170"

URI_aarch64_rust-icu_collections+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collections+serde-devel-1.5.0-3.el10_0.noarch.rpm;name=aarch64_rust-icu_collections+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collections+serde-devel}"
SRC_URI[aarch64_rust-icu_collections+serde-devel.sha256sum] = "fc67e49fc1e127b6cd645e0b9fb0b2316868e0b5ea0fe578265f6b4f4f1e697c"

URI_aarch64_rust-icu_collections+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collections+std-devel-1.5.0-3.el10_0.noarch.rpm;name=aarch64_rust-icu_collections+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collections+std-devel}"
SRC_URI[aarch64_rust-icu_collections+std-devel.sha256sum] = "95e63fa5b41a7341c54d66ce5fb599290cf04bf59b28baf3e82f17b8d4d9bdd2"

URI_aarch64_rust-icu_collections-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collections-devel-1.5.0-3.el10_0.noarch.rpm;name=aarch64_rust-icu_collections-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collections-devel}"
SRC_URI[aarch64_rust-icu_collections-devel.sha256sum] = "c4d6d9f027e7fb065aabe90f2369d8a6e7598d64abe0634807344c3a359a6432"

RDEPENDS:rust-icu_collections+databake-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-icu_collections-devel \
 rust-zerovec+databake-devel \
 "
RDEPENDS:rust-icu_collections+default-devel = " \
 cargo \
 rust-icu_collections-devel \
 "
RDEPENDS:rust-icu_collections+serde-devel = " \
 cargo \
 rust-icu_collections-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerovec+serde-devel \
 "
RDEPENDS:rust-icu_collections+std-devel = " \
 cargo \
 rust-icu_collections-devel \
 "
RDEPENDS:rust-icu_collections-devel = " \
 cargo \
 rust \
 rust-displaydoc-devel \
 rust-yoke+derive-devel \
 rust-yoke-devel \
 rust-zerofrom+derive-devel \
 rust-zerofrom-devel \
 rust-zerovec+derive-devel \
 rust-zerovec+yoke-devel \
 rust-zerovec-devel \
 "
