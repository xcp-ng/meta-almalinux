# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-harfbuzz-traits"
PV = "0.6.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-harfbuzz-traits+default-devel \
 rust-harfbuzz-traits-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-harfbuzz-traits-0.6.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca89c0cebaca223f7c16d6e886b2ebdb973cf97f3526ba4608c1bf06dc2fcb96"

URI_x86_64_v2_rust-harfbuzz-traits+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-harfbuzz-traits+default-devel-0.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-harfbuzz-traits+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-harfbuzz-traits+default-devel}"
SRC_URI[x86_64_v2_rust-harfbuzz-traits+default-devel.sha256sum] = "767808cc0c3cccb18f8feb4cf8acd18864fd8692789e46edca25c88f27f8ff33"

URI_x86_64_v2_rust-harfbuzz-traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-harfbuzz-traits-devel-0.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-harfbuzz-traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-harfbuzz-traits-devel}"
SRC_URI[x86_64_v2_rust-harfbuzz-traits-devel.sha256sum] = "f0e6f2811931d0cd41c766994035bb1c0a9ddb6c8eb91930ea40fae217ff9c7c"

URI_aarch64_rust-harfbuzz-traits+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-harfbuzz-traits+default-devel-0.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-harfbuzz-traits+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-harfbuzz-traits+default-devel}"
SRC_URI[aarch64_rust-harfbuzz-traits+default-devel.sha256sum] = "2c16069ee5dd3f86d12bb3d961abcf604ef75d17b9d865eae42bc6912eb2023c"

URI_aarch64_rust-harfbuzz-traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-harfbuzz-traits-devel-0.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-harfbuzz-traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-harfbuzz-traits-devel}"
SRC_URI[aarch64_rust-harfbuzz-traits-devel.sha256sum] = "1cc816ad78051547e38712807dde6d258a460a65ec8b189275fc7ded42b1b7a7"

RDEPENDS:rust-harfbuzz-traits+default-devel = " \
 cargo \
 rust-harfbuzz-traits-devel \
 "
RDEPENDS:rust-harfbuzz-traits-devel = " \
 cargo \
 "
