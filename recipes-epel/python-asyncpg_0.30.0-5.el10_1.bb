# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-asyncpg"
PV = "0.30.0"
PR = "5.el10_1"
PACKAGES = " \
 python3-asyncpg \
 python3-asyncpg+gssauth \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-asyncpg-0.30.0-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e07b90827e4a7884fabcba6f8425bf8960b283f023381f1b0db00243d67e91b3"

URI_x86_64_v2_python3-asyncpg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-asyncpg-0.30.0-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-asyncpg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-asyncpg}"
SRC_URI[x86_64_v2_python3-asyncpg.sha256sum] = "61b61e75cfe6b36cbb3b8e2071dc6a7b97458148506dc326394f8cc0d2ad4fb0"

URI_x86_64_v2_python3-asyncpg+gssauth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-asyncpg+gssauth-0.30.0-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-asyncpg+gssauth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-asyncpg+gssauth}"
SRC_URI[x86_64_v2_python3-asyncpg+gssauth.sha256sum] = "b0bddb8706a31f83c2c21293ec16fd0b41f5cdcef75199483047beb8ce6f9435"

URI_aarch64_python3-asyncpg = "${EPEL_MIRROR}/aarch64/Packages/p/python3-asyncpg-0.30.0-5.el10_1.aarch64.rpm;name=aarch64_python3-asyncpg;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-asyncpg}"
SRC_URI[aarch64_python3-asyncpg.sha256sum] = "b731d09b568ac7a00c7cd88893e0fd042de013eae54067e3af7d60a1d4cafe61"

URI_aarch64_python3-asyncpg+gssauth = "${EPEL_MIRROR}/aarch64/Packages/p/python3-asyncpg+gssauth-0.30.0-5.el10_1.aarch64.rpm;name=aarch64_python3-asyncpg+gssauth;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-asyncpg+gssauth}"
SRC_URI[aarch64_python3-asyncpg+gssauth.sha256sum] = "cd3102fe03b18ecdf56eec04ba9fd92d49435d5557a0f24331c99df79c4f1fb2"

RDEPENDS:python3-asyncpg = " \
 glibc \
 python3 \
 "
RDEPENDS:python3-asyncpg+gssauth = " \
 python3 \
 python3-asyncpg \
 python3-gssapi \
 "
