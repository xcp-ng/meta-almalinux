# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-git2_0.19"
PV = "0.19.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-git2_0.19+default-devel \
 rust-git2_0.19+https-devel \
 rust-git2_0.19+openssl-probe-devel \
 rust-git2_0.19+openssl-sys-devel \
 rust-git2_0.19+ssh-devel \
 rust-git2_0.19+ssh_key_from_memory-devel \
 rust-git2_0.19+unstable-devel \
 rust-git2_0.19+vendored-libgit2-devel \
 rust-git2_0.19-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-git2_0.19-0.19.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45f18006953e0f8d00896b621a46fd7e79495f8819fb716fb387ceaa88ebb933"

URI_x86_64_v2_rust-git2_0.19+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2_0.19+default-devel-0.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2_0.19+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2_0.19+default-devel}"
SRC_URI[x86_64_v2_rust-git2_0.19+default-devel.sha256sum] = "89864354c0284d6e550182d9d80ad7edebbfd156ee2d925cda0f5b1f0b0efacd"

URI_x86_64_v2_rust-git2_0.19+https-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2_0.19+https-devel-0.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2_0.19+https-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2_0.19+https-devel}"
SRC_URI[x86_64_v2_rust-git2_0.19+https-devel.sha256sum] = "95a667d4c080843e21aaea97934708f199c0d0f4dc1048de4b2d97e629f55e13"

URI_x86_64_v2_rust-git2_0.19+openssl-probe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2_0.19+openssl-probe-devel-0.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2_0.19+openssl-probe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2_0.19+openssl-probe-devel}"
SRC_URI[x86_64_v2_rust-git2_0.19+openssl-probe-devel.sha256sum] = "02aafce2808f91478ab5261f117a72a28d8883dcb5b4dcfd2b9785ba3594ef58"

URI_x86_64_v2_rust-git2_0.19+openssl-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2_0.19+openssl-sys-devel-0.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2_0.19+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2_0.19+openssl-sys-devel}"
SRC_URI[x86_64_v2_rust-git2_0.19+openssl-sys-devel.sha256sum] = "e25ed339c26b5ce5c749218b2d5808abacb16769597bb3e5da5431f46dd1c602"

URI_x86_64_v2_rust-git2_0.19+ssh-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2_0.19+ssh-devel-0.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2_0.19+ssh-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2_0.19+ssh-devel}"
SRC_URI[x86_64_v2_rust-git2_0.19+ssh-devel.sha256sum] = "e14b523158fc9c077cae539106adba245dcd07f004dcb0533d78c53a86977b38"

URI_x86_64_v2_rust-git2_0.19+ssh_key_from_memory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2_0.19+ssh_key_from_memory-devel-0.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2_0.19+ssh_key_from_memory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2_0.19+ssh_key_from_memory-devel}"
SRC_URI[x86_64_v2_rust-git2_0.19+ssh_key_from_memory-devel.sha256sum] = "ec952cde71931295882e5bc621f8d313b47f001f953bb7a150faf79ade7553a7"

URI_x86_64_v2_rust-git2_0.19+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2_0.19+unstable-devel-0.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2_0.19+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2_0.19+unstable-devel}"
SRC_URI[x86_64_v2_rust-git2_0.19+unstable-devel.sha256sum] = "6e17fb26cfa2b5d3a7cbf676b4f5e29905846952cdf2e8290d7a892e100f4d9b"

URI_x86_64_v2_rust-git2_0.19+vendored-libgit2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2_0.19+vendored-libgit2-devel-0.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2_0.19+vendored-libgit2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2_0.19+vendored-libgit2-devel}"
SRC_URI[x86_64_v2_rust-git2_0.19+vendored-libgit2-devel.sha256sum] = "04b23094e30579ac0acdedcc9b2940c54b83efb8c8c4a10547ed27cea2013654"

URI_x86_64_v2_rust-git2_0.19-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2_0.19-devel-0.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2_0.19-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2_0.19-devel}"
SRC_URI[x86_64_v2_rust-git2_0.19-devel.sha256sum] = "7c01931f1a27e86e128c4ff6814913f8ad46f8b5cc1601e8e6035f429b7d23a7"

URI_aarch64_rust-git2_0.19+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2_0.19+default-devel-0.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-git2_0.19+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2_0.19+default-devel}"
SRC_URI[aarch64_rust-git2_0.19+default-devel.sha256sum] = "ac5a243829905e64a606b41094e873758e4e5586a1a91448a5060e8b6f3a3ab3"

URI_aarch64_rust-git2_0.19+https-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2_0.19+https-devel-0.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-git2_0.19+https-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2_0.19+https-devel}"
SRC_URI[aarch64_rust-git2_0.19+https-devel.sha256sum] = "92b497fcedbe77dcc04ebc2f43afdc0cc02f42b1d37befe30b07d363cdc3269e"

URI_aarch64_rust-git2_0.19+openssl-probe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2_0.19+openssl-probe-devel-0.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-git2_0.19+openssl-probe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2_0.19+openssl-probe-devel}"
SRC_URI[aarch64_rust-git2_0.19+openssl-probe-devel.sha256sum] = "86d59c365894f3b0d0af55060866c275f6bc214dc5147be9c504ec427ce4a5f0"

URI_aarch64_rust-git2_0.19+openssl-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2_0.19+openssl-sys-devel-0.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-git2_0.19+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2_0.19+openssl-sys-devel}"
SRC_URI[aarch64_rust-git2_0.19+openssl-sys-devel.sha256sum] = "b95b4a8dc1a73dc1c812d073da685ffa8bae738c6d1bdf7b4a3c055dab33787c"

URI_aarch64_rust-git2_0.19+ssh-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2_0.19+ssh-devel-0.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-git2_0.19+ssh-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2_0.19+ssh-devel}"
SRC_URI[aarch64_rust-git2_0.19+ssh-devel.sha256sum] = "c4e1baa2570df975a513824c5d02ba9102a7b3f2dc4cad2a74375b354071c570"

URI_aarch64_rust-git2_0.19+ssh_key_from_memory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2_0.19+ssh_key_from_memory-devel-0.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-git2_0.19+ssh_key_from_memory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2_0.19+ssh_key_from_memory-devel}"
SRC_URI[aarch64_rust-git2_0.19+ssh_key_from_memory-devel.sha256sum] = "dcff27e3739e3bb0fcded37c9a6ce6ebd8ac22a085421900a4517a4830997078"

URI_aarch64_rust-git2_0.19+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2_0.19+unstable-devel-0.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-git2_0.19+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2_0.19+unstable-devel}"
SRC_URI[aarch64_rust-git2_0.19+unstable-devel.sha256sum] = "a5ce991901e73822bfba1a58b0ecb50e07daf664d4cab27307738c325719b0e6"

URI_aarch64_rust-git2_0.19+vendored-libgit2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2_0.19+vendored-libgit2-devel-0.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-git2_0.19+vendored-libgit2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2_0.19+vendored-libgit2-devel}"
SRC_URI[aarch64_rust-git2_0.19+vendored-libgit2-devel.sha256sum] = "94a73c4e098f0cb0998ba800ddd7105a7510acf311bdca5cb6a08194aab95677"

URI_aarch64_rust-git2_0.19-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2_0.19-devel-0.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-git2_0.19-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2_0.19-devel}"
SRC_URI[aarch64_rust-git2_0.19-devel.sha256sum] = "dd9e9b06251388904f7a7fe9e170202304e920aa35cae2d7a5b11ba52a12f1c9"

RDEPENDS:rust-git2_0.19+default-devel = " \
 cargo \
 rust-git2_0.19+https-devel \
 rust-git2_0.19+ssh-devel \
 rust-git2_0.19+ssh_key_from_memory-devel \
 rust-git2_0.19-devel \
 "
RDEPENDS:rust-git2_0.19+https-devel = " \
 cargo \
 rust-git2_0.19+openssl-probe-devel \
 rust-git2_0.19+openssl-sys-devel \
 rust-git2_0.19-devel \
 rust-libgit2-sys0.17+https-devel \
 "
RDEPENDS:rust-git2_0.19+openssl-probe-devel = " \
 cargo \
 rust-git2_0.19-devel \
 rust-openssl-probe+default-devel \
 "
RDEPENDS:rust-git2_0.19+openssl-sys-devel = " \
 cargo \
 rust-git2_0.19-devel \
 rust-openssl-sys+default-devel \
 "
RDEPENDS:rust-git2_0.19+ssh-devel = " \
 cargo \
 rust-git2_0.19-devel \
 rust-libgit2-sys0.17+ssh-devel \
 "
RDEPENDS:rust-git2_0.19+ssh_key_from_memory-devel = " \
 cargo \
 rust-git2_0.19-devel \
 rust-libgit2-sys0.17+ssh_key_from_memory-devel \
 "
RDEPENDS:rust-git2_0.19+unstable-devel = " \
 cargo \
 rust-git2_0.19-devel \
 "
RDEPENDS:rust-git2_0.19+vendored-libgit2-devel = " \
 cargo \
 rust-git2_0.19-devel \
 rust-libgit2-sys0.17+vendored-devel \
 "
RDEPENDS:rust-git2_0.19-devel = " \
 bash \
 cargo \
 rust-bitflags+default-devel \
 rust-libc+default-devel \
 rust-libgit2-sys0.17+default-devel \
 rust-log+default-devel \
 rust-url+default-devel \
 "
