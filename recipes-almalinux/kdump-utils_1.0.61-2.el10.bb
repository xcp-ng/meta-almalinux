# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdump-utils"
PV = "1.0.61"
PR = "2.el10"
PACKAGES = " \
 kdump-utils \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/kdump-utils-1.0.61-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "90641fe74b6a4fb0f3c0051f384fefe8bef72fbf823b208e580736c3941817a4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kdump-utils-1.0.61-2.el10.x86_64_v2.rpm;name=x86_64_v2_kdump-utils;unpack=0"
SRC_URI[x86_64_v2_kdump-utils.sha256sum] = "0995d716ba5a1016c077062c666d3f87e81d138a90597b3f62ad6af1acc24250"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kdump-utils-1.0.61-2.el10.aarch64.rpm;name=aarch64_kdump-utils;unpack=0"
SRC_URI[aarch64_kdump-utils.sha256sum] = "1988d9b44b8d2d4bda2f28a51a57a6d3a6afabb844b84e3b20141aabaf9d3023"

RDEPENDS:kdump-utils = " \
 bash \
 dracut \
 dracut-network \
 dracut-squash \
 ethtool \
 kexec-tools \
 makedumpfile \
 sed \
 systemd-udev \
 util-linux \
 virtual/coreutils \
 "
