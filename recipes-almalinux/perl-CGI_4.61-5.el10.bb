# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-CGI"
PV = "4.61"
PR = "5.el10"
PACKAGES = " \
 perl-CGI \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-CGI-4.61-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc30d44455e4f399f4ec8b5e91463e002490cf4faddc65d09d866ce437fcb302"

URI_x86_64_v2_perl-CGI = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-CGI-4.61-5.el10.noarch.rpm;name=x86_64_v2_perl-CGI;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-CGI}"
SRC_URI[x86_64_v2_perl-CGI.sha256sum] = "7185a3fbb653fc610d9933b2f6e30c40a7d203e255dcfbda2032f0285c8a3191"

URI_aarch64_perl-CGI = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-CGI-4.61-5.el10.noarch.rpm;name=aarch64_perl-CGI;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-CGI}"
SRC_URI[aarch64_perl-CGI.sha256sum] = "7185a3fbb653fc610d9933b2f6e30c40a7d203e255dcfbda2032f0285c8a3191"

RDEPENDS:perl-CGI = " \
 perl-CGI \
 perl-Carp \
 perl-Exporter \
 perl-File-Temp \
 perl-HTML-Parser \
 perl-PathTools \
 perl-Text-ParseWords \
 perl-libs \
 perl-overload \
 perl-parent \
 "
