# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libiodbc"
PV = "3.52.16"
PR = "1.el10_1"
PACKAGES = " \
 libiodbc \
 libiodbc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libiodbc-3.52.16-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e19ebc6d5085e4346bfb762914231c72ad487ed4196e532a98aecfc81380872"

URI_x86_64_v2_libiodbc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libiodbc-3.52.16-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libiodbc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libiodbc}"
SRC_URI[x86_64_v2_libiodbc.sha256sum] = "5c335c530b1ef218d05f1858988a1c4128d9fe3c1c0375aa8675b5f5721b274f"

URI_x86_64_v2_libiodbc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libiodbc-devel-3.52.16-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libiodbc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libiodbc-devel}"
SRC_URI[x86_64_v2_libiodbc-devel.sha256sum] = "2d0f223a5b5e44a6d581b2ad43a5530a9826e702b8d4dd31832799a2db14560d"

URI_aarch64_libiodbc = "${EPEL_MIRROR}/aarch64/Packages/l/libiodbc-3.52.16-1.el10_1.aarch64.rpm;name=aarch64_libiodbc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libiodbc}"
SRC_URI[aarch64_libiodbc.sha256sum] = "0e8b7df2e3f31a06b9712267cc81c2d129dd73dd908c921373a876d3b5cee1f3"

URI_aarch64_libiodbc-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libiodbc-devel-3.52.16-1.el10_1.aarch64.rpm;name=aarch64_libiodbc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libiodbc-devel}"
SRC_URI[aarch64_libiodbc-devel.sha256sum] = "87ad749690aac04566290d53dcd6ffe4088161c4273c32d0f2332c1f03b898ec"

RDEPENDS:libiodbc = " \
 glibc \
 "
RDEPENDS:libiodbc-devel = " \
 bash \
 libiodbc \
 pkgconf-pkg-config \
 "
