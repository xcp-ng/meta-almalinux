# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ghp-import"
PV = "2.1.0"
PR = "10.el10_0"
PACKAGES = " \
 python3-ghp-import \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-ghp-import-2.1.0-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0ca4ee3f18de76f6afcb19c1303caca20e4000662a149772cdaa614191a0d2a"

URI_x86_64_v2_python3-ghp-import = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ghp-import-2.1.0-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ghp-import;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ghp-import}"
SRC_URI[x86_64_v2_python3-ghp-import.sha256sum] = "48372e53c45ea5f20f9c75116b130bc26638f7f8da3634eb8fac80c76217bcd5"

URI_aarch64_python3-ghp-import = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ghp-import-2.1.0-10.el10_0.noarch.rpm;name=aarch64_python3-ghp-import;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ghp-import}"
SRC_URI[aarch64_python3-ghp-import.sha256sum] = "47aef66478e5decf447b5db8a76ec74f795e0b7a639a6be8cc7301d5535de21d"

RDEPENDS:python3-ghp-import = " \
 python3 \
 python3-dateutil \
 "
