# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "auter"
PV = "1.0.0"
PR = "16.el10_2"
PACKAGES = " \
 auter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/auter-1.0.0-16.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "275353948af7f94cecfcb01392583ba5c3781f87f1f4a002a4d22af1dfbc66ed"

URI_x86_64_v2_auter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/auter-1.0.0-16.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_auter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_auter}"
SRC_URI[x86_64_v2_auter.sha256sum] = "698c528a6ba32a128e9366589186564ab61192f4ea19e9a805ff436b25484908"

URI_aarch64_auter = "${EPEL_MIRROR}/aarch64/Packages/a/auter-1.0.0-16.el10_2.noarch.rpm;name=aarch64_auter;unpack=0"
SRC_URI:append = " ${URI_aarch64_auter}"
SRC_URI[aarch64_auter.sha256sum] = "bad8ded7329e0f26268ba155f4f92b79a14d56cf0793ea29308020990d33a4d9"

RDEPENDS:auter = " \
 bash \
 crontabs \
 yum \
 "
