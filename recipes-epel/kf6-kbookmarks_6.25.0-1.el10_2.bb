# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kbookmarks"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kbookmarks \
 kf6-kbookmarks-devel \
 kf6-kbookmarks-doc \
 kf6-kbookmarks-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kbookmarks-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b0fd993a6b5c64206dc7ae6cba9794119aa10c0ede5a955a335c373d4f796c6"

URI_x86_64_v2_kf6-kbookmarks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kbookmarks-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kbookmarks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kbookmarks}"
SRC_URI[x86_64_v2_kf6-kbookmarks.sha256sum] = "4c94924fe3add12220d111755bfaa328b6a6c4e04da58ae9dee5268ff6572163"

URI_x86_64_v2_kf6-kbookmarks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kbookmarks-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kbookmarks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kbookmarks-devel}"
SRC_URI[x86_64_v2_kf6-kbookmarks-devel.sha256sum] = "484131f14edcb7d9a4454bf6c501a845fbae3f6756461d37bbc89ac5451bf964"

URI_x86_64_v2_kf6-kbookmarks-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kbookmarks-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kbookmarks-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kbookmarks-doc}"
SRC_URI[x86_64_v2_kf6-kbookmarks-doc.sha256sum] = "01c5012a55f41867a22e8299b1e48fc5a6585c90d0d112a8c4025e0ed0522a6e"

URI_x86_64_v2_kf6-kbookmarks-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kbookmarks-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kbookmarks-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kbookmarks-html}"
SRC_URI[x86_64_v2_kf6-kbookmarks-html.sha256sum] = "3aa9f81d80aa62b2492d83d53cdef158ae1365122b0a14357cf2372f7c432ea1"

URI_aarch64_kf6-kbookmarks = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kbookmarks-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kbookmarks;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kbookmarks}"
SRC_URI[aarch64_kf6-kbookmarks.sha256sum] = "bd57a5c3675cd93e0b59e7cc326e9f609424932d3dbe90e1f395a402fb2e9b11"

URI_aarch64_kf6-kbookmarks-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kbookmarks-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kbookmarks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kbookmarks-devel}"
SRC_URI[aarch64_kf6-kbookmarks-devel.sha256sum] = "30ce0146acd9d914c2cb40bd6d7e6657c4f348ac0ee543af2d9a47f26bbeb776"

URI_aarch64_kf6-kbookmarks-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kbookmarks-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kbookmarks-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kbookmarks-doc}"
SRC_URI[aarch64_kf6-kbookmarks-doc.sha256sum] = "31262d18de3ecd92b17387872ec0b4f2c473dbb174629e4de1998e47e2557781"

URI_aarch64_kf6-kbookmarks-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kbookmarks-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kbookmarks-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kbookmarks-html}"
SRC_URI[aarch64_kf6-kbookmarks-html.sha256sum] = "d7b76cd58c1dcdbb48d993ec3a72fd12b849589a04a73ef83e9811812eadc250"

RDEPENDS:kf6-kbookmarks = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kbookmarks-devel = " \
 cmake-filesystem \
 kf6-kbookmarks \
 kf6-kwidgetsaddons-devel \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kbookmarks-doc = " \
 "
RDEPENDS:kf6-kbookmarks-html = " \
 "
