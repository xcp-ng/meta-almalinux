# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-filetime"
PV = "0.2.27"
PR = "1.el10_1"
PACKAGES = " \
 rust-filetime+default-devel \
 rust-filetime-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-filetime-0.2.27-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f1fa1e234c428425810ca75ed32fa77758238701a08e15140582d0817cd33c1"

URI_x86_64_v2_rust-filetime+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-filetime+default-devel-0.2.27-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-filetime+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-filetime+default-devel}"
SRC_URI[x86_64_v2_rust-filetime+default-devel.sha256sum] = "ba66c4900cfe3fd669f309ddcb831cbca9504b90e7bd6d6294f6cc0859236ef4"

URI_x86_64_v2_rust-filetime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-filetime-devel-0.2.27-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-filetime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-filetime-devel}"
SRC_URI[x86_64_v2_rust-filetime-devel.sha256sum] = "420202d9a3207536c837ef2a656744e88cf194831950414c4c3ab90332022325"

URI_aarch64_rust-filetime+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-filetime+default-devel-0.2.27-1.el10_1.noarch.rpm;name=aarch64_rust-filetime+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-filetime+default-devel}"
SRC_URI[aarch64_rust-filetime+default-devel.sha256sum] = "d44221272c9dbb171bd92bf0336ce424ba27dd833cdaca41306a48298a558ba3"

URI_aarch64_rust-filetime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-filetime-devel-0.2.27-1.el10_1.noarch.rpm;name=aarch64_rust-filetime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-filetime-devel}"
SRC_URI[aarch64_rust-filetime-devel.sha256sum] = "6050edebd0bb7bcd327fdd5c1f7570412a851d32e0f4bc754431b5a5659b3c4a"

RDEPENDS:rust-filetime+default-devel = " \
 cargo \
 rust-filetime-devel \
 "
RDEPENDS:rust-filetime-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 "
