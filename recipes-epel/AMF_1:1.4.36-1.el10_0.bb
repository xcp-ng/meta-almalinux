# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "AMF"
PE = "1"
PV = "1.4.36"
PR = "1.el10_0"
PACKAGES = " \
 AMF-devel \
 AMF-docs \
 AMF-samples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/AMF-1.4.36-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85a247bdf822b33ca459a7af3c167b6841970453644fb03f50e06fdc227b75ab"

URI_x86_64_v2_AMF-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/AMF-devel-1.4.36-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_AMF-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_AMF-devel}"
SRC_URI[x86_64_v2_AMF-devel.sha256sum] = "296c8d53742e2bb3980c10a92ddc23165aa52feeb6c0e3fab5740d66b9ee00bd"

URI_x86_64_v2_AMF-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/AMF-docs-1.4.36-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_AMF-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_AMF-docs}"
SRC_URI[x86_64_v2_AMF-docs.sha256sum] = "90bd17f5c72536c3e21798ccbad5f266f36735b015c975b160748e9b4583761b"

URI_x86_64_v2_AMF-samples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/AMF-samples-1.4.36-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_AMF-samples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_AMF-samples}"
SRC_URI[x86_64_v2_AMF-samples.sha256sum] = "ea53f10860764d5374af6072d12687ac66efeca4c28d66183a3f85c635094135"

URI_aarch64_AMF-devel = "${EPEL_MIRROR}/aarch64/Packages/a/AMF-devel-1.4.36-1.el10_0.noarch.rpm;name=aarch64_AMF-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_AMF-devel}"
SRC_URI[aarch64_AMF-devel.sha256sum] = "1895d5f36a543aec84e03ab009330a4d15ba147acc6986f7ea003e110e0a4bc4"

URI_aarch64_AMF-docs = "${EPEL_MIRROR}/aarch64/Packages/a/AMF-docs-1.4.36-1.el10_0.noarch.rpm;name=aarch64_AMF-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_AMF-docs}"
SRC_URI[aarch64_AMF-docs.sha256sum] = "c5442676048e99f25260a09296935adbdb511f3dcb06284e595d7b908d424f4a"

URI_aarch64_AMF-samples = "${EPEL_MIRROR}/aarch64/Packages/a/AMF-samples-1.4.36-1.el10_0.noarch.rpm;name=aarch64_AMF-samples;unpack=0"
SRC_URI:append = " ${URI_aarch64_AMF-samples}"
SRC_URI[aarch64_AMF-samples.sha256sum] = "63c311e58d4d49ed14814c74c4bed33591a84d60ed88d5ae63335fc725fa7587"

RDEPENDS:AMF-devel = " \
 "
RDEPENDS:AMF-docs = " \
 "
RDEPENDS:AMF-samples = " \
 "
