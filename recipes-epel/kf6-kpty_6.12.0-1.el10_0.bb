# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kpty"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kpty \
 kf6-kpty-devel \
 kf6-kpty-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kpty-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b2194118bad867e51cca1148bed0f8d83224242c9c9b04f7815114ef55ac2280"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpty-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kpty;unpack=0"
SRC_URI[x86_64_v2_kf6-kpty.sha256sum] = "8d6ee1b136a2b833d0dda4e7c7917262cf76c1d9f6fd06c4bad940aa46189470"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpty-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kpty-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kpty-devel.sha256sum] = "0051b522b9b9f07fb83bc75766ba92ee1446759ff6aad4b580425c71de185921"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpty-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kpty-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kpty-doc.sha256sum] = "62e6b6b955fc8f181dbb3dbf0d91bc65504b3ea56f4db9a8252b6814ada4e74e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpty-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kpty;unpack=0"
SRC_URI[aarch64_kf6-kpty.sha256sum] = "eb95804f8b9313be3ff9ca018fb156d369d3e0a119d91640a3c0a078fbe0c773"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpty-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kpty-devel;unpack=0"
SRC_URI[aarch64_kf6-kpty-devel.sha256sum] = "3e20cbaf53f63b5123ae28486116a95b6473a3adcfa79adab513bec0d88bcf30"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpty-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kpty-doc;unpack=0"
SRC_URI[aarch64_kf6-kpty-doc.sha256sum] = "0082a74d5c3a6d4c0678c62bffa24b6ba10b6728b14a4b1de586935194c0fbf7"

RDEPENDS:kf6-kpty = " \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 libutempter \
 qt6-qtbase \
 "
RDEPENDS:kf6-kpty-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kf6-kpty \
 "
RDEPENDS:kf6-kpty-doc = " \
 "
