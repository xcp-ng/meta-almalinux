# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand"
PV = "0.10.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-rand+alloc-devel \
 rust-rand+chacha-devel \
 rust-rand+default-devel \
 rust-rand+log-devel \
 rust-rand+serde-devel \
 rust-rand+std-devel \
 rust-rand+std_rng-devel \
 rust-rand+sys_rng-devel \
 rust-rand+thread_rng-devel \
 rust-rand+unbiased-devel \
 rust-rand-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand-0.10.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f21d44cb1848fd5bb870eaac3157065ca1634fc29c451c5d1f758d4d56a89039"

URI_x86_64_v2_rust-rand+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+alloc-devel-0.10.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+alloc-devel}"
SRC_URI[x86_64_v2_rust-rand+alloc-devel.sha256sum] = "668d32d0cdca43a327312d15983c33f4d59cbff617c701c522067965ad635285"

URI_x86_64_v2_rust-rand+chacha-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+chacha-devel-0.10.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+chacha-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+chacha-devel}"
SRC_URI[x86_64_v2_rust-rand+chacha-devel.sha256sum] = "6d254f471f61b180ca533891d40b2d6fa224fb0ecd1ba78abab6fe025b59d700"

URI_x86_64_v2_rust-rand+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+default-devel-0.10.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+default-devel}"
SRC_URI[x86_64_v2_rust-rand+default-devel.sha256sum] = "252da6aca0170ffb9eda8a2423f7c2a0ffbccb884601ac431ec2394b3c4f9896"

URI_x86_64_v2_rust-rand+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+log-devel-0.10.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+log-devel}"
SRC_URI[x86_64_v2_rust-rand+log-devel.sha256sum] = "039eac0a4cf3be729945282a74bb1edc5386eff7c293e95191154eb5371b702f"

URI_x86_64_v2_rust-rand+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+serde-devel-0.10.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+serde-devel}"
SRC_URI[x86_64_v2_rust-rand+serde-devel.sha256sum] = "35f6f846b33b1803b71f7432b50d00b5015b7171b0d06d620c64a6fcb65cbc8d"

URI_x86_64_v2_rust-rand+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+std-devel-0.10.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+std-devel}"
SRC_URI[x86_64_v2_rust-rand+std-devel.sha256sum] = "f2a2bbb981b54d3a642b320204c3b8f3cd4d4751c4f986922735da84c0057cc4"

URI_x86_64_v2_rust-rand+std_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+std_rng-devel-0.10.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+std_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+std_rng-devel}"
SRC_URI[x86_64_v2_rust-rand+std_rng-devel.sha256sum] = "74ba09117e5bf1d1cbc0a5dfd29b42994e8e6624775ad190d5e28c9a4adabee6"

URI_x86_64_v2_rust-rand+sys_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+sys_rng-devel-0.10.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+sys_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+sys_rng-devel}"
SRC_URI[x86_64_v2_rust-rand+sys_rng-devel.sha256sum] = "b3b0168f31a911a1bffa4aefcba023c4e4b3477275e8f4b670ff3554aa7aa277"

URI_x86_64_v2_rust-rand+thread_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+thread_rng-devel-0.10.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+thread_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+thread_rng-devel}"
SRC_URI[x86_64_v2_rust-rand+thread_rng-devel.sha256sum] = "6410cdfb4b558f92c2b32a0ddb231368235c50d9b729a9f1ed7810564df52345"
RPROVIDES:rust-rand+thread_rng-devel:x86_64_v2 = "virtual/crate_rand/thread_rng__ge_0.9.0_with_crate_rand/thread_rng__le_0.11.0"

URI_x86_64_v2_rust-rand+unbiased-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+unbiased-devel-0.10.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+unbiased-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+unbiased-devel}"
SRC_URI[x86_64_v2_rust-rand+unbiased-devel.sha256sum] = "3c74da7d0c662a1b677cb56b7568013e0d0de38e453ca3114370ef96c90752d5"

URI_x86_64_v2_rust-rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand-devel-0.10.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand-devel}"
SRC_URI[x86_64_v2_rust-rand-devel.sha256sum] = "4dede5f28b4682798e838ca2518969df7aee35a033bf7d056b1b779b5a3949b2"
RPROVIDES:rust-rand-devel:x86_64_v2 = "virtual/crate_rand__ge_0.9.0_with_crate_rand__le_0.11.0"

URI_aarch64_rust-rand+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+alloc-devel-0.10.2-1.el10_2.noarch.rpm;name=aarch64_rust-rand+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+alloc-devel}"
SRC_URI[aarch64_rust-rand+alloc-devel.sha256sum] = "3d4013766ccfacadd21b2686cb11629e8de4ac9f3863ab6a9404cbc5bb4496ff"

URI_aarch64_rust-rand+chacha-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+chacha-devel-0.10.2-1.el10_2.noarch.rpm;name=aarch64_rust-rand+chacha-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+chacha-devel}"
SRC_URI[aarch64_rust-rand+chacha-devel.sha256sum] = "6b9618b32a835c86fe05eb3611903e98863a042f71f9c5dcc16e590314d453e5"

URI_aarch64_rust-rand+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+default-devel-0.10.2-1.el10_2.noarch.rpm;name=aarch64_rust-rand+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+default-devel}"
SRC_URI[aarch64_rust-rand+default-devel.sha256sum] = "b3297d611c8e10429a1a4fa977c60a1cb710ea71d18848157cc7faaef724691d"

URI_aarch64_rust-rand+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+log-devel-0.10.2-1.el10_2.noarch.rpm;name=aarch64_rust-rand+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+log-devel}"
SRC_URI[aarch64_rust-rand+log-devel.sha256sum] = "e28e7479bf38b8d33b00c3a03ab54c66da23fef6cecd9dbca810b5b07778e1b6"

URI_aarch64_rust-rand+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+serde-devel-0.10.2-1.el10_2.noarch.rpm;name=aarch64_rust-rand+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+serde-devel}"
SRC_URI[aarch64_rust-rand+serde-devel.sha256sum] = "d0c9633352d6e2bab34db21c06ca88c630aa15cf00d4a90de17f61756fa7ff4a"

URI_aarch64_rust-rand+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+std-devel-0.10.2-1.el10_2.noarch.rpm;name=aarch64_rust-rand+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+std-devel}"
SRC_URI[aarch64_rust-rand+std-devel.sha256sum] = "321f1f6e87141bfe4dc4bf4fba979c5ccc21ea9d6ee14bc69b51eed9a9511361"

URI_aarch64_rust-rand+std_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+std_rng-devel-0.10.2-1.el10_2.noarch.rpm;name=aarch64_rust-rand+std_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+std_rng-devel}"
SRC_URI[aarch64_rust-rand+std_rng-devel.sha256sum] = "5f7ebf51ac46b63ed72c69370ee60c135223909676004cc90edcde9b0d61dc6c"

URI_aarch64_rust-rand+sys_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+sys_rng-devel-0.10.2-1.el10_2.noarch.rpm;name=aarch64_rust-rand+sys_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+sys_rng-devel}"
SRC_URI[aarch64_rust-rand+sys_rng-devel.sha256sum] = "6f65d14567bc56a5913462cdcc8a7d0390cea79965f7b19b92320eb3ea403c8d"

URI_aarch64_rust-rand+thread_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+thread_rng-devel-0.10.2-1.el10_2.noarch.rpm;name=aarch64_rust-rand+thread_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+thread_rng-devel}"
SRC_URI[aarch64_rust-rand+thread_rng-devel.sha256sum] = "67d352f813bb0c4d1e043bea0d5951e41ef802c8c0bec096d4d86a01ca10ce27"
RPROVIDES:rust-rand+thread_rng-devel:aarch64 = "virtual/crate_rand/thread_rng__ge_0.9.0_with_crate_rand/thread_rng__le_0.11.0"

URI_aarch64_rust-rand+unbiased-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+unbiased-devel-0.10.2-1.el10_2.noarch.rpm;name=aarch64_rust-rand+unbiased-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+unbiased-devel}"
SRC_URI[aarch64_rust-rand+unbiased-devel.sha256sum] = "f4fe6b09831e572a71965ae40ae1d46ef242fba66f263c90e0309d78e0300288"

URI_aarch64_rust-rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand-devel-0.10.2-1.el10_2.noarch.rpm;name=aarch64_rust-rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand-devel}"
SRC_URI[aarch64_rust-rand-devel.sha256sum] = "aceb32fbffcefbe53129323a3654a48e8cfa9d80af8c50bfb554f8a80f94c0c5"
RPROVIDES:rust-rand-devel:aarch64 = "virtual/crate_rand__ge_0.9.0_with_crate_rand__le_0.11.0"

RDEPENDS:rust-rand+alloc-devel = " \
 cargo \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+chacha-devel = " \
 cargo \
 rust-chacha20+rng-devel \
 rust-chacha20-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+default-devel = " \
 cargo \
 rust-rand+std-devel \
 rust-rand+std_rng-devel \
 rust-rand+sys_rng-devel \
 rust-rand+thread_rng-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+log-devel = " \
 cargo \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+serde-devel = " \
 cargo \
 rust-rand-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand+std-devel = " \
 cargo \
 rust-getrandom+default-devel \
 rust-getrandom+std-devel \
 rust-rand+alloc-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+std_rng-devel = " \
 cargo \
 rust-chacha20+rng-devel \
 rust-chacha20-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+sys_rng-devel = " \
 cargo \
 rust-getrandom+default-devel \
 rust-getrandom+sys_rng-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+thread_rng-devel = " \
 cargo \
 rust-rand+std-devel \
 rust-rand+std_rng-devel \
 rust-rand+sys_rng-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+unbiased-devel = " \
 cargo \
 rust-rand-devel \
 "
RDEPENDS:rust-rand-devel = " \
 cargo \
 rust \
 rust-rand_core-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_rand/thread_rng__ge_0.9.0_with_crate_rand/thread_rng__le_0.11.0 rpm/virtual/crate_rand__ge_0.9.0_with_crate_rand__le_0.11.0"

PROVIDES:append:aarch64 = " rpm/virtual/crate_rand/thread_rng__ge_0.9.0_with_crate_rand/thread_rng__le_0.11.0 rpm/virtual/crate_rand__ge_0.9.0_with_crate_rand__le_0.11.0"
