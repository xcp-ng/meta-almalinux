# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gethostname"
PV = "0.4.3"
PR = "4.el10_1"
PACKAGES = " \
 rust-gethostname+default-devel \
 rust-gethostname-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gethostname-0.4.3-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c8f5346bdd30a0c1040469966cd09c6ed76398bd5a71ad8c030ebdfc86bdbcda"

URI_x86_64_v2_rust-gethostname+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gethostname+default-devel-0.4.3-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gethostname+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gethostname+default-devel}"
SRC_URI[x86_64_v2_rust-gethostname+default-devel.sha256sum] = "a808d68d34c483f081269e493aee4a9c98723f05f4668706dc9f879085719d79"

URI_x86_64_v2_rust-gethostname-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gethostname-devel-0.4.3-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gethostname-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gethostname-devel}"
SRC_URI[x86_64_v2_rust-gethostname-devel.sha256sum] = "5e2ae469fa0b9d3f2848dc2c4e7253262f3fdfeda8b3f8f9cf6f91ac74c41351"

URI_aarch64_rust-gethostname+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gethostname+default-devel-0.4.3-4.el10_1.noarch.rpm;name=aarch64_rust-gethostname+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gethostname+default-devel}"
SRC_URI[aarch64_rust-gethostname+default-devel.sha256sum] = "8c0b2ba4cfd0b484612604cc4243d87df95b17909aed75dab4d92272860b5c91"

URI_aarch64_rust-gethostname-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gethostname-devel-0.4.3-4.el10_1.noarch.rpm;name=aarch64_rust-gethostname-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gethostname-devel}"
SRC_URI[aarch64_rust-gethostname-devel.sha256sum] = "b295a6e2ba04556264064bebe9271de9168c03880dcd0599dcee902f059c09ea"

RDEPENDS:rust-gethostname+default-devel = " \
 cargo \
 rust-gethostname-devel \
 "
RDEPENDS:rust-gethostname-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
