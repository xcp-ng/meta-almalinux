# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_plurals"
PV = "2.2.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-icu_plurals+compiled_data-devel \
 rust-icu_plurals+datagen-devel \
 rust-icu_plurals+default-devel \
 rust-icu_plurals+icu_normalizer_data-devel \
 rust-icu_plurals+serde-devel \
 rust-icu_plurals+unstable-devel \
 rust-icu_plurals-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_plurals-2.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fba30ff942a9aec52d0e1297de9fbb1c88078858eeff6c501bce8b428f17b1fe"

URI_x86_64_v2_rust-icu_plurals+compiled_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_plurals+compiled_data-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_plurals+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_plurals+compiled_data-devel}"
SRC_URI[x86_64_v2_rust-icu_plurals+compiled_data-devel.sha256sum] = "24f62d91a6ac61b43c024038e9feeb7605eb41ccf5466506582f2c02ca57b00f"

URI_x86_64_v2_rust-icu_plurals+datagen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_plurals+datagen-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_plurals+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_plurals+datagen-devel}"
SRC_URI[x86_64_v2_rust-icu_plurals+datagen-devel.sha256sum] = "d0abb0c51fc75de3001a7cd799c1d5d3bd48a708f4b7af0d9505054aea09e797"

URI_x86_64_v2_rust-icu_plurals+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_plurals+default-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_plurals+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_plurals+default-devel}"
SRC_URI[x86_64_v2_rust-icu_plurals+default-devel.sha256sum] = "e27afaff9b1b3a0132a9da559c61aa65d5b90561083c9f46aed449e2160b4406"

URI_x86_64_v2_rust-icu_plurals+icu_normalizer_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_plurals+icu_normalizer_data-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_plurals+icu_normalizer_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_plurals+icu_normalizer_data-devel}"
SRC_URI[x86_64_v2_rust-icu_plurals+icu_normalizer_data-devel.sha256sum] = "d0b8ca032fda9d3691a789138169b7244f1146a62fd58131cadfefa3586377d0"

URI_x86_64_v2_rust-icu_plurals+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_plurals+serde-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_plurals+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_plurals+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_plurals+serde-devel.sha256sum] = "2152f79dcd97b79467242f2a952a847ea8d0373844b18f8ec03d135c08326e44"

URI_x86_64_v2_rust-icu_plurals+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_plurals+unstable-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_plurals+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_plurals+unstable-devel}"
SRC_URI[x86_64_v2_rust-icu_plurals+unstable-devel.sha256sum] = "fd176b7c1bd37d41200ede9ba785e9df2062060b92a1aa68ae9359c4d3c5f4c2"

URI_x86_64_v2_rust-icu_plurals-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_plurals-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_plurals-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_plurals-devel}"
SRC_URI[x86_64_v2_rust-icu_plurals-devel.sha256sum] = "6b4f70f359ded8ade361eaf9f11fc040e6bbd6fe86d3daa3ec1530947e459ca8"

URI_aarch64_rust-icu_plurals+compiled_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_plurals+compiled_data-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_plurals+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_plurals+compiled_data-devel}"
SRC_URI[aarch64_rust-icu_plurals+compiled_data-devel.sha256sum] = "21801a66643e838596e776fc737b0f46983a7c24d7963f7ddc24fcd7615ccee0"

URI_aarch64_rust-icu_plurals+datagen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_plurals+datagen-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_plurals+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_plurals+datagen-devel}"
SRC_URI[aarch64_rust-icu_plurals+datagen-devel.sha256sum] = "62b9b32b4c84829b634c94c906d7da5c1ef7464e03f8fed91941f73a438f89ff"

URI_aarch64_rust-icu_plurals+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_plurals+default-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_plurals+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_plurals+default-devel}"
SRC_URI[aarch64_rust-icu_plurals+default-devel.sha256sum] = "51ada24e9014146c431fb0d11bc380af54624e29f279cbb26e7be6c316427965"

URI_aarch64_rust-icu_plurals+icu_normalizer_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_plurals+icu_normalizer_data-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_plurals+icu_normalizer_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_plurals+icu_normalizer_data-devel}"
SRC_URI[aarch64_rust-icu_plurals+icu_normalizer_data-devel.sha256sum] = "769f19f3013ab7b7b169173f5ac359c5ba5d2e2a23dfde5102918d72fbfa1b0a"

URI_aarch64_rust-icu_plurals+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_plurals+serde-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_plurals+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_plurals+serde-devel}"
SRC_URI[aarch64_rust-icu_plurals+serde-devel.sha256sum] = "57e81c92ab2b14a11739cef78c11170889897ec111151aa25774ef6f95861734"

URI_aarch64_rust-icu_plurals+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_plurals+unstable-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_plurals+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_plurals+unstable-devel}"
SRC_URI[aarch64_rust-icu_plurals+unstable-devel.sha256sum] = "28f03d982dd225461912bf36425dfd5fb611de4d7fe40ad223cfd80cb6c8ec03"

URI_aarch64_rust-icu_plurals-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_plurals-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_plurals-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_plurals-devel}"
SRC_URI[aarch64_rust-icu_plurals-devel.sha256sum] = "8841fd48f5d1cbc5128fe29cadc4e3e2fb29b8d2e684aaf7e2f42f29e818862c"

RDEPENDS:rust-icu_plurals+compiled_data-devel = " \
 cargo \
 rust-icu_locale+compiled_data-devel \
 rust-icu_locale-devel \
 rust-icu_plurals-devel \
 rust-icu_plurals_data-devel \
 rust-icu_provider+baked-devel \
 "
RDEPENDS:rust-icu_plurals+datagen-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-icu_plurals+serde-devel \
 rust-icu_plurals-devel \
 rust-icu_provider+export-devel \
 rust-zerovec+databake-devel \
 "
RDEPENDS:rust-icu_plurals+default-devel = " \
 cargo \
 rust-icu_plurals+compiled_data-devel \
 rust-icu_plurals-devel \
 "
RDEPENDS:rust-icu_plurals+icu_normalizer_data-devel = " \
 cargo \
 rust-icu_plurals-devel \
 "
RDEPENDS:rust-icu_plurals+serde-devel = " \
 cargo \
 rust-displaydoc-devel \
 rust-icu_plurals-devel \
 rust-icu_provider+serde-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerovec+serde-devel \
 "
RDEPENDS:rust-icu_plurals+unstable-devel = " \
 cargo \
 rust-icu_plurals-devel \
 "
RDEPENDS:rust-icu_plurals-devel = " \
 cargo \
 rust \
 rust-fixed_decimal-devel \
 rust-icu_provider+alloc-devel \
 rust-icu_provider-devel \
 rust-zerovec+alloc-devel \
 rust-zerovec+yoke-devel \
 rust-zerovec-devel \
 "
