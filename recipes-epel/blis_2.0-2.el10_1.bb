# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "blis"
PV = "2.0"
PR = "2.el10_1"
PACKAGES = " \
 blis \
 blis-devel \
 blis-openmp \
 blis-openmp64 \
 blis-serial64 \
 blis-srpm-macros \
 blis-threads \
 blis-threads64 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/blis-2.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1773a64d6a7ee8ee8d616b63f5d919a947fcaf3fbbf1b5513519180e9c1b9ddb"

URI_x86_64_v2_blis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blis-2.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_blis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blis}"
SRC_URI[x86_64_v2_blis.sha256sum] = "5ca419679374aebe6c1e5f04018d180576c8f4e1e65c60c6e695b1bd8b8ef14b"
RPROVIDES:blis:x86_64_v2 = "virtual/libblas.so.3___64bit_"

URI_x86_64_v2_blis-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blis-devel-2.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_blis-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blis-devel}"
SRC_URI[x86_64_v2_blis-devel.sha256sum] = "8708164e3a8b9604feba1b268b0eb5ad7c5bac874cb87c4237affc10d7e8b699"

URI_x86_64_v2_blis-openmp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blis-openmp-2.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_blis-openmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blis-openmp}"
SRC_URI[x86_64_v2_blis-openmp.sha256sum] = "f1ca34baee8edde5b052bee8e757771ede7e996eacd9d880deaab6b6de76abcb"
RPROVIDES:blis-openmp:x86_64_v2 = "virtual/libblas.so.3___64bit_"

URI_x86_64_v2_blis-openmp64 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blis-openmp64-2.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_blis-openmp64;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blis-openmp64}"
SRC_URI[x86_64_v2_blis-openmp64.sha256sum] = "081e311565c03c23677e144dcdfe7db0d108d290213f64c3af84b4be01a05ec1"
RPROVIDES:blis-openmp64:x86_64_v2 = "virtual/libblas64.so.3___64bit_"

URI_x86_64_v2_blis-serial64 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blis-serial64-2.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_blis-serial64;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blis-serial64}"
SRC_URI[x86_64_v2_blis-serial64.sha256sum] = "d407780a0c4a067028531f9cab5d8fc3b8272f16ab6a2faaf3833329c66c9aad"
RPROVIDES:blis-serial64:x86_64_v2 = "virtual/libblas64.so.3___64bit_"

URI_x86_64_v2_blis-srpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blis-srpm-macros-2.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_blis-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blis-srpm-macros}"
SRC_URI[x86_64_v2_blis-srpm-macros.sha256sum] = "ededd788bf4ef32e41fb067f03f7c85af1cd7810bf605d2452e94d3a2e90ce07"

URI_x86_64_v2_blis-threads = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blis-threads-2.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_blis-threads;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blis-threads}"
SRC_URI[x86_64_v2_blis-threads.sha256sum] = "bae05e5ec8467a04f986f2f00b3fd46cfad5fb5235953e6dff15f7064bfbf225"
RPROVIDES:blis-threads:x86_64_v2 = "virtual/libblas.so.3___64bit_"

URI_x86_64_v2_blis-threads64 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blis-threads64-2.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_blis-threads64;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blis-threads64}"
SRC_URI[x86_64_v2_blis-threads64.sha256sum] = "aea7fbfb6c60cded4b38b601fc8ebaba634033d5f7002a0faaaaef13f0f5a1a7"
RPROVIDES:blis-threads64:x86_64_v2 = "virtual/libblas64.so.3___64bit_"

URI_aarch64_blis = "${EPEL_MIRROR}/aarch64/Packages/b/blis-2.0-2.el10_1.aarch64.rpm;name=aarch64_blis;unpack=0"
SRC_URI:append = " ${URI_aarch64_blis}"
SRC_URI[aarch64_blis.sha256sum] = "4bfd0279bedd04ce465e97cf452d4d2b8eec4999b3ab1f1af4a63f9b833d1630"
RPROVIDES:blis:aarch64 = "virtual/libblas.so.3___64bit_"

URI_aarch64_blis-devel = "${EPEL_MIRROR}/aarch64/Packages/b/blis-devel-2.0-2.el10_1.aarch64.rpm;name=aarch64_blis-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_blis-devel}"
SRC_URI[aarch64_blis-devel.sha256sum] = "7c3906145c7cbab4d4a592f632a2f155dea37d9e85fa495b027badf8d9d9f381"

URI_aarch64_blis-openmp = "${EPEL_MIRROR}/aarch64/Packages/b/blis-openmp-2.0-2.el10_1.aarch64.rpm;name=aarch64_blis-openmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_blis-openmp}"
SRC_URI[aarch64_blis-openmp.sha256sum] = "ac0dd436edfc694ab2faae8adddebb3937bd9ba4a83dca3fc68cf914d5dcab06"
RPROVIDES:blis-openmp:aarch64 = "virtual/libblas.so.3___64bit_"

URI_aarch64_blis-openmp64 = "${EPEL_MIRROR}/aarch64/Packages/b/blis-openmp64-2.0-2.el10_1.aarch64.rpm;name=aarch64_blis-openmp64;unpack=0"
SRC_URI:append = " ${URI_aarch64_blis-openmp64}"
SRC_URI[aarch64_blis-openmp64.sha256sum] = "f009e4444713be1161222f00086c39bf5fd7d9e7f19d6ac8ff6e1215b9d0ec0a"
RPROVIDES:blis-openmp64:aarch64 = "virtual/libblas64.so.3___64bit_"

URI_aarch64_blis-serial64 = "${EPEL_MIRROR}/aarch64/Packages/b/blis-serial64-2.0-2.el10_1.aarch64.rpm;name=aarch64_blis-serial64;unpack=0"
SRC_URI:append = " ${URI_aarch64_blis-serial64}"
SRC_URI[aarch64_blis-serial64.sha256sum] = "02465d87c2bd23d360a967756b83e7130b23968e27e94204ceb17f427ffcff79"
RPROVIDES:blis-serial64:aarch64 = "virtual/libblas64.so.3___64bit_"

URI_aarch64_blis-srpm-macros = "${EPEL_MIRROR}/aarch64/Packages/b/blis-srpm-macros-2.0-2.el10_1.noarch.rpm;name=aarch64_blis-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_blis-srpm-macros}"
SRC_URI[aarch64_blis-srpm-macros.sha256sum] = "d0d4048d3340ad8e960a9c94f3be592cf1b4ff5ff5d43438674493add8366fae"

URI_aarch64_blis-threads = "${EPEL_MIRROR}/aarch64/Packages/b/blis-threads-2.0-2.el10_1.aarch64.rpm;name=aarch64_blis-threads;unpack=0"
SRC_URI:append = " ${URI_aarch64_blis-threads}"
SRC_URI[aarch64_blis-threads.sha256sum] = "d25db9e7992b5ca80e07fd77dfd04b7ce72d15ac2ae9e471ed114d37035ea32d"
RPROVIDES:blis-threads:aarch64 = "virtual/libblas.so.3___64bit_"

URI_aarch64_blis-threads64 = "${EPEL_MIRROR}/aarch64/Packages/b/blis-threads64-2.0-2.el10_1.aarch64.rpm;name=aarch64_blis-threads64;unpack=0"
SRC_URI:append = " ${URI_aarch64_blis-threads64}"
SRC_URI[aarch64_blis-threads64.sha256sum] = "4c0b34c6d26444a12087243c26654bc79b7360fc5b896138cfebd685d450ddc3"
RPROVIDES:blis-threads64:aarch64 = "virtual/libblas64.so.3___64bit_"

RDEPENDS:blis = " \
 glibc \
 "
RDEPENDS:blis-devel = " \
 blis \
 blis-openmp \
 blis-openmp64 \
 blis-serial64 \
 blis-threads \
 blis-threads64 \
 "
RDEPENDS:blis-openmp = " \
 glibc \
 libgcc \
 libgomp \
 "
RDEPENDS:blis-openmp64 = " \
 glibc \
 libgcc \
 libgomp \
 "
RDEPENDS:blis-serial64 = " \
 glibc \
 "
RDEPENDS:blis-srpm-macros = " \
 "
RDEPENDS:blis-threads = " \
 glibc \
 "
RDEPENDS:blis-threads64 = " \
 glibc \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/libblas.so.3___64bit_ rpm/virtual/libblas64.so.3___64bit_"

PROVIDES:append:aarch64 = " rpm/virtual/libblas.so.3___64bit_ rpm/virtual/libblas64.so.3___64bit_"
