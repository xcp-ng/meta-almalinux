# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pest_derive"
PV = "2.8.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-pest_derive+default-devel \
 rust-pest_derive+grammar-extras-devel \
 rust-pest_derive+std-devel \
 rust-pest_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pest_derive-2.8.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dbbdee0b9da871f6f01e115f2a4ff1b49ba8b6e6c54fe9fb2a9a25845b08af53"

URI_x86_64_v2_rust-pest_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_derive+default-devel-2.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_derive+default-devel}"
SRC_URI[x86_64_v2_rust-pest_derive+default-devel.sha256sum] = "9916e30bc7691b150e3227ddc9720bd2cb7e750c01e18363318fd572bb63d99c"

URI_x86_64_v2_rust-pest_derive+grammar-extras-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_derive+grammar-extras-devel-2.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_derive+grammar-extras-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_derive+grammar-extras-devel}"
SRC_URI[x86_64_v2_rust-pest_derive+grammar-extras-devel.sha256sum] = "d1cfca9b655ba59bc30e2df2cdd49323dd4a10896e1700139c4b178c0ef10ecb"

URI_x86_64_v2_rust-pest_derive+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_derive+std-devel-2.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_derive+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_derive+std-devel}"
SRC_URI[x86_64_v2_rust-pest_derive+std-devel.sha256sum] = "399ed60a0b2c82dab50106aac5622785003e9a9c241aba4c92fc56455c9a5b22"

URI_x86_64_v2_rust-pest_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_derive-devel-2.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_derive-devel}"
SRC_URI[x86_64_v2_rust-pest_derive-devel.sha256sum] = "4770cb77f8695b349b5c2af74ea5279c5af6be00c3a34814a3722de10a6774ad"

URI_aarch64_rust-pest_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_derive+default-devel-2.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-pest_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_derive+default-devel}"
SRC_URI[aarch64_rust-pest_derive+default-devel.sha256sum] = "3dad5d01c2225aedca50484d96d0cdb28990ffb00fc463b2c521d29d16273c21"

URI_aarch64_rust-pest_derive+grammar-extras-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_derive+grammar-extras-devel-2.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-pest_derive+grammar-extras-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_derive+grammar-extras-devel}"
SRC_URI[aarch64_rust-pest_derive+grammar-extras-devel.sha256sum] = "bf6a08e82f08bb595f2f3b2eaa93edd9367d251a4e6fa6f4b14093ef5d6fd817"

URI_aarch64_rust-pest_derive+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_derive+std-devel-2.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-pest_derive+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_derive+std-devel}"
SRC_URI[aarch64_rust-pest_derive+std-devel.sha256sum] = "ee2cacfa5ad5ffa10dbbf28cc8f8a7ce56b7266365463238834bc33ce6fb2515"

URI_aarch64_rust-pest_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_derive-devel-2.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-pest_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_derive-devel}"
SRC_URI[aarch64_rust-pest_derive-devel.sha256sum] = "1cd0d33d64e945d432438cd2cab8a2878a46e661d5e6112db98625d0874582ae"

RDEPENDS:rust-pest_derive+default-devel = " \
 cargo \
 rust-pest_derive+std-devel \
 rust-pest_derive-devel \
 "
RDEPENDS:rust-pest_derive+grammar-extras-devel = " \
 cargo \
 rust-pest_derive-devel \
 rust-pest_generator+grammar-extras-devel \
 "
RDEPENDS:rust-pest_derive+std-devel = " \
 cargo \
 rust-pest+std-devel \
 rust-pest_derive-devel \
 rust-pest_generator+std-devel \
 "
RDEPENDS:rust-pest_derive-devel = " \
 cargo \
 rust \
 rust-pest-devel \
 rust-pest_generator-devel \
 "
