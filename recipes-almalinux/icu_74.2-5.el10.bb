# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "icu"
PV = "74.2"
PR = "5.el10"
PACKAGES = " \
 icu \
 libicu \
 libicu-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/icu-74.2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a232491d1296a4a841670f9795d5b19df429921c8d6d03759a2e9635eb83a8da"

URI_x86_64_v2_icu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/icu-74.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_icu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_icu}"
SRC_URI[x86_64_v2_icu.sha256sum] = "c897e491f47630f3b7625771bafd8796e3b408c30ff79554ac6fb75b4d089ce7"

URI_x86_64_v2_libicu = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libicu-74.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_libicu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libicu}"
SRC_URI[x86_64_v2_libicu.sha256sum] = "8c2cd49ddc3fb0e66c58ff6f4eab6b25ee06cf1a7fc95faa34913e66f4e2bdfb"

URI_x86_64_v2_libicu-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libicu-devel-74.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_libicu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libicu-devel}"
SRC_URI[x86_64_v2_libicu-devel.sha256sum] = "0b9096d5fd8da43b07a4f048005fe55c58107cba1c18c6d5a313d71bdc43abbf"

URI_aarch64_icu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/icu-74.2-5.el10.aarch64.rpm;name=aarch64_icu;unpack=0"
SRC_URI:append = " ${URI_aarch64_icu}"
SRC_URI[aarch64_icu.sha256sum] = "8c5f097dc9c18073e7092db4dc2a2b82db39a3da28210cf52963ac9fd0bbd6f8"

URI_aarch64_libicu = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libicu-74.2-5.el10.aarch64.rpm;name=aarch64_libicu;unpack=0"
SRC_URI:append = " ${URI_aarch64_libicu}"
SRC_URI[aarch64_libicu.sha256sum] = "7223b6311a665444b3acf0f28512d60ae4f93198b2a5db810fa31442478b3e79"

URI_aarch64_libicu-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libicu-devel-74.2-5.el10.aarch64.rpm;name=aarch64_libicu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libicu-devel}"
SRC_URI[aarch64_libicu-devel.sha256sum] = "faa3fab11d2afff6042f1120ff64cbd9c79be41dc809edc80d1f1e0dd385d21e"

RDEPENDS:icu = " \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 "
RDEPENDS:libicu = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libicu-devel = " \
 bash \
 glibc \
 libicu \
 libicu-devel \
 pkgconf-pkg-config \
 "
