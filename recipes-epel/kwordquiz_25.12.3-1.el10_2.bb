# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kwordquiz"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kwordquiz \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kwordquiz-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "407752ffe4b1f81d16860ba8402cc2720f55215afffb3d686149ec3f9f341248"

URI_x86_64_v2_kwordquiz = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwordquiz-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwordquiz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwordquiz}"
SRC_URI[x86_64_v2_kwordquiz.sha256sum] = "bac7dc129444de74d374480820d416fc0a30b4361c54731ebc6eb09c6b2d3d8d"

URI_aarch64_kwordquiz = "${EPEL_MIRROR}/aarch64/Packages/k/kwordquiz-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kwordquiz;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwordquiz}"
SRC_URI[aarch64_kwordquiz.sha256sum] = "52d3c822f2845655826dd4f99849ca50c20c41dec9e1e3deedd8789faa4ea454"

RDEPENDS:kwordquiz = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-knewstuff \
 libkeduvocdocument \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
