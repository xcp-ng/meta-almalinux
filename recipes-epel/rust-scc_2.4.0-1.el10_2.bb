# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-scc"
PV = "2.4.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-scc+default-devel \
 rust-scc+equivalent-devel \
 rust-scc+serde-devel \
 rust-scc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-scc-2.4.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f11d4e2ae58ddc41f5eb2a51167dd4077e971d9b7747270fcfcad7ae9b14f23"

URI_x86_64_v2_rust-scc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scc+default-devel-2.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scc+default-devel}"
SRC_URI[x86_64_v2_rust-scc+default-devel.sha256sum] = "8d786e5b7d547db53ab98eba8d0aef0b8bd43a28b850763f019eef725bf7e660"

URI_x86_64_v2_rust-scc+equivalent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scc+equivalent-devel-2.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scc+equivalent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scc+equivalent-devel}"
SRC_URI[x86_64_v2_rust-scc+equivalent-devel.sha256sum] = "233404cbac6cafc2461a6a015c0ca00e169d398ae4a679f8da05b4d15ecb54a8"

URI_x86_64_v2_rust-scc+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scc+serde-devel-2.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scc+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scc+serde-devel}"
SRC_URI[x86_64_v2_rust-scc+serde-devel.sha256sum] = "05dcad9ade9458b84e981c32e1ea502174405e242eb622f1ffdb5005d347d5d7"

URI_x86_64_v2_rust-scc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scc-devel-2.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scc-devel}"
SRC_URI[x86_64_v2_rust-scc-devel.sha256sum] = "b5beb2be9deab6266a3c2d428a3371a96e79627a9338676d11670eb1f5a3a63c"

URI_aarch64_rust-scc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scc+default-devel-2.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-scc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scc+default-devel}"
SRC_URI[aarch64_rust-scc+default-devel.sha256sum] = "e3bc3d3dff26a6d50195105a9c995152a50958888a5ee09b0540ac2bfa738606"

URI_aarch64_rust-scc+equivalent-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scc+equivalent-devel-2.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-scc+equivalent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scc+equivalent-devel}"
SRC_URI[aarch64_rust-scc+equivalent-devel.sha256sum] = "696b87816dad45a8801ed956f079679bdd30895d8fce48ad1d5d4d99c5b197a9"

URI_aarch64_rust-scc+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scc+serde-devel-2.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-scc+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scc+serde-devel}"
SRC_URI[aarch64_rust-scc+serde-devel.sha256sum] = "6d522703ca5d0ff758321f9fab6541735b473dc6cec113bb867cfad9f32f7726"

URI_aarch64_rust-scc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scc-devel-2.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-scc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scc-devel}"
SRC_URI[aarch64_rust-scc-devel.sha256sum] = "8476f58cd3c2b07a9513ed04c7a719c43ef5ad93580f0fc494488a5de16593c2"

RDEPENDS:rust-scc+default-devel = " \
 cargo \
 rust-scc-devel \
 "
RDEPENDS:rust-scc+equivalent-devel = " \
 cargo \
 rust-equivalent+default-devel \
 rust-scc-devel \
 "
RDEPENDS:rust-scc+serde-devel = " \
 cargo \
 rust-scc-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-scc-devel = " \
 cargo \
 rust \
 rust-sdd+default-devel \
 "
