# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-pelletier-toml"
PV = "1.9.5"
PR = "7.el10_0"
PACKAGES = " \
 golang-github-pelletier-toml \
 golang-github-pelletier-toml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-pelletier-toml-1.9.5-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad210284d6cd155f73d595358be403c25bd2d8584f3c8ff8942352eb82d71819"

URI_x86_64_v2_golang-github-pelletier-toml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-pelletier-toml-1.9.5-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_golang-github-pelletier-toml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-pelletier-toml}"
SRC_URI[x86_64_v2_golang-github-pelletier-toml.sha256sum] = "b557c519bfcbfca7e5f0c5c9752c5365c41d71d80d3378a8360e640ee633139e"

URI_x86_64_v2_golang-github-pelletier-toml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-pelletier-toml-devel-1.9.5-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-pelletier-toml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-pelletier-toml-devel}"
SRC_URI[x86_64_v2_golang-github-pelletier-toml-devel.sha256sum] = "78a2e5a9688601ff82db6ef1314031464ebad94cafb4030bc70a820e18ef084f"

URI_aarch64_golang-github-pelletier-toml = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-pelletier-toml-1.9.5-7.el10_0.aarch64.rpm;name=aarch64_golang-github-pelletier-toml;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-pelletier-toml}"
SRC_URI[aarch64_golang-github-pelletier-toml.sha256sum] = "939b0b5ae0814b7cf353cb9b39ba1f54ccfe2979f4deb41d65692a839172c172"

URI_aarch64_golang-github-pelletier-toml-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-pelletier-toml-devel-1.9.5-7.el10_0.noarch.rpm;name=aarch64_golang-github-pelletier-toml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-pelletier-toml-devel}"
SRC_URI[aarch64_golang-github-pelletier-toml-devel.sha256sum] = "368a906f79408e574a7da863b98b0d2080457e395a0f0cf8a99541d840d9025a"

RDEPENDS:golang-github-pelletier-toml = " \
 glibc \
 "
RDEPENDS:golang-github-pelletier-toml-devel = " \
 go-filesystem \
 "
