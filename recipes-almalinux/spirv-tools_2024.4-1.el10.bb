# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "spirv-tools"
PV = "2024.4"
PR = "1.el10"
PACKAGES = " \
 spirv-tools \
 spirv-tools-devel \
 spirv-tools-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/spirv-tools-2024.4-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28c3364c7de8a6ae9eec4ffa5b2a88b2b82b3d6920f4332729cf72d6791d82b0"

URI_x86_64_v2_spirv-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/spirv-tools-2024.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_spirv-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spirv-tools}"
SRC_URI[x86_64_v2_spirv-tools.sha256sum] = "4a786f609617b470eb22a15312dab1bda937d74e37eccc74520e65cb9fffa2b4"

URI_x86_64_v2_spirv-tools-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/spirv-tools-devel-2024.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_spirv-tools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spirv-tools-devel}"
SRC_URI[x86_64_v2_spirv-tools-devel.sha256sum] = "23f07842592fcb0405641bc740275d6035515a67c28f36a082305375c34cc58d"

URI_x86_64_v2_spirv-tools-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/spirv-tools-libs-2024.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_spirv-tools-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spirv-tools-libs}"
SRC_URI[x86_64_v2_spirv-tools-libs.sha256sum] = "1aa652233bc6cfebe5e5aa60c3ccfbda91643d91a476d242916ddfa4a45e5cba"

URI_aarch64_spirv-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/spirv-tools-2024.4-1.el10.aarch64.rpm;name=aarch64_spirv-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_spirv-tools}"
SRC_URI[aarch64_spirv-tools.sha256sum] = "3f57b4fde1551b06df34871743e7e52adece407f1f9f5365214b89b7a394c39c"

URI_aarch64_spirv-tools-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/spirv-tools-devel-2024.4-1.el10.aarch64.rpm;name=aarch64_spirv-tools-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_spirv-tools-devel}"
SRC_URI[aarch64_spirv-tools-devel.sha256sum] = "b66b9c53a7458a00261d9636aa7e60aa33dc5b8d83b42a69d04ef133f0960327"

URI_aarch64_spirv-tools-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/spirv-tools-libs-2024.4-1.el10.aarch64.rpm;name=aarch64_spirv-tools-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_spirv-tools-libs}"
SRC_URI[aarch64_spirv-tools-libs.sha256sum] = "93f68da64ceac70d5f98515476abfd9f39be1a0bef39342af8a9a5c0fc4a47fd"

RDEPENDS:spirv-tools = " \
 bash \
 glibc \
 libstdc++ \
 spirv-tools-libs \
 "
RDEPENDS:spirv-tools-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 spirv-tools-libs \
 "
RDEPENDS:spirv-tools-libs = " \
 glibc \
 libstdc++ \
 "
