# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-similar"
PV = "2.7.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-similar+bstr-devel \
 rust-similar+bytes-devel \
 rust-similar+default-devel \
 rust-similar+inline-devel \
 rust-similar+serde-devel \
 rust-similar+text-devel \
 rust-similar+unicode-devel \
 rust-similar+unicode-segmentation-devel \
 rust-similar-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-similar-2.7.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "14d286eeb2df24b4ca3046de015ede5e033e7a7eb63fa1ce43fe9bec0ccff3ad"

URI_x86_64_v2_rust-similar+bstr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar+bstr-devel-2.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar+bstr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar+bstr-devel}"
SRC_URI[x86_64_v2_rust-similar+bstr-devel.sha256sum] = "9ee58bbdde8fe832c96ad4d1c6f1d166d14acdaa6e333e34cd09cb0f11550b07"

URI_x86_64_v2_rust-similar+bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar+bytes-devel-2.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar+bytes-devel}"
SRC_URI[x86_64_v2_rust-similar+bytes-devel.sha256sum] = "715fb721f66be24aa5be994f31fc81c55d697de0eca6421f430fc455a7fab794"

URI_x86_64_v2_rust-similar+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar+default-devel-2.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar+default-devel}"
SRC_URI[x86_64_v2_rust-similar+default-devel.sha256sum] = "9f33226108bb45bac483b8f9b325e7c0b2deeee4d3b611ec3bc912f3e31bff0f"

URI_x86_64_v2_rust-similar+inline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar+inline-devel-2.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar+inline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar+inline-devel}"
SRC_URI[x86_64_v2_rust-similar+inline-devel.sha256sum] = "9048a3392c7762f3e0f3b83e69068f6517a42ff73e56b769896190db9ff9bdce"

URI_x86_64_v2_rust-similar+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar+serde-devel-2.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar+serde-devel}"
SRC_URI[x86_64_v2_rust-similar+serde-devel.sha256sum] = "7208230b11fa28d1279252bc82bdd5a65222c4e3ae7e19315619105a12d2a323"

URI_x86_64_v2_rust-similar+text-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar+text-devel-2.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar+text-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar+text-devel}"
SRC_URI[x86_64_v2_rust-similar+text-devel.sha256sum] = "36b5eba69c512e92c83b1c898b441c8d2100bb45fd4736c64e99b472e17849fd"

URI_x86_64_v2_rust-similar+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar+unicode-devel-2.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar+unicode-devel}"
SRC_URI[x86_64_v2_rust-similar+unicode-devel.sha256sum] = "a4e58654a82aeaa77e2512e9fc451f623864539c49874f79bbc62c9433c708de"

URI_x86_64_v2_rust-similar+unicode-segmentation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar+unicode-segmentation-devel-2.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar+unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar+unicode-segmentation-devel}"
SRC_URI[x86_64_v2_rust-similar+unicode-segmentation-devel.sha256sum] = "31bbf42230ac80f86235113c2b14046578e169c0545238097f6832933a314f62"

URI_x86_64_v2_rust-similar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar-devel-2.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar-devel}"
SRC_URI[x86_64_v2_rust-similar-devel.sha256sum] = "9ff2f89c3e5138ace68e220513cd7f833363e439054aeaa0f6b037c0a62b50eb"

URI_aarch64_rust-similar+bstr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar+bstr-devel-2.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-similar+bstr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar+bstr-devel}"
SRC_URI[aarch64_rust-similar+bstr-devel.sha256sum] = "cdf554a7308267e5314aa60f5a8370349bd463a55eb5be7714402b3007392af0"

URI_aarch64_rust-similar+bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar+bytes-devel-2.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-similar+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar+bytes-devel}"
SRC_URI[aarch64_rust-similar+bytes-devel.sha256sum] = "590f309a13ff5203656a05e9c8b6ee61d42e958f36096889ea1394ecfeef95a2"

URI_aarch64_rust-similar+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar+default-devel-2.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-similar+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar+default-devel}"
SRC_URI[aarch64_rust-similar+default-devel.sha256sum] = "8f254c4b900c386e4b8886bf877846bcb392ff281529678de1f5e37b28a727c8"

URI_aarch64_rust-similar+inline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar+inline-devel-2.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-similar+inline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar+inline-devel}"
SRC_URI[aarch64_rust-similar+inline-devel.sha256sum] = "dd0f86fd838fc6b30c2205bcb8fc0bc9e2c6f903b95c716d9d7456d24c8d6494"

URI_aarch64_rust-similar+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar+serde-devel-2.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-similar+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar+serde-devel}"
SRC_URI[aarch64_rust-similar+serde-devel.sha256sum] = "fa5e7d9ac24d02b0f73469acb6b64a4ce573020abf88bdb929203d22d01c21fe"

URI_aarch64_rust-similar+text-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar+text-devel-2.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-similar+text-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar+text-devel}"
SRC_URI[aarch64_rust-similar+text-devel.sha256sum] = "9418bc5b2f19e03a7a1c64523896ae348e4ff391169fbb6b798184803c8c480d"

URI_aarch64_rust-similar+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar+unicode-devel-2.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-similar+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar+unicode-devel}"
SRC_URI[aarch64_rust-similar+unicode-devel.sha256sum] = "9b5aa6cc90edb90aa46922a5cdbca19de25e3a04de27d40d0d80b6e74fbd331b"

URI_aarch64_rust-similar+unicode-segmentation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar+unicode-segmentation-devel-2.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-similar+unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar+unicode-segmentation-devel}"
SRC_URI[aarch64_rust-similar+unicode-segmentation-devel.sha256sum] = "fbfc36418938912d42606cd20aa544b461a2a025b22791b4163a4707ac38ed66"

URI_aarch64_rust-similar-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar-devel-2.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-similar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar-devel}"
SRC_URI[aarch64_rust-similar-devel.sha256sum] = "158227f8390e040022aa9738c05b7882aadb49d27ec84f7f7792019c0e6541f1"

RDEPENDS:rust-similar+bstr-devel = " \
 cargo \
 rust-bstr-devel \
 rust-similar-devel \
 "
RDEPENDS:rust-similar+bytes-devel = " \
 cargo \
 rust-similar+bstr-devel \
 rust-similar+text-devel \
 rust-similar-devel \
 "
RDEPENDS:rust-similar+default-devel = " \
 cargo \
 rust-similar+text-devel \
 rust-similar-devel \
 "
RDEPENDS:rust-similar+inline-devel = " \
 cargo \
 rust-similar+text-devel \
 rust-similar-devel \
 "
RDEPENDS:rust-similar+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-similar-devel \
 "
RDEPENDS:rust-similar+text-devel = " \
 cargo \
 rust-similar-devel \
 "
RDEPENDS:rust-similar+unicode-devel = " \
 cargo \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-similar+text-devel \
 rust-similar+unicode-segmentation-devel \
 rust-similar-devel \
 "
RDEPENDS:rust-similar+unicode-segmentation-devel = " \
 cargo \
 rust-similar-devel \
 rust-unicode-segmentation+default-devel \
 "
RDEPENDS:rust-similar-devel = " \
 bash \
 cargo \
 rust \
 "
