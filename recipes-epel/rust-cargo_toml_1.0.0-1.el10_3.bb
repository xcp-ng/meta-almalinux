# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo_toml"
PV = "1.0.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-cargo_toml+default-devel \
 rust-cargo_toml+features-devel \
 rust-cargo_toml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo_toml-1.0.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "39158c0ad29dc97fcea99d41b7e43a3e205176b0ecf9cd23fc3453564d899c7d"

URI_x86_64_v2_rust-cargo_toml+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_toml+default-devel-1.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_toml+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_toml+default-devel}"
SRC_URI[x86_64_v2_rust-cargo_toml+default-devel.sha256sum] = "524015820b501aa6e5e43ca12dcdabefd74005aca54d3df230f1f3e83df953d9"

URI_x86_64_v2_rust-cargo_toml+features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_toml+features-devel-1.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_toml+features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_toml+features-devel}"
SRC_URI[x86_64_v2_rust-cargo_toml+features-devel.sha256sum] = "1be9ce03ff90584082e459b7e9933f6f680d0e2185ab09873838fc891eff4fa2"

URI_x86_64_v2_rust-cargo_toml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_toml-devel-1.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_toml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_toml-devel}"
SRC_URI[x86_64_v2_rust-cargo_toml-devel.sha256sum] = "7d34e2ed2984708e2126ea4a00a9b916535c2c1e9461306069ef5fd133245891"

URI_aarch64_rust-cargo_toml+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_toml+default-devel-1.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-cargo_toml+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_toml+default-devel}"
SRC_URI[aarch64_rust-cargo_toml+default-devel.sha256sum] = "872ebbf9e155e30d485b00547a99001aa78f27c9cc5ba1f6b7f170f8c0f105d7"

URI_aarch64_rust-cargo_toml+features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_toml+features-devel-1.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-cargo_toml+features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_toml+features-devel}"
SRC_URI[aarch64_rust-cargo_toml+features-devel.sha256sum] = "4df0249629463336bd94298a41928025a8dd2b852f7f8c5057abd733353c8773"

URI_aarch64_rust-cargo_toml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_toml-devel-1.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-cargo_toml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_toml-devel}"
SRC_URI[aarch64_rust-cargo_toml-devel.sha256sum] = "9d7ef61b07c45a325f479740972200e40c2ac83d00c187ce11680624c1db4bba"

RDEPENDS:rust-cargo_toml+default-devel = " \
 cargo \
 rust-cargo_toml-devel \
 "
RDEPENDS:rust-cargo_toml+features-devel = " \
 cargo \
 rust-cargo_toml-devel \
 "
RDEPENDS:rust-cargo_toml-devel = " \
 cargo \
 rust \
 rust-semver+serde-devel \
 rust-semver+std-devel \
 rust-semver-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-toml+default-devel \
 "
