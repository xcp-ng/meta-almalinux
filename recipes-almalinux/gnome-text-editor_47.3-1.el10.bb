# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-text-editor"
PV = "47.3"
PR = "1.el10"
PACKAGES = " \
 gnome-text-editor \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-text-editor-47.3-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "11891fb7e3b93b3102e08e60b1291b693287226580ad805ef4621feba734d560"

URI_x86_64_v2_gnome-text-editor = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-text-editor-47.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-text-editor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-text-editor}"
SRC_URI[x86_64_v2_gnome-text-editor.sha256sum] = "6e273feca93c9cb25882b2403ff93b07841dfdd5ae51fc55ac36dc3105fc5b39"

URI_aarch64_gnome-text-editor = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-text-editor-47.3-1.el10.aarch64.rpm;name=aarch64_gnome-text-editor;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-text-editor}"
SRC_URI[aarch64_gnome-text-editor.sha256sum] = "01f57ca16f41f8608baab2650ea8821bdaafb037a461ecc12f1ece01f58a6af3"

RDEPENDS:gnome-text-editor = " \
 cairo \
 editorconfig-libs \
 enchant2 \
 glib2 \
 glibc \
 gtk4 \
 gtksourceview5 \
 libadwaita \
 libgcc \
 libspelling \
 pango \
 "
