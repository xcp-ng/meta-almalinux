# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-activities-stats"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 plasma-activities-stats \
 plasma-activities-stats-devel \
 plasma-activities-stats-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-activities-stats-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "350c69f4e7bf7f1ef1a979b6dd53928390e90689862bea457da823cb99bdf867"

URI_x86_64_v2_plasma-activities-stats = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-activities-stats-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-activities-stats;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-activities-stats}"
SRC_URI[x86_64_v2_plasma-activities-stats.sha256sum] = "5ed727dfcf22c7ccc756421e41cb2ef00f952b7ecb60aa619b3f205b7cfe4be7"

URI_x86_64_v2_plasma-activities-stats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-activities-stats-devel-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-activities-stats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-activities-stats-devel}"
SRC_URI[x86_64_v2_plasma-activities-stats-devel.sha256sum] = "e7dab9cb9226ce888352988e2179af6ae8387759d79ab221f8a968cd46779768"

URI_x86_64_v2_plasma-activities-stats-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-activities-stats-doc-6.3.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-activities-stats-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-activities-stats-doc}"
SRC_URI[x86_64_v2_plasma-activities-stats-doc.sha256sum] = "cf573c2aa5f89774de405986be73549fe8b8bfc77ecfa5a9a0732dd5be391d93"

URI_aarch64_plasma-activities-stats = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-activities-stats-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-activities-stats;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-activities-stats}"
SRC_URI[aarch64_plasma-activities-stats.sha256sum] = "d364c4f28dc8a8bcd2cc23e4dea2d7f560afa11da58c3551b3fc495540ea6a12"

URI_aarch64_plasma-activities-stats-devel = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-activities-stats-devel-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-activities-stats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-activities-stats-devel}"
SRC_URI[aarch64_plasma-activities-stats-devel.sha256sum] = "7a2b11ec649c35deac3f6e54a84ce2947194a638ad452f1fcf11c58d082e65c8"

URI_aarch64_plasma-activities-stats-doc = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-activities-stats-doc-6.3.6-1.el10_0.noarch.rpm;name=aarch64_plasma-activities-stats-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-activities-stats-doc}"
SRC_URI[aarch64_plasma-activities-stats-doc.sha256sum] = "c36c70c66bc61be228083847fa0d293bb824814718337bf6accfcd96cf89fa5c"

RDEPENDS:plasma-activities-stats = " \
 glibc \
 kf6-kconfig \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 "
RDEPENDS:plasma-activities-stats-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 plasma-activities-stats \
 qt6-qtbase-devel \
 "
RDEPENDS:plasma-activities-stats-doc = " \
 "
