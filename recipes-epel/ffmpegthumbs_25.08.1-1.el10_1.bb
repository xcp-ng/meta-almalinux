# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ffmpegthumbs"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 ffmpegthumbs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/ffmpegthumbs-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2c5c78738c6bcc787816ef33d4322386eae077e34d597fc4c12f5c4ecbb89197"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - ffmpegthumbs: libavcodec.so.61()(64bit)
# - ffmpegthumbs: libavcodec.so.61(LIBAVCODEC_61)(64bit)
# - ffmpegthumbs: libavfilter.so.10()(64bit)
# - ffmpegthumbs: libavfilter.so.10(LIBAVFILTER_10)(64bit)
# - ffmpegthumbs: libavformat.so.61()(64bit)
# - ffmpegthumbs: libavformat.so.61(LIBAVFORMAT_61)(64bit)
# - ffmpegthumbs: libavutil.so.59()(64bit)
# - ffmpegthumbs: libavutil.so.59(LIBAVUTIL_59)(64bit)
# - ffmpegthumbs: libswscale.so.8()(64bit)
# - ffmpegthumbs: libswscale.so.8(LIBSWSCALE_8)(64bit)

URI_x86_64_v2_ffmpegthumbs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ffmpegthumbs-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ffmpegthumbs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ffmpegthumbs}"
SRC_URI[x86_64_v2_ffmpegthumbs.sha256sum] = "bd740bd8483845c856ead44ea8a1c867b5834e373f3d26ba0076f13ae6364a4c"

URI_aarch64_ffmpegthumbs = "${EPEL_MIRROR}/aarch64/Packages/f/ffmpegthumbs-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_ffmpegthumbs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ffmpegthumbs}"
SRC_URI[aarch64_ffmpegthumbs.sha256sum] = "4915977ab8ab052efe96fdbcf1a781c20cd258fc42953dc33dfe0c3f1615bbea"

RDEPENDS:ffmpegthumbs:x86_64_v2 = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kio-gui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
"
RDEPENDS:ffmpegthumbs:aarch64 = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kio-gui \
 libavcodec-free \
 libavfilter-free \
 libavformat-free \
 libavutil-free \
 libstdc++ \
 libswscale-free \
 qt6-qtbase \
 qt6-qtbase-gui \
"
