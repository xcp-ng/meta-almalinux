# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aggregate6"
PV = "1.0.15"
PR = "1.el10_1"
PACKAGES = " \
 aggregate6 \
 python3-aggregate6 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aggregate6-1.0.15-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27ab233037413425fde5a4d2a195102f5343cbff337b2c7b964444c9a77d7ea2"

URI_x86_64_v2_aggregate6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aggregate6-1.0.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_aggregate6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aggregate6}"
SRC_URI[x86_64_v2_aggregate6.sha256sum] = "28bda745e660d63eae281e2dd58154fe8a01a946682573aeb304d6518797cc4a"

URI_x86_64_v2_python3-aggregate6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-aggregate6-1.0.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-aggregate6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-aggregate6}"
SRC_URI[x86_64_v2_python3-aggregate6.sha256sum] = "f8fa2cd24fef36d30436c4fb54c68d8509535f318db91c666450cdd23a2a336d"

URI_aarch64_aggregate6 = "${EPEL_MIRROR}/aarch64/Packages/a/aggregate6-1.0.15-1.el10_1.noarch.rpm;name=aarch64_aggregate6;unpack=0"
SRC_URI:append = " ${URI_aarch64_aggregate6}"
SRC_URI[aarch64_aggregate6.sha256sum] = "f9efbad28c5f4703cbdf75a43d40216ecd21dfad935a6f02f90f1a3d66fccc33"

URI_aarch64_python3-aggregate6 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-aggregate6-1.0.15-1.el10_1.noarch.rpm;name=aarch64_python3-aggregate6;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-aggregate6}"
SRC_URI[aarch64_python3-aggregate6.sha256sum] = "7202ee527ebd4253b998282c7a1e3b01787824e4eec6f0490aec6ee5f8df2ac9"

RDEPENDS:aggregate6 = " \
 python3 \
 python3-aggregate6 \
 "
RDEPENDS:python3-aggregate6 = " \
 python3 \
 python3-py-radix \
 "
