# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pam-kwallet"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 pam-kwallet \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/pam-kwallet-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "38af2c53a24263583c5f54892851f6d5cc81be172971853af23a82907293f8fa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pam-kwallet-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pam-kwallet;unpack=0"
SRC_URI[x86_64_v2_pam-kwallet.sha256sum] = "2236800766b1e0df66fafe01109058747bf32804382036f8bd71208940b874d9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pam-kwallet-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_pam-kwallet;unpack=0"
SRC_URI[aarch64_pam-kwallet.sha256sum] = "57a688f244b2eb86df99bec1090c293f8619fee484798f7d9861b27901f99098"

RDEPENDS:pam-kwallet = " \
 bash \
 glibc \
 kf6-kwallet \
 libgcrypt \
 pam-libs \
 socat \
 "
