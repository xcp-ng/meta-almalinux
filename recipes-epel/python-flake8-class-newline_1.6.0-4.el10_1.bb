# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-flake8-class-newline"
PV = "1.6.0"
PR = "4.el10_1"
PACKAGES = " \
 python3-flake8-class-newline \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-flake8-class-newline-1.6.0-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dcd88fae1e36a1b7057d627395e364bab3417f3c182e55a4fe88ce1f964a9b49"

URI_x86_64_v2_python3-flake8-class-newline = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-flake8-class-newline-1.6.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-flake8-class-newline;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-flake8-class-newline}"
SRC_URI[x86_64_v2_python3-flake8-class-newline.sha256sum] = "22e7f8a0deafe54b3eb79af0336295dda5c0ce0b9616e342a47500e7988e16b4"

URI_aarch64_python3-flake8-class-newline = "${EPEL_MIRROR}/aarch64/Packages/p/python3-flake8-class-newline-1.6.0-4.el10_1.noarch.rpm;name=aarch64_python3-flake8-class-newline;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-flake8-class-newline}"
SRC_URI[aarch64_python3-flake8-class-newline.sha256sum] = "122c0dc47f1b5c750827149b85973ad7f58cda1d1a58691a5b86a619ea7742f0"

RDEPENDS:python3-flake8-class-newline = " \
 python3 \
 python3-flake8 \
 "
