# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcoreaddons"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kcoreaddons \
 kf6-kcoreaddons-devel \
 kf6-kcoreaddons-doc \
 kf6-kcoreaddons-html \
 python3-kf6-kcoreaddons \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kcoreaddons-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b051baa690d532489c8ea6e9aee63c28ec7321d8eac6a7dedc5feadf098c0eee"

URI_x86_64_v2_kf6-kcoreaddons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcoreaddons-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcoreaddons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcoreaddons}"
SRC_URI[x86_64_v2_kf6-kcoreaddons.sha256sum] = "4fbd11fb3c4041fa940f304461b84728ce13fc03b61f4a35d3379148ea2319f3"

URI_x86_64_v2_kf6-kcoreaddons-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcoreaddons-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcoreaddons-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcoreaddons-devel}"
SRC_URI[x86_64_v2_kf6-kcoreaddons-devel.sha256sum] = "bc3352ad50944920bf177bf758fa5c1e9d26bcc8ea483358b9be924fab6290eb"

URI_x86_64_v2_kf6-kcoreaddons-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcoreaddons-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcoreaddons-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcoreaddons-doc}"
SRC_URI[x86_64_v2_kf6-kcoreaddons-doc.sha256sum] = "3dd8014df7244557955a2ccef035ef28254c725803744aa23d671f0d0ef59b54"

URI_x86_64_v2_kf6-kcoreaddons-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcoreaddons-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcoreaddons-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcoreaddons-html}"
SRC_URI[x86_64_v2_kf6-kcoreaddons-html.sha256sum] = "1efb6495254e5ba2d3baa23d0c96122e6443cd7126aadcce3d65d87e1c1af285"

URI_x86_64_v2_python3-kf6-kcoreaddons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-kcoreaddons-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-kcoreaddons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kf6-kcoreaddons}"
SRC_URI[x86_64_v2_python3-kf6-kcoreaddons.sha256sum] = "2b085c8c300124300a48c684e98d077cf9179125b9417ab3fa00dab6bbb5ec87"

URI_aarch64_kf6-kcoreaddons = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcoreaddons-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kcoreaddons;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcoreaddons}"
SRC_URI[aarch64_kf6-kcoreaddons.sha256sum] = "c8b337b9c2412f7ca695fc8979f445002190c5ceb4c3bd37e6d4d60c73872801"

URI_aarch64_kf6-kcoreaddons-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcoreaddons-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kcoreaddons-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcoreaddons-devel}"
SRC_URI[aarch64_kf6-kcoreaddons-devel.sha256sum] = "f8c29a050886dc6da162bef2fab0e982f10142373545c3a6244fe0267a8e7f75"

URI_aarch64_kf6-kcoreaddons-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcoreaddons-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kcoreaddons-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcoreaddons-doc}"
SRC_URI[aarch64_kf6-kcoreaddons-doc.sha256sum] = "44df689795e49e405185e5b7f7c8bde8100a464f3358524a5ca416b2ae1c4881"

URI_aarch64_kf6-kcoreaddons-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcoreaddons-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kcoreaddons-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcoreaddons-html}"
SRC_URI[aarch64_kf6-kcoreaddons-html.sha256sum] = "9c0e8e778beabb4dc503f4e0bf173218a1a079aade5c2e55c567395512e9b343"

URI_aarch64_python3-kf6-kcoreaddons = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-kcoreaddons-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_python3-kf6-kcoreaddons;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kf6-kcoreaddons}"
SRC_URI[aarch64_python3-kf6-kcoreaddons.sha256sum] = "d1fa8774ab54302c8468eb719572f468f1de539045382d1a77d854e3a86ac900"

RDEPENDS:kf6-kcoreaddons = " \
 glibc \
 kf6-filesystem \
 libgcc \
 libmount \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 systemd-libs \
 "
RDEPENDS:kf6-kcoreaddons-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kcoreaddons-doc = " \
 "
RDEPENDS:kf6-kcoreaddons-html = " \
 "
RDEPENDS:python3-kf6-kcoreaddons = " \
 glibc \
 kf6-kcoreaddons \
 libgcc \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 "
