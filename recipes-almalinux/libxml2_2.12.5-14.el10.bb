# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libxml2"
PV = "2.12.5"
PR = "14.el10"
PACKAGES = " \
 libxml2 \
 libxml2-devel \
 libxml2-static \
 python3-libxml2 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libxml2-2.12.5-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c792a4d8b53b844a8f3d56662ab086d4d1e7d81a312f1f8d2cd9d25a88deed1c"

URI_x86_64_v2_libxml2 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libxml2-2.12.5-14.el10.x86_64_v2.rpm;name=x86_64_v2_libxml2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxml2}"
SRC_URI[x86_64_v2_libxml2.sha256sum] = "57a519151b42794fb7287d68a209f9092ff27d562097326420b6bfd48164d9c3"

URI_x86_64_v2_libxml2-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libxml2-devel-2.12.5-14.el10.x86_64_v2.rpm;name=x86_64_v2_libxml2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxml2-devel}"
SRC_URI[x86_64_v2_libxml2-devel.sha256sum] = "3bc5645b8c36a9c95b336ec286cee5c046a1abcd32254924880fb1a29bc73df6"

URI_x86_64_v2_libxml2-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libxml2-static-2.12.5-14.el10.x86_64_v2.rpm;name=x86_64_v2_libxml2-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxml2-static}"
SRC_URI[x86_64_v2_libxml2-static.sha256sum] = "1ef1a239dc4c6ccaee98f119b44c2d58e02cab558aac19d81b69751b808ca791"

URI_x86_64_v2_python3-libxml2 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-libxml2-2.12.5-14.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libxml2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libxml2}"
SRC_URI[x86_64_v2_python3-libxml2.sha256sum] = "30e049c50d2f541b651cac131e0d02bc1b6e9347932b30e9566e7aa0eb5483a1"

URI_aarch64_libxml2 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libxml2-2.12.5-14.el10.aarch64.rpm;name=aarch64_libxml2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxml2}"
SRC_URI[aarch64_libxml2.sha256sum] = "551330c76fe3b735ce54df3c5ab6309412cebf97b40e1263736b2995db40a226"

URI_aarch64_libxml2-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libxml2-devel-2.12.5-14.el10.aarch64.rpm;name=aarch64_libxml2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxml2-devel}"
SRC_URI[aarch64_libxml2-devel.sha256sum] = "18314e2dfa2481a93a3588739c78a7daec90a3618aedc8be6ff74f8e0edd2b07"

URI_aarch64_libxml2-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libxml2-static-2.12.5-14.el10.aarch64.rpm;name=aarch64_libxml2-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxml2-static}"
SRC_URI[aarch64_libxml2-static.sha256sum] = "ccab71ef516bd9ee401095d22e22082454053784aa49d7216a026e45a0ffd3b0"

URI_aarch64_python3-libxml2 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-libxml2-2.12.5-14.el10.aarch64.rpm;name=aarch64_python3-libxml2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libxml2}"
SRC_URI[aarch64_python3-libxml2.sha256sum] = "8e17ac31aced708e1a024b1fec6e046d3760b28f3f6ca2acc00182e181d76400"

RDEPENDS:libxml2 = " \
 glibc \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:libxml2-devel = " \
 bash \
 cmake-filesystem \
 libxml2 \
 pkgconf-pkg-config \
 xz-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:libxml2-static = " \
 "
RDEPENDS:python3-libxml2 = " \
 glibc \
 libxml2 \
 python3 \
 "
