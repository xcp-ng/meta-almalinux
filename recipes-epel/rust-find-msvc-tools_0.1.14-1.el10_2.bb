# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-find-msvc-tools"
PV = "0.1.14"
PR = "1.el10_2"
PACKAGES = " \
 rust-find-msvc-tools+default-devel \
 rust-find-msvc-tools-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-find-msvc-tools-0.1.14-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "05037cacb6ca31af9aeaabf0037eb2a60124323321efa35bd67fa987bdd54f8f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-find-msvc-tools+default-devel-0.1.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-find-msvc-tools+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-find-msvc-tools+default-devel.sha256sum] = "7124c8740796a0ae417b667e69d3cfd62f37216aeab9f7c2f5c5803683b116f8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-find-msvc-tools-devel-0.1.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-find-msvc-tools-devel;unpack=0"
SRC_URI[x86_64_v2_rust-find-msvc-tools-devel.sha256sum] = "4da7bcc1dd80727e11efca071eb3c4015a3db74470c483df8562d7dd8ce1f275"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-find-msvc-tools+default-devel-0.1.14-1.el10_2.noarch.rpm;name=aarch64_rust-find-msvc-tools+default-devel;unpack=0"
SRC_URI[aarch64_rust-find-msvc-tools+default-devel.sha256sum] = "b9bd90948640f244550062b71c146f9beafe72c326b0d0d041c44a562ffd67b1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-find-msvc-tools-devel-0.1.14-1.el10_2.noarch.rpm;name=aarch64_rust-find-msvc-tools-devel;unpack=0"
SRC_URI[aarch64_rust-find-msvc-tools-devel.sha256sum] = "38f10cfe8f2eb8785da19417bd7c9fc3d2aac543a984a0e157a599c5cf31db8b"

RDEPENDS:rust-find-msvc-tools+default-devel = " \
 cargo \
 rust-find-msvc-tools-devel \
 "
RDEPENDS:rust-find-msvc-tools-devel = " \
 cargo \
 rust \
 "
