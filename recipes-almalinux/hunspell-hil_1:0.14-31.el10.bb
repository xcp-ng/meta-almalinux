# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-hil"
PE = "1"
PV = "0.14"
PR = "31.el10"
PACKAGES = " \
 hunspell-hil \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-hil-0.14-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b84c5f7c0060a068471b5d7b6b6007786da54e3aff27ace32e7e38897adfa886"

URI_x86_64_v2_hunspell-hil = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-hil-0.14-31.el10.noarch.rpm;name=x86_64_v2_hunspell-hil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-hil}"
SRC_URI[x86_64_v2_hunspell-hil.sha256sum] = "c7367c931b2e40074788caeaea8bcc99307b537cad47ab279631b0b7ca5caa89"

URI_aarch64_hunspell-hil = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-hil-0.14-31.el10.noarch.rpm;name=aarch64_hunspell-hil;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-hil}"
SRC_URI[aarch64_hunspell-hil.sha256sum] = "c7367c931b2e40074788caeaea8bcc99307b537cad47ab279631b0b7ca5caa89"

RDEPENDS:hunspell-hil = " \
 hunspell-filesystem \
 "
