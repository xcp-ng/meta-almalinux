# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bitcoin-core-selinux"
PV = "0^20231127git4505616"
PR = "16.el10_0"
PACKAGES = " \
 bitcoin-core-selinux \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bitcoin-core-selinux-0^20231127git4505616-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "713a080a67dbdbf111b3d571b351f9a5334c0eea04490d16a679e87991f7304b"

URI_x86_64_v2_bitcoin-core-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bitcoin-core-selinux-0^20231127git4505616-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_bitcoin-core-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bitcoin-core-selinux}"
SRC_URI[x86_64_v2_bitcoin-core-selinux.sha256sum] = "ae39c13e8a0b2730687091626a4227ef3893e0d7925fe1c7fb860f5104e2330e"

URI_aarch64_bitcoin-core-selinux = "${EPEL_MIRROR}/aarch64/Packages/b/bitcoin-core-selinux-0^20231127git4505616-16.el10_0.noarch.rpm;name=aarch64_bitcoin-core-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_bitcoin-core-selinux}"
SRC_URI[aarch64_bitcoin-core-selinux.sha256sum] = "d7ce4f151a5c7269c0e982c1c155a15928dd4b84e3299d4c78d6dcfcbdb33fc2"

RDEPENDS:bitcoin-core-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
