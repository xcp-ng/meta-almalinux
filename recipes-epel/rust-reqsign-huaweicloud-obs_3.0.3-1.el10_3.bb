# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-huaweicloud-obs"
PV = "3.0.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-reqsign-huaweicloud-obs+default-devel \
 rust-reqsign-huaweicloud-obs-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-huaweicloud-obs-3.0.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "23868e95598e493f694e3908a0a6c7269becba2ef8e4072b53b7613db951e18b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-huaweicloud-obs+default-devel-3.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-huaweicloud-obs+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign-huaweicloud-obs+default-devel.sha256sum] = "7ef302306ef2091a075eb9ad3c408f1244d40810f379c6757a0071c8974d3c31"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-huaweicloud-obs-devel-3.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-huaweicloud-obs-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign-huaweicloud-obs-devel.sha256sum] = "68914421640a35f483c65d62f5a035a62b8f8c7b1bb7a4b8ead0037436026336"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-huaweicloud-obs+default-devel-3.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-huaweicloud-obs+default-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign-huaweicloud-obs+default-devel.sha256sum] = "fa20500ad0167db9d53772cfc584b8a2848dd43dcb41c5305516a60c356dc7e0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-huaweicloud-obs-devel-3.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-huaweicloud-obs-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign-huaweicloud-obs-devel.sha256sum] = "55783b9871531e87ea271f776587f7df31367dfadc9ac2c702cca238e59239df"

RDEPENDS:rust-reqsign-huaweicloud-obs+default-devel = " \
 cargo \
 rust-reqsign-huaweicloud-obs-devel \
 "
RDEPENDS:rust-reqsign-huaweicloud-obs-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-http+default-devel \
 rust-log+default-devel \
 rust-percent-encoding+default-devel \
 rust-reqsign-core+default-devel \
 "
