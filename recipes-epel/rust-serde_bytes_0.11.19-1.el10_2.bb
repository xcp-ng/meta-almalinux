# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_bytes"
PV = "0.11.19"
PR = "1.el10_2"
PACKAGES = " \
 rust-serde_bytes+alloc-devel \
 rust-serde_bytes+default-devel \
 rust-serde_bytes+std-devel \
 rust-serde_bytes-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_bytes-0.11.19-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e60bfac455c4eef3e4cba9db5b013cffeb8e26533ceada92cdd04f45e97a0a54"

URI_x86_64_v2_rust-serde_bytes+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_bytes+alloc-devel-0.11.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_bytes+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_bytes+alloc-devel}"
SRC_URI[x86_64_v2_rust-serde_bytes+alloc-devel.sha256sum] = "ed36b7a7f2b00fa41611feb98f403d2899a7bb9899f496abcfe2c157c67aed0c"

URI_x86_64_v2_rust-serde_bytes+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_bytes+default-devel-0.11.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_bytes+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_bytes+default-devel}"
SRC_URI[x86_64_v2_rust-serde_bytes+default-devel.sha256sum] = "cd969afc1bf793fccd2c15caa6b49d1f3b981d6cfaee3649063888c5ec0a9d3d"

URI_x86_64_v2_rust-serde_bytes+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_bytes+std-devel-0.11.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_bytes+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_bytes+std-devel}"
SRC_URI[x86_64_v2_rust-serde_bytes+std-devel.sha256sum] = "02f13bdd5007e103f5211a3a52027a77f6abd11fb66503eb3e7513b9937e4c13"

URI_x86_64_v2_rust-serde_bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_bytes-devel-0.11.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_bytes-devel}"
SRC_URI[x86_64_v2_rust-serde_bytes-devel.sha256sum] = "13eb89e08bdcfe8aa6a05a2471b07023062e2abc80fadd81985f90d29370e127"

URI_aarch64_rust-serde_bytes+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_bytes+alloc-devel-0.11.19-1.el10_2.noarch.rpm;name=aarch64_rust-serde_bytes+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_bytes+alloc-devel}"
SRC_URI[aarch64_rust-serde_bytes+alloc-devel.sha256sum] = "7f83173e95dc33abcecd63e563c7f8d02c9afcc917c86c34f2bf4974437c806c"

URI_aarch64_rust-serde_bytes+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_bytes+default-devel-0.11.19-1.el10_2.noarch.rpm;name=aarch64_rust-serde_bytes+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_bytes+default-devel}"
SRC_URI[aarch64_rust-serde_bytes+default-devel.sha256sum] = "86169695093f3837788959150d274fc133542d407b28af7a66822c22a0381228"

URI_aarch64_rust-serde_bytes+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_bytes+std-devel-0.11.19-1.el10_2.noarch.rpm;name=aarch64_rust-serde_bytes+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_bytes+std-devel}"
SRC_URI[aarch64_rust-serde_bytes+std-devel.sha256sum] = "5716a18353ea53597396a81298d24ca9a31cf6c9f55bbc228c20c4489772b868"

URI_aarch64_rust-serde_bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_bytes-devel-0.11.19-1.el10_2.noarch.rpm;name=aarch64_rust-serde_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_bytes-devel}"
SRC_URI[aarch64_rust-serde_bytes-devel.sha256sum] = "0c805668ee1f8651cbc73ec2a945d3a04cec45f17fa6c2c27fe8aa99011b47bf"

RDEPENDS:rust-serde_bytes+alloc-devel = " \
 cargo \
 rust-serde_bytes-devel \
 rust-serde_core+alloc-devel \
 "
RDEPENDS:rust-serde_bytes+default-devel = " \
 cargo \
 rust-serde_bytes+std-devel \
 rust-serde_bytes-devel \
 "
RDEPENDS:rust-serde_bytes+std-devel = " \
 cargo \
 rust-serde_bytes-devel \
 rust-serde_core+std-devel \
 "
RDEPENDS:rust-serde_bytes-devel = " \
 cargo \
 rust \
 rust-serde-devel \
 rust-serde_core-devel \
 "
