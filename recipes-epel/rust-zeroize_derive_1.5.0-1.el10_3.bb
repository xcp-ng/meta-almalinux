# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zeroize_derive"
PV = "1.5.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-zeroize_derive+default-devel \
 rust-zeroize_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zeroize_derive-1.5.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eff8fd87e34285b66aaafd7b9e961dd3e11e50ace27445ace6684a07c6880bfb"

URI_x86_64_v2_rust-zeroize_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize_derive+default-devel-1.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize_derive+default-devel}"
SRC_URI[x86_64_v2_rust-zeroize_derive+default-devel.sha256sum] = "52f017c4454b4023765b02dc12a9922c5802fb27dc490131d52a69f90b096123"

URI_x86_64_v2_rust-zeroize_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize_derive-devel-1.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize_derive-devel}"
SRC_URI[x86_64_v2_rust-zeroize_derive-devel.sha256sum] = "d73573a67a9a6ea0e8d6822ad7c790dce2f87545dc62ccebb40b04ac6d167f2a"

URI_aarch64_rust-zeroize_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize_derive+default-devel-1.5.0-1.el10_3.noarch.rpm;name=aarch64_rust-zeroize_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize_derive+default-devel}"
SRC_URI[aarch64_rust-zeroize_derive+default-devel.sha256sum] = "359c7cfe7b7d530d93cf31534e434e624e37d952141e7e217da0a6ca723af87a"

URI_aarch64_rust-zeroize_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize_derive-devel-1.5.0-1.el10_3.noarch.rpm;name=aarch64_rust-zeroize_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize_derive-devel}"
SRC_URI[aarch64_rust-zeroize_derive-devel.sha256sum] = "5489da2980d82cf34c69ce7fdc29d29da7b6168599fec14d605cdea2d1a893b1"

RDEPENDS:rust-zeroize_derive+default-devel = " \
 cargo \
 rust-zeroize_derive-devel \
 "
RDEPENDS:rust-zeroize_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+full-devel \
 rust-syn2+visit-devel \
 "
