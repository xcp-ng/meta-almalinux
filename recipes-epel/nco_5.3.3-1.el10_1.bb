# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nco"
PV = "5.3.3"
PR = "1.el10_1"
PACKAGES = " \
 nco \
 nco-devel \
 nco-static \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/n/nco-5.3.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6b214a57e81c8544f12a902f27fabbb2dc0fbd8e8b14ec04181f24eacff24e83"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nco-5.3.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nco;unpack=0"
SRC_URI[x86_64_v2_nco.sha256sum] = "942a42954e7dd24d3b4e3e8ffaa14a189a78390ff714e5d544ca2ff0e55690fd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nco-devel-5.3.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nco-devel;unpack=0"
SRC_URI[x86_64_v2_nco-devel.sha256sum] = "4e5ecd2563d944d33dac1917c102d81e927c68f04bd6d3bc8b35554824f15c39"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nco-static-5.3.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nco-static;unpack=0"
SRC_URI[x86_64_v2_nco-static.sha256sum] = "058191b00a15d60336cd1c45e5684f20e7b88d056cf70a1cdcf2f89b7c20fb2f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nco-5.3.3-1.el10_1.aarch64.rpm;name=aarch64_nco;unpack=0"
SRC_URI[aarch64_nco.sha256sum] = "01853a0d7306ef379dd6c58ba5a275da247af2fa005bc001662deb0314be91db"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nco-devel-5.3.3-1.el10_1.aarch64.rpm;name=aarch64_nco-devel;unpack=0"
SRC_URI[aarch64_nco-devel.sha256sum] = "15f1407128d01ed65cc32fc55caf62db1b7bb828040ae6741b8b16a7122a1035"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nco-static-5.3.3-1.el10_1.aarch64.rpm;name=aarch64_nco-static;unpack=0"
SRC_URI[aarch64_nco-static.sha256sum] = "79a502da0e7f7905d859aa2b67fa6868f3201bb48f96925ab2a74dce5094ada4"

RDEPENDS:nco = " \
 bash \
 glibc \
 gsl \
 libgcc \
 libgomp \
 libstdc++ \
 netcdf \
 udunits2 \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:nco-devel = " \
 nco \
 "
RDEPENDS:nco-static = " \
 nco-devel \
 "
