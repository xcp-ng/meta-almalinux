# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mlmmj"
PV = "1.6.0"
PR = "1.el10_1"
PACKAGES = " \
 mlmmj \
 mlmmj-selinux \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/m/mlmmj-1.6.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b3e6d1d0c20038a276bbac2d788563cbeb16673134005659fe649711e662a038"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mlmmj-1.6.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mlmmj;unpack=0"
SRC_URI[x86_64_v2_mlmmj.sha256sum] = "ae06ce88bbf31718ef1148f82ec18b616ceb70f7fc9247fc1482326fcfcbc73c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mlmmj-selinux-1.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_mlmmj-selinux;unpack=0"
SRC_URI[x86_64_v2_mlmmj-selinux.sha256sum] = "e8cbb754d263d70fa0e774951032defccdce9e19b13536aa536f3e8bf0c4669f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/mlmmj-1.6.0-1.el10_1.aarch64.rpm;name=aarch64_mlmmj;unpack=0"
SRC_URI[aarch64_mlmmj.sha256sum] = "e929d40f4e9962a1f4d941fc1b80cabf6a4ae35fb5006d4c8073682db12c1e78"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/mlmmj-selinux-1.6.0-1.el10_1.noarch.rpm;name=aarch64_mlmmj-selinux;unpack=0"
SRC_URI[aarch64_mlmmj-selinux.sha256sum] = "a98b70e5237068a3b382857beef7966bb7ea9e81dd6d0ac42c9c90f69708b283"

RDEPENDS:mlmmj = " \
 bash \
 glibc \
 "
RDEPENDS:mlmmj-selinux = " \
 bash \
 mlmmj \
 selinux-policy-targeted \
 "
