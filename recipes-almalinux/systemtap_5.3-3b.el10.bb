# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "systemtap"
PV = "5.3"
PR = "3b.el10"
PACKAGES = " \
 systemtap \
 systemtap-client \
 systemtap-devel \
 systemtap-exporter \
 systemtap-initscript \
 systemtap-runtime \
 systemtap-runtime-java \
 systemtap-runtime-python3 \
 systemtap-runtime-virtguest \
 systemtap-runtime-virthost \
 systemtap-sdt-devel \
 systemtap-sdt-dtrace \
 systemtap-server \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/systemtap-5.3-3b.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca2c3c0ddf6777cccb3d4702bb4ca4bd7f5518e3079279efc0dad55925438ef4"

URI_x86_64_v2_systemtap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-5.3-3b.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap}"
SRC_URI[x86_64_v2_systemtap.sha256sum] = "2866cf179e9f640d9459fc59a0225b8f4feb0f01e8f46023c6d64a4be263e6d5"

URI_x86_64_v2_systemtap-client = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-client-5.3-3b.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-client}"
SRC_URI[x86_64_v2_systemtap-client.sha256sum] = "f8fd3cbc28d25cb5d8836955b255a257b4a2f623ccceef119f2f1a4845dbe63c"

URI_x86_64_v2_systemtap-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-devel-5.3-3b.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-devel}"
SRC_URI[x86_64_v2_systemtap-devel.sha256sum] = "5e44b95159050f5b7d80e8be186ee0553ffbe4420e828534bd7517ae3e812149"

URI_x86_64_v2_systemtap-exporter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-exporter-5.3-3b.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-exporter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-exporter}"
SRC_URI[x86_64_v2_systemtap-exporter.sha256sum] = "02df1206952319575a753b719e8ed45e91d548d3e6255456470164646d2633ad"

URI_x86_64_v2_systemtap-initscript = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-initscript-5.3-3b.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-initscript;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-initscript}"
SRC_URI[x86_64_v2_systemtap-initscript.sha256sum] = "999ab6d3b1057766f0fd62d0a22fb704778028cf6eb6f89f45abdb225db1a594"

URI_x86_64_v2_systemtap-runtime = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-runtime-5.3-3b.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-runtime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-runtime}"
SRC_URI[x86_64_v2_systemtap-runtime.sha256sum] = "390be0c3d3273580b0afa708596f201db4ae909d004b05392932136bbefbe00f"

URI_x86_64_v2_systemtap-runtime-java = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-runtime-java-5.3-3b.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-runtime-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-runtime-java}"
SRC_URI[x86_64_v2_systemtap-runtime-java.sha256sum] = "a0ec975fb49ce5bd1be77719bbbb6dba810eb7368a26e36d7f7f842cea68bc00"

URI_x86_64_v2_systemtap-runtime-python3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-runtime-python3-5.3-3b.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-runtime-python3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-runtime-python3}"
SRC_URI[x86_64_v2_systemtap-runtime-python3.sha256sum] = "73ae4a1e6e417a5f9a02d90a92c6b1aef14ceaeceed28144e576880c7638556c"

URI_x86_64_v2_systemtap-runtime-virtguest = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-runtime-virtguest-5.3-3b.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-runtime-virtguest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-runtime-virtguest}"
SRC_URI[x86_64_v2_systemtap-runtime-virtguest.sha256sum] = "98f0cf07233bf39a9f64dd74a77c9cfc189f74e1a370204be8b01fa4b39238d0"

URI_x86_64_v2_systemtap-runtime-virthost = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-runtime-virthost-5.3-3b.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-runtime-virthost;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-runtime-virthost}"
SRC_URI[x86_64_v2_systemtap-runtime-virthost.sha256sum] = "6d897ca47c75a59491d783004f5409bedc05025b336fa4f0bfbfe4573ae9a897"

URI_x86_64_v2_systemtap-sdt-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-sdt-devel-5.3-3b.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-sdt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-sdt-devel}"
SRC_URI[x86_64_v2_systemtap-sdt-devel.sha256sum] = "3b3df540e8537ad0c447dc9a2b402dd4255a225dbdc39800c7f96f05c0b9aca5"

URI_x86_64_v2_systemtap-sdt-dtrace = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-sdt-dtrace-5.3-3b.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-sdt-dtrace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-sdt-dtrace}"
SRC_URI[x86_64_v2_systemtap-sdt-dtrace.sha256sum] = "eb08c2897d2d8e3c69b54d8f6839b36094bade3fd6ef2b0c2338c1547e6906a6"

URI_x86_64_v2_systemtap-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-server-5.3-3b.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-server}"
SRC_URI[x86_64_v2_systemtap-server.sha256sum] = "93d334180a8aac292d4f08dbd26a5e32a66c1e77e1ed4dd5856201aa67412c72"

URI_aarch64_systemtap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-5.3-3b.el10.aarch64.rpm;name=aarch64_systemtap;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap}"
SRC_URI[aarch64_systemtap.sha256sum] = "2784b8a58e89e963554d46b2706835d61263cccae7ca9303a7b8da6d60a81b44"

URI_aarch64_systemtap-client = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-client-5.3-3b.el10.aarch64.rpm;name=aarch64_systemtap-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-client}"
SRC_URI[aarch64_systemtap-client.sha256sum] = "717b8f1a07d760b1a806ade821c4309b8dd8f6ae1829cb2d94468140c073f5aa"

URI_aarch64_systemtap-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-devel-5.3-3b.el10.aarch64.rpm;name=aarch64_systemtap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-devel}"
SRC_URI[aarch64_systemtap-devel.sha256sum] = "56d77c34fa6faa32857bf882e6e292a7e4e0eea36fe848e5d3cfa3c4949b48a5"

URI_aarch64_systemtap-exporter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-exporter-5.3-3b.el10.aarch64.rpm;name=aarch64_systemtap-exporter;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-exporter}"
SRC_URI[aarch64_systemtap-exporter.sha256sum] = "82c69aa05009ef0035a4649fe78727eabe131072b3b001fe8dd17866412f7d3e"

URI_aarch64_systemtap-initscript = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-initscript-5.3-3b.el10.aarch64.rpm;name=aarch64_systemtap-initscript;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-initscript}"
SRC_URI[aarch64_systemtap-initscript.sha256sum] = "00cd24fa96056667ce674c9f13defd69b1d2602681e4eef437058bc471223edd"

URI_aarch64_systemtap-runtime = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-runtime-5.3-3b.el10.aarch64.rpm;name=aarch64_systemtap-runtime;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-runtime}"
SRC_URI[aarch64_systemtap-runtime.sha256sum] = "9a27c016b9ab494072c5bc897fbf6d24d0c38db0f06070edcf1b6d2967fa549f"

URI_aarch64_systemtap-runtime-java = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-runtime-java-5.3-3b.el10.aarch64.rpm;name=aarch64_systemtap-runtime-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-runtime-java}"
SRC_URI[aarch64_systemtap-runtime-java.sha256sum] = "d2de76d16f7f3381654028581e371d2eca7c7ec9d6689be40adf6b55f4e68a1a"

URI_aarch64_systemtap-runtime-python3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-runtime-python3-5.3-3b.el10.aarch64.rpm;name=aarch64_systemtap-runtime-python3;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-runtime-python3}"
SRC_URI[aarch64_systemtap-runtime-python3.sha256sum] = "1f6e45c749dfda55559337ac454ea9d0f515046d39f4e711c728b9e44cd8e10b"

URI_aarch64_systemtap-runtime-virtguest = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-runtime-virtguest-5.3-3b.el10.aarch64.rpm;name=aarch64_systemtap-runtime-virtguest;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-runtime-virtguest}"
SRC_URI[aarch64_systemtap-runtime-virtguest.sha256sum] = "3786a530f2f77e4a11561c5434e52a1dd695bd5e0f50e9d26276911d80e22c19"

URI_aarch64_systemtap-runtime-virthost = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-runtime-virthost-5.3-3b.el10.aarch64.rpm;name=aarch64_systemtap-runtime-virthost;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-runtime-virthost}"
SRC_URI[aarch64_systemtap-runtime-virthost.sha256sum] = "c13a7933149653bb16a48ec4108698c91427ca5454333b3ceca6b7175e553cad"

URI_aarch64_systemtap-sdt-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-sdt-devel-5.3-3b.el10.aarch64.rpm;name=aarch64_systemtap-sdt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-sdt-devel}"
SRC_URI[aarch64_systemtap-sdt-devel.sha256sum] = "981405954baa52888bcb19b98ca84859ad5dfe34c5a7a06bb920b19885b934d1"

URI_aarch64_systemtap-sdt-dtrace = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-sdt-dtrace-5.3-3b.el10.aarch64.rpm;name=aarch64_systemtap-sdt-dtrace;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-sdt-dtrace}"
SRC_URI[aarch64_systemtap-sdt-dtrace.sha256sum] = "b1e2a43be390f3327c643d863a8f349127b29730053757a93c17274112749fae"

URI_aarch64_systemtap-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-server-5.3-3b.el10.aarch64.rpm;name=aarch64_systemtap-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-server}"
SRC_URI[aarch64_systemtap-server.sha256sum] = "fe8165758c03fe5b252bf06bba4eebfe783ae1a607b01c5350bfd90a40a09b0d"

RDEPENDS:systemtap = " \
 bash \
 systemtap-client \
 systemtap-devel \
 "
RDEPENDS:systemtap-client:x86_64_v2 = " \
 avahi-libs \
 bash \
 boost-system \
 dyninst \
 elfutils-debuginfod-client \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 grep \
 json-c \
 libgcc \
 libstdc++ \
 mokutil \
 nspr \
 nss \
 openssh-clients \
 perl-interpreter \
 readline \
 rpm-libs \
 sed \
 sqlite-libs \
 systemtap-runtime \
 unzip \
 virtual/coreutils \
 zip \
"
RDEPENDS:systemtap-client:aarch64 = " \
 avahi-libs \
 bash \
 boost-system \
 dyninst \
 elfutils-debuginfod-client \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 grep \
 json-c \
 libgcc \
 libstdc++ \
 nspr \
 nss \
 openssh-clients \
 perl-interpreter \
 readline \
 rpm-libs \
 sed \
 sqlite-libs \
 systemtap-runtime \
 unzip \
 virtual/coreutils \
 zip \
"
RDEPENDS:systemtap-devel = " \
 avahi-libs \
 bash \
 boost-system \
 dyninst \
 elfutils-debuginfod-client \
 elfutils-devel \
 elfutils-libelf \
 elfutils-libs \
 gcc \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 make \
 nspr \
 nss \
 python3 \
 readline \
 rpm-libs \
 sqlite-libs \
 "
RDEPENDS:systemtap-exporter = " \
 bash \
 python3 \
 systemtap-runtime \
 "
RDEPENDS:systemtap-initscript = " \
 bash \
 systemd \
 systemtap \
 "
RDEPENDS:systemtap-runtime = " \
 bash \
 boost-system \
 dyninst \
 elfutils-debuginfod-client \
 elfutils-libelf \
 glibc \
 json-c \
 libgcc \
 libselinux \
 libstdc++ \
 ncurses-libs \
 nspr \
 nss \
 shadow-utils \
 "
RDEPENDS:systemtap-runtime-java = " \
 bash \
 byteman \
 glibc \
 iproute \
 java-21-openjdk-devel \
 systemtap-runtime \
 "
RDEPENDS:systemtap-runtime-python3 = " \
 glibc \
 python3 \
 systemtap-runtime \
 "
RDEPENDS:systemtap-runtime-virtguest = " \
 bash \
 findutils \
 grep \
 systemtap-runtime \
 virtual/coreutils \
 "
RDEPENDS:systemtap-runtime-virthost = " \
 glibc \
 libvirt-libs \
 libxml2 \
 "
RDEPENDS:systemtap-sdt-devel = " \
 systemtap-sdt-dtrace \
 "
RDEPENDS:systemtap-sdt-dtrace = " \
 python3 \
 python3-pyparsing \
 "
RDEPENDS:systemtap-server:x86_64_v2 = " \
 avahi-libs \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 nspr \
 nss \
 openssl \
 shadow-utils \
 systemd \
 systemtap-devel \
 unzip \
 virtual/coreutils \
 zip \
"
RDEPENDS:systemtap-server:aarch64 = " \
 avahi-libs \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 nspr \
 nss \
 shadow-utils \
 systemd \
 systemtap-devel \
 unzip \
 virtual/coreutils \
 zip \
"
