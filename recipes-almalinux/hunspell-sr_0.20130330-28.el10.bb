# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-sr"
PV = "0.20130330"
PR = "28.el10"
PACKAGES = " \
 hunspell-sr \
 hyphen-sr \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-sr-0.20130330-28.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d015bef264d77be5239eb4836ff24a7c3281d99c106349c18571f8eb737038e"

URI_x86_64_v2_hunspell-sr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-sr-0.20130330-28.el10.noarch.rpm;name=x86_64_v2_hunspell-sr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-sr}"
SRC_URI[x86_64_v2_hunspell-sr.sha256sum] = "0148b1d098e823c25fbc5b4fa24951ada430f24349d0f8aa8222043fd49a2405"

URI_x86_64_v2_hyphen-sr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-sr-0.20130330-28.el10.noarch.rpm;name=x86_64_v2_hyphen-sr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyphen-sr}"
SRC_URI[x86_64_v2_hyphen-sr.sha256sum] = "f6af88d50819b92d3836dac9a480d599ff4d82c61a39cc20c259cebf1400942b"

URI_aarch64_hunspell-sr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-sr-0.20130330-28.el10.noarch.rpm;name=aarch64_hunspell-sr;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-sr}"
SRC_URI[aarch64_hunspell-sr.sha256sum] = "0148b1d098e823c25fbc5b4fa24951ada430f24349d0f8aa8222043fd49a2405"

URI_aarch64_hyphen-sr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-sr-0.20130330-28.el10.noarch.rpm;name=aarch64_hyphen-sr;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyphen-sr}"
SRC_URI[aarch64_hyphen-sr.sha256sum] = "f6af88d50819b92d3836dac9a480d599ff4d82c61a39cc20c259cebf1400942b"

RDEPENDS:hunspell-sr = " \
 hunspell \
 "
RDEPENDS:hyphen-sr = " \
 hyphen \
 "
