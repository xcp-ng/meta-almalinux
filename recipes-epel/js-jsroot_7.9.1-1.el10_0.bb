# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "js-jsroot"
PV = "7.9.1"
PR = "1.el10_0"
PACKAGES = " \
 js-jsroot \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/js-jsroot-7.9.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f4ba526018bb66dea434a03805265eeb3733453080b7749c0bcfb3917c90022a"

URI_x86_64_v2_js-jsroot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/js-jsroot-7.9.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_js-jsroot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_js-jsroot}"
SRC_URI[x86_64_v2_js-jsroot.sha256sum] = "ea089be296c86280fa0f4de319d64569672f900846b56d05f9f79817bc442f27"

URI_aarch64_js-jsroot = "${EPEL_MIRROR}/aarch64/Packages/j/js-jsroot-7.9.1-1.el10_0.noarch.rpm;name=aarch64_js-jsroot;unpack=0"
SRC_URI:append = " ${URI_aarch64_js-jsroot}"
SRC_URI[aarch64_js-jsroot.sha256sum] = "054886f272465a2e410abc9695f90408c125d9bafe30e5bccce6da40f1087f3c"

RDEPENDS:js-jsroot = " \
 mathjax3 \
 web-assets-filesystem \
 "
