# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cfb-mode"
PV = "0.8.2"
PR = "4.el10_2"
PACKAGES = " \
 rust-cfb-mode+alloc-devel \
 rust-cfb-mode+block-padding-devel \
 rust-cfb-mode+default-devel \
 rust-cfb-mode+std-devel \
 rust-cfb-mode+zeroize-devel \
 rust-cfb-mode-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cfb-mode-0.8.2-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2707edbd378c7079daca10164591b0ca0bc8966c100ccaa7c1ae2615b550c4bd"

URI_x86_64_v2_rust-cfb-mode+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfb-mode+alloc-devel-0.8.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfb-mode+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfb-mode+alloc-devel}"
SRC_URI[x86_64_v2_rust-cfb-mode+alloc-devel.sha256sum] = "7a473e09ac53f968be1fa5ca34fbf142013e0fcf515c8456f6be76ee1f3f9459"

URI_x86_64_v2_rust-cfb-mode+block-padding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfb-mode+block-padding-devel-0.8.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfb-mode+block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfb-mode+block-padding-devel}"
SRC_URI[x86_64_v2_rust-cfb-mode+block-padding-devel.sha256sum] = "ab0b0127afdca365122ede308cb550025d900f8291435cd8ef2ef0bceee28109"

URI_x86_64_v2_rust-cfb-mode+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfb-mode+default-devel-0.8.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfb-mode+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfb-mode+default-devel}"
SRC_URI[x86_64_v2_rust-cfb-mode+default-devel.sha256sum] = "dfae2d0e7e0c61e3a54235da2eb3f0254886b4157f0f6f8c339c015b3811ad7e"

URI_x86_64_v2_rust-cfb-mode+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfb-mode+std-devel-0.8.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfb-mode+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfb-mode+std-devel}"
SRC_URI[x86_64_v2_rust-cfb-mode+std-devel.sha256sum] = "ada4e007c73876254ae16fac0c5dbf3b6e6f99d4183eed6ed2fafda94884b948"

URI_x86_64_v2_rust-cfb-mode+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfb-mode+zeroize-devel-0.8.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfb-mode+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfb-mode+zeroize-devel}"
SRC_URI[x86_64_v2_rust-cfb-mode+zeroize-devel.sha256sum] = "1dae66b3f49ec1a8b482313d86cfa087ea3917d54ae8f1ee86443dd334c5f4df"

URI_x86_64_v2_rust-cfb-mode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfb-mode-devel-0.8.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfb-mode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfb-mode-devel}"
SRC_URI[x86_64_v2_rust-cfb-mode-devel.sha256sum] = "0cd11335d0194c85580b65bade4b53c4819bd67d5ef475cf81fdd90d48081b15"

URI_aarch64_rust-cfb-mode+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfb-mode+alloc-devel-0.8.2-4.el10_2.noarch.rpm;name=aarch64_rust-cfb-mode+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfb-mode+alloc-devel}"
SRC_URI[aarch64_rust-cfb-mode+alloc-devel.sha256sum] = "f8d0c7358d09d8097743cbbbf24fdb16bab3ac225e776d71b758b6e51e1ca21f"

URI_aarch64_rust-cfb-mode+block-padding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfb-mode+block-padding-devel-0.8.2-4.el10_2.noarch.rpm;name=aarch64_rust-cfb-mode+block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfb-mode+block-padding-devel}"
SRC_URI[aarch64_rust-cfb-mode+block-padding-devel.sha256sum] = "014b41a90f52e004fce48e34efebf274f4c919a22cacc0839f465c0e07827a4b"

URI_aarch64_rust-cfb-mode+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfb-mode+default-devel-0.8.2-4.el10_2.noarch.rpm;name=aarch64_rust-cfb-mode+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfb-mode+default-devel}"
SRC_URI[aarch64_rust-cfb-mode+default-devel.sha256sum] = "1aacaf502e64925000ee77ba6ddd37c10d8d7dde12a4d843fd48e41bb881a5d7"

URI_aarch64_rust-cfb-mode+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfb-mode+std-devel-0.8.2-4.el10_2.noarch.rpm;name=aarch64_rust-cfb-mode+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfb-mode+std-devel}"
SRC_URI[aarch64_rust-cfb-mode+std-devel.sha256sum] = "eacd1e9c7be9b1cd23a8128c940a4b8b1e57553ff5785b859e8e94ee6e5eae2a"

URI_aarch64_rust-cfb-mode+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfb-mode+zeroize-devel-0.8.2-4.el10_2.noarch.rpm;name=aarch64_rust-cfb-mode+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfb-mode+zeroize-devel}"
SRC_URI[aarch64_rust-cfb-mode+zeroize-devel.sha256sum] = "21c6d7fec80608fec2a669ece7b103cbf2a9201b59761fcfe4077c80b4de9273"

URI_aarch64_rust-cfb-mode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfb-mode-devel-0.8.2-4.el10_2.noarch.rpm;name=aarch64_rust-cfb-mode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfb-mode-devel}"
SRC_URI[aarch64_rust-cfb-mode-devel.sha256sum] = "b6926f9ff81594bc10056220359ad675d1bf4a2a64d353b95104de4259c2c6dd"

RDEPENDS:rust-cfb-mode+alloc-devel = " \
 cargo \
 rust-cfb-mode-devel \
 rust-cipher0.4+alloc-devel \
 "
RDEPENDS:rust-cfb-mode+block-padding-devel = " \
 cargo \
 rust-cfb-mode-devel \
 rust-cipher0.4+block-padding-devel \
 "
RDEPENDS:rust-cfb-mode+default-devel = " \
 cargo \
 rust-cfb-mode-devel \
 "
RDEPENDS:rust-cfb-mode+std-devel = " \
 cargo \
 rust-cfb-mode+alloc-devel \
 rust-cfb-mode-devel \
 rust-cipher0.4+std-devel \
 "
RDEPENDS:rust-cfb-mode+zeroize-devel = " \
 cargo \
 rust-cfb-mode-devel \
 rust-cipher0.4+zeroize-devel \
 "
RDEPENDS:rust-cfb-mode-devel = " \
 cargo \
 rust \
 rust-cipher0.4+default-devel \
 "
