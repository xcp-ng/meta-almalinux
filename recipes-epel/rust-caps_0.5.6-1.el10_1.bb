# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-caps"
PV = "0.5.6"
PR = "1.el10_1"
PACKAGES = " \
 rust-caps+default-devel \
 rust-caps+serde-devel \
 rust-caps+serde_support-devel \
 rust-caps-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-caps-0.5.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "efe63c14628b62efbb4fd14a4a8c55507401e1e2c55a0695c68f7d433988d901"

URI_x86_64_v2_rust-caps+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-caps+default-devel-0.5.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-caps+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-caps+default-devel}"
SRC_URI[x86_64_v2_rust-caps+default-devel.sha256sum] = "83a58a3338b5f7b7c1b702aeef201fb2209daeac345f20df6f6966f58ca25fc4"

URI_x86_64_v2_rust-caps+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-caps+serde-devel-0.5.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-caps+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-caps+serde-devel}"
SRC_URI[x86_64_v2_rust-caps+serde-devel.sha256sum] = "ecb2dccb5333cf279506531d8e501268a90e8450ab3985046026a126a4e82c4b"

URI_x86_64_v2_rust-caps+serde_support-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-caps+serde_support-devel-0.5.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-caps+serde_support-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-caps+serde_support-devel}"
SRC_URI[x86_64_v2_rust-caps+serde_support-devel.sha256sum] = "2434cb6fe1ee216307e5bd5dc4931d8e1513f18378d8dfb9b0726cba99f2e4cf"

URI_x86_64_v2_rust-caps-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-caps-devel-0.5.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-caps-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-caps-devel}"
SRC_URI[x86_64_v2_rust-caps-devel.sha256sum] = "6a127ae4df85c7eaebee069fcea8685d318e1ceb50e5e417d4d909dd98d7effb"

URI_aarch64_rust-caps+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-caps+default-devel-0.5.6-1.el10_1.noarch.rpm;name=aarch64_rust-caps+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-caps+default-devel}"
SRC_URI[aarch64_rust-caps+default-devel.sha256sum] = "f27f1f2222c349dcaaca524de852d5e12c8779730485949daa96b70bcc90e6fd"

URI_aarch64_rust-caps+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-caps+serde-devel-0.5.6-1.el10_1.noarch.rpm;name=aarch64_rust-caps+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-caps+serde-devel}"
SRC_URI[aarch64_rust-caps+serde-devel.sha256sum] = "a9adead93c29592abb4d53a9d1381570472e98d1e1267c110d073637f98f2d9b"

URI_aarch64_rust-caps+serde_support-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-caps+serde_support-devel-0.5.6-1.el10_1.noarch.rpm;name=aarch64_rust-caps+serde_support-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-caps+serde_support-devel}"
SRC_URI[aarch64_rust-caps+serde_support-devel.sha256sum] = "ac55bd9e0b604c1cdea35993976d7a6a2d1f91928e78850ff976a200320c08b0"

URI_aarch64_rust-caps-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-caps-devel-0.5.6-1.el10_1.noarch.rpm;name=aarch64_rust-caps-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-caps-devel}"
SRC_URI[aarch64_rust-caps-devel.sha256sum] = "862fde44f1499b51691386886b587cabf608b520538c5c30470e2862707fcfd3"

RDEPENDS:rust-caps+default-devel = " \
 cargo \
 rust-caps-devel \
 "
RDEPENDS:rust-caps+serde-devel = " \
 cargo \
 rust-caps-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-caps+serde_support-devel = " \
 cargo \
 rust-caps+serde-devel \
 rust-caps-devel \
 "
RDEPENDS:rust-caps-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
