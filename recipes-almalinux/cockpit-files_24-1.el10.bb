# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cockpit-files"
PV = "24"
PR = "1.el10"
PACKAGES = " \
 cockpit-files \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cockpit-files-24-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2c9ac5408e409c40b79a00057a1c09edd29d48f072f570f6131ccabb784af59c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cockpit-files-24-1.el10.noarch.rpm;name=x86_64_v2_cockpit-files;unpack=0"
SRC_URI[x86_64_v2_cockpit-files.sha256sum] = "79d68429851d1a2f97bea01c337ab447824a7ce5eb88e9ead3a0d23e38120ec3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cockpit-files-24-1.el10.noarch.rpm;name=aarch64_cockpit-files;unpack=0"
SRC_URI[aarch64_cockpit-files.sha256sum] = "79d68429851d1a2f97bea01c337ab447824a7ce5eb88e9ead3a0d23e38120ec3"

RDEPENDS:cockpit-files = " \
 cockpit-bridge \
 "
