# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-path-slash"
PV = "0.2.1"
PR = "4.el10_0"
PACKAGES = " \
 rust-path-slash+default-devel \
 rust-path-slash-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-path-slash-0.2.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "650c0aa5aeb02876ec415ad643d4e894fb7333e7365789be1b68e5468ce4e9c0"

URI_x86_64_v2_rust-path-slash+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-path-slash+default-devel-0.2.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-path-slash+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-path-slash+default-devel}"
SRC_URI[x86_64_v2_rust-path-slash+default-devel.sha256sum] = "a888c310370bff65d2eaf05120343bd8a1743be944d7b8d98cdf048c274592b6"

URI_x86_64_v2_rust-path-slash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-path-slash-devel-0.2.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-path-slash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-path-slash-devel}"
SRC_URI[x86_64_v2_rust-path-slash-devel.sha256sum] = "fceebf4029f0ffadab1b21565d412b3ebef904dfc8a0622edb962b5022ef4abb"

URI_aarch64_rust-path-slash+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-path-slash+default-devel-0.2.1-4.el10_0.noarch.rpm;name=aarch64_rust-path-slash+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-path-slash+default-devel}"
SRC_URI[aarch64_rust-path-slash+default-devel.sha256sum] = "8728a6de91fbc284e037efdb588f5422fbaadaeffef96e8bed519297bb601ab3"

URI_aarch64_rust-path-slash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-path-slash-devel-0.2.1-4.el10_0.noarch.rpm;name=aarch64_rust-path-slash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-path-slash-devel}"
SRC_URI[aarch64_rust-path-slash-devel.sha256sum] = "b47a236a3f63208f7c01c0018d0ee4d3920609753233bc1cb6fa68f3453aa830"

RDEPENDS:rust-path-slash+default-devel = " \
 cargo \
 rust-path-slash-devel \
 "
RDEPENDS:rust-path-slash-devel = " \
 cargo \
 rust \
 "
