# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rancor"
PV = "0.1.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-rancor+alloc-devel \
 rust-rancor+default-devel \
 rust-rancor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rancor-0.1.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fbfe8ae87712aa0099139660e482d199d1df39c29d8e4aca0d456075c92e92e6"

URI_x86_64_v2_rust-rancor+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rancor+alloc-devel-0.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rancor+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rancor+alloc-devel}"
SRC_URI[x86_64_v2_rust-rancor+alloc-devel.sha256sum] = "888e8fc19a8384a6f62688f991be05a9b53f93f91ad6cb0d1d27a606547b6563"

URI_x86_64_v2_rust-rancor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rancor+default-devel-0.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rancor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rancor+default-devel}"
SRC_URI[x86_64_v2_rust-rancor+default-devel.sha256sum] = "07ab43b782413e51cb4beef4af156e1e25c0275c520bb1405bcef4fcd2d9c995"

URI_x86_64_v2_rust-rancor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rancor-devel-0.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rancor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rancor-devel}"
SRC_URI[x86_64_v2_rust-rancor-devel.sha256sum] = "1fefc22ab95530ab8eb55ceeab7d268c132c7ab7a2ad5b76e040f6b749e75345"

URI_aarch64_rust-rancor+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rancor+alloc-devel-0.1.1-1.el10_0.noarch.rpm;name=aarch64_rust-rancor+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rancor+alloc-devel}"
SRC_URI[aarch64_rust-rancor+alloc-devel.sha256sum] = "00ac4198de562d6d20bc69474d8c371cd14bbe432d29490a736876f392710586"

URI_aarch64_rust-rancor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rancor+default-devel-0.1.1-1.el10_0.noarch.rpm;name=aarch64_rust-rancor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rancor+default-devel}"
SRC_URI[aarch64_rust-rancor+default-devel.sha256sum] = "a129a5c7f30fe96877f83862d998f44f5b3fe26b2eb8bdf9b19202371da12f95"

URI_aarch64_rust-rancor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rancor-devel-0.1.1-1.el10_0.noarch.rpm;name=aarch64_rust-rancor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rancor-devel}"
SRC_URI[aarch64_rust-rancor-devel.sha256sum] = "ea0143c93a949943ff1417b4f532321d1c0198a77dbe451f72688e41e5ed9b42"

RDEPENDS:rust-rancor+alloc-devel = " \
 cargo \
 rust-rancor-devel \
 "
RDEPENDS:rust-rancor+default-devel = " \
 cargo \
 rust-rancor+alloc-devel \
 rust-rancor-devel \
 "
RDEPENDS:rust-rancor-devel = " \
 cargo \
 rust \
 rust-ptr_meta+derive-devel \
 rust-ptr_meta-devel \
 "
