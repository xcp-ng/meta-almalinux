# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "step"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 step \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/step-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe3f58f86dcee33a9128ac06f3f47e23b01ac9d2cc73286a7c080980a9a54391"

URI_x86_64_v2_step = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/step-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_step;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_step}"
SRC_URI[x86_64_v2_step.sha256sum] = "21783c678ca2e6798df398c92931345a8e573243d8b6149fe52417c7c3814783"

URI_aarch64_step = "${EPEL_MIRROR}/aarch64/Packages/s/step-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_step;unpack=0"
SRC_URI:append = " ${URI_aarch64_step}"
SRC_URI[aarch64_step.sha256sum] = "1802eb58b868f7a937ec1736ea7627f83ac8cec2d016ecb1a616871b4ac99ca4"

RDEPENDS:step = " \
 glibc \
 gsl \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-knewstuff \
 kf6-kplotting \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libqalculate \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
