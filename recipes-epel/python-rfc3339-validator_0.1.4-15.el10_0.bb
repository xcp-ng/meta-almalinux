# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rfc3339-validator"
PV = "0.1.4"
PR = "15.el10_0"
PACKAGES = " \
 python3-rfc3339-validator \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-rfc3339-validator-0.1.4-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b5db86bb949530c8ba702a96c4579dd942ca4ace6fba0c527b7c1290e1452514"

URI_x86_64_v2_python3-rfc3339-validator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rfc3339-validator-0.1.4-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rfc3339-validator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rfc3339-validator}"
SRC_URI[x86_64_v2_python3-rfc3339-validator.sha256sum] = "d531500a5065b57c31ad60d3dd32248358270557d0beb44ee2cd2ada78a173e4"

URI_aarch64_python3-rfc3339-validator = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rfc3339-validator-0.1.4-15.el10_0.noarch.rpm;name=aarch64_python3-rfc3339-validator;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rfc3339-validator}"
SRC_URI[aarch64_python3-rfc3339-validator.sha256sum] = "e571a69f807a97ec26d9696424972d2de3237804ca2b1efd91603e82909be86f"

RDEPENDS:python3-rfc3339-validator = " \
 python3 \
 python3-six \
 "
