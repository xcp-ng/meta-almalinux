# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bullet"
PV = "3.08"
PR = "16.el10_2"
PACKAGES = " \
 bullet \
 bullet-devel \
 bullet-devel-doc \
 bullet-extras \
 bullet-extras-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bullet-3.08-16.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86ac5de7a088d47ebfe2e5a7548d442c38c0709044dfe93b330939fc7387a064"

URI_x86_64_v2_bullet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bullet-3.08-16.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bullet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bullet}"
SRC_URI[x86_64_v2_bullet.sha256sum] = "ad569af0037840cea89eb82443fc51acc3ac59d7c4364d56944a4fcb20597516"

URI_x86_64_v2_bullet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bullet-devel-3.08-16.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bullet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bullet-devel}"
SRC_URI[x86_64_v2_bullet-devel.sha256sum] = "b0627e9ffd34a7be29a481e83735eb73aaeed591ace7dae149369e5d7557a3f6"

URI_x86_64_v2_bullet-devel-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bullet-devel-doc-3.08-16.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bullet-devel-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bullet-devel-doc}"
SRC_URI[x86_64_v2_bullet-devel-doc.sha256sum] = "a3f79f6e436810433c3a7af5c95e7f8e6877113b290610701fd6082d0f2f7c0e"

URI_x86_64_v2_bullet-extras = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bullet-extras-3.08-16.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bullet-extras;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bullet-extras}"
SRC_URI[x86_64_v2_bullet-extras.sha256sum] = "93d2ed7e9ab068a217b708b962e17f19daef6963521b9140ccf0692dbf0a6ad3"

URI_x86_64_v2_bullet-extras-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bullet-extras-devel-3.08-16.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bullet-extras-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bullet-extras-devel}"
SRC_URI[x86_64_v2_bullet-extras-devel.sha256sum] = "6891553c2f370305fda8ee76cb1e2a65e42ec5b41e5be6f1e79f13c7c209e275"

URI_aarch64_bullet = "${EPEL_MIRROR}/aarch64/Packages/b/bullet-3.08-16.el10_2.aarch64.rpm;name=aarch64_bullet;unpack=0"
SRC_URI:append = " ${URI_aarch64_bullet}"
SRC_URI[aarch64_bullet.sha256sum] = "b59e4f8c823c61d45b22a5455bce569034df92aa8d8c5bc0bce1d5a6f5407ae9"

URI_aarch64_bullet-devel = "${EPEL_MIRROR}/aarch64/Packages/b/bullet-devel-3.08-16.el10_2.aarch64.rpm;name=aarch64_bullet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_bullet-devel}"
SRC_URI[aarch64_bullet-devel.sha256sum] = "e8eda60228f33cf08f77984965bc07cfd3720e37f8de1d2b0c119ae3ff763cb9"

URI_aarch64_bullet-devel-doc = "${EPEL_MIRROR}/aarch64/Packages/b/bullet-devel-doc-3.08-16.el10_2.aarch64.rpm;name=aarch64_bullet-devel-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_bullet-devel-doc}"
SRC_URI[aarch64_bullet-devel-doc.sha256sum] = "eff10dd90d86fc8982b2a212eb615a6cc2ebc7632737270c72423d8e3bba6131"

URI_aarch64_bullet-extras = "${EPEL_MIRROR}/aarch64/Packages/b/bullet-extras-3.08-16.el10_2.aarch64.rpm;name=aarch64_bullet-extras;unpack=0"
SRC_URI:append = " ${URI_aarch64_bullet-extras}"
SRC_URI[aarch64_bullet-extras.sha256sum] = "840461d00eb80711c339bbb12416552e4fd3335225f076ddb113ba1a1968d8ad"

URI_aarch64_bullet-extras-devel = "${EPEL_MIRROR}/aarch64/Packages/b/bullet-extras-devel-3.08-16.el10_2.aarch64.rpm;name=aarch64_bullet-extras-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_bullet-extras-devel}"
SRC_URI[aarch64_bullet-extras-devel.sha256sum] = "e76d3cad5684bd6f6c5489df2749f99b1487683bd3ac4e75980df46e1055f406"

RDEPENDS:bullet = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:bullet-devel = " \
 bullet \
 cmake \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
RDEPENDS:bullet-devel-doc = " \
 bullet-extras \
 "
RDEPENDS:bullet-extras = " \
 bullet \
 glibc \
 libgcc \
 libstdc++ \
 tinyxml2 \
 "
RDEPENDS:bullet-extras-devel = " \
 bullet-devel \
 bullet-extras \
 "
