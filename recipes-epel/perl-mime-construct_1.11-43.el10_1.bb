# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-mime-construct"
PV = "1.11"
PR = "43.el10_1"
PACKAGES = " \
 perl-mime-construct \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-mime-construct-1.11-43.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e106604f3699e781a24bce76d717fb5ec25b3a30cc5985340d55ab5ba46bd78"

URI_x86_64_v2_perl-mime-construct = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-mime-construct-1.11-43.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-mime-construct;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-mime-construct}"
SRC_URI[x86_64_v2_perl-mime-construct.sha256sum] = "c2cfd687a2860e3d8c5841182b9b0a399f42bcd34a0ec878615a4a095e9b720e"

URI_aarch64_perl-mime-construct = "${EPEL_MIRROR}/aarch64/Packages/p/perl-mime-construct-1.11-43.el10_1.noarch.rpm;name=aarch64_perl-mime-construct;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-mime-construct}"
SRC_URI[aarch64_perl-mime-construct.sha256sum] = "9df9d0d8a61f44a1f91116389ade74f3442bad96a031c1b6207d09ca5b141ddc"

RDEPENDS:perl-mime-construct = " \
 perl-Proc-WaitStat \
 perl-interpreter \
 perl-libs \
 "
