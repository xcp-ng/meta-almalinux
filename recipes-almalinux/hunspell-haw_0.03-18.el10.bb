# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-haw"
PV = "0.03"
PR = "18.el10"
PACKAGES = " \
 hunspell-haw \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-haw-0.03-18.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd65f43226356e4c749cc71fe47f523438a9213e30dc78324db6a40c332a31b7"

URI_x86_64_v2_hunspell-haw = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-haw-0.03-18.el10.noarch.rpm;name=x86_64_v2_hunspell-haw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-haw}"
SRC_URI[x86_64_v2_hunspell-haw.sha256sum] = "285b14eea852c9cc186eef3fb757292deb56e0b7d9de1a20d202b9e9b9e7c819"

URI_aarch64_hunspell-haw = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-haw-0.03-18.el10.noarch.rpm;name=aarch64_hunspell-haw;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-haw}"
SRC_URI[aarch64_hunspell-haw.sha256sum] = "285b14eea852c9cc186eef3fb757292deb56e0b7d9de1a20d202b9e9b9e7c819"

RDEPENDS:hunspell-haw = " \
 hunspell-filesystem \
 "
