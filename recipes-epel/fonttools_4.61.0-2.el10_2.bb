# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fonttools"
PV = "4.61.0"
PR = "2.el10_2"
PACKAGES = " \
 fonttools \
 python3-fonttools \
 python3-fonttools+graphite \
 python3-fonttools+interpolatable \
 python3-fonttools+lxml \
 python3-fonttools+plot \
 python3-fonttools+type1 \
 python3-fonttools+ufo \
 python3-fonttools+unicode \
 python3-fonttools+woff \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fonttools-4.61.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a4d274211ac9804e6b6eb299facccec5fa697c029d5a67bde913d97ccba8e90"

URI_x86_64_v2_fonttools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fonttools-4.61.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fonttools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fonttools}"
SRC_URI[x86_64_v2_fonttools.sha256sum] = "a37e78f73d5b4193e7aeaef9426682ad06656b074d9112d8591bbdcd65476d7c"

URI_x86_64_v2_python3-fonttools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fonttools-4.61.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-fonttools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fonttools}"
SRC_URI[x86_64_v2_python3-fonttools.sha256sum] = "b6fdf093b77ed7662196090a2dc851085ec10f04ac8529774ce0ad1abbfc37b7"

URI_x86_64_v2_python3-fonttools+graphite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fonttools+graphite-4.61.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-fonttools+graphite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fonttools+graphite}"
SRC_URI[x86_64_v2_python3-fonttools+graphite.sha256sum] = "e1c04665edb6ba50cac4b3a9803e9598cbf71fe69760a2ab7d9f2aa64b79b183"

URI_x86_64_v2_python3-fonttools+interpolatable = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fonttools+interpolatable-4.61.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-fonttools+interpolatable;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fonttools+interpolatable}"
SRC_URI[x86_64_v2_python3-fonttools+interpolatable.sha256sum] = "279783b5c838d5993fe016f3654d7a28cf872f015937ed1efa499736b18678a6"

URI_x86_64_v2_python3-fonttools+lxml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fonttools+lxml-4.61.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-fonttools+lxml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fonttools+lxml}"
SRC_URI[x86_64_v2_python3-fonttools+lxml.sha256sum] = "378030e3549c1be858282c1eec434b7a5c3c116fb8ee72e5cad468d0509eb15d"

URI_x86_64_v2_python3-fonttools+plot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fonttools+plot-4.61.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-fonttools+plot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fonttools+plot}"
SRC_URI[x86_64_v2_python3-fonttools+plot.sha256sum] = "ee6170b06105658a7f4293fcdc589df1582c755d8ae77d7920fdebe8ce30cdb0"

URI_x86_64_v2_python3-fonttools+type1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fonttools+type1-4.61.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-fonttools+type1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fonttools+type1}"
SRC_URI[x86_64_v2_python3-fonttools+type1.sha256sum] = "ead574b41b7e5e42a212089363fab61f3ccffb6cf017261fdc5d46791b7c9532"

URI_x86_64_v2_python3-fonttools+ufo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fonttools+ufo-4.61.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-fonttools+ufo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fonttools+ufo}"
SRC_URI[x86_64_v2_python3-fonttools+ufo.sha256sum] = "175ec50caa1f6932bc013a1ac30ad02f70e0ac636cc77c4cba66a3c15b0d4f64"

URI_x86_64_v2_python3-fonttools+unicode = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fonttools+unicode-4.61.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-fonttools+unicode;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fonttools+unicode}"
SRC_URI[x86_64_v2_python3-fonttools+unicode.sha256sum] = "8fa3419a13b8bb3b9865972e0213d9bff56cdb379d19d6e4a871ac0f955b68fb"

URI_x86_64_v2_python3-fonttools+woff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fonttools+woff-4.61.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-fonttools+woff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fonttools+woff}"
SRC_URI[x86_64_v2_python3-fonttools+woff.sha256sum] = "09d3daac822cb7054c2799ee2318432b54aa0ca9ff3cebf7b194f4f105cfb473"

URI_aarch64_fonttools = "${EPEL_MIRROR}/aarch64/Packages/f/fonttools-4.61.0-2.el10_2.aarch64.rpm;name=aarch64_fonttools;unpack=0"
SRC_URI:append = " ${URI_aarch64_fonttools}"
SRC_URI[aarch64_fonttools.sha256sum] = "5f0e8415adf6d9af5eeefe461fe7e078a0ab0d06b518d1a8a7cf5b9c0dd40286"

URI_aarch64_python3-fonttools = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fonttools-4.61.0-2.el10_2.aarch64.rpm;name=aarch64_python3-fonttools;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fonttools}"
SRC_URI[aarch64_python3-fonttools.sha256sum] = "6c8b5ef98d415c7e1e95d0050a64876fe01ca0624cb65c14e472bf658ce7a7bd"

URI_aarch64_python3-fonttools+graphite = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fonttools+graphite-4.61.0-2.el10_2.aarch64.rpm;name=aarch64_python3-fonttools+graphite;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fonttools+graphite}"
SRC_URI[aarch64_python3-fonttools+graphite.sha256sum] = "89142245ae054b9b01786232179a5e3a1638fa3193b3ac436c4d7b1da59b9388"

URI_aarch64_python3-fonttools+interpolatable = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fonttools+interpolatable-4.61.0-2.el10_2.aarch64.rpm;name=aarch64_python3-fonttools+interpolatable;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fonttools+interpolatable}"
SRC_URI[aarch64_python3-fonttools+interpolatable.sha256sum] = "cf06a8b219e0d7250333878b096408fc8da57759f20ce1b16e3a236904f88686"

URI_aarch64_python3-fonttools+lxml = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fonttools+lxml-4.61.0-2.el10_2.aarch64.rpm;name=aarch64_python3-fonttools+lxml;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fonttools+lxml}"
SRC_URI[aarch64_python3-fonttools+lxml.sha256sum] = "41354efadd32cc90c1c1dfda9306c1631383c2951b7cc5ddd627aad206a9907c"

URI_aarch64_python3-fonttools+plot = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fonttools+plot-4.61.0-2.el10_2.aarch64.rpm;name=aarch64_python3-fonttools+plot;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fonttools+plot}"
SRC_URI[aarch64_python3-fonttools+plot.sha256sum] = "ff71ac34db7782c55d190381d50cacc79a9c9a7fa7f9ec80c82de1bf5308a77c"

URI_aarch64_python3-fonttools+type1 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fonttools+type1-4.61.0-2.el10_2.aarch64.rpm;name=aarch64_python3-fonttools+type1;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fonttools+type1}"
SRC_URI[aarch64_python3-fonttools+type1.sha256sum] = "38e3985e9de61b8d5fc39b3a3f12f0b14940257c2f4f563565a5be8ed746ef4b"

URI_aarch64_python3-fonttools+ufo = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fonttools+ufo-4.61.0-2.el10_2.aarch64.rpm;name=aarch64_python3-fonttools+ufo;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fonttools+ufo}"
SRC_URI[aarch64_python3-fonttools+ufo.sha256sum] = "97e4d143e3f9a5a36e45b66fc126cb3795bac0a594939b0dec4dc0ed727d2e33"

URI_aarch64_python3-fonttools+unicode = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fonttools+unicode-4.61.0-2.el10_2.aarch64.rpm;name=aarch64_python3-fonttools+unicode;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fonttools+unicode}"
SRC_URI[aarch64_python3-fonttools+unicode.sha256sum] = "89d9fe28b522527c04b5ce1452a27843d326d53f0159d323a1483e8b243fccce"

URI_aarch64_python3-fonttools+woff = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fonttools+woff-4.61.0-2.el10_2.aarch64.rpm;name=aarch64_python3-fonttools+woff;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fonttools+woff}"
SRC_URI[aarch64_python3-fonttools+woff.sha256sum] = "f7e6b92ce88facee865c1f592ae80d07454ce00469001857ec10a517c1c70b2f"

RDEPENDS:fonttools = " \
 python3 \
 python3-fonttools \
 "
RDEPENDS:python3-fonttools = " \
 glibc \
 python3 \
 "
RDEPENDS:python3-fonttools+graphite = " \
 python3 \
 python3-fonttools \
 python3-lz4 \
 "
RDEPENDS:python3-fonttools+interpolatable = " \
 python3 \
 python3-cairo \
 python3-fonttools \
 python3-scipy \
 "
RDEPENDS:python3-fonttools+lxml = " \
 python3 \
 python3-fonttools \
 python3-lxml \
 "
RDEPENDS:python3-fonttools+plot = " \
 python3 \
 python3-fonttools \
 python3-matplotlib \
 "
RDEPENDS:python3-fonttools+type1 = " \
 python3 \
 python3-fonttools \
 "
RDEPENDS:python3-fonttools+ufo = " \
 python3 \
 python3-fonttools \
 "
RDEPENDS:python3-fonttools+unicode = " \
 python3 \
 python3-fonttools \
 python3-unicodedata2 \
 "
RDEPENDS:python3-fonttools+woff = " \
 python3 \
 python3-brotli \
 python3-fonttools \
 python3-zopfli \
 "
