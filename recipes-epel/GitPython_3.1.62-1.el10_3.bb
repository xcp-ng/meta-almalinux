# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "GitPython"
PV = "3.1.62"
PR = "1.el10_3"
PACKAGES = " \
 python3-GitPython \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/GitPython-3.1.62-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "882bdec28c9fa3be9c7c08c5e34687081d765196e4b3a175ea011720b03969f3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-GitPython-3.1.62-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-GitPython;unpack=0"
SRC_URI[x86_64_v2_python3-GitPython.sha256sum] = "ce6cfd22add8ad0b6a72359dcfc3b0058ad6b57789793da35bc07370a3fcdfa7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-GitPython-3.1.62-1.el10_3.noarch.rpm;name=aarch64_python3-GitPython;unpack=0"
SRC_URI[aarch64_python3-GitPython.sha256sum] = "887af63e4b1e5ebeb6cfaf2418acb34d60ea547adea0fc110219cf5fc225823c"

RDEPENDS:python3-GitPython = " \
 git-core \
 python3 \
 python3-gitdb \
 "
