# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-regex-syntax"
PV = "0.8.9"
PR = "1.el10_1"
PACKAGES = " \
 rust-regex-syntax+arbitrary-devel \
 rust-regex-syntax+default-devel \
 rust-regex-syntax+std-devel \
 rust-regex-syntax+unicode-age-devel \
 rust-regex-syntax+unicode-bool-devel \
 rust-regex-syntax+unicode-case-devel \
 rust-regex-syntax+unicode-devel \
 rust-regex-syntax+unicode-gencat-devel \
 rust-regex-syntax+unicode-perl-devel \
 rust-regex-syntax+unicode-script-devel \
 rust-regex-syntax+unicode-segment-devel \
 rust-regex-syntax-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-regex-syntax-0.8.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cd855431c6b642834f95ce6bc7db6fd63dd9626f399ce9e7609f85e7dfb26182"

URI_x86_64_v2_rust-regex-syntax+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+arbitrary-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+arbitrary-devel.sha256sum] = "e9ccf9395440f10851d182af45ea1d967f44f4fcdf9595d8141e342b1c19eff3"

URI_x86_64_v2_rust-regex-syntax+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+default-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+default-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+default-devel.sha256sum] = "e7be01f7db81170676660412b0e9298382c97d189c68922c43816cad294c89ff"

URI_x86_64_v2_rust-regex-syntax+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+std-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+std-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+std-devel.sha256sum] = "a9be65d9913c2f1622a61831bff2237d7222474650103d314d7228ed2956eee0"

URI_x86_64_v2_rust-regex-syntax+unicode-age-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+unicode-age-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+unicode-age-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+unicode-age-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+unicode-age-devel.sha256sum] = "63d08efa365bf9f7b4285a8272779ed74343ed67f08c1e1532811b988647ea60"

URI_x86_64_v2_rust-regex-syntax+unicode-bool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+unicode-bool-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+unicode-bool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+unicode-bool-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+unicode-bool-devel.sha256sum] = "54a3cb9448b4615858c3ae8527dd2bdb8ca330a472e7f1e5769c6f9861661553"

URI_x86_64_v2_rust-regex-syntax+unicode-case-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+unicode-case-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+unicode-case-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+unicode-case-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+unicode-case-devel.sha256sum] = "58330cad5823e528eeb3b61688097eb9cd4743ca62204bfa424c5c61fcc4b929"

URI_x86_64_v2_rust-regex-syntax+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+unicode-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+unicode-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+unicode-devel.sha256sum] = "7f8f806d296d748e48e37aba3a78810785f4fcbe4d0df64ee5545059e6ee502c"

URI_x86_64_v2_rust-regex-syntax+unicode-gencat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+unicode-gencat-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+unicode-gencat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+unicode-gencat-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+unicode-gencat-devel.sha256sum] = "e875d5a1439f319ad9598df701f6ba623ba4a4a5bd5a714d96876c5d10912e05"

URI_x86_64_v2_rust-regex-syntax+unicode-perl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+unicode-perl-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+unicode-perl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+unicode-perl-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+unicode-perl-devel.sha256sum] = "40cd76af78660306b1dc36e3694919f377fdeea2acd75ba6aa90ee591bd4359a"

URI_x86_64_v2_rust-regex-syntax+unicode-script-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+unicode-script-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+unicode-script-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+unicode-script-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+unicode-script-devel.sha256sum] = "bffcd6ae0ec23e7c7ff348b8e58686f3216fb43d2d65ad74b6634806b309dde4"

URI_x86_64_v2_rust-regex-syntax+unicode-segment-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+unicode-segment-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+unicode-segment-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+unicode-segment-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+unicode-segment-devel.sha256sum] = "525434235b968c38fae13503a7576f3cba71e6103d9440c800311ce1c1d3bcbb"

URI_x86_64_v2_rust-regex-syntax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax-devel.sha256sum] = "d0da4cc244016aa3dd9748e12fabe8299ab62ff267d905a86a20f07dbb28a702"

URI_aarch64_rust-regex-syntax+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+arbitrary-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-regex-syntax+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+arbitrary-devel}"
SRC_URI[aarch64_rust-regex-syntax+arbitrary-devel.sha256sum] = "99838a6c24c96f9758b2e6d58c79f05861744bf889eb7398f706a0e6d429a1f4"

URI_aarch64_rust-regex-syntax+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+default-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-regex-syntax+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+default-devel}"
SRC_URI[aarch64_rust-regex-syntax+default-devel.sha256sum] = "0202cde3eebce89dc659cff6f8aed688411fac105e13e1ed4cf5d4388ffee2f3"

URI_aarch64_rust-regex-syntax+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+std-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-regex-syntax+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+std-devel}"
SRC_URI[aarch64_rust-regex-syntax+std-devel.sha256sum] = "6acaefc0d661b7c339796f389539f6a32652802107fd2797d4997bbb56725b31"

URI_aarch64_rust-regex-syntax+unicode-age-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+unicode-age-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-regex-syntax+unicode-age-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+unicode-age-devel}"
SRC_URI[aarch64_rust-regex-syntax+unicode-age-devel.sha256sum] = "6df92c74d6a1dad364b615f7aeea98ec566c01f1d73230ca939703c27b2fbdbf"

URI_aarch64_rust-regex-syntax+unicode-bool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+unicode-bool-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-regex-syntax+unicode-bool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+unicode-bool-devel}"
SRC_URI[aarch64_rust-regex-syntax+unicode-bool-devel.sha256sum] = "85d20295c5acd5c8d053505089840c9e5a336165b39cb3b42bfcc081fa5ec29e"

URI_aarch64_rust-regex-syntax+unicode-case-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+unicode-case-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-regex-syntax+unicode-case-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+unicode-case-devel}"
SRC_URI[aarch64_rust-regex-syntax+unicode-case-devel.sha256sum] = "ab5fc8752900fc4a061be2775ca0a6458512ff44adbac4080c0f9a99d796ec22"

URI_aarch64_rust-regex-syntax+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+unicode-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-regex-syntax+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+unicode-devel}"
SRC_URI[aarch64_rust-regex-syntax+unicode-devel.sha256sum] = "0d7537881aefeab8bcc835f3d2206f29712fa62a4352ad118d51e69aa38d60a0"

URI_aarch64_rust-regex-syntax+unicode-gencat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+unicode-gencat-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-regex-syntax+unicode-gencat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+unicode-gencat-devel}"
SRC_URI[aarch64_rust-regex-syntax+unicode-gencat-devel.sha256sum] = "2ea2c01459f4331eb71f3163b35698500699d94621948b55d3d15e588c8b549a"

URI_aarch64_rust-regex-syntax+unicode-perl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+unicode-perl-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-regex-syntax+unicode-perl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+unicode-perl-devel}"
SRC_URI[aarch64_rust-regex-syntax+unicode-perl-devel.sha256sum] = "eedea3a47af8bc39bcd3bb7ef2af8d219d487e24731c723cfa5d567ea4f52074"

URI_aarch64_rust-regex-syntax+unicode-script-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+unicode-script-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-regex-syntax+unicode-script-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+unicode-script-devel}"
SRC_URI[aarch64_rust-regex-syntax+unicode-script-devel.sha256sum] = "b0cc7ae53e1e60571c31df7a9b0d8cea72d8f932378653d68ccbaf03e073ddb0"

URI_aarch64_rust-regex-syntax+unicode-segment-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+unicode-segment-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-regex-syntax+unicode-segment-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+unicode-segment-devel}"
SRC_URI[aarch64_rust-regex-syntax+unicode-segment-devel.sha256sum] = "0844e30d1020c591ed1c04fba27d68b299299efa4e68d58e9b718edf863a2575"

URI_aarch64_rust-regex-syntax-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-regex-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax-devel}"
SRC_URI[aarch64_rust-regex-syntax-devel.sha256sum] = "0411c5ba5c7a7d0ee790ead7d5b780f0a4578d051c9e0a68cdb86db3fef07bd0"

RDEPENDS:rust-regex-syntax+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+default-devel = " \
 cargo \
 rust-regex-syntax+std-devel \
 rust-regex-syntax+unicode-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+std-devel = " \
 cargo \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+unicode-age-devel = " \
 cargo \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+unicode-bool-devel = " \
 cargo \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+unicode-case-devel = " \
 cargo \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+unicode-devel = " \
 cargo \
 rust-regex-syntax+unicode-age-devel \
 rust-regex-syntax+unicode-bool-devel \
 rust-regex-syntax+unicode-case-devel \
 rust-regex-syntax+unicode-gencat-devel \
 rust-regex-syntax+unicode-perl-devel \
 rust-regex-syntax+unicode-script-devel \
 rust-regex-syntax+unicode-segment-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+unicode-gencat-devel = " \
 cargo \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+unicode-perl-devel = " \
 cargo \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+unicode-script-devel = " \
 cargo \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+unicode-segment-devel = " \
 cargo \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax-devel = " \
 cargo \
 rust \
 "
