# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "c-icap"
PV = "0.6.5"
PR = "1.el10_2"
PACKAGES = " \
 c-icap \
 c-icap-devel \
 c-icap-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/c-icap-0.6.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "92fd107013933c97f6d33d2debfa2b9ba27554bf5cfd278a2754ead9b10aa541"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/c-icap-0.6.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_c-icap;unpack=0"
SRC_URI[x86_64_v2_c-icap.sha256sum] = "323b66766db5a6502026a8fbd62f5d5eed7911be209402d506c8f2269c72984c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/c-icap-devel-0.6.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_c-icap-devel;unpack=0"
SRC_URI[x86_64_v2_c-icap-devel.sha256sum] = "205f447c36c85e21d6755291d3f014c1ec4d609e2fed26b6fb0d771600a256d7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/c-icap-libs-0.6.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_c-icap-libs;unpack=0"
SRC_URI[x86_64_v2_c-icap-libs.sha256sum] = "7e3c4f5fe3f185ccff21fe27b68d99a9b7cb5792b37159d6b71ebfebbadc4fa2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/c-icap-0.6.5-1.el10_2.aarch64.rpm;name=aarch64_c-icap;unpack=0"
SRC_URI[aarch64_c-icap.sha256sum] = "dbd5feb21ab9aaa6ddef007af478fc1e18f02cda4b85bc5582e8c36d0175327a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/c-icap-devel-0.6.5-1.el10_2.aarch64.rpm;name=aarch64_c-icap-devel;unpack=0"
SRC_URI[aarch64_c-icap-devel.sha256sum] = "d42fa370756973178a076075c692a25a1ca9ffd1403396dc5021acc181ca4e0b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/c-icap-libs-0.6.5-1.el10_2.aarch64.rpm;name=aarch64_c-icap-libs;unpack=0"
SRC_URI[aarch64_c-icap-libs.sha256sum] = "69e8a5275623ec1075f3efe600ff14363b0e17837055bf25ea51b5e3e2fcb237"

RDEPENDS:c-icap = " \
 bash \
 c-icap-libs \
 glibc \
 libatomic \
 lmdb-libs \
 logrotate \
 openldap \
 shadow-utils \
 "
RDEPENDS:c-icap-devel = " \
 bash \
 c-icap-libs \
 zlib-ng-compat-devel \
 "
RDEPENDS:c-icap-libs = " \
 bzip2-libs \
 glibc \
 libatomic \
 libbrotli \
 openssl-libs \
 pcre2 \
 zlib-ng-compat \
 "
