# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nx-libs"
PV = "3.5.99.27"
PR = "6.el10_3"
PACKAGES = " \
 libNX_X11 \
 libNX_X11-devel \
 libXcomp \
 libXcomp-devel \
 libXcompshad \
 libXcompshad-devel \
 nx-libs \
 nx-libs-devel \
 nx-proto-devel \
 nxagent \
 nxdialog \
 nxproxy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nx-libs-3.5.99.27-6.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "078a3d1ee8834556b61dc0d98400c7cb1dff9b73573be20aa56981092e1ab47c"

URI_x86_64_v2_libNX_X11 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libNX_X11-3.5.99.27-6.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libNX_X11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libNX_X11}"
SRC_URI[x86_64_v2_libNX_X11.sha256sum] = "59516679093b3dc070af95f42b2b3020719f280933f19475e18ca9d491086084"

URI_x86_64_v2_libNX_X11-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libNX_X11-devel-3.5.99.27-6.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libNX_X11-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libNX_X11-devel}"
SRC_URI[x86_64_v2_libNX_X11-devel.sha256sum] = "6e78cff0bf6aec3967b8308234ea9f4dae9645a73c3652c0dae62a18f834e43d"

URI_x86_64_v2_libXcomp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libXcomp-3.5.99.27-6.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libXcomp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXcomp}"
SRC_URI[x86_64_v2_libXcomp.sha256sum] = "a81d0ba15579de08568118072b40f782038c6b859a18636f222a6499acb78dac"

URI_x86_64_v2_libXcomp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libXcomp-devel-3.5.99.27-6.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libXcomp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXcomp-devel}"
SRC_URI[x86_64_v2_libXcomp-devel.sha256sum] = "d4ebd639bd7c434682aa432cb2d932688843d3a6645cc4145aaa83372bfba3e3"

URI_x86_64_v2_libXcompshad = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libXcompshad-3.5.99.27-6.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libXcompshad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXcompshad}"
SRC_URI[x86_64_v2_libXcompshad.sha256sum] = "551e8f8aedf5813f83da73adc32ab5bd2926cfdc276468722f5a90be3d4af0a8"

URI_x86_64_v2_libXcompshad-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libXcompshad-devel-3.5.99.27-6.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libXcompshad-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXcompshad-devel}"
SRC_URI[x86_64_v2_libXcompshad-devel.sha256sum] = "f82fb71e5502fc9fa4ca74d4a79043f17cc3fd0cd0232988e798323ceb69687f"

URI_x86_64_v2_nx-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nx-libs-3.5.99.27-6.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nx-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nx-libs}"
SRC_URI[x86_64_v2_nx-libs.sha256sum] = "7b84a50f923abf30970774baf2cd20fe5b96f5294e672f65d3fb9eab98c30b01"

URI_x86_64_v2_nx-libs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nx-libs-devel-3.5.99.27-6.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nx-libs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nx-libs-devel}"
SRC_URI[x86_64_v2_nx-libs-devel.sha256sum] = "c888d119bf785b6f9b43d42148b7b7378d32871d0e485928c35750ced283aa47"

URI_x86_64_v2_nx-proto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nx-proto-devel-3.5.99.27-6.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nx-proto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nx-proto-devel}"
SRC_URI[x86_64_v2_nx-proto-devel.sha256sum] = "6038d651872f405b6999d49697f8c3a9ea6b6eb7395ea7e2981eb9fdec51097a"

URI_x86_64_v2_nxagent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nxagent-3.5.99.27-6.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nxagent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nxagent}"
SRC_URI[x86_64_v2_nxagent.sha256sum] = "9c619057e735b834e4cc0cce2ed465594857307e60b43b1541b8b1759cff038f"

URI_x86_64_v2_nxdialog = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nxdialog-3.5.99.27-6.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nxdialog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nxdialog}"
SRC_URI[x86_64_v2_nxdialog.sha256sum] = "ba49aa45c043ff1613d106d80b620df1823eff7a90773162c94dd2bc812e6588"

URI_x86_64_v2_nxproxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nxproxy-3.5.99.27-6.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nxproxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nxproxy}"
SRC_URI[x86_64_v2_nxproxy.sha256sum] = "85a5b49756c2a9d73d05f8e8cd78f2ce6693a40610b8e028f674e7c09ac78158"

URI_aarch64_libNX_X11 = "${EPEL_MIRROR}/aarch64/Packages/l/libNX_X11-3.5.99.27-6.el10_3.aarch64.rpm;name=aarch64_libNX_X11;unpack=0"
SRC_URI:append = " ${URI_aarch64_libNX_X11}"
SRC_URI[aarch64_libNX_X11.sha256sum] = "ebefa21bf6cdb58fd58531e08e50aa319c7487dc1a334019d11df294c4a6b276"

URI_aarch64_libNX_X11-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libNX_X11-devel-3.5.99.27-6.el10_3.aarch64.rpm;name=aarch64_libNX_X11-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libNX_X11-devel}"
SRC_URI[aarch64_libNX_X11-devel.sha256sum] = "f4b79170d6c1271782ddb151e56ac2b2f1c69de8f8454730f0861508d183448b"

URI_aarch64_libXcomp = "${EPEL_MIRROR}/aarch64/Packages/l/libXcomp-3.5.99.27-6.el10_3.aarch64.rpm;name=aarch64_libXcomp;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXcomp}"
SRC_URI[aarch64_libXcomp.sha256sum] = "1869079cabe26e19cc78ba37eb34cb7bf0e13ac9c588329afa14961099c32045"

URI_aarch64_libXcomp-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libXcomp-devel-3.5.99.27-6.el10_3.aarch64.rpm;name=aarch64_libXcomp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXcomp-devel}"
SRC_URI[aarch64_libXcomp-devel.sha256sum] = "fa9c0d5f43a5136bff7a714849bd20a35b3826a493d05821934fdde014218e58"

URI_aarch64_libXcompshad = "${EPEL_MIRROR}/aarch64/Packages/l/libXcompshad-3.5.99.27-6.el10_3.aarch64.rpm;name=aarch64_libXcompshad;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXcompshad}"
SRC_URI[aarch64_libXcompshad.sha256sum] = "06990d6bc5ca4c8c03702c3d44ee33978040a9793f0b18e100fcdfc16a946240"

URI_aarch64_libXcompshad-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libXcompshad-devel-3.5.99.27-6.el10_3.aarch64.rpm;name=aarch64_libXcompshad-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXcompshad-devel}"
SRC_URI[aarch64_libXcompshad-devel.sha256sum] = "b7c8541f2bdd8edc014e1026a2d41f697b63ddad852132881b78c665b01bf330"

URI_aarch64_nx-libs = "${EPEL_MIRROR}/aarch64/Packages/n/nx-libs-3.5.99.27-6.el10_3.aarch64.rpm;name=aarch64_nx-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nx-libs}"
SRC_URI[aarch64_nx-libs.sha256sum] = "9d72a8a7fe613c320b9541a4c7c9046e4a563898f7620c8280c8a52a84844622"

URI_aarch64_nx-libs-devel = "${EPEL_MIRROR}/aarch64/Packages/n/nx-libs-devel-3.5.99.27-6.el10_3.aarch64.rpm;name=aarch64_nx-libs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nx-libs-devel}"
SRC_URI[aarch64_nx-libs-devel.sha256sum] = "41dda1de9330478c43fd88bf78fc9a7540d4d61453e5fac025121e1079b74eac"

URI_aarch64_nx-proto-devel = "${EPEL_MIRROR}/aarch64/Packages/n/nx-proto-devel-3.5.99.27-6.el10_3.aarch64.rpm;name=aarch64_nx-proto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nx-proto-devel}"
SRC_URI[aarch64_nx-proto-devel.sha256sum] = "f4d2d5ba8d029584b812fdbf2394d86a2c01738fd5c85dcac34f9dbb74216806"

URI_aarch64_nxagent = "${EPEL_MIRROR}/aarch64/Packages/n/nxagent-3.5.99.27-6.el10_3.aarch64.rpm;name=aarch64_nxagent;unpack=0"
SRC_URI:append = " ${URI_aarch64_nxagent}"
SRC_URI[aarch64_nxagent.sha256sum] = "fcb6d94c4b5f66bfe5d172b5f43fd139581960387b914a635ef9ee50afe55698"

URI_aarch64_nxdialog = "${EPEL_MIRROR}/aarch64/Packages/n/nxdialog-3.5.99.27-6.el10_3.aarch64.rpm;name=aarch64_nxdialog;unpack=0"
SRC_URI:append = " ${URI_aarch64_nxdialog}"
SRC_URI[aarch64_nxdialog.sha256sum] = "c666fffd87da41cdf98b8fe69494831022f596298e49df22cc2c4ebad5995694"

URI_aarch64_nxproxy = "${EPEL_MIRROR}/aarch64/Packages/n/nxproxy-3.5.99.27-6.el10_3.aarch64.rpm;name=aarch64_nxproxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_nxproxy}"
SRC_URI[aarch64_nxproxy.sha256sum] = "2a7cc220b4de1579452f35c2fb9a720721f6ee20ee566e12d7fb4516c7c5dabd"

RDEPENDS:libNX_X11 = " \
 glibc \
 libXcomp \
 libXdmcp \
 libjpeg-turbo \
 libpng \
 nx-libs \
 zlib-ng-compat \
 "
RDEPENDS:libNX_X11-devel = " \
 libNX_X11 \
 nx-proto-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libXcomp = " \
 glibc \
 libgcc \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 nx-libs \
 zlib-ng-compat \
 "
RDEPENDS:libXcomp-devel = " \
 libX11-devel \
 libXcomp \
 libpng-devel \
 nx-proto-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libXcompshad = " \
 glibc \
 libNX_X11 \
 libX11 \
 libXcomp \
 libXdamage \
 libXdmcp \
 libXext \
 libXfixes \
 libXrandr \
 libXtst \
 libgcc \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 nx-libs \
 zlib-ng-compat \
 "
RDEPENDS:libXcompshad-devel = " \
 libNX_X11-devel \
 libX11-devel \
 libXcomp-devel \
 libXcompshad \
 nx-libs-devel \
 nx-proto-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:nx-libs = " \
 "
RDEPENDS:nx-libs-devel = " \
 libNX_X11-devel \
 nx-libs \
 nx-proto-devel \
 "
RDEPENDS:nx-proto-devel = " \
 "
RDEPENDS:nxagent = " \
 glibc \
 libNX_X11 \
 libX11 \
 libXcomp \
 libXcomposite \
 libXcompshad \
 libXdmcp \
 libXext \
 libXfixes \
 libXfont2 \
 libXinerama \
 libXpm \
 libXrender \
 libgcc \
 libjpeg-turbo \
 libpng \
 libtirpc \
 libxml2 \
 pixman \
 zlib-ng-compat \
 "
RDEPENDS:nxdialog = " \
 python3 \
 "
RDEPENDS:nxproxy = " \
 glibc \
 libXcomp \
 "
