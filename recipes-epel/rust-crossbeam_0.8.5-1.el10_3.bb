# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossbeam"
PV = "0.8.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-crossbeam+alloc-devel \
 rust-crossbeam+crossbeam-channel-devel \
 rust-crossbeam+crossbeam-deque-devel \
 rust-crossbeam+crossbeam-epoch-devel \
 rust-crossbeam+crossbeam-queue-devel \
 rust-crossbeam+default-devel \
 rust-crossbeam+nightly-devel \
 rust-crossbeam+std-devel \
 rust-crossbeam-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-crossbeam-0.8.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "267451cd5e290f8ef55280fdca0361fe3a3111ce978b1f5103739619e665a90b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam+alloc-devel-0.8.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam+alloc-devel.sha256sum] = "b547cfea9da6481cf24c09a6931f3c748e085721003405b171c4b9149e884757"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam+crossbeam-channel-devel-0.8.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam+crossbeam-channel-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam+crossbeam-channel-devel.sha256sum] = "964a60a5cab33dda81298af8b35c12e2d1cdd03c00b12a2c254b4a5f6ab0e6a0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam+crossbeam-deque-devel-0.8.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam+crossbeam-deque-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam+crossbeam-deque-devel.sha256sum] = "a6b3c036f879f8d143ddec6a9da0666f84fbfc546ef1999e26f98b925398cff1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam+crossbeam-epoch-devel-0.8.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam+crossbeam-epoch-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam+crossbeam-epoch-devel.sha256sum] = "2625d2d42fd3e6618aa48f9d57371eeaf14757660095c3eb0a6e3ccc1e2e24a9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam+crossbeam-queue-devel-0.8.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam+crossbeam-queue-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam+crossbeam-queue-devel.sha256sum] = "c31f5b9351e0a98c78a2d0db783635af3dd640aee4fa2e3972126549e8f993c3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam+default-devel-0.8.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam+default-devel.sha256sum] = "4b68b6a04de7e6dc866908c3547ebf2e46b7b8b2b20cbec6533e42b181b4222c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam+nightly-devel-0.8.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam+nightly-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam+nightly-devel.sha256sum] = "efd21c3fa95af831121fe5f1dcadfe0cb568873a04a583a5bcdf3c15a373f243"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam+std-devel-0.8.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam+std-devel.sha256sum] = "9fe828dbeeec790b5cba81907c14d4914b4bbbf20039ca0ac42cc59c3cb1b59e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-devel-0.8.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-devel.sha256sum] = "fc172254790a8d2c870918d8f6cec38cde946168d524b400bb30954d5b033f62"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam+alloc-devel-0.8.5-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam+alloc-devel.sha256sum] = "2e1fa5294dd95e2d61ae10428a1d9b3ec3075ae7fb87e65117856ad949a18749"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam+crossbeam-channel-devel-0.8.5-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam+crossbeam-channel-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam+crossbeam-channel-devel.sha256sum] = "6825b9aa23e7a6c9ecec00dc991d7ad2ad7c2a723229b469a734ee20df76b7be"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam+crossbeam-deque-devel-0.8.5-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam+crossbeam-deque-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam+crossbeam-deque-devel.sha256sum] = "4f0081e529bc202be3a2293c1d73acbe5027ea2d840e07734eb49977d6bc0da9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam+crossbeam-epoch-devel-0.8.5-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam+crossbeam-epoch-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam+crossbeam-epoch-devel.sha256sum] = "837f3c32c3ea32d68a865514987fbf699a40d774b252122784c935ef8f5ba546"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam+crossbeam-queue-devel-0.8.5-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam+crossbeam-queue-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam+crossbeam-queue-devel.sha256sum] = "d2b7416a91273a4f7771ad209befad6e8ae7152598e794e8605af04619a85972"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam+default-devel-0.8.5-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam+default-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam+default-devel.sha256sum] = "301062709e3455d4feb49b3cf93fbe0032bb04ad131a13b39d97b913c590c776"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam+nightly-devel-0.8.5-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam+nightly-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam+nightly-devel.sha256sum] = "e453f37e0cb0be8eea575312af62e3c28ef58d1cb35c74ca2ca19b654dbf1235"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam+std-devel-0.8.5-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam+std-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam+std-devel.sha256sum] = "c670c0b4bd5b34f1bcf54c6ac2ba77a47b4277ba3cb935a48a2dd89eb16ec38c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-devel-0.8.5-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-devel.sha256sum] = "34c909e7db7be14aaa247affe26d3de1bd31f1be4994ad80c1327e0e2e55ddb9"

RDEPENDS:rust-crossbeam+alloc-devel = " \
 cargo \
 rust-crossbeam-devel \
 rust-crossbeam-epoch+alloc-devel \
 rust-crossbeam-epoch-devel \
 rust-crossbeam-queue+alloc-devel \
 rust-crossbeam-queue-devel \
 "
RDEPENDS:rust-crossbeam+crossbeam-channel-devel = " \
 cargo \
 rust-crossbeam-channel-devel \
 rust-crossbeam-devel \
 "
RDEPENDS:rust-crossbeam+crossbeam-deque-devel = " \
 cargo \
 rust-crossbeam-deque-devel \
 rust-crossbeam-devel \
 "
RDEPENDS:rust-crossbeam+crossbeam-epoch-devel = " \
 cargo \
 rust-crossbeam-devel \
 rust-crossbeam-epoch-devel \
 "
RDEPENDS:rust-crossbeam+crossbeam-queue-devel = " \
 cargo \
 rust-crossbeam-devel \
 rust-crossbeam-queue-devel \
 "
RDEPENDS:rust-crossbeam+default-devel = " \
 cargo \
 rust-crossbeam+std-devel \
 rust-crossbeam-devel \
 "
RDEPENDS:rust-crossbeam+nightly-devel = " \
 cargo \
 rust-crossbeam-devel \
 rust-crossbeam-epoch+nightly-devel \
 rust-crossbeam-epoch-devel \
 rust-crossbeam-queue+nightly-devel \
 rust-crossbeam-queue-devel \
 rust-crossbeam-utils+nightly-devel \
 "
RDEPENDS:rust-crossbeam+std-devel = " \
 cargo \
 rust-crossbeam+alloc-devel \
 rust-crossbeam-channel+std-devel \
 rust-crossbeam-channel-devel \
 rust-crossbeam-deque+std-devel \
 rust-crossbeam-deque-devel \
 rust-crossbeam-devel \
 rust-crossbeam-epoch+std-devel \
 rust-crossbeam-epoch-devel \
 rust-crossbeam-queue+std-devel \
 rust-crossbeam-queue-devel \
 rust-crossbeam-utils+std-devel \
 "
RDEPENDS:rust-crossbeam-devel = " \
 cargo \
 rust \
 rust-crossbeam-utils-devel \
 "
