# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksc"
PV = "1.12"
PR = "7.git869a25c.el10"
PACKAGES = " \
 ksc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/ksc-1.12-7.git869a25c.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "caeb8abe1e3f20026c3de3091378afba566c11024bfc3b974cc8815568932054"

URI_x86_64_v2_ksc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ksc-1.12-7.git869a25c.el10.noarch.rpm;name=x86_64_v2_ksc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksc}"
SRC_URI[x86_64_v2_ksc.sha256sum] = "8be5d6ffadde49457a302c1a1b9f3d2b49d7099110430598ea9dcc5593964b62"

URI_aarch64_ksc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ksc-1.12-7.git869a25c.el10.noarch.rpm;name=aarch64_ksc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksc}"
SRC_URI[aarch64_ksc.sha256sum] = "8be5d6ffadde49457a302c1a1b9f3d2b49d7099110430598ea9dcc5593964b62"

RDEPENDS:ksc = " \
 binutils \
 kernel-devel \
 kmod \
 python3-requests \
 "
