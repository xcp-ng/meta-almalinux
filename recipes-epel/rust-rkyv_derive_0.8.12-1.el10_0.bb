# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rkyv_derive"
PV = "0.8.12"
PR = "1.el10_0"
PACKAGES = " \
 rust-rkyv_derive+bytecheck-devel \
 rust-rkyv_derive+default-devel \
 rust-rkyv_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rkyv_derive-0.8.12-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a156c3927afaff824e524f714b0935bd5502c7fe10949baceecfab8b199b9194"

URI_x86_64_v2_rust-rkyv_derive+bytecheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv_derive+bytecheck-devel-0.8.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv_derive+bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv_derive+bytecheck-devel}"
SRC_URI[x86_64_v2_rust-rkyv_derive+bytecheck-devel.sha256sum] = "67116a0715deae65f94841165e846d4381ff104346ed68263419ab3cfaab8531"

URI_x86_64_v2_rust-rkyv_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv_derive+default-devel-0.8.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv_derive+default-devel}"
SRC_URI[x86_64_v2_rust-rkyv_derive+default-devel.sha256sum] = "6d5d1ecc1b4843a26db620a577b8fb0645a820d386c90e30f5649340417dff47"

URI_x86_64_v2_rust-rkyv_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv_derive-devel-0.8.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv_derive-devel}"
SRC_URI[x86_64_v2_rust-rkyv_derive-devel.sha256sum] = "d27a9891b329b3a38bbc1c1447e4c4dd58e3bc6e66c5071b597c9fa435b17117"

URI_aarch64_rust-rkyv_derive+bytecheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv_derive+bytecheck-devel-0.8.12-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv_derive+bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv_derive+bytecheck-devel}"
SRC_URI[aarch64_rust-rkyv_derive+bytecheck-devel.sha256sum] = "2c2074897c0837c71d6a96fc8205f5e79e6bab9b82900ce9514439ae30806c00"

URI_aarch64_rust-rkyv_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv_derive+default-devel-0.8.12-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv_derive+default-devel}"
SRC_URI[aarch64_rust-rkyv_derive+default-devel.sha256sum] = "ba4e728fde0df8c2399c6ad9f8fd72617b2aad9e46b1b0cb9cd2bed389343ff5"

URI_aarch64_rust-rkyv_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv_derive-devel-0.8.12-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv_derive-devel}"
SRC_URI[aarch64_rust-rkyv_derive-devel.sha256sum] = "0192265d4b1eaa7c7f95eb53d29b4a6fe3974e05a973858bb775a0b630acd750"

RDEPENDS:rust-rkyv_derive+bytecheck-devel = " \
 cargo \
 rust-rkyv_derive-devel \
 "
RDEPENDS:rust-rkyv_derive+default-devel = " \
 cargo \
 rust-rkyv_derive-devel \
 "
RDEPENDS:rust-rkyv_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+proc-macro-devel \
 rust-proc-macro2-devel \
 rust-quote+proc-macro-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
