# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bitcoin-core-selinux"
PV = "0.2"
PR = "1.el10_2"
PACKAGES = " \
 bitcoin-core-selinux \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bitcoin-core-selinux-0.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6d469a6aac2ee899ed62898863435406097895eddf0dbf2fd3d74b9ce3cfa0ee"

URI_x86_64_v2_bitcoin-core-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bitcoin-core-selinux-0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_bitcoin-core-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bitcoin-core-selinux}"
SRC_URI[x86_64_v2_bitcoin-core-selinux.sha256sum] = "cae25f30728f1d1426f0e400a582e4ca8d0a5ca4c6b347311e31b0c8d9556d3e"

URI_aarch64_bitcoin-core-selinux = "${EPEL_MIRROR}/aarch64/Packages/b/bitcoin-core-selinux-0.2-1.el10_2.noarch.rpm;name=aarch64_bitcoin-core-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_bitcoin-core-selinux}"
SRC_URI[aarch64_bitcoin-core-selinux.sha256sum] = "8d6abe7556b9a3a665afc105de4b5bcf7f0229d0016f82b07836d2a7be7a0746"

RDEPENDS:bitcoin-core-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
