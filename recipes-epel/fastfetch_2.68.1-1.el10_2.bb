# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fastfetch"
PV = "2.68.1"
PR = "1.el10_2"
PACKAGES = " \
 fastfetch \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/f/fastfetch-2.68.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "021b8a74d5153bda1711ecf2a19f0c039975eed0183e1a48977a9b8a736f723f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fastfetch-2.68.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fastfetch;unpack=0"
SRC_URI[x86_64_v2_fastfetch.sha256sum] = "c4517dc4f2bef42a42e22f5c177e91a550ef2c24e6c3a57beebbb38fd0a12440"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/fastfetch-2.68.1-1.el10_2.aarch64.rpm;name=aarch64_fastfetch;unpack=0"
SRC_URI[aarch64_fastfetch.sha256sum] = "978f599d87ca29e38dd55da8f98d99b93956648cb8d9421ac1147c3988c89447"

RDEPENDS:fastfetch = " \
 glibc \
 libgcc \
 yyjson \
 "
