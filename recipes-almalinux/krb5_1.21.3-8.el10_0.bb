# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "krb5"
PV = "1.21.3"
PR = "8.el10_0"
PACKAGES = " \
 krb5-devel \
 krb5-libs \
 krb5-pkinit \
 krb5-server \
 krb5-server-ldap \
 krb5-workstation \
 libkadm5 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/krb5-1.21.3-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43360e2a26bd460e76e25b1b8cdf45683de0eef262878e44bc73fd585928ecb9"

URI_x86_64_v2_krb5-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/krb5-devel-1.21.3-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_krb5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krb5-devel}"
SRC_URI[x86_64_v2_krb5-devel.sha256sum] = "cad4f1b1fbfd275ed34ea5c72d20fda29fe8cf30443cba157c9cf13d4b634996"

URI_x86_64_v2_krb5-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/krb5-libs-1.21.3-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_krb5-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krb5-libs}"
SRC_URI[x86_64_v2_krb5-libs.sha256sum] = "ff2435dc320daaa17d0c8cf07eef1fa48a3f55d77fff81d3c83865727f2b3fd9"

URI_x86_64_v2_krb5-pkinit = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/krb5-pkinit-1.21.3-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_krb5-pkinit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krb5-pkinit}"
SRC_URI[x86_64_v2_krb5-pkinit.sha256sum] = "9c7424646e87c10bf72b33792ec2133c86f454b6f2c2863d2eabb076a56a9098"

URI_x86_64_v2_krb5-server = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/krb5-server-1.21.3-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_krb5-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krb5-server}"
SRC_URI[x86_64_v2_krb5-server.sha256sum] = "f14cce1b4531ab49a6a119428edc81a45ccf23b876096a63f57123494bd3c260"

URI_x86_64_v2_krb5-server-ldap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/krb5-server-ldap-1.21.3-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_krb5-server-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krb5-server-ldap}"
SRC_URI[x86_64_v2_krb5-server-ldap.sha256sum] = "c98b732e2c8723e9f8166c7375956e30783f3b7f1ca061e473206ddab222d378"

URI_x86_64_v2_krb5-workstation = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/krb5-workstation-1.21.3-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_krb5-workstation;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krb5-workstation}"
SRC_URI[x86_64_v2_krb5-workstation.sha256sum] = "10e4b226923904583ac85fd9b3e1369d4edd96c6df0b38af78ca734adb0f53be"

URI_x86_64_v2_libkadm5 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libkadm5-1.21.3-8.el10_0.x86_64_v2.rpm;name=x86_64_v2_libkadm5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkadm5}"
SRC_URI[x86_64_v2_libkadm5.sha256sum] = "6d00e0ea106543ed9ca91de4d8671cb10e849a203e6575e20003c60836f424fa"

URI_aarch64_krb5-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/krb5-devel-1.21.3-8.el10_0.aarch64.rpm;name=aarch64_krb5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_krb5-devel}"
SRC_URI[aarch64_krb5-devel.sha256sum] = "4b0e0b851a55d59011728373eba1a390e536a6030607c56396122742ba295967"

URI_aarch64_krb5-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/krb5-libs-1.21.3-8.el10_0.aarch64.rpm;name=aarch64_krb5-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_krb5-libs}"
SRC_URI[aarch64_krb5-libs.sha256sum] = "aaf1262a2989a70ddf790966edc225677a39c4879436f8a1b5cec039e2c92d5b"

URI_aarch64_krb5-pkinit = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/krb5-pkinit-1.21.3-8.el10_0.aarch64.rpm;name=aarch64_krb5-pkinit;unpack=0"
SRC_URI:append = " ${URI_aarch64_krb5-pkinit}"
SRC_URI[aarch64_krb5-pkinit.sha256sum] = "fb9bfcffc6dbeb81c01775ba3f04f428575615e20929939a31cb324730c361b1"

URI_aarch64_krb5-server = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/krb5-server-1.21.3-8.el10_0.aarch64.rpm;name=aarch64_krb5-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_krb5-server}"
SRC_URI[aarch64_krb5-server.sha256sum] = "464746fb1464571f3e66bb16101b738acbdd5915009995a9c3ba2634452910df"

URI_aarch64_krb5-server-ldap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/krb5-server-ldap-1.21.3-8.el10_0.aarch64.rpm;name=aarch64_krb5-server-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_krb5-server-ldap}"
SRC_URI[aarch64_krb5-server-ldap.sha256sum] = "e012013788fccad745162fd851f64c4b12a7deeb068ba9fb5ffcc486e4ecd658"

URI_aarch64_krb5-workstation = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/krb5-workstation-1.21.3-8.el10_0.aarch64.rpm;name=aarch64_krb5-workstation;unpack=0"
SRC_URI:append = " ${URI_aarch64_krb5-workstation}"
SRC_URI[aarch64_krb5-workstation.sha256sum] = "46c04941782bf66cd18fd264f6be102fb965697610fa5cc91ae75f46029f89b0"

URI_aarch64_libkadm5 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libkadm5-1.21.3-8.el10_0.aarch64.rpm;name=aarch64_libkadm5;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkadm5}"
SRC_URI[aarch64_libkadm5.sha256sum] = "28e2ec5ab71f3f005ada781f0f3a88737ac9d4e7aee2c90649e7aee7a8a2f514"

RDEPENDS:krb5-devel = " \
 bash \
 keyutils-libs-devel \
 krb5-devel \
 krb5-libs \
 libcom_err-devel \
 libkadm5 \
 libselinux-devel \
 libverto-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:krb5-libs = " \
 crypto-policies \
 gawk \
 glibc \
 keyutils-libs \
 libcom_err \
 libselinux \
 libverto \
 openssl-libs \
 sed \
 virtual/coreutils \
 "
RDEPENDS:krb5-pkinit = " \
 glibc \
 keyutils-libs \
 krb5-libs \
 libcom_err \
 openssl-libs \
 "
RDEPENDS:krb5-server = " \
 bash \
 glibc \
 keyutils-libs \
 krb5-libs \
 krb5-pkinit \
 libcom_err \
 libkadm5 \
 libselinux \
 libss \
 libverto \
 libverto-libev \
 lmdb-libs \
 logrotate \
 openssl-libs \
 systemd \
 words \
 "
RDEPENDS:krb5-server-ldap = " \
 glibc \
 keyutils-libs \
 krb5-libs \
 krb5-server \
 libcom_err \
 libkadm5 \
 openldap \
 openssl-libs \
 "
RDEPENDS:krb5-workstation = " \
 bash \
 glibc \
 krb5-libs \
 krb5-pkinit \
 libcom_err \
 libkadm5 \
 libss \
 pam-libs \
 "
RDEPENDS:libkadm5 = " \
 glibc \
 keyutils-libs \
 krb5-libs \
 libcom_err \
 openssl-libs \
 "
