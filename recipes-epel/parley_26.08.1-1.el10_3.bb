# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "parley"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 parley \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/parley-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7bdba61f8610a0065571cc4ae9d9df849a20e23f9bdeedd5f32e77f5d7a82ef3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/parley-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_parley;unpack=0"
SRC_URI[x86_64_v2_parley.sha256sum] = "a299c0e2666aca44c6e20e167438f9aadf36b64686084ebad616e10ad00b59b6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/parley-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_parley;unpack=0"
SRC_URI[aarch64_parley.sha256sum] = "6be5f8874e3dd080cfac99ebb1f2ca46edf11caf6cee79ba4a66ab3571e536de"

RDEPENDS:parley = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 libkeduvocdocument \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
 qt6-qtwebengine \
 "
