# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "babel"
PV = "2.13.1"
PR = "5.el10"
PACKAGES = " \
 babel \
 babel-doc \
 python3-babel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/babel-2.13.1-5.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "40c4619ff9fc270dd64230a4ed9dd06ed90ced4580c3f95104f8a3cde54d5896"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/babel-2.13.1-5.el10.noarch.rpm;name=x86_64_v2_babel;unpack=0"
SRC_URI[x86_64_v2_babel.sha256sum] = "7f2d19d6202c13bfbe71fa9dd37a4319ae0bf7d1ac6b4d719d2a778de490ee2d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/babel-doc-2.13.1-5.el10.noarch.rpm;name=x86_64_v2_babel-doc;unpack=0"
SRC_URI[x86_64_v2_babel-doc.sha256sum] = "8fb0792fc907b1e163973ec5701d28fa1f860525aede70bf126c73d9f8251159"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-babel-2.13.1-5.el10.noarch.rpm;name=x86_64_v2_python3-babel;unpack=0"
SRC_URI[x86_64_v2_python3-babel.sha256sum] = "29a00f11f4860646d98d838e0740902d8e9a81a7eb25c729f3cc7f0bf39e2077"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/babel-2.13.1-5.el10.noarch.rpm;name=aarch64_babel;unpack=0"
SRC_URI[aarch64_babel.sha256sum] = "7f2d19d6202c13bfbe71fa9dd37a4319ae0bf7d1ac6b4d719d2a778de490ee2d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/babel-doc-2.13.1-5.el10.noarch.rpm;name=aarch64_babel-doc;unpack=0"
SRC_URI[aarch64_babel-doc.sha256sum] = "8fb0792fc907b1e163973ec5701d28fa1f860525aede70bf126c73d9f8251159"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-babel-2.13.1-5.el10.noarch.rpm;name=aarch64_python3-babel;unpack=0"
SRC_URI[aarch64_python3-babel.sha256sum] = "29a00f11f4860646d98d838e0740902d8e9a81a7eb25c729f3cc7f0bf39e2077"

RDEPENDS:babel = " \
 python3 \
 python3-babel \
 "
RDEPENDS:babel-doc = " \
 "
RDEPENDS:python3-babel = " \
 python3 \
 python3-setuptools \
 "
