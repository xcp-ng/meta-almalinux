# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Web-ID"
PV = "1.927"
PR = "19.el10_0"
PACKAGES = " \
 perl-Web-ID \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Web-ID-1.927-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da821bec0160ef6965eb49867ba6bfd2acae1a7514d2d60f997274edb0258ff0"

URI_x86_64_v2_perl-Web-ID = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Web-ID-1.927-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Web-ID;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Web-ID}"
SRC_URI[x86_64_v2_perl-Web-ID.sha256sum] = "ac883e0ef708b79b0b799e758f7f8c70a3267314aa94edb5cc408b4ff5c84768"

URI_aarch64_perl-Web-ID = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Web-ID-1.927-19.el10_0.noarch.rpm;name=aarch64_perl-Web-ID;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Web-ID}"
SRC_URI[aarch64_perl-Web-ID.sha256sum] = "60e56b87570da82e9306f8bdff945404263dbfd94cfb3c07c0c6d70f620baf89"

RDEPENDS:perl-Web-ID = " \
 perl-Carp \
 perl-Crypt-X509 \
 perl-DateTime \
 perl-Digest-SHA \
 perl-Exporter-Tiny \
 perl-File-ShareDir \
 perl-File-Temp \
 perl-List-MoreUtils \
 perl-MIME-Base64 \
 perl-Math-BigInt \
 perl-Moose \
 perl-Path-Tiny \
 perl-PathTools \
 perl-Plack \
 perl-RDF-Query \
 perl-RDF-Trine \
 perl-Type-Tiny \
 perl-URI \
 perl-Web-ID \
 perl-base \
 perl-constant \
 perl-libs \
 perl-match-simple \
 perl-namespace-sweep \
 "
