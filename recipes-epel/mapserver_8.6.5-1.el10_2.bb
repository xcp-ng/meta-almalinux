# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mapserver"
PV = "8.6.5"
PR = "1.el10_2"
PACKAGES = " \
 mapserver \
 mapserver-devel \
 mapserver-java \
 mapserver-libs \
 mapserver-perl \
 mapserver-ruby \
 php-mapserver \
 python3-mapserver \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mapserver-8.6.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aabea6139762f9c74161e2a883e3ce55b3eba4ea3c0cdb6f595aacd35e0255d0"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - mapserver-libs: libgeos_c.so.1()(64bit)

URI_x86_64_v2_mapserver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mapserver-8.6.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mapserver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mapserver}"
SRC_URI[x86_64_v2_mapserver.sha256sum] = "3320569038b6177aa7aba57107c80eb173cbb9e17266790c4d1c940a15707411"

URI_x86_64_v2_mapserver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mapserver-devel-8.6.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mapserver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mapserver-devel}"
SRC_URI[x86_64_v2_mapserver-devel.sha256sum] = "c5ed65206a6056925efdcd214241807f8586ce6a469298c7e4ff4910764820b1"

URI_x86_64_v2_mapserver-java = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mapserver-java-8.6.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mapserver-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mapserver-java}"
SRC_URI[x86_64_v2_mapserver-java.sha256sum] = "fc16202f73821ba4b9905e7b397401151f331b94acdd760ac68ca0c7fc3ca13e"

URI_x86_64_v2_mapserver-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mapserver-libs-8.6.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mapserver-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mapserver-libs}"
SRC_URI[x86_64_v2_mapserver-libs.sha256sum] = "e3fd29a9fbbadc7cac6877fc336ca47920317b1d7636d4a836516c6f1a3cdb4c"

URI_x86_64_v2_mapserver-perl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mapserver-perl-8.6.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mapserver-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mapserver-perl}"
SRC_URI[x86_64_v2_mapserver-perl.sha256sum] = "10fda10602258048cc84b4c38b58fd00ef07728e7ee504392fe896ff606ad811"

URI_x86_64_v2_mapserver-ruby = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mapserver-ruby-8.6.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mapserver-ruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mapserver-ruby}"
SRC_URI[x86_64_v2_mapserver-ruby.sha256sum] = "128b710d57c435ca997702470551242f4cbfdde36f95ad57a73a8c142e20cbd8"

URI_x86_64_v2_php-mapserver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-mapserver-8.6.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-mapserver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-mapserver}"
SRC_URI[x86_64_v2_php-mapserver.sha256sum] = "a0267799235a82df6f628120cdd0963187b6c98ca4f5d9c8e836c9872f5f18ee"

URI_x86_64_v2_python3-mapserver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mapserver-8.6.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-mapserver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mapserver}"
SRC_URI[x86_64_v2_python3-mapserver.sha256sum] = "10f9a61f829e790a537a8a7470db0c9f293a67d48bb590f7aab8c67cfbe73b1a"

URI_aarch64_mapserver = "${EPEL_MIRROR}/aarch64/Packages/m/mapserver-8.6.5-1.el10_2.aarch64.rpm;name=aarch64_mapserver;unpack=0"
SRC_URI:append = " ${URI_aarch64_mapserver}"
SRC_URI[aarch64_mapserver.sha256sum] = "94e45df8e687e0129dbb851b7aa30733a4e4a2dbb9870fc1df47709fdb1c4b22"

URI_aarch64_mapserver-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mapserver-devel-8.6.5-1.el10_2.aarch64.rpm;name=aarch64_mapserver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mapserver-devel}"
SRC_URI[aarch64_mapserver-devel.sha256sum] = "f91cc721b774d9b344cc377bcf0166796fb66140e80aae8a16e9dd9a8de18781"

URI_aarch64_mapserver-java = "${EPEL_MIRROR}/aarch64/Packages/m/mapserver-java-8.6.5-1.el10_2.aarch64.rpm;name=aarch64_mapserver-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_mapserver-java}"
SRC_URI[aarch64_mapserver-java.sha256sum] = "586b1a215db7cd8a9cebcbe353934399ecc1f7024fb052735134087d5d6ab6aa"

URI_aarch64_mapserver-libs = "${EPEL_MIRROR}/aarch64/Packages/m/mapserver-libs-8.6.5-1.el10_2.aarch64.rpm;name=aarch64_mapserver-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_mapserver-libs}"
SRC_URI[aarch64_mapserver-libs.sha256sum] = "23adb23f8c78c06e59d32ded42a30bd3c406ae8364b9a5f05aaee3e0f61b58e8"

URI_aarch64_mapserver-perl = "${EPEL_MIRROR}/aarch64/Packages/m/mapserver-perl-8.6.5-1.el10_2.aarch64.rpm;name=aarch64_mapserver-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_mapserver-perl}"
SRC_URI[aarch64_mapserver-perl.sha256sum] = "384067ef9ef6d3e4760151fcfd4ea57f06203a841a03c8041271bc71ac0bb97b"

URI_aarch64_mapserver-ruby = "${EPEL_MIRROR}/aarch64/Packages/m/mapserver-ruby-8.6.5-1.el10_2.aarch64.rpm;name=aarch64_mapserver-ruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_mapserver-ruby}"
SRC_URI[aarch64_mapserver-ruby.sha256sum] = "470362bfda5f293a2c70347f368d2c999f6647cf8c27d2032f40e18168069a94"

URI_aarch64_php-mapserver = "${EPEL_MIRROR}/aarch64/Packages/p/php-mapserver-8.6.5-1.el10_2.aarch64.rpm;name=aarch64_php-mapserver;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-mapserver}"
SRC_URI[aarch64_php-mapserver.sha256sum] = "6c817f4ee9fca0082b0a8937a34b795ea327142f50726ea7556d301d99d8422f"

URI_aarch64_python3-mapserver = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mapserver-8.6.5-1.el10_2.aarch64.rpm;name=aarch64_python3-mapserver;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mapserver}"
SRC_URI[aarch64_python3-mapserver.sha256sum] = "94ce1c7c05aaa49e2e51b7f58608128a0a0adce60e9e67f1bd1eb793748a6909"

RDEPENDS:mapserver = " \
 dejavu-sans-fonts \
 fcgi \
 glibc \
 httpd \
 mapserver-libs \
 "
RDEPENDS:mapserver-devel = " \
 mapserver \
 mapserver-libs \
 "
RDEPENDS:mapserver-java = " \
 glibc \
 java-21-openjdk-headless \
 mapserver \
 mapserver-libs \
 "
RDEPENDS:mapserver-libs:x86_64_v2 = " \
 cairo \
 freetype \
 fribidi \
 gdal-libs \
 giflib \
 glibc \
 harfbuzz \
 libgcc \
 libjpeg-turbo \
 libpng \
 libpq \
 libstdc++ \
 libxml2 \
 libxslt \
 mariadb-connector-c \
 pcre2 \
 proj \
 protobuf-c \
 virtual/libcurl.so.4___64bit_ \
"
RDEPENDS:mapserver-libs:aarch64 = " \
 cairo \
 freetype \
 fribidi \
 gdal-libs \
 geos \
 giflib \
 glibc \
 harfbuzz \
 libgcc \
 libjpeg-turbo \
 libpng \
 libpq \
 libstdc++ \
 libxml2 \
 libxslt \
 mariadb-connector-c \
 pcre2 \
 proj \
 protobuf-c \
 virtual/libcurl.so.4___64bit_ \
"
RDEPENDS:mapserver-perl = " \
 glibc \
 mapserver \
 mapserver-libs \
 perl-DynaLoader \
 perl-Exporter \
 perl-base \
 perl-libs \
 perl-vars \
 "
RDEPENDS:mapserver-ruby = " \
 glibc \
 mapserver \
 mapserver-libs \
 ruby-libs \
 "
RDEPENDS:php-mapserver:x86_64_v2 = " \
 glibc \
 mapserver-libs \
 php8.4-common \
 virtual/php-gd_x86-64_ \
"
RDEPENDS:php-mapserver:aarch64 = " \
 glibc \
 mapserver-libs \
 php8.4-common \
 virtual/php-gd_aarch-64_ \
"
RDEPENDS:python3-mapserver = " \
 mapserver \
 python3 \
 "
