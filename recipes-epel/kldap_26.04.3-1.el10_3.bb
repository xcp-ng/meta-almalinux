# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kldap"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kldap \
 kldap-devel \
 kldap-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kldap-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8776f17dda2967c97984b7028b3f9bfffe61363e9927a74f549cfb32cc7c81a1"

URI_x86_64_v2_kldap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kldap-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kldap}"
SRC_URI[x86_64_v2_kldap.sha256sum] = "2543a1cce8cb06fd96bd20744f8380e1c0d22945a86394ecbd84ea2220336898"

URI_x86_64_v2_kldap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kldap-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kldap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kldap-devel}"
SRC_URI[x86_64_v2_kldap-devel.sha256sum] = "527d108e8672ac8e3fb40a5f02458c57f5b634d5324f81aa349c28ed4cd58557"

URI_x86_64_v2_kldap-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kldap-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kldap-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kldap-doc}"
SRC_URI[x86_64_v2_kldap-doc.sha256sum] = "d21245015509490401d2950726b12e50553340ba415630f71d0278438362cacf"

URI_aarch64_kldap = "${EPEL_MIRROR}/aarch64/Packages/k/kldap-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_kldap}"
SRC_URI[aarch64_kldap.sha256sum] = "85a199e840c3efddd92a6d7d234d8ce68f87364558cf878ac7aff8326f8b5eb7"

URI_aarch64_kldap-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kldap-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kldap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kldap-devel}"
SRC_URI[aarch64_kldap-devel.sha256sum] = "0fca8a9067d56b52b5dc18b635aa1dfb51461e8103824d2b37054e6cc656f348"

URI_aarch64_kldap-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kldap-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_kldap-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kldap-doc}"
SRC_URI[aarch64_kldap-doc.sha256sum] = "a3f8a28881b19317d89017566b35bdf5805a5b2fe628caad3dc912c4ad6aa590"

RDEPENDS:kldap = " \
 cyrus-sasl-lib \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 libstdc++ \
 openldap \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
RDEPENDS:kldap-devel = " \
 cmake-filesystem \
 cyrus-sasl-devel \
 kldap \
 openldap-devel \
 "
RDEPENDS:kldap-doc = " \
 "
