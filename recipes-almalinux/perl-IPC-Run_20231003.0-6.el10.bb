# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-IPC-Run"
PV = "20231003.0"
PR = "6.el10"
PACKAGES = " \
 perl-IPC-Run \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-IPC-Run-20231003.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cfd91abffee0831740b91e65620a2d6afddc9fbe37f50b8ef948cd807272df6e"

URI_x86_64_v2_perl-IPC-Run = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-IPC-Run-20231003.0-6.el10.noarch.rpm;name=x86_64_v2_perl-IPC-Run;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-IPC-Run}"
SRC_URI[x86_64_v2_perl-IPC-Run.sha256sum] = "82a08e4777f032fe4f0a2815248279e52c21c3ca2fe5c3b916e6f4379c2d4ecc"

URI_aarch64_perl-IPC-Run = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-IPC-Run-20231003.0-6.el10.noarch.rpm;name=aarch64_perl-IPC-Run;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-IPC-Run}"
SRC_URI[aarch64_perl-IPC-Run.sha256sum] = "82a08e4777f032fe4f0a2815248279e52c21c3ca2fe5c3b916e6f4379c2d4ecc"

RDEPENDS:perl-IPC-Run = " \
 perl-Carp \
 perl-Data-Dumper \
 perl-Errno \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-IO \
 perl-IO-Tty \
 perl-IPC-Run \
 perl-POSIX \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Symbol \
 perl-constant \
 perl-libs \
 perl-vars \
 "
