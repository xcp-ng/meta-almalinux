# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-evanw-esbuild"
PV = "0.27.2"
PR = "1.el10_1"
PACKAGES = " \
 golang-github-evanw-esbuild \
 golang-github-evanw-esbuild-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-evanw-esbuild-0.27.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "17b59090c6b9d9c1a593895148e9d28bca43fbc2b7f637a72cb1a15b74c14738"

URI_x86_64_v2_golang-github-evanw-esbuild = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-evanw-esbuild-0.27.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_golang-github-evanw-esbuild;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-evanw-esbuild}"
SRC_URI[x86_64_v2_golang-github-evanw-esbuild.sha256sum] = "83cb195643a79428771bf7f0c28b786550c2b2148b0be818fb131c09a7e2342d"

URI_x86_64_v2_golang-github-evanw-esbuild-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-evanw-esbuild-devel-0.27.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-evanw-esbuild-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-evanw-esbuild-devel}"
SRC_URI[x86_64_v2_golang-github-evanw-esbuild-devel.sha256sum] = "cffb8a83cde82d5c7bbfff48b484a065349375ed7eee97ec0f9ff71ecaf22e0c"

URI_aarch64_golang-github-evanw-esbuild = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-evanw-esbuild-0.27.2-1.el10_1.aarch64.rpm;name=aarch64_golang-github-evanw-esbuild;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-evanw-esbuild}"
SRC_URI[aarch64_golang-github-evanw-esbuild.sha256sum] = "1bccb5552127bd4dd75b220ed5f45d40369b180e9d9c7217b569d4d688008970"

URI_aarch64_golang-github-evanw-esbuild-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-evanw-esbuild-devel-0.27.2-1.el10_1.noarch.rpm;name=aarch64_golang-github-evanw-esbuild-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-evanw-esbuild-devel}"
SRC_URI[aarch64_golang-github-evanw-esbuild-devel.sha256sum] = "68734aa0ce1c9e97f2c175b1189e0d306994baefe0881c6d39c35a6d34560b05"

RDEPENDS:golang-github-evanw-esbuild = " \
 glibc \
 "
RDEPENDS:golang-github-evanw-esbuild-devel = " \
 go-filesystem \
 golang-x-sys-devel \
 "
