# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rpm-ostree"
PV = "2025.5"
PR = "1.el10"
PACKAGES = " \
 rpm-ostree \
 rpm-ostree-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rpm-ostree-2025.5-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d00fe192e3df48fd6b4205034c78c712c8b66bb96db7928aa98dfa0a40f734dc"

URI_x86_64_v2_rpm-ostree = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-ostree-2025.5-1.el10.x86_64_v2.rpm;name=x86_64_v2_rpm-ostree;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-ostree}"
SRC_URI[x86_64_v2_rpm-ostree.sha256sum] = "842abe8e336c9ad9ad9b5c16e2a8f0073b462f26c0b44969d90fec0e13f1fd72"

URI_x86_64_v2_rpm-ostree-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-ostree-libs-2025.5-1.el10.x86_64_v2.rpm;name=x86_64_v2_rpm-ostree-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-ostree-libs}"
SRC_URI[x86_64_v2_rpm-ostree-libs.sha256sum] = "343be06ecfd09b186c4e9c31052ca94817ea0f28404e3ca14c1de01b729cda86"

URI_aarch64_rpm-ostree = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-ostree-2025.5-1.el10.aarch64.rpm;name=aarch64_rpm-ostree;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-ostree}"
SRC_URI[aarch64_rpm-ostree.sha256sum] = "43116422cebd13bc4fdad2a0b2ed4ed3412e46ec96d220b285297d8c40024141"

URI_aarch64_rpm-ostree-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-ostree-libs-2025.5-1.el10.aarch64.rpm;name=aarch64_rpm-ostree-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-ostree-libs}"
SRC_URI[aarch64_rpm-ostree-libs.sha256sum] = "7a835869e36e4b6b1d203d1550bf39f56a5faf1a49c3a99f9d3ec85b9d443536"

RDEPENDS:rpm-ostree = " \
 bash \
 bootc \
 bubblewrap \
 fuse3 \
 glib2 \
 glibc \
 json-c \
 json-glib \
 libarchive \
 libcap \
 libgcc \
 libmodulemd \
 librepo \
 libsolv \
 libstdc++ \
 libzstd \
 openssl-libs \
 ostree \
 ostree-libs \
 polkit-libs \
 rpm-libs \
 rpm-ostree-libs \
 skopeo \
 sqlite-libs \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:rpm-ostree-libs = " \
 glib2 \
 glibc \
 json-glib \
 libgcc \
 ostree-libs \
 popt \
 rpm-libs \
 "
