# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mimetreeparser"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 mimetreeparser \
 mimetreeparser-devel \
 mimetreeparser-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mimetreeparser-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a223183db6b99fe1b3887837bed14b9b6c8daafd33d31816ae32ac3c1568db5"

URI_x86_64_v2_mimetreeparser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mimetreeparser-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mimetreeparser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mimetreeparser}"
SRC_URI[x86_64_v2_mimetreeparser.sha256sum] = "7be45000883637c3ffd942c6eec835a45a900f2a05ac93691bc3d13e14136643"

URI_x86_64_v2_mimetreeparser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mimetreeparser-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mimetreeparser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mimetreeparser-devel}"
SRC_URI[x86_64_v2_mimetreeparser-devel.sha256sum] = "21bc157748ab3ba7a9e491975eb7600cf5dbe277657722decfe6c53614af603b"

URI_x86_64_v2_mimetreeparser-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mimetreeparser-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_mimetreeparser-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mimetreeparser-doc}"
SRC_URI[x86_64_v2_mimetreeparser-doc.sha256sum] = "3193a8254d159aad1fd56dad4cad5cd5e329bd6826682b066fc3f2848cc1e2f6"

URI_aarch64_mimetreeparser = "${EPEL_MIRROR}/aarch64/Packages/m/mimetreeparser-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_mimetreeparser;unpack=0"
SRC_URI:append = " ${URI_aarch64_mimetreeparser}"
SRC_URI[aarch64_mimetreeparser.sha256sum] = "9d3989bbcb879896f0956cc3b9d9f038f10113a46ecbcc167356072cdf0f15a4"

URI_aarch64_mimetreeparser-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mimetreeparser-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_mimetreeparser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mimetreeparser-devel}"
SRC_URI[aarch64_mimetreeparser-devel.sha256sum] = "a9a04431f3d99c0b267138a6834cd08b59651fa4ae677e5911f7065e50ed3062"

URI_aarch64_mimetreeparser-doc = "${EPEL_MIRROR}/aarch64/Packages/m/mimetreeparser-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_mimetreeparser-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_mimetreeparser-doc}"
SRC_URI[aarch64_mimetreeparser-doc.sha256sum] = "2090c53204d87f47124995dcb7d0d38fec8584b490b6005e0fd4db9c0e36f8dd"

RDEPENDS:mimetreeparser = " \
 glibc \
 gpgmepp \
 kf6-kcalendarcore \
 kf6-kcolorscheme \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kmbox \
 kmime \
 libkleo \
 libstdc++ \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:mimetreeparser-devel = " \
 cmake-filesystem \
 mimetreeparser \
 "
RDEPENDS:mimetreeparser-doc = " \
 "
