# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cscope"
PV = "15.9"
PR = "31.el10"
PACKAGES = " \
 cscope \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cscope-15.9-31.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2d3c705b4331b797827c6804240be3b6fcb43c94878d6602c43a1d7690e466e1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cscope-15.9-31.el10.x86_64_v2.rpm;name=x86_64_v2_cscope;unpack=0"
SRC_URI[x86_64_v2_cscope.sha256sum] = "290864d1833fcba71b78818c6a96f6d501c2535589d7edb4320666f7434133e3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cscope-15.9-31.el10.aarch64.rpm;name=aarch64_cscope;unpack=0"
SRC_URI[aarch64_cscope.sha256sum] = "d071dabcba2b0385e18fefd83669d89df7d46146e5d8e49c7a5bed5490ccf56f"

RDEPENDS:cscope = " \
 bash \
 ed \
 emacs-filesystem \
 glibc \
 ncurses-libs \
 virtual/coreutils \
 "
