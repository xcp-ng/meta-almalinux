# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-inconshreveable-vhost"
PV = "0"
PR = "20.20190629git06d8411.el10_0"
PACKAGES = " \
 golang-github-inconshreveable-vhost-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/golang-github-inconshreveable-vhost-0-20.20190629git06d8411.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "312d37d1b47845b1d6d36848c4ea72f6364c465cf66cc7f40a4b3dafb25b994b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-github-inconshreveable-vhost-devel-0-20.20190629git06d8411.el10_0.noarch.rpm;name=aarch64_golang-github-inconshreveable-vhost-devel;unpack=0"
SRC_URI[aarch64_golang-github-inconshreveable-vhost-devel.sha256sum] = "c45ab78a1b32f67fd36ef00f0c155bdc7b5e980d64135ab96aa0a47e5b6d7b54"

RDEPENDS:golang-github-inconshreveable-vhost-devel = " \
 go-filesystem \
 "
