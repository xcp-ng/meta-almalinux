# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kate"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kate \
 kate-libs \
 kate-plugins \
 kwrite \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kate-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e1f4dfc79a7fb0ce9c3907afe8ec5ac8a03fbd73d2acd436a6e5d7a94e3c7fc1"

URI_x86_64_v2_kate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kate-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kate}"
SRC_URI[x86_64_v2_kate.sha256sum] = "341b419d4955575d3e37ff1abf01304cbd9f6f46b4948a9ef1be98ad7c45d90f"

URI_x86_64_v2_kate-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kate-libs-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kate-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kate-libs}"
SRC_URI[x86_64_v2_kate-libs.sha256sum] = "cb433bc9cf3c941bbe64333ce2715cf3c0f067a0f509ac3ed15fd625fab607cd"

URI_x86_64_v2_kate-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kate-plugins-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kate-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kate-plugins}"
SRC_URI[x86_64_v2_kate-plugins.sha256sum] = "077120fd9b94ab1a3362c1f377ea78e0ac8ed83038919cfff8709ece6c64602c"

URI_x86_64_v2_kwrite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwrite-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwrite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwrite}"
SRC_URI[x86_64_v2_kwrite.sha256sum] = "84ed55347e6dddbe81c06ec49c53d2eb2b76b1880fc75f75298ee8bf23e89db4"

URI_aarch64_kate = "${EPEL_MIRROR}/aarch64/Packages/k/kate-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kate;unpack=0"
SRC_URI:append = " ${URI_aarch64_kate}"
SRC_URI[aarch64_kate.sha256sum] = "c1081815a6f7553304699e09e3ce5e2ce326b117a569c3e4d88f9f0b5966dc82"

URI_aarch64_kate-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kate-libs-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kate-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kate-libs}"
SRC_URI[aarch64_kate-libs.sha256sum] = "ba5912c9114a38fe0b4a6ad1a68dd5432b5e483f17d7ce02ba7f7f3b300ddcd4"

URI_aarch64_kate-plugins = "${EPEL_MIRROR}/aarch64/Packages/k/kate-plugins-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kate-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_kate-plugins}"
SRC_URI[aarch64_kate-plugins.sha256sum] = "c9037b815446882db4185ccdcd62469bb3d211e92fed61dd16bd082bac5f4675"

URI_aarch64_kwrite = "${EPEL_MIRROR}/aarch64/Packages/k/kwrite-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kwrite;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwrite}"
SRC_URI[aarch64_kwrite.sha256sum] = "6238d2fb866f8fdbb4fe2680089a20661c65418a306e5788aae65a0d416406d7"

RDEPENDS:kate = " \
 glibc \
 kate-libs \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwindowsystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kate-libs = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kparts \
 kf6-kservice \
 kf6-ktexteditor \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-syntax-highlighting \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kate-plugins = " \
 bash \
 glibc \
 kate \
 kate-libs \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knewstuff \
 kf6-kparts \
 kf6-kservice \
 kf6-ktexteditor \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-syntax-highlighting \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qtkeychain-qt6 \
 "
RDEPENDS:kwrite = " \
 glibc \
 kate-libs \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
