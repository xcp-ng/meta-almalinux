# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libnbd"
PV = "1.25.6"
PR = "1.el10"
PACKAGES = " \
 libnbd \
 libnbd-bash-completion \
 libnbd-devel \
 nbdfuse \
 ocaml-libnbd \
 ocaml-libnbd-devel \
 python3-libnbd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libnbd-1.25.6-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e5f31b28ef8eca2493ac7c83b4c6572bb72862cc8b176ff58f097cd2d6481fd"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - ocaml-libnbd-devel: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libnbd-devel: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libnbd-devel: ocaml(Stdlib__Bigarray) = 8317b42277334e4ae5794d3cbabcaf4f
# - ocaml-libnbd-devel: ocaml(Stdlib__Bytes) = d5a54ebfd096c4af2a47315dda118f2d
# - ocaml-libnbd-devel: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libnbd-devel: ocaml(Stdlib__Complex) = 052959c6d02e4e692e7944dd137c4095
# - ocaml-libnbd-devel: ocaml(Stdlib__Either) = d56b2e9ca14b69fdeef09f3b2fbd10ad
# - ocaml-libnbd-devel: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libnbd-devel: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libnbd-devel: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libnbd-devel: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827
# - ocaml-libnbd-devel: ocaml(Stdlib__Seq) = ac22688c50c848ab417492a023ff76ab
# - ocaml-libnbd-devel: ocaml(Stdlib__String) = cdb3775f91c0e999766c3b2a50f03a7d
# - ocaml-libnbd-devel: ocaml(Stdlib__Uchar) = 7eb8f0d1a7c18933885eaef3b23d79f4
# - ocaml-libnbd-devel: ocaml(Unix) = 59e61ff7441dfacaa24d4eed6d45eeda
# - ocaml-libnbd-devel: ocamlx(Stdlib__Bigarray) = 2fb6f37865dd77a707635669254911e1
# - ocaml-libnbd-devel: ocamlx(Stdlib__Callback) = bafc96ea60f2aa399fe753ac0e40f764
# - ocaml-libnbd-devel: ocamlx(Stdlib__Gc) = 197914694cd716338b4da966236687f4
# - ocaml-libnbd: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libnbd: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libnbd: ocaml(Stdlib__Bigarray) = 8317b42277334e4ae5794d3cbabcaf4f
# - ocaml-libnbd: ocaml(Stdlib__Bytes) = d5a54ebfd096c4af2a47315dda118f2d
# - ocaml-libnbd: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libnbd: ocaml(Stdlib__Complex) = 052959c6d02e4e692e7944dd137c4095
# - ocaml-libnbd: ocaml(Stdlib__Either) = d56b2e9ca14b69fdeef09f3b2fbd10ad
# - ocaml-libnbd: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libnbd: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libnbd: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libnbd: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827
# - ocaml-libnbd: ocaml(Stdlib__Seq) = ac22688c50c848ab417492a023ff76ab
# - ocaml-libnbd: ocaml(Stdlib__String) = cdb3775f91c0e999766c3b2a50f03a7d
# - ocaml-libnbd: ocaml(Stdlib__Uchar) = 7eb8f0d1a7c18933885eaef3b23d79f4
# - ocaml-libnbd: ocaml(Unix) = 59e61ff7441dfacaa24d4eed6d45eeda

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - ocaml-libnbd-devel: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libnbd-devel: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libnbd-devel: ocaml(Stdlib__Bigarray) = 8317b42277334e4ae5794d3cbabcaf4f
# - ocaml-libnbd-devel: ocaml(Stdlib__Bytes) = d5a54ebfd096c4af2a47315dda118f2d
# - ocaml-libnbd-devel: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libnbd-devel: ocaml(Stdlib__Complex) = 052959c6d02e4e692e7944dd137c4095
# - ocaml-libnbd-devel: ocaml(Stdlib__Either) = d56b2e9ca14b69fdeef09f3b2fbd10ad
# - ocaml-libnbd-devel: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libnbd-devel: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libnbd-devel: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libnbd-devel: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827
# - ocaml-libnbd-devel: ocaml(Stdlib__Seq) = ac22688c50c848ab417492a023ff76ab
# - ocaml-libnbd-devel: ocaml(Stdlib__String) = cdb3775f91c0e999766c3b2a50f03a7d
# - ocaml-libnbd-devel: ocaml(Stdlib__Uchar) = 7eb8f0d1a7c18933885eaef3b23d79f4
# - ocaml-libnbd-devel: ocaml(Unix) = 59e61ff7441dfacaa24d4eed6d45eeda
# - ocaml-libnbd-devel: ocamlx(Stdlib__Bigarray) = 2fb6f37865dd77a707635669254911e1
# - ocaml-libnbd-devel: ocamlx(Stdlib__Callback) = bafc96ea60f2aa399fe753ac0e40f764
# - ocaml-libnbd-devel: ocamlx(Stdlib__Gc) = 197914694cd716338b4da966236687f4
# - ocaml-libnbd: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libnbd: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libnbd: ocaml(Stdlib__Bigarray) = 8317b42277334e4ae5794d3cbabcaf4f
# - ocaml-libnbd: ocaml(Stdlib__Bytes) = d5a54ebfd096c4af2a47315dda118f2d
# - ocaml-libnbd: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libnbd: ocaml(Stdlib__Complex) = 052959c6d02e4e692e7944dd137c4095
# - ocaml-libnbd: ocaml(Stdlib__Either) = d56b2e9ca14b69fdeef09f3b2fbd10ad
# - ocaml-libnbd: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libnbd: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libnbd: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libnbd: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827
# - ocaml-libnbd: ocaml(Stdlib__Seq) = ac22688c50c848ab417492a023ff76ab
# - ocaml-libnbd: ocaml(Stdlib__String) = cdb3775f91c0e999766c3b2a50f03a7d
# - ocaml-libnbd: ocaml(Stdlib__Uchar) = 7eb8f0d1a7c18933885eaef3b23d79f4
# - ocaml-libnbd: ocaml(Unix) = 59e61ff7441dfacaa24d4eed6d45eeda

URI_x86_64_v2_libnbd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libnbd-1.25.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_libnbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnbd}"
SRC_URI[x86_64_v2_libnbd.sha256sum] = "c6d48121cbbde2b39084cb0b2f89074966eb1616d1061dc5541236d0f6e77cc8"

URI_x86_64_v2_libnbd-bash-completion = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libnbd-bash-completion-1.25.6-1.el10.noarch.rpm;name=x86_64_v2_libnbd-bash-completion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnbd-bash-completion}"
SRC_URI[x86_64_v2_libnbd-bash-completion.sha256sum] = "60c5af1340e80dc547c6ff487a3446299815e01e959dcbf16f2a7b1b834ff2b2"

URI_x86_64_v2_libnbd-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libnbd-devel-1.25.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_libnbd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnbd-devel}"
SRC_URI[x86_64_v2_libnbd-devel.sha256sum] = "6d5ccc242dfb5826247bfcc329e31997f18f868ac8edf6b30f9479c6a5a9796d"

URI_x86_64_v2_nbdfuse = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdfuse-1.25.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_nbdfuse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdfuse}"
SRC_URI[x86_64_v2_nbdfuse.sha256sum] = "48514bee366d172cfb3d9c1a865cbbcf3f8dbddd4e00a83a35d40db14bd7248e"

URI_x86_64_v2_ocaml-libnbd = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ocaml-libnbd-1.25.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_ocaml-libnbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ocaml-libnbd}"
SRC_URI[x86_64_v2_ocaml-libnbd.sha256sum] = "cc480f992148e4184b2fcbd502c19fffc33232bbdb1c9bc935320c8d0adb8d8b"

URI_x86_64_v2_ocaml-libnbd-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ocaml-libnbd-devel-1.25.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_ocaml-libnbd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ocaml-libnbd-devel}"
SRC_URI[x86_64_v2_ocaml-libnbd-devel.sha256sum] = "f120b362c6f07d69c72255298948ae3fb8fd9e8d031866ba2775e618e4644c14"

URI_x86_64_v2_python3-libnbd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libnbd-1.25.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libnbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libnbd}"
SRC_URI[x86_64_v2_python3-libnbd.sha256sum] = "327088244b29d9ee012ab6995c2777bdc218106d8fc8e40c28b48a3ad42beae9"

URI_aarch64_libnbd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libnbd-1.25.6-1.el10.aarch64.rpm;name=aarch64_libnbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnbd}"
SRC_URI[aarch64_libnbd.sha256sum] = "53b1c3dd2dd89fa95a6740ee5b41594c5a3d085d080d283ba16ad5f2afa106c7"

URI_aarch64_libnbd-bash-completion = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libnbd-bash-completion-1.25.6-1.el10.noarch.rpm;name=aarch64_libnbd-bash-completion;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnbd-bash-completion}"
SRC_URI[aarch64_libnbd-bash-completion.sha256sum] = "60c5af1340e80dc547c6ff487a3446299815e01e959dcbf16f2a7b1b834ff2b2"

URI_aarch64_libnbd-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libnbd-devel-1.25.6-1.el10.aarch64.rpm;name=aarch64_libnbd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnbd-devel}"
SRC_URI[aarch64_libnbd-devel.sha256sum] = "b5cdf931fb2ec3e57f87fa87a28f4eec004b54401e8955b4e875279b989af3d2"

URI_aarch64_nbdfuse = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdfuse-1.25.6-1.el10.aarch64.rpm;name=aarch64_nbdfuse;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdfuse}"
SRC_URI[aarch64_nbdfuse.sha256sum] = "2c3d7d7c32263075acede153d1d961d3ce17b4a0639f8dd70460c0291eb01c8a"

URI_aarch64_ocaml-libnbd = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ocaml-libnbd-1.25.6-1.el10.aarch64.rpm;name=aarch64_ocaml-libnbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_ocaml-libnbd}"
SRC_URI[aarch64_ocaml-libnbd.sha256sum] = "49ac6c100648acb6980644415d6ec89f443abb49a1145b592a9df62a02a803ad"

URI_aarch64_ocaml-libnbd-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ocaml-libnbd-devel-1.25.6-1.el10.aarch64.rpm;name=aarch64_ocaml-libnbd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ocaml-libnbd-devel}"
SRC_URI[aarch64_ocaml-libnbd-devel.sha256sum] = "f87edec1f7c4170e49da65897d861572ba73112bfdd1ea6533437182e20aca1b"

URI_aarch64_python3-libnbd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libnbd-1.25.6-1.el10.aarch64.rpm;name=aarch64_python3-libnbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libnbd}"
SRC_URI[aarch64_python3-libnbd.sha256sum] = "7468db3422722f27687961b2637f37dd4366c43f34b2e565fac24aac11fd26ff"

RDEPENDS:libnbd = " \
 glibc \
 gnutls \
 libxml2 \
 "
RDEPENDS:libnbd-bash-completion = " \
 bash-completion \
 libnbd \
 "
RDEPENDS:libnbd-devel = " \
 libnbd \
 pkgconf-pkg-config \
 "
RDEPENDS:nbdfuse = " \
 fuse3-libs \
 glibc \
 libnbd \
 "
RDEPENDS:ocaml-libnbd = " \
 glibc \
 libnbd \
 "
RDEPENDS:ocaml-libnbd-devel = " \
 ocaml-libnbd \
 "
RDEPENDS:python3-libnbd = " \
 bash \
 glibc \
 gnutls \
 libnbd \
 libxml2 \
 python3 \
 "
