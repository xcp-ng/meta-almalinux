# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "polkit-kde"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 polkit-kde \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/polkit-kde-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0182d510e9d1d77c3553fd26947c310891a1f74abe47fa6b6798a9f1b106c6b7"

URI_x86_64_v2_polkit-kde = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/polkit-kde-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_polkit-kde;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_polkit-kde}"
SRC_URI[x86_64_v2_polkit-kde.sha256sum] = "f79e36fdb9fc7bebec732d295126f7611791e79425d912a923821f06c19f7f69"
RPROVIDES:polkit-kde:x86_64_v2 = "virtual/PolicyKit-authentication-agent"

URI_aarch64_polkit-kde = "${EPEL_MIRROR}/aarch64/Packages/p/polkit-kde-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_polkit-kde;unpack=0"
SRC_URI:append = " ${URI_aarch64_polkit-kde}"
SRC_URI[aarch64_polkit-kde.sha256sum] = "8ad382872e70324c236643b763762d59536e2959b67ff5da14cd9e60848c6e50"
RPROVIDES:polkit-kde:aarch64 = "virtual/PolicyKit-authentication-agent"

RDEPENDS:polkit-kde = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-knotifications \
 kf6-kwindowsystem \
 libstdc++ \
 polkit \
 polkit-qt6-1 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/PolicyKit-authentication-agent"

PROVIDES:append:aarch64 = " rpm/virtual/PolicyKit-authentication-agent"
