# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-multer"
PV = "3.1.0"
PR = "3.el10_0"
PACKAGES = " \
 rust-multer+all-devel \
 rust-multer+default-devel \
 rust-multer+json-devel \
 rust-multer+log-devel \
 rust-multer+serde-devel \
 rust-multer+serde_json-devel \
 rust-multer+tokio-devel \
 rust-multer+tokio-io-devel \
 rust-multer+tokio-util-devel \
 rust-multer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-multer-3.1.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b534732649f9bb9a932c1334ec1a77c2fd1b413fff1c221d6545b9e8b455f801"

URI_x86_64_v2_rust-multer+all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-multer+all-devel-3.1.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-multer+all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-multer+all-devel}"
SRC_URI[x86_64_v2_rust-multer+all-devel.sha256sum] = "8410c344e0950612f0f3566983d295ca7da6d0e0defc000163c92a6eb66a5ca1"

URI_x86_64_v2_rust-multer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-multer+default-devel-3.1.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-multer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-multer+default-devel}"
SRC_URI[x86_64_v2_rust-multer+default-devel.sha256sum] = "0e52acc984d0f687186e6959214e8709617abede6231e7ca1e8e00aa6f261e92"

URI_x86_64_v2_rust-multer+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-multer+json-devel-3.1.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-multer+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-multer+json-devel}"
SRC_URI[x86_64_v2_rust-multer+json-devel.sha256sum] = "fa25bb87b9417e312786c6ccc890a62eb13bcb511e1754c5159d02e707df7e59"

URI_x86_64_v2_rust-multer+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-multer+log-devel-3.1.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-multer+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-multer+log-devel}"
SRC_URI[x86_64_v2_rust-multer+log-devel.sha256sum] = "067450384d9d6c931c9bb80b7d265f42ca55d78cc49faa780e8c790917d0cda1"

URI_x86_64_v2_rust-multer+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-multer+serde-devel-3.1.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-multer+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-multer+serde-devel}"
SRC_URI[x86_64_v2_rust-multer+serde-devel.sha256sum] = "3fb0f2a4d6c5a83571a98a59d17f5f65bc3e42355d990a80025c6a49be0fb296"

URI_x86_64_v2_rust-multer+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-multer+serde_json-devel-3.1.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-multer+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-multer+serde_json-devel}"
SRC_URI[x86_64_v2_rust-multer+serde_json-devel.sha256sum] = "a8b126a6101b89ec80a68d95bf934f5c26c764f03031b64f4f9db2959677b680"

URI_x86_64_v2_rust-multer+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-multer+tokio-devel-3.1.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-multer+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-multer+tokio-devel}"
SRC_URI[x86_64_v2_rust-multer+tokio-devel.sha256sum] = "8c3742df676293a9e75bd71cb445dc1e5c38a5f519806688241078819f0c1fb8"

URI_x86_64_v2_rust-multer+tokio-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-multer+tokio-io-devel-3.1.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-multer+tokio-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-multer+tokio-io-devel}"
SRC_URI[x86_64_v2_rust-multer+tokio-io-devel.sha256sum] = "5734c0b8b529285e76d9b4256e959d4ea21c98e3252d459ba0fd83980395756f"

URI_x86_64_v2_rust-multer+tokio-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-multer+tokio-util-devel-3.1.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-multer+tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-multer+tokio-util-devel}"
SRC_URI[x86_64_v2_rust-multer+tokio-util-devel.sha256sum] = "58a078aa9303f4efb094cf9ad86c639b7ecee76ee0fa5daf823d6bb6d0d6b096"

URI_x86_64_v2_rust-multer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-multer-devel-3.1.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-multer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-multer-devel}"
SRC_URI[x86_64_v2_rust-multer-devel.sha256sum] = "dc72d1013a3cc237e96f12894c634f1155d53f5704bd5d64e3c19f03d7b8273a"

URI_aarch64_rust-multer+all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-multer+all-devel-3.1.0-3.el10_0.noarch.rpm;name=aarch64_rust-multer+all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-multer+all-devel}"
SRC_URI[aarch64_rust-multer+all-devel.sha256sum] = "50ef25ad05b4ae54f39842f2c33630208567d2942cd03ae39f9bd73167861154"

URI_aarch64_rust-multer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-multer+default-devel-3.1.0-3.el10_0.noarch.rpm;name=aarch64_rust-multer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-multer+default-devel}"
SRC_URI[aarch64_rust-multer+default-devel.sha256sum] = "cb19222726eb170243f533cb22ff9cd4fedcbac0c7ff001f4c9a34e5fbfc4191"

URI_aarch64_rust-multer+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-multer+json-devel-3.1.0-3.el10_0.noarch.rpm;name=aarch64_rust-multer+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-multer+json-devel}"
SRC_URI[aarch64_rust-multer+json-devel.sha256sum] = "ab62be99e0822f2fd9379d60520e7cfede32f0f512506f44d2dc271712912198"

URI_aarch64_rust-multer+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-multer+log-devel-3.1.0-3.el10_0.noarch.rpm;name=aarch64_rust-multer+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-multer+log-devel}"
SRC_URI[aarch64_rust-multer+log-devel.sha256sum] = "2f20dba81328c37e88fdd6aad730d55bae1f380328131df7bed597c3248bc530"

URI_aarch64_rust-multer+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-multer+serde-devel-3.1.0-3.el10_0.noarch.rpm;name=aarch64_rust-multer+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-multer+serde-devel}"
SRC_URI[aarch64_rust-multer+serde-devel.sha256sum] = "484876da8f6969dcbcbf3a97c6c33a170a9a51f866b3f6f52ad7c7749b4f66b4"

URI_aarch64_rust-multer+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-multer+serde_json-devel-3.1.0-3.el10_0.noarch.rpm;name=aarch64_rust-multer+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-multer+serde_json-devel}"
SRC_URI[aarch64_rust-multer+serde_json-devel.sha256sum] = "1e8925014f6c0bc5874f8c700aff7bf6c171a02e926d4f39b2c5367e7676a6b5"

URI_aarch64_rust-multer+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-multer+tokio-devel-3.1.0-3.el10_0.noarch.rpm;name=aarch64_rust-multer+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-multer+tokio-devel}"
SRC_URI[aarch64_rust-multer+tokio-devel.sha256sum] = "49d50edac2982c0ea7118e6df1fe5c995115bf9d7d0be19e4248bbdfbd657eab"

URI_aarch64_rust-multer+tokio-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-multer+tokio-io-devel-3.1.0-3.el10_0.noarch.rpm;name=aarch64_rust-multer+tokio-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-multer+tokio-io-devel}"
SRC_URI[aarch64_rust-multer+tokio-io-devel.sha256sum] = "05f8d64363febfbe3e4894b84ebf831344a8d3a66eacf24324bc724bb4447d90"

URI_aarch64_rust-multer+tokio-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-multer+tokio-util-devel-3.1.0-3.el10_0.noarch.rpm;name=aarch64_rust-multer+tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-multer+tokio-util-devel}"
SRC_URI[aarch64_rust-multer+tokio-util-devel.sha256sum] = "26d434e73aca131fec73846931c5c96768345c38abec39cb2c8c04111f7087f3"

URI_aarch64_rust-multer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-multer-devel-3.1.0-3.el10_0.noarch.rpm;name=aarch64_rust-multer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-multer-devel}"
SRC_URI[aarch64_rust-multer-devel.sha256sum] = "16bf8404ac3ebc96e2c09cd543354ea2e48ed9e2872f5479d4634260a51e5766"

RDEPENDS:rust-multer+all-devel = " \
 cargo \
 rust-multer+json-devel \
 rust-multer-devel \
 "
RDEPENDS:rust-multer+default-devel = " \
 cargo \
 rust-multer-devel \
 "
RDEPENDS:rust-multer+json-devel = " \
 cargo \
 rust-multer+serde-devel \
 rust-multer+serde_json-devel \
 rust-multer-devel \
 "
RDEPENDS:rust-multer+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-multer-devel \
 "
RDEPENDS:rust-multer+serde-devel = " \
 cargo \
 rust-multer-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-multer+serde_json-devel = " \
 cargo \
 rust-multer-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-multer+tokio-devel = " \
 cargo \
 rust-multer-devel \
 rust-tokio+default-devel \
 "
RDEPENDS:rust-multer+tokio-io-devel = " \
 cargo \
 rust-multer+tokio-devel \
 rust-multer+tokio-util-devel \
 rust-multer-devel \
 "
RDEPENDS:rust-multer+tokio-util-devel = " \
 cargo \
 rust-multer-devel \
 rust-tokio-util+default-devel \
 rust-tokio-util+io-devel \
 "
RDEPENDS:rust-multer-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-encoding_rs+default-devel \
 rust-futures-util-devel \
 rust-http+default-devel \
 rust-httparse+default-devel \
 rust-memchr+default-devel \
 rust-mime+default-devel \
 rust-spin+spin_mutex-devel \
 rust-spin-devel \
 rust-version_check+default-devel \
 "
