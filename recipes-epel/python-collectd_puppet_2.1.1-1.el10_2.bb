# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-collectd_puppet"
PV = "2.1.1"
PR = "1.el10_2"
PACKAGES = " \
 python3-collectd_puppet \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-collectd_puppet-2.1.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "31da4ec8886dce17dc0e45c8743938ac362409dd86eff962efc39f7575a30c02"

URI_x86_64_v2_python3-collectd_puppet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-collectd_puppet-2.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-collectd_puppet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-collectd_puppet}"
SRC_URI[x86_64_v2_python3-collectd_puppet.sha256sum] = "73f5fc0215409d7eac282bfd4e4b241d91facd9fd470238b2a8ce60aa924f80d"

URI_aarch64_python3-collectd_puppet = "${EPEL_MIRROR}/aarch64/Packages/p/python3-collectd_puppet-2.1.1-1.el10_2.noarch.rpm;name=aarch64_python3-collectd_puppet;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-collectd_puppet}"
SRC_URI[aarch64_python3-collectd_puppet.sha256sum] = "8dd00fbd8fbe2a9cb66954f43f17cb35ccaef3e2845c368b1411e76033a08987"

RDEPENDS:python3-collectd_puppet = " \
 python3 \
 python3-pyyaml \
 "
