# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kopeninghours"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kopeninghours \
 kopeninghours-devel \
 kopeninghours-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kopeninghours-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2219af46093a7023bb7dde9b8d13b5b577555252b423043a6a480255cf6d981"

URI_x86_64_v2_kopeninghours = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kopeninghours-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kopeninghours;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kopeninghours}"
SRC_URI[x86_64_v2_kopeninghours.sha256sum] = "ac4aeb7239175ee36e5822e344c2fc66b87fe0884251d395d4b2ae3598bb3841"

URI_x86_64_v2_kopeninghours-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kopeninghours-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kopeninghours-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kopeninghours-devel}"
SRC_URI[x86_64_v2_kopeninghours-devel.sha256sum] = "89c5f0ceafcb8c2a5eda3882f930b9ef2833136b2cd081c86f902cb3af50960c"

URI_x86_64_v2_kopeninghours-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kopeninghours-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kopeninghours-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kopeninghours-doc}"
SRC_URI[x86_64_v2_kopeninghours-doc.sha256sum] = "036506ab7a5dbcfcaace64c73bd4771fa177618dea67f967b444e7d3303d28bf"

URI_aarch64_kopeninghours = "${EPEL_MIRROR}/aarch64/Packages/k/kopeninghours-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kopeninghours;unpack=0"
SRC_URI:append = " ${URI_aarch64_kopeninghours}"
SRC_URI[aarch64_kopeninghours.sha256sum] = "ac8009e0fb6ec9602a62a010ac05794e859f1bf96f900242e1f1e59f5b1f75ea"

URI_aarch64_kopeninghours-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kopeninghours-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kopeninghours-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kopeninghours-devel}"
SRC_URI[aarch64_kopeninghours-devel.sha256sum] = "b54bcc1f85a0677ca50a7c03cda24ae20c58a06f3b0f37491672fd316ca14484"

URI_aarch64_kopeninghours-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kopeninghours-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_kopeninghours-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kopeninghours-doc}"
SRC_URI[aarch64_kopeninghours-doc.sha256sum] = "eb5294f1dd744971358e0ffba72fea4459104436ce4541d4dd552e072e159a1c"

RDEPENDS:kopeninghours = " \
 boost-python3 \
 glibc \
 kf6-filesystem \
 kf6-kholidays \
 kf6-ki18n \
 libgcc \
 libstdc++ \
 python3 \
 python3-libs \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kopeninghours-devel = " \
 cmake-filesystem \
 kopeninghours \
 "
RDEPENDS:kopeninghours-doc = " \
 "
