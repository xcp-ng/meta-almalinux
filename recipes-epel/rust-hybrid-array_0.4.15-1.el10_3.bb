# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hybrid-array"
PV = "0.4.15"
PR = "1.el10_3"
PACKAGES = " \
 rust-hybrid-array+alloc-devel \
 rust-hybrid-array+arbitrary-devel \
 rust-hybrid-array+bytemuck-devel \
 rust-hybrid-array+ctutils-devel \
 rust-hybrid-array+default-devel \
 rust-hybrid-array+extra-sizes-devel \
 rust-hybrid-array+serde-devel \
 rust-hybrid-array+subtle-devel \
 rust-hybrid-array+zerocopy-devel \
 rust-hybrid-array+zeroize-devel \
 rust-hybrid-array-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-hybrid-array-0.4.15-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8457e0cf58fa991991913865760632e4a731c3d7689ceda5aba2f2f9f878000b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hybrid-array+alloc-devel-0.4.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hybrid-array+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hybrid-array+alloc-devel.sha256sum] = "bc2ee049afcb44d6f0f0f96da5cbe274b78c69124fa97f5b3cbd81bfc0e691ff"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hybrid-array+arbitrary-devel-0.4.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hybrid-array+arbitrary-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hybrid-array+arbitrary-devel.sha256sum] = "65acb574ecf42e0fc24fb42cbc5da83e60f695c1c4062d76e65dfce42068d2ee"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hybrid-array+bytemuck-devel-0.4.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hybrid-array+bytemuck-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hybrid-array+bytemuck-devel.sha256sum] = "3a5f6b0495a7b0205f5e3eac8a297fb6b067d9e2083f8dfa5454213cc9a991e3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hybrid-array+ctutils-devel-0.4.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hybrid-array+ctutils-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hybrid-array+ctutils-devel.sha256sum] = "ec96dd5ba4e7e48f78f9bb8320a0c1938e4b0fa87c07fbe135e05eb756621c05"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hybrid-array+default-devel-0.4.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hybrid-array+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hybrid-array+default-devel.sha256sum] = "de6d27680ac03c04a3ed487380ee70b7480dd850648cb1d536c6eb930811e0b8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hybrid-array+extra-sizes-devel-0.4.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hybrid-array+extra-sizes-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hybrid-array+extra-sizes-devel.sha256sum] = "221d436cb1ae1133741ca613580c00af191b5836d46754faf24f7e7d11b02c56"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hybrid-array+serde-devel-0.4.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hybrid-array+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hybrid-array+serde-devel.sha256sum] = "89dd74e94f3b16c1cefcf6ca2caba87a1085c4eb8c58e260f1da39cab601e2ac"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hybrid-array+subtle-devel-0.4.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hybrid-array+subtle-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hybrid-array+subtle-devel.sha256sum] = "a9aaab14473e88e35d8778de784e70d5b17f16ec51b03f3cc648e7afdb1a4efb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hybrid-array+zerocopy-devel-0.4.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hybrid-array+zerocopy-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hybrid-array+zerocopy-devel.sha256sum] = "ea7c405e70beb6074441872b85cdb220fc1bf9081266c18e8542ac29efcc53fc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hybrid-array+zeroize-devel-0.4.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hybrid-array+zeroize-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hybrid-array+zeroize-devel.sha256sum] = "3e36c7a31c9eb2919f6765b83fdbf9531eff89faa63d62eccce61259a0a02ca6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hybrid-array-devel-0.4.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hybrid-array-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hybrid-array-devel.sha256sum] = "bda797006c3656cf3ea465fc760bb910ea2a5f7c8157af82f7525d4e9728b1fa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hybrid-array+alloc-devel-0.4.15-1.el10_3.noarch.rpm;name=aarch64_rust-hybrid-array+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-hybrid-array+alloc-devel.sha256sum] = "4c057f8610ebcdcb0fce129f994d0020582719e3e07e7a2ddcebc86af31d94a5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hybrid-array+arbitrary-devel-0.4.15-1.el10_3.noarch.rpm;name=aarch64_rust-hybrid-array+arbitrary-devel;unpack=0"
SRC_URI[aarch64_rust-hybrid-array+arbitrary-devel.sha256sum] = "87feee2dd3a26ebd0055bfaea51e89e57f7bcf31861faa041436ffaf0939ede5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hybrid-array+bytemuck-devel-0.4.15-1.el10_3.noarch.rpm;name=aarch64_rust-hybrid-array+bytemuck-devel;unpack=0"
SRC_URI[aarch64_rust-hybrid-array+bytemuck-devel.sha256sum] = "1a7edbcaac01f2666896da161e3ad3f9861755ef8183538f24291b4d8ea1f1c3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hybrid-array+ctutils-devel-0.4.15-1.el10_3.noarch.rpm;name=aarch64_rust-hybrid-array+ctutils-devel;unpack=0"
SRC_URI[aarch64_rust-hybrid-array+ctutils-devel.sha256sum] = "a78bc275873b0543bb8b9866616c3351e808b8e596046d4aee5769565862c9be"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hybrid-array+default-devel-0.4.15-1.el10_3.noarch.rpm;name=aarch64_rust-hybrid-array+default-devel;unpack=0"
SRC_URI[aarch64_rust-hybrid-array+default-devel.sha256sum] = "04256ecef0d01876f92f45076a132c5ead5ef22a6150575bd03a9ac7763da469"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hybrid-array+extra-sizes-devel-0.4.15-1.el10_3.noarch.rpm;name=aarch64_rust-hybrid-array+extra-sizes-devel;unpack=0"
SRC_URI[aarch64_rust-hybrid-array+extra-sizes-devel.sha256sum] = "1291df9253db2ac9b93b7473684f4f922396ddf4a707d2cd511ef21e83362134"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hybrid-array+serde-devel-0.4.15-1.el10_3.noarch.rpm;name=aarch64_rust-hybrid-array+serde-devel;unpack=0"
SRC_URI[aarch64_rust-hybrid-array+serde-devel.sha256sum] = "10d34926bf9e825e51e6dc84fdc7def38a14ccdc08f02db6ce578faa496222e4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hybrid-array+subtle-devel-0.4.15-1.el10_3.noarch.rpm;name=aarch64_rust-hybrid-array+subtle-devel;unpack=0"
SRC_URI[aarch64_rust-hybrid-array+subtle-devel.sha256sum] = "776ab2741f8db1960efb0e720e9f616d054305e52d3a7c488c37d07d489e375f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hybrid-array+zerocopy-devel-0.4.15-1.el10_3.noarch.rpm;name=aarch64_rust-hybrid-array+zerocopy-devel;unpack=0"
SRC_URI[aarch64_rust-hybrid-array+zerocopy-devel.sha256sum] = "51c0b61bfc5efdab09e21cca9253682d7e5dece98c67a96da08a97b89499525d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hybrid-array+zeroize-devel-0.4.15-1.el10_3.noarch.rpm;name=aarch64_rust-hybrid-array+zeroize-devel;unpack=0"
SRC_URI[aarch64_rust-hybrid-array+zeroize-devel.sha256sum] = "9fecc7c2c2820072d928e3993c95031ccb539ab1bea4007b4be3533d1774eca5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hybrid-array-devel-0.4.15-1.el10_3.noarch.rpm;name=aarch64_rust-hybrid-array-devel;unpack=0"
SRC_URI[aarch64_rust-hybrid-array-devel.sha256sum] = "3ed1a29887a351c9052dc99668be1715c45029ae6df81f7964bdca9e649c4ad8"

RDEPENDS:rust-hybrid-array+alloc-devel = " \
 cargo \
 rust-hybrid-array-devel \
 "
RDEPENDS:rust-hybrid-array+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-hybrid-array-devel \
 "
RDEPENDS:rust-hybrid-array+bytemuck-devel = " \
 cargo \
 rust-bytemuck-devel \
 rust-hybrid-array-devel \
 "
RDEPENDS:rust-hybrid-array+ctutils-devel = " \
 cargo \
 rust-ctutils+default-devel \
 rust-hybrid-array-devel \
 "
RDEPENDS:rust-hybrid-array+default-devel = " \
 cargo \
 rust-hybrid-array-devel \
 "
RDEPENDS:rust-hybrid-array+extra-sizes-devel = " \
 cargo \
 rust-hybrid-array-devel \
 "
RDEPENDS:rust-hybrid-array+serde-devel = " \
 cargo \
 rust-hybrid-array-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-hybrid-array+subtle-devel = " \
 cargo \
 rust-hybrid-array-devel \
 rust-subtle+const-generics-devel \
 rust-subtle-devel \
 "
RDEPENDS:rust-hybrid-array+zerocopy-devel = " \
 cargo \
 rust-hybrid-array-devel \
 rust-zerocopy+default-devel \
 rust-zerocopy+derive-devel \
 "
RDEPENDS:rust-hybrid-array+zeroize-devel = " \
 cargo \
 rust-hybrid-array-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-hybrid-array-devel = " \
 cargo \
 rust \
 rust-typenum+const-generics-devel \
 rust-typenum+default-devel \
 "
