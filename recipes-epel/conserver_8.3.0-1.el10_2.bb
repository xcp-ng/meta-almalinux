# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "conserver"
PV = "8.3.0"
PR = "1.el10_2"
PACKAGES = " \
 conserver \
 conserver-client \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/conserver-8.3.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3a2d61ce94ddd8949d0ce6786db0901499f6964d187b337e82f1725154aee3cd"

URI_x86_64_v2_conserver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/conserver-8.3.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_conserver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_conserver}"
SRC_URI[x86_64_v2_conserver.sha256sum] = "958cc2f0ce62f4272685b39dc835d19d0b51bca5c077a1823d344ee0d67addc6"

URI_x86_64_v2_conserver-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/conserver-client-8.3.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_conserver-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_conserver-client}"
SRC_URI[x86_64_v2_conserver-client.sha256sum] = "971359543d872924d4f3c1a1c3aa02fde80bf178161e5b82e63de6551d76dbe8"

URI_aarch64_conserver = "${EPEL_MIRROR}/aarch64/Packages/c/conserver-8.3.0-1.el10_2.aarch64.rpm;name=aarch64_conserver;unpack=0"
SRC_URI:append = " ${URI_aarch64_conserver}"
SRC_URI[aarch64_conserver.sha256sum] = "884cbb00e0a347ba2c36abe6661cb8cf8e93bbc21336a4594cfdaf7005f3ae2a"

URI_aarch64_conserver-client = "${EPEL_MIRROR}/aarch64/Packages/c/conserver-client-8.3.0-1.el10_2.aarch64.rpm;name=aarch64_conserver-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_conserver-client}"
SRC_URI[aarch64_conserver-client.sha256sum] = "bf6321c480d876b5d4119376d848234116b3e5161c85f96ad3f399b6e2c8b562"

RDEPENDS:conserver = " \
 bash \
 freeipmi \
 glibc \
 krb5-libs \
 libxcrypt \
 openssl-libs \
 pam-libs \
 "
RDEPENDS:conserver-client = " \
 glibc \
 krb5-libs \
 openssl-libs \
 "
