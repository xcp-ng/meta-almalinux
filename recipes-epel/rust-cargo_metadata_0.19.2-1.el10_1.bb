# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo_metadata"
PV = "0.19.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-cargo_metadata+builder-devel \
 rust-cargo_metadata+default-devel \
 rust-cargo_metadata+derive_builder-devel \
 rust-cargo_metadata+unstable-devel \
 rust-cargo_metadata-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo_metadata-0.19.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1abee19869256365b4c7da9ad21b210745c172402ff224da35735d91ac6f9921"

URI_x86_64_v2_rust-cargo_metadata+builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata+builder-devel-0.19.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata+builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata+builder-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata+builder-devel.sha256sum] = "134ed2bbbdb60d2acc8ceff0c34d0b2cb9904b103d90b1dfbb7e8a1f1c74b64b"

URI_x86_64_v2_rust-cargo_metadata+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata+default-devel-0.19.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata+default-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata+default-devel.sha256sum] = "2b21d1b578a12373353a830b405a5feffa62a6c03dd9d6e13e786e7b5141cc1d"

URI_x86_64_v2_rust-cargo_metadata+derive_builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata+derive_builder-devel-0.19.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata+derive_builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata+derive_builder-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata+derive_builder-devel.sha256sum] = "3ee4d24a3b808da9c66f15aa16e1dc310b4c37e6be8565dc15861a0c1ae3bf17"

URI_x86_64_v2_rust-cargo_metadata+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata+unstable-devel-0.19.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata+unstable-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata+unstable-devel.sha256sum] = "f67f708e25f0c3a7e17734ca6771a6f5d77d540b26c7aebecf6a52d14c5aa869"

URI_x86_64_v2_rust-cargo_metadata-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata-devel-0.19.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata-devel.sha256sum] = "c8c7215763fe89847dab2bb64707a7d7294ff57e3c9b2ea9cd19838c243c8a25"

URI_aarch64_rust-cargo_metadata+builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata+builder-devel-0.19.2-1.el10_1.noarch.rpm;name=aarch64_rust-cargo_metadata+builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata+builder-devel}"
SRC_URI[aarch64_rust-cargo_metadata+builder-devel.sha256sum] = "da48a1fcf9e6fd7749d576022ea94539c8471cdc54c37aac77724d6655db7d8b"

URI_aarch64_rust-cargo_metadata+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata+default-devel-0.19.2-1.el10_1.noarch.rpm;name=aarch64_rust-cargo_metadata+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata+default-devel}"
SRC_URI[aarch64_rust-cargo_metadata+default-devel.sha256sum] = "ab38e11309642de6e40bfb2f65e27c3be125a303d57e11f24ac288653ae4a603"

URI_aarch64_rust-cargo_metadata+derive_builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata+derive_builder-devel-0.19.2-1.el10_1.noarch.rpm;name=aarch64_rust-cargo_metadata+derive_builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata+derive_builder-devel}"
SRC_URI[aarch64_rust-cargo_metadata+derive_builder-devel.sha256sum] = "33186c4c6f710d4e6105a6bdaf0fe8dc420bbc0132e65ac885c27986bb91e043"

URI_aarch64_rust-cargo_metadata+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata+unstable-devel-0.19.2-1.el10_1.noarch.rpm;name=aarch64_rust-cargo_metadata+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata+unstable-devel}"
SRC_URI[aarch64_rust-cargo_metadata+unstable-devel.sha256sum] = "0305187b71bc37d61388ffe2833dd6b46795fc262db95c2a89cb704c93feaa09"

URI_aarch64_rust-cargo_metadata-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata-devel-0.19.2-1.el10_1.noarch.rpm;name=aarch64_rust-cargo_metadata-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata-devel}"
SRC_URI[aarch64_rust-cargo_metadata-devel.sha256sum] = "5c854733520b4833169b4ab4266b064c5865d5221be298d6601f1e813e244f75"

RDEPENDS:rust-cargo_metadata+builder-devel = " \
 cargo \
 rust-cargo_metadata+derive_builder-devel \
 rust-cargo_metadata-devel \
 "
RDEPENDS:rust-cargo_metadata+default-devel = " \
 cargo \
 rust-cargo_metadata-devel \
 "
RDEPENDS:rust-cargo_metadata+derive_builder-devel = " \
 cargo \
 rust-cargo_metadata-devel \
 rust-derive_builder+default-devel \
 "
RDEPENDS:rust-cargo_metadata+unstable-devel = " \
 cargo \
 rust-cargo_metadata-devel \
 "
RDEPENDS:rust-cargo_metadata-devel = " \
 cargo \
 rust \
 rust-camino+default-devel \
 rust-camino+serde1-devel \
 rust-cargo-platform0.1+default-devel \
 rust-semver+default-devel \
 rust-semver+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-serde_json+unbounded_depth-devel \
 rust-thiserror+default-devel \
 "
