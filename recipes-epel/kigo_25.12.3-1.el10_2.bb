# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kigo"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kigo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kigo-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2982a218323f2238aca6573791b6de088e77658324fe6f9f3018bfa4d5effcc4"

URI_x86_64_v2_kigo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kigo-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kigo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kigo}"
SRC_URI[x86_64_v2_kigo.sha256sum] = "6eaff8e1deac1db121fe90239ac4c3b8b4f9de3d2896d66356434ec4dbf44087"

URI_aarch64_kigo = "${EPEL_MIRROR}/aarch64/Packages/k/kigo-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kigo;unpack=0"
SRC_URI:append = " ${URI_aarch64_kigo}"
SRC_URI[aarch64_kigo.sha256sum] = "e7d7b0fbf3e072f29177a774f53e41b9283b4531a90456aa76952b865d5adfcd"

RDEPENDS:kigo = " \
 glibc \
 gnugo \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-widgets-libs \
 kf6-knewstuff \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
