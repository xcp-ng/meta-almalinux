# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "swig"
PV = "4.3.0"
PR = "4.el10"
PACKAGES = " \
 swig \
 swig-doc \
 swig-gdb \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/swig-4.3.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6bd42c3043d916cfb21e525cbe67af31de9cb786ec2ae8dae7eab5fb5fc2f259"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/swig-4.3.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_swig;unpack=0"
SRC_URI[x86_64_v2_swig.sha256sum] = "5f0d388417c6736e58ce5ebe8c7e550ba06669467947414a3ad1704c1c8e821a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/swig-doc-4.3.0-4.el10.noarch.rpm;name=x86_64_v2_swig-doc;unpack=0"
SRC_URI[x86_64_v2_swig-doc.sha256sum] = "d291f30869d424efac9446388afa09948727413418655dbf6d5a7692e3901abe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/swig-gdb-4.3.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_swig-gdb;unpack=0"
SRC_URI[x86_64_v2_swig-gdb.sha256sum] = "1ab8723f87405063c02177b210a30602d5be7734e8db8d87279107654e69f4d1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/swig-4.3.0-4.el10.aarch64.rpm;name=aarch64_swig;unpack=0"
SRC_URI[aarch64_swig.sha256sum] = "7f0d966e2cc4f75149db449ec2b9e1a9c2ce2b6bb364b939c5c77de7a4fddbd3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/swig-doc-4.3.0-4.el10.noarch.rpm;name=aarch64_swig-doc;unpack=0"
SRC_URI[aarch64_swig-doc.sha256sum] = "d291f30869d424efac9446388afa09948727413418655dbf6d5a7692e3901abe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/swig-gdb-4.3.0-4.el10.aarch64.rpm;name=aarch64_swig-gdb;unpack=0"
SRC_URI[aarch64_swig-gdb.sha256sum] = "28a0e904f33775639162600ee62ee634940bbe4770269935cf66aeed06b5e7d3"

RDEPENDS:swig = " \
 glibc \
 libgcc \
 libstdc++ \
 pcre2 \
 "
RDEPENDS:swig-doc = " \
 "
RDEPENDS:swig-gdb = " \
 swig \
 "
