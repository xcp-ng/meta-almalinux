# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-xmldiff"
PV = "3.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-xmldiff \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-xmldiff-3.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a620436377fec92571b527315201fb5861d1e68de70f820033dcb6926d242fa3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-xmldiff-3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-xmldiff;unpack=0"
SRC_URI[x86_64_v2_python3-xmldiff.sha256sum] = "7b57d3e94a93a463df753501fa92e328263c78f033c8015a0e43e9b75bdac367"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-xmldiff-3.0-1.el10_3.noarch.rpm;name=aarch64_python3-xmldiff;unpack=0"
SRC_URI[aarch64_python3-xmldiff.sha256sum] = "84e218ecd6bd06744e14066ed1372478e3e8614163a68581844cf2a492b00a44"

RDEPENDS:python3-xmldiff = " \
 python3 \
 python3-lxml \
 "
