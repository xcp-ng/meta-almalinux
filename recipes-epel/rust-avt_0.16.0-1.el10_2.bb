# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-avt"
PV = "0.16.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-avt+default-devel \
 rust-avt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-avt-0.16.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5c16c36beb6c8aea3b2dbf37045d053cd7370a32de3472d9618250dc28b3b94c"

URI_x86_64_v2_rust-avt+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-avt+default-devel-0.16.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-avt+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-avt+default-devel}"
SRC_URI[x86_64_v2_rust-avt+default-devel.sha256sum] = "b7b740b9ce50e4857e8d48ac0f7061ec2a66f9d38c737dec0e0b921d74d0509b"

URI_x86_64_v2_rust-avt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-avt-devel-0.16.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-avt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-avt-devel}"
SRC_URI[x86_64_v2_rust-avt-devel.sha256sum] = "6489e25f3e00a5bd9600975775580d31a0a09d5425c51115c891a0eef48bbb55"

URI_aarch64_rust-avt+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-avt+default-devel-0.16.0-1.el10_2.noarch.rpm;name=aarch64_rust-avt+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-avt+default-devel}"
SRC_URI[aarch64_rust-avt+default-devel.sha256sum] = "dbccfb3be2355f4d5e0555c480a3f634a567cf5e4f8e00c2f0e7d4b24d7e4205"

URI_aarch64_rust-avt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-avt-devel-0.16.0-1.el10_2.noarch.rpm;name=aarch64_rust-avt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-avt-devel}"
SRC_URI[aarch64_rust-avt-devel.sha256sum] = "b8b3396673bf7a593cb99747e2ba8723accd32519e3c51cdbc555753a2b16778"

RDEPENDS:rust-avt+default-devel = " \
 cargo \
 rust-avt-devel \
 "
RDEPENDS:rust-avt-devel = " \
 cargo \
 rust \
 rust-rgb+default-devel \
 rust-unicode-width0.1+default-devel \
 "
