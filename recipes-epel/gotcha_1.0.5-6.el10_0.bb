# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gotcha"
PV = "1.0.5"
PR = "6.el10_0"
PACKAGES = " \
 gotcha \
 gotcha-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gotcha-1.0.5-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "afac0dcc32a8fd04d627de2da438dea27dfac5be65c6be40c85eab0c2ccf7392"

URI_x86_64_v2_gotcha = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gotcha-1.0.5-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gotcha;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gotcha}"
SRC_URI[x86_64_v2_gotcha.sha256sum] = "6efa8edc2869732d07f103bc9d7fd55faa97724808320aef123f54cb1a2754f0"

URI_x86_64_v2_gotcha-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gotcha-devel-1.0.5-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gotcha-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gotcha-devel}"
SRC_URI[x86_64_v2_gotcha-devel.sha256sum] = "264f5444b6d00b737bed50978a54645403362af107e70d0b30d034e7d4d3fb2b"

URI_aarch64_gotcha = "${EPEL_MIRROR}/aarch64/Packages/g/gotcha-1.0.5-6.el10_0.aarch64.rpm;name=aarch64_gotcha;unpack=0"
SRC_URI:append = " ${URI_aarch64_gotcha}"
SRC_URI[aarch64_gotcha.sha256sum] = "d244cc56aff45ece380310c8be7b3d334439a19f93ff8eb7a6f6aea0b9b6f5ea"

URI_aarch64_gotcha-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gotcha-devel-1.0.5-6.el10_0.aarch64.rpm;name=aarch64_gotcha-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gotcha-devel}"
SRC_URI[aarch64_gotcha-devel.sha256sum] = "787ad154d82728e21e840449ebf63b4f06dcb19b78c3b9d4ff0277bc051b88be"

RDEPENDS:gotcha = " \
 glibc \
 "
RDEPENDS:gotcha-devel = " \
 cmake-filesystem \
 gotcha \
 "
