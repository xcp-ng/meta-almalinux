# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bytes"
PV = "1.10.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-bytes+default-devel \
 rust-bytes+extra-platforms-devel \
 rust-bytes+serde-devel \
 rust-bytes+std-devel \
 rust-bytes-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bytes-1.10.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "244ccaadd1df422e2db160cdacd4e7086b59d013fe2b0fc93b38eb6038baa23c"

URI_x86_64_v2_rust-bytes+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytes+default-devel-1.10.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytes+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytes+default-devel}"
SRC_URI[x86_64_v2_rust-bytes+default-devel.sha256sum] = "8a4dbb8781260b7f46f8ea5b40aeb4f14b08c8b5d4c0c6099e3ba3185028992d"

URI_x86_64_v2_rust-bytes+extra-platforms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytes+extra-platforms-devel-1.10.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytes+extra-platforms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytes+extra-platforms-devel}"
SRC_URI[x86_64_v2_rust-bytes+extra-platforms-devel.sha256sum] = "3b6bebe0dfe80352b1b0748ab099b892cfadc4c43c7fd2ec7e32605d5dfbb0e6"

URI_x86_64_v2_rust-bytes+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytes+serde-devel-1.10.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytes+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytes+serde-devel}"
SRC_URI[x86_64_v2_rust-bytes+serde-devel.sha256sum] = "cda037ff36de70943665ecf0b5d973046ad92a4e16a963cac398abc94e6ef7dc"

URI_x86_64_v2_rust-bytes+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytes+std-devel-1.10.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytes+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytes+std-devel}"
SRC_URI[x86_64_v2_rust-bytes+std-devel.sha256sum] = "f0a936444d5b4bd29e1c2a15f7667c91f3c222f22063b9d5c52902d40a538037"

URI_x86_64_v2_rust-bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytes-devel-1.10.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytes-devel}"
SRC_URI[x86_64_v2_rust-bytes-devel.sha256sum] = "e10f711db59f1cd2029093758e0c32cb2542f82d12faa96c701b32a438f229a2"

URI_aarch64_rust-bytes+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytes+default-devel-1.10.1-1.el10_0.noarch.rpm;name=aarch64_rust-bytes+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytes+default-devel}"
SRC_URI[aarch64_rust-bytes+default-devel.sha256sum] = "042922aee270399884b5cc4798eaaf79ed341fbc64a33614ab9872849d5a54be"

URI_aarch64_rust-bytes+extra-platforms-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytes+extra-platforms-devel-1.10.1-1.el10_0.noarch.rpm;name=aarch64_rust-bytes+extra-platforms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytes+extra-platforms-devel}"
SRC_URI[aarch64_rust-bytes+extra-platforms-devel.sha256sum] = "e2909870f126007532897bbe0c1c8bea358cf2ee0233b9298ed67e8c31a4cda8"

URI_aarch64_rust-bytes+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytes+serde-devel-1.10.1-1.el10_0.noarch.rpm;name=aarch64_rust-bytes+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytes+serde-devel}"
SRC_URI[aarch64_rust-bytes+serde-devel.sha256sum] = "475591c6f9698c59c41881dd4bee4fb399e4528549511cbdbabeb34db5e80b1f"

URI_aarch64_rust-bytes+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytes+std-devel-1.10.1-1.el10_0.noarch.rpm;name=aarch64_rust-bytes+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytes+std-devel}"
SRC_URI[aarch64_rust-bytes+std-devel.sha256sum] = "9e47ceff1430730c312cdeee9eedc57395a8af050d8b04ce66bda1d73ffd7d16"

URI_aarch64_rust-bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytes-devel-1.10.1-1.el10_0.noarch.rpm;name=aarch64_rust-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytes-devel}"
SRC_URI[aarch64_rust-bytes-devel.sha256sum] = "94a4a237185c62e0934cef9b0603713b889c37d62dbb031ccc2c66fb6596c018"

RDEPENDS:rust-bytes+default-devel = " \
 cargo \
 rust-bytes+std-devel \
 rust-bytes-devel \
 "
RDEPENDS:rust-bytes+extra-platforms-devel = " \
 cargo \
 rust-bytes-devel \
 rust-portable-atomic+require-cas-devel \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-bytes+serde-devel = " \
 cargo \
 rust-bytes-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-bytes+std-devel = " \
 cargo \
 rust-bytes-devel \
 "
RDEPENDS:rust-bytes-devel = " \
 bash \
 cargo \
 rust \
 "
