# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gcovr"
PV = "8.2"
PR = "3.el10_1"
PACKAGES = " \
 gcovr \
 gcovr-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gcovr-8.2-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b711e88fcbbe91aaa30e6ecab1d010a2416c4fbfd739ad675c19b7b5af6bac9"

URI_x86_64_v2_gcovr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcovr-8.2-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_gcovr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcovr}"
SRC_URI[x86_64_v2_gcovr.sha256sum] = "319535464a7fa2c6e083d76d80d310b68cb43b21260e5f1f25f28c7b16d8eca8"

URI_x86_64_v2_gcovr-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcovr-doc-8.2-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_gcovr-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcovr-doc}"
SRC_URI[x86_64_v2_gcovr-doc.sha256sum] = "27c41c2fc9902b0e8643667cf2983ae1ecc75e28382e4c5438f5e5ca71ad6685"

URI_aarch64_gcovr = "${EPEL_MIRROR}/aarch64/Packages/g/gcovr-8.2-3.el10_1.noarch.rpm;name=aarch64_gcovr;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcovr}"
SRC_URI[aarch64_gcovr.sha256sum] = "15415159ec3fbd83d9745075ec4a6bd141a2e5a04521eeced56d8629cdea751c"

URI_aarch64_gcovr-doc = "${EPEL_MIRROR}/aarch64/Packages/g/gcovr-doc-8.2-3.el10_1.noarch.rpm;name=aarch64_gcovr-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcovr-doc}"
SRC_URI[aarch64_gcovr-doc.sha256sum] = "83213719369396b33b0e0d5a49a86355ab17eaa6eeb1fc4ecc72a28d23e1ee36"

RDEPENDS:gcovr = " \
 gcc \
 python3 \
 python3-colorlog \
 python3-jinja2 \
 python3-lxml \
 python3-pygments \
 "
RDEPENDS:gcovr-doc = " \
 "
