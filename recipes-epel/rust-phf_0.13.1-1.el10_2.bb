# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-phf"
PV = "0.13.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-phf+default-devel \
 rust-phf+macros-devel \
 rust-phf+phf_macros-devel \
 rust-phf+serde-devel \
 rust-phf+std-devel \
 rust-phf+uncased-devel \
 rust-phf+unicase-devel \
 rust-phf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-phf-0.13.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78d0526f43676ddaabbcb2e170fb0f1b36d671cc55eda4c373e2db6ad14ffad2"

URI_x86_64_v2_rust-phf+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf+default-devel-0.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf+default-devel}"
SRC_URI[x86_64_v2_rust-phf+default-devel.sha256sum] = "07d118983e3a9ab70fb82dfd831f78d87ad75cd9a1a2e75a8bb5fae979738e13"

URI_x86_64_v2_rust-phf+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf+macros-devel-0.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf+macros-devel}"
SRC_URI[x86_64_v2_rust-phf+macros-devel.sha256sum] = "e3ec04201fe2f4d227fe524371ed0ea3e6e375988ccb24aa61891d550bba2668"

URI_x86_64_v2_rust-phf+phf_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf+phf_macros-devel-0.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf+phf_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf+phf_macros-devel}"
SRC_URI[x86_64_v2_rust-phf+phf_macros-devel.sha256sum] = "5a9472e477d8945425359ad2a6253b2d54bcdcb70980dc94d4a126ff9e9f8b25"

URI_x86_64_v2_rust-phf+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf+serde-devel-0.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf+serde-devel}"
SRC_URI[x86_64_v2_rust-phf+serde-devel.sha256sum] = "9469bb9cd4e18b262b3c93d0a7c15ea5caa3e5e8f50efc115256c8817151d5d5"

URI_x86_64_v2_rust-phf+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf+std-devel-0.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf+std-devel}"
SRC_URI[x86_64_v2_rust-phf+std-devel.sha256sum] = "697f94bffbf852f6f87c2d20160037fc99aad47994cff22be0c1e9d8e8ec5eb5"

URI_x86_64_v2_rust-phf+uncased-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf+uncased-devel-0.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf+uncased-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf+uncased-devel}"
SRC_URI[x86_64_v2_rust-phf+uncased-devel.sha256sum] = "2ad49c536111e1f06cfe1cef55d69706b3e36683b4ed42f3b0b0ae58bda6e89d"

URI_x86_64_v2_rust-phf+unicase-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf+unicase-devel-0.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf+unicase-devel}"
SRC_URI[x86_64_v2_rust-phf+unicase-devel.sha256sum] = "45ef89a07500f4c403eb18b3ccfca4ca0a5dabbe4353e9a97a8fb374bf8790a0"

URI_x86_64_v2_rust-phf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf-devel-0.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf-devel}"
SRC_URI[x86_64_v2_rust-phf-devel.sha256sum] = "06c81d9a9b79bc1a228a2fb0734c18d16d5c83218982a838f8e5ff23f9338e68"

URI_aarch64_rust-phf+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf+default-devel-0.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-phf+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf+default-devel}"
SRC_URI[aarch64_rust-phf+default-devel.sha256sum] = "5df2045bab09f3da3ed29962d1130f4cf1c8a2d1400d1d15466c86f7e87c35ed"

URI_aarch64_rust-phf+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf+macros-devel-0.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-phf+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf+macros-devel}"
SRC_URI[aarch64_rust-phf+macros-devel.sha256sum] = "a49ffe299cc684a660304c6b84e895a704c32f8e0121a107316168d6d190d6f8"

URI_aarch64_rust-phf+phf_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf+phf_macros-devel-0.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-phf+phf_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf+phf_macros-devel}"
SRC_URI[aarch64_rust-phf+phf_macros-devel.sha256sum] = "518c3d875f3b58fec4d5cbb605752544f86e54b3cf3828c32efeff6c6f168c83"

URI_aarch64_rust-phf+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf+serde-devel-0.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-phf+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf+serde-devel}"
SRC_URI[aarch64_rust-phf+serde-devel.sha256sum] = "7d95cce8fd71d732e26e2cb77db91fbc59aab43cc2c2d957a3a75f891157d9dc"

URI_aarch64_rust-phf+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf+std-devel-0.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-phf+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf+std-devel}"
SRC_URI[aarch64_rust-phf+std-devel.sha256sum] = "2e66dd53d6d7d10f3574198e57c5292a2d4f18e21570a8aafbd77674eef57a45"

URI_aarch64_rust-phf+uncased-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf+uncased-devel-0.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-phf+uncased-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf+uncased-devel}"
SRC_URI[aarch64_rust-phf+uncased-devel.sha256sum] = "d265dfc2a8f51574a3a65ea41a005c39a7fca99864dd858fe4e7c27deb4b646f"

URI_aarch64_rust-phf+unicase-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf+unicase-devel-0.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-phf+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf+unicase-devel}"
SRC_URI[aarch64_rust-phf+unicase-devel.sha256sum] = "f8b19edb3fdc9e5649d4e2b91694e04db321314a638b8fbd9e9ba26d5e56af05"

URI_aarch64_rust-phf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf-devel-0.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-phf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf-devel}"
SRC_URI[aarch64_rust-phf-devel.sha256sum] = "a6c5d051a1ffe0faf7f5b0aa2b8e3339449539c6678f2b10352e42b1b24e2248"

RDEPENDS:rust-phf+default-devel = " \
 cargo \
 rust-phf+std-devel \
 rust-phf-devel \
 "
RDEPENDS:rust-phf+macros-devel = " \
 cargo \
 rust-phf+phf_macros-devel \
 rust-phf-devel \
 "
RDEPENDS:rust-phf+phf_macros-devel = " \
 cargo \
 rust-phf-devel \
 rust-phf_macros+default-devel \
 "
RDEPENDS:rust-phf+serde-devel = " \
 cargo \
 rust-phf-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-phf+std-devel = " \
 cargo \
 rust-phf-devel \
 rust-phf_shared+std-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-phf+uncased-devel = " \
 cargo \
 rust-phf-devel \
 rust-phf_macros+default-devel \
 rust-phf_macros+uncased-devel \
 rust-phf_shared+uncased-devel \
 "
RDEPENDS:rust-phf+unicase-devel = " \
 cargo \
 rust-phf-devel \
 rust-phf_macros+default-devel \
 rust-phf_macros+unicase-devel \
 rust-phf_shared+unicase-devel \
 "
RDEPENDS:rust-phf-devel = " \
 cargo \
 rust \
 rust-phf_shared-devel \
 "
