# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "color-filesystem"
PV = "1"
PR = "35.el10"
PACKAGES = " \
 color-filesystem \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/color-filesystem-1-35.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c34c1f2e1c2db0fac62706ee3d947e6d037f5e1d6a5a5a5f2a29c337b482b20d"

URI_x86_64_v2_color-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/color-filesystem-1-35.el10.noarch.rpm;name=x86_64_v2_color-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_color-filesystem}"
SRC_URI[x86_64_v2_color-filesystem.sha256sum] = "da57f57c83ec245833e3158cfa05b3ed7f486972dc1a84beb608274ae2f64318"

URI_aarch64_color-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/color-filesystem-1-35.el10.noarch.rpm;name=aarch64_color-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_color-filesystem}"
SRC_URI[aarch64_color-filesystem.sha256sum] = "da57f57c83ec245833e3158cfa05b3ed7f486972dc1a84beb608274ae2f64318"

RDEPENDS:color-filesystem = " \
 filesystem \
 rpm \
 "
