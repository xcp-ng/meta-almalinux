# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libnftnl"
PV = "1.2.8"
PR = "2.el10"
PACKAGES = " \
 libnftnl \
 libnftnl-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libnftnl-1.2.8-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "650f1ffd3a0c7a7be32f48c9fcec4f5ba771d87f597a16eb8e9bcd4a81ea6e34"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libnftnl-1.2.8-2.el10.x86_64_v2.rpm;name=x86_64_v2_libnftnl;unpack=0"
SRC_URI[x86_64_v2_libnftnl.sha256sum] = "70ab899a60391aa0ae3c66b5c4321e40228a65bee2fff924ac51fc6e7f8d0e64"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libnftnl-devel-1.2.8-2.el10.x86_64_v2.rpm;name=x86_64_v2_libnftnl-devel;unpack=0"
SRC_URI[x86_64_v2_libnftnl-devel.sha256sum] = "38a37ea43f11ec14559f99387cf10d03066a216437abe7428416c66eb600b754"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libnftnl-1.2.8-2.el10.aarch64.rpm;name=aarch64_libnftnl;unpack=0"
SRC_URI[aarch64_libnftnl.sha256sum] = "6874d263f96eb63ad5f03d242c013eb371929d8868786a2a95ef742066d174ca"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libnftnl-devel-1.2.8-2.el10.aarch64.rpm;name=aarch64_libnftnl-devel;unpack=0"
SRC_URI[aarch64_libnftnl-devel.sha256sum] = "20250851276e0e32d2a91704afa3c5a759ee3372b174e444f5f889adecef345e"

RDEPENDS:libnftnl = " \
 glibc \
 libmnl \
 "
RDEPENDS:libnftnl-devel = " \
 libmnl-devel \
 libnftnl \
 pkgconf-pkg-config \
 "
