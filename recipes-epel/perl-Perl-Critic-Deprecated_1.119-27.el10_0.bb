# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Perl-Critic-Deprecated"
PV = "1.119"
PR = "27.el10_0"
PACKAGES = " \
 perl-Perl-Critic-Deprecated \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Perl-Critic-Deprecated-1.119-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a0d35ce0b3fa304ceceb1f66732676cc17c35f62c2f9dcda22b729063d3e2ab"

URI_x86_64_v2_perl-Perl-Critic-Deprecated = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Perl-Critic-Deprecated-1.119-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Perl-Critic-Deprecated;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Perl-Critic-Deprecated}"
SRC_URI[x86_64_v2_perl-Perl-Critic-Deprecated.sha256sum] = "2e03f8a688caaefe6b8cf9c4ea1a11162bf47fd998a7745644c61200c7bdc622"

URI_aarch64_perl-Perl-Critic-Deprecated = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Perl-Critic-Deprecated-1.119-27.el10_0.noarch.rpm;name=aarch64_perl-Perl-Critic-Deprecated;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Perl-Critic-Deprecated}"
SRC_URI[aarch64_perl-Perl-Critic-Deprecated.sha256sum] = "a4fdfc7b6da97179b9eb3c908a61e5333ddcceddd83f83ea4e4025ea96cc6415"

RDEPENDS:perl-Perl-Critic-Deprecated = " \
 perl-Carp \
 perl-English \
 perl-Exporter \
 perl-List-MoreUtils \
 perl-PPI \
 perl-Perl-Critic \
 perl-Readonly \
 perl-base \
 perl-libs \
 "
