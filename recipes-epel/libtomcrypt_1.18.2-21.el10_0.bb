# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libtomcrypt"
PV = "1.18.2"
PR = "21.el10_0"
PACKAGES = " \
 libtomcrypt \
 libtomcrypt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libtomcrypt-1.18.2-21.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43e2527236647e14dad687fd809384b09b7b14dbff0a702041250e09fa201b08"

URI_x86_64_v2_libtomcrypt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libtomcrypt-1.18.2-21.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libtomcrypt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtomcrypt}"
SRC_URI[x86_64_v2_libtomcrypt.sha256sum] = "e7ccf29e5f9deb8f80f9b40b8f5ea30edec7e6370c9aa4259f8e0e21ba022ec8"

URI_x86_64_v2_libtomcrypt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libtomcrypt-devel-1.18.2-21.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libtomcrypt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtomcrypt-devel}"
SRC_URI[x86_64_v2_libtomcrypt-devel.sha256sum] = "5e289e31a99115b4156088b5f2a53b54ca7a44dff7f6087a8e259b79f595b784"

URI_aarch64_libtomcrypt = "${EPEL_MIRROR}/aarch64/Packages/l/libtomcrypt-1.18.2-21.el10_0.aarch64.rpm;name=aarch64_libtomcrypt;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtomcrypt}"
SRC_URI[aarch64_libtomcrypt.sha256sum] = "27152ed4ba3b86c76504f72fbb62c768e794f0b26b47127b2b0058b5bb38c716"

URI_aarch64_libtomcrypt-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libtomcrypt-devel-1.18.2-21.el10_0.aarch64.rpm;name=aarch64_libtomcrypt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtomcrypt-devel}"
SRC_URI[aarch64_libtomcrypt-devel.sha256sum] = "e2dd988832cb50c9169fbc33e6f725ed4e30919ac7c8b4f7cef5c6404fa2b404"

RDEPENDS:libtomcrypt = " \
 glibc \
 libtommath \
 "
RDEPENDS:libtomcrypt-devel = " \
 libtomcrypt \
 pkgconf-pkg-config \
 "
