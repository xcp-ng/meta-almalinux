# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-funcy"
PV = "1.17"
PR = "8.el10_0"
PACKAGES = " \
 python3-funcy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-funcy-1.17-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ea6b6dc4228908d0739ef8fb9ec4934838ffe592a83af3b28ab98baf2154e9a9"

URI_x86_64_v2_python3-funcy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-funcy-1.17-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-funcy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-funcy}"
SRC_URI[x86_64_v2_python3-funcy.sha256sum] = "3edc66628dbc341e0c3e6415ef04cd91e693b6766c11e134118d220e0f00bb2c"

URI_aarch64_python3-funcy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-funcy-1.17-8.el10_0.noarch.rpm;name=aarch64_python3-funcy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-funcy}"
SRC_URI[aarch64_python3-funcy.sha256sum] = "c0f341908dc03de501bde5ac4f6c8a4addf9e2a8f2e15ebf6e168a91ed6708de"

RDEPENDS:python3-funcy = " \
 python3 \
 "
