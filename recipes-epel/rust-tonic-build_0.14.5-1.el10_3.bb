# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tonic-build"
PV = "0.14.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-tonic-build+default-devel \
 rust-tonic-build+transport-devel \
 rust-tonic-build-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tonic-build-0.14.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d1cc773951fc4f6300cbae6271e434dd9f349e1aea29c34f4af6a5d92afbccf"

URI_x86_64_v2_rust-tonic-build+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tonic-build+default-devel-0.14.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tonic-build+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tonic-build+default-devel}"
SRC_URI[x86_64_v2_rust-tonic-build+default-devel.sha256sum] = "8d6303cf1282d83770ec0cefb2380de31262348d5b80833183034549aba991b6"

URI_x86_64_v2_rust-tonic-build+transport-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tonic-build+transport-devel-0.14.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tonic-build+transport-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tonic-build+transport-devel}"
SRC_URI[x86_64_v2_rust-tonic-build+transport-devel.sha256sum] = "fabeadd69d3daebd3c9ebc4086b897b4aaca853a519280df4938dc85fe178faa"

URI_x86_64_v2_rust-tonic-build-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tonic-build-devel-0.14.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tonic-build-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tonic-build-devel}"
SRC_URI[x86_64_v2_rust-tonic-build-devel.sha256sum] = "191c5401ce650ac5a7efaae2ac349ba10cc71899f54266868f80db2851a4d16e"

URI_aarch64_rust-tonic-build+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tonic-build+default-devel-0.14.5-1.el10_3.noarch.rpm;name=aarch64_rust-tonic-build+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tonic-build+default-devel}"
SRC_URI[aarch64_rust-tonic-build+default-devel.sha256sum] = "35d6d16e3e4b31f30b54c0346e21727ed22b3fb11720e12ff939ca0aed6f3716"

URI_aarch64_rust-tonic-build+transport-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tonic-build+transport-devel-0.14.5-1.el10_3.noarch.rpm;name=aarch64_rust-tonic-build+transport-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tonic-build+transport-devel}"
SRC_URI[aarch64_rust-tonic-build+transport-devel.sha256sum] = "6892f821c0335f9ee8fa9f126ed0a9c56eb485b1bfd9063c3d997d43e731cb91"

URI_aarch64_rust-tonic-build-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tonic-build-devel-0.14.5-1.el10_3.noarch.rpm;name=aarch64_rust-tonic-build-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tonic-build-devel}"
SRC_URI[aarch64_rust-tonic-build-devel.sha256sum] = "0a91b201366af9e950069b5f1fc16399a4302f0786df3e1ae160dea4f7a51c99"

RDEPENDS:rust-tonic-build+default-devel = " \
 cargo \
 rust-tonic-build+transport-devel \
 rust-tonic-build-devel \
 "
RDEPENDS:rust-tonic-build+transport-devel = " \
 cargo \
 rust-tonic-build-devel \
 "
RDEPENDS:rust-tonic-build-devel = " \
 cargo \
 rust \
 rust-prettyplease+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 "
