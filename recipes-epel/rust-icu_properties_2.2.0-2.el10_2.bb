# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_properties"
PV = "2.2.0"
PR = "2.el10_2"
PACKAGES = " \
 rust-icu_properties+alloc-devel \
 rust-icu_properties+compiled_data-devel \
 rust-icu_properties+datagen-devel \
 rust-icu_properties+default-devel \
 rust-icu_properties+harfbuzz_traits-devel \
 rust-icu_properties+serde-devel \
 rust-icu_properties+unicode_bidi-devel \
 rust-icu_properties-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_properties-2.2.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "561d0572cd5e41ae0b7ac5486dfddafbb5528896b8ba34b98aaf47596d7ff916"

URI_x86_64_v2_rust-icu_properties+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_properties+alloc-devel-2.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_properties+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_properties+alloc-devel}"
SRC_URI[x86_64_v2_rust-icu_properties+alloc-devel.sha256sum] = "cd31f2ae7ef7f87928bea800f1b3d9148a2631e1ecb5ddfddf5a0dbaa2f27dc7"

URI_x86_64_v2_rust-icu_properties+compiled_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_properties+compiled_data-devel-2.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_properties+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_properties+compiled_data-devel}"
SRC_URI[x86_64_v2_rust-icu_properties+compiled_data-devel.sha256sum] = "d33ed80b00b461f31c2e801ae188464f0c6e6d1f3cf60e141dc66319c7ffaf9d"

URI_x86_64_v2_rust-icu_properties+datagen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_properties+datagen-devel-2.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_properties+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_properties+datagen-devel}"
SRC_URI[x86_64_v2_rust-icu_properties+datagen-devel.sha256sum] = "1de6a314a866f5f77fb4f6c2ddb2b45ac6ae248fdcdf05b8d9f4b5d413048992"

URI_x86_64_v2_rust-icu_properties+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_properties+default-devel-2.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_properties+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_properties+default-devel}"
SRC_URI[x86_64_v2_rust-icu_properties+default-devel.sha256sum] = "e0eb9a4ad0e5b782f38c30a0f3b51494a56ade121a3b981259109fb52ea3a3a8"

URI_x86_64_v2_rust-icu_properties+harfbuzz_traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_properties+harfbuzz_traits-devel-2.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_properties+harfbuzz_traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_properties+harfbuzz_traits-devel}"
SRC_URI[x86_64_v2_rust-icu_properties+harfbuzz_traits-devel.sha256sum] = "626435e4f8479ddc3bde45c0c46e7daf8c37b019cf8cdfd73098c2ef492fb5cc"

URI_x86_64_v2_rust-icu_properties+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_properties+serde-devel-2.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_properties+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_properties+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_properties+serde-devel.sha256sum] = "e0be919294ecfb88767ded85e85fd5bb6a7e62397f8b1dac2ad51064fbc86e22"

URI_x86_64_v2_rust-icu_properties+unicode_bidi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_properties+unicode_bidi-devel-2.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_properties+unicode_bidi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_properties+unicode_bidi-devel}"
SRC_URI[x86_64_v2_rust-icu_properties+unicode_bidi-devel.sha256sum] = "fe4ef9bae458ca97966465ece02a64a5eecc87004704c0b7d14bc224032d522d"

URI_x86_64_v2_rust-icu_properties-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_properties-devel-2.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_properties-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_properties-devel}"
SRC_URI[x86_64_v2_rust-icu_properties-devel.sha256sum] = "a0fd6a2fa1b1d6388d275676010d69bb96d652e5ac5e51c6feee13da3cfe84c1"

URI_aarch64_rust-icu_properties+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_properties+alloc-devel-2.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-icu_properties+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_properties+alloc-devel}"
SRC_URI[aarch64_rust-icu_properties+alloc-devel.sha256sum] = "cfc181cc09bb2a5d18ef8036dcd36e4752a69319b2cfbc45cb9f690198eef38c"

URI_aarch64_rust-icu_properties+compiled_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_properties+compiled_data-devel-2.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-icu_properties+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_properties+compiled_data-devel}"
SRC_URI[aarch64_rust-icu_properties+compiled_data-devel.sha256sum] = "8b3514ca6585b8db319cacbd42bfe49fd63f9b4a63682c9cb709f80c67bad5c5"

URI_aarch64_rust-icu_properties+datagen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_properties+datagen-devel-2.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-icu_properties+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_properties+datagen-devel}"
SRC_URI[aarch64_rust-icu_properties+datagen-devel.sha256sum] = "cd0c252b71af7bcf22791a2ece33d396af173046ada158f58f7ec9f4d28241cf"

URI_aarch64_rust-icu_properties+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_properties+default-devel-2.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-icu_properties+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_properties+default-devel}"
SRC_URI[aarch64_rust-icu_properties+default-devel.sha256sum] = "29381b1e93ab8823ff5cee464caa53ad442a9cd3532e483911e3e73cdf74f0a6"

URI_aarch64_rust-icu_properties+harfbuzz_traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_properties+harfbuzz_traits-devel-2.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-icu_properties+harfbuzz_traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_properties+harfbuzz_traits-devel}"
SRC_URI[aarch64_rust-icu_properties+harfbuzz_traits-devel.sha256sum] = "8d2d8fce49415cb774eb2c40fc85b0ad890e7f63f77386711ff91a252512baa4"

URI_aarch64_rust-icu_properties+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_properties+serde-devel-2.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-icu_properties+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_properties+serde-devel}"
SRC_URI[aarch64_rust-icu_properties+serde-devel.sha256sum] = "6f8e15ced1eb9cb40cce8c14deb39fefe5f188f3fd290068438e7b36b6ed08e4"

URI_aarch64_rust-icu_properties+unicode_bidi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_properties+unicode_bidi-devel-2.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-icu_properties+unicode_bidi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_properties+unicode_bidi-devel}"
SRC_URI[aarch64_rust-icu_properties+unicode_bidi-devel.sha256sum] = "095706f340fe3ef824c8cc6f8220b577ef33c290c157296bf67be53aab393de8"

URI_aarch64_rust-icu_properties-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_properties-devel-2.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-icu_properties-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_properties-devel}"
SRC_URI[aarch64_rust-icu_properties-devel.sha256sum] = "128aaec4e06575776459860700184510ef31a61a775ee49b190283b139ba41a2"

RDEPENDS:rust-icu_properties+alloc-devel = " \
 cargo \
 rust-icu_collections+alloc-devel \
 rust-icu_properties-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerovec+alloc-devel \
 "
RDEPENDS:rust-icu_properties+compiled_data-devel = " \
 cargo \
 rust-icu_properties-devel \
 rust-icu_properties_data-devel \
 rust-icu_provider+baked-devel \
 "
RDEPENDS:rust-icu_properties+datagen-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-icu_collections+databake-devel \
 rust-icu_locale_core+databake-devel \
 rust-icu_properties+serde-devel \
 rust-icu_properties-devel \
 rust-icu_provider+export-devel \
 rust-zerotrie+databake-devel \
 rust-zerovec+databake-devel \
 "
RDEPENDS:rust-icu_properties+default-devel = " \
 cargo \
 rust-icu_properties+compiled_data-devel \
 rust-icu_properties-devel \
 "
RDEPENDS:rust-icu_properties+harfbuzz_traits-devel = " \
 cargo \
 rust-harfbuzz-traits-devel \
 rust-icu_properties-devel \
 "
RDEPENDS:rust-icu_properties+serde-devel = " \
 cargo \
 rust-icu_collections+serde-devel \
 rust-icu_locale_core+serde-devel \
 rust-icu_properties-devel \
 rust-icu_provider+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerotrie+serde-devel \
 rust-zerovec+serde-devel \
 "
RDEPENDS:rust-icu_properties+unicode_bidi-devel = " \
 cargo \
 rust-icu_properties-devel \
 rust-unicode-bidi-devel \
 "
RDEPENDS:rust-icu_properties-devel = " \
 cargo \
 rust \
 rust-icu_collections-devel \
 rust-icu_locale_core+zerovec-devel \
 rust-icu_locale_core-devel \
 rust-icu_provider-devel \
 rust-zerotrie+yoke-devel \
 rust-zerotrie+zerofrom-devel \
 rust-zerotrie-devel \
 rust-zerovec+derive-devel \
 rust-zerovec+yoke-devel \
 rust-zerovec-devel \
 "
