# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mailimporter"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 mailimporter \
 mailimporter-akonadi \
 mailimporter-devel \
 mailimporter-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mailimporter-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4d44301fdb8ef478c085e15971f0bd9a7866e8a6661f304d5a304938f4dacf8e"

URI_x86_64_v2_mailimporter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailimporter-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mailimporter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mailimporter}"
SRC_URI[x86_64_v2_mailimporter.sha256sum] = "5efab3336c2f36adefce4a0943b537a4e8afc5697deeb9760f9b668f5e42f777"

URI_x86_64_v2_mailimporter-akonadi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailimporter-akonadi-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mailimporter-akonadi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mailimporter-akonadi}"
SRC_URI[x86_64_v2_mailimporter-akonadi.sha256sum] = "43d6a2c84b6e30e810fd654322ceeb66cd3758dcd9479d03c5bc87ae8730fc55"

URI_x86_64_v2_mailimporter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailimporter-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mailimporter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mailimporter-devel}"
SRC_URI[x86_64_v2_mailimporter-devel.sha256sum] = "3e32d627b37eb5cd39b4b69e39c603bd50fc2ca0ec9f9489d7b3dba3976a3873"

URI_x86_64_v2_mailimporter-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailimporter-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mailimporter-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mailimporter-doc}"
SRC_URI[x86_64_v2_mailimporter-doc.sha256sum] = "74bf0cb3ab47bf3f4dff3a8bd38e510605bd2ac95a15c8e43afb1f5e3f2358df"

URI_aarch64_mailimporter = "${EPEL_MIRROR}/aarch64/Packages/m/mailimporter-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_mailimporter;unpack=0"
SRC_URI:append = " ${URI_aarch64_mailimporter}"
SRC_URI[aarch64_mailimporter.sha256sum] = "5a36aa4793eaeeaee96e4e0dc8e1ad9325d7cca1dd9eb7a787536ea2accae5dd"

URI_aarch64_mailimporter-akonadi = "${EPEL_MIRROR}/aarch64/Packages/m/mailimporter-akonadi-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_mailimporter-akonadi;unpack=0"
SRC_URI:append = " ${URI_aarch64_mailimporter-akonadi}"
SRC_URI[aarch64_mailimporter-akonadi.sha256sum] = "56fcf2c3ce15cbbc94f6f33e40c48babfaa36a0c3d359f6dcfddfac57c3f936b"

URI_aarch64_mailimporter-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mailimporter-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_mailimporter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mailimporter-devel}"
SRC_URI[aarch64_mailimporter-devel.sha256sum] = "2d36bbd5e01999eae021319b16b08bfb37e43f1754b4bc576897bfa016d39977"

URI_aarch64_mailimporter-doc = "${EPEL_MIRROR}/aarch64/Packages/m/mailimporter-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_mailimporter-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_mailimporter-doc}"
SRC_URI[aarch64_mailimporter-doc.sha256sum] = "97efacc9287e624c7a522292b33634908cd52d24243f397dd274d7ad310a74a0"

RDEPENDS:mailimporter = " \
 glibc \
 kf6-karchive \
 kf6-kconfig \
 kf6-ki18n \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:mailimporter-akonadi = " \
 akonadi-mime \
 akonadi-server \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kmime \
 libgcc \
 libstdc++ \
 mailimporter \
 qt6-qtbase \
 "
RDEPENDS:mailimporter-devel = " \
 cmake-filesystem \
 kf6-karchive-devel \
 mailimporter \
 mailimporter-akonadi \
 "
RDEPENDS:mailimporter-doc = " \
 "
