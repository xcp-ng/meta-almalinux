# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-CIDR-Lite"
PV = "0.22"
PR = "7.el10_0"
PACKAGES = " \
 perl-Net-CIDR-Lite \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-CIDR-Lite-0.22-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5fda17d65d025a69fcc497982ba4cd4fa026c60556529d1a9f630548a8c27dd9"

URI_x86_64_v2_perl-Net-CIDR-Lite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-CIDR-Lite-0.22-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-CIDR-Lite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-CIDR-Lite}"
SRC_URI[x86_64_v2_perl-Net-CIDR-Lite.sha256sum] = "b0cb791f01ea4906fcb682d843696f8e028017b6850960383b484db3524af47e"

URI_aarch64_perl-Net-CIDR-Lite = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-CIDR-Lite-0.22-7.el10_0.noarch.rpm;name=aarch64_perl-Net-CIDR-Lite;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-CIDR-Lite}"
SRC_URI[aarch64_perl-Net-CIDR-Lite.sha256sum] = "06212d37ef96342333cfc6d71e2e5d635798a3d496d3746ddca97dea4bc41583"

RDEPENDS:perl-Net-CIDR-Lite = " \
 perl-Carp \
 perl-libs \
 perl-vars \
 "
