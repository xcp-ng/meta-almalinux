# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "moditect"
PV = "1.1.0"
PR = "4.el10"
PACKAGES = " \
 moditect \
 moditect-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/moditect-1.1.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e74cb12556798fa1e1a2ed66f45866bebcba77368237e998480e2cb54d24fac1"

URI_x86_64_v2_moditect = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/moditect-1.1.0-4.el10.noarch.rpm;name=x86_64_v2_moditect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_moditect}"
SRC_URI[x86_64_v2_moditect.sha256sum] = "e6caf046afc56582d350673601a1592bc9fd9c15d3044d7fa91ed6a705afafba"

URI_x86_64_v2_moditect-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/moditect-javadoc-1.1.0-4.el10.noarch.rpm;name=x86_64_v2_moditect-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_moditect-javadoc}"
SRC_URI[x86_64_v2_moditect-javadoc.sha256sum] = "041340388694b31e5a56e2e6279311c177ba98ef58809a5a68b54f7e506bef25"

URI_aarch64_moditect = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/moditect-1.1.0-4.el10.noarch.rpm;name=aarch64_moditect;unpack=0"
SRC_URI:append = " ${URI_aarch64_moditect}"
SRC_URI[aarch64_moditect.sha256sum] = "e6caf046afc56582d350673601a1592bc9fd9c15d3044d7fa91ed6a705afafba"

URI_aarch64_moditect-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/moditect-javadoc-1.1.0-4.el10.noarch.rpm;name=aarch64_moditect-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_moditect-javadoc}"
SRC_URI[aarch64_moditect-javadoc.sha256sum] = "041340388694b31e5a56e2e6279311c177ba98ef58809a5a68b54f7e506bef25"

RDEPENDS:moditect = " \
 beust-jcommander \
 javapackages-filesystem \
 javaparser \
 maven-resolver \
 objectweb-asm \
 "
RDEPENDS:moditect-javadoc = " \
 javapackages-filesystem \
 "
