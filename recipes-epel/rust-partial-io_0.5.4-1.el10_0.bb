# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-partial-io"
PV = "0.5.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-partial-io+default-devel \
 rust-partial-io+futures-devel \
 rust-partial-io+futures03-devel \
 rust-partial-io+pin-project-devel \
 rust-partial-io+proptest-devel \
 rust-partial-io+proptest1-devel \
 rust-partial-io+quickcheck-devel \
 rust-partial-io+quickcheck1-devel \
 rust-partial-io+rand-devel \
 rust-partial-io+tokio-devel \
 rust-partial-io+tokio1-devel \
 rust-partial-io-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-partial-io-0.5.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6719ab6947adc575534d9cf911293708fd410fa1d5b3bbbf00c25a77e2ed97ce"

URI_x86_64_v2_rust-partial-io+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-partial-io+default-devel-0.5.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-partial-io+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-partial-io+default-devel}"
SRC_URI[x86_64_v2_rust-partial-io+default-devel.sha256sum] = "10ae6c0f4b1d5d0c9f1559f72eb334fea8e2f2d74fc1f29c1ee587b954c3cae2"

URI_x86_64_v2_rust-partial-io+futures-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-partial-io+futures-devel-0.5.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-partial-io+futures-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-partial-io+futures-devel}"
SRC_URI[x86_64_v2_rust-partial-io+futures-devel.sha256sum] = "4a22b01f4fc1df46de3495def20c87bdede1a07a33c5824e2ff5b1e95c129d34"

URI_x86_64_v2_rust-partial-io+futures03-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-partial-io+futures03-devel-0.5.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-partial-io+futures03-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-partial-io+futures03-devel}"
SRC_URI[x86_64_v2_rust-partial-io+futures03-devel.sha256sum] = "a2640c77c58701e068b12ceca20a71e4f824ac516b407d8d48f086bd407a4a5a"

URI_x86_64_v2_rust-partial-io+pin-project-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-partial-io+pin-project-devel-0.5.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-partial-io+pin-project-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-partial-io+pin-project-devel}"
SRC_URI[x86_64_v2_rust-partial-io+pin-project-devel.sha256sum] = "babcdf306ce62f81d2ac6cb8e546869f6002607b80b254a7c6287a49b2b14ba1"

URI_x86_64_v2_rust-partial-io+proptest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-partial-io+proptest-devel-0.5.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-partial-io+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-partial-io+proptest-devel}"
SRC_URI[x86_64_v2_rust-partial-io+proptest-devel.sha256sum] = "3705902cba6f5dbeed2aa35c7fb79928bec10c19aaddb8a82c0cbf1d3ceb9e59"

URI_x86_64_v2_rust-partial-io+proptest1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-partial-io+proptest1-devel-0.5.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-partial-io+proptest1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-partial-io+proptest1-devel}"
SRC_URI[x86_64_v2_rust-partial-io+proptest1-devel.sha256sum] = "2478654a56f888ecb275b33f04b59eaa891d81efc09c80f59527b166fe81e7af"

URI_x86_64_v2_rust-partial-io+quickcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-partial-io+quickcheck-devel-0.5.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-partial-io+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-partial-io+quickcheck-devel}"
SRC_URI[x86_64_v2_rust-partial-io+quickcheck-devel.sha256sum] = "3d72a7c540466488b621b73199728dd0a4dbab741b7205dead0889935e7604fa"

URI_x86_64_v2_rust-partial-io+quickcheck1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-partial-io+quickcheck1-devel-0.5.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-partial-io+quickcheck1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-partial-io+quickcheck1-devel}"
SRC_URI[x86_64_v2_rust-partial-io+quickcheck1-devel.sha256sum] = "4ce78cd61e1c205fa5f87a707ca353d3cf614e02cffc6519c15cfb960a23251a"

URI_x86_64_v2_rust-partial-io+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-partial-io+rand-devel-0.5.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-partial-io+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-partial-io+rand-devel}"
SRC_URI[x86_64_v2_rust-partial-io+rand-devel.sha256sum] = "bc60fff7c6201bc44fa0c92018231ac6214784a75a645646029bed9781990841"

URI_x86_64_v2_rust-partial-io+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-partial-io+tokio-devel-0.5.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-partial-io+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-partial-io+tokio-devel}"
SRC_URI[x86_64_v2_rust-partial-io+tokio-devel.sha256sum] = "81a77eb9d954ac8d369beeedc56829cb5f07aef4c5839e0aa17ce487dfe2bc99"

URI_x86_64_v2_rust-partial-io+tokio1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-partial-io+tokio1-devel-0.5.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-partial-io+tokio1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-partial-io+tokio1-devel}"
SRC_URI[x86_64_v2_rust-partial-io+tokio1-devel.sha256sum] = "f108b4fff07ef00166d9131d71780888311aaa70716b1660e7ecd36c3db89751"

URI_x86_64_v2_rust-partial-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-partial-io-devel-0.5.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-partial-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-partial-io-devel}"
SRC_URI[x86_64_v2_rust-partial-io-devel.sha256sum] = "d0984830872f11c6e9ef36f5255586a1db5f70479d6ef78091d09c277dd46120"

URI_aarch64_rust-partial-io+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-partial-io+default-devel-0.5.4-1.el10_0.noarch.rpm;name=aarch64_rust-partial-io+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-partial-io+default-devel}"
SRC_URI[aarch64_rust-partial-io+default-devel.sha256sum] = "2dd05f6c2738fdead4765a12fb9d68c54c1d1db9901b2b5be647d23301f400a8"

URI_aarch64_rust-partial-io+futures-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-partial-io+futures-devel-0.5.4-1.el10_0.noarch.rpm;name=aarch64_rust-partial-io+futures-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-partial-io+futures-devel}"
SRC_URI[aarch64_rust-partial-io+futures-devel.sha256sum] = "f610f127962018c65f2c328c30fce2ab4ef0ac4d53a3cb4709eb129426ab81e5"

URI_aarch64_rust-partial-io+futures03-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-partial-io+futures03-devel-0.5.4-1.el10_0.noarch.rpm;name=aarch64_rust-partial-io+futures03-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-partial-io+futures03-devel}"
SRC_URI[aarch64_rust-partial-io+futures03-devel.sha256sum] = "aec2d9dd0a84c31d4e63202b05d2767690c167c76c5b18c8335e81d0768ab1d5"

URI_aarch64_rust-partial-io+pin-project-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-partial-io+pin-project-devel-0.5.4-1.el10_0.noarch.rpm;name=aarch64_rust-partial-io+pin-project-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-partial-io+pin-project-devel}"
SRC_URI[aarch64_rust-partial-io+pin-project-devel.sha256sum] = "a2cd4cb6b6100fb1cf4152f1affb1359750d6e3f52fd62f4a609ee46fbf58fb8"

URI_aarch64_rust-partial-io+proptest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-partial-io+proptest-devel-0.5.4-1.el10_0.noarch.rpm;name=aarch64_rust-partial-io+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-partial-io+proptest-devel}"
SRC_URI[aarch64_rust-partial-io+proptest-devel.sha256sum] = "875b90fd1473be3b7bc021270f1d6b0f7fba531364b6dca33686ba734e7788bc"

URI_aarch64_rust-partial-io+proptest1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-partial-io+proptest1-devel-0.5.4-1.el10_0.noarch.rpm;name=aarch64_rust-partial-io+proptest1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-partial-io+proptest1-devel}"
SRC_URI[aarch64_rust-partial-io+proptest1-devel.sha256sum] = "a7a7700715844145ccc50fd6f9753d726a5d06fd89ab905ca998f52b74c8a605"

URI_aarch64_rust-partial-io+quickcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-partial-io+quickcheck-devel-0.5.4-1.el10_0.noarch.rpm;name=aarch64_rust-partial-io+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-partial-io+quickcheck-devel}"
SRC_URI[aarch64_rust-partial-io+quickcheck-devel.sha256sum] = "3638c329c0e167015c7ba4be8bdac62c307f0e294a35fea1f683e8f448b66837"

URI_aarch64_rust-partial-io+quickcheck1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-partial-io+quickcheck1-devel-0.5.4-1.el10_0.noarch.rpm;name=aarch64_rust-partial-io+quickcheck1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-partial-io+quickcheck1-devel}"
SRC_URI[aarch64_rust-partial-io+quickcheck1-devel.sha256sum] = "6362cd9764bd51a304df4ac0845b45bbf1b9dfba03b347c86bc953d0e597e0ea"

URI_aarch64_rust-partial-io+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-partial-io+rand-devel-0.5.4-1.el10_0.noarch.rpm;name=aarch64_rust-partial-io+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-partial-io+rand-devel}"
SRC_URI[aarch64_rust-partial-io+rand-devel.sha256sum] = "1b1ce8f16d7e625709602e4d7fe761fb8c739278d88b1184e60cdb21203ebae3"

URI_aarch64_rust-partial-io+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-partial-io+tokio-devel-0.5.4-1.el10_0.noarch.rpm;name=aarch64_rust-partial-io+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-partial-io+tokio-devel}"
SRC_URI[aarch64_rust-partial-io+tokio-devel.sha256sum] = "6e2a9bd6595ac01ca84ad77bd1a6768e488e446c16734876abb6639efe408302"

URI_aarch64_rust-partial-io+tokio1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-partial-io+tokio1-devel-0.5.4-1.el10_0.noarch.rpm;name=aarch64_rust-partial-io+tokio1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-partial-io+tokio1-devel}"
SRC_URI[aarch64_rust-partial-io+tokio1-devel.sha256sum] = "db4b41a0d75b9da4c33a40d9faca18c6d58137b654184da7da4cae6f3f21256c"

URI_aarch64_rust-partial-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-partial-io-devel-0.5.4-1.el10_0.noarch.rpm;name=aarch64_rust-partial-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-partial-io-devel}"
SRC_URI[aarch64_rust-partial-io-devel.sha256sum] = "43d789e09df436cdb620c838b600f5332d906a03ce0b3a4033d4ebc7fc63c0d6"

RDEPENDS:rust-partial-io+default-devel = " \
 cargo \
 rust-partial-io-devel \
 "
RDEPENDS:rust-partial-io+futures-devel = " \
 cargo \
 rust-futures+default-devel \
 rust-partial-io-devel \
 "
RDEPENDS:rust-partial-io+futures03-devel = " \
 cargo \
 rust-partial-io+futures-devel \
 rust-partial-io+pin-project-devel \
 rust-partial-io-devel \
 "
RDEPENDS:rust-partial-io+pin-project-devel = " \
 cargo \
 rust-partial-io-devel \
 rust-pin-project+default-devel \
 "
RDEPENDS:rust-partial-io+proptest-devel = " \
 cargo \
 rust-partial-io-devel \
 rust-proptest+default-devel \
 "
RDEPENDS:rust-partial-io+proptest1-devel = " \
 cargo \
 rust-partial-io+proptest-devel \
 rust-partial-io-devel \
 "
RDEPENDS:rust-partial-io+quickcheck-devel = " \
 cargo \
 rust-partial-io-devel \
 rust-quickcheck+default-devel \
 "
RDEPENDS:rust-partial-io+quickcheck1-devel = " \
 cargo \
 rust-partial-io+quickcheck-devel \
 rust-partial-io+rand-devel \
 rust-partial-io-devel \
 "
RDEPENDS:rust-partial-io+rand-devel = " \
 cargo \
 rust-partial-io-devel \
 rust-rand0.8+default-devel \
 rust-rand0.8+getrandom-devel \
 rust-rand0.8+small_rng-devel \
 "
RDEPENDS:rust-partial-io+tokio-devel = " \
 cargo \
 rust-partial-io-devel \
 rust-tokio+default-devel \
 "
RDEPENDS:rust-partial-io+tokio1-devel = " \
 cargo \
 rust-partial-io+futures03-devel \
 rust-partial-io+tokio-devel \
 rust-partial-io-devel \
 "
RDEPENDS:rust-partial-io-devel = " \
 bash \
 cargo \
 rust \
 "
