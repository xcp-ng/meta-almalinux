# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opentelemetry-collector"
PV = "0.144.0"
PR = "1.el10_1"
PACKAGES = " \
 opentelemetry-collector \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/opentelemetry-collector-0.144.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "db0296e571d07001b070debac5239561ca4a7b1b0f78575f1689f30bd25110a6"

URI_x86_64_v2_opentelemetry-collector = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/opentelemetry-collector-0.144.0-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_opentelemetry-collector;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opentelemetry-collector}"
SRC_URI[x86_64_v2_opentelemetry-collector.sha256sum] = "4acb4b47917627224db46b075289f16ce3dd8df2bf8106609356a7ee50ee649c"

URI_aarch64_opentelemetry-collector = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/opentelemetry-collector-0.144.0-1.el10_1.aarch64.rpm;name=aarch64_opentelemetry-collector;unpack=0"
SRC_URI:append = " ${URI_aarch64_opentelemetry-collector}"
SRC_URI[aarch64_opentelemetry-collector.sha256sum] = "b226ae80571f5dd7345d1c650b13c78f3b299ea08a630efbcc7d77f191c8e807"

RDEPENDS:opentelemetry-collector = " \
 bash \
 glibc \
 glibc-common \
 shadow-utils \
 systemd \
 util-linux \
 "
