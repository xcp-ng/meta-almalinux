# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cadaver"
PV = "0.26"
PR = "2.el10_0"
PACKAGES = " \
 cadaver \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cadaver-0.26-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3a98cd2346c41cac20b647df7b0116b98df27bf42ac196122bffe0df2973f360"

URI_x86_64_v2_cadaver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cadaver-0.26-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cadaver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cadaver}"
SRC_URI[x86_64_v2_cadaver.sha256sum] = "345dce4f66923b3c0640e7cd0c95aec26880dab9d437f7974a040b9b9d3f1b13"

URI_aarch64_cadaver = "${EPEL_MIRROR}/aarch64/Packages/c/cadaver-0.26-2.el10_0.aarch64.rpm;name=aarch64_cadaver;unpack=0"
SRC_URI:append = " ${URI_aarch64_cadaver}"
SRC_URI[aarch64_cadaver.sha256sum] = "eb31afcfc8e3087abcdb5144906122596ef67b552b26493b7b242fe130deb4b0"

RDEPENDS:cadaver = " \
 glibc \
 neon \
 readline \
 "
