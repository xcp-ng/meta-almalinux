# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dwz"
PV = "0.16"
PR = "1.el10"
PACKAGES = " \
 dwz \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dwz-0.16-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8cbfe37a71aaab5b7ec8122e85526dd5c42d710df8b72545260bdfad2d062bd3"

URI_x86_64_v2_dwz = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dwz-0.16-1.el10.x86_64_v2.rpm;name=x86_64_v2_dwz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dwz}"
SRC_URI[x86_64_v2_dwz.sha256sum] = "28a2a1f04cd32e234a9e13a3fb8083c91d7c8a3bca1774223b6db87de889d510"

URI_aarch64_dwz = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dwz-0.16-1.el10.aarch64.rpm;name=aarch64_dwz;unpack=0"
SRC_URI:append = " ${URI_aarch64_dwz}"
SRC_URI[aarch64_dwz.sha256sum] = "0c14c6576e3d2766dd6ecb6099546fef3365b8f2ade2b3e1883bcdebe1469138"

RDEPENDS:dwz = " \
 elfutils-libelf \
 glibc \
 "
