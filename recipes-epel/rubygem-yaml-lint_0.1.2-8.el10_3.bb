# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-yaml-lint"
PV = "0.1.2"
PR = "8.el10_3"
PACKAGES = " \
 rubygem-yaml-lint \
 rubygem-yaml-lint-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-yaml-lint-0.1.2-8.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5561cd9abcc708408d3910294d09c6495eeefc388936ed7d70a0183762a3d9bf"

URI_x86_64_v2_rubygem-yaml-lint = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-yaml-lint-0.1.2-8.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-yaml-lint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-yaml-lint}"
SRC_URI[x86_64_v2_rubygem-yaml-lint.sha256sum] = "a1212a3104180bed6d429607349c6289f12d91bd80223bc04fe19fe927fa8cd6"

URI_x86_64_v2_rubygem-yaml-lint-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-yaml-lint-doc-0.1.2-8.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-yaml-lint-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-yaml-lint-doc}"
SRC_URI[x86_64_v2_rubygem-yaml-lint-doc.sha256sum] = "1a21efd54d8b4ec7f4461f31a7290ef8af50065f6658a763e8690b29e0b21e9c"

URI_aarch64_rubygem-yaml-lint = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-yaml-lint-0.1.2-8.el10_3.noarch.rpm;name=aarch64_rubygem-yaml-lint;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-yaml-lint}"
SRC_URI[aarch64_rubygem-yaml-lint.sha256sum] = "537ff3b0001819015023fc91623b536d192e8be2741c5c2ae9d1fbb5d7a22fa3"

URI_aarch64_rubygem-yaml-lint-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-yaml-lint-doc-0.1.2-8.el10_3.noarch.rpm;name=aarch64_rubygem-yaml-lint-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-yaml-lint-doc}"
SRC_URI[aarch64_rubygem-yaml-lint-doc.sha256sum] = "c86ae6cadf46efc8b1d6b8de357e21e985948591d461ddd383aae32ff1723b68"

RDEPENDS:rubygem-yaml-lint = " \
 ruby \
 rubygems \
 "
RDEPENDS:rubygem-yaml-lint-doc = " \
 rubygem-yaml-lint \
 "
