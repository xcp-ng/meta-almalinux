# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nomacs"
PV = "3.22.1"
PR = "1.el10_3"
PACKAGES = " \
 nomacs \
 nomacs-plugins \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nomacs-3.22.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "914d77831c6c1b86d2bf10502bd4edb134b8f21978ff1f2471d61513788bcde9"

URI_x86_64_v2_nomacs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nomacs-3.22.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nomacs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nomacs}"
SRC_URI[x86_64_v2_nomacs.sha256sum] = "8c17507a86dca5bbd955ef01261517781fa0d4bd6cefa99d4d5852f6620d3a7c"

URI_x86_64_v2_nomacs-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nomacs-plugins-3.22.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nomacs-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nomacs-plugins}"
SRC_URI[x86_64_v2_nomacs-plugins.sha256sum] = "5500c49e6af4e76fbdda8c64003d99beec7527ea9593832844ce6a53b1dc019f"

URI_aarch64_nomacs = "${EPEL_MIRROR}/aarch64/Packages/n/nomacs-3.22.1-1.el10_3.aarch64.rpm;name=aarch64_nomacs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nomacs}"
SRC_URI[aarch64_nomacs.sha256sum] = "c6ee1840e809587f99f7b96f3250bb32e102bc6276b3fda302d70139541f8a4c"

URI_aarch64_nomacs-plugins = "${EPEL_MIRROR}/aarch64/Packages/n/nomacs-plugins-3.22.1-1.el10_3.aarch64.rpm;name=aarch64_nomacs-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_nomacs-plugins}"
SRC_URI[aarch64_nomacs-plugins.sha256sum] = "73cb0de2bac851c379564c0fb211fb07943d94b4fe6ba657fae2846b6e336ff5"

RDEPENDS:nomacs = " \
 LibRaw \
 exiv2-libs \
 glibc \
 libgcc \
 libstdc++ \
 libtiff \
 opencv-core \
 opencv-imgproc \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 quazip-qt6 \
 "
RDEPENDS:nomacs-plugins = " \
 glibc \
 libgcc \
 libstdc++ \
 nomacs \
 opencv-core \
 opencv-imgproc \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
