# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hiprand"
PV = "6.4.2"
PR = "4.el10_1"
PACKAGES:x86_64_v2 = " \
 hiprand \
 hiprand-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/h/hiprand-6.4.2-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "373fedd793b4b46e6ec62f3c7e6db50157cc196cb5581d538300d2794f6ebcfc"

URI_x86_64_v2_hiprand = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hiprand-6.4.2-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hiprand;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hiprand}"
SRC_URI[x86_64_v2_hiprand.sha256sum] = "ae28a99c1739b8b1bd5c3def5bb26a7ca4aa9f410751162c469147f433d23985"

URI_x86_64_v2_hiprand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hiprand-devel-6.4.2-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hiprand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hiprand-devel}"
SRC_URI[x86_64_v2_hiprand-devel.sha256sum] = "e2cb5a2798bbbb62e75dff081211a2f77c29cfd578dd7f6d28cccc59d562a132"

RDEPENDS:hiprand = " \
 glibc \
 libstdc++ \
 rocrand \
 "
RDEPENDS:hiprand-devel = " \
 cmake-filesystem \
 hiprand \
 rocrand-devel \
 "
