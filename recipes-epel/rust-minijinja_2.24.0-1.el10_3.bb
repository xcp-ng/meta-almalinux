# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-minijinja"
PV = "2.24.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-minijinja+adjacent_loop_items-devel \
 rust-minijinja+builtins-devel \
 rust-minijinja+custom_syntax-devel \
 rust-minijinja+debug-devel \
 rust-minijinja+default-devel \
 rust-minijinja+deserialization-devel \
 rust-minijinja+fuel-devel \
 rust-minijinja+indexmap-devel \
 rust-minijinja+internal_debug-devel \
 rust-minijinja+internal_safe_search-devel \
 rust-minijinja+json-devel \
 rust-minijinja+key_interning-devel \
 rust-minijinja+loader-devel \
 rust-minijinja+loop_controls-devel \
 rust-minijinja+macros-devel \
 rust-minijinja+multi_template-devel \
 rust-minijinja+percent-encoding-devel \
 rust-minijinja+preserve_order-devel \
 rust-minijinja+serde-devel \
 rust-minijinja+serde_json-devel \
 rust-minijinja+speedups-devel \
 rust-minijinja+stacker-devel \
 rust-minijinja+std_collections-devel \
 rust-minijinja+unicase-devel \
 rust-minijinja+unicode-devel \
 rust-minijinja+unicode-ident-devel \
 rust-minijinja+unstable_machinery-devel \
 rust-minijinja+unstable_machinery_serde-devel \
 rust-minijinja+urlencode-devel \
 rust-minijinja+v_htmlescape-devel \
 rust-minijinja-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-minijinja-2.24.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3171bcb3eca45ea78608ae362415e4462427ee625f540e5a213793b53d81694f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+adjacent_loop_items-devel-2.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+adjacent_loop_items-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+adjacent_loop_items-devel.sha256sum] = "c687ceb591c0626721ceb65bfd95bada734ecceb4c354c1097b8a57adddc1a98"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+builtins-devel-2.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+builtins-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+builtins-devel.sha256sum] = "f90a8f345cc871f1105fc6a6d4e93ac33b904f8d0c2137d348a5ac3aa7d8d319"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+custom_syntax-devel-2.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+custom_syntax-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+custom_syntax-devel.sha256sum] = "f273b3c9138d94c48e0ced40df6043e341e57a433779dcb5acddb03bc0c81c9b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+debug-devel-2.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+debug-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+debug-devel.sha256sum] = "b55528eb289f0dacb019383e9f49062dc122e42e5a286e348d3544844b76d2d0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+default-devel-2.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+default-devel.sha256sum] = "edd73e0340b355e49a2747b27a6c4f5e7ce1630252dd3f939ff027d60ca4f1f0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+deserialization-devel-2.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+deserialization-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+deserialization-devel.sha256sum] = "4c1fccbe0880b55fab08ca2c99042de287e3fa96e0184073bceaa75790d74125"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+fuel-devel-2.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+fuel-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+fuel-devel.sha256sum] = "112b7b041010cacbaec72720919be30304a0b9beb583d198e284b7a2836b483a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+indexmap-devel-2.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+indexmap-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+indexmap-devel.sha256sum] = "aea0a2910bc1e1b5775c6fa2556f8739947990572ee1bf0c77db643cfc27a1fb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+internal_debug-devel-2.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+internal_debug-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+internal_debug-devel.sha256sum] = "0cadcad8f53bba062973d589fe38fa16005d96bd1644c2a9dab2a181eaf27534"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+internal_safe_search-devel-2.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+internal_safe_search-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+internal_safe_search-devel.sha256sum] = "df97170e1562995a24ddfc7f3ff253958166e11354b19f3ef5461dd8e9bcb64c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+json-devel-2.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+json-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+json-devel.sha256sum] = "be0cda08a03b22bafc0cb54701748e357473b4479b9d63ad0352d12313667454"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+key_interning-devel-2.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+key_interning-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+key_interning-devel.sha256sum] = "d505c39c1e7f8d7d73103bc73223b403791daf8599d34049da0186ebff36b87e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+loader-devel-2.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+loader-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+loader-devel.sha256sum] = "7d80f4b4ea9877b2734d2c4632cdf5fc8feae3f2fd0d736dc75126d43df27b38"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+loop_controls-devel-2.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+loop_controls-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+loop_controls-devel.sha256sum] = "30c71fd4bb9dbf25865e655612d394606042a9b76bdf3c273f54d27f656356e2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+macros-devel-2.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+macros-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+macros-devel.sha256sum] = "f1e35c2edac9fb22ffa4461d1ac05336780d01baec5f53fd67e274c555d332db"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+multi_template-devel-2.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+multi_template-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+multi_template-devel.sha256sum] = "e11a9a85d9da62d76bb5bcaf253903a7fe94b1927e73cbf828426efe0d3a8b24"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+percent-encoding-devel-2.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+percent-encoding-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+percent-encoding-devel.sha256sum] = "2d17e8b6177f52b509bcb04dc7a715e882cbfd27873810214177502decf59da6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+preserve_order-devel-2.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+preserve_order-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+preserve_order-devel.sha256sum] = "fc8e05a39b6fe1f6b703b969b8adfba5ad9e77b8a53fbcb49686fa4c55e8ebad"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+serde-devel-2.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+serde-devel.sha256sum] = "31268256609b646d789371508524df440a527f8b0580ceda7cd54aa2964919b6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+serde_json-devel-2.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+serde_json-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+serde_json-devel.sha256sum] = "44a7645c155ca4f31ecc6e268ef641f66b7df10e31d53857bbc8ab742ab750be"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+speedups-devel-2.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+speedups-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+speedups-devel.sha256sum] = "a5ffc33d86da8df7f90f261f1b700a1ebb6c5c5e6e82c153e3bd331eee30610c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+stacker-devel-2.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+stacker-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+stacker-devel.sha256sum] = "20fef56077b0a4d03b1b3a5f839fba78536caf116fb35f18214f5bebb78dd162"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+std_collections-devel-2.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+std_collections-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+std_collections-devel.sha256sum] = "311cc14d760df03260062cdec7a0c5df763dd177cc32b226547fb4f1830714f2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+unicase-devel-2.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+unicase-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+unicase-devel.sha256sum] = "4a2cbfd69200b69b5e55182ff1a0e1953bb83ff8a97ce396d147a4f779acddb8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+unicode-devel-2.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+unicode-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+unicode-devel.sha256sum] = "35fc6e9d8e62afad80a60bfc1e7b91eb065d0cf8234214df55d02a2822b08f5d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+unicode-ident-devel-2.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+unicode-ident-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+unicode-ident-devel.sha256sum] = "a3e793d88e7646b218cb5a6a02cc41c7d08786b85aba31cfcfb7be0181ec3b2a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+unstable_machinery-devel-2.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+unstable_machinery-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+unstable_machinery-devel.sha256sum] = "434df9ced8324f5773d0920a3846551a8ab192a54dba0240812171eb03b24c05"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+unstable_machinery_serde-devel-2.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+unstable_machinery_serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+unstable_machinery_serde-devel.sha256sum] = "b89dcb7d1189814c0e3fa549b4e8539a394806feca459cb3d74d350ac10071b2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+urlencode-devel-2.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+urlencode-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+urlencode-devel.sha256sum] = "cccb36decbcbdca246ed4f3e8453458ef36bf0fc9764749babc097ea046274ce"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+v_htmlescape-devel-2.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+v_htmlescape-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja+v_htmlescape-devel.sha256sum] = "498fd2895c6d0857d8f6827a4516a12213f200622695b427bbfb010dcc09f30f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja-devel-2.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja-devel;unpack=0"
SRC_URI[x86_64_v2_rust-minijinja-devel.sha256sum] = "4d99b70ec9e3f0e875370d7512413b192c9988120817dc7c421c9b9f044719b6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+adjacent_loop_items-devel-2.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+adjacent_loop_items-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+adjacent_loop_items-devel.sha256sum] = "c218a14ac3e0da6a8db1c5b6b5c4afe393ccfea4532258fb28decb25d51812c6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+builtins-devel-2.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+builtins-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+builtins-devel.sha256sum] = "308610202cdce143f5415c0c0451cf4a57fa8586ae3a823ccfba6f45f3a60ead"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+custom_syntax-devel-2.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+custom_syntax-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+custom_syntax-devel.sha256sum] = "99be058b2be3f3a490c3be40f133bf4485db36011105d9ba189067ff49daebc9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+debug-devel-2.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+debug-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+debug-devel.sha256sum] = "98b8f733e772e09fcd614586553c598296b2b769475b70bccb309bc0cbf625f0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+default-devel-2.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+default-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+default-devel.sha256sum] = "0170e1ee5156630d302514aab6a602b3ae0d79559b7f8620ab1b7ebc0c3d7c7b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+deserialization-devel-2.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+deserialization-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+deserialization-devel.sha256sum] = "61f0897cb243f0cb06590248daef26a9a96742238ec313e70b0baec526d3fe8b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+fuel-devel-2.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+fuel-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+fuel-devel.sha256sum] = "a4866856f8c8df93f24b7cdca56fb00f5ed7ff7b2d35716972041c5bb8e8367a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+indexmap-devel-2.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+indexmap-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+indexmap-devel.sha256sum] = "147ba02f33e2d27b25d8a31e499ace8304ef9db31da2d3670a85fe1433b740bf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+internal_debug-devel-2.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+internal_debug-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+internal_debug-devel.sha256sum] = "d5e7ae4b7ee4689c86de07e6aecda860f1201a17f9ee89479935fde733b6ee83"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+internal_safe_search-devel-2.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+internal_safe_search-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+internal_safe_search-devel.sha256sum] = "aaf37d93bb9a895fdcb50e4c31a35edf5d02eaf4adff36190d36f90db95da2bd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+json-devel-2.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+json-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+json-devel.sha256sum] = "758eef8043cbcdb1f2b67114b225849e1c240bb47b0f6b59bd531e245972d9fb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+key_interning-devel-2.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+key_interning-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+key_interning-devel.sha256sum] = "b3946dc8d467e0f86ff01e5b2cb2106d9385ca006992985617170311a2f80aae"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+loader-devel-2.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+loader-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+loader-devel.sha256sum] = "24d9f970fae344ac7b0bf93afe1ca34b360a4c24953cda1e069089ef8b4df6c7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+loop_controls-devel-2.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+loop_controls-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+loop_controls-devel.sha256sum] = "9f16d5b608396c67d0db7d4996494870b33f295c6e846b6f896e1b13d91520b9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+macros-devel-2.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+macros-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+macros-devel.sha256sum] = "4db4f518b23cff31df322710fdaa14d651242eddcab140914add356005f5be1f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+multi_template-devel-2.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+multi_template-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+multi_template-devel.sha256sum] = "f080a05793c62770e0fc3857a616487e3f7dbae18eb313428f3ccd5535cc87e6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+percent-encoding-devel-2.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+percent-encoding-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+percent-encoding-devel.sha256sum] = "2cedad4e5500f8d10a33c8b0eed06d20849512e357b3945721bdce8cdcc60f19"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+preserve_order-devel-2.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+preserve_order-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+preserve_order-devel.sha256sum] = "0a9ba15fda0f12fc3a586e97d005cbcef306c10964ffe56d3a1f13d81a7ba4ba"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+serde-devel-2.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+serde-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+serde-devel.sha256sum] = "64ce4185e9f1547d249defb84b942b21d5af5d234d165679df3a40b8694a1ca4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+serde_json-devel-2.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+serde_json-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+serde_json-devel.sha256sum] = "088a5a906c622151598e29da16eb071b7694101af92c52e4864df02cfe357a0a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+speedups-devel-2.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+speedups-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+speedups-devel.sha256sum] = "79d2d261a8ea688774a4fd19d1f05debcb80ffb0883a39eb3da98cd8d4ff9eb6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+stacker-devel-2.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+stacker-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+stacker-devel.sha256sum] = "c4fc3daf5422060b21184a0a54264b06b628843c8827907ed41c0d0d06266a96"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+std_collections-devel-2.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+std_collections-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+std_collections-devel.sha256sum] = "d565c25b1636eeb5251f2329fc4594505dc4965e14b7fd26f27887a43301d07a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+unicase-devel-2.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+unicase-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+unicase-devel.sha256sum] = "3844aa30ed8aafa7eebc8727e05c88211706dee623dd645157110317c5a4d76c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+unicode-devel-2.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+unicode-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+unicode-devel.sha256sum] = "3f2fb79a767c8d90fe72b68b7b6701530142d6692aa828a397825972ce1a87d7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+unicode-ident-devel-2.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+unicode-ident-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+unicode-ident-devel.sha256sum] = "95479301c506fba9bed92ce9d3ee6f4f7d43cd3ffb9ee275de80e1e003d3e570"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+unstable_machinery-devel-2.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+unstable_machinery-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+unstable_machinery-devel.sha256sum] = "e04ea48516ee5bb38e8e640eebfc29745ed248e39581a26fc5604bf9201d8f0f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+unstable_machinery_serde-devel-2.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+unstable_machinery_serde-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+unstable_machinery_serde-devel.sha256sum] = "89794b9127057ce61d791f76e73ddc6f3120d7bdf4cb69a1106fb8b20fb145a2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+urlencode-devel-2.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+urlencode-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+urlencode-devel.sha256sum] = "6179f953cb4efb5bb26a59bc78d5a567c3cb258e7975e1d3ff450af3ebdfcad7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+v_htmlescape-devel-2.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+v_htmlescape-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja+v_htmlescape-devel.sha256sum] = "8fd570e509069eb13ffbccce0fa0769e3b23b9a7aa4bb1b52f3e33f7c9a598c3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja-devel-2.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja-devel;unpack=0"
SRC_URI[aarch64_rust-minijinja-devel.sha256sum] = "d55764f51ee784f873cad993cafb8aaa87c4864367a0c72c2ff35cb50472bf73"

RDEPENDS:rust-minijinja+adjacent_loop_items-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+builtins-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+custom_syntax-devel = " \
 cargo \
 rust-aho-corasick-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+debug-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+default-devel = " \
 cargo \
 rust-minijinja+adjacent_loop_items-devel \
 rust-minijinja+builtins-devel \
 rust-minijinja+debug-devel \
 rust-minijinja+deserialization-devel \
 rust-minijinja+macros-devel \
 rust-minijinja+multi_template-devel \
 rust-minijinja+serde-devel \
 rust-minijinja+std_collections-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+deserialization-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+fuel-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+indexmap-devel = " \
 cargo \
 rust-indexmap+default-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+internal_debug-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+internal_safe_search-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+json-devel = " \
 cargo \
 rust-minijinja+serde_json-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+key_interning-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+loader-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+loop_controls-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+macros-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+multi_template-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+percent-encoding-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-percent-encoding+default-devel \
 "
RDEPENDS:rust-minijinja+preserve_order-devel = " \
 cargo \
 rust-minijinja+indexmap-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+serde-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+serde_json-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-minijinja+speedups-devel = " \
 cargo \
 rust-minijinja+v_htmlescape-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+stacker-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-stacker+default-devel \
 "
RDEPENDS:rust-minijinja+std_collections-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+unicase-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-unicase+default-devel \
 "
RDEPENDS:rust-minijinja+unicode-devel = " \
 cargo \
 rust-minijinja+unicase-devel \
 rust-minijinja+unicode-ident-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+unicode-ident-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-unicode-ident+default-devel \
 "
RDEPENDS:rust-minijinja+unstable_machinery-devel = " \
 cargo \
 rust-minijinja+internal_debug-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+unstable_machinery_serde-devel = " \
 cargo \
 rust-minijinja+unstable_machinery-devel \
 rust-minijinja-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-minijinja+urlencode-devel = " \
 cargo \
 rust-minijinja+percent-encoding-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+v_htmlescape-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-v_htmlescape+default-devel \
 "
RDEPENDS:rust-minijinja-devel = " \
 cargo \
 rust \
 rust-memo-map+default-devel \
 rust-serde+default-devel \
 "
