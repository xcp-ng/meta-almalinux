# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gwenview"
PE = "1"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 gwenview \
 gwenview-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gwenview-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6605a07765bbaf74084e2da914b8943c589e56b459d898042394e45e1c027e7c"

URI_x86_64_v2_gwenview = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gwenview-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gwenview;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gwenview}"
SRC_URI[x86_64_v2_gwenview.sha256sum] = "0f4b934bd82aabe06dc4c0d38e2cfaefc25f21c400cc15a271c74d22b3c90102"

URI_x86_64_v2_gwenview-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gwenview-libs-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gwenview-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gwenview-libs}"
SRC_URI[x86_64_v2_gwenview-libs.sha256sum] = "e2c753382dcc20440a549e81c17a299d25b20a73fec0b94a0420c5ec2769e526"

URI_aarch64_gwenview = "${EPEL_MIRROR}/aarch64/Packages/g/gwenview-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_gwenview;unpack=0"
SRC_URI:append = " ${URI_aarch64_gwenview}"
SRC_URI[aarch64_gwenview.sha256sum] = "77b572e6c6044fbe2c3b2db4a3993b342df3045384149eba7d431e4587ed7f57"

URI_aarch64_gwenview-libs = "${EPEL_MIRROR}/aarch64/Packages/g/gwenview-libs-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_gwenview-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gwenview-libs}"
SRC_URI[aarch64_gwenview-libs.sha256sum] = "b7066edec330dac02f891d10729d3f7da04d2c3d7bc1cfab387634398b23ac88"

RDEPENDS:gwenview = " \
 exiv2-libs \
 glibc \
 gwenview-libs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-purpose \
 kf6-solid \
 kimageannotator-qt6 \
 libgcc \
 libstdc++ \
 libtiff \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:gwenview-libs = " \
 cfitsio \
 exiv2-libs \
 glibc \
 gwenview \
 kf6-baloo-libs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kfilemetadata \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kimageannotator-qt6 \
 lcms2 \
 libX11 \
 libgcc \
 libjpeg-turbo \
 libkdcraw \
 libpng \
 libstdc++ \
 libwayland-client \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
 "
