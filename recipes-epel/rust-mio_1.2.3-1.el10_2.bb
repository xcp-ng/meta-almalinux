# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mio"
PV = "1.2.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-mio+default-devel \
 rust-mio+log-devel \
 rust-mio+net-devel \
 rust-mio+os-ext-devel \
 rust-mio+os-poll-devel \
 rust-mio-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-mio-1.2.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "daebf52631fc0be8475cc227460a4dc04eec43839be97c344fb322b4bacc9dc5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio+default-devel-1.2.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-mio+default-devel.sha256sum] = "31069cd2a6dba7d8ce99f0c243d23842591ae7746468d10e7f7a5469273fb19d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio+log-devel-1.2.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio+log-devel;unpack=0"
SRC_URI[x86_64_v2_rust-mio+log-devel.sha256sum] = "fa06238f09d4e2443a3da1eff713af9bbfe6fbf977cb270c37f7454708cf8f73"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio+net-devel-1.2.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio+net-devel;unpack=0"
SRC_URI[x86_64_v2_rust-mio+net-devel.sha256sum] = "4f385466d229da84475824c6b0bec35b27d00ed32bba1d65d8d62c5d285ab996"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio+os-ext-devel-1.2.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio+os-ext-devel;unpack=0"
SRC_URI[x86_64_v2_rust-mio+os-ext-devel.sha256sum] = "057d49f20e40cb1b9bd00ee8a1984282d2826d27348c4c62b25967494047b732"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio+os-poll-devel-1.2.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio+os-poll-devel;unpack=0"
SRC_URI[x86_64_v2_rust-mio+os-poll-devel.sha256sum] = "85958d9939693ade4de47f3bcef0feed55d9e2652d0a198782b414ba1e160ca5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio-devel-1.2.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio-devel;unpack=0"
SRC_URI[x86_64_v2_rust-mio-devel.sha256sum] = "a137ef24a2b98f54da28bdc7fcc319e97c2a1a35facdd7050680d9694576ec0b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-mio+default-devel-1.2.3-1.el10_2.noarch.rpm;name=aarch64_rust-mio+default-devel;unpack=0"
SRC_URI[aarch64_rust-mio+default-devel.sha256sum] = "bf0ae875549eb9a2703dc9734f55a395bd877f33cbf6d984aa709fddf8c1e441"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-mio+log-devel-1.2.3-1.el10_2.noarch.rpm;name=aarch64_rust-mio+log-devel;unpack=0"
SRC_URI[aarch64_rust-mio+log-devel.sha256sum] = "b81deac5c3afd333a76cb06c5b39f50fafca7fc0b5d4f6d0e9bafbfe73f9da6b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-mio+net-devel-1.2.3-1.el10_2.noarch.rpm;name=aarch64_rust-mio+net-devel;unpack=0"
SRC_URI[aarch64_rust-mio+net-devel.sha256sum] = "a5f909a2d2754384783c2f2fc779e767b5054e360a906658b1d98e9aafd844f0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-mio+os-ext-devel-1.2.3-1.el10_2.noarch.rpm;name=aarch64_rust-mio+os-ext-devel;unpack=0"
SRC_URI[aarch64_rust-mio+os-ext-devel.sha256sum] = "e55d657bacec3ec807ce6af6959a0a73593e74491fe94d032ce31a331cfd1fe0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-mio+os-poll-devel-1.2.3-1.el10_2.noarch.rpm;name=aarch64_rust-mio+os-poll-devel;unpack=0"
SRC_URI[aarch64_rust-mio+os-poll-devel.sha256sum] = "89faf22233841f6705b271eff4bf1450e8a2e1d8716621e9b820d478a9e6a427"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-mio-devel-1.2.3-1.el10_2.noarch.rpm;name=aarch64_rust-mio-devel;unpack=0"
SRC_URI[aarch64_rust-mio-devel.sha256sum] = "65984c0787927a206636eb4dee65f171aa6f1831f399803e9a71b3a54b99879a"

RDEPENDS:rust-mio+default-devel = " \
 cargo \
 rust-mio+log-devel \
 rust-mio-devel \
 "
RDEPENDS:rust-mio+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-mio-devel \
 "
RDEPENDS:rust-mio+net-devel = " \
 cargo \
 rust-mio-devel \
 "
RDEPENDS:rust-mio+os-ext-devel = " \
 cargo \
 rust-mio+os-poll-devel \
 rust-mio-devel \
 "
RDEPENDS:rust-mio+os-poll-devel = " \
 cargo \
 rust-mio-devel \
 "
RDEPENDS:rust-mio-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
