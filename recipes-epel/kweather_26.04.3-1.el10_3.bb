# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kweather"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kweather \
 kweather-plasma-applet \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kweather-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "05ec7478a0900bddd3c8a5b4080eb7b68848b3de5c0eb822b2c5dcfab6f0158b"

URI_x86_64_v2_kweather = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kweather-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kweather;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kweather}"
SRC_URI[x86_64_v2_kweather.sha256sum] = "84c9ec5955ea35cf93d5309cd3b110d7abb9d70332efc2ca87292652cb6fef94"

URI_x86_64_v2_kweather-plasma-applet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kweather-plasma-applet-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kweather-plasma-applet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kweather-plasma-applet}"
SRC_URI[x86_64_v2_kweather-plasma-applet.sha256sum] = "b1aadfc69efa7672026d27e31888d7dcb8a215d435d5db39dccbdc5aac66f871"

URI_aarch64_kweather = "${EPEL_MIRROR}/aarch64/Packages/k/kweather-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kweather;unpack=0"
SRC_URI:append = " ${URI_aarch64_kweather}"
SRC_URI[aarch64_kweather.sha256sum] = "0288097558fece0b2d620f515eb8e28d5410fec825c643555c0fc4199f68de05"

URI_aarch64_kweather-plasma-applet = "${EPEL_MIRROR}/aarch64/Packages/k/kweather-plasma-applet-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kweather-plasma-applet;unpack=0"
SRC_URI:append = " ${URI_aarch64_kweather-plasma-applet}"
SRC_URI[aarch64_kweather-plasma-applet.sha256sum] = "e6a0837674ba4850d1f3e8564112a23fa5395ab915ecedaec02550cd9ee7110f"

RDEPENDS:kweather = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kweathercore \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtcharts \
 qt6-qtdeclarative \
 "
RDEPENDS:kweather-plasma-applet = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kirigami \
 kf6-kirigami-addons \
 kweather \
 kweathercore \
 libplasma \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
