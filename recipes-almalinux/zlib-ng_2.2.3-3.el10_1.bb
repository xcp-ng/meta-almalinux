# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zlib-ng"
PV = "2.2.3"
PR = "3.el10_1"
PACKAGES = " \
 zlib-ng \
 zlib-ng-compat \
 zlib-ng-compat-devel \
 zlib-ng-compat-static \
 zlib-ng-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/zlib-ng-2.2.3-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1dcf875bf192e77a634edb230b6acd079437a6a6a63ff8b58bbe94142143e306"

URI_x86_64_v2_zlib-ng = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/zlib-ng-2.2.3-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_zlib-ng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zlib-ng}"
SRC_URI[x86_64_v2_zlib-ng.sha256sum] = "7283c204f67884c2b17c84b23246d7fee270a254cf772ebc5164e86ed0ddb128"

URI_x86_64_v2_zlib-ng-compat = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/zlib-ng-compat-2.2.3-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_zlib-ng-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zlib-ng-compat}"
SRC_URI[x86_64_v2_zlib-ng-compat.sha256sum] = "eefbe56b0c95282bdc455187f0bd955435766568029bebf3fa991bbccaf163f4"

URI_x86_64_v2_zlib-ng-compat-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/zlib-ng-compat-devel-2.2.3-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_zlib-ng-compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zlib-ng-compat-devel}"
SRC_URI[x86_64_v2_zlib-ng-compat-devel.sha256sum] = "b3a4bf4e9c7ca5d05b1c0862b9ea156c0fe735841b41edbabfe407221b037b84"

URI_x86_64_v2_zlib-ng-compat-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/zlib-ng-compat-static-2.2.3-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_zlib-ng-compat-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zlib-ng-compat-static}"
SRC_URI[x86_64_v2_zlib-ng-compat-static.sha256sum] = "462ebd4e9386dd184fcbeb9080f536db5c5c3d4b9e2dbd7e0d8ddecdcea017df"

URI_x86_64_v2_zlib-ng-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/zlib-ng-devel-2.2.3-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_zlib-ng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zlib-ng-devel}"
SRC_URI[x86_64_v2_zlib-ng-devel.sha256sum] = "58400ffb84a2b914871cbfb2e1cacd32c66f34646e9b72c5b6b05d35574f841f"

URI_aarch64_zlib-ng = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/zlib-ng-2.2.3-3.el10_1.aarch64.rpm;name=aarch64_zlib-ng;unpack=0"
SRC_URI:append = " ${URI_aarch64_zlib-ng}"
SRC_URI[aarch64_zlib-ng.sha256sum] = "7880c696457502d27ba3dc4c7b9231d6bf9cfd18936588eb0e9c2f0a2516b946"

URI_aarch64_zlib-ng-compat = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/zlib-ng-compat-2.2.3-3.el10_1.aarch64.rpm;name=aarch64_zlib-ng-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_zlib-ng-compat}"
SRC_URI[aarch64_zlib-ng-compat.sha256sum] = "a62949e0682aa706f3d523c0361d31965779e13d63d40432ed70edbc3406e771"

URI_aarch64_zlib-ng-compat-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/zlib-ng-compat-devel-2.2.3-3.el10_1.aarch64.rpm;name=aarch64_zlib-ng-compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_zlib-ng-compat-devel}"
SRC_URI[aarch64_zlib-ng-compat-devel.sha256sum] = "c79dae104887d9a403b077a8dd7875887a8f43b8010cd112c233c700f6f5e2a1"

URI_aarch64_zlib-ng-compat-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/zlib-ng-compat-static-2.2.3-3.el10_1.aarch64.rpm;name=aarch64_zlib-ng-compat-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_zlib-ng-compat-static}"
SRC_URI[aarch64_zlib-ng-compat-static.sha256sum] = "28b6f928c236c4522d6d72639c75ee1991618cced1ccad82768b89a4c70eda1d"

URI_aarch64_zlib-ng-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/zlib-ng-devel-2.2.3-3.el10_1.aarch64.rpm;name=aarch64_zlib-ng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_zlib-ng-devel}"
SRC_URI[aarch64_zlib-ng-devel.sha256sum] = "04dd165f9ac32251856da1ed62e3e3498ce70e136deca74beb767bfe8c43a6c1"

RDEPENDS:zlib-ng = " \
 glibc \
 "
RDEPENDS:zlib-ng-compat = " \
 glibc \
 "
RDEPENDS:zlib-ng-compat-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 zlib-ng-compat \
 "
RDEPENDS:zlib-ng-compat-static = " \
 zlib-ng-compat-devel \
 "
RDEPENDS:zlib-ng-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 zlib-ng \
 "
