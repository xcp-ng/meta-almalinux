# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iniparser"
PV = "4.1"
PR = "18.el10"
PACKAGES = " \
 iniparser \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/iniparser-4.1-18.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "82abb896c21fb97df2e4600c7394fe135098ec495cdafd57cd1c76f05cfe31b2"

URI_x86_64_v2_iniparser = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iniparser-4.1-18.el10.x86_64_v2.rpm;name=x86_64_v2_iniparser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iniparser}"
SRC_URI[x86_64_v2_iniparser.sha256sum] = "ad249d4dded3b5b142ff89b28c6021be97b9a968845e99e60c4eda186d8ed86b"

URI_aarch64_iniparser = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iniparser-4.1-18.el10.aarch64.rpm;name=aarch64_iniparser;unpack=0"
SRC_URI:append = " ${URI_aarch64_iniparser}"
SRC_URI[aarch64_iniparser.sha256sum] = "58c701d15b80c16e7e3cc0ec80295eb05fb5245cb78870fdf451bc64312e06bc"

RDEPENDS:iniparser = " \
 glibc \
 "
