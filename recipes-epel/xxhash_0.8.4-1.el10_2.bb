# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xxhash"
PV = "0.8.4"
PR = "1.el10_2"
PACKAGES = " \
 xxhash \
 xxhash-devel \
 xxhash-doc \
 xxhash-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/x/xxhash-0.8.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0a1ab1b7f54bc35466df9593e7ac9a3dad3c5b5e6d4977d9c4d5e415ee3ff3dc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xxhash-0.8.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xxhash;unpack=0"
SRC_URI[x86_64_v2_xxhash.sha256sum] = "91f1e8d7d2f64c4717e00f19a85b5f571a8c7ac367bb25a0ea3f2a2e281ffdd3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xxhash-devel-0.8.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xxhash-devel;unpack=0"
SRC_URI[x86_64_v2_xxhash-devel.sha256sum] = "1661c6e76198481e1f0b94c8961906c2f90f1b91f92878058be11785b3790f1d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xxhash-doc-0.8.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_xxhash-doc;unpack=0"
SRC_URI[x86_64_v2_xxhash-doc.sha256sum] = "71b3c41df956ef7224e37e3aba1b65d55d8aa3bb7c0386d558112d79a724953d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xxhash-libs-0.8.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xxhash-libs;unpack=0"
SRC_URI[x86_64_v2_xxhash-libs.sha256sum] = "e741146e5c34257dc50bf422fd44cedee417efff01edc94beb23c25618e99e09"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xxhash-0.8.4-1.el10_2.aarch64.rpm;name=aarch64_xxhash;unpack=0"
SRC_URI[aarch64_xxhash.sha256sum] = "4cd8fa0581a4204c21077756eb3f8f8d880a194e31b6d3c2d51ebb11997f94e8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xxhash-devel-0.8.4-1.el10_2.aarch64.rpm;name=aarch64_xxhash-devel;unpack=0"
SRC_URI[aarch64_xxhash-devel.sha256sum] = "2bbfcf764accd83eca6603a386c9adfea9cbd9ccafda1bc721564feeb9b973ab"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xxhash-doc-0.8.4-1.el10_2.noarch.rpm;name=aarch64_xxhash-doc;unpack=0"
SRC_URI[aarch64_xxhash-doc.sha256sum] = "e38905883746b5209b71216c13931032e52e28bcdc87b041c64a91b225e2b8e4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xxhash-libs-0.8.4-1.el10_2.aarch64.rpm;name=aarch64_xxhash-libs;unpack=0"
SRC_URI[aarch64_xxhash-libs.sha256sum] = "0c74d292c1533710227fd94cd027f4674a32c66453b928c7c8fd01bfce38f5c6"

RDEPENDS:xxhash = " \
 glibc \
 "
RDEPENDS:xxhash-devel = " \
 pkgconf-pkg-config \
 xxhash-libs \
 "
RDEPENDS:xxhash-doc = " \
 "
RDEPENDS:xxhash-libs = " \
 glibc \
 "
