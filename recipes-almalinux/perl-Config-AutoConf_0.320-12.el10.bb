# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Config-AutoConf"
PV = "0.320"
PR = "12.el10"
PACKAGES = " \
 perl-Config-AutoConf \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Config-AutoConf-0.320-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19457b05bc6cf612d443541d47639820bd93d175080e89f38f1db6b43912bc91"

URI_x86_64_v2_perl-Config-AutoConf = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Config-AutoConf-0.320-12.el10.noarch.rpm;name=x86_64_v2_perl-Config-AutoConf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Config-AutoConf}"
SRC_URI[x86_64_v2_perl-Config-AutoConf.sha256sum] = "b7d93efdc78b811cb007c093f921c2fcf713c016834e70fd840dce7bd6257bb0"

URI_aarch64_perl-Config-AutoConf = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Config-AutoConf-0.320-12.el10.noarch.rpm;name=aarch64_perl-Config-AutoConf;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Config-AutoConf}"
SRC_URI[aarch64_perl-Config-AutoConf.sha256sum] = "b7d93efdc78b811cb007c093f921c2fcf713c016834e70fd840dce7bd6257bb0"

RDEPENDS:perl-Config-AutoConf = " \
 perl-Capture-Tiny \
 perl-Carp \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Temp \
 perl-PathTools \
 perl-Text-ParseWords \
 perl-base \
 perl-constant \
 perl-libs \
 "
