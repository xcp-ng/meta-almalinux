# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsamplerate"
PV = "0.2.2"
PR = "10.el10"
PACKAGES = " \
 libsamplerate \
 libsamplerate-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libsamplerate-0.2.2-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "013f214931150457d5f7883030432a7c6d468a4dae5a8f1170c1af5414dc36fc"

URI_x86_64_v2_libsamplerate = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsamplerate-0.2.2-10.el10.x86_64_v2.rpm;name=x86_64_v2_libsamplerate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsamplerate}"
SRC_URI[x86_64_v2_libsamplerate.sha256sum] = "b082b74654f803bee7737052c444f3aae8e3a7df96c24942b1e7344a6f6f297b"

URI_x86_64_v2_libsamplerate-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsamplerate-devel-0.2.2-10.el10.x86_64_v2.rpm;name=x86_64_v2_libsamplerate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsamplerate-devel}"
SRC_URI[x86_64_v2_libsamplerate-devel.sha256sum] = "102ea12bf2b709af6063d42e04c019cb1545c1c4679751b55379416a9f8d550b"

URI_aarch64_libsamplerate = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsamplerate-0.2.2-10.el10.aarch64.rpm;name=aarch64_libsamplerate;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsamplerate}"
SRC_URI[aarch64_libsamplerate.sha256sum] = "ea429a48e5ee4041c8932f88ee6645143694011b4289549d8bb3f573c62d5e8b"

URI_aarch64_libsamplerate-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsamplerate-devel-0.2.2-10.el10.aarch64.rpm;name=aarch64_libsamplerate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsamplerate-devel}"
SRC_URI[aarch64_libsamplerate-devel.sha256sum] = "59e1daa592bc140cebabf6d1a87df52a609ca5ae6a4b85caaa3fd33ade908b1d"

RDEPENDS:libsamplerate = " \
 glibc \
 "
RDEPENDS:libsamplerate-devel = " \
 libsamplerate \
 pkgconf-pkg-config \
 "
