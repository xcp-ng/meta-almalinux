# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-polyparse"
PV = "1.13"
PR = "23.el10_0"
PACKAGES = " \
 ghc-polyparse \
 ghc-polyparse-devel \
 ghc-polyparse-doc \
 ghc-polyparse-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-polyparse-1.13-23.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1a8ab77b0146b262f7f7c69577cc58f2a56d9899138c2a5bac2ba161fed91a88"

URI_x86_64_v2_ghc-polyparse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-polyparse-1.13-23.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-polyparse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-polyparse}"
SRC_URI[x86_64_v2_ghc-polyparse.sha256sum] = "8a1f9b2e91684390972360536cb290723ed0c35ab374c156dd5f05b8b67f93f1"

URI_x86_64_v2_ghc-polyparse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-polyparse-devel-1.13-23.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-polyparse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-polyparse-devel}"
SRC_URI[x86_64_v2_ghc-polyparse-devel.sha256sum] = "cefcb7390b4568c6dead969ddd61753410b4eb7796e31eb7862403d02ec5e09c"

URI_x86_64_v2_ghc-polyparse-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-polyparse-doc-1.13-23.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-polyparse-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-polyparse-doc}"
SRC_URI[x86_64_v2_ghc-polyparse-doc.sha256sum] = "42bea1acedf549df10ff6277c9c2d37df0be07d32ab68a61bd0e7e44349ea411"

URI_x86_64_v2_ghc-polyparse-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-polyparse-prof-1.13-23.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-polyparse-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-polyparse-prof}"
SRC_URI[x86_64_v2_ghc-polyparse-prof.sha256sum] = "86f891ab6b24caf4c603c2d18f1a0c71ec54b0173739906235f9688a413b4c78"

URI_aarch64_ghc-polyparse = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-polyparse-1.13-23.el10_0.aarch64.rpm;name=aarch64_ghc-polyparse;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-polyparse}"
SRC_URI[aarch64_ghc-polyparse.sha256sum] = "5600d1e862d13036e259bdbf7295c66c2810da0b8cde86ae9ef68c04d0a5043d"

URI_aarch64_ghc-polyparse-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-polyparse-devel-1.13-23.el10_0.aarch64.rpm;name=aarch64_ghc-polyparse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-polyparse-devel}"
SRC_URI[aarch64_ghc-polyparse-devel.sha256sum] = "9c27a7bdf044c276b89156a72f4ce13196a4fd0f1894b562d7ef1ecf442e98ac"

URI_aarch64_ghc-polyparse-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-polyparse-doc-1.13-23.el10_0.noarch.rpm;name=aarch64_ghc-polyparse-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-polyparse-doc}"
SRC_URI[aarch64_ghc-polyparse-doc.sha256sum] = "cbb0f9ea17d5da3a4fb88003c352a4e9d20011069da2dd05e392ea862c378135"

URI_aarch64_ghc-polyparse-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-polyparse-prof-1.13-23.el10_0.aarch64.rpm;name=aarch64_ghc-polyparse-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-polyparse-prof}"
SRC_URI[aarch64_ghc-polyparse-prof.sha256sum] = "b70e59391bf60a2a224f1e33882e2aa13c6f6ee7918e77b9ae9ccad3e03aa38b"

RDEPENDS:ghc-polyparse = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 glibc \
 gmp \
 "
RDEPENDS:ghc-polyparse-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-polyparse \
 ghc-text-devel \
 "
RDEPENDS:ghc-polyparse-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-polyparse-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-polyparse-devel \
 ghc-text-prof \
 "
