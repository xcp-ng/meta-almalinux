# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dotnet10.0"
PV = "10.0.111"
PR = "2.el10"
PACKAGES = " \
 aspnetcore-runtime-10.0 \
 aspnetcore-runtime-dbg-10.0 \
 aspnetcore-targeting-pack-10.0 \
 dotnet-apphost-pack-10.0 \
 dotnet-host \
 dotnet-hostfxr-10.0 \
 dotnet-runtime-10.0 \
 dotnet-runtime-dbg-10.0 \
 dotnet-sdk-10.0 \
 dotnet-sdk-10.0-source-built-artifacts \
 dotnet-sdk-aot-10.0 \
 dotnet-sdk-dbg-10.0 \
 dotnet-targeting-pack-10.0 \
 dotnet-templates-10.0 \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dotnet10.0-10.0.111-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5404e653ceee78952bd010e4a030c8606edd95be70a2dfd3cd013f3d3da81251"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-10.0-10.0.11-2.el10.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-10.0;unpack=0"
SRC_URI[x86_64_v2_aspnetcore-runtime-10.0.sha256sum] = "ffaa49251dd4569eef13f8b7cca338d4563a2ec68b443b9503fe4a6e12410c1e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-dbg-10.0-10.0.11-2.el10.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-dbg-10.0;unpack=0"
SRC_URI[x86_64_v2_aspnetcore-runtime-dbg-10.0.sha256sum] = "85c35ef115ff3e50be36436a9e2012f9d56aaca3ccb74e9d4b8a8d6039a8607b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-targeting-pack-10.0-10.0.11-2.el10.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-targeting-pack-10.0;unpack=0"
SRC_URI[x86_64_v2_aspnetcore-targeting-pack-10.0.sha256sum] = "e4a478b08b52229b1141418f9a5db8b3f698c8c6e45f21ac188a2da907e40d9f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-apphost-pack-10.0-10.0.11-2.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-apphost-pack-10.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-apphost-pack-10.0.sha256sum] = "33bc0590a75d494b2e9e2a65fca03414468157664aab7af62f519af3db611d58"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-host-10.0.11-2.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-host;unpack=0"
SRC_URI[x86_64_v2_dotnet-host.sha256sum] = "4ccbbfc5c651c7b8425b1268c3ba1dcfb705b893cca0cfb6c31fb8f38186ba4b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-hostfxr-10.0-10.0.11-2.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-hostfxr-10.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-hostfxr-10.0.sha256sum] = "a6676c3bd86c62c8225aee81a3b3c67157cc66966ee3079b64947cec30778030"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-10.0-10.0.11-2.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-10.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-runtime-10.0.sha256sum] = "c3725bbfa7a622744807175f699e9138781f9786cf33ab2f529e194e6e88153a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-dbg-10.0-10.0.11-2.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-dbg-10.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-runtime-dbg-10.0.sha256sum] = "aea259a8280f83ae9506c513014e143e0ef93068a3192627abd98265a2f3a4b6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-10.0-10.0.111-2.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-10.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-sdk-10.0.sha256sum] = "847a62f5416b5fc8f1ab4383d897f78de5404e356a4750e9f03810b38b2eaf28"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dotnet-sdk-10.0-source-built-artifacts-10.0.111-2.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-10.0-source-built-artifacts;unpack=0"
SRC_URI[x86_64_v2_dotnet-sdk-10.0-source-built-artifacts.sha256sum] = "47224ee3e98adfd7b3fdbaee6f855b8ceec5217905ff0a2d3419993c1431ac5e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-aot-10.0-10.0.111-2.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-aot-10.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-sdk-aot-10.0.sha256sum] = "f3c53cdd8b17d9637802bd218f1cca5f618060e01644cdd9e0ca589ea41a0d2f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-dbg-10.0-10.0.111-2.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-dbg-10.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-sdk-dbg-10.0.sha256sum] = "0e844296495e6b309057b43e56c738a4a3deaea785fcbf6e8810b319e03fcb30"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-targeting-pack-10.0-10.0.11-2.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-targeting-pack-10.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-targeting-pack-10.0.sha256sum] = "155b1f70d4f611c9a670adbeb2565bac3dfd48ec7de71c398da86cb6795bc47e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-templates-10.0-10.0.111-2.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-templates-10.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-templates-10.0.sha256sum] = "f33c2b47df938b6cb97dd231fd88cdcfdef3be5441707cabb72f19df782dc92b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-10.0-10.0.11-2.el10.aarch64.rpm;name=aarch64_aspnetcore-runtime-10.0;unpack=0"
SRC_URI[aarch64_aspnetcore-runtime-10.0.sha256sum] = "3ff39df6079e9691656277c3a4940204808aa19c06fac82c50b4ad27943b2c25"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-dbg-10.0-10.0.11-2.el10.aarch64.rpm;name=aarch64_aspnetcore-runtime-dbg-10.0;unpack=0"
SRC_URI[aarch64_aspnetcore-runtime-dbg-10.0.sha256sum] = "1684e5612b0de4f9c3d3dfebc3b59d6baacb6b4ddb88f34864868a58084b9861"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-targeting-pack-10.0-10.0.11-2.el10.aarch64.rpm;name=aarch64_aspnetcore-targeting-pack-10.0;unpack=0"
SRC_URI[aarch64_aspnetcore-targeting-pack-10.0.sha256sum] = "6ab91dcacdc68b454a49e4a07084e9bc14ce2d5fc0be5d97a909afac775f07cb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-apphost-pack-10.0-10.0.11-2.el10.aarch64.rpm;name=aarch64_dotnet-apphost-pack-10.0;unpack=0"
SRC_URI[aarch64_dotnet-apphost-pack-10.0.sha256sum] = "95d798eda1100429dbaa068aea2ebe08ca35cd5c4a412c061a4c21e3ece2b0d5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-host-10.0.11-2.el10.aarch64.rpm;name=aarch64_dotnet-host;unpack=0"
SRC_URI[aarch64_dotnet-host.sha256sum] = "1a0d7185784d818e5691883b22ee5db1f9f39f356ca3bcc4e24505a9fb39a123"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-hostfxr-10.0-10.0.11-2.el10.aarch64.rpm;name=aarch64_dotnet-hostfxr-10.0;unpack=0"
SRC_URI[aarch64_dotnet-hostfxr-10.0.sha256sum] = "f5c13dffef92ffccd61663b91bbf97deadd2ae590ef35807425f04c3c88469b7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-10.0-10.0.11-2.el10.aarch64.rpm;name=aarch64_dotnet-runtime-10.0;unpack=0"
SRC_URI[aarch64_dotnet-runtime-10.0.sha256sum] = "a300536d745504ab5ece14a494f65dac984a52d08706e8552c226bf3414a5d6f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-dbg-10.0-10.0.11-2.el10.aarch64.rpm;name=aarch64_dotnet-runtime-dbg-10.0;unpack=0"
SRC_URI[aarch64_dotnet-runtime-dbg-10.0.sha256sum] = "d71c3372b0efab9ae01ffe4a4b152cc9afff2500bdc0170616dbbd198f616399"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-10.0-10.0.111-2.el10.aarch64.rpm;name=aarch64_dotnet-sdk-10.0;unpack=0"
SRC_URI[aarch64_dotnet-sdk-10.0.sha256sum] = "54bff28de09d1096e92ed7d817c161fa3ed08b9c2b2402a52124e34717725d1d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dotnet-sdk-10.0-source-built-artifacts-10.0.111-2.el10.aarch64.rpm;name=aarch64_dotnet-sdk-10.0-source-built-artifacts;unpack=0"
SRC_URI[aarch64_dotnet-sdk-10.0-source-built-artifacts.sha256sum] = "78ad59cf0d2792eb8f498c09077ee37cc2e10e335499c26499d3f73792e7141c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-aot-10.0-10.0.111-2.el10.aarch64.rpm;name=aarch64_dotnet-sdk-aot-10.0;unpack=0"
SRC_URI[aarch64_dotnet-sdk-aot-10.0.sha256sum] = "0c213d4c36c3dd190cd9500741921f8cdb042d6aafe91578fd9d0634f873aefb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-dbg-10.0-10.0.111-2.el10.aarch64.rpm;name=aarch64_dotnet-sdk-dbg-10.0;unpack=0"
SRC_URI[aarch64_dotnet-sdk-dbg-10.0.sha256sum] = "a371e305e835204f72afa888e3177b26b32f8048f4649862653bda561523efa2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-targeting-pack-10.0-10.0.11-2.el10.aarch64.rpm;name=aarch64_dotnet-targeting-pack-10.0;unpack=0"
SRC_URI[aarch64_dotnet-targeting-pack-10.0.sha256sum] = "a335429462c226e3197da2efaf4088ccb9535d7e199dc2936f0968682819887a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-templates-10.0-10.0.111-2.el10.aarch64.rpm;name=aarch64_dotnet-templates-10.0;unpack=0"
SRC_URI[aarch64_dotnet-templates-10.0.sha256sum] = "4e4b17273b14d8abc967d0500a58237cf3ec02384af03ca58b9595e306e43528"

RDEPENDS:aspnetcore-runtime-10.0 = " \
 dotnet-runtime-10.0 \
 "
RDEPENDS:aspnetcore-runtime-dbg-10.0 = " \
 aspnetcore-runtime-10.0 \
 "
RDEPENDS:aspnetcore-targeting-pack-10.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-apphost-pack-10.0 = " \
 dotnet-host \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-host = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:dotnet-hostfxr-10.0 = " \
 dotnet-host \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:dotnet-runtime-10.0 = " \
 dotnet-hostfxr-10.0 \
 glibc \
 libbrotli \
 libgcc \
 libicu \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-runtime-dbg-10.0 = " \
 dotnet-runtime-10.0 \
 "
RDEPENDS:dotnet-sdk-10.0 = " \
 aspnetcore-runtime-10.0 \
 aspnetcore-targeting-pack-10.0 \
 dotnet-apphost-pack-10.0 \
 dotnet-runtime-10.0 \
 dotnet-targeting-pack-10.0 \
 dotnet-templates-10.0 \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:dotnet-sdk-10.0-source-built-artifacts = " \
 "
RDEPENDS:dotnet-sdk-aot-10.0 = " \
 brotli-devel \
 clang \
 dotnet-sdk-10.0 \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 openssl-devel \
 openssl-libs \
 zlib-ng-compat \
 zlib-ng-compat-devel \
 "
RDEPENDS:dotnet-sdk-dbg-10.0 = " \
 dotnet-sdk-10.0 \
 "
RDEPENDS:dotnet-targeting-pack-10.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-templates-10.0 = " \
 dotnet-host \
 "
