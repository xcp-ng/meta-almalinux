# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Apache-Session-Browseable"
PV = "1.3.19"
PR = "1.el10_3"
PACKAGES = " \
 perl-Apache-Session-Browseable \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Apache-Session-Browseable-1.3.19-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa7352d238f327e978c23c049b7db5f26865c430efef2ca8db22c5642f1dbfcc"

URI_x86_64_v2_perl-Apache-Session-Browseable = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Apache-Session-Browseable-1.3.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Apache-Session-Browseable;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Apache-Session-Browseable}"
SRC_URI[x86_64_v2_perl-Apache-Session-Browseable.sha256sum] = "58f24dac20f9b458948e1ef0e7b3fc2ad2be965454b965417b9f71134c08a0a4"

URI_aarch64_perl-Apache-Session-Browseable = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Apache-Session-Browseable-1.3.19-1.el10_3.noarch.rpm;name=aarch64_perl-Apache-Session-Browseable;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Apache-Session-Browseable}"
SRC_URI[aarch64_perl-Apache-Session-Browseable.sha256sum] = "61edd917d3d4e72bb9f669ce2fc4f8d245a9fe60ddc5c852ce3d518d228c9182"

RDEPENDS:perl-Apache-Session-Browseable = " \
 perl-Apache-Session \
 perl-Apache-Session-Browseable \
 perl-AutoLoader \
 perl-Crypt-URandom \
 perl-DBI \
 perl-Digest-SHA \
 perl-JSON \
 perl-LDAP \
 perl-MIME-Base64 \
 perl-Redis \
 perl-Storable \
 perl-constant \
 perl-libs \
 perl-vars \
 "
