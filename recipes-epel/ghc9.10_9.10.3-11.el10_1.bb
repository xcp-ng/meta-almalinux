# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc9.10"
PV = "9.10.3"
PR = "11.el10_1"
PACKAGES:x86_64_v2 = " \
 ghc9.10 \
 ghc9.10-Cabal \
 ghc9.10-Cabal-devel \
 ghc9.10-Cabal-doc \
 ghc9.10-Cabal-syntax \
 ghc9.10-Cabal-syntax-devel \
 ghc9.10-Cabal-syntax-doc \
 ghc9.10-array \
 ghc9.10-array-devel \
 ghc9.10-array-doc \
 ghc9.10-base \
 ghc9.10-base-devel \
 ghc9.10-base-doc \
 ghc9.10-binary \
 ghc9.10-binary-devel \
 ghc9.10-binary-doc \
 ghc9.10-bytestring \
 ghc9.10-bytestring-devel \
 ghc9.10-bytestring-doc \
 ghc9.10-compiler \
 ghc9.10-compiler-default \
 ghc9.10-containers \
 ghc9.10-containers-devel \
 ghc9.10-containers-doc \
 ghc9.10-deepseq \
 ghc9.10-deepseq-devel \
 ghc9.10-deepseq-doc \
 ghc9.10-devel \
 ghc9.10-directory \
 ghc9.10-directory-devel \
 ghc9.10-directory-doc \
 ghc9.10-doc \
 ghc9.10-doc-index \
 ghc9.10-exceptions \
 ghc9.10-exceptions-devel \
 ghc9.10-exceptions-doc \
 ghc9.10-filepath \
 ghc9.10-filepath-devel \
 ghc9.10-filepath-doc \
 ghc9.10-filesystem \
 ghc9.10-ghc \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-bignum-devel \
 ghc9.10-ghc-bignum-doc \
 ghc9.10-ghc-boot \
 ghc9.10-ghc-boot-devel \
 ghc9.10-ghc-boot-doc \
 ghc9.10-ghc-boot-th \
 ghc9.10-ghc-boot-th-devel \
 ghc9.10-ghc-boot-th-doc \
 ghc9.10-ghc-compact \
 ghc9.10-ghc-compact-devel \
 ghc9.10-ghc-compact-doc \
 ghc9.10-ghc-devel \
 ghc9.10-ghc-doc \
 ghc9.10-ghc-experimental \
 ghc9.10-ghc-experimental-devel \
 ghc9.10-ghc-experimental-doc \
 ghc9.10-ghc-heap \
 ghc9.10-ghc-heap-devel \
 ghc9.10-ghc-heap-doc \
 ghc9.10-ghc-platform \
 ghc9.10-ghc-platform-devel \
 ghc9.10-ghc-platform-doc \
 ghc9.10-ghc-toolchain \
 ghc9.10-ghc-toolchain-devel \
 ghc9.10-ghc-toolchain-doc \
 ghc9.10-ghci \
 ghc9.10-ghci-devel \
 ghc9.10-ghci-doc \
 ghc9.10-hadrian \
 ghc9.10-haskeline \
 ghc9.10-haskeline-devel \
 ghc9.10-haskeline-doc \
 ghc9.10-hpc \
 ghc9.10-hpc-devel \
 ghc9.10-hpc-doc \
 ghc9.10-manual \
 ghc9.10-mtl \
 ghc9.10-mtl-devel \
 ghc9.10-mtl-doc \
 ghc9.10-os-string \
 ghc9.10-os-string-devel \
 ghc9.10-os-string-doc \
 ghc9.10-parsec \
 ghc9.10-parsec-devel \
 ghc9.10-parsec-doc \
 ghc9.10-pretty \
 ghc9.10-pretty-devel \
 ghc9.10-pretty-doc \
 ghc9.10-process \
 ghc9.10-process-devel \
 ghc9.10-process-doc \
 ghc9.10-semaphore-compat \
 ghc9.10-semaphore-compat-devel \
 ghc9.10-semaphore-compat-doc \
 ghc9.10-stm \
 ghc9.10-stm-devel \
 ghc9.10-stm-doc \
 ghc9.10-template-haskell \
 ghc9.10-template-haskell-devel \
 ghc9.10-template-haskell-doc \
 ghc9.10-terminfo \
 ghc9.10-terminfo-devel \
 ghc9.10-terminfo-doc \
 ghc9.10-text \
 ghc9.10-text-devel \
 ghc9.10-text-doc \
 ghc9.10-time \
 ghc9.10-time-devel \
 ghc9.10-time-doc \
 ghc9.10-transformers \
 ghc9.10-transformers-devel \
 ghc9.10-transformers-doc \
 ghc9.10-unix \
 ghc9.10-unix-devel \
 ghc9.10-unix-doc \
 ghc9.10-xhtml \
 ghc9.10-xhtml-devel \
 ghc9.10-xhtml-doc \
"
PACKAGES:aarch64 = " \
 ghc9.10 \
 ghc9.10-Cabal \
 ghc9.10-Cabal-devel \
 ghc9.10-Cabal-doc \
 ghc9.10-Cabal-prof \
 ghc9.10-Cabal-syntax \
 ghc9.10-Cabal-syntax-devel \
 ghc9.10-Cabal-syntax-doc \
 ghc9.10-Cabal-syntax-prof \
 ghc9.10-array \
 ghc9.10-array-devel \
 ghc9.10-array-doc \
 ghc9.10-array-prof \
 ghc9.10-base \
 ghc9.10-base-devel \
 ghc9.10-base-doc \
 ghc9.10-base-prof \
 ghc9.10-binary \
 ghc9.10-binary-devel \
 ghc9.10-binary-doc \
 ghc9.10-binary-prof \
 ghc9.10-bytestring \
 ghc9.10-bytestring-devel \
 ghc9.10-bytestring-doc \
 ghc9.10-bytestring-prof \
 ghc9.10-compiler \
 ghc9.10-compiler-default \
 ghc9.10-containers \
 ghc9.10-containers-devel \
 ghc9.10-containers-doc \
 ghc9.10-containers-prof \
 ghc9.10-deepseq \
 ghc9.10-deepseq-devel \
 ghc9.10-deepseq-doc \
 ghc9.10-deepseq-prof \
 ghc9.10-devel \
 ghc9.10-directory \
 ghc9.10-directory-devel \
 ghc9.10-directory-doc \
 ghc9.10-directory-prof \
 ghc9.10-doc \
 ghc9.10-doc-index \
 ghc9.10-exceptions \
 ghc9.10-exceptions-devel \
 ghc9.10-exceptions-doc \
 ghc9.10-exceptions-prof \
 ghc9.10-filepath \
 ghc9.10-filepath-devel \
 ghc9.10-filepath-doc \
 ghc9.10-filepath-prof \
 ghc9.10-filesystem \
 ghc9.10-ghc \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-bignum-devel \
 ghc9.10-ghc-bignum-doc \
 ghc9.10-ghc-bignum-prof \
 ghc9.10-ghc-boot \
 ghc9.10-ghc-boot-devel \
 ghc9.10-ghc-boot-doc \
 ghc9.10-ghc-boot-prof \
 ghc9.10-ghc-boot-th \
 ghc9.10-ghc-boot-th-devel \
 ghc9.10-ghc-boot-th-doc \
 ghc9.10-ghc-boot-th-prof \
 ghc9.10-ghc-compact \
 ghc9.10-ghc-compact-devel \
 ghc9.10-ghc-compact-doc \
 ghc9.10-ghc-compact-prof \
 ghc9.10-ghc-devel \
 ghc9.10-ghc-doc \
 ghc9.10-ghc-experimental \
 ghc9.10-ghc-experimental-devel \
 ghc9.10-ghc-experimental-doc \
 ghc9.10-ghc-experimental-prof \
 ghc9.10-ghc-heap \
 ghc9.10-ghc-heap-devel \
 ghc9.10-ghc-heap-doc \
 ghc9.10-ghc-heap-prof \
 ghc9.10-ghc-platform \
 ghc9.10-ghc-platform-devel \
 ghc9.10-ghc-platform-doc \
 ghc9.10-ghc-platform-prof \
 ghc9.10-ghc-prof \
 ghc9.10-ghc-toolchain \
 ghc9.10-ghc-toolchain-devel \
 ghc9.10-ghc-toolchain-doc \
 ghc9.10-ghc-toolchain-prof \
 ghc9.10-ghci \
 ghc9.10-ghci-devel \
 ghc9.10-ghci-doc \
 ghc9.10-ghci-prof \
 ghc9.10-hadrian \
 ghc9.10-haskeline \
 ghc9.10-haskeline-devel \
 ghc9.10-haskeline-doc \
 ghc9.10-haskeline-prof \
 ghc9.10-hpc \
 ghc9.10-hpc-devel \
 ghc9.10-hpc-doc \
 ghc9.10-hpc-prof \
 ghc9.10-manual \
 ghc9.10-mtl \
 ghc9.10-mtl-devel \
 ghc9.10-mtl-doc \
 ghc9.10-mtl-prof \
 ghc9.10-os-string \
 ghc9.10-os-string-devel \
 ghc9.10-os-string-doc \
 ghc9.10-os-string-prof \
 ghc9.10-parsec \
 ghc9.10-parsec-devel \
 ghc9.10-parsec-doc \
 ghc9.10-parsec-prof \
 ghc9.10-pretty \
 ghc9.10-pretty-devel \
 ghc9.10-pretty-doc \
 ghc9.10-pretty-prof \
 ghc9.10-process \
 ghc9.10-process-devel \
 ghc9.10-process-doc \
 ghc9.10-process-prof \
 ghc9.10-prof \
 ghc9.10-semaphore-compat \
 ghc9.10-semaphore-compat-devel \
 ghc9.10-semaphore-compat-doc \
 ghc9.10-semaphore-compat-prof \
 ghc9.10-stm \
 ghc9.10-stm-devel \
 ghc9.10-stm-doc \
 ghc9.10-stm-prof \
 ghc9.10-template-haskell \
 ghc9.10-template-haskell-devel \
 ghc9.10-template-haskell-doc \
 ghc9.10-template-haskell-prof \
 ghc9.10-terminfo \
 ghc9.10-terminfo-devel \
 ghc9.10-terminfo-doc \
 ghc9.10-terminfo-prof \
 ghc9.10-text \
 ghc9.10-text-devel \
 ghc9.10-text-doc \
 ghc9.10-text-prof \
 ghc9.10-time \
 ghc9.10-time-devel \
 ghc9.10-time-doc \
 ghc9.10-time-prof \
 ghc9.10-transformers \
 ghc9.10-transformers-devel \
 ghc9.10-transformers-doc \
 ghc9.10-transformers-prof \
 ghc9.10-unix \
 ghc9.10-unix-devel \
 ghc9.10-unix-doc \
 ghc9.10-unix-prof \
 ghc9.10-xhtml \
 ghc9.10-xhtml-devel \
 ghc9.10-xhtml-doc \
 ghc9.10-xhtml-prof \
"

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc9.10-9.10.3-11.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "753a9137e768772d92a5fab16a97c35bd4461d0f6bb7d37d9d8b89bb48561533"

URI_x86_64_v2_ghc9.10 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-9.10.3-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10}"
SRC_URI[x86_64_v2_ghc9.10.sha256sum] = "8217d7c14888311ee1967b6c287bf448ddde3b4bee8f92929cc3688f0b0bfc6b"

URI_x86_64_v2_ghc9.10-Cabal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-Cabal-3.12.1.0-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-Cabal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-Cabal}"
SRC_URI[x86_64_v2_ghc9.10-Cabal.sha256sum] = "2bbef1efdba33ce9ab2a4723736efa041ccad39ec636b3a4bde43aedba6e9f70"

URI_x86_64_v2_ghc9.10-Cabal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-Cabal-devel-3.12.1.0-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-Cabal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-Cabal-devel}"
SRC_URI[x86_64_v2_ghc9.10-Cabal-devel.sha256sum] = "60908fcffb33e964775ae26bac514c3e7f06fa90cdee16c811c582a0cb458ce5"

URI_x86_64_v2_ghc9.10-Cabal-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-Cabal-doc-3.12.1.0-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-Cabal-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-Cabal-doc}"
SRC_URI[x86_64_v2_ghc9.10-Cabal-doc.sha256sum] = "c41379216fe1775f116b451ed0ffd8257140420c7a4db255e4eb6af3d58f5dc2"

URI_x86_64_v2_ghc9.10-Cabal-syntax = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-Cabal-syntax-3.12.1.0-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-Cabal-syntax;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-Cabal-syntax}"
SRC_URI[x86_64_v2_ghc9.10-Cabal-syntax.sha256sum] = "39af0dc6087fa3cb4bc04704a0621baf3c79a2344006dbb1790ca28f03010432"

URI_x86_64_v2_ghc9.10-Cabal-syntax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-Cabal-syntax-devel-3.12.1.0-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-Cabal-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-Cabal-syntax-devel}"
SRC_URI[x86_64_v2_ghc9.10-Cabal-syntax-devel.sha256sum] = "39ff8f00ecf0a7128f478ac82383231a9a068468e4c330377f5ca9ac90cd2139"

URI_x86_64_v2_ghc9.10-Cabal-syntax-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-Cabal-syntax-doc-3.12.1.0-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-Cabal-syntax-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-Cabal-syntax-doc}"
SRC_URI[x86_64_v2_ghc9.10-Cabal-syntax-doc.sha256sum] = "4fe541fbf40f45bc93b7b01b0b41cd7286f5989027777957f7aef6a6115b561c"

URI_x86_64_v2_ghc9.10-array = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-array-0.5.8.0-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-array;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-array}"
SRC_URI[x86_64_v2_ghc9.10-array.sha256sum] = "3ac75fec68ac04d7f4a09244443070d7eb093e8ade6514119685813dc3708f8f"

URI_x86_64_v2_ghc9.10-array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-array-devel-0.5.8.0-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-array-devel}"
SRC_URI[x86_64_v2_ghc9.10-array-devel.sha256sum] = "4eedddb903c6dfc5df9fe41d5fb9e6810ada61825df43390271ecc5c30423f3e"

URI_x86_64_v2_ghc9.10-array-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-array-doc-0.5.8.0-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-array-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-array-doc}"
SRC_URI[x86_64_v2_ghc9.10-array-doc.sha256sum] = "147a38dd6fbf65f56474c25387e47d58053491b514948b889d0d1a64f56415f3"

URI_x86_64_v2_ghc9.10-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-base-4.20.2.0-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-base}"
SRC_URI[x86_64_v2_ghc9.10-base.sha256sum] = "94d84cfa8974d6674cbc7a9388743110e971dca85eec8f12d7ea473542c23d52"

URI_x86_64_v2_ghc9.10-base-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-base-devel-4.20.2.0-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-base-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-base-devel}"
SRC_URI[x86_64_v2_ghc9.10-base-devel.sha256sum] = "ffb67a66f8c34377dfdaf50b1c28f5397021cf2f27a1855b1d708e6d8818a247"

URI_x86_64_v2_ghc9.10-base-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-base-doc-4.20.2.0-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-base-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-base-doc}"
SRC_URI[x86_64_v2_ghc9.10-base-doc.sha256sum] = "7b68e81be9b921fb4047a67dafa798a22f668138f46e95ca6239b184cf5c8906"

URI_x86_64_v2_ghc9.10-binary = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-binary-0.8.9.3-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-binary;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-binary}"
SRC_URI[x86_64_v2_ghc9.10-binary.sha256sum] = "f824a39d0778dc5f086135476a2a701d11cee9cbbfe6a19cecfbd340b5531a4b"

URI_x86_64_v2_ghc9.10-binary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-binary-devel-0.8.9.3-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-binary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-binary-devel}"
SRC_URI[x86_64_v2_ghc9.10-binary-devel.sha256sum] = "54207bfee0e822c6300aa16f666644d6752174eebe3d09a0d77442ac1bfcd0db"

URI_x86_64_v2_ghc9.10-binary-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-binary-doc-0.8.9.3-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-binary-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-binary-doc}"
SRC_URI[x86_64_v2_ghc9.10-binary-doc.sha256sum] = "84b2eeae0d81f4e441fdf5ecf0e3c51830b5dbb41118e73ffe83e5e28f61223f"

URI_x86_64_v2_ghc9.10-bytestring = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-bytestring-0.12.2.0-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-bytestring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-bytestring}"
SRC_URI[x86_64_v2_ghc9.10-bytestring.sha256sum] = "98a73521ad8e1fc1c9506b7eec65675c9673b907f6ce6747dcfcbc9a05092388"

URI_x86_64_v2_ghc9.10-bytestring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-bytestring-devel-0.12.2.0-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-bytestring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-bytestring-devel}"
SRC_URI[x86_64_v2_ghc9.10-bytestring-devel.sha256sum] = "159929cb6cb9b11fd9c727fc3d4a668b00e31a18dac310b2767cf3db62c17cc3"

URI_x86_64_v2_ghc9.10-bytestring-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-bytestring-doc-0.12.2.0-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-bytestring-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-bytestring-doc}"
SRC_URI[x86_64_v2_ghc9.10-bytestring-doc.sha256sum] = "71d835ba65a0732c07c3cbf37e615560ed3f13527559d2274be46e50759746c8"

URI_x86_64_v2_ghc9.10-compiler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-compiler-9.10.3-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-compiler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-compiler}"
SRC_URI[x86_64_v2_ghc9.10-compiler.sha256sum] = "c90e3ed4d5a5d47e4fdab069c53b06374ede52153d2e174c65ae60f4870cb618"

URI_x86_64_v2_ghc9.10-compiler-default = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-compiler-default-9.10.3-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-compiler-default;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-compiler-default}"
SRC_URI[x86_64_v2_ghc9.10-compiler-default.sha256sum] = "3a74bcf771ea2f8c6e2d7be2e448557a3c86a0ad81789180d6bfbff425afc7fb"

URI_x86_64_v2_ghc9.10-containers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-containers-0.7-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-containers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-containers}"
SRC_URI[x86_64_v2_ghc9.10-containers.sha256sum] = "4f3b0917d902d27f20d986678f3b8ac3a747f89b15ea3d729421dae9505a934f"

URI_x86_64_v2_ghc9.10-containers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-containers-devel-0.7-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-containers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-containers-devel}"
SRC_URI[x86_64_v2_ghc9.10-containers-devel.sha256sum] = "d69f746e1e27630c9aff04b4c886ce64e127344e9be5b110f0f109574597ae9b"

URI_x86_64_v2_ghc9.10-containers-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-containers-doc-0.7-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-containers-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-containers-doc}"
SRC_URI[x86_64_v2_ghc9.10-containers-doc.sha256sum] = "8f6597f45c44ce42f4bbff124138c463b5ba2e6dce5c0a55dd6b03a050d27d8f"

URI_x86_64_v2_ghc9.10-deepseq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-deepseq-1.5.0.0-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-deepseq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-deepseq}"
SRC_URI[x86_64_v2_ghc9.10-deepseq.sha256sum] = "804b9d6f2f7bb3d9aa1e47bbcd0897724697d3a45da38d7a6a590e6828133767"

URI_x86_64_v2_ghc9.10-deepseq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-deepseq-devel-1.5.0.0-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-deepseq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-deepseq-devel}"
SRC_URI[x86_64_v2_ghc9.10-deepseq-devel.sha256sum] = "4a3e813b8842bcb7ceea80d228ffb2b1c14d28e457ea1466de5832f00b113b10"

URI_x86_64_v2_ghc9.10-deepseq-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-deepseq-doc-1.5.0.0-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-deepseq-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-deepseq-doc}"
SRC_URI[x86_64_v2_ghc9.10-deepseq-doc.sha256sum] = "f53c93876d508f878ff2eda573f8dfb1704bda8f5339b2ed21b4349a41afd83e"

URI_x86_64_v2_ghc9.10-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-devel-9.10.3-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-devel}"
SRC_URI[x86_64_v2_ghc9.10-devel.sha256sum] = "ebc1a5b09313ee964917f8b0330dfadc12dcdeed7dcc290d3f028e229c707b17"

URI_x86_64_v2_ghc9.10-directory = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-directory-1.3.8.5-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-directory;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-directory}"
SRC_URI[x86_64_v2_ghc9.10-directory.sha256sum] = "c5d8c21cfee5cb66a2101855934639f530bcaccd52523e831278f2f2560d60ef"

URI_x86_64_v2_ghc9.10-directory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-directory-devel-1.3.8.5-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-directory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-directory-devel}"
SRC_URI[x86_64_v2_ghc9.10-directory-devel.sha256sum] = "14de215bcc8e4e4070c7cb660add4556fdee3f4b34c1b89591552361f7b93eb3"

URI_x86_64_v2_ghc9.10-directory-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-directory-doc-1.3.8.5-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-directory-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-directory-doc}"
SRC_URI[x86_64_v2_ghc9.10-directory-doc.sha256sum] = "12902da89a587d9a7cff83443520ef53177de93713b3b4841e0b951438bc4966"

URI_x86_64_v2_ghc9.10-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-doc-9.10.3-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-doc}"
SRC_URI[x86_64_v2_ghc9.10-doc.sha256sum] = "76510959d7409c863f04f01cc7994a266185dbdb6357fc4711acb4b2b15e5608"

URI_x86_64_v2_ghc9.10-doc-index = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-doc-index-9.10.3-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-doc-index;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-doc-index}"
SRC_URI[x86_64_v2_ghc9.10-doc-index.sha256sum] = "f5ba15d620b9a4c122d9bffcad72b390a5eab853daf4cd5f7668c5cec6cf40ce"

URI_x86_64_v2_ghc9.10-exceptions = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-exceptions-0.10.9-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-exceptions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-exceptions}"
SRC_URI[x86_64_v2_ghc9.10-exceptions.sha256sum] = "de0eff1be7cca93deb9a65bd88b0208408c3e4f564d6cd437ae8926fe6730b2f"

URI_x86_64_v2_ghc9.10-exceptions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-exceptions-devel-0.10.9-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-exceptions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-exceptions-devel}"
SRC_URI[x86_64_v2_ghc9.10-exceptions-devel.sha256sum] = "cac59030388818f6114f75fee1ea150e9d2662252cf8f499f5d592dc6657718e"

URI_x86_64_v2_ghc9.10-exceptions-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-exceptions-doc-0.10.9-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-exceptions-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-exceptions-doc}"
SRC_URI[x86_64_v2_ghc9.10-exceptions-doc.sha256sum] = "bc4ce719904f80b31bbe4c80ebfd46991bdc4287c6fccdcd0c6858dfc93f19ff"

URI_x86_64_v2_ghc9.10-filepath = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-filepath-1.5.4.0-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-filepath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-filepath}"
SRC_URI[x86_64_v2_ghc9.10-filepath.sha256sum] = "bc06480e7ebe58e6c03492e0e4e5fa88498943eeb6d63bf2f4ebaaca2b7b681e"

URI_x86_64_v2_ghc9.10-filepath-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-filepath-devel-1.5.4.0-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-filepath-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-filepath-devel}"
SRC_URI[x86_64_v2_ghc9.10-filepath-devel.sha256sum] = "b9011cd5014bb1a65a070253a7f4c34ff433b710ef89dfa6d2a2767ef796ba88"

URI_x86_64_v2_ghc9.10-filepath-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-filepath-doc-1.5.4.0-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-filepath-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-filepath-doc}"
SRC_URI[x86_64_v2_ghc9.10-filepath-doc.sha256sum] = "883eb06789ad1d35bc02a2871e01351049bfe61e24ec4cb6b58482018f7f24a4"

URI_x86_64_v2_ghc9.10-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-filesystem-9.10.3-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-filesystem}"
SRC_URI[x86_64_v2_ghc9.10-filesystem.sha256sum] = "bcb85d6f9591b7869a4acfc96454f13738bade29407d8d070eeb93993606997b"

URI_x86_64_v2_ghc9.10-ghc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-9.10.3-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc}"
SRC_URI[x86_64_v2_ghc9.10-ghc.sha256sum] = "9d9271350b24b488cc7d5e65b4d9a979b832e2abede05e86e660c54e8f5c7a1a"

URI_x86_64_v2_ghc9.10-ghc-bignum = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-bignum-1.3-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-bignum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-bignum}"
SRC_URI[x86_64_v2_ghc9.10-ghc-bignum.sha256sum] = "76a6c85433728e222a49aa721ba3403ae0a696d44d9bb3c37569c176c184f691"

URI_x86_64_v2_ghc9.10-ghc-bignum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-bignum-devel-1.3-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-bignum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-bignum-devel}"
SRC_URI[x86_64_v2_ghc9.10-ghc-bignum-devel.sha256sum] = "3bf4129cbb29b3018c12b3b67a8d983e592b5c1da94af119f2aa439c9d9889a4"

URI_x86_64_v2_ghc9.10-ghc-bignum-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-bignum-doc-1.3-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-ghc-bignum-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-bignum-doc}"
SRC_URI[x86_64_v2_ghc9.10-ghc-bignum-doc.sha256sum] = "6398af1ae1a00a0ccea448d72b44a37f156b73a2fb1f835988311f7d656d5652"

URI_x86_64_v2_ghc9.10-ghc-boot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-boot-9.10.3-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-boot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-boot}"
SRC_URI[x86_64_v2_ghc9.10-ghc-boot.sha256sum] = "1da81daa60f12de3efb901877344de67c281adffea8fb6087192eec74f88cb97"

URI_x86_64_v2_ghc9.10-ghc-boot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-boot-devel-9.10.3-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-boot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-boot-devel}"
SRC_URI[x86_64_v2_ghc9.10-ghc-boot-devel.sha256sum] = "dcf1a0114e7979495939106263ba41b0e7bb5cd1f5e7a0606fe11ef87b869c4c"

URI_x86_64_v2_ghc9.10-ghc-boot-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-boot-doc-9.10.3-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-ghc-boot-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-boot-doc}"
SRC_URI[x86_64_v2_ghc9.10-ghc-boot-doc.sha256sum] = "8fc90965985a8479fa5e772c705d279adbfc7e8fe921b04bca03ddc510a24f36"

URI_x86_64_v2_ghc9.10-ghc-boot-th = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-boot-th-9.10.3-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-boot-th;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-boot-th}"
SRC_URI[x86_64_v2_ghc9.10-ghc-boot-th.sha256sum] = "fe0188b5949561880320899b62dccc9ec3fd6de34cb46d97d5799d7c5b2a807a"

URI_x86_64_v2_ghc9.10-ghc-boot-th-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-boot-th-devel-9.10.3-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-boot-th-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-boot-th-devel}"
SRC_URI[x86_64_v2_ghc9.10-ghc-boot-th-devel.sha256sum] = "3d8ca20ab55b2bac4d0b33494fccb00c224d0df5f0ff965a99bf9674d9a2e703"

URI_x86_64_v2_ghc9.10-ghc-boot-th-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-boot-th-doc-9.10.3-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-ghc-boot-th-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-boot-th-doc}"
SRC_URI[x86_64_v2_ghc9.10-ghc-boot-th-doc.sha256sum] = "344d3ead52026eac99fa47c8fb4fad3b34978a9f40a0dd3e759f42e4c5cbddbc"

URI_x86_64_v2_ghc9.10-ghc-compact = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-compact-0.1.0.0-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-compact;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-compact}"
SRC_URI[x86_64_v2_ghc9.10-ghc-compact.sha256sum] = "b35238bbcec218315a60dafdd017f51fdc77c5055f8493e36594e1e9ffdc4b30"

URI_x86_64_v2_ghc9.10-ghc-compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-compact-devel-0.1.0.0-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-compact-devel}"
SRC_URI[x86_64_v2_ghc9.10-ghc-compact-devel.sha256sum] = "d6f10b26947573e39593018a46ef082fb416ce4040fb05d441b68b16b7abc5b2"

URI_x86_64_v2_ghc9.10-ghc-compact-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-compact-doc-0.1.0.0-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-ghc-compact-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-compact-doc}"
SRC_URI[x86_64_v2_ghc9.10-ghc-compact-doc.sha256sum] = "1a4899d2094f994bf6d4b75cc6ed939d2ef150a51b27cfce674b0d15b9591868"

URI_x86_64_v2_ghc9.10-ghc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-devel-9.10.3-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-devel}"
SRC_URI[x86_64_v2_ghc9.10-ghc-devel.sha256sum] = "26bcee1c872329d90d02dd3126ac3cda76f873b13a078e50cccddae9c4f95e01"

URI_x86_64_v2_ghc9.10-ghc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-doc-9.10.3-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-ghc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-doc}"
SRC_URI[x86_64_v2_ghc9.10-ghc-doc.sha256sum] = "e3e5ce8c483af2b481eb70074a4e2f1204557da81d3369e44836ca036e229527"

URI_x86_64_v2_ghc9.10-ghc-experimental = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-experimental-9.1003.0-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-experimental;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-experimental}"
SRC_URI[x86_64_v2_ghc9.10-ghc-experimental.sha256sum] = "e9c0af35d019c776dc4f0eb9f1a5ecf2a609b853c295340a1e330fe598229104"

URI_x86_64_v2_ghc9.10-ghc-experimental-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-experimental-devel-9.1003.0-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-experimental-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-experimental-devel}"
SRC_URI[x86_64_v2_ghc9.10-ghc-experimental-devel.sha256sum] = "3f31cc0d92ba6e02455ee320652f4005d1da2938d4b397586d8c7696ee944b00"

URI_x86_64_v2_ghc9.10-ghc-experimental-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-experimental-doc-9.1003.0-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-ghc-experimental-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-experimental-doc}"
SRC_URI[x86_64_v2_ghc9.10-ghc-experimental-doc.sha256sum] = "44616bfeb038be01e762c68e66e6aa665fd524823be411283190e758ab2d001a"

URI_x86_64_v2_ghc9.10-ghc-heap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-heap-9.10.3-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-heap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-heap}"
SRC_URI[x86_64_v2_ghc9.10-ghc-heap.sha256sum] = "00e31c8cb9000ae2d4ab8c675cf85dd3a8a2dfdf7ce28f9de8de75da69da4a06"

URI_x86_64_v2_ghc9.10-ghc-heap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-heap-devel-9.10.3-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-heap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-heap-devel}"
SRC_URI[x86_64_v2_ghc9.10-ghc-heap-devel.sha256sum] = "917f89796efb3970734a45b24a944cb134fcdcb028ac12e76d81446295876d7f"

URI_x86_64_v2_ghc9.10-ghc-heap-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-heap-doc-9.10.3-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-ghc-heap-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-heap-doc}"
SRC_URI[x86_64_v2_ghc9.10-ghc-heap-doc.sha256sum] = "f81bbacd53270e071b298b41483b4c360b178498ff39a9b2fbd731e654a62647"

URI_x86_64_v2_ghc9.10-ghc-platform = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-platform-0.1.0.0-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-platform;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-platform}"
SRC_URI[x86_64_v2_ghc9.10-ghc-platform.sha256sum] = "cbc2532fcd4451649fec2c4c82168c8ea04b7bebe7ac7b99344c5ec22731ce03"

URI_x86_64_v2_ghc9.10-ghc-platform-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-platform-devel-0.1.0.0-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-platform-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-platform-devel}"
SRC_URI[x86_64_v2_ghc9.10-ghc-platform-devel.sha256sum] = "5a45190855249700e0a6894a183d4c49e8ddeb2e623fa2765bbb74e5bd55914b"

URI_x86_64_v2_ghc9.10-ghc-platform-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-platform-doc-0.1.0.0-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-ghc-platform-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-platform-doc}"
SRC_URI[x86_64_v2_ghc9.10-ghc-platform-doc.sha256sum] = "0fd356c03c25e09a0e11bcccedfed911322901a30855acb80dea0de85202004a"

URI_x86_64_v2_ghc9.10-ghc-toolchain = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-toolchain-0.1.0.0-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-toolchain;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-toolchain}"
SRC_URI[x86_64_v2_ghc9.10-ghc-toolchain.sha256sum] = "6d11d6bedeeed00779bbf0370bde02afdd29ddd5c2d62d9a42bccbf394abe6ae"

URI_x86_64_v2_ghc9.10-ghc-toolchain-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-toolchain-devel-0.1.0.0-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-toolchain-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-toolchain-devel}"
SRC_URI[x86_64_v2_ghc9.10-ghc-toolchain-devel.sha256sum] = "bc57cf2ad9ab308103c399231efce9281cad25c86ccd0d7f3071c4956356c2df"

URI_x86_64_v2_ghc9.10-ghc-toolchain-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-toolchain-doc-0.1.0.0-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-ghc-toolchain-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-toolchain-doc}"
SRC_URI[x86_64_v2_ghc9.10-ghc-toolchain-doc.sha256sum] = "66ab73764ff245e9e213a7d90ab33ed1765c05bc57594c9c2efeb2e63a289cf5"

URI_x86_64_v2_ghc9.10-ghci = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghci-9.10.3-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghci;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghci}"
SRC_URI[x86_64_v2_ghc9.10-ghci.sha256sum] = "ce0165d2875cacde2a4d5b43406322c8918c7a31bbdd6dafcaf2342404adfff4"

URI_x86_64_v2_ghc9.10-ghci-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghci-devel-9.10.3-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghci-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghci-devel}"
SRC_URI[x86_64_v2_ghc9.10-ghci-devel.sha256sum] = "c0e4ac31995ffc5432b09d249f40498223e86a8ee44b283f87be85459720cb9a"

URI_x86_64_v2_ghc9.10-ghci-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghci-doc-9.10.3-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-ghci-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghci-doc}"
SRC_URI[x86_64_v2_ghc9.10-ghci-doc.sha256sum] = "8fc203dd25417d26c2049b3ac58cfc2e7fe321c8895678fd88c960dc350a31b0"

URI_x86_64_v2_ghc9.10-hadrian = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-hadrian-0.1.0.0-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-hadrian;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-hadrian}"
SRC_URI[x86_64_v2_ghc9.10-hadrian.sha256sum] = "9436dc924b44a22e2f1d98b5e9c0fb521d94f3bbad65209a88eac497c7f3ccbd"

URI_x86_64_v2_ghc9.10-haskeline = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-haskeline-0.8.2.1-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-haskeline;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-haskeline}"
SRC_URI[x86_64_v2_ghc9.10-haskeline.sha256sum] = "9d7905cb928a0da2b69f99bde165caec4a3b051039893c32e45bbca6e687a70e"

URI_x86_64_v2_ghc9.10-haskeline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-haskeline-devel-0.8.2.1-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-haskeline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-haskeline-devel}"
SRC_URI[x86_64_v2_ghc9.10-haskeline-devel.sha256sum] = "b1eb6e85d9852bfcf2e65f08d8466165cb17ed676ce23a35d49187debc96f1fe"

URI_x86_64_v2_ghc9.10-haskeline-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-haskeline-doc-0.8.2.1-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-haskeline-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-haskeline-doc}"
SRC_URI[x86_64_v2_ghc9.10-haskeline-doc.sha256sum] = "1f183262736d55f3f4df8d2355faf2333fb92d73b6c59da3f68a41c083f956f5"

URI_x86_64_v2_ghc9.10-hpc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-hpc-0.7.0.2-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-hpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-hpc}"
SRC_URI[x86_64_v2_ghc9.10-hpc.sha256sum] = "691fdd5b2a4e146920b6f8e0122512cec66f2446d3f91d1dc8a75ec906cac397"

URI_x86_64_v2_ghc9.10-hpc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-hpc-devel-0.7.0.2-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-hpc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-hpc-devel}"
SRC_URI[x86_64_v2_ghc9.10-hpc-devel.sha256sum] = "785d9a4add89ce389bc7e650e166680daf8c6a5b9d8e214d2c73f24caa2b5199"

URI_x86_64_v2_ghc9.10-hpc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-hpc-doc-0.7.0.2-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-hpc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-hpc-doc}"
SRC_URI[x86_64_v2_ghc9.10-hpc-doc.sha256sum] = "4f99a10617da60eeb14f4abc48e6ab7b2760aff2a5ec304f11e4bfbbf4b709a7"

URI_x86_64_v2_ghc9.10-manual = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-manual-9.10.3-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-manual;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-manual}"
SRC_URI[x86_64_v2_ghc9.10-manual.sha256sum] = "b831ebf177bccee949b030cad7d8801cee09c2b8945e43101a17658d420f22c1"

URI_x86_64_v2_ghc9.10-mtl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-mtl-2.3.1-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-mtl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-mtl}"
SRC_URI[x86_64_v2_ghc9.10-mtl.sha256sum] = "6b5109ed9c324c0cc0c2ba96878a37c6d0524ac742b1264306ebfa90775517de"

URI_x86_64_v2_ghc9.10-mtl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-mtl-devel-2.3.1-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-mtl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-mtl-devel}"
SRC_URI[x86_64_v2_ghc9.10-mtl-devel.sha256sum] = "ed80cf1f4ab527956b0fe682c3d9f63272bb569cf06567a681c5e272f6022493"

URI_x86_64_v2_ghc9.10-mtl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-mtl-doc-2.3.1-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-mtl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-mtl-doc}"
SRC_URI[x86_64_v2_ghc9.10-mtl-doc.sha256sum] = "5c10db5ded60c893afa59e85f8b02ada5bc4f5554c61d0253a503a49ed85cfde"

URI_x86_64_v2_ghc9.10-os-string = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-os-string-2.0.7-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-os-string;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-os-string}"
SRC_URI[x86_64_v2_ghc9.10-os-string.sha256sum] = "15286365348b4596f588e5ec7d04da65e926a5d27a17556fc4319e77c3c4271c"

URI_x86_64_v2_ghc9.10-os-string-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-os-string-devel-2.0.7-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-os-string-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-os-string-devel}"
SRC_URI[x86_64_v2_ghc9.10-os-string-devel.sha256sum] = "f45608780534d5bede386b2df7d5eebbd68575c24c38e603eeb021639d36edc1"

URI_x86_64_v2_ghc9.10-os-string-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-os-string-doc-2.0.7-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-os-string-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-os-string-doc}"
SRC_URI[x86_64_v2_ghc9.10-os-string-doc.sha256sum] = "dc8236947cd2c6120157917ba2280704fbe8a68d62ed508e2478d794356c3f30"

URI_x86_64_v2_ghc9.10-parsec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-parsec-3.1.18.0-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-parsec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-parsec}"
SRC_URI[x86_64_v2_ghc9.10-parsec.sha256sum] = "78748b630a179832783537f93a43d9fa0b3633b0cb4e9c6d0fce20aa534b2c1b"

URI_x86_64_v2_ghc9.10-parsec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-parsec-devel-3.1.18.0-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-parsec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-parsec-devel}"
SRC_URI[x86_64_v2_ghc9.10-parsec-devel.sha256sum] = "4809eb5b7d4790c3e2b6638456e09e53f29cfccc3e1d8bf43f22ad36d988ff59"

URI_x86_64_v2_ghc9.10-parsec-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-parsec-doc-3.1.18.0-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-parsec-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-parsec-doc}"
SRC_URI[x86_64_v2_ghc9.10-parsec-doc.sha256sum] = "6655b8850041958383348474398161970aebe74e934310a0087f3d52d12ef814"

URI_x86_64_v2_ghc9.10-pretty = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-pretty-1.1.3.6-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-pretty;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-pretty}"
SRC_URI[x86_64_v2_ghc9.10-pretty.sha256sum] = "c3536ce698ccc015d60bbca07e34ae56e1416b6de514676c6f3125ab4d8c7af9"

URI_x86_64_v2_ghc9.10-pretty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-pretty-devel-1.1.3.6-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-pretty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-pretty-devel}"
SRC_URI[x86_64_v2_ghc9.10-pretty-devel.sha256sum] = "5af38479ca2f8438bc34de132aca9169b05a27afeb713f2636ad26f2016693df"

URI_x86_64_v2_ghc9.10-pretty-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-pretty-doc-1.1.3.6-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-pretty-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-pretty-doc}"
SRC_URI[x86_64_v2_ghc9.10-pretty-doc.sha256sum] = "b6d7b28b15f3fc25db6d14c7134defadb946e752a5fa017c158349640de508ff"

URI_x86_64_v2_ghc9.10-process = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-process-1.6.26.1-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-process;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-process}"
SRC_URI[x86_64_v2_ghc9.10-process.sha256sum] = "359804db442fbf9e1aeeccb905cf52e76bc6843b991f2fc3606c5992a2cdbaee"

URI_x86_64_v2_ghc9.10-process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-process-devel-1.6.26.1-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-process-devel}"
SRC_URI[x86_64_v2_ghc9.10-process-devel.sha256sum] = "3504a44f257757259b288f3d012b920e024f0c333291e024773e0c817c7ff28f"

URI_x86_64_v2_ghc9.10-process-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-process-doc-1.6.26.1-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-process-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-process-doc}"
SRC_URI[x86_64_v2_ghc9.10-process-doc.sha256sum] = "935f9a2d48bd03477ad0be8ea3d6d7ec49a7ee753f858ac14b50e68e9385a8d3"

URI_x86_64_v2_ghc9.10-semaphore-compat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-semaphore-compat-1.0.0-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-semaphore-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-semaphore-compat}"
SRC_URI[x86_64_v2_ghc9.10-semaphore-compat.sha256sum] = "11af0aaca85d63bae0d1fcd4d248ab90ecf9c5250e89c678630098fda5ad5b8e"

URI_x86_64_v2_ghc9.10-semaphore-compat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-semaphore-compat-devel-1.0.0-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-semaphore-compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-semaphore-compat-devel}"
SRC_URI[x86_64_v2_ghc9.10-semaphore-compat-devel.sha256sum] = "d78847ea16a82aeef18c440f482f7c482e52ef0f68cf424fd72b0c3d88ff72c8"

URI_x86_64_v2_ghc9.10-semaphore-compat-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-semaphore-compat-doc-1.0.0-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-semaphore-compat-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-semaphore-compat-doc}"
SRC_URI[x86_64_v2_ghc9.10-semaphore-compat-doc.sha256sum] = "14d2d735b9ed598c22c028035a063f11a2cd0931afc5bb33a6819119937bf71e"

URI_x86_64_v2_ghc9.10-stm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-stm-2.5.3.1-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-stm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-stm}"
SRC_URI[x86_64_v2_ghc9.10-stm.sha256sum] = "4eabed98502341fcd0f39cb8ec292e88f56078109fdfff68a266074cf875fde1"

URI_x86_64_v2_ghc9.10-stm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-stm-devel-2.5.3.1-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-stm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-stm-devel}"
SRC_URI[x86_64_v2_ghc9.10-stm-devel.sha256sum] = "75c2254b174eabd4079d45c19457cab8be5ad04b9a81ffe690a04b0033166e11"

URI_x86_64_v2_ghc9.10-stm-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-stm-doc-2.5.3.1-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-stm-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-stm-doc}"
SRC_URI[x86_64_v2_ghc9.10-stm-doc.sha256sum] = "d863d9b3d7ff6dd0b48f3a0b38eeb413b603366236e9a56c21e0ad593dcc7ffa"

URI_x86_64_v2_ghc9.10-template-haskell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-template-haskell-2.22.0.0-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-template-haskell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-template-haskell}"
SRC_URI[x86_64_v2_ghc9.10-template-haskell.sha256sum] = "49e0f7d32459dc5ac13d42484cd61559e8d09d448c98774e1aac9856fd62510f"

URI_x86_64_v2_ghc9.10-template-haskell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-template-haskell-devel-2.22.0.0-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-template-haskell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-template-haskell-devel}"
SRC_URI[x86_64_v2_ghc9.10-template-haskell-devel.sha256sum] = "76b88343544be29504f6e900c6cae21ff27458dbbf6059b268c725eb09096e9f"

URI_x86_64_v2_ghc9.10-template-haskell-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-template-haskell-doc-2.22.0.0-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-template-haskell-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-template-haskell-doc}"
SRC_URI[x86_64_v2_ghc9.10-template-haskell-doc.sha256sum] = "22dc0dabd24b0e2f84c9d38442d9d6ac12187fd40b646bf4a68b37804eaec417"

URI_x86_64_v2_ghc9.10-terminfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-terminfo-0.4.1.7-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-terminfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-terminfo}"
SRC_URI[x86_64_v2_ghc9.10-terminfo.sha256sum] = "080ede773139800c399eb68dc797aa3fbe5d6f3d971bd46f6914a4f7f4f9f534"

URI_x86_64_v2_ghc9.10-terminfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-terminfo-devel-0.4.1.7-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-terminfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-terminfo-devel}"
SRC_URI[x86_64_v2_ghc9.10-terminfo-devel.sha256sum] = "2fe59f9cddaa6c72229b4620a09ebd5c42d4699526717d86e6bc6d709050f6d2"

URI_x86_64_v2_ghc9.10-terminfo-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-terminfo-doc-0.4.1.7-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-terminfo-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-terminfo-doc}"
SRC_URI[x86_64_v2_ghc9.10-terminfo-doc.sha256sum] = "0d81de95da84d15778e7e1426ff5f2b91300223dc0d28c1f0323aca60811c6bf"

URI_x86_64_v2_ghc9.10-text = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-text-2.1.3-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-text;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-text}"
SRC_URI[x86_64_v2_ghc9.10-text.sha256sum] = "f25ca0cd9f139e446b46aa33602192cd716fa25139bba4276d81ff1c1b1c9940"

URI_x86_64_v2_ghc9.10-text-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-text-devel-2.1.3-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-text-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-text-devel}"
SRC_URI[x86_64_v2_ghc9.10-text-devel.sha256sum] = "f0641cff1d5f15d27925ea9cc815146a9bbd79ec75bf3986856ce9885a7dccf5"

URI_x86_64_v2_ghc9.10-text-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-text-doc-2.1.3-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-text-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-text-doc}"
SRC_URI[x86_64_v2_ghc9.10-text-doc.sha256sum] = "481aa6fed32cf546174e2cabe579bb6109e10553627bb40615e5a1cb4b9593d2"

URI_x86_64_v2_ghc9.10-time = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-time-1.12.2-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-time;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-time}"
SRC_URI[x86_64_v2_ghc9.10-time.sha256sum] = "463f8d79e06a724fc8d8a9dabaa70cdf4bcbc106f21f07a2fad322aa62b187e9"

URI_x86_64_v2_ghc9.10-time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-time-devel-1.12.2-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-time-devel}"
SRC_URI[x86_64_v2_ghc9.10-time-devel.sha256sum] = "056b5cfcc05179319fb2c31a44fe8e9e37a92427f817535d51019b2cfc1d52ab"

URI_x86_64_v2_ghc9.10-time-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-time-doc-1.12.2-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-time-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-time-doc}"
SRC_URI[x86_64_v2_ghc9.10-time-doc.sha256sum] = "2dd5a658e65e39b5c3584fff4e3ca282319163f592b25378305e39d1d29dfb75"

URI_x86_64_v2_ghc9.10-transformers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-transformers-0.6.1.1-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-transformers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-transformers}"
SRC_URI[x86_64_v2_ghc9.10-transformers.sha256sum] = "895482fa321d8edc8524d4a4ad466639108a6ffd028570bb737817b0c7e7cd12"

URI_x86_64_v2_ghc9.10-transformers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-transformers-devel-0.6.1.1-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-transformers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-transformers-devel}"
SRC_URI[x86_64_v2_ghc9.10-transformers-devel.sha256sum] = "ef1b2bfe412ace458688e8b219e092e6cb3b6aadeb7f422e4ce6d12bbfbedcef"

URI_x86_64_v2_ghc9.10-transformers-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-transformers-doc-0.6.1.1-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-transformers-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-transformers-doc}"
SRC_URI[x86_64_v2_ghc9.10-transformers-doc.sha256sum] = "4cc740bed6ea0eb4f0db25a74202f84ec3742c919944a54bba72a009f26f9dc2"

URI_x86_64_v2_ghc9.10-unix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-unix-2.8.7.0-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-unix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-unix}"
SRC_URI[x86_64_v2_ghc9.10-unix.sha256sum] = "3ceafa8c01e91b2fde60f4003c36a38c92b4a27581a5111c0316f9926d53ca01"

URI_x86_64_v2_ghc9.10-unix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-unix-devel-2.8.7.0-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-unix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-unix-devel}"
SRC_URI[x86_64_v2_ghc9.10-unix-devel.sha256sum] = "7cdd46c66a3b3a8ffba844e24f009a1e1942159e39bd0d1475e58c875486cc78"

URI_x86_64_v2_ghc9.10-unix-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-unix-doc-2.8.7.0-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-unix-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-unix-doc}"
SRC_URI[x86_64_v2_ghc9.10-unix-doc.sha256sum] = "975cdbf877e03a64c2293a7f5273571b2e35b80031f90a0b3dc6409309095be9"

URI_x86_64_v2_ghc9.10-xhtml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-xhtml-3000.2.2.1-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-xhtml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-xhtml}"
SRC_URI[x86_64_v2_ghc9.10-xhtml.sha256sum] = "9600f72737f1180858c00973ba420a0ce6af00ef36b01b6cc14f8f1d490550a0"

URI_x86_64_v2_ghc9.10-xhtml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-xhtml-devel-3000.2.2.1-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-xhtml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-xhtml-devel}"
SRC_URI[x86_64_v2_ghc9.10-xhtml-devel.sha256sum] = "93271d20d97368a855a3f5eef519aacf9d80ee11e381fb68edc05dad805b7f96"

URI_x86_64_v2_ghc9.10-xhtml-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-xhtml-doc-3000.2.2.1-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-xhtml-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-xhtml-doc}"
SRC_URI[x86_64_v2_ghc9.10-xhtml-doc.sha256sum] = "aecbf53ada354fde99ac0bebdae80aa22f39912a86719f80804d202bcf3ef9ca"

URI_aarch64_ghc9.10 = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-9.10.3-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10}"
SRC_URI[aarch64_ghc9.10.sha256sum] = "93fddf17b7c248167682c23a11a4646a6886709f8e2c3c96d258e80022063080"

URI_aarch64_ghc9.10-Cabal = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-Cabal-3.12.1.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-Cabal;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-Cabal}"
SRC_URI[aarch64_ghc9.10-Cabal.sha256sum] = "a22d8e27f222ed9623a5389714d47c8c7df91093742b7c7dbba379ca7021ca8d"

URI_aarch64_ghc9.10-Cabal-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-Cabal-devel-3.12.1.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-Cabal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-Cabal-devel}"
SRC_URI[aarch64_ghc9.10-Cabal-devel.sha256sum] = "be098ad97a9fcb24064a59627e74e6a856cacce1b8032db20941877b2884b2fb"

URI_aarch64_ghc9.10-Cabal-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-Cabal-doc-3.12.1.0-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-Cabal-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-Cabal-doc}"
SRC_URI[aarch64_ghc9.10-Cabal-doc.sha256sum] = "5402668b0c0b402cb26fe786f7609587a6dcbe6380675e0291d93eac6467a13b"

URI_aarch64_ghc9.10-Cabal-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-Cabal-prof-3.12.1.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-Cabal-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-Cabal-prof}"
SRC_URI[aarch64_ghc9.10-Cabal-prof.sha256sum] = "9fba7463b0d1da995634ac85fb70c9c2dcfa74aa9884cd6dd66d60465716095e"

URI_aarch64_ghc9.10-Cabal-syntax = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-Cabal-syntax-3.12.1.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-Cabal-syntax;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-Cabal-syntax}"
SRC_URI[aarch64_ghc9.10-Cabal-syntax.sha256sum] = "072ee2aa63766763f61bea692d4cb4d13339f146ca6af859f1c34e8fa2013998"

URI_aarch64_ghc9.10-Cabal-syntax-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-Cabal-syntax-devel-3.12.1.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-Cabal-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-Cabal-syntax-devel}"
SRC_URI[aarch64_ghc9.10-Cabal-syntax-devel.sha256sum] = "00d23f6ac91ad3ff1c8032891c222c80a04b99fc969e272ed010a1af6a64faea"

URI_aarch64_ghc9.10-Cabal-syntax-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-Cabal-syntax-doc-3.12.1.0-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-Cabal-syntax-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-Cabal-syntax-doc}"
SRC_URI[aarch64_ghc9.10-Cabal-syntax-doc.sha256sum] = "4556361aee1217eee2e036782d70a897534b634967ca13e57c4701a9b800349a"

URI_aarch64_ghc9.10-Cabal-syntax-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-Cabal-syntax-prof-3.12.1.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-Cabal-syntax-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-Cabal-syntax-prof}"
SRC_URI[aarch64_ghc9.10-Cabal-syntax-prof.sha256sum] = "9b5260ef7e6012a3d8f2e5d39f0821d455b27e52a35fa395e37057c2b4ea4b1d"

URI_aarch64_ghc9.10-array = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-array-0.5.8.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-array;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-array}"
SRC_URI[aarch64_ghc9.10-array.sha256sum] = "b3ea04922e26c12ca1e1b328c23424d367a9dd2b3e43bb8486733bedbc8a07cc"

URI_aarch64_ghc9.10-array-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-array-devel-0.5.8.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-array-devel}"
SRC_URI[aarch64_ghc9.10-array-devel.sha256sum] = "5ab3f0485d098fdb32a6f82a6009255429b1c588d6999ba64fbcbbcd07131cc1"

URI_aarch64_ghc9.10-array-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-array-doc-0.5.8.0-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-array-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-array-doc}"
SRC_URI[aarch64_ghc9.10-array-doc.sha256sum] = "f0b21d2fdc578064d11924bb549a905044d0a775fd00372538b7d1bdba911fa3"

URI_aarch64_ghc9.10-array-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-array-prof-0.5.8.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-array-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-array-prof}"
SRC_URI[aarch64_ghc9.10-array-prof.sha256sum] = "18cfa1bb659113dfee3f37138dc4a5198ac3b02c55bfb3a772a651da633bc865"

URI_aarch64_ghc9.10-base = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-base-4.20.2.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-base}"
SRC_URI[aarch64_ghc9.10-base.sha256sum] = "50625e59f7eda578b802deb0839d96446f05cb2927f2d0d23556c04631a81cf0"

URI_aarch64_ghc9.10-base-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-base-devel-4.20.2.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-base-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-base-devel}"
SRC_URI[aarch64_ghc9.10-base-devel.sha256sum] = "248ed00121369f2ee90d9f1728a7daceda434a7a7228564c2fd949fa13864bf2"

URI_aarch64_ghc9.10-base-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-base-doc-4.20.2.0-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-base-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-base-doc}"
SRC_URI[aarch64_ghc9.10-base-doc.sha256sum] = "f5eab429b9ac76e3a975a2f9e6bbb2350736da0ccde738cb408f66e2e5af5905"

URI_aarch64_ghc9.10-base-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-base-prof-4.20.2.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-base-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-base-prof}"
SRC_URI[aarch64_ghc9.10-base-prof.sha256sum] = "493dd745ea76f23855e348d6305772a92360c87bfa1db2f3a410f4f3b828e211"

URI_aarch64_ghc9.10-binary = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-binary-0.8.9.3-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-binary;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-binary}"
SRC_URI[aarch64_ghc9.10-binary.sha256sum] = "f7bf02ef1ac63628c614b116307085c6e38e9c3fef1b1f8b9919903000b7fff5"

URI_aarch64_ghc9.10-binary-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-binary-devel-0.8.9.3-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-binary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-binary-devel}"
SRC_URI[aarch64_ghc9.10-binary-devel.sha256sum] = "c23bee21f5269289e927e676d95ebf2278177ddecfbd9cad50548093a11df661"

URI_aarch64_ghc9.10-binary-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-binary-doc-0.8.9.3-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-binary-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-binary-doc}"
SRC_URI[aarch64_ghc9.10-binary-doc.sha256sum] = "8367c67fe8336059ffc66a1a0154b926ecd0ca21207fba2936b2e52dfc2875f8"

URI_aarch64_ghc9.10-binary-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-binary-prof-0.8.9.3-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-binary-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-binary-prof}"
SRC_URI[aarch64_ghc9.10-binary-prof.sha256sum] = "50e8099322e078ec07c216366afdf26745c3f3594dcf560f25e4d8cd12e31521"

URI_aarch64_ghc9.10-bytestring = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-bytestring-0.12.2.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-bytestring;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-bytestring}"
SRC_URI[aarch64_ghc9.10-bytestring.sha256sum] = "6aebf0325ca9c42138eed4dc838c015649c8038b54d8bdf5088461d770fde7f7"

URI_aarch64_ghc9.10-bytestring-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-bytestring-devel-0.12.2.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-bytestring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-bytestring-devel}"
SRC_URI[aarch64_ghc9.10-bytestring-devel.sha256sum] = "a30a4185f45de6ceddd04abe038e4bbe7798d5fec270168aabb99c08b53ffa77"

URI_aarch64_ghc9.10-bytestring-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-bytestring-doc-0.12.2.0-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-bytestring-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-bytestring-doc}"
SRC_URI[aarch64_ghc9.10-bytestring-doc.sha256sum] = "8cd34397067315be331bc2c669b9993e37cf4acea763aca10d518fd0cddd3f8f"

URI_aarch64_ghc9.10-bytestring-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-bytestring-prof-0.12.2.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-bytestring-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-bytestring-prof}"
SRC_URI[aarch64_ghc9.10-bytestring-prof.sha256sum] = "6ed5caaf360ce6d5fbb6f29efe89687ac13defb2a6472bae5f91d5906747d88b"

URI_aarch64_ghc9.10-compiler = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-compiler-9.10.3-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-compiler;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-compiler}"
SRC_URI[aarch64_ghc9.10-compiler.sha256sum] = "4c6beb708118523cfd722aab92bd8cd5143761debedfb31949adb305e6bb1b9c"

URI_aarch64_ghc9.10-compiler-default = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-compiler-default-9.10.3-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-compiler-default;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-compiler-default}"
SRC_URI[aarch64_ghc9.10-compiler-default.sha256sum] = "ac9fd133438a2c8f24391c29a22d13bc3499ff0053c158c55b089f6c9e7fbc3d"

URI_aarch64_ghc9.10-containers = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-containers-0.7-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-containers;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-containers}"
SRC_URI[aarch64_ghc9.10-containers.sha256sum] = "9720f5fcff9fbd141209ef0ed54fbbf65c2c9b746c33a382d367fbff0065e870"

URI_aarch64_ghc9.10-containers-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-containers-devel-0.7-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-containers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-containers-devel}"
SRC_URI[aarch64_ghc9.10-containers-devel.sha256sum] = "2a3b2b7837df7e4dddfc09c07a1bbc2965f870c6de3f741203b7866c7e2481d5"

URI_aarch64_ghc9.10-containers-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-containers-doc-0.7-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-containers-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-containers-doc}"
SRC_URI[aarch64_ghc9.10-containers-doc.sha256sum] = "88c3ee422e789b5da3e11e545833c10ef03766a3c989747fb13b4c47df53f36f"

URI_aarch64_ghc9.10-containers-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-containers-prof-0.7-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-containers-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-containers-prof}"
SRC_URI[aarch64_ghc9.10-containers-prof.sha256sum] = "0ec45f76aa5926517560b3d1e8a0294a3615a586801c9c1e7c10de63400e1239"

URI_aarch64_ghc9.10-deepseq = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-deepseq-1.5.0.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-deepseq;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-deepseq}"
SRC_URI[aarch64_ghc9.10-deepseq.sha256sum] = "2752e6c8c4cbcbbab0e21fae82593a28d00f4f726ea4a06f6b3086c3aad39f93"

URI_aarch64_ghc9.10-deepseq-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-deepseq-devel-1.5.0.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-deepseq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-deepseq-devel}"
SRC_URI[aarch64_ghc9.10-deepseq-devel.sha256sum] = "4e4fd5c82223fb83fee0132b5f6fe2db78df37bbb11582bb4779059576bae63b"

URI_aarch64_ghc9.10-deepseq-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-deepseq-doc-1.5.0.0-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-deepseq-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-deepseq-doc}"
SRC_URI[aarch64_ghc9.10-deepseq-doc.sha256sum] = "018268a79ffd0b86bce270168eccc570d24eb485defa08a73b4a3d6a39e0957a"

URI_aarch64_ghc9.10-deepseq-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-deepseq-prof-1.5.0.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-deepseq-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-deepseq-prof}"
SRC_URI[aarch64_ghc9.10-deepseq-prof.sha256sum] = "5433d15560674fe30f9a18ec020ac4a4adac5ca3d7c5981ca55bf8325893270f"

URI_aarch64_ghc9.10-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-devel-9.10.3-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-devel}"
SRC_URI[aarch64_ghc9.10-devel.sha256sum] = "d48fc4a6df3321eb30fc9fd29e1408fb897e9dd3d7fe37224da7e4175bad32f9"

URI_aarch64_ghc9.10-directory = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-directory-1.3.8.5-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-directory;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-directory}"
SRC_URI[aarch64_ghc9.10-directory.sha256sum] = "75aa4958ff9bf4e5cbcc5748a0556fc8fac06ba7284d65993d0d773e8fe04b42"

URI_aarch64_ghc9.10-directory-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-directory-devel-1.3.8.5-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-directory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-directory-devel}"
SRC_URI[aarch64_ghc9.10-directory-devel.sha256sum] = "63c6f163c520d721f3160cb37f2e8e8a7a7ecad8dda4bd9a1306fcc1fd8e271c"

URI_aarch64_ghc9.10-directory-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-directory-doc-1.3.8.5-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-directory-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-directory-doc}"
SRC_URI[aarch64_ghc9.10-directory-doc.sha256sum] = "c409252194d6d0c5d9fa4c39e51318fe8a9769803508d0b773a66095622491f6"

URI_aarch64_ghc9.10-directory-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-directory-prof-1.3.8.5-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-directory-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-directory-prof}"
SRC_URI[aarch64_ghc9.10-directory-prof.sha256sum] = "12dc855f1534d06be2d171d0aae50542242d7de45082f70de1eec2f972bc8276"

URI_aarch64_ghc9.10-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-doc-9.10.3-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-doc}"
SRC_URI[aarch64_ghc9.10-doc.sha256sum] = "317139068ff7cf3b91b5420b238cd5ef6777b17ba98639a1f9a594d72f509701"

URI_aarch64_ghc9.10-doc-index = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-doc-index-9.10.3-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-doc-index;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-doc-index}"
SRC_URI[aarch64_ghc9.10-doc-index.sha256sum] = "5d147887c1f6a2284d0ed95c7da77a771a6312492737bca48a38af2c4a5a9ae7"

URI_aarch64_ghc9.10-exceptions = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-exceptions-0.10.9-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-exceptions;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-exceptions}"
SRC_URI[aarch64_ghc9.10-exceptions.sha256sum] = "6cf5e7e4cbca9909b6d1206405b966100265fd7698d4627ac01de2599b691fe2"

URI_aarch64_ghc9.10-exceptions-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-exceptions-devel-0.10.9-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-exceptions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-exceptions-devel}"
SRC_URI[aarch64_ghc9.10-exceptions-devel.sha256sum] = "b4eb45c38190d3a40297d173f05a586d6a76838e26e405cb5792b4dc3a823156"

URI_aarch64_ghc9.10-exceptions-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-exceptions-doc-0.10.9-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-exceptions-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-exceptions-doc}"
SRC_URI[aarch64_ghc9.10-exceptions-doc.sha256sum] = "7bd39226f7a4dddf1d320341cdddf883d894e30c5d49f69d2c0328808f49cf77"

URI_aarch64_ghc9.10-exceptions-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-exceptions-prof-0.10.9-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-exceptions-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-exceptions-prof}"
SRC_URI[aarch64_ghc9.10-exceptions-prof.sha256sum] = "57d816bce4c73bc74f3809ff368862910da32a87fc245a277e9394a29f1a7e5b"

URI_aarch64_ghc9.10-filepath = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-filepath-1.5.4.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-filepath;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-filepath}"
SRC_URI[aarch64_ghc9.10-filepath.sha256sum] = "525cea23648b4363c9f55c883f88dbab5ece02b15b355c21282f46da4015253d"

URI_aarch64_ghc9.10-filepath-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-filepath-devel-1.5.4.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-filepath-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-filepath-devel}"
SRC_URI[aarch64_ghc9.10-filepath-devel.sha256sum] = "79a006dd7a7ddd828d9386a3c5612a5e5c3786887646241a01b655f00a9e37d5"

URI_aarch64_ghc9.10-filepath-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-filepath-doc-1.5.4.0-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-filepath-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-filepath-doc}"
SRC_URI[aarch64_ghc9.10-filepath-doc.sha256sum] = "9203b751816f1cfb12254f8b364f95a4692033aa7331bec0e01248345342bb52"

URI_aarch64_ghc9.10-filepath-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-filepath-prof-1.5.4.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-filepath-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-filepath-prof}"
SRC_URI[aarch64_ghc9.10-filepath-prof.sha256sum] = "75affa37264261dd60d86fca63773f0b9874b6df83102863799936341bdfb371"

URI_aarch64_ghc9.10-filesystem = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-filesystem-9.10.3-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-filesystem}"
SRC_URI[aarch64_ghc9.10-filesystem.sha256sum] = "23f7265ce73b4cd608c0a5c431fbaef6b18e52c861f14e9bcacddc034aed0a27"

URI_aarch64_ghc9.10-ghc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-9.10.3-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-ghc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc}"
SRC_URI[aarch64_ghc9.10-ghc.sha256sum] = "a747201f624ba2c19f1da4d48fcc8de698fe683129f8f544717ccf2bb07071cb"

URI_aarch64_ghc9.10-ghc-bignum = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-bignum-1.3-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-ghc-bignum;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-bignum}"
SRC_URI[aarch64_ghc9.10-ghc-bignum.sha256sum] = "4c1da93a5331e064c4ae3a3447d6a6b91483dde423baac39ce78f4d63f4b784f"

URI_aarch64_ghc9.10-ghc-bignum-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-bignum-devel-1.3-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-ghc-bignum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-bignum-devel}"
SRC_URI[aarch64_ghc9.10-ghc-bignum-devel.sha256sum] = "a8bc06483418c1c282b4a36a9e3ff9627603333d774c010e9c312395252c45cb"

URI_aarch64_ghc9.10-ghc-bignum-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-bignum-doc-1.3-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-ghc-bignum-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-bignum-doc}"
SRC_URI[aarch64_ghc9.10-ghc-bignum-doc.sha256sum] = "de71447c1b122ad1ade5aa0c7f0f3a956d5ae2c0ad6ef7b6e662fae06b2955a9"

URI_aarch64_ghc9.10-ghc-bignum-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-bignum-prof-1.3-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-ghc-bignum-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-bignum-prof}"
SRC_URI[aarch64_ghc9.10-ghc-bignum-prof.sha256sum] = "c09c5d6783870b715fe8c347a5465fea2d36686f80cc159597caae2301a9d2c6"

URI_aarch64_ghc9.10-ghc-boot = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-boot-9.10.3-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-ghc-boot;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-boot}"
SRC_URI[aarch64_ghc9.10-ghc-boot.sha256sum] = "f6bde27461750cc96c8f7c0b0f67ffe340b20957b82fb0c6ed5c118f197d0dc8"

URI_aarch64_ghc9.10-ghc-boot-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-boot-devel-9.10.3-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-ghc-boot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-boot-devel}"
SRC_URI[aarch64_ghc9.10-ghc-boot-devel.sha256sum] = "fa1fc2314ed3a45631f75f40957f33b4ec2c8b2ad40d473c43708311ae7568db"

URI_aarch64_ghc9.10-ghc-boot-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-boot-doc-9.10.3-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-ghc-boot-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-boot-doc}"
SRC_URI[aarch64_ghc9.10-ghc-boot-doc.sha256sum] = "cac7a9b62c742c3ac396c4354d8831147020f3e677a19640face0254d5c7196e"

URI_aarch64_ghc9.10-ghc-boot-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-boot-prof-9.10.3-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-ghc-boot-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-boot-prof}"
SRC_URI[aarch64_ghc9.10-ghc-boot-prof.sha256sum] = "aac5fd179d52bbee4abc8c4242521e9051e2e510a097903b2c90f3c1800f239c"

URI_aarch64_ghc9.10-ghc-boot-th = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-boot-th-9.10.3-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-ghc-boot-th;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-boot-th}"
SRC_URI[aarch64_ghc9.10-ghc-boot-th.sha256sum] = "d71a11f62f6542f0f247b7e0852e4167c46e794bac599d43c8888f572d4c3e84"

URI_aarch64_ghc9.10-ghc-boot-th-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-boot-th-devel-9.10.3-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-ghc-boot-th-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-boot-th-devel}"
SRC_URI[aarch64_ghc9.10-ghc-boot-th-devel.sha256sum] = "94673acc28ac62cd6015d282803408806585e3dc62a2f516dd2be4bba00ccbab"

URI_aarch64_ghc9.10-ghc-boot-th-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-boot-th-doc-9.10.3-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-ghc-boot-th-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-boot-th-doc}"
SRC_URI[aarch64_ghc9.10-ghc-boot-th-doc.sha256sum] = "d5bf29add9dd548d2618eb7b4be86bf4db3c9a3669e2960b526e2a1115d31ac7"

URI_aarch64_ghc9.10-ghc-boot-th-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-boot-th-prof-9.10.3-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-ghc-boot-th-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-boot-th-prof}"
SRC_URI[aarch64_ghc9.10-ghc-boot-th-prof.sha256sum] = "76c188aaf3a1a5ee8930eb500f9891d88c91276fdde15ae2e4c3ab39d5a7a4fa"

URI_aarch64_ghc9.10-ghc-compact = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-compact-0.1.0.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-ghc-compact;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-compact}"
SRC_URI[aarch64_ghc9.10-ghc-compact.sha256sum] = "65b9f7ada3c70548b933669b36fa71374038e7224d14ce46e06e198e22cb7f40"

URI_aarch64_ghc9.10-ghc-compact-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-compact-devel-0.1.0.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-ghc-compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-compact-devel}"
SRC_URI[aarch64_ghc9.10-ghc-compact-devel.sha256sum] = "44b5bb67302042ee87bd14fbcbf6dee0d6fb76a1b97551c80a2426bdbf1fc4f2"

URI_aarch64_ghc9.10-ghc-compact-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-compact-doc-0.1.0.0-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-ghc-compact-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-compact-doc}"
SRC_URI[aarch64_ghc9.10-ghc-compact-doc.sha256sum] = "239db6109876c94cfc8fe575b9856537de0730e7618bdd2fee7587ebf8587b49"

URI_aarch64_ghc9.10-ghc-compact-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-compact-prof-0.1.0.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-ghc-compact-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-compact-prof}"
SRC_URI[aarch64_ghc9.10-ghc-compact-prof.sha256sum] = "1cd07f6f24aeff51e1952d160b3e81a225782a3c48161e712b9cc80b45131068"

URI_aarch64_ghc9.10-ghc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-devel-9.10.3-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-ghc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-devel}"
SRC_URI[aarch64_ghc9.10-ghc-devel.sha256sum] = "09e047536dadea9175b3fe036e85d04adcebc6f5265bde120df19a9a2cb68178"

URI_aarch64_ghc9.10-ghc-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-doc-9.10.3-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-ghc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-doc}"
SRC_URI[aarch64_ghc9.10-ghc-doc.sha256sum] = "4b867dcfc4b8168c975ab428db0f7d5d2a9dfe78cb841085437deb56f6d7b4fc"

URI_aarch64_ghc9.10-ghc-experimental = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-experimental-9.1003.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-ghc-experimental;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-experimental}"
SRC_URI[aarch64_ghc9.10-ghc-experimental.sha256sum] = "6b9d466d74e1c87039301a1c3237fda4d9ec9aae0717c08e8e1bc1e5ebb40aa3"

URI_aarch64_ghc9.10-ghc-experimental-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-experimental-devel-9.1003.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-ghc-experimental-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-experimental-devel}"
SRC_URI[aarch64_ghc9.10-ghc-experimental-devel.sha256sum] = "550aa5990b6fea02d612e32f2b2bfe7498fb36a2b8a1ca524d214eb99ba75e20"

URI_aarch64_ghc9.10-ghc-experimental-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-experimental-doc-9.1003.0-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-ghc-experimental-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-experimental-doc}"
SRC_URI[aarch64_ghc9.10-ghc-experimental-doc.sha256sum] = "c7e2ab1c75ea4a5879e2a6875a62fe83dcac9b19f6ad28c845707aec8df2b573"

URI_aarch64_ghc9.10-ghc-experimental-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-experimental-prof-9.1003.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-ghc-experimental-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-experimental-prof}"
SRC_URI[aarch64_ghc9.10-ghc-experimental-prof.sha256sum] = "8eea31e60c8c08eac5f74ec253f8f2c27d78cd8a70e1b85bf8804dc203077e46"

URI_aarch64_ghc9.10-ghc-heap = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-heap-9.10.3-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-ghc-heap;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-heap}"
SRC_URI[aarch64_ghc9.10-ghc-heap.sha256sum] = "1b98332e712b468ebcccf09be493169614424bd8fba993f3715b7961ea682e20"

URI_aarch64_ghc9.10-ghc-heap-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-heap-devel-9.10.3-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-ghc-heap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-heap-devel}"
SRC_URI[aarch64_ghc9.10-ghc-heap-devel.sha256sum] = "455e4ec3a77a39c39bfbd210d1bd77c8065868faffbd4792430ec28a896f329e"

URI_aarch64_ghc9.10-ghc-heap-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-heap-doc-9.10.3-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-ghc-heap-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-heap-doc}"
SRC_URI[aarch64_ghc9.10-ghc-heap-doc.sha256sum] = "81cc187747b9b2dc667da84fd6535768cbf58f1bfda10855a21ca3e0780ea967"

URI_aarch64_ghc9.10-ghc-heap-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-heap-prof-9.10.3-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-ghc-heap-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-heap-prof}"
SRC_URI[aarch64_ghc9.10-ghc-heap-prof.sha256sum] = "058ecdec2f683f87253149e682fcb33e59138b3b216865a6246dd4cf7744d1ef"

URI_aarch64_ghc9.10-ghc-platform = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-platform-0.1.0.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-ghc-platform;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-platform}"
SRC_URI[aarch64_ghc9.10-ghc-platform.sha256sum] = "6e673f40146d1a899bfd292eb8d7474f092dfed263161a76d2e93cd85ddcaec0"

URI_aarch64_ghc9.10-ghc-platform-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-platform-devel-0.1.0.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-ghc-platform-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-platform-devel}"
SRC_URI[aarch64_ghc9.10-ghc-platform-devel.sha256sum] = "cbfc229caad6a79ca926b3ea00ef22dad8cfffc437155c5c004281bd8651d1be"

URI_aarch64_ghc9.10-ghc-platform-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-platform-doc-0.1.0.0-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-ghc-platform-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-platform-doc}"
SRC_URI[aarch64_ghc9.10-ghc-platform-doc.sha256sum] = "d9621f548fc31c1d4b58d657cebbeeb473bfb7deb431848401ebe1e6f9d4c55c"

URI_aarch64_ghc9.10-ghc-platform-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-platform-prof-0.1.0.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-ghc-platform-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-platform-prof}"
SRC_URI[aarch64_ghc9.10-ghc-platform-prof.sha256sum] = "f87ac2cfec761f586fd1dec558ddcf4156b3521976c3dd62963d76dc58dd8aeb"

URI_aarch64_ghc9.10-ghc-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-prof-9.10.3-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-ghc-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-prof}"
SRC_URI[aarch64_ghc9.10-ghc-prof.sha256sum] = "3354f2c2631aef2dde6d3a22c0cd2e6ad5cc540176c29a3a7b8b3040a705c9f6"

URI_aarch64_ghc9.10-ghc-toolchain = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-toolchain-0.1.0.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-ghc-toolchain;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-toolchain}"
SRC_URI[aarch64_ghc9.10-ghc-toolchain.sha256sum] = "75bebd5a7c1ab6b62b82aa857692418a51ef5d75546b40df550ef47621a05356"

URI_aarch64_ghc9.10-ghc-toolchain-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-toolchain-devel-0.1.0.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-ghc-toolchain-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-toolchain-devel}"
SRC_URI[aarch64_ghc9.10-ghc-toolchain-devel.sha256sum] = "af8a93e1ee4dabef7b19fd81b1be1b38b23c7792d5f91744fa53b99e21dd71f9"

URI_aarch64_ghc9.10-ghc-toolchain-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-toolchain-doc-0.1.0.0-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-ghc-toolchain-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-toolchain-doc}"
SRC_URI[aarch64_ghc9.10-ghc-toolchain-doc.sha256sum] = "a634114aa0d353c2b0e7ae71d5d65369adadc55bc29524fcc8a5062a69cf0648"

URI_aarch64_ghc9.10-ghc-toolchain-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-toolchain-prof-0.1.0.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-ghc-toolchain-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-toolchain-prof}"
SRC_URI[aarch64_ghc9.10-ghc-toolchain-prof.sha256sum] = "4696f2edb4a06a3ffcdcdc0ed8daa79136e80a081430cbf15b4c2e00d4194927"

URI_aarch64_ghc9.10-ghci = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghci-9.10.3-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-ghci;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghci}"
SRC_URI[aarch64_ghc9.10-ghci.sha256sum] = "697de8779ee44a4cd2713652599ac208246718a0991b64b3b5291c25fe54bd92"

URI_aarch64_ghc9.10-ghci-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghci-devel-9.10.3-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-ghci-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghci-devel}"
SRC_URI[aarch64_ghc9.10-ghci-devel.sha256sum] = "846becb0c643264ff911e438b42dd4dc6befbf687f370293d27370fa2388816a"

URI_aarch64_ghc9.10-ghci-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghci-doc-9.10.3-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-ghci-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghci-doc}"
SRC_URI[aarch64_ghc9.10-ghci-doc.sha256sum] = "33580ec44105d0944e8b8132d29c97731af0ee750ece4aa33cbd919c5c07291f"

URI_aarch64_ghc9.10-ghci-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghci-prof-9.10.3-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-ghci-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghci-prof}"
SRC_URI[aarch64_ghc9.10-ghci-prof.sha256sum] = "3c8f6ad546ca68f52b9ff41f036d333e736e513df58de1126c1cff706f149b79"

URI_aarch64_ghc9.10-hadrian = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-hadrian-0.1.0.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-hadrian;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-hadrian}"
SRC_URI[aarch64_ghc9.10-hadrian.sha256sum] = "021952a70be0ee8fcfdfb8c872db83aedcfb351b3d50d7f30677f29a66d46915"

URI_aarch64_ghc9.10-haskeline = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-haskeline-0.8.2.1-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-haskeline;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-haskeline}"
SRC_URI[aarch64_ghc9.10-haskeline.sha256sum] = "9c477c94e26279461a0d7338b172f01ecee655329463f32be839aab39eb035e9"

URI_aarch64_ghc9.10-haskeline-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-haskeline-devel-0.8.2.1-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-haskeline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-haskeline-devel}"
SRC_URI[aarch64_ghc9.10-haskeline-devel.sha256sum] = "fa7e2a7706c4f97bd8ea1a1db8e0e6c9f5eb3c91d12f628c04c49284e16623f2"

URI_aarch64_ghc9.10-haskeline-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-haskeline-doc-0.8.2.1-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-haskeline-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-haskeline-doc}"
SRC_URI[aarch64_ghc9.10-haskeline-doc.sha256sum] = "a3bafe6c75cd30cb02eb846948d2d8055c8fd8ab743c7f9af6ff48b691883a3f"

URI_aarch64_ghc9.10-haskeline-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-haskeline-prof-0.8.2.1-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-haskeline-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-haskeline-prof}"
SRC_URI[aarch64_ghc9.10-haskeline-prof.sha256sum] = "446004046774e787eb3f78b78b552ca0256c973b1e6ae0d7657c34e1675ec731"

URI_aarch64_ghc9.10-hpc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-hpc-0.7.0.2-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-hpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-hpc}"
SRC_URI[aarch64_ghc9.10-hpc.sha256sum] = "33e1cf3c207e4f0a5001e6507ea00c83be9ef75744fccc50f45aa7ac53b24e94"

URI_aarch64_ghc9.10-hpc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-hpc-devel-0.7.0.2-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-hpc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-hpc-devel}"
SRC_URI[aarch64_ghc9.10-hpc-devel.sha256sum] = "af9bec5d598bd6d19d0fd026107ae21004c2735a6cb7eba69d9534490bcc5548"

URI_aarch64_ghc9.10-hpc-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-hpc-doc-0.7.0.2-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-hpc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-hpc-doc}"
SRC_URI[aarch64_ghc9.10-hpc-doc.sha256sum] = "880c15b5c0ddda9c975d9d0edc5da462e0238497c6b655dc26d34a413d558a97"

URI_aarch64_ghc9.10-hpc-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-hpc-prof-0.7.0.2-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-hpc-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-hpc-prof}"
SRC_URI[aarch64_ghc9.10-hpc-prof.sha256sum] = "813cd8c53776574f507cfcbb406193b308c37be0d88a4bb7bd16e2ffd062ddd7"

URI_aarch64_ghc9.10-manual = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-manual-9.10.3-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-manual;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-manual}"
SRC_URI[aarch64_ghc9.10-manual.sha256sum] = "e56277cfccdf08a1323123dba15f2ee5b54ef0fc6c58c5aef9ff15953a6ee39b"

URI_aarch64_ghc9.10-mtl = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-mtl-2.3.1-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-mtl;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-mtl}"
SRC_URI[aarch64_ghc9.10-mtl.sha256sum] = "ee0b3e908e1fcb381ced28fceefff3f6927d6554534cc1cd367b2e7b4f01420e"

URI_aarch64_ghc9.10-mtl-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-mtl-devel-2.3.1-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-mtl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-mtl-devel}"
SRC_URI[aarch64_ghc9.10-mtl-devel.sha256sum] = "12247ca7c31f7114541e229718368687af32ee83e2ba14806e74c992a1ff227d"

URI_aarch64_ghc9.10-mtl-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-mtl-doc-2.3.1-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-mtl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-mtl-doc}"
SRC_URI[aarch64_ghc9.10-mtl-doc.sha256sum] = "7aa4505aa7eb85c7af4f184756347a110994e5311fa21b4a69de8b0640e41bb2"

URI_aarch64_ghc9.10-mtl-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-mtl-prof-2.3.1-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-mtl-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-mtl-prof}"
SRC_URI[aarch64_ghc9.10-mtl-prof.sha256sum] = "2c6a7c65121752701a5aba4ffd5af4a208651a0b27a1caf64f3b58e0709fa934"

URI_aarch64_ghc9.10-os-string = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-os-string-2.0.7-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-os-string;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-os-string}"
SRC_URI[aarch64_ghc9.10-os-string.sha256sum] = "3b99e5452c3b537e4107b182cb1762e04c8766a9873cf1d42294dd4e12d9ca2e"

URI_aarch64_ghc9.10-os-string-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-os-string-devel-2.0.7-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-os-string-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-os-string-devel}"
SRC_URI[aarch64_ghc9.10-os-string-devel.sha256sum] = "c53b30628dde1732e0dbd07eeaa7f07537a1944a58b08f8af435ec3cd39a2fe1"

URI_aarch64_ghc9.10-os-string-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-os-string-doc-2.0.7-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-os-string-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-os-string-doc}"
SRC_URI[aarch64_ghc9.10-os-string-doc.sha256sum] = "8f7e9208126e4873f5a49d0a3e395f5da163935cb6fd5837805046f0e2e5a37e"

URI_aarch64_ghc9.10-os-string-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-os-string-prof-2.0.7-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-os-string-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-os-string-prof}"
SRC_URI[aarch64_ghc9.10-os-string-prof.sha256sum] = "05816de985e72b08010dc96fb2d094b132ab45ba572142927b78b2409051204b"

URI_aarch64_ghc9.10-parsec = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-parsec-3.1.18.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-parsec;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-parsec}"
SRC_URI[aarch64_ghc9.10-parsec.sha256sum] = "2f78eccb3a175f01439612fa364483950e462e65fb7e250a031d9c747682aa43"

URI_aarch64_ghc9.10-parsec-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-parsec-devel-3.1.18.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-parsec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-parsec-devel}"
SRC_URI[aarch64_ghc9.10-parsec-devel.sha256sum] = "ed52f37a47fbe22e7230fb5c1e370ea87731479d8367053fa34cc5df0ccac627"

URI_aarch64_ghc9.10-parsec-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-parsec-doc-3.1.18.0-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-parsec-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-parsec-doc}"
SRC_URI[aarch64_ghc9.10-parsec-doc.sha256sum] = "86f247a3ae48de69168d0e48a37d09c24ac3fa59f26e9365c6b53f96e328d4db"

URI_aarch64_ghc9.10-parsec-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-parsec-prof-3.1.18.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-parsec-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-parsec-prof}"
SRC_URI[aarch64_ghc9.10-parsec-prof.sha256sum] = "902e979c2ed0dbf6d26548da1d8e07b5ea1e9c094199ea962827319bfc5fcecb"

URI_aarch64_ghc9.10-pretty = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-pretty-1.1.3.6-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-pretty;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-pretty}"
SRC_URI[aarch64_ghc9.10-pretty.sha256sum] = "2a2e32cdaf6e1692568fbb854616545a45fa7f9e57842081c272f997bb705b7d"

URI_aarch64_ghc9.10-pretty-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-pretty-devel-1.1.3.6-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-pretty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-pretty-devel}"
SRC_URI[aarch64_ghc9.10-pretty-devel.sha256sum] = "99478e56b55628c65672b414d3bef27b5f4ba1b2a88f86318633c4f619075df8"

URI_aarch64_ghc9.10-pretty-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-pretty-doc-1.1.3.6-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-pretty-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-pretty-doc}"
SRC_URI[aarch64_ghc9.10-pretty-doc.sha256sum] = "e68fbdd883219d5dae7e9b9c46b8fd7aa9b38bf8e0d1be7643a825483ecbf3ae"

URI_aarch64_ghc9.10-pretty-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-pretty-prof-1.1.3.6-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-pretty-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-pretty-prof}"
SRC_URI[aarch64_ghc9.10-pretty-prof.sha256sum] = "6cda2f9350ddfe4177bfc2535fc0570205d6f95bcbc2fc773ded34d527c15043"

URI_aarch64_ghc9.10-process = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-process-1.6.26.1-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-process;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-process}"
SRC_URI[aarch64_ghc9.10-process.sha256sum] = "83b0c65853fe567e15a4b804e35324b0b457e728c2ab9984c3d7e723aadd880b"

URI_aarch64_ghc9.10-process-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-process-devel-1.6.26.1-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-process-devel}"
SRC_URI[aarch64_ghc9.10-process-devel.sha256sum] = "d59f65d746dbc57a06e68dbd9cc737c4f65d2ccedbf4cdd053aaad835e4999d7"

URI_aarch64_ghc9.10-process-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-process-doc-1.6.26.1-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-process-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-process-doc}"
SRC_URI[aarch64_ghc9.10-process-doc.sha256sum] = "2dded10a3ca7388ddd51e7015d02e2bb020f430209af6bf0faa49b90f040b398"

URI_aarch64_ghc9.10-process-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-process-prof-1.6.26.1-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-process-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-process-prof}"
SRC_URI[aarch64_ghc9.10-process-prof.sha256sum] = "652d0ae9793007dc59641e1479fa98dd68dbb8ce4cef1a7bcf18739f0c3b547e"

URI_aarch64_ghc9.10-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-prof-9.10.3-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-prof}"
SRC_URI[aarch64_ghc9.10-prof.sha256sum] = "2781677bfaa6ce4e3de268156822047e637eb0bf378ada91b1c8c6ef0664cea6"

URI_aarch64_ghc9.10-semaphore-compat = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-semaphore-compat-1.0.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-semaphore-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-semaphore-compat}"
SRC_URI[aarch64_ghc9.10-semaphore-compat.sha256sum] = "7453095e76d2bcad708d2f253aa84c307013fba8eb420cb94cb39addd4e43fdc"

URI_aarch64_ghc9.10-semaphore-compat-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-semaphore-compat-devel-1.0.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-semaphore-compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-semaphore-compat-devel}"
SRC_URI[aarch64_ghc9.10-semaphore-compat-devel.sha256sum] = "37ddd3b4c1d2e0b52123cfafc29c1d5280d5788f391082655b1a375c2aa4f56f"

URI_aarch64_ghc9.10-semaphore-compat-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-semaphore-compat-doc-1.0.0-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-semaphore-compat-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-semaphore-compat-doc}"
SRC_URI[aarch64_ghc9.10-semaphore-compat-doc.sha256sum] = "7f0de20142ed0202ca038dbcd00e041446c7f0f677ea3ca1798c55368c914aa7"

URI_aarch64_ghc9.10-semaphore-compat-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-semaphore-compat-prof-1.0.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-semaphore-compat-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-semaphore-compat-prof}"
SRC_URI[aarch64_ghc9.10-semaphore-compat-prof.sha256sum] = "b584e4c3f3326dbe731c67e0cbcc6691556072641f8555b10869f044a513a2ab"

URI_aarch64_ghc9.10-stm = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-stm-2.5.3.1-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-stm;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-stm}"
SRC_URI[aarch64_ghc9.10-stm.sha256sum] = "6b0d671a59868cce31b0cb1c2f0f8504ff45be9fa01f28b35281b3682d4a89b9"

URI_aarch64_ghc9.10-stm-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-stm-devel-2.5.3.1-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-stm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-stm-devel}"
SRC_URI[aarch64_ghc9.10-stm-devel.sha256sum] = "0b4fcf53d266018b4dd79635f31ace6ec897217d14c8bb63f8af02c8f89d859b"

URI_aarch64_ghc9.10-stm-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-stm-doc-2.5.3.1-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-stm-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-stm-doc}"
SRC_URI[aarch64_ghc9.10-stm-doc.sha256sum] = "3c73d210e24ef1f5f959c36b8ab1121e606445c7da057db118241031beab12ce"

URI_aarch64_ghc9.10-stm-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-stm-prof-2.5.3.1-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-stm-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-stm-prof}"
SRC_URI[aarch64_ghc9.10-stm-prof.sha256sum] = "a9d38cdc0281b1f58350b11ba0bb624fb3a031dddd73291f4407842ebb073688"

URI_aarch64_ghc9.10-template-haskell = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-template-haskell-2.22.0.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-template-haskell;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-template-haskell}"
SRC_URI[aarch64_ghc9.10-template-haskell.sha256sum] = "897a0b16224025d326e281e4b12cad40eece9a61ccba09d7cc160409bb2e12de"

URI_aarch64_ghc9.10-template-haskell-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-template-haskell-devel-2.22.0.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-template-haskell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-template-haskell-devel}"
SRC_URI[aarch64_ghc9.10-template-haskell-devel.sha256sum] = "b4197fb98cd6b025d35d2f718afa28b4b1944ff6cb8d0b1716b55962ab2e60da"

URI_aarch64_ghc9.10-template-haskell-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-template-haskell-doc-2.22.0.0-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-template-haskell-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-template-haskell-doc}"
SRC_URI[aarch64_ghc9.10-template-haskell-doc.sha256sum] = "c3c316a3393e091f4342a6617e5cc3ab6a36ac335c5b6080247bbc01f84407dc"

URI_aarch64_ghc9.10-template-haskell-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-template-haskell-prof-2.22.0.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-template-haskell-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-template-haskell-prof}"
SRC_URI[aarch64_ghc9.10-template-haskell-prof.sha256sum] = "7f23c42f6c1696aea9cdc28ee62933e8d1953bb836656355620a968bb0fd8cf7"

URI_aarch64_ghc9.10-terminfo = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-terminfo-0.4.1.7-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-terminfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-terminfo}"
SRC_URI[aarch64_ghc9.10-terminfo.sha256sum] = "714c38eef4b5b7e442dc2b0843fb66628e9c22450a3f08d8d90fea1a93b93619"

URI_aarch64_ghc9.10-terminfo-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-terminfo-devel-0.4.1.7-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-terminfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-terminfo-devel}"
SRC_URI[aarch64_ghc9.10-terminfo-devel.sha256sum] = "fa475c7912d498cc6863d601fc06e32b48a48736a90dedb5207eb5e5de732061"

URI_aarch64_ghc9.10-terminfo-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-terminfo-doc-0.4.1.7-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-terminfo-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-terminfo-doc}"
SRC_URI[aarch64_ghc9.10-terminfo-doc.sha256sum] = "8ba93b20ad84cda5c8e00d747b07e019e54258f305c86a3b0b5f5e61b761ce77"

URI_aarch64_ghc9.10-terminfo-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-terminfo-prof-0.4.1.7-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-terminfo-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-terminfo-prof}"
SRC_URI[aarch64_ghc9.10-terminfo-prof.sha256sum] = "114763761ac91760d1a0e8a432b17d577130918c1ea85ef09586a717698b8c64"

URI_aarch64_ghc9.10-text = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-text-2.1.3-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-text;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-text}"
SRC_URI[aarch64_ghc9.10-text.sha256sum] = "9d8c1b958e57d5226098874985e5456388ddab516a8d8cf253e5ccc9227c4818"

URI_aarch64_ghc9.10-text-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-text-devel-2.1.3-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-text-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-text-devel}"
SRC_URI[aarch64_ghc9.10-text-devel.sha256sum] = "c11ec93d87d8a7d112fc53d0598a4c7da0b06869f727e66281bcc96555c1c535"

URI_aarch64_ghc9.10-text-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-text-doc-2.1.3-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-text-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-text-doc}"
SRC_URI[aarch64_ghc9.10-text-doc.sha256sum] = "d24e8bf5a0b8ca3a0ef5417f6ebb937f985f3bf705ef8a43778f495211976ba8"

URI_aarch64_ghc9.10-text-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-text-prof-2.1.3-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-text-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-text-prof}"
SRC_URI[aarch64_ghc9.10-text-prof.sha256sum] = "4c03ec1aa1c61d757b3a2fed30dffe141ae7b63e620861dac5c4824e9d7d7268"

URI_aarch64_ghc9.10-time = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-time-1.12.2-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-time;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-time}"
SRC_URI[aarch64_ghc9.10-time.sha256sum] = "bef885d76d3aa26e29bb2f7a365f9275758bfdf68fd5038b34c2149687fc45b4"

URI_aarch64_ghc9.10-time-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-time-devel-1.12.2-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-time-devel}"
SRC_URI[aarch64_ghc9.10-time-devel.sha256sum] = "52ecf6a5ef1989ab4d44b3993cb172d7b9078914d2be6d97a206c3c671bd6012"

URI_aarch64_ghc9.10-time-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-time-doc-1.12.2-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-time-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-time-doc}"
SRC_URI[aarch64_ghc9.10-time-doc.sha256sum] = "eb3ad4ebe127144388370be5e8d44f7fd62021947659787fbcf1514762ec8db0"

URI_aarch64_ghc9.10-time-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-time-prof-1.12.2-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-time-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-time-prof}"
SRC_URI[aarch64_ghc9.10-time-prof.sha256sum] = "e0e72c80451fbbd6b212df6f843a365b52e2841702bb8e48701b76f2d651f1f1"

URI_aarch64_ghc9.10-transformers = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-transformers-0.6.1.1-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-transformers;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-transformers}"
SRC_URI[aarch64_ghc9.10-transformers.sha256sum] = "a98a9e908f91d6d376b2b2f582edd74b78c37361708b5d452e1aa9a26dfa5540"

URI_aarch64_ghc9.10-transformers-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-transformers-devel-0.6.1.1-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-transformers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-transformers-devel}"
SRC_URI[aarch64_ghc9.10-transformers-devel.sha256sum] = "04e5fc55f28ad8fbe0449bd98d5ed8e736cf6c72a12329b14a776d4ba94e5990"

URI_aarch64_ghc9.10-transformers-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-transformers-doc-0.6.1.1-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-transformers-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-transformers-doc}"
SRC_URI[aarch64_ghc9.10-transformers-doc.sha256sum] = "04d81b5d9475b1fb0ca5ecca3d69b0ea62bb8ed27b14b8bd09b23979ae080efb"

URI_aarch64_ghc9.10-transformers-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-transformers-prof-0.6.1.1-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-transformers-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-transformers-prof}"
SRC_URI[aarch64_ghc9.10-transformers-prof.sha256sum] = "b2a3aeeb81cbccb2e2c8f282eaadba0eaba3e90558cdd4fb0b5901a9def032f9"

URI_aarch64_ghc9.10-unix = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-unix-2.8.7.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-unix;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-unix}"
SRC_URI[aarch64_ghc9.10-unix.sha256sum] = "b93e902bf053ce7e2f6222b8ed5f1d37615608fe732d76876e655a3f40cb9381"

URI_aarch64_ghc9.10-unix-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-unix-devel-2.8.7.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-unix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-unix-devel}"
SRC_URI[aarch64_ghc9.10-unix-devel.sha256sum] = "bf1c3875e80fd319fef0ae5b55051ab9dbb6260192a0c291fdd9bc6241fe5a69"

URI_aarch64_ghc9.10-unix-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-unix-doc-2.8.7.0-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-unix-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-unix-doc}"
SRC_URI[aarch64_ghc9.10-unix-doc.sha256sum] = "9a3fdad71f13a766454d6b4dff2b6da8d31344453d1450c10e39f3a4f036c9cd"

URI_aarch64_ghc9.10-unix-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-unix-prof-2.8.7.0-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-unix-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-unix-prof}"
SRC_URI[aarch64_ghc9.10-unix-prof.sha256sum] = "4d3b571ab94be5753483a24e373159d6481fb08791675b47d635b172b736beb6"

URI_aarch64_ghc9.10-xhtml = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-xhtml-3000.2.2.1-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-xhtml;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-xhtml}"
SRC_URI[aarch64_ghc9.10-xhtml.sha256sum] = "f187c58e1bea0ee4cccd151282baccbc6438356ac41a709af0635b7388ce8da7"

URI_aarch64_ghc9.10-xhtml-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-xhtml-devel-3000.2.2.1-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-xhtml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-xhtml-devel}"
SRC_URI[aarch64_ghc9.10-xhtml-devel.sha256sum] = "9bbe430555b5f0acf20fd995b5ac6bda479a2289c0650743590356eb650764bd"

URI_aarch64_ghc9.10-xhtml-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-xhtml-doc-3000.2.2.1-11.el10_1.noarch.rpm;name=aarch64_ghc9.10-xhtml-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-xhtml-doc}"
SRC_URI[aarch64_ghc9.10-xhtml-doc.sha256sum] = "a32eeb2e8dc7b6e5440dd43e49b9215b40e548a1aac94675a7b30c63a7f57b82"

URI_aarch64_ghc9.10-xhtml-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-xhtml-prof-3000.2.2.1-11.el10_1.aarch64.rpm;name=aarch64_ghc9.10-xhtml-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-xhtml-prof}"
SRC_URI[aarch64_ghc9.10-xhtml-prof.sha256sum] = "0d1213c1402b7550c02f3e2f2dd57ffe05e1bd3fe518b428dafad3209a973561"

RDEPENDS:ghc9.10 = " \
 ghc9.10-compiler \
 ghc9.10-devel \
 ghc9.10-ghc-boot-devel \
 ghc9.10-ghc-compact-devel \
 ghc9.10-ghc-devel \
 ghc9.10-ghc-heap-devel \
 ghc9.10-ghci-devel \
 ghc9.10-hpc-devel \
 "
RDEPENDS:ghc9.10-Cabal = " \
 ghc9.10-Cabal-syntax \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-binary \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-directory \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-parsec \
 ghc9.10-pretty \
 ghc9.10-process \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-text \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-Cabal-devel = " \
 ghc9.10-Cabal \
 ghc9.10-Cabal-syntax-devel \
 ghc9.10-array-devel \
 ghc9.10-base-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-containers-devel \
 ghc9.10-deepseq-devel \
 ghc9.10-directory-devel \
 ghc9.10-filepath-devel \
 ghc9.10-mtl-devel \
 ghc9.10-parsec-devel \
 ghc9.10-pretty-devel \
 ghc9.10-process-devel \
 ghc9.10-time-devel \
 ghc9.10-transformers-devel \
 ghc9.10-unix-devel \
 "
RDEPENDS:ghc9.10-Cabal-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-Cabal-syntax = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-binary \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-directory \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-parsec \
 ghc9.10-pretty \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-text \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-Cabal-syntax-devel = " \
 ghc9.10-Cabal-syntax \
 ghc9.10-array-devel \
 ghc9.10-base-devel \
 ghc9.10-binary-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-containers-devel \
 ghc9.10-deepseq-devel \
 ghc9.10-directory-devel \
 ghc9.10-filepath-devel \
 ghc9.10-mtl-devel \
 ghc9.10-parsec-devel \
 ghc9.10-pretty-devel \
 ghc9.10-text-devel \
 ghc9.10-time-devel \
 ghc9.10-transformers-devel \
 "
RDEPENDS:ghc9.10-Cabal-syntax-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-array = " \
 ghc9.10-base \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-array-devel = " \
 ghc9.10-array \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 "
RDEPENDS:ghc9.10-array-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-base = " \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 libffi \
 numactl-libs \
 "
RDEPENDS:ghc9.10-base-devel = " \
 ghc9.10-base \
 ghc9.10-compiler \
 ghc9.10-ghc-bignum-devel \
 gmp-devel \
 libffi-devel \
 numactl-devel \
 "
RDEPENDS:ghc9.10-base-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-binary = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-pretty \
 ghc9.10-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-binary-devel = " \
 ghc9.10-array-devel \
 ghc9.10-base-devel \
 ghc9.10-binary \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-containers-devel \
 "
RDEPENDS:ghc9.10-binary-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-bytestring = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-deepseq \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-pretty \
 ghc9.10-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-bytestring-devel = " \
 ghc9.10-base-devel \
 ghc9.10-bytestring \
 ghc9.10-compiler \
 ghc9.10-deepseq-devel \
 ghc9.10-template-haskell-devel \
 "
RDEPENDS:ghc9.10-bytestring-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-compiler = " \
 bash \
 binutils \
 gcc \
 ghc9.10-Cabal \
 ghc9.10-Cabal-syntax \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-base-devel \
 ghc9.10-binary \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-directory \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-filesystem \
 ghc9.10-ghc \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot \
 ghc9.10-ghc-boot-th \
 ghc9.10-ghc-heap \
 ghc9.10-ghc-platform \
 ghc9.10-ghc-toolchain \
 ghc9.10-ghci \
 ghc9.10-haskeline \
 ghc9.10-hpc \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-parsec \
 ghc9.10-pretty \
 ghc9.10-process \
 ghc9.10-semaphore-compat \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-terminfo \
 ghc9.10-text \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 ghc9.10-xhtml \
 glibc \
 gmp \
 libffi \
 ncurses-libs \
 numactl-libs \
 "
RDEPENDS:ghc9.10-compiler-default = " \
 bash \
 ghc9.10-compiler \
 "
RDEPENDS:ghc9.10-containers = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-deepseq \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-pretty \
 ghc9.10-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-containers-devel = " \
 ghc9.10-array-devel \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-containers \
 ghc9.10-deepseq-devel \
 ghc9.10-template-haskell-devel \
 "
RDEPENDS:ghc9.10-containers-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-deepseq = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-deepseq-devel = " \
 ghc9.10-array-devel \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-deepseq \
 "
RDEPENDS:ghc9.10-deepseq-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-devel = " \
 ghc9.10-Cabal-devel \
 ghc9.10-Cabal-syntax-devel \
 ghc9.10-array-devel \
 ghc9.10-base-devel \
 ghc9.10-binary-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-containers-devel \
 ghc9.10-deepseq-devel \
 ghc9.10-directory-devel \
 ghc9.10-exceptions-devel \
 ghc9.10-filepath-devel \
 ghc9.10-ghc-boot-th-devel \
 ghc9.10-haskeline-devel \
 ghc9.10-mtl-devel \
 ghc9.10-os-string-devel \
 ghc9.10-parsec-devel \
 ghc9.10-pretty-devel \
 ghc9.10-process-devel \
 ghc9.10-semaphore-compat-devel \
 ghc9.10-stm-devel \
 ghc9.10-template-haskell-devel \
 ghc9.10-terminfo-devel \
 ghc9.10-text-devel \
 ghc9.10-time-devel \
 ghc9.10-transformers-devel \
 ghc9.10-unix-devel \
 ghc9.10-xhtml-devel \
 "
RDEPENDS:ghc9.10-directory = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-bytestring \
 ghc9.10-deepseq \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-pretty \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-directory-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-directory \
 ghc9.10-filepath-devel \
 ghc9.10-os-string-devel \
 ghc9.10-time-devel \
 ghc9.10-unix-devel \
 "
RDEPENDS:ghc9.10-directory-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-doc = " \
 "
RDEPENDS:ghc9.10-doc-index = " \
 ghc9.10-compiler \
 "
RDEPENDS:ghc9.10-exceptions = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-deepseq \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-pretty \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-exceptions-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-exceptions \
 ghc9.10-mtl-devel \
 ghc9.10-stm-devel \
 ghc9.10-template-haskell-devel \
 ghc9.10-transformers-devel \
 "
RDEPENDS:ghc9.10-exceptions-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-filepath = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-bytestring \
 ghc9.10-deepseq \
 ghc9.10-exceptions \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-pretty \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-filepath-devel = " \
 ghc9.10-base-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-deepseq-devel \
 ghc9.10-exceptions-devel \
 ghc9.10-filepath \
 ghc9.10-os-string-devel \
 ghc9.10-template-haskell-devel \
 "
RDEPENDS:ghc9.10-filepath-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-filesystem = " \
 "
RDEPENDS:ghc9.10-ghc = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-binary \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-directory \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot \
 ghc9.10-ghc-boot-th \
 ghc9.10-ghc-heap \
 ghc9.10-ghc-platform \
 ghc9.10-ghci \
 ghc9.10-hpc \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-pretty \
 ghc9.10-process \
 ghc9.10-semaphore-compat \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-ghc-bignum = " \
 ghc9.10-base \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-ghc-bignum-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-ghc-bignum \
 "
RDEPENDS:ghc9.10-ghc-bignum-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-ghc-boot = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-binary \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-directory \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-ghc-platform \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-pretty \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-ghc-boot-devel = " \
 ghc9.10-base-devel \
 ghc9.10-binary-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-containers-devel \
 ghc9.10-deepseq-devel \
 ghc9.10-directory-devel \
 ghc9.10-filepath-devel \
 ghc9.10-ghc-boot \
 ghc9.10-ghc-boot-th-devel \
 ghc9.10-ghc-platform-devel \
 ghc9.10-unix-devel \
 "
RDEPENDS:ghc9.10-ghc-boot-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-ghc-boot-th = " \
 ghc9.10-base \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-ghc-boot-th-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-ghc-boot-th \
 "
RDEPENDS:ghc9.10-ghc-boot-th-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-ghc-compact = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-bytestring \
 ghc9.10-deepseq \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-pretty \
 ghc9.10-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-ghc-compact-devel = " \
 ghc9.10-base-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-ghc-compact \
 "
RDEPENDS:ghc9.10-ghc-compact-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-ghc-devel = " \
 ghc9.10-array-devel \
 ghc9.10-base-devel \
 ghc9.10-binary-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-containers-devel \
 ghc9.10-deepseq-devel \
 ghc9.10-directory-devel \
 ghc9.10-exceptions-devel \
 ghc9.10-filepath-devel \
 ghc9.10-ghc \
 ghc9.10-ghc-boot-devel \
 ghc9.10-ghc-heap-devel \
 ghc9.10-ghci-devel \
 ghc9.10-hpc-devel \
 ghc9.10-process-devel \
 ghc9.10-semaphore-compat-devel \
 ghc9.10-stm-devel \
 ghc9.10-template-haskell-devel \
 ghc9.10-time-devel \
 ghc9.10-transformers-devel \
 ghc9.10-unix-devel \
 "
RDEPENDS:ghc9.10-ghc-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-ghc-experimental = " \
 ghc9.10-base \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-ghc-experimental-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-ghc-experimental \
 "
RDEPENDS:ghc9.10-ghc-experimental-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-ghc-heap = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-pretty \
 ghc9.10-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-ghc-heap-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-containers-devel \
 ghc9.10-ghc-heap \
 "
RDEPENDS:ghc9.10-ghc-heap-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-ghc-platform = " \
 ghc9.10-base \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-ghc-platform-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-ghc-platform \
 "
RDEPENDS:ghc9.10-ghc-platform-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-ghc-toolchain = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-binary \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-directory \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-ghc-platform \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-pretty \
 ghc9.10-process \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-text \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-ghc-toolchain-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-directory-devel \
 ghc9.10-filepath-devel \
 ghc9.10-ghc-platform-devel \
 ghc9.10-ghc-toolchain \
 ghc9.10-process-devel \
 ghc9.10-text-devel \
 ghc9.10-transformers-devel \
 "
RDEPENDS:ghc9.10-ghc-toolchain-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-ghci = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-binary \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-directory \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot \
 ghc9.10-ghc-boot-th \
 ghc9.10-ghc-heap \
 ghc9.10-ghc-platform \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-pretty \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-ghci-devel = " \
 ghc9.10-array-devel \
 ghc9.10-base-devel \
 ghc9.10-binary-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-containers-devel \
 ghc9.10-deepseq-devel \
 ghc9.10-filepath-devel \
 ghc9.10-ghc-boot-devel \
 ghc9.10-ghc-heap-devel \
 ghc9.10-ghci \
 ghc9.10-template-haskell-devel \
 ghc9.10-transformers-devel \
 ghc9.10-unix-devel \
 "
RDEPENDS:ghc9.10-ghci-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-hadrian = " \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc9.10-haskeline = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-directory \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-pretty \
 ghc9.10-process \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-terminfo \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.10-haskeline-devel = " \
 ghc9.10-base-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-containers-devel \
 ghc9.10-directory-devel \
 ghc9.10-exceptions-devel \
 ghc9.10-filepath-devel \
 ghc9.10-haskeline \
 ghc9.10-process-devel \
 ghc9.10-stm-devel \
 ghc9.10-terminfo-devel \
 ghc9.10-transformers-devel \
 ghc9.10-unix-devel \
 "
RDEPENDS:ghc9.10-haskeline-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-hpc = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-directory \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-pretty \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-hpc-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-containers-devel \
 ghc9.10-deepseq-devel \
 ghc9.10-directory-devel \
 ghc9.10-filepath-devel \
 ghc9.10-hpc \
 ghc9.10-time-devel \
 "
RDEPENDS:ghc9.10-hpc-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-manual = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-mtl = " \
 ghc9.10-base \
 ghc9.10-ghc-bignum \
 ghc9.10-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-mtl-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-mtl \
 ghc9.10-transformers-devel \
 "
RDEPENDS:ghc9.10-mtl-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-os-string = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-bytestring \
 ghc9.10-deepseq \
 ghc9.10-exceptions \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-pretty \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-os-string-devel = " \
 ghc9.10-base-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-deepseq-devel \
 ghc9.10-exceptions-devel \
 ghc9.10-os-string \
 ghc9.10-template-haskell-devel \
 "
RDEPENDS:ghc9.10-os-string-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-parsec = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-binary \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-pretty \
 ghc9.10-template-haskell \
 ghc9.10-text \
 ghc9.10-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-parsec-devel = " \
 ghc9.10-base-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-mtl-devel \
 ghc9.10-parsec \
 ghc9.10-text-devel \
 "
RDEPENDS:ghc9.10-parsec-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-pretty = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-deepseq \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-pretty-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-deepseq-devel \
 ghc9.10-pretty \
 "
RDEPENDS:ghc9.10-pretty-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-process = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-bytestring \
 ghc9.10-deepseq \
 ghc9.10-directory \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-pretty \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-process-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-deepseq-devel \
 ghc9.10-directory-devel \
 ghc9.10-filepath-devel \
 ghc9.10-os-string-devel \
 ghc9.10-process \
 ghc9.10-unix-devel \
 "
RDEPENDS:ghc9.10-process-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-semaphore-compat = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-bytestring \
 ghc9.10-deepseq \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-pretty \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-semaphore-compat-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-exceptions-devel \
 ghc9.10-semaphore-compat \
 ghc9.10-unix-devel \
 "
RDEPENDS:ghc9.10-semaphore-compat-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-stm = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-stm-devel = " \
 ghc9.10-array-devel \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-stm \
 "
RDEPENDS:ghc9.10-stm-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-template-haskell = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-deepseq \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-pretty \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-template-haskell-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-ghc-boot-th-devel \
 ghc9.10-pretty-devel \
 ghc9.10-template-haskell \
 "
RDEPENDS:ghc9.10-template-haskell-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-terminfo = " \
 ghc9.10-base \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.10-terminfo-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-terminfo \
 ncurses-devel \
 "
RDEPENDS:ghc9.10-terminfo-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-text = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-binary \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-pretty \
 ghc9.10-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-text-devel = " \
 ghc9.10-array-devel \
 ghc9.10-base-devel \
 ghc9.10-binary-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-deepseq-devel \
 ghc9.10-template-haskell-devel \
 ghc9.10-text \
 "
RDEPENDS:ghc9.10-text-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-time = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-deepseq \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-time-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-deepseq-devel \
 ghc9.10-time \
 "
RDEPENDS:ghc9.10-time-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-transformers = " \
 ghc9.10-base \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-transformers-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-transformers \
 "
RDEPENDS:ghc9.10-transformers-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-unix = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-bytestring \
 ghc9.10-deepseq \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-pretty \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-time \
 ghc9.10-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-unix-devel = " \
 ghc9.10-base-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-filepath-devel \
 ghc9.10-os-string-devel \
 ghc9.10-time-devel \
 ghc9.10-unix \
 "
RDEPENDS:ghc9.10-unix-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-xhtml = " \
 ghc9.10-base \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-xhtml-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-xhtml \
 "
RDEPENDS:ghc9.10-xhtml-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-Cabal-prof = " \
 ghc9.10-Cabal-devel \
 "
RDEPENDS:ghc9.10-Cabal-syntax-prof = " \
 ghc9.10-Cabal-syntax-devel \
 "
RDEPENDS:ghc9.10-array-prof = " \
 ghc9.10-array-devel \
 "
RDEPENDS:ghc9.10-base-prof = " \
 ghc9.10-base-devel \
 glibc \
 gmp \
 libffi \
 numactl-libs \
 "
RDEPENDS:ghc9.10-binary-prof = " \
 ghc9.10-binary-devel \
 "
RDEPENDS:ghc9.10-bytestring-prof = " \
 ghc9.10-bytestring-devel \
 "
RDEPENDS:ghc9.10-containers-prof = " \
 ghc9.10-containers-devel \
 "
RDEPENDS:ghc9.10-deepseq-prof = " \
 ghc9.10-deepseq-devel \
 "
RDEPENDS:ghc9.10-directory-prof = " \
 ghc9.10-directory-devel \
 "
RDEPENDS:ghc9.10-exceptions-prof = " \
 ghc9.10-exceptions-devel \
 "
RDEPENDS:ghc9.10-filepath-prof = " \
 ghc9.10-filepath-devel \
 "
RDEPENDS:ghc9.10-ghc-bignum-prof = " \
 ghc9.10-ghc-bignum-devel \
 "
RDEPENDS:ghc9.10-ghc-boot-prof = " \
 ghc9.10-ghc-boot-devel \
 "
RDEPENDS:ghc9.10-ghc-boot-th-prof = " \
 ghc9.10-ghc-boot-th-devel \
 "
RDEPENDS:ghc9.10-ghc-compact-prof = " \
 ghc9.10-ghc-compact-devel \
 "
RDEPENDS:ghc9.10-ghc-experimental-prof = " \
 ghc9.10-ghc-experimental-devel \
 "
RDEPENDS:ghc9.10-ghc-heap-prof = " \
 ghc9.10-ghc-heap-devel \
 "
RDEPENDS:ghc9.10-ghc-platform-prof = " \
 ghc9.10-ghc-platform-devel \
 "
RDEPENDS:ghc9.10-ghc-prof = " \
 ghc9.10-ghc-devel \
 "
RDEPENDS:ghc9.10-ghc-toolchain-prof = " \
 ghc9.10-ghc-toolchain-devel \
 "
RDEPENDS:ghc9.10-ghci-prof = " \
 ghc9.10-ghci-devel \
 "
RDEPENDS:ghc9.10-haskeline-prof = " \
 ghc9.10-haskeline-devel \
 "
RDEPENDS:ghc9.10-hpc-prof = " \
 ghc9.10-hpc-devel \
 "
RDEPENDS:ghc9.10-mtl-prof = " \
 ghc9.10-mtl-devel \
 "
RDEPENDS:ghc9.10-os-string-prof = " \
 ghc9.10-os-string-devel \
 "
RDEPENDS:ghc9.10-parsec-prof = " \
 ghc9.10-parsec-devel \
 "
RDEPENDS:ghc9.10-pretty-prof = " \
 ghc9.10-pretty-devel \
 "
RDEPENDS:ghc9.10-process-prof = " \
 ghc9.10-process-devel \
 "
RDEPENDS:ghc9.10-prof = " \
 ghc9.10-compiler \
 "
RDEPENDS:ghc9.10-semaphore-compat-prof = " \
 ghc9.10-semaphore-compat-devel \
 "
RDEPENDS:ghc9.10-stm-prof = " \
 ghc9.10-stm-devel \
 "
RDEPENDS:ghc9.10-template-haskell-prof = " \
 ghc9.10-template-haskell-devel \
 "
RDEPENDS:ghc9.10-terminfo-prof = " \
 ghc9.10-terminfo-devel \
 "
RDEPENDS:ghc9.10-text-prof = " \
 ghc9.10-text-devel \
 "
RDEPENDS:ghc9.10-time-prof = " \
 ghc9.10-time-devel \
 "
RDEPENDS:ghc9.10-transformers-prof = " \
 ghc9.10-transformers-devel \
 "
RDEPENDS:ghc9.10-unix-prof = " \
 ghc9.10-unix-devel \
 "
RDEPENDS:ghc9.10-xhtml-prof = " \
 ghc9.10-xhtml-devel \
 "
