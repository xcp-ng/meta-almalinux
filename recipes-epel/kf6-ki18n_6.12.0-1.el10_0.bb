# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-ki18n"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-ki18n \
 kf6-ki18n-devel \
 kf6-ki18n-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-ki18n-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f7a449056ce985c56635b69b95015bdf8d8365219a51948aa612961a83215fd"

URI_x86_64_v2_kf6-ki18n = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ki18n-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ki18n;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ki18n}"
SRC_URI[x86_64_v2_kf6-ki18n.sha256sum] = "a60d2431ada6f801a6fc44d8d1dc9c76bee528f853a9a4ab7ded53df78f37498"

URI_x86_64_v2_kf6-ki18n-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ki18n-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ki18n-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ki18n-devel}"
SRC_URI[x86_64_v2_kf6-ki18n-devel.sha256sum] = "f27f6dcc3ddf3f84995198006876c6bf4fb04f3c6f23211f005772604c639fe0"

URI_x86_64_v2_kf6-ki18n-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ki18n-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ki18n-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ki18n-doc}"
SRC_URI[x86_64_v2_kf6-ki18n-doc.sha256sum] = "61b460ac603d4034bfc1f7d868f1c2623824c09f91afbce0efb40d88dcdd4c1b"

URI_aarch64_kf6-ki18n = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ki18n-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-ki18n;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ki18n}"
SRC_URI[aarch64_kf6-ki18n.sha256sum] = "f186ba45cd194d54e9ca7e8986831147c98fc9cdf1163ccc1b389a5c31d1e156"

URI_aarch64_kf6-ki18n-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ki18n-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-ki18n-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ki18n-devel}"
SRC_URI[aarch64_kf6-ki18n-devel.sha256sum] = "90654394941f8bb1d8ffe6b541544df19ba848b38df4f7f7c4e226b945b90d10"

URI_aarch64_kf6-ki18n-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ki18n-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-ki18n-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ki18n-doc}"
SRC_URI[aarch64_kf6-ki18n-doc.sha256sum] = "f398268f5ec8b6f671d1e360c1238f0bc3ff63604d07a48ee9d41be2b415b111"

RDEPENDS:kf6-ki18n = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-ki18n-devel = " \
 cmake-filesystem \
 gettext \
 kf6-ki18n \
 python3 \
 "
RDEPENDS:kf6-ki18n-doc = " \
 "
