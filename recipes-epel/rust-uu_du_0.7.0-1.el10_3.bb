# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_du"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_du+default-devel \
 rust-uu_du-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_du-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fc214bf874b710f2f4d1a1c5ac371ed01e299432c92da5f2aeea03dc365a85b7"

URI_x86_64_v2_rust-uu_du+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_du+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_du+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_du+default-devel}"
SRC_URI[x86_64_v2_rust-uu_du+default-devel.sha256sum] = "e1832235cbe37280b3728bd9fd1cfb26a0b05de9868b443a057ef7746eb18f76"

URI_x86_64_v2_rust-uu_du-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_du-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_du-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_du-devel}"
SRC_URI[x86_64_v2_rust-uu_du-devel.sha256sum] = "436dd92df11fd1b262a518cad5261f3e8fdfef1c18f9687e4845cb4bf88de120"

URI_aarch64_rust-uu_du+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_du+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_du+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_du+default-devel}"
SRC_URI[aarch64_rust-uu_du+default-devel.sha256sum] = "e7b275628aeb501e59b9a6ad88302a0bfa5a577480a9e9fbefcdc314461f3636"

URI_aarch64_rust-uu_du-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_du-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_du-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_du-devel}"
SRC_URI[aarch64_rust-uu_du-devel.sha256sum] = "23fc48d07815c5fcb0922523061c76d9ac255a9953971887b82d2bbb36bed3a3"

RDEPENDS:rust-uu_du+default-devel = " \
 cargo \
 rust-uu_du-devel \
 "
RDEPENDS:rust-uu_du-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-glob+default-devel \
 rust-rustc-hash+default-devel \
 rust-thiserror+default-devel \
 rust-uucore+default-devel \
 rust-uucore+format-devel \
 rust-uucore+fsext-devel \
 rust-uucore+parser-glob-devel \
 rust-uucore+parser-size-devel \
 rust-uucore+safe-traversal-devel \
 rust-uucore+time-devel \
 "
