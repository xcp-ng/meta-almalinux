# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aws-c-io"
PV = "0.18.1"
PR = "1.el10_1"
PACKAGES = " \
 aws-c-io \
 aws-c-io-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/aws-c-io-0.18.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fb02a55c7230f6e3805338a5527698fb6b8fd574172bd88a99d5de64302d30c5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-io-0.18.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-io;unpack=0"
SRC_URI[x86_64_v2_aws-c-io.sha256sum] = "057479e313b4fdefe5beb30c4eed580685831de1803db74f81cf7fc9226b9979"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-io-devel-0.18.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-io-devel;unpack=0"
SRC_URI[x86_64_v2_aws-c-io-devel.sha256sum] = "7a278dfabd68b67a1a5a664f2546abf0cea2000e8d51b2bbed5c1f562a398ff8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/aws-c-io-0.18.1-1.el10_1.aarch64.rpm;name=aarch64_aws-c-io;unpack=0"
SRC_URI[aarch64_aws-c-io.sha256sum] = "653c29402fdfe134681664537faa70a109bbe9360bedb3a3f9bf1a8ad0d53271"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/aws-c-io-devel-0.18.1-1.el10_1.aarch64.rpm;name=aarch64_aws-c-io-devel;unpack=0"
SRC_URI[aarch64_aws-c-io-devel.sha256sum] = "b3e227faaa99c0c30975971de28d22f83746b2d704b327c510eaa65f46b36414"

RDEPENDS:aws-c-io = " \
 aws-c-cal-libs \
 aws-c-common-libs \
 glibc \
 s2n-tls \
 "
RDEPENDS:aws-c-io-devel = " \
 aws-c-cal-devel \
 aws-c-common-devel \
 aws-c-io \
 cmake-filesystem \
 openssl-devel \
 s2n-tls-devel \
 "
