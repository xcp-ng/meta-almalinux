# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-reportlab"
PV = "4.4.1"
PR = "2.el10_1"
PACKAGES = " \
 python3-reportlab \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-reportlab-4.4.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "67a435cfd25692c723b09ee575e18cac7380e1d1e5e783570520e3260c881d91"

URI_x86_64_v2_python3-reportlab = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-reportlab-4.4.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-reportlab;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-reportlab}"
SRC_URI[x86_64_v2_python3-reportlab.sha256sum] = "0117032de00b45da789b1791ddea7e82fdd50ffcb81d1c9439e89c4fa6ac4523"

URI_aarch64_python3-reportlab = "${EPEL_MIRROR}/aarch64/Packages/p/python3-reportlab-4.4.1-2.el10_1.noarch.rpm;name=aarch64_python3-reportlab;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-reportlab}"
SRC_URI[aarch64_python3-reportlab.sha256sum] = "44e47c257d182f89b0c770a4195e195a4dd4a491fd908dd42bda52d09adeaae6"

RDEPENDS:python3-reportlab = " \
 dejavu-sans-fonts \
 python3 \
 python3-chardet \
 python3-pillow \
 "
