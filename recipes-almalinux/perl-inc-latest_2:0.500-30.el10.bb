# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-inc-latest"
PE = "2"
PV = "0.500"
PR = "30.el10"
PACKAGES = " \
 perl-inc-latest \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-inc-latest-0.500-30.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0b7b46a56c6a353a8338a93c69c764124328f5b6d2d5099a04884b76e44f604c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-inc-latest-0.500-30.el10.noarch.rpm;name=x86_64_v2_perl-inc-latest;unpack=0"
SRC_URI[x86_64_v2_perl-inc-latest.sha256sum] = "82d28276df1122d6ea851410a69a8d2b3a197ff21f611421e075d5182be7e42b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-inc-latest-0.500-30.el10.noarch.rpm;name=aarch64_perl-inc-latest;unpack=0"
SRC_URI[aarch64_perl-inc-latest.sha256sum] = "82d28276df1122d6ea851410a69a8d2b3a197ff21f611421e075d5182be7e42b"

RDEPENDS:perl-inc-latest = " \
 perl-Carp \
 perl-ExtUtils-Install \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Path \
 perl-IO \
 perl-PathTools \
 perl-libs \
 "
