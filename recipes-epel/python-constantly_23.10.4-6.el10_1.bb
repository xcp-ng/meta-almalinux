# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-constantly"
PV = "23.10.4"
PR = "6.el10_1"
PACKAGES = " \
 python-constantly-doc \
 python3-constantly \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-constantly-23.10.4-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e25c7ff85044e02025ef16f1324c853c826c2e7434b27de960733203904090ce"

URI_x86_64_v2_python-constantly-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-constantly-doc-23.10.4-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-constantly-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-constantly-doc}"
SRC_URI[x86_64_v2_python-constantly-doc.sha256sum] = "9831e4b109b45cacf59486736911fb300efe9f6e8d23107b04d255d52f39f41a"

URI_x86_64_v2_python3-constantly = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-constantly-23.10.4-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-constantly;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-constantly}"
SRC_URI[x86_64_v2_python3-constantly.sha256sum] = "b51e348f084905d6964ee5f8a13f5a7b676d7b71a501de4272a01fde34b0a5f4"

URI_aarch64_python-constantly-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-constantly-doc-23.10.4-6.el10_1.noarch.rpm;name=aarch64_python-constantly-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-constantly-doc}"
SRC_URI[aarch64_python-constantly-doc.sha256sum] = "235f656c5ebd54d9ff70047d006c52e38943f29682d9cc13291b0f6bbcc1460f"

URI_aarch64_python3-constantly = "${EPEL_MIRROR}/aarch64/Packages/p/python3-constantly-23.10.4-6.el10_1.noarch.rpm;name=aarch64_python3-constantly;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-constantly}"
SRC_URI[aarch64_python3-constantly.sha256sum] = "802c7e3b8f62249caa251889c15194f33fe369ec048294eb9c22d8b14d45c2e1"

RDEPENDS:python-constantly-doc = " \
 "
RDEPENDS:python3-constantly = " \
 python3 \
 "
