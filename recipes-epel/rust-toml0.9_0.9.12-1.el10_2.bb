# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-toml0.9"
PV = "0.9.12"
PR = "1.el10_2"
PACKAGES = " \
 rust-toml0.9+debug-devel \
 rust-toml0.9+default-devel \
 rust-toml0.9+display-devel \
 rust-toml0.9+fast_hash-devel \
 rust-toml0.9+parse-devel \
 rust-toml0.9+preserve_order-devel \
 rust-toml0.9+serde-devel \
 rust-toml0.9+std-devel \
 rust-toml0.9+unbounded-devel \
 rust-toml0.9-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-toml0.9-0.9.12-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "13b2aa3d1eeec0cb744bf9aa975cba34ac0fd52cedc1c213a98090aaef2aad77"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - rust-toml0.9+debug-devel: (crate(toml_parser) >= 1.0.7 with crate(toml_parser) < 2.0.0~)
# - rust-toml0.9+debug-devel: (crate(toml_parser/alloc) >= 1.0.7 with crate(toml_parser/alloc) < 2.0.0~)
# - rust-toml0.9+debug-devel: (crate(toml_parser/debug) >= 1.0.7 with crate(toml_parser/debug) < 2.0.0~)
# - rust-toml0.9+parse-devel: (crate(toml_parser) >= 1.0.7 with crate(toml_parser) < 2.0.0~)
# - rust-toml0.9+parse-devel: (crate(toml_parser/alloc) >= 1.0.7 with crate(toml_parser/alloc) < 2.0.0~)
# - rust-toml0.9+std-devel: (crate(toml_parser) >= 1.0.7 with crate(toml_parser) < 2.0.0~)
# - rust-toml0.9+std-devel: (crate(toml_parser/alloc) >= 1.0.7 with crate(toml_parser/alloc) < 2.0.0~)
# - rust-toml0.9+std-devel: (crate(toml_parser/std) >= 1.0.7 with crate(toml_parser/std) < 2.0.0~)

URI_x86_64_v2_rust-toml0.9+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml0.9+debug-devel-0.9.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml0.9+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml0.9+debug-devel}"
SRC_URI[x86_64_v2_rust-toml0.9+debug-devel.sha256sum] = "6bbfaf21878bf338afc9fb2da540bf60fce308745157bafbcc9a800784ffa5a5"

URI_x86_64_v2_rust-toml0.9+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml0.9+default-devel-0.9.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml0.9+default-devel}"
SRC_URI[x86_64_v2_rust-toml0.9+default-devel.sha256sum] = "cc167607cc01568144ef6a5f550a31c9e517a704698cb55cfe52efab39fa1abb"
RPROVIDES:rust-toml0.9+default-devel:x86_64_v2 = "virtual/crate_toml/default__ge_0.6.0_with_crate_toml/default__lt_2.0.0~"

URI_x86_64_v2_rust-toml0.9+display-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml0.9+display-devel-0.9.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml0.9+display-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml0.9+display-devel}"
SRC_URI[x86_64_v2_rust-toml0.9+display-devel.sha256sum] = "fe89ed878320eaf45d12fefa56c1880da9ceee1a906a4b563d2e5455b44c4b71"

URI_x86_64_v2_rust-toml0.9+fast_hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml0.9+fast_hash-devel-0.9.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml0.9+fast_hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml0.9+fast_hash-devel}"
SRC_URI[x86_64_v2_rust-toml0.9+fast_hash-devel.sha256sum] = "93ae31c7a02b744589c2474577570db8419f089391d273e8cac90d7cff43b723"

URI_x86_64_v2_rust-toml0.9+parse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml0.9+parse-devel-0.9.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml0.9+parse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml0.9+parse-devel}"
SRC_URI[x86_64_v2_rust-toml0.9+parse-devel.sha256sum] = "f69bae4343e15efccda7ad03e82b3f1bb35f0059635a9fb61646972db1655f06"

URI_x86_64_v2_rust-toml0.9+preserve_order-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml0.9+preserve_order-devel-0.9.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml0.9+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml0.9+preserve_order-devel}"
SRC_URI[x86_64_v2_rust-toml0.9+preserve_order-devel.sha256sum] = "fc132124b8ef25ca89581c393be6f7c8a4488a57c58c32b4b150fa64ad9728f4"

URI_x86_64_v2_rust-toml0.9+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml0.9+serde-devel-0.9.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml0.9+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml0.9+serde-devel}"
SRC_URI[x86_64_v2_rust-toml0.9+serde-devel.sha256sum] = "d9f16e944f66c7e2f29744e57b4e9591c2873bab6180e4929bb2912e3215b2cd"

URI_x86_64_v2_rust-toml0.9+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml0.9+std-devel-0.9.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml0.9+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml0.9+std-devel}"
SRC_URI[x86_64_v2_rust-toml0.9+std-devel.sha256sum] = "48052f122bf74fc776293e29f0e5b9d7b39f5134c32ae528b4f3dcdcf6e4bd4d"

URI_x86_64_v2_rust-toml0.9+unbounded-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml0.9+unbounded-devel-0.9.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml0.9+unbounded-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml0.9+unbounded-devel}"
SRC_URI[x86_64_v2_rust-toml0.9+unbounded-devel.sha256sum] = "543896bad8880fd81f840a065523fe83cdcc71e0971bf0121a92ac38b81e3bc2"

URI_x86_64_v2_rust-toml0.9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml0.9-devel-0.9.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml0.9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml0.9-devel}"
SRC_URI[x86_64_v2_rust-toml0.9-devel.sha256sum] = "49e6ffe393bf774295ba021562ca392650d6f29c0beebfedbeea0247a05289c9"

URI_aarch64_rust-toml0.9+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml0.9+debug-devel-0.9.12-1.el10_2.noarch.rpm;name=aarch64_rust-toml0.9+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml0.9+debug-devel}"
SRC_URI[aarch64_rust-toml0.9+debug-devel.sha256sum] = "059b6a19390f798124d427fe0a9c4c0defb1d02cbfd8889ea7f48d1a646d27bf"

URI_aarch64_rust-toml0.9+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml0.9+default-devel-0.9.12-1.el10_2.noarch.rpm;name=aarch64_rust-toml0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml0.9+default-devel}"
SRC_URI[aarch64_rust-toml0.9+default-devel.sha256sum] = "37805f74663cdecdc10b02fa17c779fbfbed8b422e46d317892746748766a27d"
RPROVIDES:rust-toml0.9+default-devel:aarch64 = "virtual/crate_toml/default__ge_0.6.0_with_crate_toml/default__lt_2.0.0~"

URI_aarch64_rust-toml0.9+display-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml0.9+display-devel-0.9.12-1.el10_2.noarch.rpm;name=aarch64_rust-toml0.9+display-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml0.9+display-devel}"
SRC_URI[aarch64_rust-toml0.9+display-devel.sha256sum] = "31b2103922d9c650738e45b875916b3edcd93fce094890226a65fc1070bd8d55"

URI_aarch64_rust-toml0.9+fast_hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml0.9+fast_hash-devel-0.9.12-1.el10_2.noarch.rpm;name=aarch64_rust-toml0.9+fast_hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml0.9+fast_hash-devel}"
SRC_URI[aarch64_rust-toml0.9+fast_hash-devel.sha256sum] = "effd112808bf8c308d41dd32f18d10f778b28757923589e4e56dca87a58c50ef"

URI_aarch64_rust-toml0.9+parse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml0.9+parse-devel-0.9.12-1.el10_2.noarch.rpm;name=aarch64_rust-toml0.9+parse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml0.9+parse-devel}"
SRC_URI[aarch64_rust-toml0.9+parse-devel.sha256sum] = "e99b1f948344a39db46d28ab52173d742f6f2856f5dff10a92f67fa191ad8081"

URI_aarch64_rust-toml0.9+preserve_order-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml0.9+preserve_order-devel-0.9.12-1.el10_2.noarch.rpm;name=aarch64_rust-toml0.9+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml0.9+preserve_order-devel}"
SRC_URI[aarch64_rust-toml0.9+preserve_order-devel.sha256sum] = "02e9f03f69e7fc02b6138c7b24eb62008f628cdae0236f9f1958d0e067d73ec2"

URI_aarch64_rust-toml0.9+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml0.9+serde-devel-0.9.12-1.el10_2.noarch.rpm;name=aarch64_rust-toml0.9+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml0.9+serde-devel}"
SRC_URI[aarch64_rust-toml0.9+serde-devel.sha256sum] = "ecad47c7637ec515fa989df6d387cef82f062824a3b861a722297a81e52ef126"

URI_aarch64_rust-toml0.9+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml0.9+std-devel-0.9.12-1.el10_2.noarch.rpm;name=aarch64_rust-toml0.9+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml0.9+std-devel}"
SRC_URI[aarch64_rust-toml0.9+std-devel.sha256sum] = "e4b23b8e201d6474d51f9494580a003f7f06c408b226ad800b71a60f83d07cd9"

URI_aarch64_rust-toml0.9+unbounded-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml0.9+unbounded-devel-0.9.12-1.el10_2.noarch.rpm;name=aarch64_rust-toml0.9+unbounded-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml0.9+unbounded-devel}"
SRC_URI[aarch64_rust-toml0.9+unbounded-devel.sha256sum] = "310b350d15cec83eb268072081af3e58dd5bda4438b34e34f1bdffc464edd120"

URI_aarch64_rust-toml0.9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml0.9-devel-0.9.12-1.el10_2.noarch.rpm;name=aarch64_rust-toml0.9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml0.9-devel}"
SRC_URI[aarch64_rust-toml0.9-devel.sha256sum] = "521617bd4b0d2d636e20cc22ed7f907ba2670260b799973c953fdf020a80ee23"

RDEPENDS:rust-toml0.9+debug-devel:x86_64_v2 = " \
 cargo \
 rust-anstream0.6+default-devel \
 rust-anstyle+default-devel \
 rust-toml0.9+std-devel \
 rust-toml0.9-devel \
"
RDEPENDS:rust-toml0.9+debug-devel:aarch64 = " \
 cargo \
 rust-anstream0.6+default-devel \
 rust-anstyle+default-devel \
 rust-toml0.9+std-devel \
 rust-toml0.9-devel \
 rust-toml_parser+alloc-devel \
 rust-toml_parser+debug-devel \
 rust-toml_parser-devel \
"
RDEPENDS:rust-toml0.9+default-devel = " \
 cargo \
 rust-toml0.9+display-devel \
 rust-toml0.9+parse-devel \
 rust-toml0.9+serde-devel \
 rust-toml0.9+std-devel \
 rust-toml0.9-devel \
 "
RDEPENDS:rust-toml0.9+display-devel = " \
 cargo \
 rust-toml0.9-devel \
 rust-toml_writer+alloc-devel \
 rust-toml_writer-devel \
 "
RDEPENDS:rust-toml0.9+fast_hash-devel = " \
 cargo \
 rust-foldhash-devel \
 rust-toml0.9+preserve_order-devel \
 rust-toml0.9-devel \
 "
RDEPENDS:rust-toml0.9+parse-devel:x86_64_v2 = " \
 cargo \
 rust-toml0.9-devel \
 rust-winnow0.7-devel \
"
RDEPENDS:rust-toml0.9+parse-devel:aarch64 = " \
 cargo \
 rust-toml0.9-devel \
 rust-toml_parser+alloc-devel \
 rust-toml_parser-devel \
 rust-winnow0.7-devel \
"
RDEPENDS:rust-toml0.9+preserve_order-devel = " \
 cargo \
 rust-indexmap-devel \
 rust-toml0.9+std-devel \
 rust-toml0.9-devel \
 "
RDEPENDS:rust-toml0.9+serde-devel = " \
 cargo \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 rust-serde_spanned+serde-devel \
 rust-toml0.9-devel \
 rust-toml_datetime0.7+serde-devel \
 "
RDEPENDS:rust-toml0.9+std-devel:x86_64_v2 = " \
 cargo \
 rust-indexmap+std-devel \
 rust-indexmap-devel \
 rust-serde_core+alloc-devel \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 rust-serde_spanned+std-devel \
 rust-toml0.9-devel \
 rust-toml_datetime0.7+std-devel \
 rust-toml_writer+alloc-devel \
 rust-toml_writer+std-devel \
 rust-toml_writer-devel \
"
RDEPENDS:rust-toml0.9+std-devel:aarch64 = " \
 cargo \
 rust-indexmap+std-devel \
 rust-indexmap-devel \
 rust-serde_core+alloc-devel \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 rust-serde_spanned+std-devel \
 rust-toml0.9-devel \
 rust-toml_datetime0.7+std-devel \
 rust-toml_parser+alloc-devel \
 rust-toml_parser+std-devel \
 rust-toml_parser-devel \
 rust-toml_writer+alloc-devel \
 rust-toml_writer+std-devel \
 rust-toml_writer-devel \
"
RDEPENDS:rust-toml0.9+unbounded-devel = " \
 cargo \
 rust-toml0.9-devel \
 "
RDEPENDS:rust-toml0.9-devel = " \
 cargo \
 rust \
 rust-serde_spanned+alloc-devel \
 rust-serde_spanned-devel \
 rust-toml_datetime0.7+alloc-devel \
 rust-toml_datetime0.7-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_toml/default__ge_0.6.0_with_crate_toml/default__lt_2.0.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_toml/default__ge_0.6.0_with_crate_toml/default__lt_2.0.0~"
