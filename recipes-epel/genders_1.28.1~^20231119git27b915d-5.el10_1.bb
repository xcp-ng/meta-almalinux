# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "genders"
PV = "1.28.1~^20231119git27b915d"
PR = "5.el10_1"
PACKAGES = " \
 genders \
 genders-compat \
 genders-java \
 genders-java-devel \
 genders-javadoc \
 genders-perl \
 libgenders \
 libgenders-devel \
 libgendersplusplus \
 libgendersplusplus-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/genders-1.28.1~^20231119git27b915d-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "145bf73324568764d12d7107249559e1b0ba0fc9e2fe7a7824c014e1158d06aa"

URI_x86_64_v2_genders = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/genders-1.28.1~^20231119git27b915d-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_genders;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_genders}"
SRC_URI[x86_64_v2_genders.sha256sum] = "3f846e21fdddc4d87f11b7b205b607e6af36a0f0f98143af4888e4ace4858216"

URI_x86_64_v2_genders-compat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/genders-compat-1.28.1~^20231119git27b915d-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_genders-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_genders-compat}"
SRC_URI[x86_64_v2_genders-compat.sha256sum] = "eb31a4e887248ed4afdd33fc29d3f3ac82dbbd99d480ece37afd987266a47e56"

URI_x86_64_v2_genders-java = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/genders-java-1.28.1~^20231119git27b915d-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_genders-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_genders-java}"
SRC_URI[x86_64_v2_genders-java.sha256sum] = "09f43e08fcd9c48171e6061425798143ed2246d43fe2296b9c5678c3890d2e11"

URI_x86_64_v2_genders-java-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/genders-java-devel-1.28.1~^20231119git27b915d-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_genders-java-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_genders-java-devel}"
SRC_URI[x86_64_v2_genders-java-devel.sha256sum] = "d206522ee9fb04ebecb7fc8f599f1747af666a3bb374f1ef34615613512cfe02"

URI_x86_64_v2_genders-javadoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/genders-javadoc-1.28.1~^20231119git27b915d-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_genders-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_genders-javadoc}"
SRC_URI[x86_64_v2_genders-javadoc.sha256sum] = "e8e3087657542b0b441fd374460669518f8866c79a3a65793d27419f5c7d1931"

URI_x86_64_v2_genders-perl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/genders-perl-1.28.1~^20231119git27b915d-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_genders-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_genders-perl}"
SRC_URI[x86_64_v2_genders-perl.sha256sum] = "7e336dd613aa8dad440d513e74aefac2c6bbacdc431f1fce05a4adbd188e574b"

URI_x86_64_v2_libgenders = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgenders-1.28.1~^20231119git27b915d-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgenders;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgenders}"
SRC_URI[x86_64_v2_libgenders.sha256sum] = "e0bb4b3e559095d2b2c74f1b0baf194fdda5e560dfff3d02798280f74aefd07d"

URI_x86_64_v2_libgenders-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgenders-devel-1.28.1~^20231119git27b915d-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgenders-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgenders-devel}"
SRC_URI[x86_64_v2_libgenders-devel.sha256sum] = "e2dc30e6a4cc4c84255bd01df68061535dc4a184baf68b74defddc0fbc094871"

URI_x86_64_v2_libgendersplusplus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgendersplusplus-1.28.1~^20231119git27b915d-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgendersplusplus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgendersplusplus}"
SRC_URI[x86_64_v2_libgendersplusplus.sha256sum] = "efcfbc340c1e94660e045ab9f91bb5840d1ff48766055c8360a879e3acdb587e"

URI_x86_64_v2_libgendersplusplus-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgendersplusplus-devel-1.28.1~^20231119git27b915d-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgendersplusplus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgendersplusplus-devel}"
SRC_URI[x86_64_v2_libgendersplusplus-devel.sha256sum] = "fb284d3a8136e86b51de0f0f26030ed81e52cf4a2a33857e831ea338e94544db"

URI_aarch64_genders = "${EPEL_MIRROR}/aarch64/Packages/g/genders-1.28.1~^20231119git27b915d-5.el10_1.aarch64.rpm;name=aarch64_genders;unpack=0"
SRC_URI:append = " ${URI_aarch64_genders}"
SRC_URI[aarch64_genders.sha256sum] = "260842fff1ef3bfdb8be4d66b1c5db7612e6efd777164218c660d969e245777e"

URI_aarch64_genders-compat = "${EPEL_MIRROR}/aarch64/Packages/g/genders-compat-1.28.1~^20231119git27b915d-5.el10_1.noarch.rpm;name=aarch64_genders-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_genders-compat}"
SRC_URI[aarch64_genders-compat.sha256sum] = "b24f5b761702108a84a363ec0b0722926fcad90797691fc5e4b9e4fd52936f61"

URI_aarch64_genders-java = "${EPEL_MIRROR}/aarch64/Packages/g/genders-java-1.28.1~^20231119git27b915d-5.el10_1.aarch64.rpm;name=aarch64_genders-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_genders-java}"
SRC_URI[aarch64_genders-java.sha256sum] = "7ce6de2e9deac6b7139804631974555873480d6aa9b3fd68749fefd2a11db1e8"

URI_aarch64_genders-java-devel = "${EPEL_MIRROR}/aarch64/Packages/g/genders-java-devel-1.28.1~^20231119git27b915d-5.el10_1.aarch64.rpm;name=aarch64_genders-java-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_genders-java-devel}"
SRC_URI[aarch64_genders-java-devel.sha256sum] = "fa260c0f015a2fcb66bb06ad696d9d0a1acd4ee46dee0434e2c82d46268a9f07"

URI_aarch64_genders-javadoc = "${EPEL_MIRROR}/aarch64/Packages/g/genders-javadoc-1.28.1~^20231119git27b915d-5.el10_1.aarch64.rpm;name=aarch64_genders-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_genders-javadoc}"
SRC_URI[aarch64_genders-javadoc.sha256sum] = "f6e56ccf8b6fbfa082c6ed1ba635451191e8bcbff11fdbf095213dca95bd970b"

URI_aarch64_genders-perl = "${EPEL_MIRROR}/aarch64/Packages/g/genders-perl-1.28.1~^20231119git27b915d-5.el10_1.aarch64.rpm;name=aarch64_genders-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_genders-perl}"
SRC_URI[aarch64_genders-perl.sha256sum] = "6ede014f0569cb804a4711b6ff493e878b1a19e2a1b0171f6748841ed8daa650"

URI_aarch64_libgenders = "${EPEL_MIRROR}/aarch64/Packages/l/libgenders-1.28.1~^20231119git27b915d-5.el10_1.aarch64.rpm;name=aarch64_libgenders;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgenders}"
SRC_URI[aarch64_libgenders.sha256sum] = "59c05fba0d7889b5d2721c945b47cd1040394768144b6422f888ce509c5dbc36"

URI_aarch64_libgenders-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libgenders-devel-1.28.1~^20231119git27b915d-5.el10_1.aarch64.rpm;name=aarch64_libgenders-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgenders-devel}"
SRC_URI[aarch64_libgenders-devel.sha256sum] = "f473588cc6453da197cbbee4630b0e89bd441d1fd0e49432f41d7e0243ece7a0"

URI_aarch64_libgendersplusplus = "${EPEL_MIRROR}/aarch64/Packages/l/libgendersplusplus-1.28.1~^20231119git27b915d-5.el10_1.aarch64.rpm;name=aarch64_libgendersplusplus;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgendersplusplus}"
SRC_URI[aarch64_libgendersplusplus.sha256sum] = "d385ae70d85f12bb65ecdec4052231be4f85c08768dd2c33d4e6611e5d94c979"

URI_aarch64_libgendersplusplus-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libgendersplusplus-devel-1.28.1~^20231119git27b915d-5.el10_1.aarch64.rpm;name=aarch64_libgendersplusplus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgendersplusplus-devel}"
SRC_URI[aarch64_libgendersplusplus-devel.sha256sum] = "2fb223051da848a3bbd7a4322d3d4ae85b81844df81ff9ae3d93c30868118445"

RDEPENDS:genders = " \
 glibc \
 libgenders \
 "
RDEPENDS:genders-compat = " \
 "
RDEPENDS:genders-java = " \
 glibc \
 libgenders \
 "
RDEPENDS:genders-java-devel = " \
 genders-java \
 "
RDEPENDS:genders-javadoc = " \
 "
RDEPENDS:genders-perl = " \
 genders-perl \
 glibc \
 libgenders \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:libgenders = " \
 glibc \
 "
RDEPENDS:libgenders-devel = " \
 libgenders \
 "
RDEPENDS:libgendersplusplus = " \
 glibc \
 libgcc \
 libgenders \
 libstdc++ \
 "
RDEPENDS:libgendersplusplus-devel = " \
 libgenders-devel \
 libgendersplusplus \
 "
