# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zig"
PV = "0.15.2"
PR = "2.el10_2"
PACKAGES:x86_64_v2 = " \
 zig \
 zig-doc \
 zig-libs \
 zig-rpm-macros \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/z/zig-0.15.2-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a0c788042bf35376d9ef8dc6778270d47927381199f200903784b65e5f309b1"

URI_x86_64_v2_zig = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zig-0.15.2-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zig}"
SRC_URI[x86_64_v2_zig.sha256sum] = "631fee2fae7afae0b50283d53aa45e11ecf5c800b9670d09c76f53f25b2f8ce9"

URI_x86_64_v2_zig-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zig-doc-0.15.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_zig-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zig-doc}"
SRC_URI[x86_64_v2_zig-doc.sha256sum] = "b62dc1f991fb89e010a8bc41a4f69f5df538e1a0217598cce520205e99c18783"

URI_x86_64_v2_zig-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zig-libs-0.15.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_zig-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zig-libs}"
SRC_URI[x86_64_v2_zig-libs.sha256sum] = "6ca4fe689d1fa96822e896c154c6f7a66fdc7f9044c3208dbaae51af08b895b5"

URI_x86_64_v2_zig-rpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zig-rpm-macros-0.15.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_zig-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zig-rpm-macros}"
SRC_URI[x86_64_v2_zig-rpm-macros.sha256sum] = "99d7992b3421238b1eb2ac018ebe8656c3800fa110845750d57a45b9e275067c"

RDEPENDS:zig = " \
 clang20-libs \
 glibc \
 libstdc++ \
 lld20-libs \
 llvm20-libs \
 zig-libs \
 "
RDEPENDS:zig-doc = " \
 zig \
 "
RDEPENDS:zig-libs = " \
 "
RDEPENDS:zig-rpm-macros = " \
 rpm \
 "
