# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-lock"
PV = "10.1.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-cargo-lock+default-devel \
 rust-cargo-lock+dependency-tree-devel \
 rust-cargo-lock+petgraph-devel \
 rust-cargo-lock-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-lock-10.1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "481d9afa6d621c293a7b167aeedc55130295f571f11b0ad884146221fbe1a985"

URI_x86_64_v2_rust-cargo-lock+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-lock+default-devel-10.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-lock+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-lock+default-devel}"
SRC_URI[x86_64_v2_rust-cargo-lock+default-devel.sha256sum] = "1f0cd171e70ded58195f02bce95672c802bb570f80b5bb01615ac8a39fc9cf46"

URI_x86_64_v2_rust-cargo-lock+dependency-tree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-lock+dependency-tree-devel-10.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-lock+dependency-tree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-lock+dependency-tree-devel}"
SRC_URI[x86_64_v2_rust-cargo-lock+dependency-tree-devel.sha256sum] = "1557ed74a69ab83672438f7b0f5959f8fa2185a9e11e04eae4f0dcd74afe12bc"

URI_x86_64_v2_rust-cargo-lock+petgraph-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-lock+petgraph-devel-10.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-lock+petgraph-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-lock+petgraph-devel}"
SRC_URI[x86_64_v2_rust-cargo-lock+petgraph-devel.sha256sum] = "eeb74dbdc993c8456f56aa0867829cdb40e20dc1b458e890b6727ac04abb8b4a"

URI_x86_64_v2_rust-cargo-lock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-lock-devel-10.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-lock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-lock-devel}"
SRC_URI[x86_64_v2_rust-cargo-lock-devel.sha256sum] = "570da0c0534b790b64353fe386e9404a11f52706ea16248dec6648736f8f3ac6"

URI_aarch64_rust-cargo-lock+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-lock+default-devel-10.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-cargo-lock+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-lock+default-devel}"
SRC_URI[aarch64_rust-cargo-lock+default-devel.sha256sum] = "51f4785f2226ee255547d9a11e262b16d7607b33cdc9d586bab0edfc6a383c20"

URI_aarch64_rust-cargo-lock+dependency-tree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-lock+dependency-tree-devel-10.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-cargo-lock+dependency-tree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-lock+dependency-tree-devel}"
SRC_URI[aarch64_rust-cargo-lock+dependency-tree-devel.sha256sum] = "4a6d8ea82cbce6c63a6b5fd6de43d66d33134166aba237227231af80d8fdbc30"

URI_aarch64_rust-cargo-lock+petgraph-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-lock+petgraph-devel-10.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-cargo-lock+petgraph-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-lock+petgraph-devel}"
SRC_URI[aarch64_rust-cargo-lock+petgraph-devel.sha256sum] = "13c77f8985768af99462031547bc4da376ff3c8d6775d8b433d4cc3617f57431"

URI_aarch64_rust-cargo-lock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-lock-devel-10.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-cargo-lock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-lock-devel}"
SRC_URI[aarch64_rust-cargo-lock-devel.sha256sum] = "04757ed3d2a55a12f2e19bdc13e7eb32676441cab49fc8e915d3e199e42e9f3a"

RDEPENDS:rust-cargo-lock+default-devel = " \
 cargo \
 rust-cargo-lock-devel \
 "
RDEPENDS:rust-cargo-lock+dependency-tree-devel = " \
 cargo \
 rust-cargo-lock+petgraph-devel \
 rust-cargo-lock-devel \
 "
RDEPENDS:rust-cargo-lock+petgraph-devel = " \
 cargo \
 rust-cargo-lock-devel \
 rust-petgraph0.6+default-devel \
 "
RDEPENDS:rust-cargo-lock-devel = " \
 cargo \
 rust \
 rust-semver+default-devel \
 rust-semver+serde-devel \
 rust-serde+default-devel \
 rust-serde+serde_derive-devel \
 rust-toml+default-devel \
 rust-url+default-devel \
 "
