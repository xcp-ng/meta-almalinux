# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-control-monad-free"
PV = "0.6.2"
PR = "27.el10_0"
PACKAGES = " \
 ghc-control-monad-free \
 ghc-control-monad-free-devel \
 ghc-control-monad-free-doc \
 ghc-control-monad-free-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-control-monad-free-0.6.2-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4bcc78103bf4464acb3e8d3e7fc40ce78c5b790fc6ce070de5c8330fa67008b2"

URI_x86_64_v2_ghc-control-monad-free = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-control-monad-free-0.6.2-27.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-control-monad-free;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-control-monad-free}"
SRC_URI[x86_64_v2_ghc-control-monad-free.sha256sum] = "921ed0a9fbd74ee46bdb95dba375d1de7ba1e361e9584cc343786f323febd6a0"

URI_x86_64_v2_ghc-control-monad-free-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-control-monad-free-devel-0.6.2-27.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-control-monad-free-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-control-monad-free-devel}"
SRC_URI[x86_64_v2_ghc-control-monad-free-devel.sha256sum] = "0459312dacf211c867fea083ae220c6ae3d13b6fb5aaa36bcb3a58f989574786"

URI_x86_64_v2_ghc-control-monad-free-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-control-monad-free-doc-0.6.2-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-control-monad-free-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-control-monad-free-doc}"
SRC_URI[x86_64_v2_ghc-control-monad-free-doc.sha256sum] = "2e1c0db6601a052197788ea9e61d526aa3f4f98e5a21c0acd8f816ea78978b70"

URI_x86_64_v2_ghc-control-monad-free-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-control-monad-free-prof-0.6.2-27.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-control-monad-free-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-control-monad-free-prof}"
SRC_URI[x86_64_v2_ghc-control-monad-free-prof.sha256sum] = "21a165074eb15b5731292d4b8e8936813b97d47c8233566e73239503c84a7c57"

URI_aarch64_ghc-control-monad-free = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-control-monad-free-0.6.2-27.el10_0.aarch64.rpm;name=aarch64_ghc-control-monad-free;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-control-monad-free}"
SRC_URI[aarch64_ghc-control-monad-free.sha256sum] = "97a90ceecc114b382c8f08d8dc0e23c9baf670b8249b772cce08f32893769a75"

URI_aarch64_ghc-control-monad-free-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-control-monad-free-devel-0.6.2-27.el10_0.aarch64.rpm;name=aarch64_ghc-control-monad-free-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-control-monad-free-devel}"
SRC_URI[aarch64_ghc-control-monad-free-devel.sha256sum] = "7a314e15545cb6a1569b7186e786f547eba5fa7d1754996987988ca3e629bc87"

URI_aarch64_ghc-control-monad-free-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-control-monad-free-doc-0.6.2-27.el10_0.noarch.rpm;name=aarch64_ghc-control-monad-free-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-control-monad-free-doc}"
SRC_URI[aarch64_ghc-control-monad-free-doc.sha256sum] = "ff957775d5f6e4847f279f9bfb644845ac1f042676a1c994d91864e0a6800e7c"

URI_aarch64_ghc-control-monad-free-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-control-monad-free-prof-0.6.2-27.el10_0.aarch64.rpm;name=aarch64_ghc-control-monad-free-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-control-monad-free-prof}"
SRC_URI[aarch64_ghc-control-monad-free-prof.sha256sum] = "18b024f96c5bcd9e993775e63c159d9213148d4a6e106fd7a6bd5396ed8d506c"

RDEPENDS:ghc-control-monad-free = " \
 ghc-base \
 ghc-ghc-bignum \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-control-monad-free-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-control-monad-free \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-control-monad-free-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-control-monad-free-prof = " \
 ghc-base-prof \
 ghc-control-monad-free-devel \
 ghc-transformers-prof \
 "
