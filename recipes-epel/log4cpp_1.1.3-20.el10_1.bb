# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "log4cpp"
PV = "1.1.3"
PR = "20.el10_1"
PACKAGES = " \
 log4cpp \
 log4cpp-devel \
 log4cpp-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/log4cpp-1.1.3-20.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed01c07aab1673b9197be7e050285c0ec3b88fb87a007b5e31d2c048a27a78f4"

URI_x86_64_v2_log4cpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/log4cpp-1.1.3-20.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_log4cpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_log4cpp}"
SRC_URI[x86_64_v2_log4cpp.sha256sum] = "811365666fcdaefdfcc6791d29c286a52e099e110a8982ad77620565317fe1d9"

URI_x86_64_v2_log4cpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/log4cpp-devel-1.1.3-20.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_log4cpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_log4cpp-devel}"
SRC_URI[x86_64_v2_log4cpp-devel.sha256sum] = "f2bd978fb99941192285b4c9bafe77b23ee61150a3d925ec9abe3801ec2fb2bf"

URI_x86_64_v2_log4cpp-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/log4cpp-doc-1.1.3-20.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_log4cpp-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_log4cpp-doc}"
SRC_URI[x86_64_v2_log4cpp-doc.sha256sum] = "928d3cb69d2991ac6b9f09292d9cbd1a3809f75d1875a5c8ddc9a07f572b9e3c"

URI_aarch64_log4cpp = "${EPEL_MIRROR}/aarch64/Packages/l/log4cpp-1.1.3-20.el10_1.aarch64.rpm;name=aarch64_log4cpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_log4cpp}"
SRC_URI[aarch64_log4cpp.sha256sum] = "bf3f17e1339fd1898c3f3562dd6e7f9005b7b817475f323a4bf24836a37a0e23"

URI_aarch64_log4cpp-devel = "${EPEL_MIRROR}/aarch64/Packages/l/log4cpp-devel-1.1.3-20.el10_1.aarch64.rpm;name=aarch64_log4cpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_log4cpp-devel}"
SRC_URI[aarch64_log4cpp-devel.sha256sum] = "3d9c1038f3ae28b3dd8ae9051294010673fa2e0186b70e87c34c3e4d307c7bf3"

URI_aarch64_log4cpp-doc = "${EPEL_MIRROR}/aarch64/Packages/l/log4cpp-doc-1.1.3-20.el10_1.aarch64.rpm;name=aarch64_log4cpp-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_log4cpp-doc}"
SRC_URI[aarch64_log4cpp-doc.sha256sum] = "2c617601db844b9c4055fe3848db1fa16946f48a05326d4da67bb008289dd029"

RDEPENDS:log4cpp = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:log4cpp-devel = " \
 bash \
 log4cpp \
 pkgconf-pkg-config \
 "
RDEPENDS:log4cpp-doc = " \
 log4cpp \
 "
