# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-oxygen-icons"
PV = "6.27.0"
PR = "2.el10_3"
PACKAGES = " \
 oxygen-icon-theme \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-oxygen-icons-6.27.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e333cea47a0394846e3fe3b4f19a2276601892d58d149b6a4783d123aa40d99f"

URI_x86_64_v2_oxygen-icon-theme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oxygen-icon-theme-6.27.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_oxygen-icon-theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oxygen-icon-theme}"
SRC_URI[x86_64_v2_oxygen-icon-theme.sha256sum] = "242f7776e03b71101f23ace4a8eedba773a3fbde7062959da314e7a0af41ee94"

URI_aarch64_oxygen-icon-theme = "${EPEL_MIRROR}/aarch64/Packages/o/oxygen-icon-theme-6.27.0-2.el10_3.noarch.rpm;name=aarch64_oxygen-icon-theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_oxygen-icon-theme}"
SRC_URI[aarch64_oxygen-icon-theme.sha256sum] = "09805bf447f4c0f89b72fa8ac1f93a570c9b0ac503f99a07adce751bdd94b301"

RDEPENDS:oxygen-icon-theme = " \
 almalinux-logos \
 bash \
 hicolor-icon-theme \
 "
