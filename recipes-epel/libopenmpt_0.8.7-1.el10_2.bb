# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libopenmpt"
PV = "0.8.7"
PR = "1.el10_2"
PACKAGES = " \
 libopenmpt \
 libopenmpt-devel \
 openmpt123 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libopenmpt-0.8.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b21d63dca011f024575af99dde19a451f0c2597bf08819aad93178a7a679db3"

URI_x86_64_v2_libopenmpt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libopenmpt-0.8.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libopenmpt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libopenmpt}"
SRC_URI[x86_64_v2_libopenmpt.sha256sum] = "6701698ff430192a70cd6e033cbd665ccc62376eaa979c269b1084d0aa12a884"

URI_x86_64_v2_libopenmpt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libopenmpt-devel-0.8.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libopenmpt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libopenmpt-devel}"
SRC_URI[x86_64_v2_libopenmpt-devel.sha256sum] = "ba80436343611911d164045c304190c3bf262b7c3f5b62e5a84c614e3218027b"

URI_x86_64_v2_openmpt123 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openmpt123-0.8.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openmpt123;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openmpt123}"
SRC_URI[x86_64_v2_openmpt123.sha256sum] = "20fa202fab961bf5f67218f03f15956d07ea53622aec1f2499f4045fbda71c3d"

URI_aarch64_libopenmpt = "${EPEL_MIRROR}/aarch64/Packages/l/libopenmpt-0.8.7-1.el10_2.aarch64.rpm;name=aarch64_libopenmpt;unpack=0"
SRC_URI:append = " ${URI_aarch64_libopenmpt}"
SRC_URI[aarch64_libopenmpt.sha256sum] = "d05d4f8b35a6ec049725f651f09a4b419b8c0ee05e1749dff2a1d508a6a1f540"

URI_aarch64_libopenmpt-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libopenmpt-devel-0.8.7-1.el10_2.aarch64.rpm;name=aarch64_libopenmpt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libopenmpt-devel}"
SRC_URI[aarch64_libopenmpt-devel.sha256sum] = "04dc984f04d932f1f8b8aea4c362c2dd961d8f74f22419b0b5c36868ccd00e60"

URI_aarch64_openmpt123 = "${EPEL_MIRROR}/aarch64/Packages/o/openmpt123-0.8.7-1.el10_2.aarch64.rpm;name=aarch64_openmpt123;unpack=0"
SRC_URI:append = " ${URI_aarch64_openmpt123}"
SRC_URI[aarch64_openmpt123.sha256sum] = "934c3049851f0b58eeaed24fcd6386b1b40a9b50f3f8e753a679a0d3232e173f"

RDEPENDS:libopenmpt = " \
 glibc \
 libgcc \
 libogg \
 libstdc++ \
 libvorbis \
 mpg123-libs \
 zlib-ng-compat \
 "
RDEPENDS:libopenmpt-devel = " \
 libogg-devel \
 libopenmpt \
 libvorbis-devel \
 mpg123-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:openmpt123 = " \
 flac-libs \
 glibc \
 libgcc \
 libopenmpt \
 libsndfile \
 libstdc++ \
 pulseaudio-libs \
 "
