# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "criu"
PV = "4.1"
PR = "1.el10"
PACKAGES = " \
 crit \
 criu \
 criu-devel \
 criu-libs \
 python3-criu \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/criu-4.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "261444f43880db310ac7f2beeed67fd10b804e139a9b166c167297b8f4ad7601"

URI_x86_64_v2_crit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/crit-4.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_crit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_crit}"
SRC_URI[x86_64_v2_crit.sha256sum] = "85a32196e97f06fb1f78d2379d4c05563b2042040d320cfcbf271d918539f787"

URI_x86_64_v2_criu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/criu-4.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_criu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_criu}"
SRC_URI[x86_64_v2_criu.sha256sum] = "b7dda9d518b0f7b4df2d6dfc7b841c5b0c7e65cf2f66ca6d9a351a33d887b15f"

URI_x86_64_v2_criu-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/criu-devel-4.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_criu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_criu-devel}"
SRC_URI[x86_64_v2_criu-devel.sha256sum] = "de6d84ab8ebcc9f50e66c77aba82b03360b78c91e8dda3d2e3b76ecf5470e090"

URI_x86_64_v2_criu-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/criu-libs-4.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_criu-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_criu-libs}"
SRC_URI[x86_64_v2_criu-libs.sha256sum] = "2ac3ef72f41edae0dd53dc2d48ed0354f1d4fe929cd9a7ff126f1352468b7e86"

URI_x86_64_v2_python3-criu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-criu-4.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-criu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-criu}"
SRC_URI[x86_64_v2_python3-criu.sha256sum] = "96f3e086f05079ee191d29e9d3ee13d321fe01f9d05a7569a7716fa313d75e96"

URI_aarch64_crit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/crit-4.1-1.el10.aarch64.rpm;name=aarch64_crit;unpack=0"
SRC_URI:append = " ${URI_aarch64_crit}"
SRC_URI[aarch64_crit.sha256sum] = "725b5e4740c0a3a702f6cf4d5f4a059d8aac682fb009a5c0b63560aaa832133e"

URI_aarch64_criu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/criu-4.1-1.el10.aarch64.rpm;name=aarch64_criu;unpack=0"
SRC_URI:append = " ${URI_aarch64_criu}"
SRC_URI[aarch64_criu.sha256sum] = "cd611bfe259090cf86834ce05c9e55fda8c34afee6a9298cf26ffb6f6127cca8"

URI_aarch64_criu-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/criu-devel-4.1-1.el10.aarch64.rpm;name=aarch64_criu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_criu-devel}"
SRC_URI[aarch64_criu-devel.sha256sum] = "cab02a308918d97518c488aaee1fb1dfe7aa00ad0a73203618907a8d15894bdb"

URI_aarch64_criu-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/criu-libs-4.1-1.el10.aarch64.rpm;name=aarch64_criu-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_criu-libs}"
SRC_URI[aarch64_criu-libs.sha256sum] = "e8d526cc8485471b072e0bbb07eb8baebc24cadd4955703136be3bda9704de66"

URI_aarch64_python3-criu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-criu-4.1-1.el10.aarch64.rpm;name=aarch64_python3-criu;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-criu}"
SRC_URI[aarch64_python3-criu.sha256sum] = "10af784bd5764c61dc5751a2b1b6c279f34b5d5c0e234d8fe082bfe83f607706"

RDEPENDS:crit = " \
 python3 \
 python3-criu \
 "
RDEPENDS:criu = " \
 bash \
 glibc \
 gnutls \
 libgcc \
 libnet \
 libnl3 \
 libselinux \
 libuuid \
 nftables \
 protobuf-c \
 "
RDEPENDS:criu-devel = " \
 criu \
 criu-libs \
 pkgconf-pkg-config \
 protobuf-c-devel \
 "
RDEPENDS:criu-libs = " \
 criu \
 glibc \
 protobuf-c \
 "
RDEPENDS:python3-criu = " \
 python3 \
 python3-protobuf \
 "
