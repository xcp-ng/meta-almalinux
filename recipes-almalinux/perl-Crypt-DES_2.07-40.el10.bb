# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-DES"
PV = "2.07"
PR = "40.el10"
PACKAGES = " \
 perl-Crypt-DES \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Crypt-DES-2.07-40.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ddefa9a78ef2eeb0b86c725c4c694d4c77c67efdd224ef1f11312ca4d4a209e1"

URI_x86_64_v2_perl-Crypt-DES = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Crypt-DES-2.07-40.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Crypt-DES;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-DES}"
SRC_URI[x86_64_v2_perl-Crypt-DES.sha256sum] = "d307413845f77c32f5ad58e66969d0915c4db557089087da431bb9ff1c451b10"

URI_aarch64_perl-Crypt-DES = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Crypt-DES-2.07-40.el10.aarch64.rpm;name=aarch64_perl-Crypt-DES;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-DES}"
SRC_URI[aarch64_perl-Crypt-DES.sha256sum] = "5d0ef5fe02e92cfd5574fa1a0586e7a7ba37c223dfa64bbf993538f8f31e4195"

RDEPENDS:perl-Crypt-DES = " \
 glibc \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
