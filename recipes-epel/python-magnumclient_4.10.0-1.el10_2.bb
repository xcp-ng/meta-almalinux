# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-magnumclient"
PV = "4.10.0"
PR = "1.el10_2"
PACKAGES = " \
 python-magnumclient-doc \
 python3-magnumclient \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-magnumclient-4.10.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c987a2dddc4f609fe3bf07359a53989ba38c72ce7a875433924277c21d2deab9"

URI_x86_64_v2_python-magnumclient-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-magnumclient-doc-4.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-magnumclient-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-magnumclient-doc}"
SRC_URI[x86_64_v2_python-magnumclient-doc.sha256sum] = "e5bbaaf463bcd3cad90bf7e8e25d6a346688675a3bbfd57aec1c0fe0e233156e"

URI_x86_64_v2_python3-magnumclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-magnumclient-4.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-magnumclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-magnumclient}"
SRC_URI[x86_64_v2_python3-magnumclient.sha256sum] = "40c937d8c10972ecfaf771c670424011e8d68f2530f8803a0227ba9d590d6949"

URI_aarch64_python-magnumclient-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-magnumclient-doc-4.10.0-1.el10_2.noarch.rpm;name=aarch64_python-magnumclient-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-magnumclient-doc}"
SRC_URI[aarch64_python-magnumclient-doc.sha256sum] = "0bd92f0cc8f2f77bd22bb526a9fbe266b1f0592dd7f0f0cf71a5c5869ba718e0"

URI_aarch64_python3-magnumclient = "${EPEL_MIRROR}/aarch64/Packages/p/python3-magnumclient-4.10.0-1.el10_2.noarch.rpm;name=aarch64_python3-magnumclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-magnumclient}"
SRC_URI[aarch64_python3-magnumclient.sha256sum] = "407c6bea358ff9f5ba43053bd461078a37e0f0ce5b2c964cbab17f8c595c4bc1"

RDEPENDS:python-magnumclient-doc = " \
 "
RDEPENDS:python3-magnumclient = " \
 python3 \
 python3-cryptography \
 python3-decorator \
 python3-keystoneauth1 \
 python3-openstacksdk \
 python3-osc-lib \
 python3-oslo-i18n \
 python3-oslo-log \
 python3-oslo-serialization \
 python3-oslo-utils \
 python3-pbr \
 python3-prettytable \
 python3-requests \
 python3-stevedore \
 "
