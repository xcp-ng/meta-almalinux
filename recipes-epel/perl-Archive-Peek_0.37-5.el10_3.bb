# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Archive-Peek"
PV = "0.37"
PR = "5.el10_3"
PACKAGES = " \
 perl-Archive-Peek \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Archive-Peek-0.37-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e5bc7e20507849b271b1117d20ec3c0b93a443774c784093cb48cb3b8286eca7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Archive-Peek-0.37-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Archive-Peek;unpack=0"
SRC_URI[x86_64_v2_perl-Archive-Peek.sha256sum] = "9932623f4fcbaecd2049203e3aff9e1ed432b45045f4ffc3da69d42aa557d30b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Archive-Peek-0.37-5.el10_3.noarch.rpm;name=aarch64_perl-Archive-Peek;unpack=0"
SRC_URI[aarch64_perl-Archive-Peek.sha256sum] = "19eb41a55896a212f1418580f3980c45872536516d2d5d904ffca0539816fb0d"

RDEPENDS:perl-Archive-Peek = " \
 perl-Archive-Tar \
 perl-Archive-Zip \
 perl-Carp \
 perl-IO-Compress \
 perl-Moo \
 perl-Types-Path-Tiny \
 perl-libs \
 "
