# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bear"
PV = "4.1.4"
PR = "1.el10_3"
PACKAGES = " \
 bear \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/b/bear-4.1.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8d2663aa9757664f6979df3b87deae2054b929edf5e7b1145071ef740137439b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bear-4.1.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bear;unpack=0"
SRC_URI[x86_64_v2_bear.sha256sum] = "5521d325ba6c950551633548060e1971d5b1466904a3c79473c70626685d5af3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bear-4.1.4-1.el10_3.aarch64.rpm;name=aarch64_bear;unpack=0"
SRC_URI[aarch64_bear.sha256sum] = "383d60f76186b725f377a4cb3f88c149473bea7ba421a79432f811fb646b7a08"

RDEPENDS:bear = " \
 bash \
 glibc \
 libgcc \
 "
