# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libbz2-rs-sys"
PV = "0.2.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-libbz2-rs-sys+c-allocator-devel \
 rust-libbz2-rs-sys+custom-prefix-devel \
 rust-libbz2-rs-sys+default-devel \
 rust-libbz2-rs-sys+export-symbols-devel \
 rust-libbz2-rs-sys+rust-allocator-devel \
 rust-libbz2-rs-sys+semver-prefix-devel \
 rust-libbz2-rs-sys+std-devel \
 rust-libbz2-rs-sys+stdio-devel \
 rust-libbz2-rs-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libbz2-rs-sys-0.2.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "76071671e119412288f3327856460ebe9ddbc25218b2c49fc796da002d0c314d"

URI_x86_64_v2_rust-libbz2-rs-sys+c-allocator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbz2-rs-sys+c-allocator-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbz2-rs-sys+c-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbz2-rs-sys+c-allocator-devel}"
SRC_URI[x86_64_v2_rust-libbz2-rs-sys+c-allocator-devel.sha256sum] = "f43a1176709adb85ec6482f2cd38cfca2acfe93ca86c46a530d3288d779b08f7"

URI_x86_64_v2_rust-libbz2-rs-sys+custom-prefix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbz2-rs-sys+custom-prefix-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbz2-rs-sys+custom-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbz2-rs-sys+custom-prefix-devel}"
SRC_URI[x86_64_v2_rust-libbz2-rs-sys+custom-prefix-devel.sha256sum] = "3956b0a7c2e8ede4b3d7ad6adab5b1f8ddc36bf9dca58316113a13143480bb69"

URI_x86_64_v2_rust-libbz2-rs-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbz2-rs-sys+default-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbz2-rs-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbz2-rs-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libbz2-rs-sys+default-devel.sha256sum] = "4bbdeab87d534ce5bd8df99660c4e7018554c9fd85757767b544e016397338ce"

URI_x86_64_v2_rust-libbz2-rs-sys+export-symbols-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbz2-rs-sys+export-symbols-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbz2-rs-sys+export-symbols-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbz2-rs-sys+export-symbols-devel}"
SRC_URI[x86_64_v2_rust-libbz2-rs-sys+export-symbols-devel.sha256sum] = "2fd924cdc063bb0d2e21854439e7e16972fce7eefdd16fe567143e61e96d8a5d"

URI_x86_64_v2_rust-libbz2-rs-sys+rust-allocator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbz2-rs-sys+rust-allocator-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbz2-rs-sys+rust-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbz2-rs-sys+rust-allocator-devel}"
SRC_URI[x86_64_v2_rust-libbz2-rs-sys+rust-allocator-devel.sha256sum] = "0ad1c869299f90f0e0c83400ea08c3642d33ae678ed3c5493cc80d51dfb67aba"

URI_x86_64_v2_rust-libbz2-rs-sys+semver-prefix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbz2-rs-sys+semver-prefix-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbz2-rs-sys+semver-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbz2-rs-sys+semver-prefix-devel}"
SRC_URI[x86_64_v2_rust-libbz2-rs-sys+semver-prefix-devel.sha256sum] = "8940a4358f6cfa272911fd01e293b002eb42397f5f917e22bf7253045b0fb609"

URI_x86_64_v2_rust-libbz2-rs-sys+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbz2-rs-sys+std-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbz2-rs-sys+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbz2-rs-sys+std-devel}"
SRC_URI[x86_64_v2_rust-libbz2-rs-sys+std-devel.sha256sum] = "6b069979d113b450a2c0eeca020c9c951fc1d75af3091dc67db75bf8a303ae6f"

URI_x86_64_v2_rust-libbz2-rs-sys+stdio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbz2-rs-sys+stdio-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbz2-rs-sys+stdio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbz2-rs-sys+stdio-devel}"
SRC_URI[x86_64_v2_rust-libbz2-rs-sys+stdio-devel.sha256sum] = "fb8f06e2f8af875941797753301153d1a06230040fe2d6b1bae578b6747114e7"

URI_x86_64_v2_rust-libbz2-rs-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbz2-rs-sys-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbz2-rs-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbz2-rs-sys-devel}"
SRC_URI[x86_64_v2_rust-libbz2-rs-sys-devel.sha256sum] = "0d3f1f681ac08ea5ab4da7008e6999c4395f31dd4e19309d75a27ebc24f62630"

URI_aarch64_rust-libbz2-rs-sys+c-allocator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbz2-rs-sys+c-allocator-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-libbz2-rs-sys+c-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbz2-rs-sys+c-allocator-devel}"
SRC_URI[aarch64_rust-libbz2-rs-sys+c-allocator-devel.sha256sum] = "5b6798437c4a90d5604eaa81a099104735ea0e409698851f8d88f3c8ad078a24"

URI_aarch64_rust-libbz2-rs-sys+custom-prefix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbz2-rs-sys+custom-prefix-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-libbz2-rs-sys+custom-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbz2-rs-sys+custom-prefix-devel}"
SRC_URI[aarch64_rust-libbz2-rs-sys+custom-prefix-devel.sha256sum] = "aeafcafd304a88ea2476cf82afd7c1b5823514ad33cfb935123c448f02121dc1"

URI_aarch64_rust-libbz2-rs-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbz2-rs-sys+default-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-libbz2-rs-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbz2-rs-sys+default-devel}"
SRC_URI[aarch64_rust-libbz2-rs-sys+default-devel.sha256sum] = "7af50e22f8d8f13cd5bc4c7a3f69d2340d4c9fa33c04455890b043edda0ffed5"

URI_aarch64_rust-libbz2-rs-sys+export-symbols-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbz2-rs-sys+export-symbols-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-libbz2-rs-sys+export-symbols-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbz2-rs-sys+export-symbols-devel}"
SRC_URI[aarch64_rust-libbz2-rs-sys+export-symbols-devel.sha256sum] = "da445adae83757657c657615fe3ee6f4d886b23432646fa8ee7d376438a53469"

URI_aarch64_rust-libbz2-rs-sys+rust-allocator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbz2-rs-sys+rust-allocator-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-libbz2-rs-sys+rust-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbz2-rs-sys+rust-allocator-devel}"
SRC_URI[aarch64_rust-libbz2-rs-sys+rust-allocator-devel.sha256sum] = "d34c674f575ff0e09a69636b883ce309e378e0f29781cacf5733b26f905b0d82"

URI_aarch64_rust-libbz2-rs-sys+semver-prefix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbz2-rs-sys+semver-prefix-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-libbz2-rs-sys+semver-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbz2-rs-sys+semver-prefix-devel}"
SRC_URI[aarch64_rust-libbz2-rs-sys+semver-prefix-devel.sha256sum] = "6a08d8449be52714229cdd45bdaa7953263dca307a1801ff50a0f1e739d4bd3d"

URI_aarch64_rust-libbz2-rs-sys+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbz2-rs-sys+std-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-libbz2-rs-sys+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbz2-rs-sys+std-devel}"
SRC_URI[aarch64_rust-libbz2-rs-sys+std-devel.sha256sum] = "b69ef5aa119124036c523b1f91da591be54542638af9156380387b6d7db940cb"

URI_aarch64_rust-libbz2-rs-sys+stdio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbz2-rs-sys+stdio-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-libbz2-rs-sys+stdio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbz2-rs-sys+stdio-devel}"
SRC_URI[aarch64_rust-libbz2-rs-sys+stdio-devel.sha256sum] = "20ff2f931608119b7aff5c7113bdb284adc1f37521ba1d755b6457ff5f35960d"

URI_aarch64_rust-libbz2-rs-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbz2-rs-sys-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-libbz2-rs-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbz2-rs-sys-devel}"
SRC_URI[aarch64_rust-libbz2-rs-sys-devel.sha256sum] = "e380357d6ad66b940ce0bbbed2e2510f9dcff63d8c0d003ba2704bcac10bf1e4"

RDEPENDS:rust-libbz2-rs-sys+c-allocator-devel = " \
 cargo \
 rust-libbz2-rs-sys-devel \
 rust-libc+default-devel \
 "
RDEPENDS:rust-libbz2-rs-sys+custom-prefix-devel = " \
 cargo \
 rust-libbz2-rs-sys+export-symbols-devel \
 rust-libbz2-rs-sys-devel \
 "
RDEPENDS:rust-libbz2-rs-sys+default-devel = " \
 cargo \
 rust-libbz2-rs-sys+std-devel \
 rust-libbz2-rs-sys+stdio-devel \
 rust-libbz2-rs-sys-devel \
 "
RDEPENDS:rust-libbz2-rs-sys+export-symbols-devel = " \
 cargo \
 rust-libbz2-rs-sys-devel \
 "
RDEPENDS:rust-libbz2-rs-sys+rust-allocator-devel = " \
 cargo \
 rust-libbz2-rs-sys-devel \
 "
RDEPENDS:rust-libbz2-rs-sys+semver-prefix-devel = " \
 cargo \
 rust-libbz2-rs-sys+export-symbols-devel \
 rust-libbz2-rs-sys-devel \
 "
RDEPENDS:rust-libbz2-rs-sys+std-devel = " \
 cargo \
 rust-libbz2-rs-sys+rust-allocator-devel \
 rust-libbz2-rs-sys-devel \
 "
RDEPENDS:rust-libbz2-rs-sys+stdio-devel = " \
 cargo \
 rust-libbz2-rs-sys-devel \
 rust-libc+default-devel \
 "
RDEPENDS:rust-libbz2-rs-sys-devel = " \
 cargo \
 rust \
 "
