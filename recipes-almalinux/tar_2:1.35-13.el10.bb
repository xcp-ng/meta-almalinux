# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tar"
PE = "2"
PV = "1.35"
PR = "13.el10"
PACKAGES = " \
 tar \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/tar-1.35-13.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4ded7408504aa7b8f46e9d6c3090f205b266581d893fa9c4099663deb4d014a8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tar-1.35-13.el10.x86_64_v2.rpm;name=x86_64_v2_tar;unpack=0"
SRC_URI[x86_64_v2_tar.sha256sum] = "00d0019d07be0c3498922b76e5fa21f57ecf4fb6038e947aaccdc710ccf3609b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tar-1.35-13.el10.aarch64.rpm;name=aarch64_tar;unpack=0"
SRC_URI[aarch64_tar.sha256sum] = "c11504647e0b145354afb03ee5c5a815d5ecb7acbb3adeeb96b9a28f2f88fc20"

RDEPENDS:tar = " \
 glibc \
 libacl \
 libselinux \
 "
