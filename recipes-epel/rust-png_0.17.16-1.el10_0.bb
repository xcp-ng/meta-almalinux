# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-png"
PV = "0.17.16"
PR = "1.el10_0"
PACKAGES = " \
 rust-png+benchmarks-devel \
 rust-png+default-devel \
 rust-png+unstable-devel \
 rust-png-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-png-0.17.16-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8cb324fe835cdc19a417247b825c4ecf6e63ab69077ebd30ed3f9d9985ceba8"

URI_x86_64_v2_rust-png+benchmarks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-png+benchmarks-devel-0.17.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-png+benchmarks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-png+benchmarks-devel}"
SRC_URI[x86_64_v2_rust-png+benchmarks-devel.sha256sum] = "766f47a7e26505067587c424ac85107f125e59a7a0e16339add526d339447409"

URI_x86_64_v2_rust-png+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-png+default-devel-0.17.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-png+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-png+default-devel}"
SRC_URI[x86_64_v2_rust-png+default-devel.sha256sum] = "2543b6726729982d6ed9d308abab06ea5a426cecc750c5874ab80b8b845f1a73"

URI_x86_64_v2_rust-png+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-png+unstable-devel-0.17.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-png+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-png+unstable-devel}"
SRC_URI[x86_64_v2_rust-png+unstable-devel.sha256sum] = "ed58fac2de1f87eaff192e23ab1f3b26ab8f367850b6d6aee15ffa22b2ca67a4"

URI_x86_64_v2_rust-png-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-png-devel-0.17.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-png-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-png-devel}"
SRC_URI[x86_64_v2_rust-png-devel.sha256sum] = "5900850ad4156f0b9d886769dffd57d0f829da1e542944d2cb813db8cb7c2890"

URI_aarch64_rust-png+benchmarks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-png+benchmarks-devel-0.17.16-1.el10_0.noarch.rpm;name=aarch64_rust-png+benchmarks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-png+benchmarks-devel}"
SRC_URI[aarch64_rust-png+benchmarks-devel.sha256sum] = "55935eb0f2f68795ec01dc6e01b6cd36ae869a87ee7a0cff78a5240bcc5beb7d"

URI_aarch64_rust-png+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-png+default-devel-0.17.16-1.el10_0.noarch.rpm;name=aarch64_rust-png+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-png+default-devel}"
SRC_URI[aarch64_rust-png+default-devel.sha256sum] = "edd095818d25c1e1e9f15e4074ce5a3e001c3dcb535936157a0bd5ce180cfa76"

URI_aarch64_rust-png+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-png+unstable-devel-0.17.16-1.el10_0.noarch.rpm;name=aarch64_rust-png+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-png+unstable-devel}"
SRC_URI[aarch64_rust-png+unstable-devel.sha256sum] = "d661a8fb6cb19a0def71027f9392af4aaff4ac59aeee76c1637756c76b3d169d"

URI_aarch64_rust-png-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-png-devel-0.17.16-1.el10_0.noarch.rpm;name=aarch64_rust-png-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-png-devel}"
SRC_URI[aarch64_rust-png-devel.sha256sum] = "0bafd3846dda9d4b33030ffcc8df72b8fdfac89b8a9b236fc32f0c3ad808a462"

RDEPENDS:rust-png+benchmarks-devel = " \
 cargo \
 rust-png-devel \
 "
RDEPENDS:rust-png+default-devel = " \
 cargo \
 rust-png-devel \
 "
RDEPENDS:rust-png+unstable-devel = " \
 cargo \
 rust-crc32fast+nightly-devel \
 rust-png-devel \
 "
RDEPENDS:rust-png-devel = " \
 cargo \
 rust \
 rust-bitflags1+default-devel \
 rust-crc32fast+default-devel \
 rust-fdeflate+default-devel \
 rust-flate2+default-devel \
 rust-miniz_oxide+default-devel \
 rust-miniz_oxide+simd-devel \
 "
