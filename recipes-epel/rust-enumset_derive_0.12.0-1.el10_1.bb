# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-enumset_derive"
PV = "0.12.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-enumset_derive+default-devel \
 rust-enumset_derive+proc-macro-crate-devel \
 rust-enumset_derive+serde2_deprecation_warning-devel \
 rust-enumset_derive+std_deprecation_warning-devel \
 rust-enumset_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-enumset_derive-0.12.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e71163f155b54d3494cac873244bb46a9257f2384316e68b4d48bf6f1e43e14d"

URI_x86_64_v2_rust-enumset_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enumset_derive+default-devel-0.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enumset_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enumset_derive+default-devel}"
SRC_URI[x86_64_v2_rust-enumset_derive+default-devel.sha256sum] = "b905cd44e91169bc64d91eab8a609b1ccca58b6438cbf500e7dcd77623c1b00b"

URI_x86_64_v2_rust-enumset_derive+proc-macro-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enumset_derive+proc-macro-crate-devel-0.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enumset_derive+proc-macro-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enumset_derive+proc-macro-crate-devel}"
SRC_URI[x86_64_v2_rust-enumset_derive+proc-macro-crate-devel.sha256sum] = "1f7bfbc188938445ad6533a954af8c5d8cc76ba2e6be7cc0085e9269ec1ca714"

URI_x86_64_v2_rust-enumset_derive+serde2_deprecation_warning-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enumset_derive+serde2_deprecation_warning-devel-0.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enumset_derive+serde2_deprecation_warning-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enumset_derive+serde2_deprecation_warning-devel}"
SRC_URI[x86_64_v2_rust-enumset_derive+serde2_deprecation_warning-devel.sha256sum] = "ee02add635fce40a69cf383e6c25e0fcac5593e4d65f87ff3720e366fe747222"

URI_x86_64_v2_rust-enumset_derive+std_deprecation_warning-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enumset_derive+std_deprecation_warning-devel-0.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enumset_derive+std_deprecation_warning-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enumset_derive+std_deprecation_warning-devel}"
SRC_URI[x86_64_v2_rust-enumset_derive+std_deprecation_warning-devel.sha256sum] = "e99222a186fbef6de5297e35a7ac62942f4f4d50775e2032384a244c5dfab979"

URI_x86_64_v2_rust-enumset_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enumset_derive-devel-0.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enumset_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enumset_derive-devel}"
SRC_URI[x86_64_v2_rust-enumset_derive-devel.sha256sum] = "89416b95321b73176bf687129316a8d72abda860034eb0d21f3556898a52375d"

URI_aarch64_rust-enumset_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enumset_derive+default-devel-0.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-enumset_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enumset_derive+default-devel}"
SRC_URI[aarch64_rust-enumset_derive+default-devel.sha256sum] = "5f268f7083f4ae37a0f0296c73e020354a75ec376a91c0ebde1a177aaca9602e"

URI_aarch64_rust-enumset_derive+proc-macro-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enumset_derive+proc-macro-crate-devel-0.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-enumset_derive+proc-macro-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enumset_derive+proc-macro-crate-devel}"
SRC_URI[aarch64_rust-enumset_derive+proc-macro-crate-devel.sha256sum] = "d9b6ee7fb7bae2443bd84708336af7fca497096ebd882220f470cf5423f75728"

URI_aarch64_rust-enumset_derive+serde2_deprecation_warning-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enumset_derive+serde2_deprecation_warning-devel-0.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-enumset_derive+serde2_deprecation_warning-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enumset_derive+serde2_deprecation_warning-devel}"
SRC_URI[aarch64_rust-enumset_derive+serde2_deprecation_warning-devel.sha256sum] = "59a9b7886065660c4a8239b05278fbe00a6b58c348dddbec256777007c6bdba6"

URI_aarch64_rust-enumset_derive+std_deprecation_warning-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enumset_derive+std_deprecation_warning-devel-0.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-enumset_derive+std_deprecation_warning-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enumset_derive+std_deprecation_warning-devel}"
SRC_URI[aarch64_rust-enumset_derive+std_deprecation_warning-devel.sha256sum] = "5106dbdbb08f93fafdca5a3fccea2af6dde5a6c2b7ecdc002aa68dcd07397c98"

URI_aarch64_rust-enumset_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enumset_derive-devel-0.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-enumset_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enumset_derive-devel}"
SRC_URI[aarch64_rust-enumset_derive-devel.sha256sum] = "2a0148a847ce79f5c337bb533a7f42e8bc666b3f8b9c96160d70191ba5773abb"

RDEPENDS:rust-enumset_derive+default-devel = " \
 cargo \
 rust-enumset_derive-devel \
 "
RDEPENDS:rust-enumset_derive+proc-macro-crate-devel = " \
 cargo \
 rust-enumset_derive-devel \
 rust-proc-macro-crate+default-devel \
 "
RDEPENDS:rust-enumset_derive+serde2_deprecation_warning-devel = " \
 cargo \
 rust-enumset_derive-devel \
 "
RDEPENDS:rust-enumset_derive+std_deprecation_warning-devel = " \
 cargo \
 rust-enumset_derive-devel \
 "
RDEPENDS:rust-enumset_derive-devel = " \
 cargo \
 rust-darling-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
