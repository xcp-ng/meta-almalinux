# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocprim"
PV = "7.1.1"
PR = "2.el10_2"
PACKAGES:x86_64_v2 = " \
 rocprim-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocprim-7.1.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b1d40303e36609ffa5165b0c92dab61e8a98cbdcef946be49c76ece9b5242d79"

URI_x86_64_v2_rocprim-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocprim-devel-7.1.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rocprim-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocprim-devel}"
SRC_URI[x86_64_v2_rocprim-devel.sha256sum] = "93ac1c922d60b4c0c7988cebbff0e0e0e26d8542509b622c656f027db4b74817"

RDEPENDS:rocprim-devel = " \
 cmake-filesystem \
 "
