# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-dotgen"
PV = "0.4.3"
PR = "16.el10_0"
PACKAGES = " \
 ghc-dotgen \
 ghc-dotgen-devel \
 ghc-dotgen-doc \
 ghc-dotgen-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-dotgen-0.4.3-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6022718cbcfe10c6156f6984a9cad0750b37fb8670f4885a14c4334f203c3afc"

URI_x86_64_v2_ghc-dotgen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-dotgen-0.4.3-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-dotgen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-dotgen}"
SRC_URI[x86_64_v2_ghc-dotgen.sha256sum] = "2aca4c84a7aaceb071e8d4f8a9bbfcf97d16faa69dc551c489298b4e736c9724"

URI_x86_64_v2_ghc-dotgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-dotgen-devel-0.4.3-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-dotgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-dotgen-devel}"
SRC_URI[x86_64_v2_ghc-dotgen-devel.sha256sum] = "fdd314575a7b1cb5b212b19af43b59715688fdb979f614ff371b0c73a33c726b"

URI_x86_64_v2_ghc-dotgen-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-dotgen-doc-0.4.3-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-dotgen-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-dotgen-doc}"
SRC_URI[x86_64_v2_ghc-dotgen-doc.sha256sum] = "bef1a23ff408e7178df84bc850b45cafc485445778c139fe20a10ae7690f65b3"

URI_x86_64_v2_ghc-dotgen-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-dotgen-prof-0.4.3-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-dotgen-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-dotgen-prof}"
SRC_URI[x86_64_v2_ghc-dotgen-prof.sha256sum] = "fd057a36294f04167f1101b3587cb985e557cf19682b5fa061ba733ac85768a1"

URI_aarch64_ghc-dotgen = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-dotgen-0.4.3-16.el10_0.aarch64.rpm;name=aarch64_ghc-dotgen;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-dotgen}"
SRC_URI[aarch64_ghc-dotgen.sha256sum] = "9a49ac270fe597e5816506638a7d9e4d6bda41e021f5931a1c63b2b507d73245"

URI_aarch64_ghc-dotgen-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-dotgen-devel-0.4.3-16.el10_0.aarch64.rpm;name=aarch64_ghc-dotgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-dotgen-devel}"
SRC_URI[aarch64_ghc-dotgen-devel.sha256sum] = "7406856374840547d729c9584d3fd992b3bbe0f6f854234f56e9b5968368a915"

URI_aarch64_ghc-dotgen-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-dotgen-doc-0.4.3-16.el10_0.noarch.rpm;name=aarch64_ghc-dotgen-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-dotgen-doc}"
SRC_URI[aarch64_ghc-dotgen-doc.sha256sum] = "82f235ad0f03d2b357d121ac5cd0eff584ae694453b8426ad5d58005bbc646b4"

URI_aarch64_ghc-dotgen-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-dotgen-prof-0.4.3-16.el10_0.aarch64.rpm;name=aarch64_ghc-dotgen-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-dotgen-prof}"
SRC_URI[aarch64_ghc-dotgen-prof.sha256sum] = "b148b996d8e5d1ecb1991c294a1dbd1e3755cb9f481541d0be71625e829166b0"

RDEPENDS:ghc-dotgen = " \
 ghc-array \
 ghc-base \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-dotgen-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-dotgen \
 "
RDEPENDS:ghc-dotgen-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-dotgen-prof = " \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-dotgen-devel \
 "
