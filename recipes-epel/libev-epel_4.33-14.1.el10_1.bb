# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libev-epel"
PV = "4.33"
PR = "14.1.el10_1"
PACKAGES = " \
 libev-libevent-devel \
 libev-source \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libev-epel-4.33-14.1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e72e774b50cfcb4da1940bf16249ca4f110754bf1f0a44a5add554f7595d5ff"

URI_x86_64_v2_libev-libevent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libev-libevent-devel-4.33-14.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libev-libevent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libev-libevent-devel}"
SRC_URI[x86_64_v2_libev-libevent-devel.sha256sum] = "698d5680af0190f936bc358aad682c6bc54a3369064eb9f195b950f4fda450d7"

URI_x86_64_v2_libev-source = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libev-source-4.33-14.1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_libev-source;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libev-source}"
SRC_URI[x86_64_v2_libev-source.sha256sum] = "3b4b47959fd687bc634f5af8578f889d9ac6cf2f6ecac3d517489027bcae2a18"

URI_aarch64_libev-libevent-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libev-libevent-devel-4.33-14.1.el10_1.aarch64.rpm;name=aarch64_libev-libevent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libev-libevent-devel}"
SRC_URI[aarch64_libev-libevent-devel.sha256sum] = "51806dfe55902e5d4a7ac1de1cd554bdc94e47a61c81104bad9ec9fd8513838c"

URI_aarch64_libev-source = "${EPEL_MIRROR}/aarch64/Packages/l/libev-source-4.33-14.1.el10_1.noarch.rpm;name=aarch64_libev-source;unpack=0"
SRC_URI:append = " ${URI_aarch64_libev-source}"
SRC_URI[aarch64_libev-source.sha256sum] = "c7e57106c9cbe1fc0a51116e41b9acc9a790c3cf9f2598193223883471a917e5"

RDEPENDS:libev-libevent-devel = " \
 libev-devel \
 "
RDEPENDS:libev-source = " \
 "
