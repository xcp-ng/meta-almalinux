# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-Pcap"
PV = "0.21"
PR = "8.el10_1"
PACKAGES = " \
 perl-Net-Pcap \
 perl-Net-Pcap-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-Pcap-0.21-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d6e84765502e46161d07a2781debff2196dbc6ddac2750788c07509397dfae7e"

URI_x86_64_v2_perl-Net-Pcap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-Pcap-0.21-8.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Net-Pcap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-Pcap}"
SRC_URI[x86_64_v2_perl-Net-Pcap.sha256sum] = "76ee31bf5c1bce45bf9f34514f0ec18a13ed3f13326ddd4c8c9f8527c8eed0e9"

URI_x86_64_v2_perl-Net-Pcap-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-Pcap-tests-0.21-8.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Net-Pcap-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-Pcap-tests}"
SRC_URI[x86_64_v2_perl-Net-Pcap-tests.sha256sum] = "43cbd4d3d9bc289a36c9694df72758c6974cd5498e7c7d90fab51548cb69dd1f"

URI_aarch64_perl-Net-Pcap = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-Pcap-0.21-8.el10_1.aarch64.rpm;name=aarch64_perl-Net-Pcap;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-Pcap}"
SRC_URI[aarch64_perl-Net-Pcap.sha256sum] = "05c45cdfad10ee0a8da967e34a9a68ea083fc403e2e764bdb73ccdc0c44b6011"

URI_aarch64_perl-Net-Pcap-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-Pcap-tests-0.21-8.el10_1.aarch64.rpm;name=aarch64_perl-Net-Pcap-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-Pcap-tests}"
SRC_URI[aarch64_perl-Net-Pcap-tests.sha256sum] = "293ac35beb80f11056c224c9cd6ef0ba92c35345f17e8e3e2c5104c924a6fedd"

RDEPENDS:perl-Net-Pcap = " \
 glibc \
 libpcap \
 perl-Carp \
 perl-Exporter \
 perl-Net-Pcap \
 perl-Sys-Hostname \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:perl-Net-Pcap-tests = " \
 bash \
 perl-English \
 perl-ExtUtils-MakeMaker \
 perl-Net-Pcap \
 perl-PathTools \
 perl-Socket \
 perl-Test-Exception \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-lib \
 perl-libs \
 "
