# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hipblaslt"
PV = "7.1.1"
PR = "6.el10_2"
PACKAGES:x86_64_v2 = " \
 hipblaslt \
 hipblaslt-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/h/hipblaslt-7.1.1-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b1f66022ab0e6c048c91d81bbd54e61ff30d65714bd59c74c4100545a3e8b982"

URI_x86_64_v2_hipblaslt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipblaslt-7.1.1-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipblaslt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipblaslt}"
SRC_URI[x86_64_v2_hipblaslt.sha256sum] = "cb6696e73fcb421bbcb137867ce9f1e8c9e887e8baa3c070b42529faff0a4164"

URI_x86_64_v2_hipblaslt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipblaslt-devel-7.1.1-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipblaslt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipblaslt-devel}"
SRC_URI[x86_64_v2_hipblaslt-devel.sha256sum] = "aff21d8450ce2ba95b141dca55e3d3dc04436173881bbbbc7d5030828d89fa7a"

RDEPENDS:hipblaslt = " \
 glibc \
 libgcc \
 libstdc++ \
 rocm-hip \
 rocm-origami \
 "
RDEPENDS:hipblaslt-devel = " \
 cmake-filesystem \
 hipblaslt \
 "
