# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-am"
PV = "0.20090704"
PR = "31.el10"
PACKAGES = " \
 hunspell-am \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-am-0.20090704-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "544e3ad5c0fac1e1dd827eff9a4292bf1cfc9a16ad4f0b084830ed30a20621ed"

URI_x86_64_v2_hunspell-am = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-am-0.20090704-31.el10.noarch.rpm;name=x86_64_v2_hunspell-am;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-am}"
SRC_URI[x86_64_v2_hunspell-am.sha256sum] = "14e02163d17d7824360775e36c7f0bb7bf8fdded3f455fe3633e3ad05e549f77"

URI_aarch64_hunspell-am = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-am-0.20090704-31.el10.noarch.rpm;name=aarch64_hunspell-am;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-am}"
SRC_URI[aarch64_hunspell-am.sha256sum] = "14e02163d17d7824360775e36c7f0bb7bf8fdded3f455fe3633e3ad05e549f77"

RDEPENDS:hunspell-am = " \
 hunspell-filesystem \
 "
