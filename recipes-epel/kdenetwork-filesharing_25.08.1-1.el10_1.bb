# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdenetwork-filesharing"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kdenetwork-filesharing \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdenetwork-filesharing-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "530ee0a4650d9ef7e906b3dc74e45f3fd122b45982f2ea09494dabb6722ec919"

URI_x86_64_v2_kdenetwork-filesharing = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdenetwork-filesharing-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdenetwork-filesharing;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdenetwork-filesharing}"
SRC_URI[x86_64_v2_kdenetwork-filesharing.sha256sum] = "1004355bd8082e8fe797f1a8fe4182b7ae4b9a67916ccd7f5c17737495c7e14c"

URI_aarch64_kdenetwork-filesharing = "${EPEL_MIRROR}/aarch64/Packages/k/kdenetwork-filesharing-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kdenetwork-filesharing;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdenetwork-filesharing}"
SRC_URI[aarch64_kdenetwork-filesharing.sha256sum] = "b4f5d5bf2afd4dea636c56ea33fc94a6664b39b4fd215bba7a172d3659925091"

RDEPENDS:kdenetwork-filesharing = " \
 PackageKit-Qt6 \
 glibc \
 kf6-kauth \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
