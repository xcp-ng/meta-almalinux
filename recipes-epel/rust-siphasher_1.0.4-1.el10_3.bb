# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-siphasher"
PV = "1.0.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-siphasher+default-devel \
 rust-siphasher+serde-devel \
 rust-siphasher+serde_json-devel \
 rust-siphasher+serde_no_std-devel \
 rust-siphasher+serde_std-devel \
 rust-siphasher+std-devel \
 rust-siphasher-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-siphasher-1.0.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7a2c6a4c90614fcfa235a834027933f8fa48b990f560c437a6bacead1324f392"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher+default-devel-1.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-siphasher+default-devel.sha256sum] = "eb01e13bf400955996fb6c47b8abede3a9e7fd48a2148934ea27aa4a41c29958"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher+serde-devel-1.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-siphasher+serde-devel.sha256sum] = "236882e3c90f6d32aa57c7e5f70e7f8c6de5108a15f648ae220f1370872011fe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher+serde_json-devel-1.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher+serde_json-devel;unpack=0"
SRC_URI[x86_64_v2_rust-siphasher+serde_json-devel.sha256sum] = "4401c7128fcb8d27466d2053cace905311dfeca19deae0ecc7212d8e287ea905"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher+serde_no_std-devel-1.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher+serde_no_std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-siphasher+serde_no_std-devel.sha256sum] = "75bdcf9bab698184bd925c14d6b49608bb87797ff8dc82cb1fe6facef415fbfd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher+serde_std-devel-1.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher+serde_std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-siphasher+serde_std-devel.sha256sum] = "0c983d167f569e6ff084f6291d7f9cb029527c4c63c24d9a64296a45e7616a2a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher+std-devel-1.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-siphasher+std-devel.sha256sum] = "48afdc6ecf7cda86d1092a567c4a7d1cb37a0c45595fc7c99230a73374afb30f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher-devel-1.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher-devel;unpack=0"
SRC_URI[x86_64_v2_rust-siphasher-devel.sha256sum] = "a8b4d9207e3cf05bc3a78b1824b8d15db44dffa08c3ccb1df8ac8e4dfc071953"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher+default-devel-1.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-siphasher+default-devel;unpack=0"
SRC_URI[aarch64_rust-siphasher+default-devel.sha256sum] = "482ae17ee00e300477d3a6ca6158475d9607a71cd19257833ec7e4404e1148eb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher+serde-devel-1.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-siphasher+serde-devel;unpack=0"
SRC_URI[aarch64_rust-siphasher+serde-devel.sha256sum] = "386b68ddbe44af27e6638871406bd24471322daf6fd86371d0c4c3c84330cf2e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher+serde_json-devel-1.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-siphasher+serde_json-devel;unpack=0"
SRC_URI[aarch64_rust-siphasher+serde_json-devel.sha256sum] = "f4afd478d0342b5d4f764cd607ec22617acf0f002220cc76ad03af2a7e54c742"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher+serde_no_std-devel-1.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-siphasher+serde_no_std-devel;unpack=0"
SRC_URI[aarch64_rust-siphasher+serde_no_std-devel.sha256sum] = "67dbdb5aa09e7f9bb483429bc18f5a0d01e4cad51dacea53f8a4df7fbb86187f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher+serde_std-devel-1.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-siphasher+serde_std-devel;unpack=0"
SRC_URI[aarch64_rust-siphasher+serde_std-devel.sha256sum] = "fbe39df6efadb330efacc0d37788ba9099b7f34bce306b71bde051f9e163f20b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher+std-devel-1.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-siphasher+std-devel;unpack=0"
SRC_URI[aarch64_rust-siphasher+std-devel.sha256sum] = "35d2f7b92f65c5615d0ce4dbae83dbd904c627b5e8df99f22f032e68b70ee0b6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher-devel-1.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-siphasher-devel;unpack=0"
SRC_URI[aarch64_rust-siphasher-devel.sha256sum] = "0d838a7055b29f1fe6bf7641351c6e65b77388b6ca980a9552dfa96975c5a9e0"

RDEPENDS:rust-siphasher+default-devel = " \
 cargo \
 rust-siphasher+std-devel \
 rust-siphasher-devel \
 "
RDEPENDS:rust-siphasher+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-siphasher-devel \
 "
RDEPENDS:rust-siphasher+serde_json-devel = " \
 cargo \
 rust-serde_json+default-devel \
 rust-siphasher-devel \
 "
RDEPENDS:rust-siphasher+serde_no_std-devel = " \
 cargo \
 rust-serde+alloc-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-siphasher-devel \
 "
RDEPENDS:rust-siphasher+serde_std-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-siphasher+std-devel \
 rust-siphasher-devel \
 "
RDEPENDS:rust-siphasher+std-devel = " \
 cargo \
 rust-siphasher-devel \
 "
RDEPENDS:rust-siphasher-devel = " \
 cargo \
 "
