# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kalgebra"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kalgebra \
 kalgebra-plasma-applet \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kalgebra-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7afc9eee5bc909e7ed68762fa32f6bdd7b9724a3d303165041c1694be7239677"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kalgebra-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kalgebra;unpack=0"
SRC_URI[x86_64_v2_kalgebra.sha256sum] = "0435ff56b5679a8b102dc948a71258c9fb90d0889b9e037053232f964cc50a46"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kalgebra-plasma-applet-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kalgebra-plasma-applet;unpack=0"
SRC_URI[x86_64_v2_kalgebra-plasma-applet.sha256sum] = "9604e1f15d186760950883ba66575b53c3fbc3ca6d21e9e89ad2a0881817fa6c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kalgebra-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kalgebra;unpack=0"
SRC_URI[aarch64_kalgebra.sha256sum] = "909fd390861ef01704a81f3516036f0e1b11f600272877343cf6948c9ef7a015"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kalgebra-plasma-applet-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kalgebra-plasma-applet;unpack=0"
SRC_URI[aarch64_kalgebra-plasma-applet.sha256sum] = "6134025af7227f19ecd58b5f7eab8629d27bf441584ee81bf28438bb93c2abfd"

RDEPENDS:kalgebra = " \
 analitza \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebengine \
 readline \
 "
RDEPENDS:kalgebra-plasma-applet = " \
 kalgebra \
 libplasma \
 "
