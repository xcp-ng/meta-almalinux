# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-derive_builder"
PV = "0.20.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-derive_builder+alloc-devel \
 rust-derive_builder+default-devel \
 rust-derive_builder+std-devel \
 rust-derive_builder-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-derive_builder-0.20.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4147bad246ac13b7ce49ffea6afe6f1130e293d56c10d572260183ab1e1f2cb9"

URI_x86_64_v2_rust-derive_builder+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_builder+alloc-devel-0.20.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_builder+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_builder+alloc-devel}"
SRC_URI[x86_64_v2_rust-derive_builder+alloc-devel.sha256sum] = "e0b60c17b7599da5f82841b57b0a6ce79383dccf66ecfc6ea192f294b7abdc6c"

URI_x86_64_v2_rust-derive_builder+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_builder+default-devel-0.20.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_builder+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_builder+default-devel}"
SRC_URI[x86_64_v2_rust-derive_builder+default-devel.sha256sum] = "48d64a361f7b8e7aa0f2bc0624792eb0a15c350c7bde3f108abc17b11bb91e60"

URI_x86_64_v2_rust-derive_builder+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_builder+std-devel-0.20.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_builder+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_builder+std-devel}"
SRC_URI[x86_64_v2_rust-derive_builder+std-devel.sha256sum] = "dd64c99a8625a21e26e6113fcde7626400e7da9609f75b50b4a3bacc7e37e0c4"

URI_x86_64_v2_rust-derive_builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_builder-devel-0.20.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_builder-devel}"
SRC_URI[x86_64_v2_rust-derive_builder-devel.sha256sum] = "53b8cc8b298cd77bf9a8a69f85ce9979f42dcb0100398ce5f8e8960403cda0a0"

URI_aarch64_rust-derive_builder+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_builder+alloc-devel-0.20.2-1.el10_0.noarch.rpm;name=aarch64_rust-derive_builder+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_builder+alloc-devel}"
SRC_URI[aarch64_rust-derive_builder+alloc-devel.sha256sum] = "cd02c4be626bba8fa20415945fda5ea65adcacb3e84f87924f34c5c1fb54ea0f"

URI_aarch64_rust-derive_builder+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_builder+default-devel-0.20.2-1.el10_0.noarch.rpm;name=aarch64_rust-derive_builder+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_builder+default-devel}"
SRC_URI[aarch64_rust-derive_builder+default-devel.sha256sum] = "0e8b0adc6e8f6b799cc70b9752b37f4f1e1caadf4ea3728d1fc68f23f089be5b"

URI_aarch64_rust-derive_builder+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_builder+std-devel-0.20.2-1.el10_0.noarch.rpm;name=aarch64_rust-derive_builder+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_builder+std-devel}"
SRC_URI[aarch64_rust-derive_builder+std-devel.sha256sum] = "acc37324046353edd723be18044a42194a9a242ef2f41e21702e931fc2a65eb6"

URI_aarch64_rust-derive_builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_builder-devel-0.20.2-1.el10_0.noarch.rpm;name=aarch64_rust-derive_builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_builder-devel}"
SRC_URI[aarch64_rust-derive_builder-devel.sha256sum] = "54f7d39943337f306f04d42910d5d391c77605d4e4621943b41144efb5260e4f"

RDEPENDS:rust-derive_builder+alloc-devel = " \
 cargo \
 rust-derive_builder-devel \
 rust-derive_builder_macro+alloc-devel \
 "
RDEPENDS:rust-derive_builder+default-devel = " \
 cargo \
 rust-derive_builder+std-devel \
 rust-derive_builder-devel \
 "
RDEPENDS:rust-derive_builder+std-devel = " \
 cargo \
 rust-derive_builder-devel \
 rust-derive_builder_macro+lib_has_std-devel \
 "
RDEPENDS:rust-derive_builder-devel = " \
 cargo \
 rust-derive_builder_macro+default-devel \
 "
