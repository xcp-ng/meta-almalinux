# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-transport"
PV = "0.57.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-transport+async-client-devel \
 rust-gix-transport+async-std-devel \
 rust-gix-transport+async-trait-devel \
 rust-gix-transport+base64-devel \
 rust-gix-transport+blocking-client-devel \
 rust-gix-transport+curl-devel \
 rust-gix-transport+default-devel \
 rust-gix-transport+document-features-devel \
 rust-gix-transport+futures-io-devel \
 rust-gix-transport+futures-lite-devel \
 rust-gix-transport+gix-credentials-devel \
 rust-gix-transport+http-client-curl-devel \
 rust-gix-transport+http-client-curl-openssl-devel \
 rust-gix-transport+http-client-devel \
 rust-gix-transport+http-client-insecure-credentials-devel \
 rust-gix-transport+http-client-reqwest-devel \
 rust-gix-transport+http-client-reqwest-native-tls-devel \
 rust-gix-transport+http-client-reqwest-rust-tls-devel \
 rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel \
 rust-gix-transport+pin-project-lite-devel \
 rust-gix-transport+reqwest-devel \
 rust-gix-transport+serde-devel \
 rust-gix-transport-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-transport-0.57.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc23e77e4fac663e290e9bde59d6ff09a55a5037829cd0e916de419ad234bca1"

URI_x86_64_v2_rust-gix-transport+async-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+async-client-devel-0.57.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+async-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+async-client-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+async-client-devel.sha256sum] = "39c3b582d5b147cb8a0a1e8f989961bbee2e8c824849341763058c3e7854ad41"

URI_x86_64_v2_rust-gix-transport+async-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+async-std-devel-0.57.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+async-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+async-std-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+async-std-devel.sha256sum] = "d664ac8f783b98b698bf716b2ed69fe857e8dfb2f5af0d8b05b700089a5a73b5"

URI_x86_64_v2_rust-gix-transport+async-trait-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+async-trait-devel-0.57.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+async-trait-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+async-trait-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+async-trait-devel.sha256sum] = "3e5e750af190810972f908d4d6353cabcd3770eeab4a24a256f1ed9d636b6709"

URI_x86_64_v2_rust-gix-transport+base64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+base64-devel-0.57.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+base64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+base64-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+base64-devel.sha256sum] = "e399abf3cdcb5f8fb0b88b46cdb36990f47e2df5d9afc66f6fc512d9c0265d06"

URI_x86_64_v2_rust-gix-transport+blocking-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+blocking-client-devel-0.57.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+blocking-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+blocking-client-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+blocking-client-devel.sha256sum] = "86b89ea4f522ed0c26386248c83576cc153a8fe8cdbf5ce931f7eb78c4db5be0"

URI_x86_64_v2_rust-gix-transport+curl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+curl-devel-0.57.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+curl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+curl-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+curl-devel.sha256sum] = "a0eb8327f4f8b9f1a6aa4f7278ba9b58d062166ca093c37be05420a4f42a3980"

URI_x86_64_v2_rust-gix-transport+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+default-devel-0.57.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+default-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+default-devel.sha256sum] = "5d43c3e7e06363824ccb7f6c9d0a48df35626c06b66871b06fa4a0871f279618"

URI_x86_64_v2_rust-gix-transport+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+document-features-devel-0.57.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+document-features-devel.sha256sum] = "0c8ded32f15eb1c1051159039292b28f80b8688b3a8de4923fe6dac50a6dfb9c"

URI_x86_64_v2_rust-gix-transport+futures-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+futures-io-devel-0.57.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+futures-io-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+futures-io-devel.sha256sum] = "7dac349f5e427588e1aa8b35146d5910e79b5317c5f30b9bbed97446fca5dcc8"

URI_x86_64_v2_rust-gix-transport+futures-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+futures-lite-devel-0.57.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+futures-lite-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+futures-lite-devel.sha256sum] = "fb0670cc9b4e3c2b9f36f632fe2292d522d5fd4c884ad8e99ed23ef14910f1b4"

URI_x86_64_v2_rust-gix-transport+gix-credentials-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+gix-credentials-devel-0.57.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+gix-credentials-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+gix-credentials-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+gix-credentials-devel.sha256sum] = "1ac5a8fd1d1cbc25541ec93c429f2a9656f8f289c1e462befb1de4e9c6001e0b"

URI_x86_64_v2_rust-gix-transport+http-client-curl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+http-client-curl-devel-0.57.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+http-client-curl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+http-client-curl-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+http-client-curl-devel.sha256sum] = "ce5e98daf910f25c2681ab1e02f98931aaba3d5047c0989544a5dc23cfb7f895"

URI_x86_64_v2_rust-gix-transport+http-client-curl-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+http-client-curl-openssl-devel-0.57.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+http-client-curl-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+http-client-curl-openssl-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+http-client-curl-openssl-devel.sha256sum] = "c5d57288f2cdc305c71362c0f8b985f17f2b76950813632b3a59b74c31343105"

URI_x86_64_v2_rust-gix-transport+http-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+http-client-devel-0.57.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+http-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+http-client-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+http-client-devel.sha256sum] = "99c2a162289d89c76dc85a0e3b89849af7f1954dc83e19fdd6fe7efcdea95690"

URI_x86_64_v2_rust-gix-transport+http-client-insecure-credentials-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+http-client-insecure-credentials-devel-0.57.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+http-client-insecure-credentials-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+http-client-insecure-credentials-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+http-client-insecure-credentials-devel.sha256sum] = "67cfcd34676442330150869702243e466b351cd1e781c0bc0a8dae6d8e6b935f"

URI_x86_64_v2_rust-gix-transport+http-client-reqwest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+http-client-reqwest-devel-0.57.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+http-client-reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+http-client-reqwest-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+http-client-reqwest-devel.sha256sum] = "0af8913bb139e27423d30065f0ab1440d8537339e7fb7be1d26a2aedbc939e51"

URI_x86_64_v2_rust-gix-transport+http-client-reqwest-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+http-client-reqwest-native-tls-devel-0.57.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+http-client-reqwest-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+http-client-reqwest-native-tls-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+http-client-reqwest-native-tls-devel.sha256sum] = "dbc4a6f1915b06ddd0ec6173784fb6b604e8ac67702bd9ec0ea6c91154fa5b7a"

URI_x86_64_v2_rust-gix-transport+http-client-reqwest-rust-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+http-client-reqwest-rust-tls-devel-0.57.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+http-client-reqwest-rust-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+http-client-reqwest-rust-tls-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+http-client-reqwest-rust-tls-devel.sha256sum] = "73aea7f20a42aa1b15f07b1ed25c7200eb2a38a835825179b788648d8da7da36"

URI_x86_64_v2_rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel-0.57.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel.sha256sum] = "e0a08219bf8f9bfb59be6eed97fccb63767e66f80e879ed2a6beabcee6381f7f"

URI_x86_64_v2_rust-gix-transport+pin-project-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+pin-project-lite-devel-0.57.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+pin-project-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+pin-project-lite-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+pin-project-lite-devel.sha256sum] = "52449e76402c84d85058008b247108bc8890bf38a53d52c773ec95af75b9ee41"

URI_x86_64_v2_rust-gix-transport+reqwest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+reqwest-devel-0.57.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+reqwest-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+reqwest-devel.sha256sum] = "4e0a80a2deea7b1f58299dde49bde3e2d4c5110e0ffc82dca4e6c32120cf9359"

URI_x86_64_v2_rust-gix-transport+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+serde-devel-0.57.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+serde-devel.sha256sum] = "99ae0b7a528c8a17182b7108acdf98a2e1c8444b16c0ee75e3d7011006848e01"

URI_x86_64_v2_rust-gix-transport-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport-devel-0.57.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport-devel}"
SRC_URI[x86_64_v2_rust-gix-transport-devel.sha256sum] = "310188fc0d7c62bebacd7ffb77e0a17de97b9cce34bb3d41a06e92132bf92330"

URI_aarch64_rust-gix-transport+async-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+async-client-devel-0.57.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-transport+async-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+async-client-devel}"
SRC_URI[aarch64_rust-gix-transport+async-client-devel.sha256sum] = "56f4a4ae5d0d44d3ba3d28fda6ef5d058809877a5747c0d3fd2100e6d99da4d7"

URI_aarch64_rust-gix-transport+async-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+async-std-devel-0.57.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-transport+async-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+async-std-devel}"
SRC_URI[aarch64_rust-gix-transport+async-std-devel.sha256sum] = "34340cc15ec9802678076aa72c7b73292b9d16bd13fda6b30da4218eb0605eff"

URI_aarch64_rust-gix-transport+async-trait-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+async-trait-devel-0.57.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-transport+async-trait-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+async-trait-devel}"
SRC_URI[aarch64_rust-gix-transport+async-trait-devel.sha256sum] = "f07cc05fe8241a0ea5aff74cc1021b98da93d4cfcf1159742247af9435e3516b"

URI_aarch64_rust-gix-transport+base64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+base64-devel-0.57.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-transport+base64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+base64-devel}"
SRC_URI[aarch64_rust-gix-transport+base64-devel.sha256sum] = "0a1abd79545541d1d59ef3d6ba72550dc549c5d414caa80e39a003fe21b13eab"

URI_aarch64_rust-gix-transport+blocking-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+blocking-client-devel-0.57.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-transport+blocking-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+blocking-client-devel}"
SRC_URI[aarch64_rust-gix-transport+blocking-client-devel.sha256sum] = "f6874c3f40dd85bae0916590443b9e92ee475ab86708b51eca27f43d2f70ffd7"

URI_aarch64_rust-gix-transport+curl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+curl-devel-0.57.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-transport+curl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+curl-devel}"
SRC_URI[aarch64_rust-gix-transport+curl-devel.sha256sum] = "dadc73ac23181a807284803c34dd0d46a7eec88dc43704b604f5ad67106d8867"

URI_aarch64_rust-gix-transport+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+default-devel-0.57.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-transport+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+default-devel}"
SRC_URI[aarch64_rust-gix-transport+default-devel.sha256sum] = "7f4d242f4f8e6f3a5bfaabc03d9828df017b36629cef3b9d11d78f6d803f5ada"

URI_aarch64_rust-gix-transport+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+document-features-devel-0.57.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-transport+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+document-features-devel}"
SRC_URI[aarch64_rust-gix-transport+document-features-devel.sha256sum] = "7471596fc0bc9069854cae2d6686e58b8a84b1e800758029e8f4b592ea0d07e4"

URI_aarch64_rust-gix-transport+futures-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+futures-io-devel-0.57.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-transport+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+futures-io-devel}"
SRC_URI[aarch64_rust-gix-transport+futures-io-devel.sha256sum] = "94eade74e36a954bd25fddc4217c649298f9445c5798386080c96432852ce21c"

URI_aarch64_rust-gix-transport+futures-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+futures-lite-devel-0.57.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-transport+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+futures-lite-devel}"
SRC_URI[aarch64_rust-gix-transport+futures-lite-devel.sha256sum] = "a76032de7085bc5b734f07689091eba8945f9f6898e84d08050cfbdd40bcac89"

URI_aarch64_rust-gix-transport+gix-credentials-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+gix-credentials-devel-0.57.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-transport+gix-credentials-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+gix-credentials-devel}"
SRC_URI[aarch64_rust-gix-transport+gix-credentials-devel.sha256sum] = "9f9871f11b7c3e9fec3008a3c2d37a4ba2a382b36e866bb892730f683cb57892"

URI_aarch64_rust-gix-transport+http-client-curl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+http-client-curl-devel-0.57.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-transport+http-client-curl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+http-client-curl-devel}"
SRC_URI[aarch64_rust-gix-transport+http-client-curl-devel.sha256sum] = "f16b57eba30952461af2af56e6c7bdfc78dc65397b33d9beb70bc753c90feaa0"

URI_aarch64_rust-gix-transport+http-client-curl-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+http-client-curl-openssl-devel-0.57.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-transport+http-client-curl-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+http-client-curl-openssl-devel}"
SRC_URI[aarch64_rust-gix-transport+http-client-curl-openssl-devel.sha256sum] = "5985124161db9a8269a56e1ebf61e6f36fc430e58e9883fbad2fe6f794dc892f"

URI_aarch64_rust-gix-transport+http-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+http-client-devel-0.57.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-transport+http-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+http-client-devel}"
SRC_URI[aarch64_rust-gix-transport+http-client-devel.sha256sum] = "2efc80a685342fefc1338cc24d4911e19376408e9043d0907e2e3338f482b661"

URI_aarch64_rust-gix-transport+http-client-insecure-credentials-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+http-client-insecure-credentials-devel-0.57.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-transport+http-client-insecure-credentials-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+http-client-insecure-credentials-devel}"
SRC_URI[aarch64_rust-gix-transport+http-client-insecure-credentials-devel.sha256sum] = "d3d3b94b845271de899ec8a26280939515c1c7e9311be51005776153ddbd87cd"

URI_aarch64_rust-gix-transport+http-client-reqwest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+http-client-reqwest-devel-0.57.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-transport+http-client-reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+http-client-reqwest-devel}"
SRC_URI[aarch64_rust-gix-transport+http-client-reqwest-devel.sha256sum] = "8abb5fd562e286c85408641cc5e891975db6b8f8f979269d500181d48e173612"

URI_aarch64_rust-gix-transport+http-client-reqwest-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+http-client-reqwest-native-tls-devel-0.57.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-transport+http-client-reqwest-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+http-client-reqwest-native-tls-devel}"
SRC_URI[aarch64_rust-gix-transport+http-client-reqwest-native-tls-devel.sha256sum] = "9b264a63967cc449707dfc3647ae24b30fc89a5e24710473a52e111d93a9b03a"

URI_aarch64_rust-gix-transport+http-client-reqwest-rust-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+http-client-reqwest-rust-tls-devel-0.57.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-transport+http-client-reqwest-rust-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+http-client-reqwest-rust-tls-devel}"
SRC_URI[aarch64_rust-gix-transport+http-client-reqwest-rust-tls-devel.sha256sum] = "10ce7d341a255c39c190263cd5a70fd5e4c2f6de9346e41197e110ea2db44030"

URI_aarch64_rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel-0.57.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel}"
SRC_URI[aarch64_rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel.sha256sum] = "25368cf22085328f004da84b724aae6c1be7f6939e93d370c8bee8df164b0e5c"

URI_aarch64_rust-gix-transport+pin-project-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+pin-project-lite-devel-0.57.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-transport+pin-project-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+pin-project-lite-devel}"
SRC_URI[aarch64_rust-gix-transport+pin-project-lite-devel.sha256sum] = "9a5bb3f086278bcfb1d4988219618ce9bf8f8d1cc42a4d2609ebaffd6efc5c9b"

URI_aarch64_rust-gix-transport+reqwest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+reqwest-devel-0.57.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-transport+reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+reqwest-devel}"
SRC_URI[aarch64_rust-gix-transport+reqwest-devel.sha256sum] = "64f155e7d3b85ad673c818d5a96d528bf6905b32453c786ad051e4ac4ec6c157"

URI_aarch64_rust-gix-transport+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+serde-devel-0.57.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-transport+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+serde-devel}"
SRC_URI[aarch64_rust-gix-transport+serde-devel.sha256sum] = "5eaee5200198fb67708cef421f0f6e3538d5e090ced80c42dc51ac107dd50a8e"

URI_aarch64_rust-gix-transport-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport-devel-0.57.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-transport-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport-devel}"
SRC_URI[aarch64_rust-gix-transport-devel.sha256sum] = "31493baa9750cc85d445b43e462e3654d693717ec5eace852f065af189bc9844"

RDEPENDS:rust-gix-transport+async-client-devel = " \
 cargo \
 rust-gix-packetline+async-io-devel \
 rust-gix-transport+async-trait-devel \
 rust-gix-transport+futures-io-devel \
 rust-gix-transport+futures-lite-devel \
 rust-gix-transport+pin-project-lite-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+async-std-devel = " \
 cargo \
 rust-async-std+default-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+async-trait-devel = " \
 cargo \
 rust-async-trait+default-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+base64-devel = " \
 cargo \
 rust-base64_0.22+default-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+blocking-client-devel = " \
 cargo \
 rust-gix-packetline+blocking-io-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+curl-devel = " \
 cargo \
 rust-curl-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+default-devel = " \
 cargo \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+futures-io-devel = " \
 cargo \
 rust-futures-io+default-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+futures-lite-devel = " \
 cargo \
 rust-futures-lite+default-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+gix-credentials-devel = " \
 cargo \
 rust-gix-credentials+default-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+http-client-curl-devel = " \
 cargo \
 rust-gix-transport+curl-devel \
 rust-gix-transport+http-client-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+http-client-curl-openssl-devel = " \
 cargo \
 rust-curl+ssl-devel \
 rust-curl-devel \
 rust-gix-transport+http-client-curl-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+http-client-devel = " \
 cargo \
 rust-gix-features+io-pipe-devel \
 rust-gix-transport+base64-devel \
 rust-gix-transport+blocking-client-devel \
 rust-gix-transport+gix-credentials-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+http-client-insecure-credentials-devel = " \
 cargo \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+http-client-reqwest-devel = " \
 cargo \
 rust-gix-transport+http-client-devel \
 rust-gix-transport+reqwest-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+http-client-reqwest-native-tls-devel = " \
 cargo \
 rust-gix-transport+http-client-reqwest-devel \
 rust-gix-transport-devel \
 rust-reqwest+blocking-devel \
 rust-reqwest+charset-devel \
 rust-reqwest+http2-devel \
 rust-reqwest+native-tls-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-gix-transport+http-client-reqwest-rust-tls-devel = " \
 cargo \
 rust-gix-transport+http-client-reqwest-devel \
 rust-gix-transport-devel \
 rust-reqwest+blocking-devel \
 rust-reqwest+charset-devel \
 rust-reqwest+http2-devel \
 rust-reqwest+rustls-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel = " \
 cargo \
 rust-gix-transport+http-client-reqwest-devel \
 rust-gix-transport-devel \
 rust-reqwest+blocking-devel \
 rust-reqwest+charset-devel \
 rust-reqwest+hickory-dns-devel \
 rust-reqwest+http2-devel \
 rust-reqwest+rustls-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-gix-transport+pin-project-lite-devel = " \
 cargo \
 rust-gix-transport-devel \
 rust-pin-project-lite+default-devel \
 "
RDEPENDS:rust-gix-transport+reqwest-devel = " \
 cargo \
 rust-gix-transport-devel \
 rust-reqwest+blocking-devel \
 rust-reqwest+charset-devel \
 rust-reqwest+http2-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-gix-transport+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-transport-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-transport-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-command+default-devel \
 rust-gix-features+default-devel \
 rust-gix-packetline+default-devel \
 rust-gix-quote+default-devel \
 rust-gix-sec+default-devel \
 rust-gix-url+default-devel \
 rust-thiserror+default-devel \
 "
