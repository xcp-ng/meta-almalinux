# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libc"
PV = "0.2.189"
PR = "1.el10_2"
PACKAGES = " \
 rust-libc+align-devel \
 rust-libc+const-extern-fn-devel \
 rust-libc+default-devel \
 rust-libc+extra_traits-devel \
 rust-libc+std-devel \
 rust-libc+use_std-devel \
 rust-libc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libc-0.2.189-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52c81a0358216d6f9050698fc924d84f71521ce2530befa57f24af8476360050"

URI_x86_64_v2_rust-libc+align-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libc+align-devel-0.2.189-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libc+align-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libc+align-devel}"
SRC_URI[x86_64_v2_rust-libc+align-devel.sha256sum] = "77c622fbf8f9dc695b3631555afea6756ac4e83ca4d437787b1b22b276243119"

URI_x86_64_v2_rust-libc+const-extern-fn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libc+const-extern-fn-devel-0.2.189-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libc+const-extern-fn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libc+const-extern-fn-devel}"
SRC_URI[x86_64_v2_rust-libc+const-extern-fn-devel.sha256sum] = "ecacf3e3f887d4ec2724356e34556d08e9e7a271a2d53e90dbf1520884e7e599"

URI_x86_64_v2_rust-libc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libc+default-devel-0.2.189-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libc+default-devel}"
SRC_URI[x86_64_v2_rust-libc+default-devel.sha256sum] = "53fd452063156263b562f984c2de5f985829f702a3ead95e4baa94af028cfd12"

URI_x86_64_v2_rust-libc+extra_traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libc+extra_traits-devel-0.2.189-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libc+extra_traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libc+extra_traits-devel}"
SRC_URI[x86_64_v2_rust-libc+extra_traits-devel.sha256sum] = "2a3dd74eba86e44895aa46fccb95b084e37583279d35f28153ea6de75c27adf0"

URI_x86_64_v2_rust-libc+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libc+std-devel-0.2.189-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libc+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libc+std-devel}"
SRC_URI[x86_64_v2_rust-libc+std-devel.sha256sum] = "a8a88a6d94b3b4fa8b97f74ccba4627728a96b4083e311f044985951c8f0d4c7"

URI_x86_64_v2_rust-libc+use_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libc+use_std-devel-0.2.189-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libc+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libc+use_std-devel}"
SRC_URI[x86_64_v2_rust-libc+use_std-devel.sha256sum] = "e0748733a669ac96ef97a3395941e494ca11e3794f2e11b3d147f64d25783b35"

URI_x86_64_v2_rust-libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libc-devel-0.2.189-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libc-devel}"
SRC_URI[x86_64_v2_rust-libc-devel.sha256sum] = "a476162966bf20bb86938821012b95e43d3c9b43c2b1b2581ea48eb32d7bd7e8"

URI_aarch64_rust-libc+align-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libc+align-devel-0.2.189-1.el10_2.noarch.rpm;name=aarch64_rust-libc+align-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libc+align-devel}"
SRC_URI[aarch64_rust-libc+align-devel.sha256sum] = "0fc97061701f150e298747ec87cea67d9d667e6d2f73ff017687475425036c1c"

URI_aarch64_rust-libc+const-extern-fn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libc+const-extern-fn-devel-0.2.189-1.el10_2.noarch.rpm;name=aarch64_rust-libc+const-extern-fn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libc+const-extern-fn-devel}"
SRC_URI[aarch64_rust-libc+const-extern-fn-devel.sha256sum] = "acd540aaa2ac2d59db47359cb6e3a35ad45082aa59065379201e8eebf984260d"

URI_aarch64_rust-libc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libc+default-devel-0.2.189-1.el10_2.noarch.rpm;name=aarch64_rust-libc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libc+default-devel}"
SRC_URI[aarch64_rust-libc+default-devel.sha256sum] = "e93f0c0ee2a949faf8c7a1481da8a70afe31a1b4ed0d842ebd6797e5d9d460a0"

URI_aarch64_rust-libc+extra_traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libc+extra_traits-devel-0.2.189-1.el10_2.noarch.rpm;name=aarch64_rust-libc+extra_traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libc+extra_traits-devel}"
SRC_URI[aarch64_rust-libc+extra_traits-devel.sha256sum] = "92d011ff30c5f50f4521071118b5501cfaef511949ddfc6660688052ca7841a0"

URI_aarch64_rust-libc+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libc+std-devel-0.2.189-1.el10_2.noarch.rpm;name=aarch64_rust-libc+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libc+std-devel}"
SRC_URI[aarch64_rust-libc+std-devel.sha256sum] = "50d6d65ea81a7f48546547a9b636c423637da0c58379520e808ab434d35cf123"

URI_aarch64_rust-libc+use_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libc+use_std-devel-0.2.189-1.el10_2.noarch.rpm;name=aarch64_rust-libc+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libc+use_std-devel}"
SRC_URI[aarch64_rust-libc+use_std-devel.sha256sum] = "091bf4d6b092d06c8286a28662f6bae11de03dfab60ac0e2360b535b2b49b1b3"

URI_aarch64_rust-libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libc-devel-0.2.189-1.el10_2.noarch.rpm;name=aarch64_rust-libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libc-devel}"
SRC_URI[aarch64_rust-libc-devel.sha256sum] = "71ec78478244eb530a61f516aaf5ea0309caca1f90657e39091706e58684bc4b"

RDEPENDS:rust-libc+align-devel = " \
 cargo \
 rust-libc-devel \
 "
RDEPENDS:rust-libc+const-extern-fn-devel = " \
 cargo \
 rust-libc-devel \
 "
RDEPENDS:rust-libc+default-devel = " \
 cargo \
 rust-libc+std-devel \
 rust-libc-devel \
 "
RDEPENDS:rust-libc+extra_traits-devel = " \
 cargo \
 rust-libc-devel \
 "
RDEPENDS:rust-libc+std-devel = " \
 cargo \
 rust-libc-devel \
 "
RDEPENDS:rust-libc+use_std-devel = " \
 cargo \
 rust-libc+std-devel \
 rust-libc-devel \
 "
RDEPENDS:rust-libc-devel = " \
 cargo \
 glibc-devel \
 rust \
 "
