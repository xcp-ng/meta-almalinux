# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcmutils"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kcmutils \
 kf6-kcmutils-devel \
 kf6-kcmutils-doc \
 kf6-kcmutils-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kcmutils-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "860a7e51bacc65c1d75338645e4435a37e27e5a0352d68486c175de1dd8b124d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcmutils-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcmutils;unpack=0"
SRC_URI[x86_64_v2_kf6-kcmutils.sha256sum] = "537ff4d0ce22a0e861d0638339ccfc3fb81e894604c6d3f23ac1e06c4d1bfd28"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcmutils-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcmutils-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kcmutils-devel.sha256sum] = "e8f77773f448997507e0bcd839ac4931148c9f121e79cfd7a246201215a85edb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcmutils-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcmutils-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kcmutils-doc.sha256sum] = "33f4ad29f6e1d3af42b7de1b3f64d4562c83863120d9d4724ec7ed89be54f781"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcmutils-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcmutils-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kcmutils-html.sha256sum] = "01c29981dcac69c80735e47b99b74d56ba363f6e0188724bfa33c0be58c374a9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcmutils-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kcmutils;unpack=0"
SRC_URI[aarch64_kf6-kcmutils.sha256sum] = "398a804d8d4c5ea459b7aa5c2a087fff1488aaef66c1a7dc81fc470de364a3c4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcmutils-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kcmutils-devel;unpack=0"
SRC_URI[aarch64_kf6-kcmutils-devel.sha256sum] = "5568b4a1c89f48646b95a1908a204a887923de8ecf2364e434aee0c945fa5eaa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcmutils-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kcmutils-doc;unpack=0"
SRC_URI[aarch64_kf6-kcmutils-doc.sha256sum] = "39b79e2063a804e554d79d412105f408e6eeef1cf91111ee6eaecfd95240b748"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcmutils-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kcmutils-html;unpack=0"
SRC_URI[aarch64_kf6-kcmutils-html.sha256sum] = "b1db63c745ca99586d8d98f7f3a5e34a8ee0b35269ef327e023cf1304636c071"

RDEPENDS:kf6-kcmutils = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kitemviews \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kcmutils-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kcmutils \
 kf6-kconfigwidgets-devel \
 kf6-kservice-devel \
 qt6-qtbase \
 qt6-qtdeclarative-devel \
 "
RDEPENDS:kf6-kcmutils-doc = " \
 "
RDEPENDS:kf6-kcmutils-html = " \
 "
