# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-option-ext"
PV = "0.2.0"
PR = "4.el10_0"
PACKAGES = " \
 rust-option-ext+default-devel \
 rust-option-ext-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-option-ext-0.2.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a34cfb61ed666885060efda3a28b3f69aaef1840e95cdf75d4f7f03a32e95b4"

URI_x86_64_v2_rust-option-ext+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-option-ext+default-devel-0.2.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-option-ext+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-option-ext+default-devel}"
SRC_URI[x86_64_v2_rust-option-ext+default-devel.sha256sum] = "abc8728be022a83cd1199502dd49f0ed8cfb4a00564e41efc81fc02f1725c922"

URI_x86_64_v2_rust-option-ext-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-option-ext-devel-0.2.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-option-ext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-option-ext-devel}"
SRC_URI[x86_64_v2_rust-option-ext-devel.sha256sum] = "671127d543955a8eca9092515d12962fc79ddadb54ad3ac10054eb941b097908"

URI_aarch64_rust-option-ext+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-option-ext+default-devel-0.2.0-4.el10_0.noarch.rpm;name=aarch64_rust-option-ext+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-option-ext+default-devel}"
SRC_URI[aarch64_rust-option-ext+default-devel.sha256sum] = "f6620286995b646be450ec0e1fbe54ec22e04fcfeba9ea7048bdec8881787d79"

URI_aarch64_rust-option-ext-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-option-ext-devel-0.2.0-4.el10_0.noarch.rpm;name=aarch64_rust-option-ext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-option-ext-devel}"
SRC_URI[aarch64_rust-option-ext-devel.sha256sum] = "7224162baaea021f943d56e104e4a6aab8e8a4e82d8a405f1b7b4e6e536ebbd0"

RDEPENDS:rust-option-ext+default-devel = " \
 cargo \
 rust-option-ext-devel \
 "
RDEPENDS:rust-option-ext-devel = " \
 cargo \
 "
