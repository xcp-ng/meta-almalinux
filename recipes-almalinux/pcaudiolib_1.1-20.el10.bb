# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pcaudiolib"
PV = "1.1"
PR = "20.el10"
PACKAGES = " \
 pcaudiolib \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pcaudiolib-1.1-20.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "759bb0ccb30000ee13425e67b77f9838138a5e0525a40ffa8608292822ee099b"

URI_x86_64_v2_pcaudiolib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcaudiolib-1.1-20.el10.x86_64_v2.rpm;name=x86_64_v2_pcaudiolib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcaudiolib}"
SRC_URI[x86_64_v2_pcaudiolib.sha256sum] = "2c54b2f7204c22e8c21e447ae0f5eb7dfbef246ede11a46d9b5ab4b144bbe839"

URI_aarch64_pcaudiolib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcaudiolib-1.1-20.el10.aarch64.rpm;name=aarch64_pcaudiolib;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcaudiolib}"
SRC_URI[aarch64_pcaudiolib.sha256sum] = "7e2eee02f7c5c3bc40a4b8dead06ccc3b28d9a92e242712b4977ba3d300a3e89"

RDEPENDS:pcaudiolib = " \
 alsa-lib \
 glibc \
 pulseaudio-libs \
 "
