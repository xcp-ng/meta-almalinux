# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fast_float"
PV = "6.1.6"
PR = "4.el10_0"
PACKAGES = " \
 fast_float-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fast_float-6.1.6-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1893fb977f53a7bc9a0f5fb3282929bb90ce44eac97af8f9614ed3f82b02c925"

URI_x86_64_v2_fast_float-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fast_float-devel-6.1.6-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fast_float-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fast_float-devel}"
SRC_URI[x86_64_v2_fast_float-devel.sha256sum] = "707cb68b7c538e621b986a44d6070ef1b0bb5944774b1462794c1e0428748b31"

URI_aarch64_fast_float-devel = "${EPEL_MIRROR}/aarch64/Packages/f/fast_float-devel-6.1.6-4.el10_0.noarch.rpm;name=aarch64_fast_float-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_fast_float-devel}"
SRC_URI[aarch64_fast_float-devel.sha256sum] = "33e5677f5bdfd247fc2ff81034ebab20c2e3a8e9454b044172ab3764a7cc07ee"

RDEPENDS:fast_float-devel = " \
 cmake-filesystem \
 "
