# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-scikit-learn"
PV = "1.6.1"
PR = "3.el10_0"
PACKAGES = " \
 python3-scikit-learn \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-scikit-learn-1.6.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f1b8e9950c95b379f704c6e02e17d1eaeabd590adf32e683fcb2078f03eaf9a"

URI_x86_64_v2_python3-scikit-learn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-scikit-learn-1.6.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-scikit-learn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-scikit-learn}"
SRC_URI[x86_64_v2_python3-scikit-learn.sha256sum] = "deca1583a7475441c193ce1cb83a4b74e4874d3ea2c73bc53da687fae55e4ba5"

URI_aarch64_python3-scikit-learn = "${EPEL_MIRROR}/aarch64/Packages/p/python3-scikit-learn-1.6.1-3.el10_0.aarch64.rpm;name=aarch64_python3-scikit-learn;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-scikit-learn}"
SRC_URI[aarch64_python3-scikit-learn.sha256sum] = "19d3f504291094c80cca41e306e59aead58578d0efc3868da000128f08e17229"

RDEPENDS:python3-scikit-learn = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 python3 \
 python3-joblib \
 python3-numpy \
 python3-scipy \
 python3-threadpoolctl \
 "
