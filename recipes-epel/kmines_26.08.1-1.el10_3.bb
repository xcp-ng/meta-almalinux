# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmines"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kmines \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kmines-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6c9bba860ffa5f3b2a978459620cc5b575998c3a7254a2eec0210c4e053700b0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmines-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmines;unpack=0"
SRC_URI[x86_64_v2_kmines.sha256sum] = "3da0583c2f56c6bc1fa0e152625c20fb9aa1f066617418b86a06633fd9ab7e71"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kmines-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kmines;unpack=0"
SRC_URI[aarch64_kmines.sha256sum] = "675896fd8a3344388eb78d77edd178d008db925b7c6bcb018eb6dad228a8bef8"

RDEPENDS:kmines = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
