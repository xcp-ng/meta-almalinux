# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sshguard"
PV = "2.5.1"
PR = "1.el10_1"
PACKAGES = " \
 sshguard \
 sshguard-firewalld \
 sshguard-iptables \
 sshguard-nftables \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sshguard-2.5.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce7ef9ec3e4eb1e519b34d96ae707ac8dc071cb5a9f07e68155b2e4f53fab0e8"

URI_x86_64_v2_sshguard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sshguard-2.5.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sshguard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sshguard}"
SRC_URI[x86_64_v2_sshguard.sha256sum] = "e43a522224071d4ef355f7e0ddc26e5089ee70c76fa1a4cce4c6f9ada7278668"

URI_x86_64_v2_sshguard-firewalld = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sshguard-firewalld-2.5.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sshguard-firewalld;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sshguard-firewalld}"
SRC_URI[x86_64_v2_sshguard-firewalld.sha256sum] = "c0b7eff52645da4d63e52c9bbd1f220b5d41ff59ead40b33be9de5130a567202"
RPROVIDES:sshguard-firewalld:x86_64_v2 = "virtual/sshguard-config_eq_2.5.1-1.el10_1.alma_altarch"

URI_x86_64_v2_sshguard-iptables = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sshguard-iptables-2.5.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sshguard-iptables;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sshguard-iptables}"
SRC_URI[x86_64_v2_sshguard-iptables.sha256sum] = "518151b02b47a27ec989c07813894e97dbeb7e528ce52b7020c2e8ad4bcdca8f"
RPROVIDES:sshguard-iptables:x86_64_v2 = "virtual/sshguard-config_eq_2.5.1-1.el10_1.alma_altarch"

URI_x86_64_v2_sshguard-nftables = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sshguard-nftables-2.5.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sshguard-nftables;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sshguard-nftables}"
SRC_URI[x86_64_v2_sshguard-nftables.sha256sum] = "b8c8b37da3abae1144f2dbd1f7c8a4214c8917469ebd7bc34a4a1dd92aa432f8"
RPROVIDES:sshguard-nftables:x86_64_v2 = "virtual/sshguard-config_eq_2.5.1-1.el10_1.alma_altarch"

URI_aarch64_sshguard = "${EPEL_MIRROR}/aarch64/Packages/s/sshguard-2.5.1-1.el10_1.aarch64.rpm;name=aarch64_sshguard;unpack=0"
SRC_URI:append = " ${URI_aarch64_sshguard}"
SRC_URI[aarch64_sshguard.sha256sum] = "edb25f8f2f6bd2ca7d1b84fdb9b8017c3b772ba14e31161104b581929cbea441"

URI_aarch64_sshguard-firewalld = "${EPEL_MIRROR}/aarch64/Packages/s/sshguard-firewalld-2.5.1-1.el10_1.aarch64.rpm;name=aarch64_sshguard-firewalld;unpack=0"
SRC_URI:append = " ${URI_aarch64_sshguard-firewalld}"
SRC_URI[aarch64_sshguard-firewalld.sha256sum] = "26f3b509f073a785822e6e09c2d633fe6e9dc8ed6b6213e1913570a33606e82e"
RPROVIDES:sshguard-firewalld:aarch64 = "virtual/sshguard-config_eq_2.5.1-1.el10_1"

URI_aarch64_sshguard-iptables = "${EPEL_MIRROR}/aarch64/Packages/s/sshguard-iptables-2.5.1-1.el10_1.aarch64.rpm;name=aarch64_sshguard-iptables;unpack=0"
SRC_URI:append = " ${URI_aarch64_sshguard-iptables}"
SRC_URI[aarch64_sshguard-iptables.sha256sum] = "a953b9820ed0d50d1e219ec669560a57ceef47053a166af547ebe0a3a59e2a46"
RPROVIDES:sshguard-iptables:aarch64 = "virtual/sshguard-config_eq_2.5.1-1.el10_1"

URI_aarch64_sshguard-nftables = "${EPEL_MIRROR}/aarch64/Packages/s/sshguard-nftables-2.5.1-1.el10_1.aarch64.rpm;name=aarch64_sshguard-nftables;unpack=0"
SRC_URI:append = " ${URI_aarch64_sshguard-nftables}"
SRC_URI[aarch64_sshguard-nftables.sha256sum] = "e62fd7423838387a40690ba2bd9f1621499db59ac668dac4bcc346ced9cfd036"
RPROVIDES:sshguard-nftables:aarch64 = "virtual/sshguard-config_eq_2.5.1-1.el10_1"

RDEPENDS:sshguard:x86_64_v2 = " \
 bash \
 glibc \
 grep \
 systemd \
 virtual/coreutils \
 virtual/sshguard-config_eq_2.5.1-1.el10_1.alma_altarch \
"
RDEPENDS:sshguard:aarch64 = " \
 bash \
 glibc \
 grep \
 systemd \
 virtual/coreutils \
 virtual/sshguard-config_eq_2.5.1-1.el10_1 \
"
RDEPENDS:sshguard-firewalld = " \
 firewalld \
 ipset \
 sshguard \
 "
RDEPENDS:sshguard-iptables = " \
 bash \
 iptables-nft-services \
 sshguard \
 "
RDEPENDS:sshguard-nftables = " \
 nftables \
 sshguard \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/sshguard-config_eq_2.5.1-1.el10_1.alma_altarch"

PROVIDES:append:aarch64 = " rpm/virtual/sshguard-config_eq_2.5.1-1.el10_1"
