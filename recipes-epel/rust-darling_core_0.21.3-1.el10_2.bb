# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-darling_core"
PV = "0.21.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-darling_core+default-devel \
 rust-darling_core+diagnostics-devel \
 rust-darling_core+serde-devel \
 rust-darling_core+strsim-devel \
 rust-darling_core+suggestions-devel \
 rust-darling_core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-darling_core-0.21.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "39044d380664048077c59b52d409294bc80055c955f06af705ba830f67bce76d"

URI_x86_64_v2_rust-darling_core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling_core+default-devel-0.21.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling_core+default-devel}"
SRC_URI[x86_64_v2_rust-darling_core+default-devel.sha256sum] = "f7e855a4cf72b800149e724062c9594e46f13303c3290263f8e94bc707750ca8"

URI_x86_64_v2_rust-darling_core+diagnostics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling_core+diagnostics-devel-0.21.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling_core+diagnostics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling_core+diagnostics-devel}"
SRC_URI[x86_64_v2_rust-darling_core+diagnostics-devel.sha256sum] = "e9e75a3f53ed96aa97af6abf800454f038906314d97683ac387cd21f62540263"

URI_x86_64_v2_rust-darling_core+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling_core+serde-devel-0.21.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling_core+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling_core+serde-devel}"
SRC_URI[x86_64_v2_rust-darling_core+serde-devel.sha256sum] = "21f871ef85072739d018385445769e36ae897714d337402d2358459096d591b9"

URI_x86_64_v2_rust-darling_core+strsim-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling_core+strsim-devel-0.21.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling_core+strsim-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling_core+strsim-devel}"
SRC_URI[x86_64_v2_rust-darling_core+strsim-devel.sha256sum] = "61da7d0228d9b68349be0d0b08236f4de6531446097c5bdb12632c25aab1bd91"

URI_x86_64_v2_rust-darling_core+suggestions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling_core+suggestions-devel-0.21.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling_core+suggestions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling_core+suggestions-devel}"
SRC_URI[x86_64_v2_rust-darling_core+suggestions-devel.sha256sum] = "7adab781598207528ae3cf0e66538fca322d7ebe67b8f1009d25258df7d05ac8"

URI_x86_64_v2_rust-darling_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling_core-devel-0.21.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling_core-devel}"
SRC_URI[x86_64_v2_rust-darling_core-devel.sha256sum] = "d45573b87165848221fbe8d005c9a9a0a1faa9c9fbcd34da315b240a9a6a84eb"

URI_aarch64_rust-darling_core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling_core+default-devel-0.21.3-1.el10_2.noarch.rpm;name=aarch64_rust-darling_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling_core+default-devel}"
SRC_URI[aarch64_rust-darling_core+default-devel.sha256sum] = "9f9bdf9c9009200e2dffa1160751e33de5fb82b1ca01ef86f20215b925ebba31"

URI_aarch64_rust-darling_core+diagnostics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling_core+diagnostics-devel-0.21.3-1.el10_2.noarch.rpm;name=aarch64_rust-darling_core+diagnostics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling_core+diagnostics-devel}"
SRC_URI[aarch64_rust-darling_core+diagnostics-devel.sha256sum] = "04ad675cf55e104f950b421e5928baf5a0a06e605b1cbde20fd35ae866bf5c08"

URI_aarch64_rust-darling_core+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling_core+serde-devel-0.21.3-1.el10_2.noarch.rpm;name=aarch64_rust-darling_core+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling_core+serde-devel}"
SRC_URI[aarch64_rust-darling_core+serde-devel.sha256sum] = "70b146912d7b5ee5c391ba85e46f78fa238963bef296806b9cbf0b030c65415c"

URI_aarch64_rust-darling_core+strsim-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling_core+strsim-devel-0.21.3-1.el10_2.noarch.rpm;name=aarch64_rust-darling_core+strsim-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling_core+strsim-devel}"
SRC_URI[aarch64_rust-darling_core+strsim-devel.sha256sum] = "8e120afdb0ab7a88edfdc9cfa0f9c60666058150d8c9f940897893bf8ded5c9b"

URI_aarch64_rust-darling_core+suggestions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling_core+suggestions-devel-0.21.3-1.el10_2.noarch.rpm;name=aarch64_rust-darling_core+suggestions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling_core+suggestions-devel}"
SRC_URI[aarch64_rust-darling_core+suggestions-devel.sha256sum] = "77e504f4d3736b6d83aac291cbcf18e342faf61a5f741978b9070cf67408bb9a"

URI_aarch64_rust-darling_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling_core-devel-0.21.3-1.el10_2.noarch.rpm;name=aarch64_rust-darling_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling_core-devel}"
SRC_URI[aarch64_rust-darling_core-devel.sha256sum] = "755768924064bff12e9c66b8c90020a343d7b8fbda36dcbc0e79524a54189588"

RDEPENDS:rust-darling_core+default-devel = " \
 cargo \
 rust-darling_core-devel \
 "
RDEPENDS:rust-darling_core+diagnostics-devel = " \
 cargo \
 rust-darling_core-devel \
 "
RDEPENDS:rust-darling_core+serde-devel = " \
 cargo \
 rust-darling_core-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-darling_core+strsim-devel = " \
 cargo \
 rust-darling_core-devel \
 rust-strsim+default-devel \
 "
RDEPENDS:rust-darling_core+suggestions-devel = " \
 cargo \
 rust-darling_core+strsim-devel \
 rust-darling_core-devel \
 "
RDEPENDS:rust-darling_core-devel = " \
 cargo \
 rust \
 rust-fnv+default-devel \
 rust-ident_case+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 "
