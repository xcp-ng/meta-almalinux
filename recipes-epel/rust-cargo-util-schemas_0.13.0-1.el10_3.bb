# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-util-schemas"
PV = "0.13.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-cargo-util-schemas+default-devel \
 rust-cargo-util-schemas-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-util-schemas-0.13.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "01f11fe58700a6434c900c44a4856a30dcb70fc405fc8a5341fa818ee08d33c0"

URI_x86_64_v2_rust-cargo-util-schemas+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-util-schemas+default-devel-0.13.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-util-schemas+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-util-schemas+default-devel}"
SRC_URI[x86_64_v2_rust-cargo-util-schemas+default-devel.sha256sum] = "51b4cf40b401dcf8c3cfc207167b042668ba3b8bbb629a51f3b4a11970b2bd5b"

URI_x86_64_v2_rust-cargo-util-schemas-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-util-schemas-devel-0.13.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-util-schemas-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-util-schemas-devel}"
SRC_URI[x86_64_v2_rust-cargo-util-schemas-devel.sha256sum] = "436b50dd6d74786c67525a4f29b4ddc5aa5078755fad28f165fca5bab69d210a"

URI_aarch64_rust-cargo-util-schemas+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-util-schemas+default-devel-0.13.0-1.el10_3.noarch.rpm;name=aarch64_rust-cargo-util-schemas+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-util-schemas+default-devel}"
SRC_URI[aarch64_rust-cargo-util-schemas+default-devel.sha256sum] = "f0dd055efc340179509c2d76a88e96d764be1e0caba04212de23f07adc31c9e1"

URI_aarch64_rust-cargo-util-schemas-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-util-schemas-devel-0.13.0-1.el10_3.noarch.rpm;name=aarch64_rust-cargo-util-schemas-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-util-schemas-devel}"
SRC_URI[aarch64_rust-cargo-util-schemas-devel.sha256sum] = "39afa075e7d91c29ee8771ab7a3601c3f1e647335d4ac5a5a9cd672386462c62"

RDEPENDS:rust-cargo-util-schemas+default-devel = " \
 cargo \
 rust-cargo-util-schemas-devel \
 "
RDEPENDS:rust-cargo-util-schemas-devel = " \
 cargo \
 rust \
 rust-jiff+serde-devel \
 rust-jiff+std-devel \
 rust-jiff-devel \
 rust-semver+default-devel \
 rust-semver+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde-untagged+default-devel \
 rust-serde-value+default-devel \
 rust-thiserror+default-devel \
 rust-toml0.9+serde-devel \
 rust-toml0.9-devel \
 rust-unicode-ident+default-devel \
 rust-url+default-devel \
 "
