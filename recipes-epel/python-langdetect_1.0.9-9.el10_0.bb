# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-langdetect"
PV = "1.0.9"
PR = "9.el10_0"
PACKAGES = " \
 python3-langdetect \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-langdetect-1.0.9-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "01746f7d95e3eb51a12afb426a04e2414dc6c884b1c93bd7db9eb724c64ac311"

URI_x86_64_v2_python3-langdetect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-langdetect-1.0.9-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-langdetect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-langdetect}"
SRC_URI[x86_64_v2_python3-langdetect.sha256sum] = "b3af547416031c3e06d229e74052cb129d94eca2def040e64e89c118bf1c741b"

URI_aarch64_python3-langdetect = "${EPEL_MIRROR}/aarch64/Packages/p/python3-langdetect-1.0.9-9.el10_0.noarch.rpm;name=aarch64_python3-langdetect;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-langdetect}"
SRC_URI[aarch64_python3-langdetect.sha256sum] = "acffbe3b910081dd398af0590ba6b2e4cd5e52c389415c97d7a652c25a0ca0b7"

RDEPENDS:python3-langdetect = " \
 python3 \
 python3-six \
 "
