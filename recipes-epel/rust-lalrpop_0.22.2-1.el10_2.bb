# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lalrpop"
PV = "0.22.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-lalrpop+default-devel \
 rust-lalrpop+lexer-devel \
 rust-lalrpop+unicode-devel \
 rust-lalrpop-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lalrpop-0.22.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7dc3971ce4810582cfc8392ed97fbf01100dc9d757845ad747df7482f0b82ff8"

URI_x86_64_v2_rust-lalrpop+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lalrpop+default-devel-0.22.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lalrpop+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lalrpop+default-devel}"
SRC_URI[x86_64_v2_rust-lalrpop+default-devel.sha256sum] = "de34190c22362929bf598eff8369d6ed6f055c0bd3746387b23b66f7681e1134"

URI_x86_64_v2_rust-lalrpop+lexer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lalrpop+lexer-devel-0.22.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lalrpop+lexer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lalrpop+lexer-devel}"
SRC_URI[x86_64_v2_rust-lalrpop+lexer-devel.sha256sum] = "fa9edc1695704eca8cce4201451bd867a485b91221390f2449186fe47f5c3a86"

URI_x86_64_v2_rust-lalrpop+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lalrpop+unicode-devel-0.22.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lalrpop+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lalrpop+unicode-devel}"
SRC_URI[x86_64_v2_rust-lalrpop+unicode-devel.sha256sum] = "e91817de7a83b575b5077beeed3c9ef2f25a0825dd4621a1bc7b2ecb2e9cd62f"

URI_x86_64_v2_rust-lalrpop-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lalrpop-devel-0.22.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lalrpop-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lalrpop-devel}"
SRC_URI[x86_64_v2_rust-lalrpop-devel.sha256sum] = "89c519440eddd3575fc9e75a9b44bc5562c9866d9cbe02edbf1497d035c7618d"

URI_aarch64_rust-lalrpop+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lalrpop+default-devel-0.22.2-1.el10_2.noarch.rpm;name=aarch64_rust-lalrpop+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lalrpop+default-devel}"
SRC_URI[aarch64_rust-lalrpop+default-devel.sha256sum] = "81b0e8d432dddeae2531cf134e9eb4c59b97041410e5264604aecdd5be3f0865"

URI_aarch64_rust-lalrpop+lexer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lalrpop+lexer-devel-0.22.2-1.el10_2.noarch.rpm;name=aarch64_rust-lalrpop+lexer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lalrpop+lexer-devel}"
SRC_URI[aarch64_rust-lalrpop+lexer-devel.sha256sum] = "bf46708c1ae560dddc7213264c95fdc81a81f6b47b9478a0dc064986e5fa616a"

URI_aarch64_rust-lalrpop+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lalrpop+unicode-devel-0.22.2-1.el10_2.noarch.rpm;name=aarch64_rust-lalrpop+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lalrpop+unicode-devel}"
SRC_URI[aarch64_rust-lalrpop+unicode-devel.sha256sum] = "ca51b8788af07805b159920e0e757350a6669252174fbaa984d25d279f47fc5b"

URI_aarch64_rust-lalrpop-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lalrpop-devel-0.22.2-1.el10_2.noarch.rpm;name=aarch64_rust-lalrpop-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lalrpop-devel}"
SRC_URI[aarch64_rust-lalrpop-devel.sha256sum] = "848db4c26497aeac04c8da1e8e6cdeb35fc45e892be4a73b579cd010aed9fa5c"

RDEPENDS:rust-lalrpop+default-devel = " \
 cargo \
 rust-lalrpop+lexer-devel \
 rust-lalrpop+unicode-devel \
 rust-lalrpop-devel \
 "
RDEPENDS:rust-lalrpop+lexer-devel = " \
 cargo \
 rust-lalrpop-devel \
 rust-lalrpop-util+lexer-devel \
 rust-lalrpop-util+std-devel \
 "
RDEPENDS:rust-lalrpop+unicode-devel = " \
 cargo \
 rust-lalrpop-devel \
 rust-lalrpop-util+unicode-devel \
 rust-regex+unicode-devel \
 rust-regex-syntax+unicode-devel \
 "
RDEPENDS:rust-lalrpop-devel = " \
 cargo \
 rust \
 rust-ascii-canvas-devel \
 rust-bit-set-devel \
 rust-ena-devel \
 rust-itertools+use_std-devel \
 rust-itertools-devel \
 rust-lalrpop-util-devel \
 rust-petgraph0.7-devel \
 rust-regex+std-devel \
 rust-regex-devel \
 rust-regex-syntax-devel \
 rust-sha3-devel \
 rust-string_cache-devel \
 rust-term-devel \
 rust-unicode-xid-devel \
 rust-walkdir+default-devel \
 "
