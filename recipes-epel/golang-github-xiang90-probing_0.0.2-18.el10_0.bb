# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-xiang90-probing"
PV = "0.0.2"
PR = "18.el10_0"
PACKAGES = " \
 golang-github-xiang90-probing-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-xiang90-probing-0.0.2-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8371c78ec8acf4bdbac0650a9c381e7e42832999d5ce467a008e257479018809"

URI_x86_64_v2_golang-github-xiang90-probing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-xiang90-probing-devel-0.0.2-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-xiang90-probing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-xiang90-probing-devel}"
SRC_URI[x86_64_v2_golang-github-xiang90-probing-devel.sha256sum] = "7740de73e9887726536905997d429b718b5c13c03aba9398b5c333602ef5027b"

URI_aarch64_golang-github-xiang90-probing-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-xiang90-probing-devel-0.0.2-18.el10_0.noarch.rpm;name=aarch64_golang-github-xiang90-probing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-xiang90-probing-devel}"
SRC_URI[aarch64_golang-github-xiang90-probing-devel.sha256sum] = "de2949e0ca064e23763c7baff13a1097a83859aa210d4c17915af8889c301ca9"

RDEPENDS:golang-github-xiang90-probing-devel = " \
 go-filesystem \
 "
