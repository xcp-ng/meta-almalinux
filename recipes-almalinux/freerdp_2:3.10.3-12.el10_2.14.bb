# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "freerdp"
PE = "2"
PV = "3.10.3"
PR = "12.el10_2.14"
PACKAGES = " \
 freerdp \
 freerdp-devel \
 freerdp-libs \
 freerdp-server \
 libwinpr \
 libwinpr-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/freerdp-3.10.3-12.el10_2.14.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "421bf0a1c661d479b37d10b93b6efc01be9259b129b8150edeff2f58e5d6c10a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freerdp-3.10.3-12.el10_2.14.x86_64_v2.rpm;name=x86_64_v2_freerdp;unpack=0"
SRC_URI[x86_64_v2_freerdp.sha256sum] = "cb5ff540c701fb7c98467e47e5444abccb3528eebb87075d22f82428404239fe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/freerdp-devel-3.10.3-12.el10_2.14.x86_64_v2.rpm;name=x86_64_v2_freerdp-devel;unpack=0"
SRC_URI[x86_64_v2_freerdp-devel.sha256sum] = "13f3c5670b3816938bc100bfe138440073dc95bb8d2b76c35c1280dce0496828"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freerdp-libs-3.10.3-12.el10_2.14.x86_64_v2.rpm;name=x86_64_v2_freerdp-libs;unpack=0"
SRC_URI[x86_64_v2_freerdp-libs.sha256sum] = "add80044a58d2aa8952a06291a66e337500e1356aed354dbfc4ef2730450c07d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/freerdp-server-3.10.3-12.el10_2.14.x86_64_v2.rpm;name=x86_64_v2_freerdp-server;unpack=0"
SRC_URI[x86_64_v2_freerdp-server.sha256sum] = "32943e9f68f5448f7499899d9ece325e372cd0229def7dc9df56713f9d70c13d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libwinpr-3.10.3-12.el10_2.14.x86_64_v2.rpm;name=x86_64_v2_libwinpr;unpack=0"
SRC_URI[x86_64_v2_libwinpr.sha256sum] = "bf2d015f31a1f6a382560140edb3ecbc850462d97e9f9899e98c0e7d8f5b6716"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libwinpr-devel-3.10.3-12.el10_2.14.x86_64_v2.rpm;name=x86_64_v2_libwinpr-devel;unpack=0"
SRC_URI[x86_64_v2_libwinpr-devel.sha256sum] = "e55d4c0ac0b9fa7fd00aca64019e8f206d07c6e2d0d77963ca6a0e7e58cb3624"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freerdp-3.10.3-12.el10_2.14.aarch64.rpm;name=aarch64_freerdp;unpack=0"
SRC_URI[aarch64_freerdp.sha256sum] = "06977562df0bdc4f404fb309518b2ceeae5de60322303d6253d1587feba95a90"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/freerdp-devel-3.10.3-12.el10_2.14.aarch64.rpm;name=aarch64_freerdp-devel;unpack=0"
SRC_URI[aarch64_freerdp-devel.sha256sum] = "f7bbbb7e0c37bd4812ab63eff819620b41dc7feeada5e85c9a77bb774b3fd80a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freerdp-libs-3.10.3-12.el10_2.14.aarch64.rpm;name=aarch64_freerdp-libs;unpack=0"
SRC_URI[aarch64_freerdp-libs.sha256sum] = "50dd7ef6804b664f59397efc9ee9cccc073c0e56cca0c5b8d0791b5490ecf9d0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/freerdp-server-3.10.3-12.el10_2.14.aarch64.rpm;name=aarch64_freerdp-server;unpack=0"
SRC_URI[aarch64_freerdp-server.sha256sum] = "d57d59c458761e6c2500bb3999a17bc6ee5907ad3d3a4d7144d4157d18b471cd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libwinpr-3.10.3-12.el10_2.14.aarch64.rpm;name=aarch64_libwinpr;unpack=0"
SRC_URI[aarch64_libwinpr.sha256sum] = "faa4e0cd66ede292f59a944252b259a0c1648b9a5c79e52521933fe6dd548079"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libwinpr-devel-3.10.3-12.el10_2.14.aarch64.rpm;name=aarch64_libwinpr-devel;unpack=0"
SRC_URI[aarch64_libwinpr-devel.sha256sum] = "386e37e55da6aa3213dd9949b63200820a77e47b613c1447b419b9dee299ea6a"

RDEPENDS:freerdp = " \
 freerdp-libs \
 glibc \
 libX11 \
 libXcursor \
 libXext \
 libXfixes \
 libXi \
 libXinerama \
 libXrandr \
 libXrender \
 libwayland-client \
 libwayland-cursor \
 libwinpr \
 libxkbcommon \
 "
RDEPENDS:freerdp-devel = " \
 cmake \
 cmake-filesystem \
 freerdp-devel \
 freerdp-libs \
 libwinpr-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:freerdp-libs = " \
 alsa-lib \
 cairo \
 cups-libs \
 fdk-aac-free \
 fuse3-libs \
 glibc \
 gsm \
 lame-libs \
 libX11 \
 libXdamage \
 libXext \
 libXfixes \
 libXinerama \
 libXtst \
 libgcc \
 libstdc++ \
 libusb1 \
 libwinpr \
 libxkbfile \
 openssl-libs \
 opus \
 pam-libs \
 pulseaudio-libs \
 zlib-ng-compat \
 "
RDEPENDS:freerdp-server = " \
 freerdp-libs \
 glibc \
 libwinpr \
 "
RDEPENDS:libwinpr = " \
 glibc \
 json-c \
 krb5-libs \
 libcom_err \
 libgcc \
 libicu \
 libjpeg-turbo \
 libpng \
 libwebp \
 openssl-libs \
 "
RDEPENDS:libwinpr-devel = " \
 cmake \
 cmake-filesystem \
 libwinpr \
 libwinpr-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
