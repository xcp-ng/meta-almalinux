# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-SharedFork"
PV = "0.35"
PR = "28.el10_0"
PACKAGES = " \
 perl-Test-SharedFork \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Test-SharedFork-0.35-28.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f034b0cd3d08831ab6dbb87070e518b1c6438cfc17b630c6bb5bf61dfaba7281"

URI_x86_64_v2_perl-Test-SharedFork = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-SharedFork-0.35-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-SharedFork;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-SharedFork}"
SRC_URI[x86_64_v2_perl-Test-SharedFork.sha256sum] = "a5cfba8b9de638c9598d48a247d570c967ec6637c8832a68c11c8c0f855b1eb8"

URI_aarch64_perl-Test-SharedFork = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-SharedFork-0.35-28.el10_0.noarch.rpm;name=aarch64_perl-Test-SharedFork;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-SharedFork}"
SRC_URI[aarch64_perl-Test-SharedFork.sha256sum] = "3cab1d58383bc52627ad5843e67e28c22d661bb4c1e900b04c66e0aeb7da4862"

RDEPENDS:perl-Test-SharedFork = " \
 perl-Fcntl \
 perl-File-Temp \
 perl-IO \
 perl-Storable \
 perl-Test-Simple \
 perl-Tie \
 perl-base \
 perl-libs \
 "
