# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-network-uri"
PV = "2.6.4.2"
PR = "9.el10_0"
PACKAGES = " \
 ghc-network-uri \
 ghc-network-uri-devel \
 ghc-network-uri-doc \
 ghc-network-uri-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-network-uri-2.6.4.2-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4250c120023433ea00ca1f32e29add3016598a8086ca7f37a25b800efcd27be6"

URI_x86_64_v2_ghc-network-uri = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-network-uri-2.6.4.2-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-network-uri;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-network-uri}"
SRC_URI[x86_64_v2_ghc-network-uri.sha256sum] = "94283472700c74d44c43affb988c54be64247bae3961e5e67fa756fff811f1e6"

URI_x86_64_v2_ghc-network-uri-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-network-uri-devel-2.6.4.2-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-network-uri-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-network-uri-devel}"
SRC_URI[x86_64_v2_ghc-network-uri-devel.sha256sum] = "20e38d26f4a246166f5c7229d6871e9cb83899a173b10d8ec7a32be25d445c75"

URI_x86_64_v2_ghc-network-uri-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-network-uri-doc-2.6.4.2-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-network-uri-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-network-uri-doc}"
SRC_URI[x86_64_v2_ghc-network-uri-doc.sha256sum] = "66b1faacd01053997663c5cb0087b27ae8e7101b07348a6392605e129a746e77"

URI_x86_64_v2_ghc-network-uri-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-network-uri-prof-2.6.4.2-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-network-uri-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-network-uri-prof}"
SRC_URI[x86_64_v2_ghc-network-uri-prof.sha256sum] = "0da05934ba13082a42a3689150e57bdf6bcc828c7689bd1c74e976a84d0e2152"

URI_aarch64_ghc-network-uri = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-network-uri-2.6.4.2-9.el10_0.aarch64.rpm;name=aarch64_ghc-network-uri;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-network-uri}"
SRC_URI[aarch64_ghc-network-uri.sha256sum] = "30325864606f8419181e2d2f8672288f53f90a7dc8e0216d071cca628cb7bba0"

URI_aarch64_ghc-network-uri-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-network-uri-devel-2.6.4.2-9.el10_0.aarch64.rpm;name=aarch64_ghc-network-uri-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-network-uri-devel}"
SRC_URI[aarch64_ghc-network-uri-devel.sha256sum] = "2f4e0b5e0d133d7bf7c87873990376796361160655f5bf81e8582ada8fa7f677"

URI_aarch64_ghc-network-uri-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-network-uri-doc-2.6.4.2-9.el10_0.noarch.rpm;name=aarch64_ghc-network-uri-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-network-uri-doc}"
SRC_URI[aarch64_ghc-network-uri-doc.sha256sum] = "ded70a9a9955fcb60ab8b42883f646597f9e0e4781cfdb610451e82842257c66"

URI_aarch64_ghc-network-uri-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-network-uri-prof-2.6.4.2-9.el10_0.aarch64.rpm;name=aarch64_ghc-network-uri-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-network-uri-prof}"
SRC_URI[aarch64_ghc-network-uri-prof.sha256sum] = "0b2b6db77b66422d3063858bb3c45350f907d569a2b3504ba0a889208e687dfc"

RDEPENDS:ghc-network-uri = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-parsec \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 ghc-th-compat \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-network-uri-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-network-uri \
 ghc-parsec-devel \
 ghc-template-haskell-devel \
 ghc-th-compat-devel \
 "
RDEPENDS:ghc-network-uri-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-network-uri-prof = " \
 ghc-base-prof \
 ghc-deepseq-prof \
 ghc-network-uri-devel \
 ghc-parsec-prof \
 ghc-template-haskell-prof \
 ghc-th-compat-prof \
 "
