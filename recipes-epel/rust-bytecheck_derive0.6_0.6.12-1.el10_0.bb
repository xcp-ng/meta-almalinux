# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bytecheck_derive0.6"
PV = "0.6.12"
PR = "1.el10_0"
PACKAGES = " \
 rust-bytecheck_derive0.6+default-devel \
 rust-bytecheck_derive0.6+std-devel \
 rust-bytecheck_derive0.6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bytecheck_derive0.6-0.6.12-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8bc466002468bf3e6cfe78af2535858bdfc7cf422b5299defcda7dba664a065f"

URI_x86_64_v2_rust-bytecheck_derive0.6+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecheck_derive0.6+default-devel-0.6.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecheck_derive0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecheck_derive0.6+default-devel}"
SRC_URI[x86_64_v2_rust-bytecheck_derive0.6+default-devel.sha256sum] = "843663bca3987d6382370ad2ed669ed8c4c448dacb2eb811ab592ad7b0a6e2f8"

URI_x86_64_v2_rust-bytecheck_derive0.6+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecheck_derive0.6+std-devel-0.6.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecheck_derive0.6+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecheck_derive0.6+std-devel}"
SRC_URI[x86_64_v2_rust-bytecheck_derive0.6+std-devel.sha256sum] = "388da75b27279619f180c300d344f96a955aaaea05d9814f1c7a2000c93069f3"

URI_x86_64_v2_rust-bytecheck_derive0.6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecheck_derive0.6-devel-0.6.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecheck_derive0.6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecheck_derive0.6-devel}"
SRC_URI[x86_64_v2_rust-bytecheck_derive0.6-devel.sha256sum] = "243e6fc9c1c2ccc24b7ae9b199d1a3990a39498e49f4a67a91edc91e6141bf23"

URI_aarch64_rust-bytecheck_derive0.6+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecheck_derive0.6+default-devel-0.6.12-1.el10_0.noarch.rpm;name=aarch64_rust-bytecheck_derive0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecheck_derive0.6+default-devel}"
SRC_URI[aarch64_rust-bytecheck_derive0.6+default-devel.sha256sum] = "5bcff1a5faea281b624d3bcc80aa25516d7b6ad2c730836dda75032fb5154d5a"

URI_aarch64_rust-bytecheck_derive0.6+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecheck_derive0.6+std-devel-0.6.12-1.el10_0.noarch.rpm;name=aarch64_rust-bytecheck_derive0.6+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecheck_derive0.6+std-devel}"
SRC_URI[aarch64_rust-bytecheck_derive0.6+std-devel.sha256sum] = "b6b0af0847114d30b43bd2fd01cae034e284eae5b70fa7015746d670823112bf"

URI_aarch64_rust-bytecheck_derive0.6-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecheck_derive0.6-devel-0.6.12-1.el10_0.noarch.rpm;name=aarch64_rust-bytecheck_derive0.6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecheck_derive0.6-devel}"
SRC_URI[aarch64_rust-bytecheck_derive0.6-devel.sha256sum] = "2d0ef25187ed99eac3c2e9a53e8532533ac0e949b9d1456bea600129015e229b"

RDEPENDS:rust-bytecheck_derive0.6+default-devel = " \
 cargo \
 rust-bytecheck_derive0.6+std-devel \
 rust-bytecheck_derive0.6-devel \
 "
RDEPENDS:rust-bytecheck_derive0.6+std-devel = " \
 cargo \
 rust-bytecheck_derive0.6-devel \
 "
RDEPENDS:rust-bytecheck_derive0.6-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn1+default-devel \
 "
