# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-manyhow"
PV = "0.11.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-manyhow+darling-devel \
 rust-manyhow+darling_core-devel \
 rust-manyhow+default-devel \
 rust-manyhow+macros-devel \
 rust-manyhow+syn-devel \
 rust-manyhow+syn1-devel \
 rust-manyhow+syn2-devel \
 rust-manyhow-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-manyhow-0.11.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c32086491abe8b71939eda99cad19bdc77feb6e1fd479c4eebeb323fd6b4cfb"

URI_x86_64_v2_rust-manyhow+darling-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-manyhow+darling-devel-0.11.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-manyhow+darling-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-manyhow+darling-devel}"
SRC_URI[x86_64_v2_rust-manyhow+darling-devel.sha256sum] = "b6f9c8d40fb6d44dee5038480e46a6eecbd4fe972cd0d117f6ea9e24d3f86682"

URI_x86_64_v2_rust-manyhow+darling_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-manyhow+darling_core-devel-0.11.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-manyhow+darling_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-manyhow+darling_core-devel}"
SRC_URI[x86_64_v2_rust-manyhow+darling_core-devel.sha256sum] = "d820da98d8f35567483ae15a247ee742d2e6ea44de2d77ec79a30dc4b1a4ac9d"

URI_x86_64_v2_rust-manyhow+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-manyhow+default-devel-0.11.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-manyhow+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-manyhow+default-devel}"
SRC_URI[x86_64_v2_rust-manyhow+default-devel.sha256sum] = "86cf3d69241668739b15c317580ae1ca8669928a82b886b432d29fd43ad5b4ac"

URI_x86_64_v2_rust-manyhow+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-manyhow+macros-devel-0.11.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-manyhow+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-manyhow+macros-devel}"
SRC_URI[x86_64_v2_rust-manyhow+macros-devel.sha256sum] = "31ce8f0749524da24cf0ae4ba09d28a831ee93ea41174121b83ada3adecec886"

URI_x86_64_v2_rust-manyhow+syn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-manyhow+syn-devel-0.11.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-manyhow+syn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-manyhow+syn-devel}"
SRC_URI[x86_64_v2_rust-manyhow+syn-devel.sha256sum] = "39da751cbc0ec4830a8ac36ef4f11c91be9ec7262ed3a55d8b1db6b343b2d128"

URI_x86_64_v2_rust-manyhow+syn1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-manyhow+syn1-devel-0.11.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-manyhow+syn1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-manyhow+syn1-devel}"
SRC_URI[x86_64_v2_rust-manyhow+syn1-devel.sha256sum] = "d8077dfb131b0442a61c15fd86cc09765a6308f3b6c4351baa8c065ae27d7671"

URI_x86_64_v2_rust-manyhow+syn2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-manyhow+syn2-devel-0.11.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-manyhow+syn2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-manyhow+syn2-devel}"
SRC_URI[x86_64_v2_rust-manyhow+syn2-devel.sha256sum] = "0d8771db458183209a75d07bff7601c43d4cc3d56ed794662c86c4c09a56b8a3"

URI_x86_64_v2_rust-manyhow-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-manyhow-devel-0.11.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-manyhow-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-manyhow-devel}"
SRC_URI[x86_64_v2_rust-manyhow-devel.sha256sum] = "52cd9bd3e81ae4825db570f2058fd4220149774598cc82cfaf68a93cf1826967"

URI_aarch64_rust-manyhow+darling-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-manyhow+darling-devel-0.11.4-1.el10_2.noarch.rpm;name=aarch64_rust-manyhow+darling-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-manyhow+darling-devel}"
SRC_URI[aarch64_rust-manyhow+darling-devel.sha256sum] = "20b7f74d3a9f50f26e84579f26bff8319182c69e816f8213e7277688ebef2f6e"

URI_aarch64_rust-manyhow+darling_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-manyhow+darling_core-devel-0.11.4-1.el10_2.noarch.rpm;name=aarch64_rust-manyhow+darling_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-manyhow+darling_core-devel}"
SRC_URI[aarch64_rust-manyhow+darling_core-devel.sha256sum] = "760aac4bb9c3eba7aa95758d66bac5dc99af9531c0a2d09dcf0a94eeb474278f"

URI_aarch64_rust-manyhow+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-manyhow+default-devel-0.11.4-1.el10_2.noarch.rpm;name=aarch64_rust-manyhow+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-manyhow+default-devel}"
SRC_URI[aarch64_rust-manyhow+default-devel.sha256sum] = "60e1c306140595e126ca8f66fd7a7770c0daa589a97ff67de14cdb72bdb14e9f"

URI_aarch64_rust-manyhow+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-manyhow+macros-devel-0.11.4-1.el10_2.noarch.rpm;name=aarch64_rust-manyhow+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-manyhow+macros-devel}"
SRC_URI[aarch64_rust-manyhow+macros-devel.sha256sum] = "b1d34e165029940ee1944d15171ca70f1045d9f6079f73fdc8da7552ca0517a8"

URI_aarch64_rust-manyhow+syn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-manyhow+syn-devel-0.11.4-1.el10_2.noarch.rpm;name=aarch64_rust-manyhow+syn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-manyhow+syn-devel}"
SRC_URI[aarch64_rust-manyhow+syn-devel.sha256sum] = "9c0d24001ae18ba35972efab5df348f9edb3dfb9230322ee03f4fc67f39dc6bc"

URI_aarch64_rust-manyhow+syn1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-manyhow+syn1-devel-0.11.4-1.el10_2.noarch.rpm;name=aarch64_rust-manyhow+syn1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-manyhow+syn1-devel}"
SRC_URI[aarch64_rust-manyhow+syn1-devel.sha256sum] = "84d5101671ebd631ce88675aacffe751fe65fb6bd20e552ea00b311304f8443b"

URI_aarch64_rust-manyhow+syn2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-manyhow+syn2-devel-0.11.4-1.el10_2.noarch.rpm;name=aarch64_rust-manyhow+syn2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-manyhow+syn2-devel}"
SRC_URI[aarch64_rust-manyhow+syn2-devel.sha256sum] = "b81f9a8a696b6e812d37c65d1907d533b5b92bffb11ea763f937d2138d05efbc"

URI_aarch64_rust-manyhow-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-manyhow-devel-0.11.4-1.el10_2.noarch.rpm;name=aarch64_rust-manyhow-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-manyhow-devel}"
SRC_URI[aarch64_rust-manyhow-devel.sha256sum] = "623394b199a2b3f047392379cfd019b1549c09144e3dc32916eff288a518fae9"

RDEPENDS:rust-manyhow+darling-devel = " \
 cargo \
 rust-manyhow+darling_core-devel \
 rust-manyhow-devel \
 "
RDEPENDS:rust-manyhow+darling_core-devel = " \
 cargo \
 rust-darling_core0.20+default-devel \
 rust-manyhow-devel \
 "
RDEPENDS:rust-manyhow+default-devel = " \
 cargo \
 rust-manyhow+macros-devel \
 rust-manyhow+syn-devel \
 rust-manyhow-devel \
 "
RDEPENDS:rust-manyhow+macros-devel = " \
 cargo \
 rust-manyhow-devel \
 rust-manyhow-macros+default-devel \
 "
RDEPENDS:rust-manyhow+syn-devel = " \
 cargo \
 rust-manyhow+syn2-devel \
 rust-manyhow-devel \
 "
RDEPENDS:rust-manyhow+syn1-devel = " \
 cargo \
 rust-manyhow-devel \
 rust-syn1+printing-devel \
 rust-syn1-devel \
 "
RDEPENDS:rust-manyhow+syn2-devel = " \
 cargo \
 rust-manyhow-devel \
 rust-syn2+parsing-devel \
 rust-syn2+printing-devel \
 rust-syn2-devel \
 "
RDEPENDS:rust-manyhow-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 "
