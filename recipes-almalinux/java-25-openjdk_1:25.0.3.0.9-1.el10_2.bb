# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "java-25-openjdk"
PE = "1"
PV = "25.0.3.0.9"
PR = "1.el10_2"
PACKAGES = " \
 java-25-openjdk \
 java-25-openjdk-crypto-adapter \
 java-25-openjdk-crypto-adapter-fastdebug \
 java-25-openjdk-crypto-adapter-slowdebug \
 java-25-openjdk-demo \
 java-25-openjdk-demo-fastdebug \
 java-25-openjdk-demo-slowdebug \
 java-25-openjdk-devel \
 java-25-openjdk-devel-fastdebug \
 java-25-openjdk-devel-slowdebug \
 java-25-openjdk-fastdebug \
 java-25-openjdk-headless \
 java-25-openjdk-headless-fastdebug \
 java-25-openjdk-headless-slowdebug \
 java-25-openjdk-javadoc \
 java-25-openjdk-javadoc-zip \
 java-25-openjdk-jmods \
 java-25-openjdk-jmods-fastdebug \
 java-25-openjdk-jmods-slowdebug \
 java-25-openjdk-slowdebug \
 java-25-openjdk-src \
 java-25-openjdk-src-fastdebug \
 java-25-openjdk-src-slowdebug \
 java-25-openjdk-static-libs \
 java-25-openjdk-static-libs-fastdebug \
 java-25-openjdk-static-libs-slowdebug \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/java-25-openjdk-25.0.3.0.9-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f4915329edf15dcc67f44ccda1b96e70805cdd98877b99979bf255843cb93e5"

URI_x86_64_v2_java-25-openjdk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-25.0.3.0.9-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk}"
SRC_URI[x86_64_v2_java-25-openjdk.sha256sum] = "42efc6833ab60f9ca697dffb4354eff387b08130964f9dda2e8b72e727e9c58b"

URI_x86_64_v2_java-25-openjdk-crypto-adapter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-crypto-adapter-25.0.3.0.9-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-crypto-adapter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-crypto-adapter}"
SRC_URI[x86_64_v2_java-25-openjdk-crypto-adapter.sha256sum] = "18d60fefc68943528b952a012ca8e561b22d7aecc06b053f79540dddd3d1b148"

URI_x86_64_v2_java-25-openjdk-crypto-adapter-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-crypto-adapter-fastdebug-25.0.3.0.9-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-crypto-adapter-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-crypto-adapter-fastdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-crypto-adapter-fastdebug.sha256sum] = "acfa5374f2abab407f8b0d1e4aba513ea84c0891c8a011bf42359f14c9306358"

URI_x86_64_v2_java-25-openjdk-crypto-adapter-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-crypto-adapter-slowdebug-25.0.3.0.9-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-crypto-adapter-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-crypto-adapter-slowdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-crypto-adapter-slowdebug.sha256sum] = "a5592a1812eb377a9e67134d8dd8890845b62a4d99cb0c3e8b02a7815bc5da58"

URI_x86_64_v2_java-25-openjdk-demo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-demo-25.0.3.0.9-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-demo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-demo}"
SRC_URI[x86_64_v2_java-25-openjdk-demo.sha256sum] = "f41bfdb0d9b6119e824380d68e12848cd702651317ddff00dcf23dd29d95b6c0"

URI_x86_64_v2_java-25-openjdk-demo-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-demo-fastdebug-25.0.3.0.9-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-demo-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-demo-fastdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-demo-fastdebug.sha256sum] = "586b6d6155ffd81f46ccab65124f2c35d54e1cca59fb250d54405f3e5f3d9776"

URI_x86_64_v2_java-25-openjdk-demo-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-demo-slowdebug-25.0.3.0.9-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-demo-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-demo-slowdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-demo-slowdebug.sha256sum] = "ede6edf34b7610b99ccd5507c8a0282a6f2700eff6399be9367937db7eedbe54"

URI_x86_64_v2_java-25-openjdk-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-devel-25.0.3.0.9-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-devel}"
SRC_URI[x86_64_v2_java-25-openjdk-devel.sha256sum] = "bba71268f20ef627146e68347fa95b2437bbf94f4b2d5f881251d27c9b7e6083"

URI_x86_64_v2_java-25-openjdk-devel-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-devel-fastdebug-25.0.3.0.9-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-devel-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-devel-fastdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-devel-fastdebug.sha256sum] = "1dbf2c0bef9a453256e5b883c7c40d8b6ea579ac876f66cb2a5df2fe594605f6"

URI_x86_64_v2_java-25-openjdk-devel-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-devel-slowdebug-25.0.3.0.9-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-devel-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-devel-slowdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-devel-slowdebug.sha256sum] = "6209bc0a77770161dce83e23b38ceba90793b938b308578456b6972395c950f2"

URI_x86_64_v2_java-25-openjdk-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-fastdebug-25.0.3.0.9-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-fastdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-fastdebug.sha256sum] = "e67256c3916fce83a939ed3731e7c2f5b2014cc63c1288bdd5fb23e65b436a8b"

URI_x86_64_v2_java-25-openjdk-headless = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-headless-25.0.3.0.9-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-headless;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-headless}"
SRC_URI[x86_64_v2_java-25-openjdk-headless.sha256sum] = "fcc4bbd4e942e44229c9e05fa7d830cde368f78e251834fcf306e8af9d1414ac"
RPROVIDES:java-25-openjdk-headless:x86_64_v2 = "virtual/java-headless_or_java-21-headless_or_java-25-headless"

URI_x86_64_v2_java-25-openjdk-headless-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-headless-fastdebug-25.0.3.0.9-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-headless-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-headless-fastdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-headless-fastdebug.sha256sum] = "3b1b4b2f8bef09ba4016db73576fc9dadb664aec6b28b0e8d2f6c5b45e287d4e"

URI_x86_64_v2_java-25-openjdk-headless-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-headless-slowdebug-25.0.3.0.9-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-headless-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-headless-slowdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-headless-slowdebug.sha256sum] = "036c051b48dad48b03042f08f144b1d734abb2febe614d690170a5780e02a189"

URI_x86_64_v2_java-25-openjdk-javadoc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-javadoc-25.0.3.0.9-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-javadoc}"
SRC_URI[x86_64_v2_java-25-openjdk-javadoc.sha256sum] = "cdd7dc2db1e134e9fec0fda2fa396ca19d158125038280e455f1eac3ed1be682"

URI_x86_64_v2_java-25-openjdk-javadoc-zip = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-javadoc-zip-25.0.3.0.9-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-javadoc-zip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-javadoc-zip}"
SRC_URI[x86_64_v2_java-25-openjdk-javadoc-zip.sha256sum] = "355fe9bc1c7a027457b4dce16716430b484695e3f6e69f532d804e46edee3407"

URI_x86_64_v2_java-25-openjdk-jmods = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-jmods-25.0.3.0.9-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-jmods;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-jmods}"
SRC_URI[x86_64_v2_java-25-openjdk-jmods.sha256sum] = "597dab6c6699d422095e6c838a5ea414843897ba926d3c7acf402cd621004f1a"

URI_x86_64_v2_java-25-openjdk-jmods-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-jmods-fastdebug-25.0.3.0.9-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-jmods-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-jmods-fastdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-jmods-fastdebug.sha256sum] = "d3e5fae8d762d4f489a97c039c3fe08649293c7ae4b646230132e7a94e9b7b8f"

URI_x86_64_v2_java-25-openjdk-jmods-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-jmods-slowdebug-25.0.3.0.9-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-jmods-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-jmods-slowdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-jmods-slowdebug.sha256sum] = "7131a517b399492b4ce61fe841bdcf4b288ccc309af1b4938934667919632898"

URI_x86_64_v2_java-25-openjdk-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-slowdebug-25.0.3.0.9-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-slowdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-slowdebug.sha256sum] = "cd1829312971a17e1d69460e1538079bb60a3d7c1513327a535dc37031c670a8"

URI_x86_64_v2_java-25-openjdk-src = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-src-25.0.3.0.9-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-src;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-src}"
SRC_URI[x86_64_v2_java-25-openjdk-src.sha256sum] = "9c4cced8f0ca643d9049a61df6650e743839dd495c6ae4ab778d9a7e38fbc70f"

URI_x86_64_v2_java-25-openjdk-src-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-src-fastdebug-25.0.3.0.9-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-src-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-src-fastdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-src-fastdebug.sha256sum] = "fa41d1cf38760671e6faa40c3047edf4845a41d3ea3ba0845f7ff3c38550f05d"

URI_x86_64_v2_java-25-openjdk-src-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-src-slowdebug-25.0.3.0.9-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-src-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-src-slowdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-src-slowdebug.sha256sum] = "a16ea778df62cdfb1149745a2e84f3e153899ad48f4ddae89e26c1a0c2c301da"

URI_x86_64_v2_java-25-openjdk-static-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-static-libs-25.0.3.0.9-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-static-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-static-libs}"
SRC_URI[x86_64_v2_java-25-openjdk-static-libs.sha256sum] = "c481c1612d250af8a546602e59deac5eacba06790aa00bfa0278c9808f354f8d"

URI_x86_64_v2_java-25-openjdk-static-libs-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-static-libs-fastdebug-25.0.3.0.9-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-static-libs-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-static-libs-fastdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-static-libs-fastdebug.sha256sum] = "20b5476111de04eb333d1a47c6aab9119f38ecaf2c867d5b8d85a319934ac8a4"

URI_x86_64_v2_java-25-openjdk-static-libs-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-static-libs-slowdebug-25.0.3.0.9-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-static-libs-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-static-libs-slowdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-static-libs-slowdebug.sha256sum] = "1abfe64d305bb1cddbb1b04632382557f4b15919020e4a7fadfa86e76a46ed07"

URI_aarch64_java-25-openjdk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-25.0.3.0.9-1.el10_2.aarch64.rpm;name=aarch64_java-25-openjdk;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk}"
SRC_URI[aarch64_java-25-openjdk.sha256sum] = "e39da4243b2de2d2260f2a51fb1280c0abaafbf04e28fe30d51d49b9ae4a68ee"

URI_aarch64_java-25-openjdk-crypto-adapter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-crypto-adapter-25.0.3.0.9-1.el10_2.aarch64.rpm;name=aarch64_java-25-openjdk-crypto-adapter;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-crypto-adapter}"
SRC_URI[aarch64_java-25-openjdk-crypto-adapter.sha256sum] = "de97870eb49cd10c1697199860ee6d9e2e5be4e1c5269176b0d7d55f673f12dd"

URI_aarch64_java-25-openjdk-crypto-adapter-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-crypto-adapter-fastdebug-25.0.3.0.9-1.el10_2.aarch64.rpm;name=aarch64_java-25-openjdk-crypto-adapter-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-crypto-adapter-fastdebug}"
SRC_URI[aarch64_java-25-openjdk-crypto-adapter-fastdebug.sha256sum] = "b5ce298c03a7aa84eac1fb71f6c3a462aa004fca6d1410b0f576c6a5d62423c7"

URI_aarch64_java-25-openjdk-crypto-adapter-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-crypto-adapter-slowdebug-25.0.3.0.9-1.el10_2.aarch64.rpm;name=aarch64_java-25-openjdk-crypto-adapter-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-crypto-adapter-slowdebug}"
SRC_URI[aarch64_java-25-openjdk-crypto-adapter-slowdebug.sha256sum] = "2c0cff9e6e21edf62cd5625860d8c9963153884fcd6aa24a99e33fbf7a1a0033"

URI_aarch64_java-25-openjdk-demo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-demo-25.0.3.0.9-1.el10_2.aarch64.rpm;name=aarch64_java-25-openjdk-demo;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-demo}"
SRC_URI[aarch64_java-25-openjdk-demo.sha256sum] = "e421883835232a1cc98f77c777e0579d509bedceaa77055e0d8dfa1471ee8e00"

URI_aarch64_java-25-openjdk-demo-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-demo-fastdebug-25.0.3.0.9-1.el10_2.aarch64.rpm;name=aarch64_java-25-openjdk-demo-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-demo-fastdebug}"
SRC_URI[aarch64_java-25-openjdk-demo-fastdebug.sha256sum] = "5ee77a52de6905c3900a518280dbeb49a41c06ac0b56ad0ef552597286c1e460"

URI_aarch64_java-25-openjdk-demo-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-demo-slowdebug-25.0.3.0.9-1.el10_2.aarch64.rpm;name=aarch64_java-25-openjdk-demo-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-demo-slowdebug}"
SRC_URI[aarch64_java-25-openjdk-demo-slowdebug.sha256sum] = "1ddc86606e4b17f4d7c314a46171fd839ba6a4477a02fd51f277e98c637db4ee"

URI_aarch64_java-25-openjdk-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-devel-25.0.3.0.9-1.el10_2.aarch64.rpm;name=aarch64_java-25-openjdk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-devel}"
SRC_URI[aarch64_java-25-openjdk-devel.sha256sum] = "86b205ddc8b3ae668de8199f2cfa6cd386088327e387a953716a886fd5d7f2c7"

URI_aarch64_java-25-openjdk-devel-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-devel-fastdebug-25.0.3.0.9-1.el10_2.aarch64.rpm;name=aarch64_java-25-openjdk-devel-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-devel-fastdebug}"
SRC_URI[aarch64_java-25-openjdk-devel-fastdebug.sha256sum] = "c12b86db105de48dda1c618d0ad04bf2d9bf209a3a4a92eb70811c7863654761"

URI_aarch64_java-25-openjdk-devel-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-devel-slowdebug-25.0.3.0.9-1.el10_2.aarch64.rpm;name=aarch64_java-25-openjdk-devel-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-devel-slowdebug}"
SRC_URI[aarch64_java-25-openjdk-devel-slowdebug.sha256sum] = "bfe4c9c4958a398f6cff58f66672d448dd95e330d6825e1e77c163a89d783c72"

URI_aarch64_java-25-openjdk-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-fastdebug-25.0.3.0.9-1.el10_2.aarch64.rpm;name=aarch64_java-25-openjdk-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-fastdebug}"
SRC_URI[aarch64_java-25-openjdk-fastdebug.sha256sum] = "1cb3cee8a2812c680ca118685ee4b3fa165702f8d10b5ab30514694ec60d4c62"

URI_aarch64_java-25-openjdk-headless = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-headless-25.0.3.0.9-1.el10_2.aarch64.rpm;name=aarch64_java-25-openjdk-headless;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-headless}"
SRC_URI[aarch64_java-25-openjdk-headless.sha256sum] = "ce2c8ce1d6c7f9c3fb30160d0c5005036ac8b223d94ec16808ec2d45010ccf9e"
RPROVIDES:java-25-openjdk-headless:aarch64 = "virtual/java-headless_or_java-21-headless_or_java-25-headless"

URI_aarch64_java-25-openjdk-headless-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-headless-fastdebug-25.0.3.0.9-1.el10_2.aarch64.rpm;name=aarch64_java-25-openjdk-headless-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-headless-fastdebug}"
SRC_URI[aarch64_java-25-openjdk-headless-fastdebug.sha256sum] = "bc0ba456c925b3e6ab4d492885ee2be0eaf3afe4446e2fab879da901d5dda125"

URI_aarch64_java-25-openjdk-headless-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-headless-slowdebug-25.0.3.0.9-1.el10_2.aarch64.rpm;name=aarch64_java-25-openjdk-headless-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-headless-slowdebug}"
SRC_URI[aarch64_java-25-openjdk-headless-slowdebug.sha256sum] = "ef5f8c0bd9bfee09554683fbc69d263fe0a64ca9dd5bef8c36d17c3a62a2081b"

URI_aarch64_java-25-openjdk-javadoc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-javadoc-25.0.3.0.9-1.el10_2.aarch64.rpm;name=aarch64_java-25-openjdk-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-javadoc}"
SRC_URI[aarch64_java-25-openjdk-javadoc.sha256sum] = "1db94cecae70259e842bf72f518b604f38dba647f9c4d886e576248aa9bf3f84"

URI_aarch64_java-25-openjdk-javadoc-zip = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-javadoc-zip-25.0.3.0.9-1.el10_2.aarch64.rpm;name=aarch64_java-25-openjdk-javadoc-zip;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-javadoc-zip}"
SRC_URI[aarch64_java-25-openjdk-javadoc-zip.sha256sum] = "a2bebe3ddab4d926ff0eab99a414eaadd30eb419ff1ed0cd9cd595824cc964d8"

URI_aarch64_java-25-openjdk-jmods = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-jmods-25.0.3.0.9-1.el10_2.aarch64.rpm;name=aarch64_java-25-openjdk-jmods;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-jmods}"
SRC_URI[aarch64_java-25-openjdk-jmods.sha256sum] = "c99190a217258b03b2f1ba31f042935b62beda4bd806e8886054236b0ed89d63"

URI_aarch64_java-25-openjdk-jmods-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-jmods-fastdebug-25.0.3.0.9-1.el10_2.aarch64.rpm;name=aarch64_java-25-openjdk-jmods-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-jmods-fastdebug}"
SRC_URI[aarch64_java-25-openjdk-jmods-fastdebug.sha256sum] = "75f380a2ea8cd6d00747767e26b13e6be7aa945857cf716ee111d389bf3204c6"

URI_aarch64_java-25-openjdk-jmods-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-jmods-slowdebug-25.0.3.0.9-1.el10_2.aarch64.rpm;name=aarch64_java-25-openjdk-jmods-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-jmods-slowdebug}"
SRC_URI[aarch64_java-25-openjdk-jmods-slowdebug.sha256sum] = "8ff85c296a6b93290281bfd676b4ffaca7d37d7dc28793b578a06ce3d28b96e3"

URI_aarch64_java-25-openjdk-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-slowdebug-25.0.3.0.9-1.el10_2.aarch64.rpm;name=aarch64_java-25-openjdk-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-slowdebug}"
SRC_URI[aarch64_java-25-openjdk-slowdebug.sha256sum] = "d178c8972826a8f4297e34c4aadfd7fd9017177f23bc07e44cdfc29af5419a62"

URI_aarch64_java-25-openjdk-src = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-src-25.0.3.0.9-1.el10_2.aarch64.rpm;name=aarch64_java-25-openjdk-src;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-src}"
SRC_URI[aarch64_java-25-openjdk-src.sha256sum] = "cfd81994b8e5f01cd500a24d0b50260710acb4585a6af38a7ed07207dc306182"

URI_aarch64_java-25-openjdk-src-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-src-fastdebug-25.0.3.0.9-1.el10_2.aarch64.rpm;name=aarch64_java-25-openjdk-src-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-src-fastdebug}"
SRC_URI[aarch64_java-25-openjdk-src-fastdebug.sha256sum] = "2aacf1f32f865b7f31d312173c42b23d933d8c4cf2b466091cf6b6c289fa63c7"

URI_aarch64_java-25-openjdk-src-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-src-slowdebug-25.0.3.0.9-1.el10_2.aarch64.rpm;name=aarch64_java-25-openjdk-src-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-src-slowdebug}"
SRC_URI[aarch64_java-25-openjdk-src-slowdebug.sha256sum] = "7f5d1b3b93143ff88174c9d8cb695a975a99cc9696997d20f72dda319f322ec3"

URI_aarch64_java-25-openjdk-static-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-static-libs-25.0.3.0.9-1.el10_2.aarch64.rpm;name=aarch64_java-25-openjdk-static-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-static-libs}"
SRC_URI[aarch64_java-25-openjdk-static-libs.sha256sum] = "5de1ddfc548f8baeba6cb62e132c058b407176d285edd24fcadfc14582814a4e"

URI_aarch64_java-25-openjdk-static-libs-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-static-libs-fastdebug-25.0.3.0.9-1.el10_2.aarch64.rpm;name=aarch64_java-25-openjdk-static-libs-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-static-libs-fastdebug}"
SRC_URI[aarch64_java-25-openjdk-static-libs-fastdebug.sha256sum] = "b1a4fc2b9cfdb975e46e4920c688bee77b12c8ceb32079f25758c783815e50b2"

URI_aarch64_java-25-openjdk-static-libs-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-static-libs-slowdebug-25.0.3.0.9-1.el10_2.aarch64.rpm;name=aarch64_java-25-openjdk-static-libs-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-static-libs-slowdebug}"
SRC_URI[aarch64_java-25-openjdk-static-libs-slowdebug.sha256sum] = "ad76e2a475281554978793f0c64fc5a3c96b6f6abd7445be955fb4a96ac2e49a"

RDEPENDS:java-25-openjdk = " \
 bash \
 fontconfig \
 glibc \
 java-25-openjdk-headless \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-25-openjdk-crypto-adapter = " \
 glibc \
 nss \
 nss-softokn \
 "
RDEPENDS:java-25-openjdk-crypto-adapter-fastdebug = " \
 glibc \
 nss \
 nss-softokn \
 "
RDEPENDS:java-25-openjdk-crypto-adapter-slowdebug = " \
 glibc \
 nss \
 nss-softokn \
 "
RDEPENDS:java-25-openjdk-demo = " \
 java-25-openjdk \
 "
RDEPENDS:java-25-openjdk-demo-fastdebug = " \
 java-25-openjdk-fastdebug \
 "
RDEPENDS:java-25-openjdk-demo-slowdebug = " \
 java-25-openjdk-slowdebug \
 "
RDEPENDS:java-25-openjdk-devel = " \
 alternatives \
 bash \
 glibc \
 java-25-openjdk \
 "
RDEPENDS:java-25-openjdk-devel-fastdebug = " \
 alternatives \
 bash \
 glibc \
 java-25-openjdk-fastdebug \
 "
RDEPENDS:java-25-openjdk-devel-slowdebug = " \
 alternatives \
 bash \
 glibc \
 java-25-openjdk-slowdebug \
 "
RDEPENDS:java-25-openjdk-fastdebug = " \
 bash \
 fontconfig \
 glibc \
 java-25-openjdk-headless-fastdebug \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-25-openjdk-headless = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 java-25-openjdk-crypto-adapter \
 javapackages-filesystem \
 lksctp-tools \
 tzdata-java \
 "
RDEPENDS:java-25-openjdk-headless-fastdebug = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 java-25-openjdk-crypto-adapter-fastdebug \
 javapackages-filesystem \
 lksctp-tools \
 tzdata-java \
 "
RDEPENDS:java-25-openjdk-headless-slowdebug = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 java-25-openjdk-crypto-adapter-slowdebug \
 javapackages-filesystem \
 lksctp-tools \
 tzdata-java \
 "
RDEPENDS:java-25-openjdk-javadoc = " \
 alternatives \
 bash \
 java-25-openjdk-headless \
 javapackages-filesystem \
 "
RDEPENDS:java-25-openjdk-javadoc-zip = " \
 alternatives \
 bash \
 java-25-openjdk-headless \
 javapackages-filesystem \
 "
RDEPENDS:java-25-openjdk-jmods = " \
 java-25-openjdk-devel \
 "
RDEPENDS:java-25-openjdk-jmods-fastdebug = " \
 java-25-openjdk-devel-fastdebug \
 "
RDEPENDS:java-25-openjdk-jmods-slowdebug = " \
 java-25-openjdk-devel-slowdebug \
 "
RDEPENDS:java-25-openjdk-slowdebug = " \
 bash \
 fontconfig \
 glibc \
 java-25-openjdk-headless-slowdebug \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-25-openjdk-src = " \
 java-25-openjdk-headless \
 "
RDEPENDS:java-25-openjdk-src-fastdebug = " \
 java-25-openjdk-headless-fastdebug \
 "
RDEPENDS:java-25-openjdk-src-slowdebug = " \
 java-25-openjdk-headless-slowdebug \
 "
RDEPENDS:java-25-openjdk-static-libs = " \
 java-25-openjdk-devel \
 "
RDEPENDS:java-25-openjdk-static-libs-fastdebug = " \
 java-25-openjdk-devel-fastdebug \
 "
RDEPENDS:java-25-openjdk-static-libs-slowdebug = " \
 java-25-openjdk-devel-slowdebug \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/java-headless_or_java-21-headless_or_java-25-headless"

PROVIDES:append:aarch64 = " rpm/virtual/java-headless_or_java-21-headless_or_java-25-headless"
