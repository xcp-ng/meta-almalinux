# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-gi-gdkpixbuf"
PV = "2.0.32"
PR = "1.el10_0"
PACKAGES = " \
 ghc-gi-gdkpixbuf \
 ghc-gi-gdkpixbuf-devel \
 ghc-gi-gdkpixbuf-doc \
 ghc-gi-gdkpixbuf-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-gi-gdkpixbuf-2.0.32-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b7f1210ef520d0615ccfad91f3924f36ba0291d104b59253816375423e0c471"

URI_x86_64_v2_ghc-gi-gdkpixbuf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-gi-gdkpixbuf-2.0.32-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-gi-gdkpixbuf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-gi-gdkpixbuf}"
SRC_URI[x86_64_v2_ghc-gi-gdkpixbuf.sha256sum] = "4c4dd7b8e736aa5faa5e6972e656be9958cd8bdceb1619262bb770e528f23eb8"

URI_x86_64_v2_ghc-gi-gdkpixbuf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-gi-gdkpixbuf-devel-2.0.32-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-gi-gdkpixbuf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-gi-gdkpixbuf-devel}"
SRC_URI[x86_64_v2_ghc-gi-gdkpixbuf-devel.sha256sum] = "bcc65e24c4f83fa093f958990023e1b3be05abaa7129bcac112f6cff90579b6c"

URI_x86_64_v2_ghc-gi-gdkpixbuf-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-gi-gdkpixbuf-doc-2.0.32-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-gi-gdkpixbuf-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-gi-gdkpixbuf-doc}"
SRC_URI[x86_64_v2_ghc-gi-gdkpixbuf-doc.sha256sum] = "dbe58cf1420ca7578777694480654bee010be3f417ef5af3c956f540f0efa6b6"

URI_x86_64_v2_ghc-gi-gdkpixbuf-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-gi-gdkpixbuf-prof-2.0.32-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-gi-gdkpixbuf-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-gi-gdkpixbuf-prof}"
SRC_URI[x86_64_v2_ghc-gi-gdkpixbuf-prof.sha256sum] = "b3f34a57f41600ed1987a4d97530b13a6f90bab4bf5f8cf100d8a3968566afd0"

URI_aarch64_ghc-gi-gdkpixbuf = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-gi-gdkpixbuf-2.0.32-1.el10_0.aarch64.rpm;name=aarch64_ghc-gi-gdkpixbuf;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-gi-gdkpixbuf}"
SRC_URI[aarch64_ghc-gi-gdkpixbuf.sha256sum] = "653af0007235e323906a0d17fb31736f35d95d11eadbf4d2fddf1a683eaa10c3"

URI_aarch64_ghc-gi-gdkpixbuf-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-gi-gdkpixbuf-devel-2.0.32-1.el10_0.aarch64.rpm;name=aarch64_ghc-gi-gdkpixbuf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-gi-gdkpixbuf-devel}"
SRC_URI[aarch64_ghc-gi-gdkpixbuf-devel.sha256sum] = "1f3c5634baff837c017751594e46d786da6bd7c05e3da6f883d3c6cb81bb04b2"

URI_aarch64_ghc-gi-gdkpixbuf-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-gi-gdkpixbuf-doc-2.0.32-1.el10_0.noarch.rpm;name=aarch64_ghc-gi-gdkpixbuf-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-gi-gdkpixbuf-doc}"
SRC_URI[aarch64_ghc-gi-gdkpixbuf-doc.sha256sum] = "a012e29f8760b0db5352484be3f874bf6fd6224b6d080828cb4d536a7005b058"

URI_aarch64_ghc-gi-gdkpixbuf-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-gi-gdkpixbuf-prof-2.0.32-1.el10_0.aarch64.rpm;name=aarch64_ghc-gi-gdkpixbuf-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-gi-gdkpixbuf-prof}"
SRC_URI[aarch64_ghc-gi-gdkpixbuf-prof.sha256sum] = "a800b95de7f980fe97da0d32cbf882c2b4a9e45943913ce878f757c0a7bb0f60"

RDEPENDS:ghc-gi-gdkpixbuf = " \
 gdk-pixbuf2 \
 ghc-Cabal \
 ghc-Cabal-syntax \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-array \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-bytestring \
 ghc-colour \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-data-default-class \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-gi-gio \
 ghc-gi-glib \
 ghc-gi-gmodule \
 ghc-gi-gobject \
 ghc-hashable \
 ghc-haskell-gi \
 ghc-haskell-gi-base \
 ghc-haskell-lexer \
 ghc-integer-logarithms \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-os-string \
 ghc-parsec \
 ghc-pretty \
 ghc-pretty-show \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-regex-base \
 ghc-regex-tdfa \
 ghc-resourcet \
 ghc-safe \
 ghc-scientific \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-typed-process \
 ghc-unix \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-xdg-basedir \
 ghc-xml-conduit \
 ghc-xml-types \
 ghc-zlib \
 glib2 \
 glibc \
 gmp \
 gobject-introspection \
 zlib-ng-compat \
 "
RDEPENDS:ghc-gi-gdkpixbuf-devel = " \
 gdk-pixbuf2-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-gi-gdkpixbuf \
 ghc-gi-gio-devel \
 ghc-gi-glib-devel \
 ghc-gi-gmodule-devel \
 ghc-gi-gobject-devel \
 ghc-haskell-gi-base-devel \
 ghc-haskell-gi-devel \
 ghc-haskell-gi-overloading-devel \
 ghc-text-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-gi-gdkpixbuf-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-gi-gdkpixbuf-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-gi-gdkpixbuf-devel \
 ghc-gi-gio-prof \
 ghc-gi-glib-prof \
 ghc-gi-gmodule-prof \
 ghc-gi-gobject-prof \
 ghc-haskell-gi-base-prof \
 ghc-haskell-gi-prof \
 ghc-text-prof \
 ghc-transformers-prof \
 "
