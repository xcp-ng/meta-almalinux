# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-uber-multierr"
PV = "1.11.0"
PR = "5.el10_0"
PACKAGES = " \
 golang-uber-multierr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-uber-multierr-1.11.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da3a01866309b2ab24caadc5c6fbcefeb401a217be681b215a91ef2d580b986c"

URI_x86_64_v2_golang-uber-multierr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-uber-multierr-devel-1.11.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-uber-multierr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-uber-multierr-devel}"
SRC_URI[x86_64_v2_golang-uber-multierr-devel.sha256sum] = "bbb7368d0c2389b6d0298633ae5cee3defa9f3b1e51cd3c9f48ca323ad8e2866"

URI_aarch64_golang-uber-multierr-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-uber-multierr-devel-1.11.0-5.el10_0.noarch.rpm;name=aarch64_golang-uber-multierr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-uber-multierr-devel}"
SRC_URI[aarch64_golang-uber-multierr-devel.sha256sum] = "d2c9d52edce6c24651fb7d65f9954b133433fc71a11c34e2a4efd5a27aa041ad"

RDEPENDS:golang-uber-multierr-devel = " \
 go-filesystem \
 "
