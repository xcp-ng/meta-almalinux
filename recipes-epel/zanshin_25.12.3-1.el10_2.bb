# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zanshin"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 zanshin \
 zanshin-common \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/z/zanshin-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be6712db2247735ec1201510003a01dc8017c287389aca1f43790a1c1f363185"

URI_x86_64_v2_zanshin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zanshin-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zanshin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zanshin}"
SRC_URI[x86_64_v2_zanshin.sha256sum] = "aff33734831545e79bba7cc665548520823f6bae10fd17401763cc1ab5a8de7a"

URI_x86_64_v2_zanshin-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zanshin-common-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_zanshin-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zanshin-common}"
SRC_URI[x86_64_v2_zanshin-common.sha256sum] = "ecec859fa442e16b3662f6569ee59844644bb1e10a9851c29d2e803b70890fc0"

URI_aarch64_zanshin = "${EPEL_MIRROR}/aarch64/Packages/z/zanshin-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_zanshin;unpack=0"
SRC_URI:append = " ${URI_aarch64_zanshin}"
SRC_URI[aarch64_zanshin.sha256sum] = "37f4d93b379a8bcedcac68eafe9fa897c1e66d70fe7baf30b2c7e60acb057528"

URI_aarch64_zanshin-common = "${EPEL_MIRROR}/aarch64/Packages/z/zanshin-common-25.12.3-1.el10_2.noarch.rpm;name=aarch64_zanshin-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_zanshin-common}"
SRC_URI[aarch64_zanshin-common.sha256sum] = "1ebc03d83413e279ba8924f3655eb39f9b0f0098249204aeb354d9dd05dc259a"

RDEPENDS:zanshin = " \
 akonadi-server \
 glibc \
 kdepim-runtime \
 kf6-kcalendarcore \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kitemmodels \
 kf6-kparts \
 kf6-krunner \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kontactinterface \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 zanshin-common \
 "
RDEPENDS:zanshin-common = " \
 zanshin \
 "
