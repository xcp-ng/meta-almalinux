# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocm-origami"
PV = "7.2.0"
PR = "5.el10_3"
PACKAGES:x86_64_v2 = " \
 rocm-origami \
 rocm-origami-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocm-origami-7.2.0-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85cde607f06673248c474518147152a789f82d72c9a83c278a7d7c23a2ed5ee3"

URI_x86_64_v2_rocm-origami = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-origami-7.2.0-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-origami;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-origami}"
SRC_URI[x86_64_v2_rocm-origami.sha256sum] = "a0812d40e4fae0344b828619cc00e119f9d26433c3695a1143708bb751314aad"

URI_x86_64_v2_rocm-origami-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-origami-devel-7.2.0-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-origami-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-origami-devel}"
SRC_URI[x86_64_v2_rocm-origami-devel.sha256sum] = "4ed27572c64cfd66c4d7423b82b7fc928eb3b1d9306b3e71419d7d43fede4cbc"

RDEPENDS:rocm-origami = " \
 glibc \
 libgcc \
 libstdc++ \
 rocm-filesystem \
 "
RDEPENDS:rocm-origami-devel = " \
 cmake-filesystem \
 rocm-filesystem \
 rocm-origami \
 "
