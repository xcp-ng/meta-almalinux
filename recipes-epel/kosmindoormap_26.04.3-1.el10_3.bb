# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kosmindoormap"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kosmindoormap \
 kosmindoormap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kosmindoormap-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6b463c65703d8b34396bc7da815a614830f6c202e615807fe789f82f943f2c2"

URI_x86_64_v2_kosmindoormap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kosmindoormap-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kosmindoormap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kosmindoormap}"
SRC_URI[x86_64_v2_kosmindoormap.sha256sum] = "c8a9a6b041a70a163aecb8bbf0af1d2d29fb2fb75eba30ba1ab44f6041f6dd76"

URI_x86_64_v2_kosmindoormap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kosmindoormap-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kosmindoormap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kosmindoormap-devel}"
SRC_URI[x86_64_v2_kosmindoormap-devel.sha256sum] = "b9a6639f9df75ea80f1cb19410e4b54388de6fe4db6816a2b69ef4d65db8a14d"

URI_aarch64_kosmindoormap = "${EPEL_MIRROR}/aarch64/Packages/k/kosmindoormap-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kosmindoormap;unpack=0"
SRC_URI:append = " ${URI_aarch64_kosmindoormap}"
SRC_URI[aarch64_kosmindoormap.sha256sum] = "6342149c36a6fc83fa40616eb3d9f14b9911dade3161b815997adcd685a21420"

URI_aarch64_kosmindoormap-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kosmindoormap-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kosmindoormap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kosmindoormap-devel}"
SRC_URI[aarch64_kosmindoormap-devel.sha256sum] = "2223c5fd4919ff5e4bedf3ce8bce719ca953b5772a1ca18be2e03b3891ffe751"

RDEPENDS:kosmindoormap = " \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kservice \
 kopeninghours \
 kpublictransport \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kosmindoormap-devel = " \
 cmake-filesystem \
 kosmindoormap \
 "
