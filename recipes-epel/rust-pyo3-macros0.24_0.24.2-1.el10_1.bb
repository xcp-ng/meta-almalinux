# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-macros0.24"
PV = "0.24.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-pyo3-macros0.24+default-devel \
 rust-pyo3-macros0.24+experimental-async-devel \
 rust-pyo3-macros0.24+multiple-pymethods-devel \
 rust-pyo3-macros0.24-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-macros0.24-0.24.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "869b7c6bd58b335c9dd3abca4373dea5f4e3725d00223d8e5366e762aaed8836"

URI_x86_64_v2_rust-pyo3-macros0.24+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros0.24+default-devel-0.24.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros0.24+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros0.24+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros0.24+default-devel.sha256sum] = "26cc6efb85f831a1e3b88e6a15169dd3883b17e1b5206232080cca185187492d"

URI_x86_64_v2_rust-pyo3-macros0.24+experimental-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros0.24+experimental-async-devel-0.24.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros0.24+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros0.24+experimental-async-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros0.24+experimental-async-devel.sha256sum] = "e776cd1bd3d9c83c3ca141c8de6881d149828c04e9c5a6300264582bcae9a4e1"

URI_x86_64_v2_rust-pyo3-macros0.24+multiple-pymethods-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros0.24+multiple-pymethods-devel-0.24.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros0.24+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros0.24+multiple-pymethods-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros0.24+multiple-pymethods-devel.sha256sum] = "2691d9f24d20601eac6227955ea53b01c177607b9a5ad3b3909783dfc94e6a69"

URI_x86_64_v2_rust-pyo3-macros0.24-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros0.24-devel-0.24.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros0.24-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros0.24-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros0.24-devel.sha256sum] = "9c1671477dc63946c365c95310e15e69ccc0dd545bbca7f75fcce1442f7904fd"

URI_aarch64_rust-pyo3-macros0.24+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros0.24+default-devel-0.24.2-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-macros0.24+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros0.24+default-devel}"
SRC_URI[aarch64_rust-pyo3-macros0.24+default-devel.sha256sum] = "4c09ec323ce37befe4671175d4fbc308171ab4ac9ea1f3fc152735e706ebe824"

URI_aarch64_rust-pyo3-macros0.24+experimental-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros0.24+experimental-async-devel-0.24.2-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-macros0.24+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros0.24+experimental-async-devel}"
SRC_URI[aarch64_rust-pyo3-macros0.24+experimental-async-devel.sha256sum] = "9becf103d6a937efa67f9489183e35c5b04d00c0f9f21ffecd526d46b7cfe1a9"

URI_aarch64_rust-pyo3-macros0.24+multiple-pymethods-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros0.24+multiple-pymethods-devel-0.24.2-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-macros0.24+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros0.24+multiple-pymethods-devel}"
SRC_URI[aarch64_rust-pyo3-macros0.24+multiple-pymethods-devel.sha256sum] = "62c9421455a2c6ca7e283849279bc1dbf8dbfd90d0e01f287b2315cdb9930f45"

URI_aarch64_rust-pyo3-macros0.24-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros0.24-devel-0.24.2-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-macros0.24-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros0.24-devel}"
SRC_URI[aarch64_rust-pyo3-macros0.24-devel.sha256sum] = "82ce7d7f31ad08a17eeebd1601632577ba8ad085fdfc7f076ad1ee767de4ecdf"

RDEPENDS:rust-pyo3-macros0.24+default-devel = " \
 cargo \
 rust-pyo3-macros0.24-devel \
 "
RDEPENDS:rust-pyo3-macros0.24+experimental-async-devel = " \
 cargo \
 rust-pyo3-macros-backend0.24+experimental-async-devel \
 rust-pyo3-macros0.24-devel \
 "
RDEPENDS:rust-pyo3-macros0.24+multiple-pymethods-devel = " \
 cargo \
 rust-pyo3-macros0.24-devel \
 "
RDEPENDS:rust-pyo3-macros0.24-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 rust-pyo3-macros-backend0.24+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 "
