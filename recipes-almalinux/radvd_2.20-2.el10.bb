# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "radvd"
PV = "2.20"
PR = "2.el10"
PACKAGES = " \
 radvd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/radvd-2.20-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a457182bfa4f92ea740d16ab58dcc7d4b98f1edda1ba41ef35dac2840a18b096"

URI_x86_64_v2_radvd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/radvd-2.20-2.el10.x86_64_v2.rpm;name=x86_64_v2_radvd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_radvd}"
SRC_URI[x86_64_v2_radvd.sha256sum] = "3cc7c6d4967e5cec09e000f817fd643f28218e6c026dec765622d2f14e72b5d6"

URI_aarch64_radvd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/radvd-2.20-2.el10.aarch64.rpm;name=aarch64_radvd;unpack=0"
SRC_URI:append = " ${URI_aarch64_radvd}"
SRC_URI[aarch64_radvd.sha256sum] = "e84b0580d6b4b2f4170b0b017eb1b58dff75f819d5161cfb1d9f84fa9b0b6e09"

RDEPENDS:radvd = " \
 bash \
 glibc \
 shadow-utils \
 systemd \
 "
