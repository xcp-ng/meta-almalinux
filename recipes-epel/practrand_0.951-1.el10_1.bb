# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "practrand"
PV = "0.951"
PR = "1.el10_1"
PACKAGES = " \
 practrand \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/practrand-0.951-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7d9d6e5ecb0ae019507bfea7f3442836b4d56867d0bf2a5afd0438c0f8d7dc6c"

URI_x86_64_v2_practrand = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/practrand-0.951-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_practrand;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_practrand}"
SRC_URI[x86_64_v2_practrand.sha256sum] = "90d9179bbbe33377324b36b0a3b1333545f284d9cccad6c955266531197ecfc5"

URI_aarch64_practrand = "${EPEL_MIRROR}/aarch64/Packages/p/practrand-0.951-1.el10_1.aarch64.rpm;name=aarch64_practrand;unpack=0"
SRC_URI:append = " ${URI_aarch64_practrand}"
SRC_URI[aarch64_practrand.sha256sum] = "5c01e073af7cc61f00c8173ba3df71c49b40e1988240be4345622ec5d7376053"

RDEPENDS:practrand = " \
 glibc \
 libgcc \
 libstdc++ \
 "
