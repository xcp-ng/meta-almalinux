# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-regex"
PV = "2024.11.6"
PR = "1.el10_0"
PACKAGES = " \
 python3-regex \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-regex-2024.11.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6d09fbb33232e75be01bd4ed6a6b859082c08749f4028aa1e9180d3c0c11cb71"

URI_x86_64_v2_python3-regex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-regex-2024.11.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-regex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-regex}"
SRC_URI[x86_64_v2_python3-regex.sha256sum] = "c80f772a976f1122ebd11342adbdafaf038ee5bd1dfe9ba04a29cf09cd812812"

URI_aarch64_python3-regex = "${EPEL_MIRROR}/aarch64/Packages/p/python3-regex-2024.11.6-1.el10_0.aarch64.rpm;name=aarch64_python3-regex;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-regex}"
SRC_URI[aarch64_python3-regex.sha256sum] = "27b428d8ef90b3bf53251508de4a68cc70775aef6d31a4a18391dc1f4a06f5bd"

RDEPENDS:python3-regex = " \
 glibc \
 python3 \
 "
