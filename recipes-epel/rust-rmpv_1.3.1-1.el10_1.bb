# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rmpv"
PV = "1.3.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-rmpv+default-devel \
 rust-rmpv+serde-devel \
 rust-rmpv+serde_bytes-devel \
 rust-rmpv+with-serde-devel \
 rust-rmpv-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rmpv-1.3.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45f1a4101c3ac7d59c49084ce66a90a2fe57a7e0d561f806c77d1b7c28e0e95c"

URI_x86_64_v2_rust-rmpv+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rmpv+default-devel-1.3.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rmpv+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rmpv+default-devel}"
SRC_URI[x86_64_v2_rust-rmpv+default-devel.sha256sum] = "ac2899147d7d26b14854b6df4f8e02ab34c1c6f8e22a1602a27fb2e0a6c4f43b"

URI_x86_64_v2_rust-rmpv+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rmpv+serde-devel-1.3.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rmpv+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rmpv+serde-devel}"
SRC_URI[x86_64_v2_rust-rmpv+serde-devel.sha256sum] = "f74816756d63c2585cd9641982016fe7fc4385857072c291f4a962607b3f6572"

URI_x86_64_v2_rust-rmpv+serde_bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rmpv+serde_bytes-devel-1.3.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rmpv+serde_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rmpv+serde_bytes-devel}"
SRC_URI[x86_64_v2_rust-rmpv+serde_bytes-devel.sha256sum] = "44135ab30d95e1aa8d8da5ac82b93d96252f8f9d7c89b19ae88fcedf98d3448b"

URI_x86_64_v2_rust-rmpv+with-serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rmpv+with-serde-devel-1.3.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rmpv+with-serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rmpv+with-serde-devel}"
SRC_URI[x86_64_v2_rust-rmpv+with-serde-devel.sha256sum] = "46a7e20203f333a445d14e03c23ba51ceb2065ba501c7ae532b5ab250ec04bb8"

URI_x86_64_v2_rust-rmpv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rmpv-devel-1.3.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rmpv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rmpv-devel}"
SRC_URI[x86_64_v2_rust-rmpv-devel.sha256sum] = "34168800755cc182c14b2c5d5e51093c1ee043bafeb6bc339389656923c387c6"

URI_aarch64_rust-rmpv+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rmpv+default-devel-1.3.1-1.el10_1.noarch.rpm;name=aarch64_rust-rmpv+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rmpv+default-devel}"
SRC_URI[aarch64_rust-rmpv+default-devel.sha256sum] = "a5de86bd399417cde8ae91a4f0cf305ced98d3979470e4130ce91411b0d396d9"

URI_aarch64_rust-rmpv+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rmpv+serde-devel-1.3.1-1.el10_1.noarch.rpm;name=aarch64_rust-rmpv+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rmpv+serde-devel}"
SRC_URI[aarch64_rust-rmpv+serde-devel.sha256sum] = "d9c0b8a8f843416a7b3b00d8f4b611d1ff5a5217d868504238be6d312eb9330c"

URI_aarch64_rust-rmpv+serde_bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rmpv+serde_bytes-devel-1.3.1-1.el10_1.noarch.rpm;name=aarch64_rust-rmpv+serde_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rmpv+serde_bytes-devel}"
SRC_URI[aarch64_rust-rmpv+serde_bytes-devel.sha256sum] = "b02efcbc5590e5a56f5bb5f23c3b68ced84755be5de9bc9e7f1215900cbbec07"

URI_aarch64_rust-rmpv+with-serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rmpv+with-serde-devel-1.3.1-1.el10_1.noarch.rpm;name=aarch64_rust-rmpv+with-serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rmpv+with-serde-devel}"
SRC_URI[aarch64_rust-rmpv+with-serde-devel.sha256sum] = "886dc9c71333c267587d0cc1629c23c9d7aebc24bd394d81668478431d762766"

URI_aarch64_rust-rmpv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rmpv-devel-1.3.1-1.el10_1.noarch.rpm;name=aarch64_rust-rmpv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rmpv-devel}"
SRC_URI[aarch64_rust-rmpv-devel.sha256sum] = "0d037955914587e267fd36078e632669caeb06c762d204a064281231a9844082"

RDEPENDS:rust-rmpv+default-devel = " \
 cargo \
 rust-rmpv-devel \
 "
RDEPENDS:rust-rmpv+serde-devel = " \
 cargo \
 rust-rmpv-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-rmpv+serde_bytes-devel = " \
 cargo \
 rust-rmpv-devel \
 rust-serde_bytes+default-devel \
 "
RDEPENDS:rust-rmpv+with-serde-devel = " \
 cargo \
 rust-rmpv+serde-devel \
 rust-rmpv+serde_bytes-devel \
 rust-rmpv-devel \
 "
RDEPENDS:rust-rmpv-devel = " \
 cargo \
 rust \
 rust-rmp+default-devel \
 "
