# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "waycheck"
PV = "1.7.0"
PR = "1.el10_1"
PACKAGES = " \
 waycheck \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/waycheck-1.7.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "67a8701af4da4749f1ebe6a2299c8fbb672b56553aa8b7e3ad1fa08ef25b1361"

URI_x86_64_v2_waycheck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/waycheck-1.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_waycheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_waycheck}"
SRC_URI[x86_64_v2_waycheck.sha256sum] = "c37d0abf2daf766d2b8f9e18458f18cfa93cb0174bef96b64f824b4fc4cf7fa9"

URI_aarch64_waycheck = "${EPEL_MIRROR}/aarch64/Packages/w/waycheck-1.7.0-1.el10_1.aarch64.rpm;name=aarch64_waycheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_waycheck}"
SRC_URI[aarch64_waycheck.sha256sum] = "78cf4d80515c21356c303c2af9fd2dee2d96108d806422813c4b8cfa3d06ca36"

RDEPENDS:waycheck = " \
 glibc \
 hicolor-icon-theme \
 libgcc \
 libstdc++ \
 libwayland-client \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
