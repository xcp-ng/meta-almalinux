# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "stratis-cli"
PV = "3.7.0"
PR = "2.el10"
PACKAGES = " \
 stratis-cli \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/stratis-cli-3.7.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15d60a1ff1230fe95e58a4e21caecc470481cfa11133b09c1525448f90550a8b"

URI_x86_64_v2_stratis-cli = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/stratis-cli-3.7.0-2.el10.noarch.rpm;name=x86_64_v2_stratis-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stratis-cli}"
SRC_URI[x86_64_v2_stratis-cli.sha256sum] = "7af984624bf5935e94b77a2c41cdf6903c13d07c658dfd0dd7e58770f8100f8f"

URI_aarch64_stratis-cli = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/stratis-cli-3.7.0-2.el10.noarch.rpm;name=aarch64_stratis-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_stratis-cli}"
SRC_URI[aarch64_stratis-cli.sha256sum] = "7af984624bf5935e94b77a2c41cdf6903c13d07c658dfd0dd7e58770f8100f8f"

RDEPENDS:stratis-cli = " \
 python3 \
 python3-dateutil \
 python3-dbus-client-gen \
 python3-dbus-python-client-gen \
 python3-justbytes \
 python3-packaging \
 python3-psutil \
 python3-wcwidth \
 stratisd \
 "
