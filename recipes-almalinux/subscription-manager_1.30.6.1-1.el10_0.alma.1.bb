# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "subscription-manager"
PV = "1.30.6.1"
PR = "1.el10_0.alma.1"
PACKAGES = " \
 libdnf-plugin-subscription-manager \
 python3-cloud-what \
 python3-subscription-manager-rhsm \
 subscription-manager \
 subscription-manager-plugin-ostree \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/subscription-manager-1.30.6.1-1.el10_0.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9994c6211553cb56eb04d86d1b491c68a79dafe3459447040c55a270b9218eda"

URI_x86_64_v2_libdnf-plugin-subscription-manager = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libdnf-plugin-subscription-manager-1.30.6.1-1.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_libdnf-plugin-subscription-manager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdnf-plugin-subscription-manager}"
SRC_URI[x86_64_v2_libdnf-plugin-subscription-manager.sha256sum] = "bbf3c348d6250576a5ab9dec891f2417721196563b2fbde4a74848f21955cb8b"

URI_x86_64_v2_python3-cloud-what = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-cloud-what-1.30.6.1-1.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-cloud-what;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cloud-what}"
SRC_URI[x86_64_v2_python3-cloud-what.sha256sum] = "ba8e75dbfe42caf009d776cd273aea3f7b47900caf3938939b8932d300eef358"

URI_x86_64_v2_python3-subscription-manager-rhsm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-subscription-manager-rhsm-1.30.6.1-1.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-subscription-manager-rhsm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-subscription-manager-rhsm}"
SRC_URI[x86_64_v2_python3-subscription-manager-rhsm.sha256sum] = "144f364bbb6784275317a5a3c93885fd7d277b38288cd7ba4329abee99fd4fdf"

URI_x86_64_v2_subscription-manager = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/subscription-manager-1.30.6.1-1.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_subscription-manager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_subscription-manager}"
SRC_URI[x86_64_v2_subscription-manager.sha256sum] = "704ea5f0bc2731078d323418b7f4534944c709352f629f99e8f49259b7968fe4"

URI_x86_64_v2_subscription-manager-plugin-ostree = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/subscription-manager-plugin-ostree-1.30.6.1-1.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_subscription-manager-plugin-ostree;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_subscription-manager-plugin-ostree}"
SRC_URI[x86_64_v2_subscription-manager-plugin-ostree.sha256sum] = "60370f4d21f031652d0e5204a5d8c179b087cfd4c8df06b83ecf8b6819b8957b"

URI_aarch64_libdnf-plugin-subscription-manager = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libdnf-plugin-subscription-manager-1.30.6.1-1.el10_0.alma.1.aarch64.rpm;name=aarch64_libdnf-plugin-subscription-manager;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdnf-plugin-subscription-manager}"
SRC_URI[aarch64_libdnf-plugin-subscription-manager.sha256sum] = "d6bfb641818ab7b349b38115afc52a46e63148f2e44bca03408d61d5896b94f9"

URI_aarch64_python3-cloud-what = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-cloud-what-1.30.6.1-1.el10_0.alma.1.aarch64.rpm;name=aarch64_python3-cloud-what;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cloud-what}"
SRC_URI[aarch64_python3-cloud-what.sha256sum] = "8746df6106e401aab5a35a15e39ea701839bf8999563b5b7e1cca63b205488ba"

URI_aarch64_python3-subscription-manager-rhsm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-subscription-manager-rhsm-1.30.6.1-1.el10_0.alma.1.aarch64.rpm;name=aarch64_python3-subscription-manager-rhsm;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-subscription-manager-rhsm}"
SRC_URI[aarch64_python3-subscription-manager-rhsm.sha256sum] = "558f173fd579b9d749c4465934593839dc10687d3bf68d2c237eca04f3df65bd"

URI_aarch64_subscription-manager = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/subscription-manager-1.30.6.1-1.el10_0.alma.1.aarch64.rpm;name=aarch64_subscription-manager;unpack=0"
SRC_URI:append = " ${URI_aarch64_subscription-manager}"
SRC_URI[aarch64_subscription-manager.sha256sum] = "389499d71e21ed82f6ab5596b8e1fb68058cac5d1efc6a14ac84d15f5fc2e806"

URI_aarch64_subscription-manager-plugin-ostree = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/subscription-manager-plugin-ostree-1.30.6.1-1.el10_0.alma.1.aarch64.rpm;name=aarch64_subscription-manager-plugin-ostree;unpack=0"
SRC_URI:append = " ${URI_aarch64_subscription-manager-plugin-ostree}"
SRC_URI[aarch64_subscription-manager-plugin-ostree.sha256sum] = "8ec9d30be1a6c22808655c357cb9300e23be8c8e1f59fdf50c73953830dd1020"

RDEPENDS:libdnf-plugin-subscription-manager = " \
 glib2 \
 glibc \
 json-c \
 libdnf \
 librepo \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3-cloud-what = " \
 dmidecode \
 python3 \
 python3-requests \
 "
RDEPENDS:python3-subscription-manager-rhsm = " \
 glibc \
 openssl-libs \
 python3 \
 python3-cloud-what \
 python3-dateutil \
 python3-iniparse \
 python3-rpm \
 subscription-manager-rhsm-certificates \
 "
RDEPENDS:subscription-manager = " \
 bash \
 dmidecode \
 glib2 \
 glibc \
 iproute \
 libdnf-plugin-subscription-manager \
 python3 \
 python3-cloud-what \
 python3-dateutil \
 python3-dbus \
 python3-decorator \
 python3-dnf \
 python3-dnf-plugins-core \
 python3-gobject-base \
 python3-iniparse \
 python3-inotify \
 python3-librepo \
 python3-subscription-manager-rhsm \
 subscription-manager-rhsm-certificates \
 systemd \
 virt-what \
 "
RDEPENDS:subscription-manager-plugin-ostree = " \
 python3 \
 python3-gobject-base \
 python3-iniparse \
 subscription-manager \
 "
