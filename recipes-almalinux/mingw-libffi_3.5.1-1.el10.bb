# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mingw-libffi"
PV = "3.5.1"
PR = "1.el10"
PACKAGES = " \
 mingw32-libffi \
 mingw64-libffi \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/mingw-libffi-3.5.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e0b975bf3e428a1beede97c5988012739280b0195790009a9872278071c1caf"

URI_x86_64_v2_mingw32-libffi = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw32-libffi-3.5.1-1.el10.noarch.rpm;name=x86_64_v2_mingw32-libffi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-libffi}"
SRC_URI[x86_64_v2_mingw32-libffi.sha256sum] = "058e902ef4c26629b561f98c1f44702990b4a146011d896caf95763875552611"

URI_x86_64_v2_mingw64-libffi = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw64-libffi-3.5.1-1.el10.noarch.rpm;name=x86_64_v2_mingw64-libffi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-libffi}"
SRC_URI[x86_64_v2_mingw64-libffi.sha256sum] = "03482eb44b91a943137a8358e3132767a930e715810515bf3cd2ad84fd07cbc4"

URI_aarch64_mingw32-libffi = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw32-libffi-3.5.1-1.el10.noarch.rpm;name=aarch64_mingw32-libffi;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw32-libffi}"
SRC_URI[aarch64_mingw32-libffi.sha256sum] = "058e902ef4c26629b561f98c1f44702990b4a146011d896caf95763875552611"

URI_aarch64_mingw64-libffi = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw64-libffi-3.5.1-1.el10.noarch.rpm;name=aarch64_mingw64-libffi;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw64-libffi}"
SRC_URI[aarch64_mingw64-libffi.sha256sum] = "03482eb44b91a943137a8358e3132767a930e715810515bf3cd2ad84fd07cbc4"

RDEPENDS:mingw32-libffi = " \
 mingw32-crt \
 mingw32-filesystem \
 "
RDEPENDS:mingw64-libffi = " \
 mingw64-crt \
 mingw64-filesystem \
 "
