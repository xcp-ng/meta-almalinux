# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-disks"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 plasma-disks \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma-disks-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5b399452b63041325db518c77eceae856c46cc78ccb7dc058b283058c20bc5d9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-disks-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-disks;unpack=0"
SRC_URI[x86_64_v2_plasma-disks.sha256sum] = "a775a45c1fb2237a5919bffa1184620e97a9de53fc9459b6dbeb3b0f2b6354f6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-disks-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-disks;unpack=0"
SRC_URI[aarch64_plasma-disks.sha256sum] = "6a29a241bc8d236bc8f77cc52d05cdf2f04c6200c7539ba19436930810fc2efc"

RDEPENDS:plasma-disks = " \
 glibc \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-knotifications \
 kf6-kservice \
 kf6-solid \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 smartmontools \
 "
