# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kgpg"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kgpg \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kgpg-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7595605a6d8848e7de722ce1472296ed63ff9c3698c7fc4404309d6411067b63"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kgpg-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kgpg;unpack=0"
SRC_URI[x86_64_v2_kgpg.sha256sum] = "33ee65075b6af3da09dd506d0f1a3f89e3f1751c4d8263cb7a29ff60645054df"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kgpg-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kgpg;unpack=0"
SRC_URI[aarch64_kgpg.sha256sum] = "50d5752d3389c37d13493592bc96d11b74bc6d979e042130a1981c5888a97a36"

RDEPENDS:kgpg = " \
 akonadi-contacts \
 akonadi-server \
 glibc \
 gnupg2 \
 kf6-karchive \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
