# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bytes"
PV = "1.12.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-bytes+default-devel \
 rust-bytes+extra-platforms-devel \
 rust-bytes+serde-devel \
 rust-bytes+std-devel \
 rust-bytes-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bytes-1.12.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc8ebfe729c04edc410c04284b49acb8f293061fd8638ba273e672fde177bacc"

URI_x86_64_v2_rust-bytes+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytes+default-devel-1.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytes+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytes+default-devel}"
SRC_URI[x86_64_v2_rust-bytes+default-devel.sha256sum] = "de03911cebc704728f13a95e6689ec74f87db8f4e668fd581ff3dc8b7cf7ac08"

URI_x86_64_v2_rust-bytes+extra-platforms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytes+extra-platforms-devel-1.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytes+extra-platforms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytes+extra-platforms-devel}"
SRC_URI[x86_64_v2_rust-bytes+extra-platforms-devel.sha256sum] = "f99094a68639212112ff509723bed2fdf52b1b84b25eb3b8d056f31603dad16a"

URI_x86_64_v2_rust-bytes+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytes+serde-devel-1.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytes+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytes+serde-devel}"
SRC_URI[x86_64_v2_rust-bytes+serde-devel.sha256sum] = "5b3709f36e24ab8d4426409cd8b2e060307d6fefa4deaca250ec7b6901eb21cf"

URI_x86_64_v2_rust-bytes+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytes+std-devel-1.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytes+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytes+std-devel}"
SRC_URI[x86_64_v2_rust-bytes+std-devel.sha256sum] = "d92405efb585597470c8ad21e2bfb96ec18cb28dfd9e44abaff3d14ec26ad0c1"

URI_x86_64_v2_rust-bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytes-devel-1.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytes-devel}"
SRC_URI[x86_64_v2_rust-bytes-devel.sha256sum] = "3c4fd3f0be4ca92b776eeee63b2675b4f45bdbed9bea9336f3bf10a90040860e"

URI_aarch64_rust-bytes+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytes+default-devel-1.12.1-1.el10_3.noarch.rpm;name=aarch64_rust-bytes+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytes+default-devel}"
SRC_URI[aarch64_rust-bytes+default-devel.sha256sum] = "f12193ccf77047b3fa02b0c128e4f2235f1dd7ab859c7bd9a337d49d0d69b059"

URI_aarch64_rust-bytes+extra-platforms-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytes+extra-platforms-devel-1.12.1-1.el10_3.noarch.rpm;name=aarch64_rust-bytes+extra-platforms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytes+extra-platforms-devel}"
SRC_URI[aarch64_rust-bytes+extra-platforms-devel.sha256sum] = "87888b098d238ee40954bbc1b0a85de6feedd1cad3b8d1e11af60431bff93cd3"

URI_aarch64_rust-bytes+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytes+serde-devel-1.12.1-1.el10_3.noarch.rpm;name=aarch64_rust-bytes+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytes+serde-devel}"
SRC_URI[aarch64_rust-bytes+serde-devel.sha256sum] = "0996e7b1595534a3605447b214ecedfb5bb948312298945422cf1dcfaebc5bb0"

URI_aarch64_rust-bytes+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytes+std-devel-1.12.1-1.el10_3.noarch.rpm;name=aarch64_rust-bytes+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytes+std-devel}"
SRC_URI[aarch64_rust-bytes+std-devel.sha256sum] = "5f07b26cd33780ac30c6cc2de8cf0fc53e777c7e9668a5119156b7f406158140"

URI_aarch64_rust-bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytes-devel-1.12.1-1.el10_3.noarch.rpm;name=aarch64_rust-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytes-devel}"
SRC_URI[aarch64_rust-bytes-devel.sha256sum] = "ac152add300f9883f91b080b3bd38a647179136c0ac680975d7deb9f814af357"

RDEPENDS:rust-bytes+default-devel = " \
 cargo \
 rust-bytes+std-devel \
 rust-bytes-devel \
 "
RDEPENDS:rust-bytes+extra-platforms-devel = " \
 cargo \
 rust-bytes-devel \
 rust-portable-atomic+require-cas-devel \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-bytes+serde-devel = " \
 cargo \
 rust-bytes-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-bytes+std-devel = " \
 cargo \
 rust-bytes-devel \
 "
RDEPENDS:rust-bytes-devel = " \
 cargo \
 rust \
 "
