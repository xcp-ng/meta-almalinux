# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-term0.7"
PV = "0.7.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-term0.7+default-devel \
 rust-term0.7-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-term0.7-0.7.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c2ccfeccacae6e0a76be54e167d76e3caf1202dee67f19c8b859a8a3c4c3572"

URI_x86_64_v2_rust-term0.7+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-term0.7+default-devel-0.7.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-term0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-term0.7+default-devel}"
SRC_URI[x86_64_v2_rust-term0.7+default-devel.sha256sum] = "37597b54e25ff97b21193fb9f1a5a91a1cdfe5bb4773bd4e12340dccb6556966"

URI_x86_64_v2_rust-term0.7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-term0.7-devel-0.7.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-term0.7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-term0.7-devel}"
SRC_URI[x86_64_v2_rust-term0.7-devel.sha256sum] = "efd22224284b8c47af32f0d8ffae39beca15218284c20dd9f6cf08e9b4d8935f"

URI_aarch64_rust-term0.7+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-term0.7+default-devel-0.7.0-1.el10_2.noarch.rpm;name=aarch64_rust-term0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-term0.7+default-devel}"
SRC_URI[aarch64_rust-term0.7+default-devel.sha256sum] = "a9096956e909414f3c4857cb31e0915b4193376c39e643d5df313d5d44b611af"

URI_aarch64_rust-term0.7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-term0.7-devel-0.7.0-1.el10_2.noarch.rpm;name=aarch64_rust-term0.7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-term0.7-devel}"
SRC_URI[aarch64_rust-term0.7-devel.sha256sum] = "ce2ff4613d1272145e21f2b5b37882005b6343d3bc64695a828adbac5aad96df"

RDEPENDS:rust-term0.7+default-devel = " \
 cargo \
 rust-term0.7-devel \
 "
RDEPENDS:rust-term0.7-devel = " \
 cargo \
 rust-dirs-next+default-devel \
 "
