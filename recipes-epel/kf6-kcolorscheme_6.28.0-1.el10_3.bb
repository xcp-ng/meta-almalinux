# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcolorscheme"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kcolorscheme \
 kf6-kcolorscheme-devel \
 kf6-kcolorscheme-doc \
 kf6-kcolorscheme-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kcolorscheme-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "24651e90c11cd872b32212868018f4445f94c7eae73a0ec193fd9a36218ee924"

URI_x86_64_v2_kf6-kcolorscheme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcolorscheme-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcolorscheme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcolorscheme}"
SRC_URI[x86_64_v2_kf6-kcolorscheme.sha256sum] = "2e385832c388a254814793d95785498c05a407631ee6d9ba5bc85200636512f8"

URI_x86_64_v2_kf6-kcolorscheme-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcolorscheme-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcolorscheme-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcolorscheme-devel}"
SRC_URI[x86_64_v2_kf6-kcolorscheme-devel.sha256sum] = "5b1c8db20eb63f6c13eeedd4022246179e9c6023e3027cbdec3ee157f0bd2e69"

URI_x86_64_v2_kf6-kcolorscheme-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcolorscheme-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcolorscheme-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcolorscheme-doc}"
SRC_URI[x86_64_v2_kf6-kcolorscheme-doc.sha256sum] = "4d6a27942dba602ff818f049a4a740e7371acb5dfe975d999b100d97ac200856"

URI_x86_64_v2_kf6-kcolorscheme-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcolorscheme-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcolorscheme-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcolorscheme-html}"
SRC_URI[x86_64_v2_kf6-kcolorscheme-html.sha256sum] = "1b8778ab8f519146966e3036b104512dabd1d445c71ea2102679ec8274f50280"

URI_aarch64_kf6-kcolorscheme = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcolorscheme-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kcolorscheme;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcolorscheme}"
SRC_URI[aarch64_kf6-kcolorscheme.sha256sum] = "366af9398c927de7298ab77cc6d817ed5877e4ca369a92dd9ae9952c83d7ac54"

URI_aarch64_kf6-kcolorscheme-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcolorscheme-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kcolorscheme-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcolorscheme-devel}"
SRC_URI[aarch64_kf6-kcolorscheme-devel.sha256sum] = "a363e6f67529d3bb1c644bff7dc28d4fbf932ff7bb16ef634660a381cf2f892f"

URI_aarch64_kf6-kcolorscheme-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcolorscheme-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kcolorscheme-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcolorscheme-doc}"
SRC_URI[aarch64_kf6-kcolorscheme-doc.sha256sum] = "b50e29ea3f0a2558c0c1a669b9a5bbabf70888d14a9b0bcce8cee2df883a895c"

URI_aarch64_kf6-kcolorscheme-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcolorscheme-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kcolorscheme-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcolorscheme-html}"
SRC_URI[aarch64_kf6-kcolorscheme-html.sha256sum] = "f1323697966d8b7d9df732188f9d86d2dc033318cd29c219703ec5fe87ecbd09"

RDEPENDS:kf6-kcolorscheme = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kguiaddons \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kcolorscheme-devel = " \
 cmake-filesystem \
 kf6-kcolorscheme \
 "
RDEPENDS:kf6-kcolorscheme-doc = " \
 "
RDEPENDS:kf6-kcolorscheme-html = " \
 "
