# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libtracecmd"
PV = "1.5.2"
PR = "1.el10"
PACKAGES = " \
 libtracecmd \
 libtracecmd-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libtracecmd-1.5.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "421ce020743beeeaf6728c2924ab28bec67ebc36e68be3bee81574a598a2f220"

URI_x86_64_v2_libtracecmd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libtracecmd-1.5.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_libtracecmd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtracecmd}"
SRC_URI[x86_64_v2_libtracecmd.sha256sum] = "7b766ef69e29ce2c5c485f8b708f42d2510078058be363910f97879047fc7f98"

URI_x86_64_v2_libtracecmd-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libtracecmd-devel-1.5.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_libtracecmd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtracecmd-devel}"
SRC_URI[x86_64_v2_libtracecmd-devel.sha256sum] = "2e0ff4fecfe4518c3c79b0a872ba8f1c6b438d4a5fb771120a67c89862711c5c"

URI_aarch64_libtracecmd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libtracecmd-1.5.2-1.el10.aarch64.rpm;name=aarch64_libtracecmd;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtracecmd}"
SRC_URI[aarch64_libtracecmd.sha256sum] = "eb6215592fad3d323ad8a7b8fbd889f1601a231117e3795d960efce2144ba641"

URI_aarch64_libtracecmd-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libtracecmd-devel-1.5.2-1.el10.aarch64.rpm;name=aarch64_libtracecmd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtracecmd-devel}"
SRC_URI[aarch64_libtracecmd-devel.sha256sum] = "211600952648be5915dd8ad2faf150b4aff0670bf29db4e3846cf2873f95b7a1"

RDEPENDS:libtracecmd = " \
 glibc \
 libtraceevent \
 libtracefs \
 libzstd \
 zlib-ng-compat \
 "
RDEPENDS:libtracecmd-devel = " \
 libtracecmd \
 libtracefs-devel \
 pkgconf-pkg-config \
 "
