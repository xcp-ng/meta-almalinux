# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-distro"
PV = "1.9.0"
PR = "5.el10"
PACKAGES = " \
 python3-distro \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-distro-1.9.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bce7ed391ce1cf2db9bf66abb16be098057359fc39e1bbdf96718e83628e57fa"

URI_x86_64_v2_python3-distro = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-distro-1.9.0-5.el10.noarch.rpm;name=x86_64_v2_python3-distro;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-distro}"
SRC_URI[x86_64_v2_python3-distro.sha256sum] = "bd6ca26d98a0cfb27817fa33a1750a950a5149c43fdcf129b936950e19859613"

URI_aarch64_python3-distro = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-distro-1.9.0-5.el10.noarch.rpm;name=aarch64_python3-distro;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-distro}"
SRC_URI[aarch64_python3-distro.sha256sum] = "bd6ca26d98a0cfb27817fa33a1750a950a5149c43fdcf129b936950e19859613"

RDEPENDS:python3-distro = " \
 python3 \
 "
