# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aardvark-dns"
PE = "2"
PV = "1.16.0"
PR = "2.el10"
PACKAGES = " \
 aardvark-dns \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/aardvark-dns-1.16.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "288491e4ca2ab04b66fb0ddcc21c8b3405463c05c10ecde6c4d00e011b567444"

URI_x86_64_v2_aardvark-dns = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aardvark-dns-1.16.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_aardvark-dns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aardvark-dns}"
SRC_URI[x86_64_v2_aardvark-dns.sha256sum] = "33493741683a31e9e1709f5a6d3255f9f3a27f547754ef156a6027e5bdc7a933"

URI_aarch64_aardvark-dns = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aardvark-dns-1.16.0-2.el10.aarch64.rpm;name=aarch64_aardvark-dns;unpack=0"
SRC_URI:append = " ${URI_aarch64_aardvark-dns}"
SRC_URI[aarch64_aardvark-dns.sha256sum] = "0c66fdabcc4224ccd72ccb2597b20565ef00b842b4fdef432a1b8fc742acbac9"

RDEPENDS:aardvark-dns = " \
 glibc \
 libgcc \
 "
