# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dav1d"
PV = "1.5.4"
PR = "1.el10_2"
PACKAGES = " \
 dav1d \
 libdav1d \
 libdav1d-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/dav1d-1.5.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0ee92ca0c5fbea23a8ef88b9eb822b19300c7bf31f0785fed1aedc415f04114b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dav1d-1.5.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dav1d;unpack=0"
SRC_URI[x86_64_v2_dav1d.sha256sum] = "65d7356164867d766e1043ed81e57c69be7fd9aa58e804dda5892a0528f55d14"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdav1d-1.5.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdav1d;unpack=0"
SRC_URI[x86_64_v2_libdav1d.sha256sum] = "782e98c30b23f98a42532eb2bba7d2ab278bbf3e89b9c99f5c154ebd867f016d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdav1d-devel-1.5.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdav1d-devel;unpack=0"
SRC_URI[x86_64_v2_libdav1d-devel.sha256sum] = "2af046ecda1a423b17f4ca3250d8bbf044dad3fc498456e7bfb7bec7855f5ae8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dav1d-1.5.4-1.el10_2.aarch64.rpm;name=aarch64_dav1d;unpack=0"
SRC_URI[aarch64_dav1d.sha256sum] = "33bcea2eaa191da84444252c48e17085337301decede5c9aff2c3d7fa4940075"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libdav1d-1.5.4-1.el10_2.aarch64.rpm;name=aarch64_libdav1d;unpack=0"
SRC_URI[aarch64_libdav1d.sha256sum] = "2c91ee560dfe34b12faf9c33d9f158d6121d00f2490ed9d1b237a76dd87535ff"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libdav1d-devel-1.5.4-1.el10_2.aarch64.rpm;name=aarch64_libdav1d-devel;unpack=0"
SRC_URI[aarch64_libdav1d-devel.sha256sum] = "0b3ca33fb50aa16202c6f513661a3a2cd7e2f35542cdd376da7e4c92045308a7"

RDEPENDS:dav1d = " \
 glibc \
 libdav1d \
 "
RDEPENDS:libdav1d = " \
 glibc \
 "
RDEPENDS:libdav1d-devel = " \
 libdav1d \
 pkgconf-pkg-config \
 "
