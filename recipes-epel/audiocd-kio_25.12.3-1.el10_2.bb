# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "audiocd-kio"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 audiocd-kio \
 audiocd-kio-devel \
 audiocd-kio-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/audiocd-kio-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12c2aca554e5652e9a912910fad3d3b6294e29174e59750d21c6dd6d1172b70c"

URI_x86_64_v2_audiocd-kio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/audiocd-kio-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_audiocd-kio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audiocd-kio}"
SRC_URI[x86_64_v2_audiocd-kio.sha256sum] = "f259468934395e52d36f1add329176335b76d643fe4afb110416ae8ea5cf3fbe"

URI_x86_64_v2_audiocd-kio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/audiocd-kio-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_audiocd-kio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audiocd-kio-devel}"
SRC_URI[x86_64_v2_audiocd-kio-devel.sha256sum] = "45a5e9a500b0264cdc6a849817a9104a3b1b9265d64477d58d7ab898cc706ffb"

URI_x86_64_v2_audiocd-kio-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/audiocd-kio-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_audiocd-kio-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audiocd-kio-doc}"
SRC_URI[x86_64_v2_audiocd-kio-doc.sha256sum] = "90dcfdb423187b1bff718ba03b8ad46451548ed0ec9f55b029c851538837cbc0"

URI_aarch64_audiocd-kio = "${EPEL_MIRROR}/aarch64/Packages/a/audiocd-kio-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_audiocd-kio;unpack=0"
SRC_URI:append = " ${URI_aarch64_audiocd-kio}"
SRC_URI[aarch64_audiocd-kio.sha256sum] = "42b4fc7b106c11c5a3f77a60295c1fac25fe843606875df8f194d82430843426"

URI_aarch64_audiocd-kio-devel = "${EPEL_MIRROR}/aarch64/Packages/a/audiocd-kio-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_audiocd-kio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_audiocd-kio-devel}"
SRC_URI[aarch64_audiocd-kio-devel.sha256sum] = "ca3f50146b432e45485f1e36b16e3994fd8fc30fd7393f04ed1e605129ced97d"

URI_aarch64_audiocd-kio-doc = "${EPEL_MIRROR}/aarch64/Packages/a/audiocd-kio-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_audiocd-kio-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_audiocd-kio-doc}"
SRC_URI[aarch64_audiocd-kio-doc.sha256sum] = "0019d936286a5dde68d9cdc041a685498bc962afdbed5b48f990bf8e3e76b220"

RDEPENDS:audiocd-kio = " \
 audiocd-kio-doc \
 cdparanoia-libs \
 flac-libs \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 libkcddb \
 libkcompactdisc \
 libogg \
 libstdc++ \
 libvorbis \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:audiocd-kio-devel = " \
 audiocd-kio \
 "
RDEPENDS:audiocd-kio-doc = " \
 audiocd-kio \
 "
