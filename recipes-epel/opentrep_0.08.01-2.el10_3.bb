# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opentrep"
PV = "0.08.01"
PR = "2.el10_3"
PACKAGES = " \
 opentrep \
 opentrep-devel \
 opentrep-doc \
 python3-opentrep \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/opentrep-0.08.01-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "752e5c89532544eaf271b213a76e078541cba596c8314891965111d758aebb4a"

URI_x86_64_v2_opentrep = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opentrep-0.08.01-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opentrep;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opentrep}"
SRC_URI[x86_64_v2_opentrep.sha256sum] = "75a41df3af636551d7415fcf2ba021f5d65723ec3e251b9299b09083d3e7114f"

URI_x86_64_v2_opentrep-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opentrep-devel-0.08.01-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opentrep-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opentrep-devel}"
SRC_URI[x86_64_v2_opentrep-devel.sha256sum] = "537e589a260b96e0b294951a8055ea9bf7571252a9d003c0b059fb946b66d146"

URI_x86_64_v2_opentrep-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opentrep-doc-0.08.01-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_opentrep-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opentrep-doc}"
SRC_URI[x86_64_v2_opentrep-doc.sha256sum] = "db13242dc01319d5cb46cd4d878993214e30dd7a6e084ce16745c1c5142b3d10"

URI_x86_64_v2_python3-opentrep = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-opentrep-0.08.01-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-opentrep;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-opentrep}"
SRC_URI[x86_64_v2_python3-opentrep.sha256sum] = "304988b0ebae7d8e0ae7f37bc80805f053a7d1e81b1252a94e70214822755ebc"

URI_aarch64_opentrep = "${EPEL_MIRROR}/aarch64/Packages/o/opentrep-0.08.01-2.el10_3.aarch64.rpm;name=aarch64_opentrep;unpack=0"
SRC_URI:append = " ${URI_aarch64_opentrep}"
SRC_URI[aarch64_opentrep.sha256sum] = "7fc45913b536cc107efead5706e37cd53948c75296a984d23ae6418cddfd5531"

URI_aarch64_opentrep-devel = "${EPEL_MIRROR}/aarch64/Packages/o/opentrep-devel-0.08.01-2.el10_3.aarch64.rpm;name=aarch64_opentrep-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_opentrep-devel}"
SRC_URI[aarch64_opentrep-devel.sha256sum] = "92c9d25cb2811ffaab5ae299cb41abf16a3d79845ac0411caec6b1fffb35ec11"

URI_aarch64_opentrep-doc = "${EPEL_MIRROR}/aarch64/Packages/o/opentrep-doc-0.08.01-2.el10_3.noarch.rpm;name=aarch64_opentrep-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_opentrep-doc}"
SRC_URI[aarch64_opentrep-doc.sha256sum] = "155d821bec7186618d2b184f67de88eb5c91bc3e7666d2705d24ddb1e2789d81"

URI_aarch64_python3-opentrep = "${EPEL_MIRROR}/aarch64/Packages/p/python3-opentrep-0.08.01-2.el10_3.aarch64.rpm;name=aarch64_python3-opentrep;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-opentrep}"
SRC_URI[aarch64_python3-opentrep.sha256sum] = "383b41d4ed462ceb880bf4a55d8f9f6c3e6f450601e52122c7e8321ea806656d"

RDEPENDS:opentrep = " \
 bash \
 boost-filesystem \
 boost-iostreams \
 boost-program-options \
 boost-random \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 protobuf \
 readline \
 soci \
 soci-mysql \
 soci-postgresql \
 soci-sqlite3 \
 xapian-core-libs \
 "
RDEPENDS:opentrep-devel = " \
 bash \
 cmake-filesystem \
 opentrep \
 pkgconf-pkg-config \
 "
RDEPENDS:opentrep-doc = " \
 "
RDEPENDS:python3-opentrep = " \
 bash \
 boost-python3 \
 glibc \
 libgcc \
 libstdc++ \
 opentrep \
 python3 \
 python3-libs \
 "
