# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libtalloc"
PV = "2.4.2"
PR = "106.el10"
PACKAGES = " \
 libtalloc \
 libtalloc-devel \
 python3-talloc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libtalloc-2.4.2-106.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "757d1b7ad309016c65b6e88ae0a0479e5e277007a3d3faff006630f1c2d9e53c"

URI_x86_64_v2_libtalloc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libtalloc-2.4.2-106.el10.x86_64_v2.rpm;name=x86_64_v2_libtalloc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtalloc}"
SRC_URI[x86_64_v2_libtalloc.sha256sum] = "e9783236f819cb43849c111ce6adfcd488617adf72890f7bdc22dac0db1f793b"

URI_x86_64_v2_libtalloc-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libtalloc-devel-2.4.2-106.el10.x86_64_v2.rpm;name=x86_64_v2_libtalloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtalloc-devel}"
SRC_URI[x86_64_v2_libtalloc-devel.sha256sum] = "84f821ba49a1a1d49c4942f97e427678ad0e7655821a5dbd607c3e88a39ad239"

URI_x86_64_v2_python3-talloc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-talloc-2.4.2-106.el10.x86_64_v2.rpm;name=x86_64_v2_python3-talloc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-talloc}"
SRC_URI[x86_64_v2_python3-talloc.sha256sum] = "81ee159c426f4bb6c615744306ea36150032aca26bb982a3b67cccf57a8590a1"

URI_aarch64_libtalloc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libtalloc-2.4.2-106.el10.aarch64.rpm;name=aarch64_libtalloc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtalloc}"
SRC_URI[aarch64_libtalloc.sha256sum] = "31340b8195ddccd83b6e84e6ebe8942b63e435374c08da1324e3b5ceaed4eb6a"

URI_aarch64_libtalloc-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libtalloc-devel-2.4.2-106.el10.aarch64.rpm;name=aarch64_libtalloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtalloc-devel}"
SRC_URI[aarch64_libtalloc-devel.sha256sum] = "ba12f9a1824e27087220c3afd0325a7a00d1cd032fa30ecfaf88bff167953e4d"

URI_aarch64_python3-talloc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-talloc-2.4.2-106.el10.aarch64.rpm;name=aarch64_python3-talloc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-talloc}"
SRC_URI[aarch64_python3-talloc.sha256sum] = "a9ea4be2995b532746829e1866bf813956e0bc2693c1d623f8d841ff1572d7d7"

RDEPENDS:libtalloc = " \
 glibc \
 "
RDEPENDS:libtalloc-devel = " \
 libtalloc \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-talloc = " \
 glibc \
 libtalloc \
 python3 \
 python3-libs \
 "
