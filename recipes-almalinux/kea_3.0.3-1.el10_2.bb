# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kea"
PV = "3.0.3"
PR = "1.el10_2"
PACKAGES = " \
 kea \
 kea-doc \
 kea-hooks \
 kea-keama \
 kea-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/kea-3.0.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9160520da5aaa4ea14ff215fdaa8ffbd4ea1e6749ab6f392d086005122a8d69d"

URI_x86_64_v2_kea = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kea-3.0.3-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kea;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kea}"
SRC_URI[x86_64_v2_kea.sha256sum] = "6b32519e5e24cf831c43a2095c2d4a12342faa75759a4a35ee2b234e9b425799"

URI_x86_64_v2_kea-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kea-doc-3.0.3-1.el10_2.noarch.rpm;name=x86_64_v2_kea-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kea-doc}"
SRC_URI[x86_64_v2_kea-doc.sha256sum] = "a53eb43c470846ffe6405847e987763fcf2b06460c82c5a3c022af9f966b2ccb"

URI_x86_64_v2_kea-hooks = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kea-hooks-3.0.3-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kea-hooks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kea-hooks}"
SRC_URI[x86_64_v2_kea-hooks.sha256sum] = "ae63346c6d17a91dbabcad74b845a96954ea923ef9bfa48c839f348be3a630e5"

URI_x86_64_v2_kea-keama = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/kea-keama-3.0.3-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kea-keama;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kea-keama}"
SRC_URI[x86_64_v2_kea-keama.sha256sum] = "8174ee256336089c6ae55fa92818d81f0638a5eabe2877b2b1e7138ff3b8f6b3"

URI_x86_64_v2_kea-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kea-libs-3.0.3-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kea-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kea-libs}"
SRC_URI[x86_64_v2_kea-libs.sha256sum] = "bb0b4f508676a15e17e4d3858aa4b11e817786091fc943a5e336003181b14822"

URI_aarch64_kea = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kea-3.0.3-1.el10_2.aarch64.rpm;name=aarch64_kea;unpack=0"
SRC_URI:append = " ${URI_aarch64_kea}"
SRC_URI[aarch64_kea.sha256sum] = "124ecdc117b97cdd75cb8aa40fa1327112ddb5e08364d85f45041e7d7e9117a3"

URI_aarch64_kea-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kea-doc-3.0.3-1.el10_2.noarch.rpm;name=aarch64_kea-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kea-doc}"
SRC_URI[aarch64_kea-doc.sha256sum] = "a53eb43c470846ffe6405847e987763fcf2b06460c82c5a3c022af9f966b2ccb"

URI_aarch64_kea-hooks = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kea-hooks-3.0.3-1.el10_2.aarch64.rpm;name=aarch64_kea-hooks;unpack=0"
SRC_URI:append = " ${URI_aarch64_kea-hooks}"
SRC_URI[aarch64_kea-hooks.sha256sum] = "2705425b3427e40eb39bd868b34aa7dd02a5cc4e18116e35d8a7a96448a40a0e"

URI_aarch64_kea-keama = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/kea-keama-3.0.3-1.el10_2.aarch64.rpm;name=aarch64_kea-keama;unpack=0"
SRC_URI:append = " ${URI_aarch64_kea-keama}"
SRC_URI[aarch64_kea-keama.sha256sum] = "b41715f09841e473d9b8c43ffd457449969dbf40ae25b5401d61da2129af6587"

URI_aarch64_kea-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kea-libs-3.0.3-1.el10_2.aarch64.rpm;name=aarch64_kea-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kea-libs}"
SRC_URI[aarch64_kea-libs.sha256sum] = "a43953acf2a007d9c2acf542da02f1d22d4a10eeccc56752fb76887968fce7c9"

RDEPENDS:kea = " \
 bash \
 glibc \
 kea-libs \
 libgcc \
 libstdc++ \
 openssl-libs \
 python3 \
 shadow-utils \
 systemd \
 systemd-libs \
 util-linux \
 virtual/coreutils \
 "
RDEPENDS:kea-doc = " \
 "
RDEPENDS:kea-hooks = " \
 glibc \
 kea-libs \
 krb5-libs \
 libgcc \
 libpq \
 libstdc++ \
 mariadb-connector-c \
 openssl-libs \
 "
RDEPENDS:kea-keama = " \
 glibc \
 "
RDEPENDS:kea-libs = " \
 glibc \
 libgcc \
 libpq \
 libstdc++ \
 log4cplus \
 mariadb-connector-c \
 openssl-libs \
 "
