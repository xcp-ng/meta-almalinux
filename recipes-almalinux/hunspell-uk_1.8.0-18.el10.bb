# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-uk"
PV = "1.8.0"
PR = "18.el10"
PACKAGES = " \
 hunspell-uk \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-uk-1.8.0-18.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "912ae594f9c538caec02e01241c429a7da9c0d9682d77f936169b8f9b3093c23"

URI_x86_64_v2_hunspell-uk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-uk-1.8.0-18.el10.noarch.rpm;name=x86_64_v2_hunspell-uk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-uk}"
SRC_URI[x86_64_v2_hunspell-uk.sha256sum] = "c46893ad629f88d24b1abfa7669e92cce926048c0337fb46f52d05a6a1bc1cb8"

URI_aarch64_hunspell-uk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-uk-1.8.0-18.el10.noarch.rpm;name=aarch64_hunspell-uk;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-uk}"
SRC_URI[aarch64_hunspell-uk.sha256sum] = "c46893ad629f88d24b1abfa7669e92cce926048c0337fb46f52d05a6a1bc1cb8"

RDEPENDS:hunspell-uk = " \
 hunspell-filesystem \
 "
