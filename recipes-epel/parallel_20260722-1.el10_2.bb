# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "parallel"
PV = "20260722"
PR = "1.el10_2"
PACKAGES = " \
 parallel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/parallel-20260722-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ef6f9b61de4c37a1304d69350e1c1679ad7f9384f8828d3f55cb270a72d15123"

URI_x86_64_v2_parallel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/parallel-20260722-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_parallel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_parallel}"
SRC_URI[x86_64_v2_parallel.sha256sum] = "91fcd0fbcf3ac26947b1fd2d82a25ab0a6731795030a17471a387d8954be7d85"

URI_aarch64_parallel = "${EPEL_MIRROR}/aarch64/Packages/p/parallel-20260722-1.el10_2.noarch.rpm;name=aarch64_parallel;unpack=0"
SRC_URI:append = " ${URI_aarch64_parallel}"
SRC_URI[aarch64_parallel.sha256sum] = "ba4e415ab16648ee6856a729bedce59d786cbae3d58f96c57b1cb6f6aeadc6d5"

RDEPENDS:parallel = " \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Path \
 perl-File-Temp \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-IO \
 perl-IPC-Open3 \
 perl-POSIX \
 perl-Symbol \
 perl-Thread-Queue \
 perl-interpreter \
 perl-libs \
 perl-threads \
 perl-threads-shared \
 "
