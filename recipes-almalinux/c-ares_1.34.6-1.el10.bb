# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "c-ares"
PV = "1.34.6"
PR = "1.el10"
PACKAGES = " \
 c-ares \
 c-ares-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/c-ares-1.34.6-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86c1ba6034584588de270c52be81b33ace4435b186b8d90fa10e81b9c1a2a490"

URI_x86_64_v2_c-ares = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/c-ares-1.34.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_c-ares;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_c-ares}"
SRC_URI[x86_64_v2_c-ares.sha256sum] = "dcce46f14438cb5c738880f563bb101ca969aef20c3f28f5b0bf9bb55ab02417"

URI_x86_64_v2_c-ares-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/c-ares-devel-1.34.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_c-ares-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_c-ares-devel}"
SRC_URI[x86_64_v2_c-ares-devel.sha256sum] = "66b1315a428c0d96720ba784f66e0fb1f7aa9d6074871e182e128620b6fbede7"

URI_aarch64_c-ares = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/c-ares-1.34.6-1.el10.aarch64.rpm;name=aarch64_c-ares;unpack=0"
SRC_URI:append = " ${URI_aarch64_c-ares}"
SRC_URI[aarch64_c-ares.sha256sum] = "905a36a50dcb1412d3356b23de1b03653b8ffefdb19c7bd34d9519933ef85bd6"

URI_aarch64_c-ares-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/c-ares-devel-1.34.6-1.el10.aarch64.rpm;name=aarch64_c-ares-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_c-ares-devel}"
SRC_URI[aarch64_c-ares-devel.sha256sum] = "03a808beb7916ede9fbb5909e06ae64c356f68ec6fa6f8badeeec239ec303641"

RDEPENDS:c-ares = " \
 glibc \
 "
RDEPENDS:c-ares-devel = " \
 c-ares \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
