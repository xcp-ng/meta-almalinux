# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kanagram"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kanagram \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kanagram-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "29e8d1e35a846b38bbea144fa5d99ff490e841622173b4f1cd1c64c499ff1721"

URI_x86_64_v2_kanagram = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kanagram-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kanagram;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kanagram}"
SRC_URI[x86_64_v2_kanagram.sha256sum] = "63978ddf81dadc77a619b7b8acc9ba026f9435e85963b3eac8bf5626648de59c"

URI_aarch64_kanagram = "${EPEL_MIRROR}/aarch64/Packages/k/kanagram-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kanagram;unpack=0"
SRC_URI:append = " ${URI_aarch64_kanagram}"
SRC_URI[aarch64_kanagram.sha256sum] = "e03ca14d516df435c835975025ae09d9489ea6ae0240892b48d0d29884aa6595"

RDEPENDS:kanagram = " \
 glibc \
 kdeedu-data \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 libkeduvocdocument \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtspeech \
 "
