# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sqlx-macros-core"
PV = "0.8.6"
PR = "4.el10_2"
PACKAGES = " \
 rust-sqlx-macros-core+_rt-tokio-devel \
 rust-sqlx-macros-core+_sqlite-devel \
 rust-sqlx-macros-core+_tls-native-tls-devel \
 rust-sqlx-macros-core+_tls-rustls-ring-native-roots-devel \
 rust-sqlx-macros-core+_tls-rustls-ring-webpki-devel \
 rust-sqlx-macros-core+async-std-devel \
 rust-sqlx-macros-core+bigdecimal-devel \
 rust-sqlx-macros-core+bit-vec-devel \
 rust-sqlx-macros-core+chrono-devel \
 rust-sqlx-macros-core+default-devel \
 rust-sqlx-macros-core+derive-devel \
 rust-sqlx-macros-core+ipnet-devel \
 rust-sqlx-macros-core+ipnetwork-devel \
 rust-sqlx-macros-core+json-devel \
 rust-sqlx-macros-core+mac_address-devel \
 rust-sqlx-macros-core+macros-devel \
 rust-sqlx-macros-core+migrate-devel \
 rust-sqlx-macros-core+mysql-devel \
 rust-sqlx-macros-core+postgres-devel \
 rust-sqlx-macros-core+rust_decimal-devel \
 rust-sqlx-macros-core+sqlite-devel \
 rust-sqlx-macros-core+sqlite-unbundled-devel \
 rust-sqlx-macros-core+sqlx-mysql-devel \
 rust-sqlx-macros-core+sqlx-postgres-devel \
 rust-sqlx-macros-core+sqlx-sqlite-devel \
 rust-sqlx-macros-core+time-devel \
 rust-sqlx-macros-core+tokio-devel \
 rust-sqlx-macros-core+uuid-devel \
 rust-sqlx-macros-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sqlx-macros-core-0.8.6-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b3b78267ac445a43b69b36b1794c88e851e635fdab7572d8f493e697b43841e7"

URI_x86_64_v2_rust-sqlx-macros-core+_rt-tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros-core+_rt-tokio-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros-core+_rt-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros-core+_rt-tokio-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros-core+_rt-tokio-devel.sha256sum] = "fda010ae2632cf781c659eb985cc4687fac080c071496282de5d89c659ebc003"

URI_x86_64_v2_rust-sqlx-macros-core+_sqlite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros-core+_sqlite-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros-core+_sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros-core+_sqlite-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros-core+_sqlite-devel.sha256sum] = "3999f17394ae566440e0fb9835e7b28b54725ca93d075706c0b42b491d2ee44c"

URI_x86_64_v2_rust-sqlx-macros-core+_tls-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros-core+_tls-native-tls-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros-core+_tls-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros-core+_tls-native-tls-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros-core+_tls-native-tls-devel.sha256sum] = "7cda099240864431274c1c8c5b43f43b9af6058b3f57fcab570ba7d3a71cbbfa"

URI_x86_64_v2_rust-sqlx-macros-core+_tls-rustls-ring-native-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros-core+_tls-rustls-ring-native-roots-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros-core+_tls-rustls-ring-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros-core+_tls-rustls-ring-native-roots-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros-core+_tls-rustls-ring-native-roots-devel.sha256sum] = "c477c57fa38d86d24ea2b028b7d5fb01cea71d7a252146205e69a17830b08ae3"

URI_x86_64_v2_rust-sqlx-macros-core+_tls-rustls-ring-webpki-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros-core+_tls-rustls-ring-webpki-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros-core+_tls-rustls-ring-webpki-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros-core+_tls-rustls-ring-webpki-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros-core+_tls-rustls-ring-webpki-devel.sha256sum] = "4fbd09ad2f464c28001812c323f9794ff22e27b812e8ffdf69d2b81b68fe477d"

URI_x86_64_v2_rust-sqlx-macros-core+async-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros-core+async-std-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros-core+async-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros-core+async-std-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros-core+async-std-devel.sha256sum] = "12ff2a1eed7c5d39247dda34d61e9e2a787264f20bef6d64743075639f3cab4b"

URI_x86_64_v2_rust-sqlx-macros-core+bigdecimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros-core+bigdecimal-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros-core+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros-core+bigdecimal-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros-core+bigdecimal-devel.sha256sum] = "eb94a391aa5e531a386177e12e86c1e42e558ac688250f4504598013ececd4c6"

URI_x86_64_v2_rust-sqlx-macros-core+bit-vec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros-core+bit-vec-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros-core+bit-vec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros-core+bit-vec-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros-core+bit-vec-devel.sha256sum] = "fdbc3dd37412b17f2913e6656e3c7f76f905a1d8c8b53b26e5a96b2c43c7f164"

URI_x86_64_v2_rust-sqlx-macros-core+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros-core+chrono-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros-core+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros-core+chrono-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros-core+chrono-devel.sha256sum] = "c88cadc069c7b0b1035b3324b455523adec11261d851bf462f02d96456317ee3"

URI_x86_64_v2_rust-sqlx-macros-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros-core+default-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros-core+default-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros-core+default-devel.sha256sum] = "1829e9661a3786abd56d29c31b5641fcf77c319557e86d20609ac16bb6e45acc"

URI_x86_64_v2_rust-sqlx-macros-core+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros-core+derive-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros-core+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros-core+derive-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros-core+derive-devel.sha256sum] = "dd6c3f767f4affb15635fe307422da9e6f1b59584e8826fc9fe5f3a74a2ead8c"

URI_x86_64_v2_rust-sqlx-macros-core+ipnet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros-core+ipnet-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros-core+ipnet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros-core+ipnet-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros-core+ipnet-devel.sha256sum] = "0fe0a4a6a84278dcb004d14bf32578f7aee6960fe2a2a06e3439fd86b5cae498"

URI_x86_64_v2_rust-sqlx-macros-core+ipnetwork-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros-core+ipnetwork-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros-core+ipnetwork-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros-core+ipnetwork-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros-core+ipnetwork-devel.sha256sum] = "886aa39a2dec4e64c7a8ffd6c482cf679ff0e27d06854d98a63dc1bb82b05e82"

URI_x86_64_v2_rust-sqlx-macros-core+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros-core+json-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros-core+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros-core+json-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros-core+json-devel.sha256sum] = "758b782b1be6df3520575005ad7a52b76cee70825d7f2b72746d47d3d4cd00e3"

URI_x86_64_v2_rust-sqlx-macros-core+mac_address-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros-core+mac_address-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros-core+mac_address-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros-core+mac_address-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros-core+mac_address-devel.sha256sum] = "cb273730af435f0df66c3cdf0cbaf24d013f2e45d283848a857ece3b7e63bd9a"

URI_x86_64_v2_rust-sqlx-macros-core+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros-core+macros-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros-core+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros-core+macros-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros-core+macros-devel.sha256sum] = "62ab2f865687193cd07501cec259f054fcb7ed28569f215373724718f67812e7"

URI_x86_64_v2_rust-sqlx-macros-core+migrate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros-core+migrate-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros-core+migrate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros-core+migrate-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros-core+migrate-devel.sha256sum] = "7f1940fcd955c3acb585438f91165f1f98735b732abea7fdcd53d70e065e793e"

URI_x86_64_v2_rust-sqlx-macros-core+mysql-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros-core+mysql-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros-core+mysql-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros-core+mysql-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros-core+mysql-devel.sha256sum] = "9aa25f1bdd7889b13e9c4f1af9168c0a5349aa67690d9cf5f5964efd4f48d02e"

URI_x86_64_v2_rust-sqlx-macros-core+postgres-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros-core+postgres-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros-core+postgres-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros-core+postgres-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros-core+postgres-devel.sha256sum] = "82f1ebd7f6f74e7db11837f6fd5870b6e41d9d0e550536918de8a20c2c15549d"

URI_x86_64_v2_rust-sqlx-macros-core+rust_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros-core+rust_decimal-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros-core+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros-core+rust_decimal-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros-core+rust_decimal-devel.sha256sum] = "a8ef4271db5a44a8a61717851872d152fddda93990bc3ff6a89fa4dbbb41eb76"

URI_x86_64_v2_rust-sqlx-macros-core+sqlite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros-core+sqlite-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros-core+sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros-core+sqlite-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros-core+sqlite-devel.sha256sum] = "a01286113848d98d5ff34eac403b7468b006672d8129ea2b310d456b9ce9f918"

URI_x86_64_v2_rust-sqlx-macros-core+sqlite-unbundled-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros-core+sqlite-unbundled-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros-core+sqlite-unbundled-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros-core+sqlite-unbundled-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros-core+sqlite-unbundled-devel.sha256sum] = "a6483c189a09403947a06756e661ff7dcd583c8a6fa41285c860e927835c0b4b"

URI_x86_64_v2_rust-sqlx-macros-core+sqlx-mysql-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros-core+sqlx-mysql-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros-core+sqlx-mysql-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros-core+sqlx-mysql-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros-core+sqlx-mysql-devel.sha256sum] = "97abab523fe6e7d98b1343692ef062facfaaf6a7d470e70c5ac5dda3c6e00986"

URI_x86_64_v2_rust-sqlx-macros-core+sqlx-postgres-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros-core+sqlx-postgres-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros-core+sqlx-postgres-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros-core+sqlx-postgres-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros-core+sqlx-postgres-devel.sha256sum] = "568310c51ae5706cc523a8548353b57ed022615961f9e671d65649900609eca6"

URI_x86_64_v2_rust-sqlx-macros-core+sqlx-sqlite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros-core+sqlx-sqlite-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros-core+sqlx-sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros-core+sqlx-sqlite-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros-core+sqlx-sqlite-devel.sha256sum] = "e71271afa505a3aa40126d3ba4c6ee1c863ccfcaf8e8b9e5d4f38ba95e0b1206"

URI_x86_64_v2_rust-sqlx-macros-core+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros-core+time-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros-core+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros-core+time-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros-core+time-devel.sha256sum] = "2dd8c943b6e1ac78b464c51fd30a907d734fcd4701ecadb117af73803b64d0b4"

URI_x86_64_v2_rust-sqlx-macros-core+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros-core+tokio-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros-core+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros-core+tokio-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros-core+tokio-devel.sha256sum] = "51b1dce77f38759ad6e7e817eb298e2ee4483ee278c4adb9f9b41cfa2f8c1efc"

URI_x86_64_v2_rust-sqlx-macros-core+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros-core+uuid-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros-core+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros-core+uuid-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros-core+uuid-devel.sha256sum] = "8962cb73da024661ae255d997a3eee9d2f366946f10b7703f405873a6b58f79f"

URI_x86_64_v2_rust-sqlx-macros-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros-core-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros-core-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros-core-devel.sha256sum] = "f65a407cee2c01f14c16180d4393a8412b9b2e8c126c68a4b7e8e77d9d270be5"

URI_aarch64_rust-sqlx-macros-core+_rt-tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros-core+_rt-tokio-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros-core+_rt-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros-core+_rt-tokio-devel}"
SRC_URI[aarch64_rust-sqlx-macros-core+_rt-tokio-devel.sha256sum] = "23151a931200962b16be81852b6eba9f9e03f5b6e63b6ccc263fbbd41d4b9172"

URI_aarch64_rust-sqlx-macros-core+_sqlite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros-core+_sqlite-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros-core+_sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros-core+_sqlite-devel}"
SRC_URI[aarch64_rust-sqlx-macros-core+_sqlite-devel.sha256sum] = "95d98e0ef08206ac8854b18dc6ddc6f50b3d8fc47dd9ca510b2bb1a9ef899ca2"

URI_aarch64_rust-sqlx-macros-core+_tls-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros-core+_tls-native-tls-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros-core+_tls-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros-core+_tls-native-tls-devel}"
SRC_URI[aarch64_rust-sqlx-macros-core+_tls-native-tls-devel.sha256sum] = "d457a236f366d47060e17fd61438ca81cc453720b97ab933720a82519a0b0e9a"

URI_aarch64_rust-sqlx-macros-core+_tls-rustls-ring-native-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros-core+_tls-rustls-ring-native-roots-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros-core+_tls-rustls-ring-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros-core+_tls-rustls-ring-native-roots-devel}"
SRC_URI[aarch64_rust-sqlx-macros-core+_tls-rustls-ring-native-roots-devel.sha256sum] = "6082fe3722ab2a9b1726df5d299e4cd6bbba4b1f28a2d85b655668f31f45d2d7"

URI_aarch64_rust-sqlx-macros-core+_tls-rustls-ring-webpki-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros-core+_tls-rustls-ring-webpki-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros-core+_tls-rustls-ring-webpki-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros-core+_tls-rustls-ring-webpki-devel}"
SRC_URI[aarch64_rust-sqlx-macros-core+_tls-rustls-ring-webpki-devel.sha256sum] = "8395920809c648f47141ee10ad85fc3a00dfb43f8a0ef547a9d6a1f8ab396d53"

URI_aarch64_rust-sqlx-macros-core+async-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros-core+async-std-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros-core+async-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros-core+async-std-devel}"
SRC_URI[aarch64_rust-sqlx-macros-core+async-std-devel.sha256sum] = "cf7618ad7ce1432e617b90d7ac822b2a899ff37c30d8f90758760f5ef33ea726"

URI_aarch64_rust-sqlx-macros-core+bigdecimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros-core+bigdecimal-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros-core+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros-core+bigdecimal-devel}"
SRC_URI[aarch64_rust-sqlx-macros-core+bigdecimal-devel.sha256sum] = "948a5546e070fe3fc9bdfea4d7e446bb63df41faff2981d3fe674ae4e3c9ba8a"

URI_aarch64_rust-sqlx-macros-core+bit-vec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros-core+bit-vec-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros-core+bit-vec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros-core+bit-vec-devel}"
SRC_URI[aarch64_rust-sqlx-macros-core+bit-vec-devel.sha256sum] = "ae39162f6988561c355ce9f497d6173e2c82302404379ebb1a47d0bbfed4f6ca"

URI_aarch64_rust-sqlx-macros-core+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros-core+chrono-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros-core+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros-core+chrono-devel}"
SRC_URI[aarch64_rust-sqlx-macros-core+chrono-devel.sha256sum] = "f340455fbaf49fac2d99afded860c7fd5004c0443c4583411b912c66a36e11fe"

URI_aarch64_rust-sqlx-macros-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros-core+default-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros-core+default-devel}"
SRC_URI[aarch64_rust-sqlx-macros-core+default-devel.sha256sum] = "95b478c60a7b465126ee21c0bd046a6ac4808256cc5fa36a1946d1d31fa14593"

URI_aarch64_rust-sqlx-macros-core+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros-core+derive-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros-core+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros-core+derive-devel}"
SRC_URI[aarch64_rust-sqlx-macros-core+derive-devel.sha256sum] = "4d7f64662e58728b0f18d7e70245ccda138d6584e36865ce1dd73171f649dcf5"

URI_aarch64_rust-sqlx-macros-core+ipnet-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros-core+ipnet-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros-core+ipnet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros-core+ipnet-devel}"
SRC_URI[aarch64_rust-sqlx-macros-core+ipnet-devel.sha256sum] = "1c3a24fb7d676ca496d9e4532c28ee8b54d1d4bf5e32a884227a787645c155ea"

URI_aarch64_rust-sqlx-macros-core+ipnetwork-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros-core+ipnetwork-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros-core+ipnetwork-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros-core+ipnetwork-devel}"
SRC_URI[aarch64_rust-sqlx-macros-core+ipnetwork-devel.sha256sum] = "3397654f9ec5fd8dfe61a868aea6846840c47455826b9ed55a5d7c27ea03d4d3"

URI_aarch64_rust-sqlx-macros-core+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros-core+json-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros-core+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros-core+json-devel}"
SRC_URI[aarch64_rust-sqlx-macros-core+json-devel.sha256sum] = "a4b45b2a8afdb859631145dd9c89b3b5d58b6737e3326e8035f245bcf1b16bb6"

URI_aarch64_rust-sqlx-macros-core+mac_address-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros-core+mac_address-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros-core+mac_address-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros-core+mac_address-devel}"
SRC_URI[aarch64_rust-sqlx-macros-core+mac_address-devel.sha256sum] = "26edbed2dfb5fc411fbbdf30857919b479af5638864f529f8306f227334cbb0e"

URI_aarch64_rust-sqlx-macros-core+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros-core+macros-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros-core+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros-core+macros-devel}"
SRC_URI[aarch64_rust-sqlx-macros-core+macros-devel.sha256sum] = "629f40a8f095150b5309f0f2204fa381099990e7fff927d2fc2db2936e92aab1"

URI_aarch64_rust-sqlx-macros-core+migrate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros-core+migrate-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros-core+migrate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros-core+migrate-devel}"
SRC_URI[aarch64_rust-sqlx-macros-core+migrate-devel.sha256sum] = "385188d2e2e8c9b70d97117dae864d4a0a52aa642de4ab2af9997a9b95c55f8f"

URI_aarch64_rust-sqlx-macros-core+mysql-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros-core+mysql-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros-core+mysql-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros-core+mysql-devel}"
SRC_URI[aarch64_rust-sqlx-macros-core+mysql-devel.sha256sum] = "386eb72d179b5ca04a5ee801d8a6aabdaac2258ac82061d29176d862999f58b1"

URI_aarch64_rust-sqlx-macros-core+postgres-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros-core+postgres-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros-core+postgres-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros-core+postgres-devel}"
SRC_URI[aarch64_rust-sqlx-macros-core+postgres-devel.sha256sum] = "8fb9ae10d0c2b8457d7e5065148ab96065727381ffd7aff3e53be10b5187ca22"

URI_aarch64_rust-sqlx-macros-core+rust_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros-core+rust_decimal-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros-core+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros-core+rust_decimal-devel}"
SRC_URI[aarch64_rust-sqlx-macros-core+rust_decimal-devel.sha256sum] = "410cda0c0b355fced41f72ec948de97e82bc973f03d3ea0422b6b3d5e45b2419"

URI_aarch64_rust-sqlx-macros-core+sqlite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros-core+sqlite-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros-core+sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros-core+sqlite-devel}"
SRC_URI[aarch64_rust-sqlx-macros-core+sqlite-devel.sha256sum] = "984a5088092ff3afe2e8d1fa36f3cd7298f02b4e4622d8288d2e99ecb10a2c7f"

URI_aarch64_rust-sqlx-macros-core+sqlite-unbundled-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros-core+sqlite-unbundled-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros-core+sqlite-unbundled-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros-core+sqlite-unbundled-devel}"
SRC_URI[aarch64_rust-sqlx-macros-core+sqlite-unbundled-devel.sha256sum] = "4f72d588f3a62a40f36df2888ffd75f226a8a90df3ccf98b1f884884112c8028"

URI_aarch64_rust-sqlx-macros-core+sqlx-mysql-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros-core+sqlx-mysql-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros-core+sqlx-mysql-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros-core+sqlx-mysql-devel}"
SRC_URI[aarch64_rust-sqlx-macros-core+sqlx-mysql-devel.sha256sum] = "3f5ff10aa92c9b97e19fcc84104a51a18e431a11aa291f325a55cdf660344304"

URI_aarch64_rust-sqlx-macros-core+sqlx-postgres-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros-core+sqlx-postgres-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros-core+sqlx-postgres-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros-core+sqlx-postgres-devel}"
SRC_URI[aarch64_rust-sqlx-macros-core+sqlx-postgres-devel.sha256sum] = "4f16880153f9a83de9b3e65cd270635b1870e269eda155e6070b8348a2111b97"

URI_aarch64_rust-sqlx-macros-core+sqlx-sqlite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros-core+sqlx-sqlite-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros-core+sqlx-sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros-core+sqlx-sqlite-devel}"
SRC_URI[aarch64_rust-sqlx-macros-core+sqlx-sqlite-devel.sha256sum] = "0cea1a04b38d8191d6146f52c8abdba54b85ff3c4f8f73b19e476651215c7a34"

URI_aarch64_rust-sqlx-macros-core+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros-core+time-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros-core+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros-core+time-devel}"
SRC_URI[aarch64_rust-sqlx-macros-core+time-devel.sha256sum] = "55b091f7ee38ae6e828a2af97030621b2b743f1c58df6cb5b4b39f048caa93e8"

URI_aarch64_rust-sqlx-macros-core+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros-core+tokio-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros-core+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros-core+tokio-devel}"
SRC_URI[aarch64_rust-sqlx-macros-core+tokio-devel.sha256sum] = "ec8a8a8464e3d2f715fbd4329f344fd922b577615f652c68afaf8a5d620790ff"

URI_aarch64_rust-sqlx-macros-core+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros-core+uuid-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros-core+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros-core+uuid-devel}"
SRC_URI[aarch64_rust-sqlx-macros-core+uuid-devel.sha256sum] = "6c4148b15ca553bd015baaf00259809a0856bf2a5134acc212c51da6cf69748d"

URI_aarch64_rust-sqlx-macros-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros-core-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-macros-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros-core-devel}"
SRC_URI[aarch64_rust-sqlx-macros-core-devel.sha256sum] = "7bb69340997f0d6d91cb7c3c45a2de799357dbb7627a20270a753ea4d65c2b15"

RDEPENDS:rust-sqlx-macros-core+_rt-tokio-devel = " \
 cargo \
 rust-sqlx-core+_rt-tokio-devel \
 rust-sqlx-macros-core+tokio-devel \
 rust-sqlx-macros-core-devel \
 "
RDEPENDS:rust-sqlx-macros-core+_sqlite-devel = " \
 cargo \
 rust-sqlx-macros-core-devel \
 "
RDEPENDS:rust-sqlx-macros-core+_tls-native-tls-devel = " \
 cargo \
 rust-sqlx-core+_tls-native-tls-devel \
 rust-sqlx-macros-core-devel \
 "
RDEPENDS:rust-sqlx-macros-core+_tls-rustls-ring-native-roots-devel = " \
 cargo \
 rust-sqlx-core+_tls-rustls-ring-native-roots-devel \
 rust-sqlx-macros-core-devel \
 "
RDEPENDS:rust-sqlx-macros-core+_tls-rustls-ring-webpki-devel = " \
 cargo \
 rust-sqlx-core+_tls-rustls-ring-webpki-devel \
 rust-sqlx-macros-core-devel \
 "
RDEPENDS:rust-sqlx-macros-core+async-std-devel = " \
 cargo \
 rust-async-std+default-devel \
 rust-sqlx-macros-core-devel \
 "
RDEPENDS:rust-sqlx-macros-core+bigdecimal-devel = " \
 cargo \
 rust-sqlx-core+bigdecimal-devel \
 rust-sqlx-macros-core-devel \
 rust-sqlx-mysql+bigdecimal-devel \
 rust-sqlx-mysql+default-devel \
 rust-sqlx-mysql+migrate-devel \
 rust-sqlx-mysql+offline-devel \
 rust-sqlx-postgres+bigdecimal-devel \
 rust-sqlx-postgres+default-devel \
 rust-sqlx-postgres+migrate-devel \
 rust-sqlx-postgres+offline-devel \
 "
RDEPENDS:rust-sqlx-macros-core+bit-vec-devel = " \
 cargo \
 rust-sqlx-core+bit-vec-devel \
 rust-sqlx-macros-core-devel \
 rust-sqlx-postgres+bit-vec-devel \
 rust-sqlx-postgres+default-devel \
 rust-sqlx-postgres+migrate-devel \
 rust-sqlx-postgres+offline-devel \
 "
RDEPENDS:rust-sqlx-macros-core+chrono-devel = " \
 cargo \
 rust-sqlx-core+chrono-devel \
 rust-sqlx-macros-core-devel \
 rust-sqlx-mysql+chrono-devel \
 rust-sqlx-mysql+default-devel \
 rust-sqlx-mysql+migrate-devel \
 rust-sqlx-mysql+offline-devel \
 rust-sqlx-postgres+chrono-devel \
 rust-sqlx-postgres+default-devel \
 rust-sqlx-postgres+migrate-devel \
 rust-sqlx-postgres+offline-devel \
 rust-sqlx-sqlite+chrono-devel \
 rust-sqlx-sqlite+default-devel \
 rust-sqlx-sqlite+migrate-devel \
 rust-sqlx-sqlite+offline-devel \
 "
RDEPENDS:rust-sqlx-macros-core+default-devel = " \
 cargo \
 rust-sqlx-macros-core-devel \
 "
RDEPENDS:rust-sqlx-macros-core+derive-devel = " \
 cargo \
 rust-sqlx-macros-core-devel \
 "
RDEPENDS:rust-sqlx-macros-core+ipnet-devel = " \
 cargo \
 rust-sqlx-core+ipnet-devel \
 rust-sqlx-macros-core-devel \
 rust-sqlx-postgres+default-devel \
 rust-sqlx-postgres+ipnet-devel \
 rust-sqlx-postgres+migrate-devel \
 rust-sqlx-postgres+offline-devel \
 "
RDEPENDS:rust-sqlx-macros-core+ipnetwork-devel = " \
 cargo \
 rust-sqlx-core+ipnetwork-devel \
 rust-sqlx-macros-core-devel \
 rust-sqlx-postgres+default-devel \
 rust-sqlx-postgres+ipnetwork-devel \
 rust-sqlx-postgres+migrate-devel \
 rust-sqlx-postgres+offline-devel \
 "
RDEPENDS:rust-sqlx-macros-core+json-devel = " \
 cargo \
 rust-sqlx-core+json-devel \
 rust-sqlx-macros-core-devel \
 rust-sqlx-mysql+default-devel \
 rust-sqlx-mysql+json-devel \
 rust-sqlx-mysql+migrate-devel \
 rust-sqlx-mysql+offline-devel \
 rust-sqlx-postgres+default-devel \
 rust-sqlx-postgres+json-devel \
 rust-sqlx-postgres+migrate-devel \
 rust-sqlx-postgres+offline-devel \
 rust-sqlx-sqlite+default-devel \
 rust-sqlx-sqlite+json-devel \
 rust-sqlx-sqlite+migrate-devel \
 rust-sqlx-sqlite+offline-devel \
 "
RDEPENDS:rust-sqlx-macros-core+mac_address-devel = " \
 cargo \
 rust-sqlx-core+mac_address-devel \
 rust-sqlx-macros-core-devel \
 rust-sqlx-postgres+default-devel \
 rust-sqlx-postgres+mac_address-devel \
 rust-sqlx-postgres+migrate-devel \
 rust-sqlx-postgres+offline-devel \
 "
RDEPENDS:rust-sqlx-macros-core+macros-devel = " \
 cargo \
 rust-sqlx-macros-core-devel \
 "
RDEPENDS:rust-sqlx-macros-core+migrate-devel = " \
 cargo \
 rust-sqlx-core+migrate-devel \
 rust-sqlx-macros-core-devel \
 "
RDEPENDS:rust-sqlx-macros-core+mysql-devel = " \
 cargo \
 rust-sqlx-macros-core+sqlx-mysql-devel \
 rust-sqlx-macros-core-devel \
 "
RDEPENDS:rust-sqlx-macros-core+postgres-devel = " \
 cargo \
 rust-sqlx-macros-core+sqlx-postgres-devel \
 rust-sqlx-macros-core-devel \
 "
RDEPENDS:rust-sqlx-macros-core+rust_decimal-devel = " \
 cargo \
 rust-sqlx-core+rust_decimal-devel \
 rust-sqlx-macros-core-devel \
 rust-sqlx-mysql+default-devel \
 rust-sqlx-mysql+migrate-devel \
 rust-sqlx-mysql+offline-devel \
 rust-sqlx-mysql+rust_decimal-devel \
 rust-sqlx-postgres+default-devel \
 rust-sqlx-postgres+migrate-devel \
 rust-sqlx-postgres+offline-devel \
 rust-sqlx-postgres+rust_decimal-devel \
 "
RDEPENDS:rust-sqlx-macros-core+sqlite-devel = " \
 cargo \
 rust-sqlx-macros-core+sqlite-unbundled-devel \
 rust-sqlx-macros-core-devel \
 "
RDEPENDS:rust-sqlx-macros-core+sqlite-unbundled-devel = " \
 cargo \
 rust-sqlx-macros-core+_sqlite-devel \
 rust-sqlx-macros-core-devel \
 rust-sqlx-sqlite+default-devel \
 rust-sqlx-sqlite+migrate-devel \
 rust-sqlx-sqlite+offline-devel \
 rust-sqlx-sqlite+unbundled-devel \
 "
RDEPENDS:rust-sqlx-macros-core+sqlx-mysql-devel = " \
 cargo \
 rust-sqlx-macros-core-devel \
 rust-sqlx-mysql+default-devel \
 rust-sqlx-mysql+migrate-devel \
 rust-sqlx-mysql+offline-devel \
 "
RDEPENDS:rust-sqlx-macros-core+sqlx-postgres-devel = " \
 cargo \
 rust-sqlx-macros-core-devel \
 rust-sqlx-postgres+default-devel \
 rust-sqlx-postgres+migrate-devel \
 rust-sqlx-postgres+offline-devel \
 "
RDEPENDS:rust-sqlx-macros-core+sqlx-sqlite-devel = " \
 cargo \
 rust-sqlx-macros-core-devel \
 rust-sqlx-sqlite+default-devel \
 rust-sqlx-sqlite+migrate-devel \
 rust-sqlx-sqlite+offline-devel \
 "
RDEPENDS:rust-sqlx-macros-core+time-devel = " \
 cargo \
 rust-sqlx-core+time-devel \
 rust-sqlx-macros-core-devel \
 rust-sqlx-mysql+default-devel \
 rust-sqlx-mysql+migrate-devel \
 rust-sqlx-mysql+offline-devel \
 rust-sqlx-mysql+time-devel \
 rust-sqlx-postgres+default-devel \
 rust-sqlx-postgres+migrate-devel \
 rust-sqlx-postgres+offline-devel \
 rust-sqlx-postgres+time-devel \
 rust-sqlx-sqlite+default-devel \
 rust-sqlx-sqlite+migrate-devel \
 rust-sqlx-sqlite+offline-devel \
 rust-sqlx-sqlite+time-devel \
 "
RDEPENDS:rust-sqlx-macros-core+tokio-devel = " \
 cargo \
 rust-sqlx-macros-core-devel \
 rust-tokio+fs-devel \
 rust-tokio+io-util-devel \
 rust-tokio+net-devel \
 rust-tokio+rt-devel \
 rust-tokio+sync-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-sqlx-macros-core+uuid-devel = " \
 cargo \
 rust-sqlx-core+uuid-devel \
 rust-sqlx-macros-core-devel \
 rust-sqlx-mysql+default-devel \
 rust-sqlx-mysql+migrate-devel \
 rust-sqlx-mysql+offline-devel \
 rust-sqlx-mysql+uuid-devel \
 rust-sqlx-postgres+default-devel \
 rust-sqlx-postgres+migrate-devel \
 rust-sqlx-postgres+offline-devel \
 rust-sqlx-postgres+uuid-devel \
 rust-sqlx-sqlite+default-devel \
 rust-sqlx-sqlite+migrate-devel \
 rust-sqlx-sqlite+offline-devel \
 rust-sqlx-sqlite+uuid-devel \
 "
RDEPENDS:rust-sqlx-macros-core-devel = " \
 cargo \
 rust-dotenvy-devel \
 rust-either+default-devel \
 rust-heck+default-devel \
 rust-hex+default-devel \
 rust-once_cell+default-devel \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-sha2+default-devel \
 rust-sqlx-core+default-devel \
 rust-sqlx-core+offline-devel \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn-devel \
 rust-url+default-devel \
 "
