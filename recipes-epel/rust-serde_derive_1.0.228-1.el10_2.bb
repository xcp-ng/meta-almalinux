# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_derive"
PV = "1.0.228"
PR = "1.el10_2"
PACKAGES = " \
 rust-serde_derive+default-devel \
 rust-serde_derive+deserialize_in_place-devel \
 rust-serde_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_derive-1.0.228-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d2441c74cb89b5762dc2393d651ad86c9c32ed8cc2801e8d0848584a6e5629b7"

URI_x86_64_v2_rust-serde_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_derive+default-devel-1.0.228-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_derive+default-devel}"
SRC_URI[x86_64_v2_rust-serde_derive+default-devel.sha256sum] = "2bf007153227aadcc4a652c2638108b2d66f053f3f81e4191f85021f71c6c653"

URI_x86_64_v2_rust-serde_derive+deserialize_in_place-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_derive+deserialize_in_place-devel-1.0.228-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_derive+deserialize_in_place-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_derive+deserialize_in_place-devel}"
SRC_URI[x86_64_v2_rust-serde_derive+deserialize_in_place-devel.sha256sum] = "bfac9cabd68ce73ac3c3f38f8a00e30b1036f63fff7dcc14e7b9e98e146f7200"

URI_x86_64_v2_rust-serde_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_derive-devel-1.0.228-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_derive-devel}"
SRC_URI[x86_64_v2_rust-serde_derive-devel.sha256sum] = "6bcd71fbca8042abad5a9510815bd8d52298b0ba2c9f52b95e08f88cd786e355"

URI_aarch64_rust-serde_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_derive+default-devel-1.0.228-1.el10_2.noarch.rpm;name=aarch64_rust-serde_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_derive+default-devel}"
SRC_URI[aarch64_rust-serde_derive+default-devel.sha256sum] = "34b67adf815fb9250571e491058a006b4df08cd44246fa85aa423c30b33a332b"

URI_aarch64_rust-serde_derive+deserialize_in_place-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_derive+deserialize_in_place-devel-1.0.228-1.el10_2.noarch.rpm;name=aarch64_rust-serde_derive+deserialize_in_place-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_derive+deserialize_in_place-devel}"
SRC_URI[aarch64_rust-serde_derive+deserialize_in_place-devel.sha256sum] = "161ec03b0b57baa9dec43786d96817456667468cc27183ca8d5c92ef2ce70abf"

URI_aarch64_rust-serde_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_derive-devel-1.0.228-1.el10_2.noarch.rpm;name=aarch64_rust-serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_derive-devel}"
SRC_URI[aarch64_rust-serde_derive-devel.sha256sum] = "70e967c85f71906bce2d916db7edcf571ba7f157b8d97d18b1256c7b3196e29c"

RDEPENDS:rust-serde_derive+default-devel = " \
 cargo \
 rust-serde_derive-devel \
 "
RDEPENDS:rust-serde_derive+deserialize_in_place-devel = " \
 cargo \
 rust-serde_derive-devel \
 "
RDEPENDS:rust-serde_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+proc-macro-devel \
 rust-proc-macro2-devel \
 rust-quote+proc-macro-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
