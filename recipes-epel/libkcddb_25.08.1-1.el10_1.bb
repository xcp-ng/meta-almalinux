# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkcddb"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 libkcddb \
 libkcddb-devel \
 libkcddb-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkcddb-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "66fae88d25ec8cc62f0320270aecec3b9ceba4c6362c7a75ef1bbb18aaca18c8"

URI_x86_64_v2_libkcddb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkcddb-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkcddb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkcddb}"
SRC_URI[x86_64_v2_libkcddb.sha256sum] = "5a533a99bcd403c354f7060b3f488582f4c7bf37d22664070812a015f87713ba"

URI_x86_64_v2_libkcddb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkcddb-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkcddb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkcddb-devel}"
SRC_URI[x86_64_v2_libkcddb-devel.sha256sum] = "3f006b2418d8f5fe95c573ce07bce6620c780afd0618253f42d0421f2ca5b2fd"

URI_x86_64_v2_libkcddb-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkcddb-doc-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_libkcddb-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkcddb-doc}"
SRC_URI[x86_64_v2_libkcddb-doc.sha256sum] = "407a2f453afd039754050f78d0f15111882cd86e3f1f06b6597f1cc6b4bd257a"

URI_aarch64_libkcddb = "${EPEL_MIRROR}/aarch64/Packages/l/libkcddb-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_libkcddb;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkcddb}"
SRC_URI[aarch64_libkcddb.sha256sum] = "393f816ef84689e6e02c6efecbd6e12b67dfc78542afac90e48dc4a24fa654a0"

URI_aarch64_libkcddb-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkcddb-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_libkcddb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkcddb-devel}"
SRC_URI[aarch64_libkcddb-devel.sha256sum] = "09a9732fae02d7d8dc388368c2a795bb4fa557e8fd0c3d411992658fe5200e39"

URI_aarch64_libkcddb-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libkcddb-doc-25.08.1-1.el10_1.noarch.rpm;name=aarch64_libkcddb-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkcddb-doc}"
SRC_URI[aarch64_libkcddb-doc.sha256sum] = "9867236de43f26a4de9aa13aa6948418c7b0a8fcd8c065fc360079f4f73af23f"

RDEPENDS:libkcddb = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 libgcc \
 libkcddb-doc \
 libmusicbrainz5 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkcddb-devel = " \
 cmake-filesystem \
 libkcddb \
 "
RDEPENDS:libkcddb-doc = " \
 libkcddb \
 "
