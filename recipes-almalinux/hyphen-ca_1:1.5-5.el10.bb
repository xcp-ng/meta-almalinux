# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyphen-ca"
PE = "1"
PV = "1.5"
PR = "5.el10"
PACKAGES = " \
 hyphen-ca \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyphen-ca-1.5-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0904a792b82a6d5c60be92134d667ab0a3009988b36c101d8fe0dd7f0cea9e7"

URI_x86_64_v2_hyphen-ca = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-ca-1.5-5.el10.noarch.rpm;name=x86_64_v2_hyphen-ca;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyphen-ca}"
SRC_URI[x86_64_v2_hyphen-ca.sha256sum] = "63da1daa37d9d421e17651d5a27395ff188827a104711591b12ede163a0c6a20"

URI_aarch64_hyphen-ca = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-ca-1.5-5.el10.noarch.rpm;name=aarch64_hyphen-ca;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyphen-ca}"
SRC_URI[aarch64_hyphen-ca.sha256sum] = "63da1daa37d9d421e17651d5a27395ff188827a104711591b12ede163a0c6a20"

RDEPENDS:hyphen-ca = " \
 hyphen \
 "
