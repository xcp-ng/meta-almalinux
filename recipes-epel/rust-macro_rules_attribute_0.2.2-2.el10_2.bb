# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-macro_rules_attribute"
PV = "0.2.2"
PR = "2.el10_2"
PACKAGES = " \
 rust-macro_rules_attribute+better-docs-devel \
 rust-macro_rules_attribute+default-devel \
 rust-macro_rules_attribute+verbose-expansions-devel \
 rust-macro_rules_attribute-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-macro_rules_attribute-0.2.2-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f1626c915d5ddf42840e71aa68771e81ac88de5de51fe69de06add9998dd9e9c"

URI_x86_64_v2_rust-macro_rules_attribute+better-docs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-macro_rules_attribute+better-docs-devel-0.2.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-macro_rules_attribute+better-docs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-macro_rules_attribute+better-docs-devel}"
SRC_URI[x86_64_v2_rust-macro_rules_attribute+better-docs-devel.sha256sum] = "723d6c73362c460f1bb8c729872d1b24fd97b48f127d42194d99dc811e2603a0"

URI_x86_64_v2_rust-macro_rules_attribute+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-macro_rules_attribute+default-devel-0.2.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-macro_rules_attribute+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-macro_rules_attribute+default-devel}"
SRC_URI[x86_64_v2_rust-macro_rules_attribute+default-devel.sha256sum] = "ee07b258dfc5dfcda58d9ab11d06329e2fee93bc2fbafea9c5c3a44fd7830fbd"

URI_x86_64_v2_rust-macro_rules_attribute+verbose-expansions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-macro_rules_attribute+verbose-expansions-devel-0.2.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-macro_rules_attribute+verbose-expansions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-macro_rules_attribute+verbose-expansions-devel}"
SRC_URI[x86_64_v2_rust-macro_rules_attribute+verbose-expansions-devel.sha256sum] = "2c0ffbfb9d22a7757f2aeaaa896e47895cd1c2201e8f8288a8545155deadcf50"

URI_x86_64_v2_rust-macro_rules_attribute-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-macro_rules_attribute-devel-0.2.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-macro_rules_attribute-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-macro_rules_attribute-devel}"
SRC_URI[x86_64_v2_rust-macro_rules_attribute-devel.sha256sum] = "13425f3ae5e12091a67a6c17491edfe745d9a5482bbe34a77c5cf00b952b14ab"

URI_aarch64_rust-macro_rules_attribute+better-docs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-macro_rules_attribute+better-docs-devel-0.2.2-2.el10_2.noarch.rpm;name=aarch64_rust-macro_rules_attribute+better-docs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-macro_rules_attribute+better-docs-devel}"
SRC_URI[aarch64_rust-macro_rules_attribute+better-docs-devel.sha256sum] = "d8f19767b8e20353031044dc4f78f2a8c434d5d177876ab7a2130bf426c44368"

URI_aarch64_rust-macro_rules_attribute+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-macro_rules_attribute+default-devel-0.2.2-2.el10_2.noarch.rpm;name=aarch64_rust-macro_rules_attribute+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-macro_rules_attribute+default-devel}"
SRC_URI[aarch64_rust-macro_rules_attribute+default-devel.sha256sum] = "0fbe3bd5296ad6e93e2c7f9d90d2669a529b26c64e346b81d2ceb04507de1692"

URI_aarch64_rust-macro_rules_attribute+verbose-expansions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-macro_rules_attribute+verbose-expansions-devel-0.2.2-2.el10_2.noarch.rpm;name=aarch64_rust-macro_rules_attribute+verbose-expansions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-macro_rules_attribute+verbose-expansions-devel}"
SRC_URI[aarch64_rust-macro_rules_attribute+verbose-expansions-devel.sha256sum] = "ea2d8399b9ae46b9f86669e97d18fad959f82ff87de13ba0aadcf0926228147f"

URI_aarch64_rust-macro_rules_attribute-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-macro_rules_attribute-devel-0.2.2-2.el10_2.noarch.rpm;name=aarch64_rust-macro_rules_attribute-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-macro_rules_attribute-devel}"
SRC_URI[aarch64_rust-macro_rules_attribute-devel.sha256sum] = "efaf93f4f71c82cbebe984d289f85f4442ac8c32816ad332ef7370516b7a6957"

RDEPENDS:rust-macro_rules_attribute+better-docs-devel = " \
 cargo \
 rust-macro_rules_attribute-devel \
 "
RDEPENDS:rust-macro_rules_attribute+default-devel = " \
 cargo \
 rust-macro_rules_attribute-devel \
 "
RDEPENDS:rust-macro_rules_attribute+verbose-expansions-devel = " \
 cargo \
 rust-macro_rules_attribute-devel \
 rust-macro_rules_attribute-proc_macro+verbose-expansions-devel \
 "
RDEPENDS:rust-macro_rules_attribute-devel = " \
 cargo \
 rust-macro_rules_attribute-proc_macro+default-devel \
 rust-paste+default-devel \
 "
