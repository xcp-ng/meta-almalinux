# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-cucumber-messages"
PV = "17.1.0"
PR = "10.el10_1"
PACKAGES = " \
 rubygem-cucumber-messages \
 rubygem-cucumber-messages-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rubygem-cucumber-messages-17.1.0-10.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "08aeb1b14e6ee4de822c31427c373fc0bf8141e226d44e1a271091635039dbc7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-cucumber-messages-17.1.0-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-cucumber-messages;unpack=0"
SRC_URI[x86_64_v2_rubygem-cucumber-messages.sha256sum] = "513a345a45b29347f246ac0fe04e77f580bb018f54735afd4ccdea75c26f2a76"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-cucumber-messages-doc-17.1.0-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-cucumber-messages-doc;unpack=0"
SRC_URI[x86_64_v2_rubygem-cucumber-messages-doc.sha256sum] = "47e71b721e922cb4d2b167f3c67031487f9ca2b4d42ae408e37f8741f798fe6c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rubygem-cucumber-messages-17.1.0-10.el10_1.noarch.rpm;name=aarch64_rubygem-cucumber-messages;unpack=0"
SRC_URI[aarch64_rubygem-cucumber-messages.sha256sum] = "dc8b580d4475347b5069d864f07ee0cb0b2d98610a7d6873ba79346b0dbc9891"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rubygem-cucumber-messages-doc-17.1.0-10.el10_1.noarch.rpm;name=aarch64_rubygem-cucumber-messages-doc;unpack=0"
SRC_URI[aarch64_rubygem-cucumber-messages-doc.sha256sum] = "02ad2ffda50a9e1d51d363a8c293f16d6e32cb5d32441492d80ea5ca3f50c449"

RDEPENDS:rubygem-cucumber-messages = " \
 rubygems \
 "
RDEPENDS:rubygem-cucumber-messages-doc = " \
 rubygem-cucumber-messages \
 "
