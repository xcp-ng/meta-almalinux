# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Geography-Countries"
PV = "2009041301"
PR = "36.el10_0"
PACKAGES = " \
 perl-Geography-Countries \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Geography-Countries-2009041301-36.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9412941f879683c5313d11579bc643ffc42e64230b42a7e2d61f78416a8f0682"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Geography-Countries-2009041301-36.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Geography-Countries;unpack=0"
SRC_URI[x86_64_v2_perl-Geography-Countries.sha256sum] = "e957173586af498062836bc0a8b9307a292c96406fc8c4153a64c96ad3c87f6c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Geography-Countries-2009041301-36.el10_0.noarch.rpm;name=aarch64_perl-Geography-Countries;unpack=0"
SRC_URI[aarch64_perl-Geography-Countries.sha256sum] = "dae6a417b6403cf0bc63274f646add24870c8c5b8aaa9959d926e9db8e45d884"

RDEPENDS:perl-Geography-Countries = " \
 perl-Exporter \
 perl-constant \
 perl-libs \
 "
