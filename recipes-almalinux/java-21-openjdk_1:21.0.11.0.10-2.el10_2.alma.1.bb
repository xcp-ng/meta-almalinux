# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "java-21-openjdk"
PE = "1"
PV = "21.0.11.0.10"
PR = "2.el10_2.alma.1"
PACKAGES = " \
 java-21-openjdk \
 java-21-openjdk-demo \
 java-21-openjdk-demo-fastdebug \
 java-21-openjdk-demo-slowdebug \
 java-21-openjdk-devel \
 java-21-openjdk-devel-fastdebug \
 java-21-openjdk-devel-slowdebug \
 java-21-openjdk-fastdebug \
 java-21-openjdk-headless \
 java-21-openjdk-headless-fastdebug \
 java-21-openjdk-headless-slowdebug \
 java-21-openjdk-javadoc \
 java-21-openjdk-javadoc-zip \
 java-21-openjdk-jmods \
 java-21-openjdk-jmods-fastdebug \
 java-21-openjdk-jmods-slowdebug \
 java-21-openjdk-slowdebug \
 java-21-openjdk-src \
 java-21-openjdk-src-fastdebug \
 java-21-openjdk-src-slowdebug \
 java-21-openjdk-static-libs \
 java-21-openjdk-static-libs-fastdebug \
 java-21-openjdk-static-libs-slowdebug \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/java-21-openjdk-21.0.11.0.10-2.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b1c42893f507d331d372f76ea7504295a3fbc7e0700c0ecd8bca19b71153a1b4"

URI_x86_64_v2_java-21-openjdk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-21.0.11.0.10-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk}"
SRC_URI[x86_64_v2_java-21-openjdk.sha256sum] = "bb6f7f91fd7db8343f05e79ea062b0a21701ac5f4c3e5d3833835543ba3c5ea2"

URI_x86_64_v2_java-21-openjdk-demo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-demo-21.0.11.0.10-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-demo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-demo}"
SRC_URI[x86_64_v2_java-21-openjdk-demo.sha256sum] = "dff170dd4a2a98f748ebb32cc008c677b168bd622c6422e922a3cfea4b302728"

URI_x86_64_v2_java-21-openjdk-demo-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-demo-fastdebug-21.0.11.0.10-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-demo-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-demo-fastdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-demo-fastdebug.sha256sum] = "16fae92376e17339ca7f4e86963be1f595aa2b0de539434708c3cc223751a002"

URI_x86_64_v2_java-21-openjdk-demo-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-demo-slowdebug-21.0.11.0.10-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-demo-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-demo-slowdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-demo-slowdebug.sha256sum] = "f9587c81ed2906c76f30cb1ec1879cf19332a40b60e009864f43f1db4c88d244"

URI_x86_64_v2_java-21-openjdk-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-devel-21.0.11.0.10-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-devel}"
SRC_URI[x86_64_v2_java-21-openjdk-devel.sha256sum] = "53d03e0aef4516705b360dadf29514a2a965047acff1581d0b8fffe986ee44c3"

URI_x86_64_v2_java-21-openjdk-devel-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-devel-fastdebug-21.0.11.0.10-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-devel-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-devel-fastdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-devel-fastdebug.sha256sum] = "9e1ae6677e45c2da0e8805c604b02ef2e807c9f813aebedd269db3cce74da395"

URI_x86_64_v2_java-21-openjdk-devel-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-devel-slowdebug-21.0.11.0.10-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-devel-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-devel-slowdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-devel-slowdebug.sha256sum] = "e87136a13bc6d767eff7c24a35c549d8b3f8aac25bab7940e0da6241694eddb3"

URI_x86_64_v2_java-21-openjdk-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-fastdebug-21.0.11.0.10-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-fastdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-fastdebug.sha256sum] = "04027915aa3555a5de06d0b3dce6b9096f41512d466c59da58a0aab78a450bad"

URI_x86_64_v2_java-21-openjdk-headless = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-headless-21.0.11.0.10-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-headless;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-headless}"
SRC_URI[x86_64_v2_java-21-openjdk-headless.sha256sum] = "27fbd1d3563b5ac9b9771d64203c9beb96467f7e7fe601080efdd04ddd74f242"
RPROVIDES:java-21-openjdk-headless:x86_64_v2 = "virtual/java-headless_or_java-21-headless_or_java-25-headless"

URI_x86_64_v2_java-21-openjdk-headless-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-headless-fastdebug-21.0.11.0.10-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-headless-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-headless-fastdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-headless-fastdebug.sha256sum] = "b683675a6ddb052bed1b8392c2a1763e66ffce0f592fc0f34d306ba0851a3f45"

URI_x86_64_v2_java-21-openjdk-headless-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-headless-slowdebug-21.0.11.0.10-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-headless-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-headless-slowdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-headless-slowdebug.sha256sum] = "c7f34e8f7ec743a8afbc255bc4cbf27404c6bcd51871002f876d0e51663a7e58"

URI_x86_64_v2_java-21-openjdk-javadoc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-javadoc-21.0.11.0.10-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-javadoc}"
SRC_URI[x86_64_v2_java-21-openjdk-javadoc.sha256sum] = "154d56ea5bc43105652249ce45322b3c8f8e102d2d5c9e663d05697494936d03"

URI_x86_64_v2_java-21-openjdk-javadoc-zip = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-javadoc-zip-21.0.11.0.10-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-javadoc-zip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-javadoc-zip}"
SRC_URI[x86_64_v2_java-21-openjdk-javadoc-zip.sha256sum] = "13a8c3e562a07cdd29c8aa04120b0efa64b671228e345d1fe0206fbe99d2beb5"

URI_x86_64_v2_java-21-openjdk-jmods = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-jmods-21.0.11.0.10-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-jmods;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-jmods}"
SRC_URI[x86_64_v2_java-21-openjdk-jmods.sha256sum] = "b28f7f9ff101e429830a04f9a819bc088aa7c5cd2cd68cf214f711932f20eb3a"

URI_x86_64_v2_java-21-openjdk-jmods-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-jmods-fastdebug-21.0.11.0.10-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-jmods-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-jmods-fastdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-jmods-fastdebug.sha256sum] = "e72c462835597bb33dceecf16a47d9e48b832413d13c8d72b1b8179ed83a336a"

URI_x86_64_v2_java-21-openjdk-jmods-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-jmods-slowdebug-21.0.11.0.10-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-jmods-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-jmods-slowdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-jmods-slowdebug.sha256sum] = "f9fd6c635b3ffca78062974408ac28668974047d76c930dd12a516fbc915aac1"

URI_x86_64_v2_java-21-openjdk-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-slowdebug-21.0.11.0.10-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-slowdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-slowdebug.sha256sum] = "aa56891290231ad0b50d3c21f59d34712181abc6e51c62a1a21dc5538f74ecab"

URI_x86_64_v2_java-21-openjdk-src = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-src-21.0.11.0.10-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-src;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-src}"
SRC_URI[x86_64_v2_java-21-openjdk-src.sha256sum] = "4550eabf93518f620a22709333a62455d1954057c3ee649e26cabf03d7a499d7"

URI_x86_64_v2_java-21-openjdk-src-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-src-fastdebug-21.0.11.0.10-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-src-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-src-fastdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-src-fastdebug.sha256sum] = "fc827957e123c52c951770013a614dbc90ed735d5377c2c08cf43bafcd7bacf6"

URI_x86_64_v2_java-21-openjdk-src-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-src-slowdebug-21.0.11.0.10-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-src-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-src-slowdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-src-slowdebug.sha256sum] = "24abbb507808da318d8d425bdbebff1a4f7d2bc0c092a6918ff91954be39b5bf"

URI_x86_64_v2_java-21-openjdk-static-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-static-libs-21.0.11.0.10-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-static-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-static-libs}"
SRC_URI[x86_64_v2_java-21-openjdk-static-libs.sha256sum] = "d4b5b910d15d0b4e981fd2db9f42bd3cbb76035407c2dbd5f9528b6408b0e58e"

URI_x86_64_v2_java-21-openjdk-static-libs-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-static-libs-fastdebug-21.0.11.0.10-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-static-libs-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-static-libs-fastdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-static-libs-fastdebug.sha256sum] = "f16bc6c410726920e6fdf332a84b6c8a0226687eb1e24776e9f3ea305d2f1d2b"

URI_x86_64_v2_java-21-openjdk-static-libs-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-static-libs-slowdebug-21.0.11.0.10-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-static-libs-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-static-libs-slowdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-static-libs-slowdebug.sha256sum] = "e92ac49679404c69b05d41c6ba2ca261c56b25a37994e9e5b87e7a56eb968862"

URI_aarch64_java-21-openjdk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-21.0.11.0.10-2.el10_2.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk}"
SRC_URI[aarch64_java-21-openjdk.sha256sum] = "862048387c4fbed34070536295ccba672822facf48404c03f8906f31a1af1b68"

URI_aarch64_java-21-openjdk-demo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-demo-21.0.11.0.10-2.el10_2.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-demo;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-demo}"
SRC_URI[aarch64_java-21-openjdk-demo.sha256sum] = "7d2083d784b76ff315db9510e0d68821e637ac754477041176c5ebba7687d79e"

URI_aarch64_java-21-openjdk-demo-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-demo-fastdebug-21.0.11.0.10-2.el10_2.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-demo-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-demo-fastdebug}"
SRC_URI[aarch64_java-21-openjdk-demo-fastdebug.sha256sum] = "b4d0f42443ad64725a32f09b3cceb42fe39f3e9a45cb352252a7763642915c08"

URI_aarch64_java-21-openjdk-demo-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-demo-slowdebug-21.0.11.0.10-2.el10_2.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-demo-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-demo-slowdebug}"
SRC_URI[aarch64_java-21-openjdk-demo-slowdebug.sha256sum] = "9374fa66d3eaf19b6a6591e2d252c36c5882be74dccd8926da5a29e820ee1235"

URI_aarch64_java-21-openjdk-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-devel-21.0.11.0.10-2.el10_2.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-devel}"
SRC_URI[aarch64_java-21-openjdk-devel.sha256sum] = "7bf840fa7e8e0420489238760af052404309aa96a240b98f449b393497b48039"

URI_aarch64_java-21-openjdk-devel-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-devel-fastdebug-21.0.11.0.10-2.el10_2.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-devel-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-devel-fastdebug}"
SRC_URI[aarch64_java-21-openjdk-devel-fastdebug.sha256sum] = "46985d5cc0d3a742fbf7e288a9e92093243a2f5cf69a8a4128f7b5d77765c8de"

URI_aarch64_java-21-openjdk-devel-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-devel-slowdebug-21.0.11.0.10-2.el10_2.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-devel-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-devel-slowdebug}"
SRC_URI[aarch64_java-21-openjdk-devel-slowdebug.sha256sum] = "d560a8fb431fcef389667b2208861c42954b619170602a4f6fc896c94529f511"

URI_aarch64_java-21-openjdk-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-fastdebug-21.0.11.0.10-2.el10_2.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-fastdebug}"
SRC_URI[aarch64_java-21-openjdk-fastdebug.sha256sum] = "edb36d78ac399fb8a7534fd1da9752c62cb300f749ca40e929c4e56a166cf829"

URI_aarch64_java-21-openjdk-headless = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-headless-21.0.11.0.10-2.el10_2.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-headless;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-headless}"
SRC_URI[aarch64_java-21-openjdk-headless.sha256sum] = "f52da5abaa3d32cd88f30f41dbe7b16d99870881c6ca238a6a3a1692d66d42a1"
RPROVIDES:java-21-openjdk-headless:aarch64 = "virtual/java-headless_or_java-21-headless_or_java-25-headless"

URI_aarch64_java-21-openjdk-headless-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-headless-fastdebug-21.0.11.0.10-2.el10_2.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-headless-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-headless-fastdebug}"
SRC_URI[aarch64_java-21-openjdk-headless-fastdebug.sha256sum] = "7a8f2adfe3f82938afa72b5ad2c4a79050e2baf626f3bd7c0ea851ef207423bf"

URI_aarch64_java-21-openjdk-headless-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-headless-slowdebug-21.0.11.0.10-2.el10_2.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-headless-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-headless-slowdebug}"
SRC_URI[aarch64_java-21-openjdk-headless-slowdebug.sha256sum] = "d7bbbe782caf82cf9c722980a6a53f3252adfa8746e9e1097616426e7fcad6d3"

URI_aarch64_java-21-openjdk-javadoc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-javadoc-21.0.11.0.10-2.el10_2.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-javadoc}"
SRC_URI[aarch64_java-21-openjdk-javadoc.sha256sum] = "44d08c885bcfd550ca45c1ec96067a9a05016aa5d7369e7a2148187be1808e13"

URI_aarch64_java-21-openjdk-javadoc-zip = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-javadoc-zip-21.0.11.0.10-2.el10_2.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-javadoc-zip;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-javadoc-zip}"
SRC_URI[aarch64_java-21-openjdk-javadoc-zip.sha256sum] = "11fa1517da2cf0b104e81ea18fd325bca9ef7c6eff468e91d5191c7f14cc1d1f"

URI_aarch64_java-21-openjdk-jmods = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-jmods-21.0.11.0.10-2.el10_2.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-jmods;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-jmods}"
SRC_URI[aarch64_java-21-openjdk-jmods.sha256sum] = "536b51b9a6bbd3059d8958879264d1100237c781df23f0206da83c1e8771ba6d"

URI_aarch64_java-21-openjdk-jmods-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-jmods-fastdebug-21.0.11.0.10-2.el10_2.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-jmods-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-jmods-fastdebug}"
SRC_URI[aarch64_java-21-openjdk-jmods-fastdebug.sha256sum] = "f1ad086a0794a8ee0676a08bada04431f3011b03c83b83f811029580f820ea88"

URI_aarch64_java-21-openjdk-jmods-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-jmods-slowdebug-21.0.11.0.10-2.el10_2.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-jmods-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-jmods-slowdebug}"
SRC_URI[aarch64_java-21-openjdk-jmods-slowdebug.sha256sum] = "fc8152fdaec81532f1a8983a861c3bc75854305cd83cdf2512255c93bc3b86b2"

URI_aarch64_java-21-openjdk-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-slowdebug-21.0.11.0.10-2.el10_2.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-slowdebug}"
SRC_URI[aarch64_java-21-openjdk-slowdebug.sha256sum] = "ccfb5bf8770989aa523dd933abd2966708358dac2294b039760aa3038aed7b11"

URI_aarch64_java-21-openjdk-src = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-src-21.0.11.0.10-2.el10_2.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-src;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-src}"
SRC_URI[aarch64_java-21-openjdk-src.sha256sum] = "bec2368b2dabccefb7d2f77657fd855e0f84d4c5388bc74705b505ff798f9994"

URI_aarch64_java-21-openjdk-src-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-src-fastdebug-21.0.11.0.10-2.el10_2.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-src-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-src-fastdebug}"
SRC_URI[aarch64_java-21-openjdk-src-fastdebug.sha256sum] = "802462bf7853e355f1439118bf1aa89285932545bd0e5c66edee17f3ded761c7"

URI_aarch64_java-21-openjdk-src-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-src-slowdebug-21.0.11.0.10-2.el10_2.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-src-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-src-slowdebug}"
SRC_URI[aarch64_java-21-openjdk-src-slowdebug.sha256sum] = "e87ff82d5aac43668c92c87e1f51549481f56f5406a031347a45110c9a17ae08"

URI_aarch64_java-21-openjdk-static-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-static-libs-21.0.11.0.10-2.el10_2.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-static-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-static-libs}"
SRC_URI[aarch64_java-21-openjdk-static-libs.sha256sum] = "5023ce1cb4880329f8434319896f8172f8a29bec25b72fb388a00ed557d3e6d5"

URI_aarch64_java-21-openjdk-static-libs-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-static-libs-fastdebug-21.0.11.0.10-2.el10_2.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-static-libs-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-static-libs-fastdebug}"
SRC_URI[aarch64_java-21-openjdk-static-libs-fastdebug.sha256sum] = "6fd93a3eccd68e6f969be6355616de2aeb3bcfb405a189e8ee07d114cb44f2fe"

URI_aarch64_java-21-openjdk-static-libs-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-static-libs-slowdebug-21.0.11.0.10-2.el10_2.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-static-libs-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-static-libs-slowdebug}"
SRC_URI[aarch64_java-21-openjdk-static-libs-slowdebug.sha256sum] = "5efac86a23cfed84e6b2cd6a87b9c776fbffb1786cba55ed9cd71dd5cfc33693"

RDEPENDS:java-21-openjdk = " \
 bash \
 fontconfig \
 glibc \
 java-21-openjdk-headless \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-21-openjdk-demo = " \
 java-21-openjdk \
 "
RDEPENDS:java-21-openjdk-demo-fastdebug = " \
 java-21-openjdk-fastdebug \
 "
RDEPENDS:java-21-openjdk-demo-slowdebug = " \
 java-21-openjdk-slowdebug \
 "
RDEPENDS:java-21-openjdk-devel = " \
 alternatives \
 bash \
 glibc \
 java-21-openjdk \
 "
RDEPENDS:java-21-openjdk-devel-fastdebug = " \
 alternatives \
 bash \
 java-21-openjdk-fastdebug \
 "
RDEPENDS:java-21-openjdk-devel-slowdebug = " \
 alternatives \
 bash \
 java-21-openjdk-slowdebug \
 "
RDEPENDS:java-21-openjdk-fastdebug = " \
 bash \
 fontconfig \
 java-21-openjdk-headless-fastdebug \
 libXcomposite \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-21-openjdk-headless = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 javapackages-filesystem \
 lksctp-tools \
 nss \
 tzdata-java \
 "
RDEPENDS:java-21-openjdk-headless-fastdebug = " \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 javapackages-filesystem \
 lksctp-tools \
 nss \
 tzdata-java \
 "
RDEPENDS:java-21-openjdk-headless-slowdebug = " \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 javapackages-filesystem \
 lksctp-tools \
 nss \
 tzdata-java \
 "
RDEPENDS:java-21-openjdk-javadoc = " \
 alternatives \
 bash \
 java-21-openjdk-headless \
 javapackages-filesystem \
 "
RDEPENDS:java-21-openjdk-javadoc-zip = " \
 alternatives \
 bash \
 java-21-openjdk-headless \
 javapackages-filesystem \
 "
RDEPENDS:java-21-openjdk-jmods = " \
 java-21-openjdk-devel \
 "
RDEPENDS:java-21-openjdk-jmods-fastdebug = " \
 java-21-openjdk-devel-fastdebug \
 "
RDEPENDS:java-21-openjdk-jmods-slowdebug = " \
 java-21-openjdk-devel-slowdebug \
 "
RDEPENDS:java-21-openjdk-slowdebug = " \
 bash \
 fontconfig \
 java-21-openjdk-headless-slowdebug \
 libXcomposite \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-21-openjdk-src = " \
 java-21-openjdk-headless \
 "
RDEPENDS:java-21-openjdk-src-fastdebug = " \
 java-21-openjdk-headless-fastdebug \
 "
RDEPENDS:java-21-openjdk-src-slowdebug = " \
 java-21-openjdk-headless-slowdebug \
 "
RDEPENDS:java-21-openjdk-static-libs = " \
 java-21-openjdk-devel \
 "
RDEPENDS:java-21-openjdk-static-libs-fastdebug = " \
 java-21-openjdk-devel-fastdebug \
 "
RDEPENDS:java-21-openjdk-static-libs-slowdebug = " \
 java-21-openjdk-devel-slowdebug \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/java-headless_or_java-21-headless_or_java-25-headless"

PROVIDES:append:aarch64 = " rpm/virtual/java-headless_or_java-21-headless_or_java-25-headless"
