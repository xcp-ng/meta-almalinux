# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unicode-width"
PV = "0.2.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-unicode-width+cjk-devel \
 rust-unicode-width+default-devel \
 rust-unicode-width+no_std-devel \
 rust-unicode-width-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unicode-width-0.2.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cbe063513ce15e8f188ff4dfd63a31be67e621d5a055686137409737cfd4b9e4"

URI_x86_64_v2_rust-unicode-width+cjk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-width+cjk-devel-0.2.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-width+cjk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-width+cjk-devel}"
SRC_URI[x86_64_v2_rust-unicode-width+cjk-devel.sha256sum] = "ca78e617263b7528ab553a7233bc296f4f19a7f0f9b3c94bc9acd8a1ab61e9dc"

URI_x86_64_v2_rust-unicode-width+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-width+default-devel-0.2.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-width+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-width+default-devel}"
SRC_URI[x86_64_v2_rust-unicode-width+default-devel.sha256sum] = "cf757ddc72e33d5c7b7a4e1c0b08a95c96ac0fef4d3acf79ea0c4c16481229b0"
RPROVIDES:rust-unicode-width+default-devel:x86_64_v2 = "virtual/crate_unicode-width/default__ge_0.0.0_with_crate_unicode-width/default__lt_1.0.0~ virtual/crate_unicode-width/default__ge_0.1.0_with_crate_unicode-width/default__lt_0.3.0~"

URI_x86_64_v2_rust-unicode-width+no_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-width+no_std-devel-0.2.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-width+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-width+no_std-devel}"
SRC_URI[x86_64_v2_rust-unicode-width+no_std-devel.sha256sum] = "d109fe7aa6d897bff302bff3872d50958948f54b9a671caf38ff6546908cfeeb"

URI_x86_64_v2_rust-unicode-width-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-width-devel-0.2.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-width-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-width-devel}"
SRC_URI[x86_64_v2_rust-unicode-width-devel.sha256sum] = "981a1096605b95f9e55ddd745104885a1d827caf066216e19fb83d60056c47fb"

URI_aarch64_rust-unicode-width+cjk-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-width+cjk-devel-0.2.2-1.el10_1.noarch.rpm;name=aarch64_rust-unicode-width+cjk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-width+cjk-devel}"
SRC_URI[aarch64_rust-unicode-width+cjk-devel.sha256sum] = "d8a65a6c83029b810f1227d77495f282b580e4a8c4363ee6314b23214932a62d"

URI_aarch64_rust-unicode-width+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-width+default-devel-0.2.2-1.el10_1.noarch.rpm;name=aarch64_rust-unicode-width+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-width+default-devel}"
SRC_URI[aarch64_rust-unicode-width+default-devel.sha256sum] = "8afad16475bc79a8287038e4cb51807e3ff0a78c76238b4777798dcbe249a4f7"
RPROVIDES:rust-unicode-width+default-devel:aarch64 = "virtual/crate_unicode-width/default__ge_0.0.0_with_crate_unicode-width/default__lt_1.0.0~ virtual/crate_unicode-width/default__ge_0.1.0_with_crate_unicode-width/default__lt_0.3.0~"

URI_aarch64_rust-unicode-width+no_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-width+no_std-devel-0.2.2-1.el10_1.noarch.rpm;name=aarch64_rust-unicode-width+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-width+no_std-devel}"
SRC_URI[aarch64_rust-unicode-width+no_std-devel.sha256sum] = "fc60667830cb2accd6e93cb806b4b3e234231aba2e6dcf7830e1bdc88f015b85"

URI_aarch64_rust-unicode-width-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-width-devel-0.2.2-1.el10_1.noarch.rpm;name=aarch64_rust-unicode-width-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-width-devel}"
SRC_URI[aarch64_rust-unicode-width-devel.sha256sum] = "778b27fe0aae7c390d1ccb7b9e202970ce860e5a16569e18cd31ec9ffbf7c5f7"

RDEPENDS:rust-unicode-width+cjk-devel = " \
 cargo \
 rust-unicode-width-devel \
 "
RDEPENDS:rust-unicode-width+default-devel = " \
 cargo \
 rust-unicode-width+cjk-devel \
 rust-unicode-width-devel \
 "
RDEPENDS:rust-unicode-width+no_std-devel = " \
 cargo \
 rust-unicode-width-devel \
 "
RDEPENDS:rust-unicode-width-devel = " \
 cargo \
 rust \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_unicode-width/default__ge_0.0.0_with_crate_unicode-width/default__lt_1.0.0~ rpm/virtual/crate_unicode-width/default__ge_0.1.0_with_crate_unicode-width/default__lt_0.3.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_unicode-width/default__ge_0.0.0_with_crate_unicode-width/default__lt_1.0.0~ rpm/virtual/crate_unicode-width/default__ge_0.1.0_with_crate_unicode-width/default__lt_0.3.0~"
