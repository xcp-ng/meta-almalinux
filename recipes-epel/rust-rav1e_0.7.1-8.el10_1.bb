# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rav1e"
PV = "0.7.1"
PR = "8.el10_1"
PACKAGES = " \
 rav1e \
 rav1e-devel \
 rav1e-libs \
 rust-rav1e+asm-devel \
 rust-rav1e+av-metrics-devel \
 rust-rav1e+backtrace-devel \
 rust-rav1e+binaries-devel \
 rust-rav1e+capi-devel \
 rust-rav1e+cc-devel \
 rust-rav1e+channel-api-devel \
 rust-rav1e+check_asm-devel \
 rust-rav1e+clap-devel \
 rust-rav1e+clap_complete-devel \
 rust-rav1e+console-devel \
 rust-rav1e+crossbeam-devel \
 rust-rav1e+default-devel \
 rust-rav1e+desync_finder-devel \
 rust-rav1e+dump_ivf-devel \
 rust-rav1e+fern-devel \
 rust-rav1e+ivf-devel \
 rust-rav1e+nasm-rs-devel \
 rust-rav1e+nom-devel \
 rust-rav1e+quick_test-devel \
 rust-rav1e+scan_fmt-devel \
 rust-rav1e+scenechange-devel \
 rust-rav1e+serde-big-array-devel \
 rust-rav1e+serde-devel \
 rust-rav1e+serialize-devel \
 rust-rav1e+signal-hook-devel \
 rust-rav1e+signal_support-devel \
 rust-rav1e+threading-devel \
 rust-rav1e+toml-devel \
 rust-rav1e+unstable-devel \
 rust-rav1e+y4m-devel \
 rust-rav1e-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rav1e-0.7.1-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2492ab6ce44d2f41dbdf536499a00bdcc451f52089fb0e2eda878ce3644c9a6a"

URI_x86_64_v2_rav1e = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rav1e-0.7.1-8.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rav1e;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rav1e}"
SRC_URI[x86_64_v2_rav1e.sha256sum] = "e1bab08c5b4e61f8098eef2d16946f4414e8893d065c308943f30d9750cc70bc"

URI_x86_64_v2_rav1e-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rav1e-devel-0.7.1-8.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rav1e-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rav1e-devel}"
SRC_URI[x86_64_v2_rav1e-devel.sha256sum] = "b0ea6c3ce2937efc6f11bd293d0d661decc8f72f3b3ee591eb83996d11632217"

URI_x86_64_v2_rav1e-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rav1e-libs-0.7.1-8.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rav1e-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rav1e-libs}"
SRC_URI[x86_64_v2_rav1e-libs.sha256sum] = "9838c2a59569650f7bed27c17c008bff50ce2ec6cdd5f373e2a5b9f1c30cd416"

URI_x86_64_v2_rust-rav1e+asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+asm-devel-0.7.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+asm-devel}"
SRC_URI[x86_64_v2_rust-rav1e+asm-devel.sha256sum] = "3832e6c0abcd72b09272d4155bf31402bbfd0349eef61667a8fa7671727d1831"

URI_x86_64_v2_rust-rav1e+av-metrics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+av-metrics-devel-0.7.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+av-metrics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+av-metrics-devel}"
SRC_URI[x86_64_v2_rust-rav1e+av-metrics-devel.sha256sum] = "337c2d6dc5959cec0ee6e4eccf7ff3f9ffe03f15d90792c1981e38504bd1e589"

URI_x86_64_v2_rust-rav1e+backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+backtrace-devel-0.7.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+backtrace-devel}"
SRC_URI[x86_64_v2_rust-rav1e+backtrace-devel.sha256sum] = "430b53c0927c670946ae212e5ee14a1b783fbb75b41705a917fc26d4ab702ac6"

URI_x86_64_v2_rust-rav1e+binaries-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+binaries-devel-0.7.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+binaries-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+binaries-devel}"
SRC_URI[x86_64_v2_rust-rav1e+binaries-devel.sha256sum] = "ae91ce05fb63458d293da1f4be54fe9f52ab85bbb623c4ee0c0fa22cc9e13025"

URI_x86_64_v2_rust-rav1e+capi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+capi-devel-0.7.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+capi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+capi-devel}"
SRC_URI[x86_64_v2_rust-rav1e+capi-devel.sha256sum] = "0d4b5ffca9e8c839e789e840473ae32184112c21c43dd7b30f1fe46b2365c77e"

URI_x86_64_v2_rust-rav1e+cc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+cc-devel-0.7.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+cc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+cc-devel}"
SRC_URI[x86_64_v2_rust-rav1e+cc-devel.sha256sum] = "73f7cb03eb577cfa8000043bb6659e46a3b681f237ad9d100f761ccfb6a8f20e"

URI_x86_64_v2_rust-rav1e+channel-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+channel-api-devel-0.7.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+channel-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+channel-api-devel}"
SRC_URI[x86_64_v2_rust-rav1e+channel-api-devel.sha256sum] = "d16ff9707e5120f72f18e7a07f082e284ea01c7e8dde5e2d2d284a2fe18e4525"

URI_x86_64_v2_rust-rav1e+check_asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+check_asm-devel-0.7.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+check_asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+check_asm-devel}"
SRC_URI[x86_64_v2_rust-rav1e+check_asm-devel.sha256sum] = "8c568d6e3d6a3c2a9ff3c834ac255b3afea0dbee23fca92c358d09e98533aefe"

URI_x86_64_v2_rust-rav1e+clap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+clap-devel-0.7.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+clap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+clap-devel}"
SRC_URI[x86_64_v2_rust-rav1e+clap-devel.sha256sum] = "9452f8f587b8c4a7d28acb77b5875ac2a4617524304294c4a0f92cd2bd513775"

URI_x86_64_v2_rust-rav1e+clap_complete-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+clap_complete-devel-0.7.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+clap_complete-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+clap_complete-devel}"
SRC_URI[x86_64_v2_rust-rav1e+clap_complete-devel.sha256sum] = "ae53149a853543c27651229e9f48ccbcfed0a2235d0f13a5633198e7eefb55ef"

URI_x86_64_v2_rust-rav1e+console-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+console-devel-0.7.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+console-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+console-devel}"
SRC_URI[x86_64_v2_rust-rav1e+console-devel.sha256sum] = "887c6fe2041284973f932d8164aba3c7e2f5bdcb70e09659d60fde407352318a"

URI_x86_64_v2_rust-rav1e+crossbeam-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+crossbeam-devel-0.7.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+crossbeam-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+crossbeam-devel}"
SRC_URI[x86_64_v2_rust-rav1e+crossbeam-devel.sha256sum] = "ebca305cf10d22d84322f2bb589934b1443975c91d4f260567fa5ff879971e93"

URI_x86_64_v2_rust-rav1e+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+default-devel-0.7.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+default-devel}"
SRC_URI[x86_64_v2_rust-rav1e+default-devel.sha256sum] = "532c190b15753167257f76caaae9f02e8a9f9327bf035a3f83ccf498c03aea27"

URI_x86_64_v2_rust-rav1e+desync_finder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+desync_finder-devel-0.7.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+desync_finder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+desync_finder-devel}"
SRC_URI[x86_64_v2_rust-rav1e+desync_finder-devel.sha256sum] = "06f565b19c2992514b90045816993e359ae86ad1922e63aae9e49f49a9397bd9"

URI_x86_64_v2_rust-rav1e+dump_ivf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+dump_ivf-devel-0.7.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+dump_ivf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+dump_ivf-devel}"
SRC_URI[x86_64_v2_rust-rav1e+dump_ivf-devel.sha256sum] = "3b9d9383a352eb3aa553a5827ece92e7b0dfd88e443152d90399fe2581a513e9"

URI_x86_64_v2_rust-rav1e+fern-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+fern-devel-0.7.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+fern-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+fern-devel}"
SRC_URI[x86_64_v2_rust-rav1e+fern-devel.sha256sum] = "3853b2d8c5812dce74c8a1e7f63fd4a1e7afb705906824be550e52881a62a564"

URI_x86_64_v2_rust-rav1e+ivf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+ivf-devel-0.7.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+ivf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+ivf-devel}"
SRC_URI[x86_64_v2_rust-rav1e+ivf-devel.sha256sum] = "86bacd11e70ff85becaaf9e3edf97cc2033bf6a26eae72e6d75989b851559fc0"

URI_x86_64_v2_rust-rav1e+nasm-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+nasm-rs-devel-0.7.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+nasm-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+nasm-rs-devel}"
SRC_URI[x86_64_v2_rust-rav1e+nasm-rs-devel.sha256sum] = "509657afe903552e2955289e11b31abd96b84ff9bc15caf070d5966fdc92a959"

URI_x86_64_v2_rust-rav1e+nom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+nom-devel-0.7.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+nom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+nom-devel}"
SRC_URI[x86_64_v2_rust-rav1e+nom-devel.sha256sum] = "bc75e1ea1228646b576da667b6b2222197c4a24c6fd0b5764f4326432793d1c7"

URI_x86_64_v2_rust-rav1e+quick_test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+quick_test-devel-0.7.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+quick_test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+quick_test-devel}"
SRC_URI[x86_64_v2_rust-rav1e+quick_test-devel.sha256sum] = "40473f4149ae89cc342fec74de1573d09056f7fdae3e14ee53a6aa80b8de4412"

URI_x86_64_v2_rust-rav1e+scan_fmt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+scan_fmt-devel-0.7.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+scan_fmt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+scan_fmt-devel}"
SRC_URI[x86_64_v2_rust-rav1e+scan_fmt-devel.sha256sum] = "a3fda832e0a93490ee7b090029300cb11094f7e93c1feacc86e5e77236ddb124"

URI_x86_64_v2_rust-rav1e+scenechange-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+scenechange-devel-0.7.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+scenechange-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+scenechange-devel}"
SRC_URI[x86_64_v2_rust-rav1e+scenechange-devel.sha256sum] = "b099cbdc1ccc4eda7b2ce5a90aa505c72acdcb431351d1eb0d50f360c0406a3f"

URI_x86_64_v2_rust-rav1e+serde-big-array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+serde-big-array-devel-0.7.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+serde-big-array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+serde-big-array-devel}"
SRC_URI[x86_64_v2_rust-rav1e+serde-big-array-devel.sha256sum] = "c224524fc8c374465248f929b395a306180cfa7ddde2a1dcccbbb1ae785612e6"

URI_x86_64_v2_rust-rav1e+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+serde-devel-0.7.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+serde-devel}"
SRC_URI[x86_64_v2_rust-rav1e+serde-devel.sha256sum] = "d50a4152b8ba434e60553117692f11b99944dc90aa3d97c2db0acd47e96a4bbe"

URI_x86_64_v2_rust-rav1e+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+serialize-devel-0.7.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+serialize-devel}"
SRC_URI[x86_64_v2_rust-rav1e+serialize-devel.sha256sum] = "e29e686eae5d3eb70ad63e6a52032ab6c511d490d8d2bc031ae1488559e4625f"

URI_x86_64_v2_rust-rav1e+signal-hook-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+signal-hook-devel-0.7.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+signal-hook-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+signal-hook-devel}"
SRC_URI[x86_64_v2_rust-rav1e+signal-hook-devel.sha256sum] = "cedc799eb78492f57156a5398384109a9bd9b346fade4d9cbf8d6d9f67544c75"

URI_x86_64_v2_rust-rav1e+signal_support-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+signal_support-devel-0.7.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+signal_support-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+signal_support-devel}"
SRC_URI[x86_64_v2_rust-rav1e+signal_support-devel.sha256sum] = "0dfbf9214fcbf98e3250093caaf69c86b21d92be07ad32e4cb868f37af9e24ad"

URI_x86_64_v2_rust-rav1e+threading-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+threading-devel-0.7.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+threading-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+threading-devel}"
SRC_URI[x86_64_v2_rust-rav1e+threading-devel.sha256sum] = "8ffb9fe85338bf6f7610299d675493b05e9dc79e4e43e78e4d50bcdef2af6485"

URI_x86_64_v2_rust-rav1e+toml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+toml-devel-0.7.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+toml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+toml-devel}"
SRC_URI[x86_64_v2_rust-rav1e+toml-devel.sha256sum] = "535e8e9b4f36d1e00b8eb56e0af254aa32ae3aca2ad2c0f36775d8a9555be3c9"

URI_x86_64_v2_rust-rav1e+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+unstable-devel-0.7.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+unstable-devel}"
SRC_URI[x86_64_v2_rust-rav1e+unstable-devel.sha256sum] = "f63d12f45c531f25904e30e8b0737d3e00b2abf11bb253fefbbe55d8d71af84a"

URI_x86_64_v2_rust-rav1e+y4m-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e+y4m-devel-0.7.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e+y4m-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e+y4m-devel}"
SRC_URI[x86_64_v2_rust-rav1e+y4m-devel.sha256sum] = "c1d9184323cfd6b4da9178003cadeeffa27c285d2507e351ebb1e61dee249a77"

URI_x86_64_v2_rust-rav1e-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rav1e-devel-0.7.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rav1e-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rav1e-devel}"
SRC_URI[x86_64_v2_rust-rav1e-devel.sha256sum] = "f30470990f25dfbe0a84ec461be2c3f572a181c5debc56ba8acb3e5f18bc4050"

URI_aarch64_rav1e = "${EPEL_MIRROR}/aarch64/Packages/r/rav1e-0.7.1-8.el10_1.aarch64.rpm;name=aarch64_rav1e;unpack=0"
SRC_URI:append = " ${URI_aarch64_rav1e}"
SRC_URI[aarch64_rav1e.sha256sum] = "db78735fe342e79e5265d1773c635a9142ec1bb43db3efcb558b37e1158e0fda"

URI_aarch64_rav1e-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rav1e-devel-0.7.1-8.el10_1.aarch64.rpm;name=aarch64_rav1e-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rav1e-devel}"
SRC_URI[aarch64_rav1e-devel.sha256sum] = "515185782aea03d184b0f9d225992d580714549efdaf26c8c02c7cc48a8d7cf0"

URI_aarch64_rav1e-libs = "${EPEL_MIRROR}/aarch64/Packages/r/rav1e-libs-0.7.1-8.el10_1.aarch64.rpm;name=aarch64_rav1e-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_rav1e-libs}"
SRC_URI[aarch64_rav1e-libs.sha256sum] = "2f8f821c8c889a28f6dbe082251e89e7cb33943333428ebb92dde1055f23f46b"

URI_aarch64_rust-rav1e+asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+asm-devel-0.7.1-8.el10_1.noarch.rpm;name=aarch64_rust-rav1e+asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+asm-devel}"
SRC_URI[aarch64_rust-rav1e+asm-devel.sha256sum] = "a5444ba098e1b5b1a3986cb46b1e4e749f31c3f2e1ca280cf25ecd76e83ed6a9"

URI_aarch64_rust-rav1e+av-metrics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+av-metrics-devel-0.7.1-8.el10_1.noarch.rpm;name=aarch64_rust-rav1e+av-metrics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+av-metrics-devel}"
SRC_URI[aarch64_rust-rav1e+av-metrics-devel.sha256sum] = "e1a4d8823670024984e24e262028d99e8ceab1ca2ec8682bb3d45acca1a2694a"

URI_aarch64_rust-rav1e+backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+backtrace-devel-0.7.1-8.el10_1.noarch.rpm;name=aarch64_rust-rav1e+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+backtrace-devel}"
SRC_URI[aarch64_rust-rav1e+backtrace-devel.sha256sum] = "ee633beec386cece924b0e4a18c37344d2f25995a7095d5e34c2364df8174a30"

URI_aarch64_rust-rav1e+binaries-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+binaries-devel-0.7.1-8.el10_1.noarch.rpm;name=aarch64_rust-rav1e+binaries-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+binaries-devel}"
SRC_URI[aarch64_rust-rav1e+binaries-devel.sha256sum] = "6a24f1030386e4bad4455ab5771224e79d64eff6933f855c6c81d4fc75b2a214"

URI_aarch64_rust-rav1e+capi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+capi-devel-0.7.1-8.el10_1.noarch.rpm;name=aarch64_rust-rav1e+capi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+capi-devel}"
SRC_URI[aarch64_rust-rav1e+capi-devel.sha256sum] = "40b5a265567db67df50e74adab6e2e44a0fe1edb5336b0951d7d8f826a2e4bce"

URI_aarch64_rust-rav1e+cc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+cc-devel-0.7.1-8.el10_1.noarch.rpm;name=aarch64_rust-rav1e+cc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+cc-devel}"
SRC_URI[aarch64_rust-rav1e+cc-devel.sha256sum] = "72a2638fdeeeb1d7c4f54bea45e757cdff26421f6fb42499dc79f75b760a08d9"

URI_aarch64_rust-rav1e+channel-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+channel-api-devel-0.7.1-8.el10_1.noarch.rpm;name=aarch64_rust-rav1e+channel-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+channel-api-devel}"
SRC_URI[aarch64_rust-rav1e+channel-api-devel.sha256sum] = "e65348c76d8a4cfb99ca86a10d77f0ee8e1d5546efb81814cbe937332a4ac695"

URI_aarch64_rust-rav1e+check_asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+check_asm-devel-0.7.1-8.el10_1.noarch.rpm;name=aarch64_rust-rav1e+check_asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+check_asm-devel}"
SRC_URI[aarch64_rust-rav1e+check_asm-devel.sha256sum] = "b2ef61775ff6c696671dd55f80d6091f918cfb37f4e9c7bb9b762e039d0e462e"

URI_aarch64_rust-rav1e+clap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+clap-devel-0.7.1-8.el10_1.noarch.rpm;name=aarch64_rust-rav1e+clap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+clap-devel}"
SRC_URI[aarch64_rust-rav1e+clap-devel.sha256sum] = "573119399f39b006b895ccffb8ab8199d12e3257811f2a9de350a3fe88d667dc"

URI_aarch64_rust-rav1e+clap_complete-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+clap_complete-devel-0.7.1-8.el10_1.noarch.rpm;name=aarch64_rust-rav1e+clap_complete-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+clap_complete-devel}"
SRC_URI[aarch64_rust-rav1e+clap_complete-devel.sha256sum] = "b3f26f0467e656e3790b49068dca5a410a5a2f5b76e5f82049fbbf176686af33"

URI_aarch64_rust-rav1e+console-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+console-devel-0.7.1-8.el10_1.noarch.rpm;name=aarch64_rust-rav1e+console-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+console-devel}"
SRC_URI[aarch64_rust-rav1e+console-devel.sha256sum] = "ecf23758afd62299bb44b9c5e64afb37db4589fb8aa766ed1a6bbe4e3743adef"

URI_aarch64_rust-rav1e+crossbeam-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+crossbeam-devel-0.7.1-8.el10_1.noarch.rpm;name=aarch64_rust-rav1e+crossbeam-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+crossbeam-devel}"
SRC_URI[aarch64_rust-rav1e+crossbeam-devel.sha256sum] = "c3445391acadcb7e15b8f362fd0bd44eff950f0ac719f36bb5f2a270c354a4b4"

URI_aarch64_rust-rav1e+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+default-devel-0.7.1-8.el10_1.noarch.rpm;name=aarch64_rust-rav1e+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+default-devel}"
SRC_URI[aarch64_rust-rav1e+default-devel.sha256sum] = "870f6bc246a4406e076eb44bf09db3d0a250d972147a2f1556e47e418feacf64"

URI_aarch64_rust-rav1e+desync_finder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+desync_finder-devel-0.7.1-8.el10_1.noarch.rpm;name=aarch64_rust-rav1e+desync_finder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+desync_finder-devel}"
SRC_URI[aarch64_rust-rav1e+desync_finder-devel.sha256sum] = "fcb2871b19fac74bc57760f75d33aefd7e1928771e5dbf6a3ad1572b0b64134b"

URI_aarch64_rust-rav1e+dump_ivf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+dump_ivf-devel-0.7.1-8.el10_1.noarch.rpm;name=aarch64_rust-rav1e+dump_ivf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+dump_ivf-devel}"
SRC_URI[aarch64_rust-rav1e+dump_ivf-devel.sha256sum] = "53684df97fa515f6d477f90bb6582e4b158b41fc883aab808f211cfdd8509177"

URI_aarch64_rust-rav1e+fern-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+fern-devel-0.7.1-8.el10_1.noarch.rpm;name=aarch64_rust-rav1e+fern-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+fern-devel}"
SRC_URI[aarch64_rust-rav1e+fern-devel.sha256sum] = "1aba7a30a5802a6e45953cefc781274390c596d927ef1f859b1327a75d019f88"

URI_aarch64_rust-rav1e+ivf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+ivf-devel-0.7.1-8.el10_1.noarch.rpm;name=aarch64_rust-rav1e+ivf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+ivf-devel}"
SRC_URI[aarch64_rust-rav1e+ivf-devel.sha256sum] = "43503befcaf69a5463aed08fb8393c15110c9b53aeb68e499214a3d88f338df5"

URI_aarch64_rust-rav1e+nasm-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+nasm-rs-devel-0.7.1-8.el10_1.noarch.rpm;name=aarch64_rust-rav1e+nasm-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+nasm-rs-devel}"
SRC_URI[aarch64_rust-rav1e+nasm-rs-devel.sha256sum] = "a6ea5992e95eeb57295ee34638bab16deee09b060792c444c855316610f81299"

URI_aarch64_rust-rav1e+nom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+nom-devel-0.7.1-8.el10_1.noarch.rpm;name=aarch64_rust-rav1e+nom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+nom-devel}"
SRC_URI[aarch64_rust-rav1e+nom-devel.sha256sum] = "d0219cd66cb3b4dc81faeb307cc267c156fe3db5e3f4791a9434f8229cd5ddb0"

URI_aarch64_rust-rav1e+quick_test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+quick_test-devel-0.7.1-8.el10_1.noarch.rpm;name=aarch64_rust-rav1e+quick_test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+quick_test-devel}"
SRC_URI[aarch64_rust-rav1e+quick_test-devel.sha256sum] = "e2220148cd4cf0e115f6ba2794dc0c0a11f7e6221482ffe0f4a887f0c30e064a"

URI_aarch64_rust-rav1e+scan_fmt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+scan_fmt-devel-0.7.1-8.el10_1.noarch.rpm;name=aarch64_rust-rav1e+scan_fmt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+scan_fmt-devel}"
SRC_URI[aarch64_rust-rav1e+scan_fmt-devel.sha256sum] = "ddcd4954b15887034e80d17cd4e1158f5214c05d9fc0524ea06b4df0c0946f4b"

URI_aarch64_rust-rav1e+scenechange-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+scenechange-devel-0.7.1-8.el10_1.noarch.rpm;name=aarch64_rust-rav1e+scenechange-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+scenechange-devel}"
SRC_URI[aarch64_rust-rav1e+scenechange-devel.sha256sum] = "26c9e51acdf13940041924c334acedd0187f8fa822ae942cbbbb8b2aa91d4fca"

URI_aarch64_rust-rav1e+serde-big-array-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+serde-big-array-devel-0.7.1-8.el10_1.noarch.rpm;name=aarch64_rust-rav1e+serde-big-array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+serde-big-array-devel}"
SRC_URI[aarch64_rust-rav1e+serde-big-array-devel.sha256sum] = "848131be4bf72e81d2c458cc06e92bfba1f442fb6cceaabc5e78d12cdd051780"

URI_aarch64_rust-rav1e+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+serde-devel-0.7.1-8.el10_1.noarch.rpm;name=aarch64_rust-rav1e+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+serde-devel}"
SRC_URI[aarch64_rust-rav1e+serde-devel.sha256sum] = "745c10a39327d666e3918a1b9c0044e288c61506267262c862dbd2330100e97e"

URI_aarch64_rust-rav1e+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+serialize-devel-0.7.1-8.el10_1.noarch.rpm;name=aarch64_rust-rav1e+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+serialize-devel}"
SRC_URI[aarch64_rust-rav1e+serialize-devel.sha256sum] = "5dd878a38aec9a2308efbe7eb6c021f9d84f5ba3485c7fa6c569fe6287f3fd42"

URI_aarch64_rust-rav1e+signal-hook-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+signal-hook-devel-0.7.1-8.el10_1.noarch.rpm;name=aarch64_rust-rav1e+signal-hook-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+signal-hook-devel}"
SRC_URI[aarch64_rust-rav1e+signal-hook-devel.sha256sum] = "81cdf090a83dd304c1736077352c5469a1d2f8fb97725d6afe3de014c06144c7"

URI_aarch64_rust-rav1e+signal_support-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+signal_support-devel-0.7.1-8.el10_1.noarch.rpm;name=aarch64_rust-rav1e+signal_support-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+signal_support-devel}"
SRC_URI[aarch64_rust-rav1e+signal_support-devel.sha256sum] = "10cf329ddb96db53118d907c25963f9040db364edf961bbb963b2b07084926fc"

URI_aarch64_rust-rav1e+threading-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+threading-devel-0.7.1-8.el10_1.noarch.rpm;name=aarch64_rust-rav1e+threading-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+threading-devel}"
SRC_URI[aarch64_rust-rav1e+threading-devel.sha256sum] = "52c5010b9046efea0d7e40388dff010bc96de6d8912a5f1a2b8f5a43d3c4a54c"

URI_aarch64_rust-rav1e+toml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+toml-devel-0.7.1-8.el10_1.noarch.rpm;name=aarch64_rust-rav1e+toml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+toml-devel}"
SRC_URI[aarch64_rust-rav1e+toml-devel.sha256sum] = "8aec3790bfd1cfdee3b4b584b2f1e17abb58a647acf227580cf8bfe9b24ec5dc"

URI_aarch64_rust-rav1e+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+unstable-devel-0.7.1-8.el10_1.noarch.rpm;name=aarch64_rust-rav1e+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+unstable-devel}"
SRC_URI[aarch64_rust-rav1e+unstable-devel.sha256sum] = "d0166c04f66b488f6e7e79bf61edb7d5178b51d657818bf7b818da1e3e60016a"

URI_aarch64_rust-rav1e+y4m-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e+y4m-devel-0.7.1-8.el10_1.noarch.rpm;name=aarch64_rust-rav1e+y4m-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e+y4m-devel}"
SRC_URI[aarch64_rust-rav1e+y4m-devel.sha256sum] = "9d666de05a986b6db143139a9fc33debb481e2c322297110e9b780b486ac210a"

URI_aarch64_rust-rav1e-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rav1e-devel-0.7.1-8.el10_1.noarch.rpm;name=aarch64_rust-rav1e-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rav1e-devel}"
SRC_URI[aarch64_rust-rav1e-devel.sha256sum] = "83d16cb746ef03fef8b9b93b6159ba96c768bd41d539d812f0c8220fd1a3047c"

RDEPENDS:rav1e = " \
 glibc \
 libgcc \
 "
RDEPENDS:rav1e-devel = " \
 pkgconf-pkg-config \
 rav1e-libs \
 "
RDEPENDS:rav1e-libs = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-rav1e+asm-devel = " \
 cargo \
 rust-rav1e+cc-devel \
 rust-rav1e+nasm-rs-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+av-metrics-devel = " \
 cargo \
 rust-av-metrics-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+backtrace-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+binaries-devel = " \
 cargo \
 rust-rav1e+av-metrics-devel \
 rust-rav1e+clap-devel \
 rust-rav1e+clap_complete-devel \
 rust-rav1e+console-devel \
 rust-rav1e+fern-devel \
 rust-rav1e+ivf-devel \
 rust-rav1e+nom-devel \
 rust-rav1e+scan_fmt-devel \
 rust-rav1e+y4m-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+capi-devel = " \
 cargo \
 rust-rav1e+scan_fmt-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+cc-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-cc+parallel-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+channel-api-devel = " \
 cargo \
 rust-rav1e+crossbeam-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+check_asm-devel = " \
 cargo \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+clap-devel = " \
 cargo \
 rust-clap+color-devel \
 rust-clap+derive-devel \
 rust-clap+std-devel \
 rust-clap+wrap_help-devel \
 rust-clap-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+clap_complete-devel = " \
 cargo \
 rust-clap_complete+default-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+console-devel = " \
 cargo \
 rust-console+default-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+crossbeam-devel = " \
 cargo \
 rust-crossbeam+default-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+default-devel = " \
 cargo \
 rust-rav1e+asm-devel \
 rust-rav1e+binaries-devel \
 rust-rav1e+signal_support-devel \
 rust-rav1e+threading-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+desync_finder-devel = " \
 cargo \
 rust-rav1e+backtrace-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+dump_ivf-devel = " \
 cargo \
 rust-rav1e+ivf-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+fern-devel = " \
 cargo \
 rust-fern0.6+default-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+ivf-devel = " \
 cargo \
 rust-ivf+default-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+nasm-rs-devel = " \
 cargo \
 rust-nasm-rs+default-devel \
 rust-nasm-rs+parallel-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+nom-devel = " \
 cargo \
 rust-nom7+default-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+quick_test-devel = " \
 cargo \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+scan_fmt-devel = " \
 cargo \
 rust-rav1e-devel \
 rust-scan_fmt-devel \
 "
RDEPENDS:rust-rav1e+scenechange-devel = " \
 cargo \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+serde-big-array-devel = " \
 cargo \
 rust-rav1e-devel \
 rust-serde-big-array+default-devel \
 "
RDEPENDS:rust-rav1e+serde-devel = " \
 cargo \
 rust-rav1e-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rav1e+serialize-devel = " \
 cargo \
 rust-av1-grain+serialize-devel \
 rust-rav1e+serde-big-array-devel \
 rust-rav1e+serde-devel \
 rust-rav1e+toml-devel \
 rust-rav1e-devel \
 rust-v_frame+serialize-devel \
 "
RDEPENDS:rust-rav1e+signal-hook-devel = " \
 cargo \
 rust-rav1e-devel \
 rust-signal-hook+default-devel \
 "
RDEPENDS:rust-rav1e+signal_support-devel = " \
 cargo \
 rust-rav1e+signal-hook-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+threading-devel = " \
 cargo \
 rust-maybe-rayon+threads-devel \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+toml-devel = " \
 cargo \
 rust-rav1e-devel \
 rust-toml0.8+default-devel \
 "
RDEPENDS:rust-rav1e+unstable-devel = " \
 cargo \
 rust-rav1e-devel \
 "
RDEPENDS:rust-rav1e+y4m-devel = " \
 cargo \
 rust-rav1e-devel \
 rust-y4m+default-devel \
 "
RDEPENDS:rust-rav1e-devel = " \
 cargo \
 rust \
 rust-arg_enum_proc_macro+default-devel \
 rust-arrayvec+default-devel \
 rust-av1-grain+default-devel \
 rust-bitstream-io2+default-devel \
 rust-cfg-if+default-devel \
 rust-itertools0.13+default-devel \
 rust-libc+default-devel \
 rust-log+default-devel \
 rust-maybe-rayon-devel \
 rust-new_debug_unreachable+default-devel \
 rust-noop_proc_macro+default-devel \
 rust-num-derive+default-devel \
 rust-num-traits+default-devel \
 rust-once_cell+default-devel \
 rust-paste+default-devel \
 rust-simd_helpers+default-devel \
 rust-thiserror1+default-devel \
 rust-v_frame+default-devel \
 "
