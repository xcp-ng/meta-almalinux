# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-connection_pool"
PV = "2.2.5"
PR = "11.el10_2"
PACKAGES = " \
 rubygem-connection_pool \
 rubygem-connection_pool-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-connection_pool-2.2.5-11.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d2f394499b8f972657f1964a4fdf679243bb832a2759b0037700268bc1256e61"

URI_x86_64_v2_rubygem-connection_pool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-connection_pool-2.2.5-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-connection_pool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-connection_pool}"
SRC_URI[x86_64_v2_rubygem-connection_pool.sha256sum] = "924b4ddc1d0c9ac8a08b8ec1bd7f6388a92cac592f1ceeb66446b6b653bd7fe7"

URI_x86_64_v2_rubygem-connection_pool-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-connection_pool-doc-2.2.5-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-connection_pool-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-connection_pool-doc}"
SRC_URI[x86_64_v2_rubygem-connection_pool-doc.sha256sum] = "b61ec256fc10fb200ce337061f476b776a1627a1f3b1e98b4c8e940e005f8b35"

URI_aarch64_rubygem-connection_pool = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-connection_pool-2.2.5-11.el10_2.noarch.rpm;name=aarch64_rubygem-connection_pool;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-connection_pool}"
SRC_URI[aarch64_rubygem-connection_pool.sha256sum] = "8310d4f9b670d934499cfa0fcd0a59a36784df9858b68ac0ce1598537d891c28"

URI_aarch64_rubygem-connection_pool-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-connection_pool-doc-2.2.5-11.el10_2.noarch.rpm;name=aarch64_rubygem-connection_pool-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-connection_pool-doc}"
SRC_URI[aarch64_rubygem-connection_pool-doc.sha256sum] = "bd86ac21d18ccbc4b308e380bc422d91baf785f7d98e35d10b8e7f9df06f241a"

RDEPENDS:rubygem-connection_pool = " \
 rubygems \
 "
RDEPENDS:rubygem-connection_pool-doc = " \
 rubygem-connection_pool \
 "
