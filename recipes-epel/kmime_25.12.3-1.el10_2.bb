# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmime"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kmime \
 kmime-devel \
 kmime-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmime-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "82a045ec668ee217dd4aa2d5a3ba3e59804db34f187bb13e9e6fc3975f1c3a91"

URI_x86_64_v2_kmime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmime-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmime}"
SRC_URI[x86_64_v2_kmime.sha256sum] = "169d25f47b8b2e3592848965468849cf97e793b07b8bdb34b5f61cc9ca06b65e"

URI_x86_64_v2_kmime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmime-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmime-devel}"
SRC_URI[x86_64_v2_kmime-devel.sha256sum] = "fd320b0b731d263b20d6ea810fdeb682ada5c0fc444ab942a28538b902a04c86"

URI_x86_64_v2_kmime-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmime-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kmime-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmime-doc}"
SRC_URI[x86_64_v2_kmime-doc.sha256sum] = "5b7aab6c5ce570dcb5bbc35f3e435297c07b9d604579741a01fd60facbd86b01"

URI_aarch64_kmime = "${EPEL_MIRROR}/aarch64/Packages/k/kmime-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kmime;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmime}"
SRC_URI[aarch64_kmime.sha256sum] = "3b85ff7fdbdbb8472b4aaf9040cf23aaac9b03501570f176a173297d893cd904"

URI_aarch64_kmime-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kmime-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kmime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmime-devel}"
SRC_URI[aarch64_kmime-devel.sha256sum] = "f2590caaf4962ba1bc34845e13a8885c308ba72a65cd4235e1b752e5b3eec5c5"

URI_aarch64_kmime-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kmime-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_kmime-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmime-doc}"
SRC_URI[aarch64_kmime-doc.sha256sum] = "4e2406d497645d0fb794875481ec5ebb66bc75fa36bb849fcd2ceda721c2b8c9"

RDEPENDS:kmime = " \
 glibc \
 kf6-kcodecs \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kmime-devel = " \
 boost-devel \
 cmake-filesystem \
 kf6-kcodecs-devel \
 kmime \
 "
RDEPENDS:kmime-doc = " \
 "
