# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-mailru-easyjson"
PV = "0.7.7"
PR = "7.el10_0"
PACKAGES = " \
 golang-github-mailru-easyjson \
 golang-github-mailru-easyjson-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-mailru-easyjson-0.7.7-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a74c8cf19166f8a312a20995847971ca96bf69f8e00b09eabcf2af81946da67"

URI_x86_64_v2_golang-github-mailru-easyjson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-mailru-easyjson-0.7.7-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_golang-github-mailru-easyjson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-mailru-easyjson}"
SRC_URI[x86_64_v2_golang-github-mailru-easyjson.sha256sum] = "c3f455da70e43fe2353b15b29320358a019ebdd5c3f8196acf30fbf3087de494"

URI_x86_64_v2_golang-github-mailru-easyjson-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-mailru-easyjson-devel-0.7.7-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-mailru-easyjson-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-mailru-easyjson-devel}"
SRC_URI[x86_64_v2_golang-github-mailru-easyjson-devel.sha256sum] = "24860852cbdf4ae44f418d0a9c4ed3e2345025884744448d7f51143521a5a336"

URI_aarch64_golang-github-mailru-easyjson = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-mailru-easyjson-0.7.7-7.el10_0.aarch64.rpm;name=aarch64_golang-github-mailru-easyjson;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-mailru-easyjson}"
SRC_URI[aarch64_golang-github-mailru-easyjson.sha256sum] = "f677bfbc2e715edf315a8207950f3ee2667cabf46ad31df193a51eb49d52c0a0"

URI_aarch64_golang-github-mailru-easyjson-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-mailru-easyjson-devel-0.7.7-7.el10_0.noarch.rpm;name=aarch64_golang-github-mailru-easyjson-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-mailru-easyjson-devel}"
SRC_URI[aarch64_golang-github-mailru-easyjson-devel.sha256sum] = "959c720162eca6f38feb1a9251e913593e86a49f4c0b032ff355cb9f04a6c4f1"

RDEPENDS:golang-github-mailru-easyjson = " \
 glibc \
 "
RDEPENDS:golang-github-mailru-easyjson-devel = " \
 go-filesystem \
 golang-github-josharian-intern-devel \
 "
