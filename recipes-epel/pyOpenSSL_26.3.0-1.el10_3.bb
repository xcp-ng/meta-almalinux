# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pyOpenSSL"
PV = "26.3.0"
PR = "1.el10_3"
PACKAGES = " \
 pyOpenSSL-doc \
 python3-pyOpenSSL \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pyOpenSSL-26.3.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87a20c3b15211ab69fe12752f18413364216e98ee3e63403226a33b852f35bda"

URI_x86_64_v2_pyOpenSSL-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pyOpenSSL-doc-26.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_pyOpenSSL-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pyOpenSSL-doc}"
SRC_URI[x86_64_v2_pyOpenSSL-doc.sha256sum] = "d83abb64a71a3c34ace199a5e4a4d6b2a7f13a6c398f2ba8a11be45bbfc69823"

URI_x86_64_v2_python3-pyOpenSSL = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyOpenSSL-26.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pyOpenSSL;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyOpenSSL}"
SRC_URI[x86_64_v2_python3-pyOpenSSL.sha256sum] = "bbbceaa1b9c7776d0d876eb5059fb38300aefd4c0f364f477aeac03189e20d65"

URI_aarch64_pyOpenSSL-doc = "${EPEL_MIRROR}/aarch64/Packages/p/pyOpenSSL-doc-26.3.0-1.el10_3.noarch.rpm;name=aarch64_pyOpenSSL-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pyOpenSSL-doc}"
SRC_URI[aarch64_pyOpenSSL-doc.sha256sum] = "19d2ce674047c52cc724f79f43e84cf5aa207a6a3a6488918a1c7cf7b2a683af"

URI_aarch64_python3-pyOpenSSL = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyOpenSSL-26.3.0-1.el10_3.noarch.rpm;name=aarch64_python3-pyOpenSSL;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyOpenSSL}"
SRC_URI[aarch64_python3-pyOpenSSL.sha256sum] = "49bbc828d8dd9d9ae13d8b931c6d71af23c3d73ac6de6d1d875ed70c273f08d3"

RDEPENDS:pyOpenSSL-doc = " \
 "
RDEPENDS:python3-pyOpenSSL = " \
 python3 \
 python3-cryptography \
 python3-typing-extensions \
 "
