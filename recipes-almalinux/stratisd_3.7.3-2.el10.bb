# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "stratisd"
PV = "3.7.3"
PR = "2.el10"
PACKAGES = " \
 stratisd \
 stratisd-dracut \
 stratisd-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/stratisd-3.7.3-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6605eb6ae39b8456ce1065ce5b7d07b221163e0f1fc9e944d623cc27a8bb194c"

URI_x86_64_v2_stratisd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/stratisd-3.7.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_stratisd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stratisd}"
SRC_URI[x86_64_v2_stratisd.sha256sum] = "d238a1fddf37a43c998a45b621b745e034ffd0e3b9a75df02f453ae3919b2ed9"

URI_x86_64_v2_stratisd-dracut = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/stratisd-dracut-3.7.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_stratisd-dracut;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stratisd-dracut}"
SRC_URI[x86_64_v2_stratisd-dracut.sha256sum] = "4c34e844ae4b27c9e8b7691dffdafd8ef6cac1e9d8528927366fcf8146ae5210"

URI_x86_64_v2_stratisd-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/stratisd-tools-3.7.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_stratisd-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stratisd-tools}"
SRC_URI[x86_64_v2_stratisd-tools.sha256sum] = "b0b57327530ce4b25ac771dd072e9e55e5a5324e5b792daf13fcb6fc86299ed4"

URI_aarch64_stratisd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/stratisd-3.7.3-2.el10.aarch64.rpm;name=aarch64_stratisd;unpack=0"
SRC_URI:append = " ${URI_aarch64_stratisd}"
SRC_URI[aarch64_stratisd.sha256sum] = "59702233058492b03f459fc418f22d984c7959dc76c0b05c15022cefa1b0707f"

URI_aarch64_stratisd-dracut = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/stratisd-dracut-3.7.3-2.el10.aarch64.rpm;name=aarch64_stratisd-dracut;unpack=0"
SRC_URI:append = " ${URI_aarch64_stratisd-dracut}"
SRC_URI[aarch64_stratisd-dracut.sha256sum] = "b1f05fbb166f460b8b77fe2e1928a3c83890d1dfad41b0a296933503a32e1d30"

URI_aarch64_stratisd-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/stratisd-tools-3.7.3-2.el10.aarch64.rpm;name=aarch64_stratisd-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_stratisd-tools}"
SRC_URI[aarch64_stratisd-tools.sha256sum] = "af9e3f1bbba2a769854edda3f16b29dffb5d05f6dbbbdefa8372f069620fc8b9"

RDEPENDS:stratisd = " \
 bash \
 cryptsetup-libs \
 dbus-libs \
 device-mapper-persistent-data \
 glibc \
 libblkid \
 libgcc \
 python3 \
 systemd-libs \
 xfsprogs \
 "
RDEPENDS:stratisd-dracut = " \
 bash \
 cryptsetup-libs \
 dracut \
 glibc \
 libblkid \
 libgcc \
 stratisd \
 systemd \
 systemd-libs \
 "
RDEPENDS:stratisd-tools = " \
 cryptsetup-libs \
 glibc \
 libblkid \
 libgcc \
 stratisd \
 systemd-libs \
 "
