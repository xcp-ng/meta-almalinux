# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-vector-algorithms"
PV = "0.9.0.2"
PR = "1.el10_0"
PACKAGES = " \
 ghc-bitvec \
 ghc-bitvec-devel \
 ghc-bitvec-doc \
 ghc-bitvec-prof \
 ghc-vector-algorithms \
 ghc-vector-algorithms-devel \
 ghc-vector-algorithms-doc \
 ghc-vector-algorithms-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-vector-algorithms-0.9.0.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d471578cf561dbc2d3c282924d0cbf1e81f62171156622333c8e831a06e23ccb"

URI_x86_64_v2_ghc-bitvec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bitvec-1.1.5.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-bitvec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bitvec}"
SRC_URI[x86_64_v2_ghc-bitvec.sha256sum] = "8efd934a7c255249478d1f5907bd2af46aa35ecaf67a9dd35981183149d2458e"

URI_x86_64_v2_ghc-bitvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bitvec-devel-1.1.5.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-bitvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bitvec-devel}"
SRC_URI[x86_64_v2_ghc-bitvec-devel.sha256sum] = "b78059f80a23924b56dba714429e809d0237b97815a68061fa879142d97868f2"

URI_x86_64_v2_ghc-bitvec-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bitvec-doc-1.1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-bitvec-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bitvec-doc}"
SRC_URI[x86_64_v2_ghc-bitvec-doc.sha256sum] = "cabad4a2e89fc586e09a2abce11048e054392b49d7a1a5a0cba163fb803d7958"

URI_x86_64_v2_ghc-bitvec-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bitvec-prof-1.1.5.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-bitvec-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bitvec-prof}"
SRC_URI[x86_64_v2_ghc-bitvec-prof.sha256sum] = "18153254877b6b5f475cc60f874c16728fd50f04639bcbbc88d9029bcba24b6d"

URI_x86_64_v2_ghc-vector-algorithms = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-vector-algorithms-0.9.0.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-vector-algorithms;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-vector-algorithms}"
SRC_URI[x86_64_v2_ghc-vector-algorithms.sha256sum] = "4f3184e3018abe8fe54e2e046e2bee32e0aa9bb0410136c4d46b9b620826471f"

URI_x86_64_v2_ghc-vector-algorithms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-vector-algorithms-devel-0.9.0.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-vector-algorithms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-vector-algorithms-devel}"
SRC_URI[x86_64_v2_ghc-vector-algorithms-devel.sha256sum] = "d0796f249eac6b976010c072f1f4f7f659c6623c552572ee91e51eead31b0c89"

URI_x86_64_v2_ghc-vector-algorithms-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-vector-algorithms-doc-0.9.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-vector-algorithms-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-vector-algorithms-doc}"
SRC_URI[x86_64_v2_ghc-vector-algorithms-doc.sha256sum] = "7e013ec50f2af572d254bdbd0c4105c1fc8fba7417e2f00a41239888e786fc3f"

URI_x86_64_v2_ghc-vector-algorithms-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-vector-algorithms-prof-0.9.0.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-vector-algorithms-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-vector-algorithms-prof}"
SRC_URI[x86_64_v2_ghc-vector-algorithms-prof.sha256sum] = "d8891a47ddfd9cc8b7638c96dabde39bf4bba31b887a4bf4d49559cdc8d50a59"

URI_aarch64_ghc-bitvec = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bitvec-1.1.5.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-bitvec;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bitvec}"
SRC_URI[aarch64_ghc-bitvec.sha256sum] = "0d85b02dc5ff4247f7c9e2a082187e2eba5ef365941624b84428d9256b437805"

URI_aarch64_ghc-bitvec-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bitvec-devel-1.1.5.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-bitvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bitvec-devel}"
SRC_URI[aarch64_ghc-bitvec-devel.sha256sum] = "107f4960cc4d96306212f6176c4e32128e83c46d65e76b5c8d140b97171eb775"

URI_aarch64_ghc-bitvec-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bitvec-doc-1.1.5.0-1.el10_0.noarch.rpm;name=aarch64_ghc-bitvec-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bitvec-doc}"
SRC_URI[aarch64_ghc-bitvec-doc.sha256sum] = "12060113cb9b6d9700140d0bcae928584717a4b35411b9ba8cb60162c2c6e374"

URI_aarch64_ghc-bitvec-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bitvec-prof-1.1.5.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-bitvec-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bitvec-prof}"
SRC_URI[aarch64_ghc-bitvec-prof.sha256sum] = "9a129717387deab475a8b0168d6ac889a77ae83bbad65664832b3f569a9bec90"

URI_aarch64_ghc-vector-algorithms = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-vector-algorithms-0.9.0.2-1.el10_0.aarch64.rpm;name=aarch64_ghc-vector-algorithms;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-vector-algorithms}"
SRC_URI[aarch64_ghc-vector-algorithms.sha256sum] = "e1bb9f1fedb0c983f2e6303c7d29170382d80b74348310ff869674a40a76c05d"

URI_aarch64_ghc-vector-algorithms-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-vector-algorithms-devel-0.9.0.2-1.el10_0.aarch64.rpm;name=aarch64_ghc-vector-algorithms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-vector-algorithms-devel}"
SRC_URI[aarch64_ghc-vector-algorithms-devel.sha256sum] = "62b7682347470440916195f41bfe2833b96b71d8c053a3eadf5e2e64e99559dc"

URI_aarch64_ghc-vector-algorithms-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-vector-algorithms-doc-0.9.0.2-1.el10_0.noarch.rpm;name=aarch64_ghc-vector-algorithms-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-vector-algorithms-doc}"
SRC_URI[aarch64_ghc-vector-algorithms-doc.sha256sum] = "d262affbb7bee75a4e7b55f6e2f7ba9477408fabdc481364d41f5e7da3f9ec50"

URI_aarch64_ghc-vector-algorithms-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-vector-algorithms-prof-0.9.0.2-1.el10_0.aarch64.rpm;name=aarch64_ghc-vector-algorithms-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-vector-algorithms-prof}"
SRC_URI[aarch64_ghc-vector-algorithms-prof.sha256sum] = "c8ed02481f0b47423c0ed6511b70474c91b1604914e6efb5f1074492430079d2"

RDEPENDS:ghc-bitvec = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-primitive \
 ghc-template-haskell \
 ghc-transformers \
 ghc-vector \
 ghc-vector-stream \
 glibc \
 gmp \
 "
RDEPENDS:ghc-bitvec-devel = " \
 ghc-base-devel \
 ghc-bitvec \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-ghc-bignum-devel \
 ghc-primitive-devel \
 ghc-vector-devel \
 "
RDEPENDS:ghc-bitvec-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-bitvec-prof = " \
 ghc-base-prof \
 ghc-bitvec-devel \
 ghc-bytestring-prof \
 ghc-deepseq-prof \
 ghc-ghc-bignum-prof \
 ghc-primitive-prof \
 ghc-vector-prof \
 "
RDEPENDS:ghc-vector-algorithms = " \
 ghc-array \
 ghc-base \
 ghc-bitvec \
 ghc-bytestring \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-primitive \
 ghc-template-haskell \
 ghc-transformers \
 ghc-vector \
 ghc-vector-stream \
 glibc \
 gmp \
 "
RDEPENDS:ghc-vector-algorithms-devel = " \
 ghc-base-devel \
 ghc-bitvec-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-primitive-devel \
 ghc-vector-algorithms \
 ghc-vector-devel \
 "
RDEPENDS:ghc-vector-algorithms-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-vector-algorithms-prof = " \
 ghc-base-prof \
 ghc-bitvec-prof \
 ghc-bytestring-prof \
 ghc-primitive-prof \
 ghc-vector-algorithms-devel \
 ghc-vector-prof \
 "
