# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-open"
PV = "5.4.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-open+default-devel \
 rust-open-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-open-5.4.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c1d8b51489575b5209003dc5a06d7d4206f0876134a7df567689877146a55985"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-open+default-devel-5.4.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-open+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-open+default-devel.sha256sum] = "1a982e05af4b2051f5f5d5b964f69ade93d4315d7e3a2e4c77f56c18f5ca9a99"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-open-devel-5.4.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-open-devel;unpack=0"
SRC_URI[x86_64_v2_rust-open-devel.sha256sum] = "b6e8a2f5a7eccc1a3213d45d13cd4c450fd2692c8fddab8650c1fd3d358ef4de"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-open+default-devel-5.4.4-1.el10_3.noarch.rpm;name=aarch64_rust-open+default-devel;unpack=0"
SRC_URI[aarch64_rust-open+default-devel.sha256sum] = "71f0416a61540b6ecdbea8793f4d3362fbc24cb79a6e8877775c913aaaa1ec47"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-open-devel-5.4.4-1.el10_3.noarch.rpm;name=aarch64_rust-open-devel;unpack=0"
SRC_URI[aarch64_rust-open-devel.sha256sum] = "c440d3968f440f40d75eda88bb61b5d180241b790955540aa1858f7cc2f1739f"

RDEPENDS:rust-open+default-devel = " \
 cargo \
 rust-open-devel \
 "
RDEPENDS:rust-open-devel = " \
 cargo \
 rust \
 rust-is-wsl+default-devel \
 rust-libc+default-devel \
 "
