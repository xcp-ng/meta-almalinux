# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kitemmodels"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kitemmodels \
 kf6-kitemmodels-devel \
 kf6-kitemmodels-doc \
 kf6-kitemmodels-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kitemmodels-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d0c5b9ce24da3757c8d3047cb3107054662ddd572849d68099501faabe774e2"

URI_x86_64_v2_kf6-kitemmodels = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemmodels-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kitemmodels;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kitemmodels}"
SRC_URI[x86_64_v2_kf6-kitemmodels.sha256sum] = "41046671c544e90b7090ca503544cc96dd43ca884c7f0896377ad4e5bc256d01"

URI_x86_64_v2_kf6-kitemmodels-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemmodels-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kitemmodels-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kitemmodels-devel}"
SRC_URI[x86_64_v2_kf6-kitemmodels-devel.sha256sum] = "edfff940678a96883b3d2f5c99fe85624317f139b1359f1abb11c19c2ae2d7f5"

URI_x86_64_v2_kf6-kitemmodels-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemmodels-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kitemmodels-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kitemmodels-doc}"
SRC_URI[x86_64_v2_kf6-kitemmodels-doc.sha256sum] = "4123de5e7684e5726bf24d6b5030e293ca77bd9a765fb8f12e618f5a26c9643a"

URI_x86_64_v2_kf6-kitemmodels-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemmodels-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kitemmodels-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kitemmodels-html}"
SRC_URI[x86_64_v2_kf6-kitemmodels-html.sha256sum] = "220397f51d65f0fab35680ff6efc6933dab83be2695539749b9f6d806d3b712f"

URI_aarch64_kf6-kitemmodels = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemmodels-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kitemmodels;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kitemmodels}"
SRC_URI[aarch64_kf6-kitemmodels.sha256sum] = "69426707963db238cda4c26ea489c83a2613860547d5309ea4a1481ed1d3385c"

URI_aarch64_kf6-kitemmodels-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemmodels-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kitemmodels-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kitemmodels-devel}"
SRC_URI[aarch64_kf6-kitemmodels-devel.sha256sum] = "54f5abb91813ad9ec3c6496c58edd64919033b7df0f0d974cbf4602d8158df64"

URI_aarch64_kf6-kitemmodels-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemmodels-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kitemmodels-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kitemmodels-doc}"
SRC_URI[aarch64_kf6-kitemmodels-doc.sha256sum] = "1037980b6043285c87ae9450f9cbabeae3b32164d217b7ce57dc74f7fe21a21b"

URI_aarch64_kf6-kitemmodels-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemmodels-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kitemmodels-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kitemmodels-html}"
SRC_URI[aarch64_kf6-kitemmodels-html.sha256sum] = "d71259a28fd7593ce4b528936769644f2b61ca99411582cbb9caeeb64a53dfa7"

RDEPENDS:kf6-kitemmodels = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kitemmodels-devel = " \
 cmake-filesystem \
 kf6-kitemmodels \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kitemmodels-doc = " \
 "
RDEPENDS:kf6-kitemmodels-html = " \
 "
