# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num"
PV = "0.4.3"
PR = "2.el10_1"
PACKAGES = " \
 rust-num+alloc-devel \
 rust-num+default-devel \
 rust-num+libm-devel \
 rust-num+num-bigint-devel \
 rust-num+rand-devel \
 rust-num+serde-devel \
 rust-num+std-devel \
 rust-num-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-num-0.4.3-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1389002173572cd86396c6f1ebc7cba18591bfa165412afdb1ffd2a68c817c99"

URI_x86_64_v2_rust-num+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num+alloc-devel-0.4.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num+alloc-devel}"
SRC_URI[x86_64_v2_rust-num+alloc-devel.sha256sum] = "e637b5837fbda6b2aa8b56199d8ab5f0abe34f17ae0397016196f733bcdc3526"

URI_x86_64_v2_rust-num+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num+default-devel-0.4.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num+default-devel}"
SRC_URI[x86_64_v2_rust-num+default-devel.sha256sum] = "8a13a4754ca7c618ea91b30fad0a128afc6a34c3f134c716fbdb64c35d5b5020"

URI_x86_64_v2_rust-num+libm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num+libm-devel-0.4.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num+libm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num+libm-devel}"
SRC_URI[x86_64_v2_rust-num+libm-devel.sha256sum] = "0cab1ee59781542c5eca17f27379bc5b2004efb1342675db40f580334720728d"

URI_x86_64_v2_rust-num+num-bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num+num-bigint-devel-0.4.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num+num-bigint-devel}"
SRC_URI[x86_64_v2_rust-num+num-bigint-devel.sha256sum] = "e1862cadde0b59d0eec757dd92781643ff6e6dd159fa7b618ab2de34d1ba9e96"

URI_x86_64_v2_rust-num+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num+rand-devel-0.4.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num+rand-devel}"
SRC_URI[x86_64_v2_rust-num+rand-devel.sha256sum] = "9029c82770ae6fefc01154fd7b5524e62a4e3aee72a4e388aef7cb47cc77eb8e"

URI_x86_64_v2_rust-num+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num+serde-devel-0.4.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num+serde-devel}"
SRC_URI[x86_64_v2_rust-num+serde-devel.sha256sum] = "78c8e30b6b166010c56aa2bc938aaf9854d5fe6f50195ce4eb9ee70ab29cfd8c"

URI_x86_64_v2_rust-num+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num+std-devel-0.4.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num+std-devel}"
SRC_URI[x86_64_v2_rust-num+std-devel.sha256sum] = "c95acd9259cb26cc351def6e4712126e71343f8ba5e13b6229095abb674ca6ba"

URI_x86_64_v2_rust-num-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-devel-0.4.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-devel}"
SRC_URI[x86_64_v2_rust-num-devel.sha256sum] = "01f6fd3f0b8f732ca22136904b69c16b67a8b8e5fd3d6b6b24d7852fe2933371"

URI_aarch64_rust-num+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num+alloc-devel-0.4.3-2.el10_1.noarch.rpm;name=aarch64_rust-num+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num+alloc-devel}"
SRC_URI[aarch64_rust-num+alloc-devel.sha256sum] = "ab7a830cf48f240d9c5bbc02154096cfcc155fa91c7be39a02fdf153ab60cf74"

URI_aarch64_rust-num+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num+default-devel-0.4.3-2.el10_1.noarch.rpm;name=aarch64_rust-num+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num+default-devel}"
SRC_URI[aarch64_rust-num+default-devel.sha256sum] = "e59aa5f59ba05f1421e4172f51cdcff6dbd3041ac09d73735bcbf10a2eeed2a4"

URI_aarch64_rust-num+libm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num+libm-devel-0.4.3-2.el10_1.noarch.rpm;name=aarch64_rust-num+libm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num+libm-devel}"
SRC_URI[aarch64_rust-num+libm-devel.sha256sum] = "1d4ee9f6fe811733d6d6ba4c488baf4cc322b7607a981c523e8171e93d591336"

URI_aarch64_rust-num+num-bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num+num-bigint-devel-0.4.3-2.el10_1.noarch.rpm;name=aarch64_rust-num+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num+num-bigint-devel}"
SRC_URI[aarch64_rust-num+num-bigint-devel.sha256sum] = "28b00920237cb8cc70852bb0350ea335862d2c124e8a2309fe5c366272b6ad5e"

URI_aarch64_rust-num+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num+rand-devel-0.4.3-2.el10_1.noarch.rpm;name=aarch64_rust-num+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num+rand-devel}"
SRC_URI[aarch64_rust-num+rand-devel.sha256sum] = "1e71d28719dcea1a08244af104a1a25878512055016fe1b1ff27c8250f0f103e"

URI_aarch64_rust-num+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num+serde-devel-0.4.3-2.el10_1.noarch.rpm;name=aarch64_rust-num+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num+serde-devel}"
SRC_URI[aarch64_rust-num+serde-devel.sha256sum] = "6e41a9c5aca1319339223a2e19125c91c45195ac3426fed580ab5469d613fc8c"

URI_aarch64_rust-num+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num+std-devel-0.4.3-2.el10_1.noarch.rpm;name=aarch64_rust-num+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num+std-devel}"
SRC_URI[aarch64_rust-num+std-devel.sha256sum] = "69f12f1d1621a6f21e012a1ea1eb66789b6401f74561e6657b508c0e25d12f0e"

URI_aarch64_rust-num-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-devel-0.4.3-2.el10_1.noarch.rpm;name=aarch64_rust-num-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-devel}"
SRC_URI[aarch64_rust-num-devel.sha256sum] = "8a8a30c3ee8b6f39dde16085b4f87ae66a7317cf9e1e29645e916b4b26fe8531"

RDEPENDS:rust-num+alloc-devel = " \
 cargo \
 rust-num-bigint-devel \
 rust-num-devel \
 rust-num-rational+num-bigint-devel \
 "
RDEPENDS:rust-num+default-devel = " \
 cargo \
 rust-num+std-devel \
 rust-num-devel \
 "
RDEPENDS:rust-num+libm-devel = " \
 cargo \
 rust-num-complex+libm-devel \
 rust-num-devel \
 rust-num-traits+libm-devel \
 "
RDEPENDS:rust-num+num-bigint-devel = " \
 cargo \
 rust-num-bigint-devel \
 rust-num-devel \
 "
RDEPENDS:rust-num+rand-devel = " \
 cargo \
 rust-num-bigint+rand-devel \
 rust-num-bigint-devel \
 rust-num-complex+rand-devel \
 rust-num-devel \
 "
RDEPENDS:rust-num+serde-devel = " \
 cargo \
 rust-num-bigint+serde-devel \
 rust-num-bigint-devel \
 rust-num-complex+serde-devel \
 rust-num-devel \
 rust-num-rational+serde-devel \
 "
RDEPENDS:rust-num+std-devel = " \
 cargo \
 rust-num-bigint+std-devel \
 rust-num-bigint-devel \
 rust-num-complex+std-devel \
 rust-num-devel \
 rust-num-integer+std-devel \
 rust-num-iter+std-devel \
 rust-num-rational+num-bigint-std-devel \
 rust-num-rational+std-devel \
 rust-num-traits+std-devel \
 "
RDEPENDS:rust-num-devel = " \
 cargo \
 rust \
 rust-num-complex-devel \
 rust-num-integer+i128-devel \
 rust-num-integer-devel \
 rust-num-iter+i128-devel \
 rust-num-iter-devel \
 rust-num-rational-devel \
 rust-num-traits+i128-devel \
 rust-num-traits-devel \
 "
