# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kconfig"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kconfig \
 kf6-kconfig-devel \
 kf6-kconfig-doc \
 kf6-kconfig-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kconfig-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6de4e127b435a7c984f671f4a0fee70ca7ae048408fe93dc66bc4455493afebf"

URI_x86_64_v2_kf6-kconfig = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfig-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kconfig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kconfig}"
SRC_URI[x86_64_v2_kf6-kconfig.sha256sum] = "5d0827507ed737402c5058e93ce75521c1c9cf9141b0a9fced603ebf086aff93"

URI_x86_64_v2_kf6-kconfig-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfig-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kconfig-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kconfig-devel}"
SRC_URI[x86_64_v2_kf6-kconfig-devel.sha256sum] = "3178dcc5c3bd0d9998f7dc2afc6b9f5fe6a75fe6027bade48ded04d03be0f31f"

URI_x86_64_v2_kf6-kconfig-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfig-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kconfig-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kconfig-doc}"
SRC_URI[x86_64_v2_kf6-kconfig-doc.sha256sum] = "c2968be25340904c10c795db4fac1cf4e6cd2d1d62cd663d8f9bbe739ddfcf17"

URI_x86_64_v2_kf6-kconfig-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfig-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kconfig-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kconfig-html}"
SRC_URI[x86_64_v2_kf6-kconfig-html.sha256sum] = "abb38a0123285583818cf96b88cb9118c173ccabb2e52524a9cdb070e1dc3ce8"

URI_aarch64_kf6-kconfig = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfig-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kconfig;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kconfig}"
SRC_URI[aarch64_kf6-kconfig.sha256sum] = "5ecaf022c44f6f7d4e37f02feecce281693bfe6fb66e4b1ae82b2858ea929e65"

URI_aarch64_kf6-kconfig-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfig-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kconfig-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kconfig-devel}"
SRC_URI[aarch64_kf6-kconfig-devel.sha256sum] = "48daff77a68ef45bb26c33e83c34f52f833d267644a3d1ded46059a2b36295aa"

URI_aarch64_kf6-kconfig-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfig-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kconfig-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kconfig-doc}"
SRC_URI[aarch64_kf6-kconfig-doc.sha256sum] = "b23ca7f5c369c6c0a034f44927037e0bc8356a491793426081268a093af60e3e"

URI_aarch64_kf6-kconfig-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfig-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kconfig-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kconfig-html}"
SRC_URI[aarch64_kf6-kconfig-html.sha256sum] = "37e855bd736efec74deed632a12d2f98c4b519ffe1a92ce162064042465e1c48"

RDEPENDS:kf6-kconfig = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kconfig-devel = " \
 cmake-filesystem \
 kf6-kconfig \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 "
RDEPENDS:kf6-kconfig-doc = " \
 "
RDEPENDS:kf6-kconfig-html = " \
 "
