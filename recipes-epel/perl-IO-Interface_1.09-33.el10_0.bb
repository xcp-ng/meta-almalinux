# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-IO-Interface"
PV = "1.09"
PR = "33.el10_0"
PACKAGES = " \
 perl-IO-Interface \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-IO-Interface-1.09-33.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "89679f202a28b4a8927b5901db0eeee58bed95e8262694285517fd7da9467ed1"

URI_x86_64_v2_perl-IO-Interface = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-IO-Interface-1.09-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-IO-Interface;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-IO-Interface}"
SRC_URI[x86_64_v2_perl-IO-Interface.sha256sum] = "d484234cf6e9ec405de8c11b5ed85ad14f140173eb93332cd15d05841f4fd24d"

URI_aarch64_perl-IO-Interface = "${EPEL_MIRROR}/aarch64/Packages/p/perl-IO-Interface-1.09-33.el10_0.aarch64.rpm;name=aarch64_perl-IO-Interface;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-IO-Interface}"
SRC_URI[aarch64_perl-IO-Interface.sha256sum] = "72470e50f63db22a8c7bec56d5561105890169cfa18e24ca0a30c5daa5150aed"

RDEPENDS:perl-IO-Interface = " \
 glibc \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-IO \
 perl-IO-Interface \
 perl-libs \
 perl-overload \
 perl-vars \
 "
