# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-calendar"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 akonadi-calendar \
 akonadi-calendar-devel \
 akonadi-calendar-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akonadi-calendar-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5acfa1e1874488588aa6389a2a3da92751c110720cb4736535ee0f6eb582c554"

URI_x86_64_v2_akonadi-calendar = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-calendar-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-calendar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-calendar}"
SRC_URI[x86_64_v2_akonadi-calendar.sha256sum] = "8d19a272bda0bf5bd9038b8bf3271e4e302623feda6065110dc947713c18d5fa"

URI_x86_64_v2_akonadi-calendar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-calendar-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-calendar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-calendar-devel}"
SRC_URI[x86_64_v2_akonadi-calendar-devel.sha256sum] = "e47dd903c75a8afabd62377e46adb99238d4c67c69fb1ce1ead30b0a824658b5"

URI_x86_64_v2_akonadi-calendar-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-calendar-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_akonadi-calendar-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-calendar-doc}"
SRC_URI[x86_64_v2_akonadi-calendar-doc.sha256sum] = "c475e34b16248643adb74b1e58d62241de1fca211ab5ae2a0ba9ef0b8179c66b"

URI_aarch64_akonadi-calendar = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-calendar-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_akonadi-calendar;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-calendar}"
SRC_URI[aarch64_akonadi-calendar.sha256sum] = "5ca3457b21f5a3a7911dca57ddd66f608c51590967ab456ad40fa021edfb6b9f"

URI_aarch64_akonadi-calendar-devel = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-calendar-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_akonadi-calendar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-calendar-devel}"
SRC_URI[aarch64_akonadi-calendar-devel.sha256sum] = "343e6f082588f363d0a22bbb8a8640c45f29cbb31441e8eae81b37a7b57c3167"

URI_aarch64_akonadi-calendar-doc = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-calendar-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_akonadi-calendar-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-calendar-doc}"
SRC_URI[aarch64_akonadi-calendar-doc.sha256sum] = "90d15e37f2562b5ba07c335c8e604419a8f63726046428317d1285c4accdf293"

RDEPENDS:akonadi-calendar = " \
 akonadi-contacts \
 akonadi-mime \
 akonadi-server \
 glibc \
 gpgmepp \
 kcalutils \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kitemmodels \
 kf6-knotifications \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kidentitymanagement \
 kmailtransport \
 kmime \
 libgcc \
 libkleo \
 libstdc++ \
 messagelib \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:akonadi-calendar-devel = " \
 akonadi-calendar \
 akonadi-contacts-devel \
 akonadi-server-devel \
 cmake-filesystem \
 kf6-kcalendarcore-devel \
 kidentitymanagement-devel \
 "
RDEPENDS:akonadi-calendar-doc = " \
 "
