# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gvfs"
PV = "1.54.4"
PR = "2.el10"
PACKAGES = " \
 gvfs \
 gvfs-client \
 gvfs-fuse \
 gvfs-goa \
 gvfs-gphoto2 \
 gvfs-mtp \
 gvfs-smb \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gvfs-1.54.4-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bde121f7dcbcdd17d875b2a202379b8b2422761a3b058c867bb710af36916c6f"

URI_x86_64_v2_gvfs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gvfs-1.54.4-2.el10.x86_64_v2.rpm;name=x86_64_v2_gvfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gvfs}"
SRC_URI[x86_64_v2_gvfs.sha256sum] = "2d95385a03012da26738f6a56016c40a41267e5a61f2a95be965cf3646111e5a"

URI_x86_64_v2_gvfs-client = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gvfs-client-1.54.4-2.el10.x86_64_v2.rpm;name=x86_64_v2_gvfs-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gvfs-client}"
SRC_URI[x86_64_v2_gvfs-client.sha256sum] = "f1b45fc399dea0c5615d2960f4067aea8363491e5d39b48db28f378fdc88787d"

URI_x86_64_v2_gvfs-fuse = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gvfs-fuse-1.54.4-2.el10.x86_64_v2.rpm;name=x86_64_v2_gvfs-fuse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gvfs-fuse}"
SRC_URI[x86_64_v2_gvfs-fuse.sha256sum] = "6d65f8cc6b72f7c3a0b3435bbb38c2e329dfe88155bad55ee286d27271e74b61"

URI_x86_64_v2_gvfs-goa = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gvfs-goa-1.54.4-2.el10.x86_64_v2.rpm;name=x86_64_v2_gvfs-goa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gvfs-goa}"
SRC_URI[x86_64_v2_gvfs-goa.sha256sum] = "b557b537cb74d55e810870367aa39e12d22148b3497ca0fe6e19bdd42489fd95"

URI_x86_64_v2_gvfs-gphoto2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gvfs-gphoto2-1.54.4-2.el10.x86_64_v2.rpm;name=x86_64_v2_gvfs-gphoto2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gvfs-gphoto2}"
SRC_URI[x86_64_v2_gvfs-gphoto2.sha256sum] = "ad08c1261c69fe52dfd69c5725dd9c87c143e2cccefd66cc616c7b626eaf9812"

URI_x86_64_v2_gvfs-mtp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gvfs-mtp-1.54.4-2.el10.x86_64_v2.rpm;name=x86_64_v2_gvfs-mtp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gvfs-mtp}"
SRC_URI[x86_64_v2_gvfs-mtp.sha256sum] = "792e4e9269a97cd9b5bf7ba51ef9532de34010d09a0ef061e6f53cef5e1f965d"

URI_x86_64_v2_gvfs-smb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gvfs-smb-1.54.4-2.el10.x86_64_v2.rpm;name=x86_64_v2_gvfs-smb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gvfs-smb}"
SRC_URI[x86_64_v2_gvfs-smb.sha256sum] = "7737d42d4dd3eb43da10db436ba2e4fc5913ec794175c37d57767e6eb3748512"

URI_aarch64_gvfs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gvfs-1.54.4-2.el10.aarch64.rpm;name=aarch64_gvfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gvfs}"
SRC_URI[aarch64_gvfs.sha256sum] = "1f289c64678dd0848558f8200669fba1051924e0d25fabc2b1a459c6fb563437"

URI_aarch64_gvfs-client = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gvfs-client-1.54.4-2.el10.aarch64.rpm;name=aarch64_gvfs-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_gvfs-client}"
SRC_URI[aarch64_gvfs-client.sha256sum] = "ae8e7126cde21ca11bba1035c2ad518fe04003796d3f046f409f67b2011b69d9"

URI_aarch64_gvfs-fuse = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gvfs-fuse-1.54.4-2.el10.aarch64.rpm;name=aarch64_gvfs-fuse;unpack=0"
SRC_URI:append = " ${URI_aarch64_gvfs-fuse}"
SRC_URI[aarch64_gvfs-fuse.sha256sum] = "5b6e7aeeb343f3b8643ed24635ae1180f72e10ffd83738c40ceeade2ac731852"

URI_aarch64_gvfs-goa = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gvfs-goa-1.54.4-2.el10.aarch64.rpm;name=aarch64_gvfs-goa;unpack=0"
SRC_URI:append = " ${URI_aarch64_gvfs-goa}"
SRC_URI[aarch64_gvfs-goa.sha256sum] = "9ea1f99bd30c79185d0d68d754711369111ab8a63076fd3085c78b74d32fbcd2"

URI_aarch64_gvfs-gphoto2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gvfs-gphoto2-1.54.4-2.el10.aarch64.rpm;name=aarch64_gvfs-gphoto2;unpack=0"
SRC_URI:append = " ${URI_aarch64_gvfs-gphoto2}"
SRC_URI[aarch64_gvfs-gphoto2.sha256sum] = "545eb5a9b88a4db272fe49a43a245b162d53a098d6d7a83de7747a557303f5ce"

URI_aarch64_gvfs-mtp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gvfs-mtp-1.54.4-2.el10.aarch64.rpm;name=aarch64_gvfs-mtp;unpack=0"
SRC_URI:append = " ${URI_aarch64_gvfs-mtp}"
SRC_URI[aarch64_gvfs-mtp.sha256sum] = "621363913d8fd8b4783c51ddb5f33d81e8ba4c7b61bbe1109973666b98a4c2be"

URI_aarch64_gvfs-smb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gvfs-smb-1.54.4-2.el10.aarch64.rpm;name=aarch64_gvfs-smb;unpack=0"
SRC_URI:append = " ${URI_aarch64_gvfs-smb}"
SRC_URI[aarch64_gvfs-smb.sha256sum] = "a83a453f40732000c5b2a66d438277f371e35682fe0d9479b37b236e5e4c7baa"

RDEPENDS:gvfs = " \
 avahi-glib \
 avahi-libs \
 bash \
 gcr-libs \
 glib2 \
 glibc \
 gsettings-desktop-schemas \
 gvfs-client \
 libgcc \
 libgudev \
 libsecret \
 libsoup3 \
 libudisks2 \
 libxml2 \
 polkit \
 polkit-libs \
 systemd-libs \
 udisks2 \
 wsdd \
 "
RDEPENDS:gvfs-client = " \
 glib2 \
 glibc \
 libgcc \
 "
RDEPENDS:gvfs-fuse = " \
 fuse3 \
 fuse3-libs \
 glib2 \
 glibc \
 gvfs \
 gvfs-client \
 "
RDEPENDS:gvfs-goa = " \
 bash \
 glib2 \
 glibc \
 gnome-online-accounts \
 gvfs \
 gvfs-client \
 "
RDEPENDS:gvfs-gphoto2 = " \
 bash \
 glib2 \
 glibc \
 gvfs \
 gvfs-client \
 libgphoto2 \
 libgudev \
 "
RDEPENDS:gvfs-mtp = " \
 bash \
 glib2 \
 glibc \
 gvfs \
 gvfs-client \
 libgudev \
 libmtp \
 libusb1 \
 "
RDEPENDS:gvfs-smb = " \
 bash \
 glib2 \
 glibc \
 gvfs \
 gvfs-client \
 libgcc \
 libsmbclient \
 "
