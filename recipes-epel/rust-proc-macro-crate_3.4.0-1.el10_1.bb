# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-proc-macro-crate"
PV = "3.4.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-proc-macro-crate+default-devel \
 rust-proc-macro-crate-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-proc-macro-crate-3.4.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2acb2f5c986961233eeec0c3cf2318011a9557a5281ce09b52a4c45caff939dd"

URI_x86_64_v2_rust-proc-macro-crate+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-crate+default-devel-3.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-crate+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro-crate+default-devel}"
SRC_URI[x86_64_v2_rust-proc-macro-crate+default-devel.sha256sum] = "df8d4c18e6b03a411d7d62e3a37d30cc9f52d3614b1eb0c8a1bb1c856696dd87"

URI_x86_64_v2_rust-proc-macro-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-crate-devel-3.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro-crate-devel}"
SRC_URI[x86_64_v2_rust-proc-macro-crate-devel.sha256sum] = "477c074be2f1367384cef877c400d8de0d487a255b3aa9bde22f665decdb7a3a"

URI_aarch64_rust-proc-macro-crate+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-crate+default-devel-3.4.0-1.el10_1.noarch.rpm;name=aarch64_rust-proc-macro-crate+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro-crate+default-devel}"
SRC_URI[aarch64_rust-proc-macro-crate+default-devel.sha256sum] = "be0cd3802d1ccb1a71c3f2151c0922cfb0ef1f441f38b91a5428f2f4651442d1"

URI_aarch64_rust-proc-macro-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-crate-devel-3.4.0-1.el10_1.noarch.rpm;name=aarch64_rust-proc-macro-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro-crate-devel}"
SRC_URI[aarch64_rust-proc-macro-crate-devel.sha256sum] = "174209d005f8b45b8caed1e133c6dfd72ba0ed1de067aa7fb75d13da8909041d"

RDEPENDS:rust-proc-macro-crate+default-devel = " \
 cargo \
 rust-proc-macro-crate-devel \
 "
RDEPENDS:rust-proc-macro-crate-devel = " \
 cargo \
 rust \
 rust-toml_edit+parse-devel \
 rust-toml_edit-devel \
 "
