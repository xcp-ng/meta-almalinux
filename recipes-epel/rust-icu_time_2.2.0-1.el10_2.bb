# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_time"
PV = "2.2.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-icu_time+alloc-devel \
 rust-icu_time+compiled_data-devel \
 rust-icu_time+datagen-devel \
 rust-icu_time+default-devel \
 rust-icu_time+ixdtf-devel \
 rust-icu_time+serde-devel \
 rust-icu_time+unstable-devel \
 rust-icu_time+unstable_chrono_0_4-devel \
 rust-icu_time+unstable_jiff_0_2-devel \
 rust-icu_time+unstable_time_0_3-devel \
 rust-icu_time-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_time-2.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fda8983676c639ed539bd2230352d4965219c1f7b253204396eec59e0270532a"

URI_x86_64_v2_rust-icu_time+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_time+alloc-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_time+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_time+alloc-devel}"
SRC_URI[x86_64_v2_rust-icu_time+alloc-devel.sha256sum] = "cf0c7ca28eba20270207793283e2f80a7c4af6dc2b80f9848139edebe65a2da3"

URI_x86_64_v2_rust-icu_time+compiled_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_time+compiled_data-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_time+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_time+compiled_data-devel}"
SRC_URI[x86_64_v2_rust-icu_time+compiled_data-devel.sha256sum] = "3d634759fdb0c9af15c2055aa9ddd976adb23fcef882d95c8d68f50f03bfa30d"

URI_x86_64_v2_rust-icu_time+datagen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_time+datagen-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_time+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_time+datagen-devel}"
SRC_URI[x86_64_v2_rust-icu_time+datagen-devel.sha256sum] = "26aefe806eccd9eb08944bbbdcd5e57b4e430a559ab5350170c6da37c00f2a85"

URI_x86_64_v2_rust-icu_time+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_time+default-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_time+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_time+default-devel}"
SRC_URI[x86_64_v2_rust-icu_time+default-devel.sha256sum] = "745bc02b0295dc37f46da8b8ab12348f36771dffddb1084e31a7896a56c0e759"

URI_x86_64_v2_rust-icu_time+ixdtf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_time+ixdtf-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_time+ixdtf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_time+ixdtf-devel}"
SRC_URI[x86_64_v2_rust-icu_time+ixdtf-devel.sha256sum] = "d494812f00719ba2ebaf3b09437f5697ac4a1297167d4c30af33990cf2adc77a"

URI_x86_64_v2_rust-icu_time+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_time+serde-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_time+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_time+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_time+serde-devel.sha256sum] = "09a8f5f5947ab9aa4719553433f5331daef47a7d6f5e6cd6de7d5c01629bba86"

URI_x86_64_v2_rust-icu_time+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_time+unstable-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_time+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_time+unstable-devel}"
SRC_URI[x86_64_v2_rust-icu_time+unstable-devel.sha256sum] = "1289dd48e3e555bc2cf7ffe301b00f7aa08644882ef17afe105d5850802f5bed"

URI_x86_64_v2_rust-icu_time+unstable_chrono_0_4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_time+unstable_chrono_0_4-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_time+unstable_chrono_0_4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_time+unstable_chrono_0_4-devel}"
SRC_URI[x86_64_v2_rust-icu_time+unstable_chrono_0_4-devel.sha256sum] = "7d185878439dfed1dc5188023f21e35eb1d1f5f08c5fb53c1f9f1dff6e49a677"

URI_x86_64_v2_rust-icu_time+unstable_jiff_0_2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_time+unstable_jiff_0_2-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_time+unstable_jiff_0_2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_time+unstable_jiff_0_2-devel}"
SRC_URI[x86_64_v2_rust-icu_time+unstable_jiff_0_2-devel.sha256sum] = "2176d0a9b012ea01e6a4a6d32ff316b1fa3f182dc03f7503b3f98ef09daa9fd6"

URI_x86_64_v2_rust-icu_time+unstable_time_0_3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_time+unstable_time_0_3-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_time+unstable_time_0_3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_time+unstable_time_0_3-devel}"
SRC_URI[x86_64_v2_rust-icu_time+unstable_time_0_3-devel.sha256sum] = "49414ac3cdaa5967d986250bb16863c9ef3d69caa6cc859ea54cff9c2e484d71"

URI_x86_64_v2_rust-icu_time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_time-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_time-devel}"
SRC_URI[x86_64_v2_rust-icu_time-devel.sha256sum] = "27d9c7a40ef1b5f9163be976188239d379ee3b334b86fb95218c436a0994d908"

URI_aarch64_rust-icu_time+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_time+alloc-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_time+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_time+alloc-devel}"
SRC_URI[aarch64_rust-icu_time+alloc-devel.sha256sum] = "fbb88eefae2a6bc0a395d2a5265d1fd81bb9926f66fd9d86d4fb5d0f2239bc67"

URI_aarch64_rust-icu_time+compiled_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_time+compiled_data-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_time+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_time+compiled_data-devel}"
SRC_URI[aarch64_rust-icu_time+compiled_data-devel.sha256sum] = "54f23559cb82eca8747f62cfffb46c011e50f708a43b14b53e80893c96fdc12a"

URI_aarch64_rust-icu_time+datagen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_time+datagen-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_time+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_time+datagen-devel}"
SRC_URI[aarch64_rust-icu_time+datagen-devel.sha256sum] = "1b4906dee55ea1919c4b4dd3b6ad1574f3cab43fd80aa5a4cdd92b9c29c8066e"

URI_aarch64_rust-icu_time+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_time+default-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_time+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_time+default-devel}"
SRC_URI[aarch64_rust-icu_time+default-devel.sha256sum] = "f9827573aa81c12d0c44700d3ea18e1c589fcae680b7a2ad559d7b8389b455ff"

URI_aarch64_rust-icu_time+ixdtf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_time+ixdtf-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_time+ixdtf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_time+ixdtf-devel}"
SRC_URI[aarch64_rust-icu_time+ixdtf-devel.sha256sum] = "ba219583a01ec5102a4c6b0697639bc72fb66fd0efd1efbe06607e270ef2ae87"

URI_aarch64_rust-icu_time+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_time+serde-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_time+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_time+serde-devel}"
SRC_URI[aarch64_rust-icu_time+serde-devel.sha256sum] = "7c48c2ae00d7594ffffc1bb7397ef52280e3b4eba87aad38dcb16da809ac080a"

URI_aarch64_rust-icu_time+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_time+unstable-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_time+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_time+unstable-devel}"
SRC_URI[aarch64_rust-icu_time+unstable-devel.sha256sum] = "78439f9fa1616c74053eb8bca8e486e483861f98ef959a716bbf823c100b0972"

URI_aarch64_rust-icu_time+unstable_chrono_0_4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_time+unstable_chrono_0_4-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_time+unstable_chrono_0_4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_time+unstable_chrono_0_4-devel}"
SRC_URI[aarch64_rust-icu_time+unstable_chrono_0_4-devel.sha256sum] = "53e72b09ec06abbedab3ed8219a134ace508cfb204e612b149d942cae1d9f1c9"

URI_aarch64_rust-icu_time+unstable_jiff_0_2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_time+unstable_jiff_0_2-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_time+unstable_jiff_0_2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_time+unstable_jiff_0_2-devel}"
SRC_URI[aarch64_rust-icu_time+unstable_jiff_0_2-devel.sha256sum] = "9cf235c96ef8c5ab62ba575458de798dc1b2d20802a816c9341b88138d4f9de3"

URI_aarch64_rust-icu_time+unstable_time_0_3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_time+unstable_time_0_3-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_time+unstable_time_0_3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_time+unstable_time_0_3-devel}"
SRC_URI[aarch64_rust-icu_time+unstable_time_0_3-devel.sha256sum] = "8cb8cc71b62a97d8955966b9bf67c39afa6f8bec0518309b49c2253e6d656559"

URI_aarch64_rust-icu_time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_time-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_time-devel}"
SRC_URI[aarch64_rust-icu_time-devel.sha256sum] = "6d85d0fd047e2aa83e21e53f589062adcca2d50da4ce38450604a49a6d56e7bd"

RDEPENDS:rust-icu_time+alloc-devel = " \
 cargo \
 rust-icu_time-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerotrie+alloc-devel \
 rust-zerovec+alloc-devel \
 "
RDEPENDS:rust-icu_time+compiled_data-devel = " \
 cargo \
 rust-icu_calendar+compiled_data-devel \
 rust-icu_provider+baked-devel \
 rust-icu_time-devel \
 rust-icu_time_data-devel \
 "
RDEPENDS:rust-icu_time+datagen-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-icu_locale_core+databake-devel \
 rust-icu_provider+export-devel \
 rust-icu_time+alloc-devel \
 rust-icu_time+serde-devel \
 rust-icu_time-devel \
 rust-zerotrie+databake-devel \
 rust-zerovec+databake-devel \
 "
RDEPENDS:rust-icu_time+default-devel = " \
 cargo \
 rust-icu_time+compiled_data-devel \
 rust-icu_time+ixdtf-devel \
 rust-icu_time-devel \
 "
RDEPENDS:rust-icu_time+ixdtf-devel = " \
 cargo \
 rust-icu_calendar+ixdtf-devel \
 rust-icu_time-devel \
 rust-ixdtf-devel \
 "
RDEPENDS:rust-icu_time+serde-devel = " \
 cargo \
 rust-icu_locale_core+serde-devel \
 rust-icu_provider+serde-devel \
 rust-icu_time+alloc-devel \
 rust-icu_time-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerotrie+serde-devel \
 rust-zerovec+serde-devel \
 "
RDEPENDS:rust-icu_time+unstable-devel = " \
 cargo \
 rust-icu_time-devel \
 "
RDEPENDS:rust-icu_time+unstable_chrono_0_4-devel = " \
 cargo \
 rust-chrono-devel \
 rust-chrono-tz-devel \
 rust-icu_calendar+unstable_chrono_0_4-devel \
 rust-icu_time-devel \
 "
RDEPENDS:rust-icu_time+unstable_jiff_0_2-devel = " \
 cargo \
 rust-icu_calendar+unstable_jiff_0_2-devel \
 rust-icu_time-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-icu_time+unstable_time_0_3-devel = " \
 cargo \
 rust-icu_calendar+unstable_time_0_3-devel \
 rust-icu_time-devel \
 rust-time-devel \
 "
RDEPENDS:rust-icu_time-devel = " \
 cargo \
 rust \
 rust-calendrical_calculations-devel \
 rust-displaydoc-devel \
 rust-icu_calendar-devel \
 rust-icu_locale_core+zerovec-devel \
 rust-icu_locale_core-devel \
 rust-icu_provider-devel \
 rust-zerotrie+yoke-devel \
 rust-zerotrie+zerofrom-devel \
 rust-zerotrie-devel \
 rust-zerovec+derive-devel \
 rust-zerovec+yoke-devel \
 rust-zerovec-devel \
 "
