# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "msv"
PV = "2022.7"
PR = "6.el10"
PACKAGES = " \
 msv-javadoc \
 msv-xsdlib \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/msv-2022.7-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85e0ca5639546fc34f4dbd39565a7c1c68a1e60f6c936d9e58cfa00ccf862431"

URI_x86_64_v2_msv-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/msv-javadoc-2022.7-6.el10.noarch.rpm;name=x86_64_v2_msv-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_msv-javadoc}"
SRC_URI[x86_64_v2_msv-javadoc.sha256sum] = "d2e0d1c1ba001af585a45d1d946bb406a47db8828eee3d25081f81011dca0f08"

URI_x86_64_v2_msv-xsdlib = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/msv-xsdlib-2022.7-6.el10.noarch.rpm;name=x86_64_v2_msv-xsdlib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_msv-xsdlib}"
SRC_URI[x86_64_v2_msv-xsdlib.sha256sum] = "1919d9bfac1e3b758f76994c6aeee70e9a86f3bf8d8b6be700cc58affe70e76d"

URI_aarch64_msv-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/msv-javadoc-2022.7-6.el10.noarch.rpm;name=aarch64_msv-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_msv-javadoc}"
SRC_URI[aarch64_msv-javadoc.sha256sum] = "d2e0d1c1ba001af585a45d1d946bb406a47db8828eee3d25081f81011dca0f08"

URI_aarch64_msv-xsdlib = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/msv-xsdlib-2022.7-6.el10.noarch.rpm;name=aarch64_msv-xsdlib;unpack=0"
SRC_URI:append = " ${URI_aarch64_msv-xsdlib}"
SRC_URI[aarch64_msv-xsdlib.sha256sum] = "1919d9bfac1e3b758f76994c6aeee70e9a86f3bf8d8b6be700cc58affe70e76d"

RDEPENDS:msv-javadoc = " \
 javapackages-filesystem \
 "
RDEPENDS:msv-xsdlib = " \
 javapackages-filesystem \
 relaxng-datatype-java \
 "
