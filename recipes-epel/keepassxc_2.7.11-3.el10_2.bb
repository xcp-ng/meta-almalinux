# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keepassxc"
PV = "2.7.11"
PR = "3.el10_2"
PACKAGES = " \
 keepassxc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/keepassxc-2.7.11-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55375b1cbe114acf8e64463b0d84d6769104c1e6fae2958af0d4073ce39f6640"

URI_x86_64_v2_keepassxc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/keepassxc-2.7.11-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_keepassxc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keepassxc}"
SRC_URI[x86_64_v2_keepassxc.sha256sum] = "9ed86ad7f12f8b015048107abb75fb9a212c621536b1a95b8a82316609a62943"

URI_aarch64_keepassxc = "${EPEL_MIRROR}/aarch64/Packages/k/keepassxc-2.7.11-3.el10_2.aarch64.rpm;name=aarch64_keepassxc;unpack=0"
SRC_URI:append = " ${URI_aarch64_keepassxc}"
SRC_URI[aarch64_keepassxc.sha256sum] = "277382bcdd7c2a5869d38ada7ed75d04926e3db21a18827ec0dffbdff1bd7064"

RDEPENDS:keepassxc = " \
 botan3 \
 glibc \
 libX11 \
 libXtst \
 libargon2 \
 libgcc \
 libstdc++ \
 libusb1 \
 minizip-ng-compat \
 pcsc-lite-libs \
 qrencode-libs \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtsvg \
 qt5-qtx11extras \
 readline \
 zlib-ng-compat \
 "
