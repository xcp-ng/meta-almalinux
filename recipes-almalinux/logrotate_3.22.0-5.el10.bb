# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "logrotate"
PV = "3.22.0"
PR = "5.el10"
PACKAGES = " \
 logrotate \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/logrotate-3.22.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2104020319878d6dfea57c6100187ea5f4b757ca061895771e70205fd4035bca"

URI_x86_64_v2_logrotate = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/logrotate-3.22.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_logrotate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_logrotate}"
SRC_URI[x86_64_v2_logrotate.sha256sum] = "8c6527c2bfb8e23f15692ad217acc7b06bdd648f0f9425c5c5bbbf9c5e9e2ddd"

URI_aarch64_logrotate = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/logrotate-3.22.0-5.el10.aarch64.rpm;name=aarch64_logrotate;unpack=0"
SRC_URI:append = " ${URI_aarch64_logrotate}"
SRC_URI[aarch64_logrotate.sha256sum] = "f523ab30f811d4e1a6461da8d57cc274dd26f88abeaae330b3305b9ada829035"

RDEPENDS:logrotate = " \
 bash \
 glibc \
 libacl \
 libselinux \
 popt \
 systemd \
 virtual/coreutils \
 "
