# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bash"
PV = "5.2.26"
PR = "6.el10"
PACKAGES = " \
 bash \
 bash-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/bash-5.2.26-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8bdbc70bc9a03158c9475057371317096df355a734106612f8d1585f6e24941"

URI_x86_64_v2_bash = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/bash-5.2.26-6.el10.x86_64_v2.rpm;name=x86_64_v2_bash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bash}"
SRC_URI[x86_64_v2_bash.sha256sum] = "06674be4185048638c884c43e5cc458d1d092d013252df9b87fd872aa6860c6c"

URI_x86_64_v2_bash-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/bash-devel-5.2.26-6.el10.x86_64_v2.rpm;name=x86_64_v2_bash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bash-devel}"
SRC_URI[x86_64_v2_bash-devel.sha256sum] = "e1fd331aa3bbd3eeea369985a26710ec2b5c3fe191bfefafe8ed20088032fcd9"

URI_aarch64_bash = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/bash-5.2.26-6.el10.aarch64.rpm;name=aarch64_bash;unpack=0"
SRC_URI:append = " ${URI_aarch64_bash}"
SRC_URI[aarch64_bash.sha256sum] = "1479a2fa43fedec3d7a9a0cc3f9a735d99c32811db9129497bb706e3a4dfab29"

URI_aarch64_bash-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/bash-devel-5.2.26-6.el10.aarch64.rpm;name=aarch64_bash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_bash-devel}"
SRC_URI[aarch64_bash-devel.sha256sum] = "7b714c4c9c566b22c1619029e7fa528659845b4816652d387fefb637ebb60895"

RDEPENDS:bash = " \
 filesystem \
 glibc \
 ncurses-libs \
 "
RDEPENDS:bash-devel = " \
 bash \
 pkgconf-pkg-config \
 "
