# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-core"
PV = "0.3.32"
PR = "1.el10_2"
PACKAGES = " \
 rust-futures-core+alloc-devel \
 rust-futures-core+cfg-target-has-atomic-devel \
 rust-futures-core+default-devel \
 rust-futures-core+portable-atomic-devel \
 rust-futures-core+std-devel \
 rust-futures-core+unstable-devel \
 rust-futures-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-core-0.3.32-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a02addac5c07e476a8b07005b222e0f41b20a5bcd1967b59eb1c7389c10a8863"

URI_x86_64_v2_rust-futures-core+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-core+alloc-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-core+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-core+alloc-devel}"
SRC_URI[x86_64_v2_rust-futures-core+alloc-devel.sha256sum] = "f03c34f252b77ef02a9e6ef19850eca756faa6d3c9c6035d3e873ebfe7a0cacd"

URI_x86_64_v2_rust-futures-core+cfg-target-has-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-core+cfg-target-has-atomic-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-core+cfg-target-has-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-core+cfg-target-has-atomic-devel}"
SRC_URI[x86_64_v2_rust-futures-core+cfg-target-has-atomic-devel.sha256sum] = "e42ebd53d2260fe6e9a061d81bdd4c75763f40fbfe48d8e9eeab9dd253b1f611"

URI_x86_64_v2_rust-futures-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-core+default-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-core+default-devel}"
SRC_URI[x86_64_v2_rust-futures-core+default-devel.sha256sum] = "aef19106254aeb82f40b50584dfbf70c978c24d4133829a96a556ba567239492"

URI_x86_64_v2_rust-futures-core+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-core+portable-atomic-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-core+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-core+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-futures-core+portable-atomic-devel.sha256sum] = "80b397409257c9951fdff279f90c94f82372fc7eb5d532d6716e4a831064dd18"

URI_x86_64_v2_rust-futures-core+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-core+std-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-core+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-core+std-devel}"
SRC_URI[x86_64_v2_rust-futures-core+std-devel.sha256sum] = "ae698544c621838a57258b876362af137c11fe1be790f0b67e3b2bde04d107f6"

URI_x86_64_v2_rust-futures-core+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-core+unstable-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-core+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-core+unstable-devel}"
SRC_URI[x86_64_v2_rust-futures-core+unstable-devel.sha256sum] = "61941805127d1e1b92e5608457dc735e7e948202b70b73038b0b3242a189b487"

URI_x86_64_v2_rust-futures-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-core-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-core-devel}"
SRC_URI[x86_64_v2_rust-futures-core-devel.sha256sum] = "37af4e7432017eef4c6cb1f2cc7eb2a30d677427e28215a7bcd029295617f72d"

URI_aarch64_rust-futures-core+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-core+alloc-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-core+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-core+alloc-devel}"
SRC_URI[aarch64_rust-futures-core+alloc-devel.sha256sum] = "1fce3e6157fa09d1db0dcac2f11a3834e689a72854296eb5d2afbc56c09b2c3b"

URI_aarch64_rust-futures-core+cfg-target-has-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-core+cfg-target-has-atomic-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-core+cfg-target-has-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-core+cfg-target-has-atomic-devel}"
SRC_URI[aarch64_rust-futures-core+cfg-target-has-atomic-devel.sha256sum] = "088add7205d02c56704f967afda005687a3e776111886b3580fe29465abc4a58"

URI_aarch64_rust-futures-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-core+default-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-core+default-devel}"
SRC_URI[aarch64_rust-futures-core+default-devel.sha256sum] = "da289b9a529925af3b50c803d4e77d88afb8305bd9c14e5e98e5e0079e894b1a"

URI_aarch64_rust-futures-core+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-core+portable-atomic-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-core+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-core+portable-atomic-devel}"
SRC_URI[aarch64_rust-futures-core+portable-atomic-devel.sha256sum] = "65d013e0087f45ab8f24bc3283c70fd7c0325dadd2cfc521c6264deca95b5fd1"

URI_aarch64_rust-futures-core+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-core+std-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-core+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-core+std-devel}"
SRC_URI[aarch64_rust-futures-core+std-devel.sha256sum] = "e1af19e6f949a01df86fe9d5497d7839ad90a0071c72a689adb6aa929ab9b95f"

URI_aarch64_rust-futures-core+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-core+unstable-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-core+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-core+unstable-devel}"
SRC_URI[aarch64_rust-futures-core+unstable-devel.sha256sum] = "bbd459795f81e9609b57c811bd665f3ae68d10559a307da134a6919e83db62da"

URI_aarch64_rust-futures-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-core-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-core-devel}"
SRC_URI[aarch64_rust-futures-core-devel.sha256sum] = "d3164f60dfa894efb7f9e488e67857aa0608f09d07544a5ce646db4603d24427"

RDEPENDS:rust-futures-core+alloc-devel = " \
 cargo \
 rust-futures-core-devel \
 "
RDEPENDS:rust-futures-core+cfg-target-has-atomic-devel = " \
 cargo \
 rust-futures-core-devel \
 "
RDEPENDS:rust-futures-core+default-devel = " \
 cargo \
 rust-futures-core+std-devel \
 rust-futures-core-devel \
 "
RDEPENDS:rust-futures-core+portable-atomic-devel = " \
 cargo \
 rust-futures-core-devel \
 rust-portable-atomic+require-cas-devel \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-futures-core+std-devel = " \
 cargo \
 rust-futures-core+alloc-devel \
 rust-futures-core-devel \
 "
RDEPENDS:rust-futures-core+unstable-devel = " \
 cargo \
 rust-futures-core-devel \
 "
RDEPENDS:rust-futures-core-devel = " \
 cargo \
 rust \
 "
