# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "distribution-gpg-keys"
PV = "1.123"
PR = "1.el10_3"
PACKAGES = " \
 distribution-gpg-keys \
 distribution-gpg-keys-copr \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/distribution-gpg-keys-1.123-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "858df4ac29a0e22df94f0057cb539dd364b18c5c7cffeda123fc51c53f1ca5c1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/distribution-gpg-keys-1.123-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_distribution-gpg-keys;unpack=0"
SRC_URI[x86_64_v2_distribution-gpg-keys.sha256sum] = "db03ab924a483ef9f9368f17c24d7a1030f16a167b5bd8d8cd013920f254aed7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/distribution-gpg-keys-copr-1.123-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_distribution-gpg-keys-copr;unpack=0"
SRC_URI[x86_64_v2_distribution-gpg-keys-copr.sha256sum] = "08f26a676eacae8d52eded4f9ba2661ce03e102ddcfd7008ec7fa9272e32ce06"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/distribution-gpg-keys-1.123-1.el10_3.noarch.rpm;name=aarch64_distribution-gpg-keys;unpack=0"
SRC_URI[aarch64_distribution-gpg-keys.sha256sum] = "030d53b08e52b653362dcc71cccb0d82c8f8d19938b7477014c6852c10da8048"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/distribution-gpg-keys-copr-1.123-1.el10_3.noarch.rpm;name=aarch64_distribution-gpg-keys-copr;unpack=0"
SRC_URI[aarch64_distribution-gpg-keys-copr.sha256sum] = "62ea729b4df28378acff226e25c9b10fa6230c2c3cc108648d5c63061ad9cc5e"

RDEPENDS:distribution-gpg-keys = " \
 "
RDEPENDS:distribution-gpg-keys-copr = " \
 "
