# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ratatui-widgets"
PV = "0.3.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-ratatui-widgets+all-widgets-devel \
 rust-ratatui-widgets+calendar-devel \
 rust-ratatui-widgets+default-devel \
 rust-ratatui-widgets+document-features-devel \
 rust-ratatui-widgets+serde-devel \
 rust-ratatui-widgets+std-devel \
 rust-ratatui-widgets+unstable-devel \
 rust-ratatui-widgets+unstable-rendered-line-info-devel \
 rust-ratatui-widgets-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ratatui-widgets-0.3.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d304a33114c6034e338d7d1b5f26e632a11c36d161dace883ae4e31aecbefc5"

URI_x86_64_v2_rust-ratatui-widgets+all-widgets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-widgets+all-widgets-devel-0.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-widgets+all-widgets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-widgets+all-widgets-devel}"
SRC_URI[x86_64_v2_rust-ratatui-widgets+all-widgets-devel.sha256sum] = "e9c8e7e26122ebfb7ad314b7f6d858075bc8571562abea648f40de4d5155be4a"

URI_x86_64_v2_rust-ratatui-widgets+calendar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-widgets+calendar-devel-0.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-widgets+calendar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-widgets+calendar-devel}"
SRC_URI[x86_64_v2_rust-ratatui-widgets+calendar-devel.sha256sum] = "a0535fab2cad12f4ee78e66c72da3df2d914f8a9509f56ad47f97406cb6d1999"

URI_x86_64_v2_rust-ratatui-widgets+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-widgets+default-devel-0.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-widgets+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-widgets+default-devel}"
SRC_URI[x86_64_v2_rust-ratatui-widgets+default-devel.sha256sum] = "5ecf709720e7cc62bd5717774ecd236a53f2c9573dcbb3f24defa3b7df02044d"

URI_x86_64_v2_rust-ratatui-widgets+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-widgets+document-features-devel-0.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-widgets+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-widgets+document-features-devel}"
SRC_URI[x86_64_v2_rust-ratatui-widgets+document-features-devel.sha256sum] = "dadb5aefd36eccb27a62f77f11f4e48f1c724b4bc945eb4700ec35f52d591250"

URI_x86_64_v2_rust-ratatui-widgets+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-widgets+serde-devel-0.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-widgets+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-widgets+serde-devel}"
SRC_URI[x86_64_v2_rust-ratatui-widgets+serde-devel.sha256sum] = "56cc6827698de0cfec2b91a380e1e9b165cb0aafcb58883f492b059f2b9131a7"

URI_x86_64_v2_rust-ratatui-widgets+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-widgets+std-devel-0.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-widgets+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-widgets+std-devel}"
SRC_URI[x86_64_v2_rust-ratatui-widgets+std-devel.sha256sum] = "ba0073ce7e4a0bc335613dc416c2639792ad0e898605258ef9e66e11fbdcbb6f"

URI_x86_64_v2_rust-ratatui-widgets+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-widgets+unstable-devel-0.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-widgets+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-widgets+unstable-devel}"
SRC_URI[x86_64_v2_rust-ratatui-widgets+unstable-devel.sha256sum] = "8fb6707b047097589c761ece0bc28dcbbc2da174190fbd9562b9e05b08194aa9"

URI_x86_64_v2_rust-ratatui-widgets+unstable-rendered-line-info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-widgets+unstable-rendered-line-info-devel-0.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-widgets+unstable-rendered-line-info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-widgets+unstable-rendered-line-info-devel}"
SRC_URI[x86_64_v2_rust-ratatui-widgets+unstable-rendered-line-info-devel.sha256sum] = "3ab761f34d380d02c6d6a0a360cc05d744f5ba5689e826f531eb2b850d61449e"

URI_x86_64_v2_rust-ratatui-widgets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-widgets-devel-0.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-widgets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-widgets-devel}"
SRC_URI[x86_64_v2_rust-ratatui-widgets-devel.sha256sum] = "a1d7cebf295f4073c2c8f3dde795f59addaa45b67c276c72e5d60385540db76f"

URI_aarch64_rust-ratatui-widgets+all-widgets-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-widgets+all-widgets-devel-0.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-widgets+all-widgets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-widgets+all-widgets-devel}"
SRC_URI[aarch64_rust-ratatui-widgets+all-widgets-devel.sha256sum] = "2e046bef52283d839f4589d0473eb5484b7df58fae59970c546bb2e14f11a167"

URI_aarch64_rust-ratatui-widgets+calendar-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-widgets+calendar-devel-0.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-widgets+calendar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-widgets+calendar-devel}"
SRC_URI[aarch64_rust-ratatui-widgets+calendar-devel.sha256sum] = "6bbef0715820104f3b7348c6674063a2cbdbc98f41d524dad54a3cdaa7fe1dda"

URI_aarch64_rust-ratatui-widgets+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-widgets+default-devel-0.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-widgets+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-widgets+default-devel}"
SRC_URI[aarch64_rust-ratatui-widgets+default-devel.sha256sum] = "e2458c6d2b121dd4f233275d0f3c995877073677108a2f281c12a86727c01c9a"

URI_aarch64_rust-ratatui-widgets+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-widgets+document-features-devel-0.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-widgets+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-widgets+document-features-devel}"
SRC_URI[aarch64_rust-ratatui-widgets+document-features-devel.sha256sum] = "1e488795e7bb4f08622701b4ec70c5cd5ef3c1305397b1127fb7f8b844743dde"

URI_aarch64_rust-ratatui-widgets+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-widgets+serde-devel-0.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-widgets+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-widgets+serde-devel}"
SRC_URI[aarch64_rust-ratatui-widgets+serde-devel.sha256sum] = "40f9f4fb4bbcdf830594930becd08b69cfcd624b3ee637d98763068cb959617d"

URI_aarch64_rust-ratatui-widgets+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-widgets+std-devel-0.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-widgets+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-widgets+std-devel}"
SRC_URI[aarch64_rust-ratatui-widgets+std-devel.sha256sum] = "7ac739f2b4749781577ee5f994d8bed3b02eb0a9f2b16572ebd1fa491ae24ef6"

URI_aarch64_rust-ratatui-widgets+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-widgets+unstable-devel-0.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-widgets+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-widgets+unstable-devel}"
SRC_URI[aarch64_rust-ratatui-widgets+unstable-devel.sha256sum] = "7bdef9bca4f2baac1fcdf6fa9efcf820d31ccffcadd0839d8221a2a1347e7951"

URI_aarch64_rust-ratatui-widgets+unstable-rendered-line-info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-widgets+unstable-rendered-line-info-devel-0.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-widgets+unstable-rendered-line-info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-widgets+unstable-rendered-line-info-devel}"
SRC_URI[aarch64_rust-ratatui-widgets+unstable-rendered-line-info-devel.sha256sum] = "2a2a2fbdde7363b7931e34df46dc8c4606fd1c871f287ffb07a3d3e38055c87c"

URI_aarch64_rust-ratatui-widgets-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-widgets-devel-0.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-widgets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-widgets-devel}"
SRC_URI[aarch64_rust-ratatui-widgets-devel.sha256sum] = "2fd42cc4ee74b76338b741c90757458cd311247faf2ae3b7e2b5542f050524de"

RDEPENDS:rust-ratatui-widgets+all-widgets-devel = " \
 cargo \
 rust-ratatui-widgets+calendar-devel \
 rust-ratatui-widgets-devel \
 "
RDEPENDS:rust-ratatui-widgets+calendar-devel = " \
 cargo \
 rust-ratatui-widgets-devel \
 rust-time-devel \
 "
RDEPENDS:rust-ratatui-widgets+default-devel = " \
 cargo \
 rust-ratatui-widgets+all-widgets-devel \
 rust-ratatui-widgets-devel \
 "
RDEPENDS:rust-ratatui-widgets+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-ratatui-widgets-devel \
 "
RDEPENDS:rust-ratatui-widgets+serde-devel = " \
 cargo \
 rust-ratatui-core+serde-devel \
 rust-ratatui-widgets-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-ratatui-widgets+std-devel = " \
 cargo \
 rust-ratatui-widgets-devel \
 rust-time+local-offset-devel \
 rust-time-devel \
 "
RDEPENDS:rust-ratatui-widgets+unstable-devel = " \
 cargo \
 rust-ratatui-widgets+unstable-rendered-line-info-devel \
 rust-ratatui-widgets-devel \
 "
RDEPENDS:rust-ratatui-widgets+unstable-rendered-line-info-devel = " \
 cargo \
 rust-ratatui-widgets-devel \
 "
RDEPENDS:rust-ratatui-widgets-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-hashbrown+default-devel \
 rust-indoc+default-devel \
 rust-instability+default-devel \
 rust-itertools+use_alloc-devel \
 rust-itertools-devel \
 rust-line-clipping+default-devel \
 rust-ratatui-core+default-devel \
 rust-strum+derive-devel \
 rust-strum-devel \
 rust-unicode-segmentation+default-devel \
 rust-unicode-width+default-devel \
 "
