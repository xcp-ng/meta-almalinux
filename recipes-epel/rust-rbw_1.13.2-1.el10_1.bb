# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rbw"
PV = "1.13.2"
PR = "1.el10_1"
PACKAGES = " \
 rbw \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rbw-1.13.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f615e4297e9fad48c038fa8d2e4cc959c58009bb586fa8394b2ac59d36c5afe9"

URI_x86_64_v2_rbw = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rbw-1.13.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rbw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rbw}"
SRC_URI[x86_64_v2_rbw.sha256sum] = "7cfd9fe6dbe53c20d8bf60f3fc1ac4ab12651caf5c3f0090027be3a3e67f9caf"

URI_aarch64_rbw = "${EPEL_MIRROR}/aarch64/Packages/r/rbw-1.13.2-1.el10_1.aarch64.rpm;name=aarch64_rbw;unpack=0"
SRC_URI:append = " ${URI_aarch64_rbw}"
SRC_URI[aarch64_rbw.sha256sum] = "791c80a5d3dd04b90ebcd67a839dd16839b78db7cd7b2166405ec4e2abb166e5"

RDEPENDS:rbw = " \
 glibc \
 libgcc \
 "
