# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unic-ucd-hangul"
PV = "0.9.0"
PR = "5.el10_0"
PACKAGES = " \
 rust-unic-ucd-hangul+default-devel \
 rust-unic-ucd-hangul-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unic-ucd-hangul-0.9.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "39a45dea631c89f94f2d3e1e706a0a184f0cf97dd59205a670276880cf0e3f0d"

URI_x86_64_v2_rust-unic-ucd-hangul+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-ucd-hangul+default-devel-0.9.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-ucd-hangul+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-ucd-hangul+default-devel}"
SRC_URI[x86_64_v2_rust-unic-ucd-hangul+default-devel.sha256sum] = "36fde688698c42f15ce3214710774a09f8789ab5854e6293219a3bac9cf66721"

URI_x86_64_v2_rust-unic-ucd-hangul-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-ucd-hangul-devel-0.9.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-ucd-hangul-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-ucd-hangul-devel}"
SRC_URI[x86_64_v2_rust-unic-ucd-hangul-devel.sha256sum] = "f1dbeda17ad523bc215b448782a36c023d6fab9993e28b6b7d757642af548676"

URI_aarch64_rust-unic-ucd-hangul+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-ucd-hangul+default-devel-0.9.0-5.el10_0.noarch.rpm;name=aarch64_rust-unic-ucd-hangul+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-ucd-hangul+default-devel}"
SRC_URI[aarch64_rust-unic-ucd-hangul+default-devel.sha256sum] = "cf8033e52e5749a992544a9ef026d22d4d0033ab37865b4a2b8abfd75d69e7e8"

URI_aarch64_rust-unic-ucd-hangul-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-ucd-hangul-devel-0.9.0-5.el10_0.noarch.rpm;name=aarch64_rust-unic-ucd-hangul-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-ucd-hangul-devel}"
SRC_URI[aarch64_rust-unic-ucd-hangul-devel.sha256sum] = "34a12a033677a61a5d1920da8d2c8d3b9a618965931d9876b9406b449dff5059"

RDEPENDS:rust-unic-ucd-hangul+default-devel = " \
 cargo \
 rust-unic-ucd-hangul-devel \
 "
RDEPENDS:rust-unic-ucd-hangul-devel = " \
 cargo \
 rust-unic-ucd-version+default-devel \
 "
