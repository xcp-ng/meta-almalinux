# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossbeam-deque"
PV = "0.8.7"
PR = "1.el10_3"
PACKAGES = " \
 rust-crossbeam-deque+default-devel \
 rust-crossbeam-deque+std-devel \
 rust-crossbeam-deque-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crossbeam-deque-0.8.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f1fceedf3eec1eb6faa056f679fa1636372ac06b31010e4e2e84820ef3f4e82"

URI_x86_64_v2_rust-crossbeam-deque+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-deque+default-devel-0.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-deque+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-deque+default-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-deque+default-devel.sha256sum] = "f7bbd8bdde4a81ddad1ecdb5dc7f5a360eae2b066e753a88bddee4a245b516b9"

URI_x86_64_v2_rust-crossbeam-deque+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-deque+std-devel-0.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-deque+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-deque+std-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-deque+std-devel.sha256sum] = "00ac0fa4ec73c0c7c5bae89a6bbfdce8d0f502fbb851e6435ad08f993f693838"

URI_x86_64_v2_rust-crossbeam-deque-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-deque-devel-0.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-deque-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-deque-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-deque-devel.sha256sum] = "e5ee68cc95b176124dbe0d1058a135a4779fb00e71b87e5798201bcb0e7459d3"

URI_aarch64_rust-crossbeam-deque+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-deque+default-devel-0.8.7-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-deque+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-deque+default-devel}"
SRC_URI[aarch64_rust-crossbeam-deque+default-devel.sha256sum] = "e3352ecb8f7679aa3119a436a7fa08dab4f1c3e21b98a69337e7eaf14f0a8139"

URI_aarch64_rust-crossbeam-deque+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-deque+std-devel-0.8.7-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-deque+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-deque+std-devel}"
SRC_URI[aarch64_rust-crossbeam-deque+std-devel.sha256sum] = "b937854e89a5c051e647a294ab191e0d7aee317330d8279e31a470983945f4ee"

URI_aarch64_rust-crossbeam-deque-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-deque-devel-0.8.7-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-deque-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-deque-devel}"
SRC_URI[aarch64_rust-crossbeam-deque-devel.sha256sum] = "e302417bd5941ad118cba2be1a5eba8266adb2c9785b9c30e9c081ed0d81205b"

RDEPENDS:rust-crossbeam-deque+default-devel = " \
 cargo \
 rust-crossbeam-deque+std-devel \
 rust-crossbeam-deque-devel \
 "
RDEPENDS:rust-crossbeam-deque+std-devel = " \
 cargo \
 rust-crossbeam-deque-devel \
 rust-crossbeam-epoch+std-devel \
 rust-crossbeam-utils+std-devel \
 "
RDEPENDS:rust-crossbeam-deque-devel = " \
 cargo \
 rust \
 rust-crossbeam-epoch-devel \
 rust-crossbeam-utils-devel \
 "
