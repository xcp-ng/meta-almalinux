# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua-luaossl"
PV = "20200709"
PR = "8.el10_1"
PACKAGES = " \
 lua-luaossl \
 lua-luaossl-doc \
 lua5.1-luaossl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lua-luaossl-20200709-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5983a20033b476600a6c0a4483a826691b7bdd1a6e0e24b9582ff813fe9d9bcb"

URI_x86_64_v2_lua-luaossl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua-luaossl-20200709-8.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lua-luaossl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-luaossl}"
SRC_URI[x86_64_v2_lua-luaossl.sha256sum] = "993f9db9f3df3c42a9f865095408fdebe00f7fdea5b5d5430b07b028ce8924d9"

URI_x86_64_v2_lua-luaossl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua-luaossl-doc-20200709-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lua-luaossl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-luaossl-doc}"
SRC_URI[x86_64_v2_lua-luaossl-doc.sha256sum] = "7aa76ceec711cbe07adcc26e2c610a1119071c8ec504bad3a2f4afc25433d329"

URI_x86_64_v2_lua5.1-luaossl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua5.1-luaossl-20200709-8.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lua5.1-luaossl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua5.1-luaossl}"
SRC_URI[x86_64_v2_lua5.1-luaossl.sha256sum] = "b4d77fc361a06267f9950bfade6bbc77cc330d5e695ea144b4a50e94a561a6c5"

URI_aarch64_lua-luaossl = "${EPEL_MIRROR}/aarch64/Packages/l/lua-luaossl-20200709-8.el10_1.aarch64.rpm;name=aarch64_lua-luaossl;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-luaossl}"
SRC_URI[aarch64_lua-luaossl.sha256sum] = "0e9f3fa027d97c673173d5e2b7250683b554408828a8c7e916226d302885f203"

URI_aarch64_lua-luaossl-doc = "${EPEL_MIRROR}/aarch64/Packages/l/lua-luaossl-doc-20200709-8.el10_1.noarch.rpm;name=aarch64_lua-luaossl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-luaossl-doc}"
SRC_URI[aarch64_lua-luaossl-doc.sha256sum] = "b7977fd7ceecfcc5e7fcffb07669a77a31ade00d431f7a7806661a35052cea2b"

URI_aarch64_lua5.1-luaossl = "${EPEL_MIRROR}/aarch64/Packages/l/lua5.1-luaossl-20200709-8.el10_1.aarch64.rpm;name=aarch64_lua5.1-luaossl;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua5.1-luaossl}"
SRC_URI[aarch64_lua5.1-luaossl.sha256sum] = "ec53ec9d07c68f53b9794aa18d8b41865623606a7922791339ae4397b413955b"

RDEPENDS:lua-luaossl = " \
 glibc \
 lua-libs \
 openssl-libs \
 "
RDEPENDS:lua-luaossl-doc = " \
 lua-luaossl \
 lua5.1-luaossl \
 "
RDEPENDS:lua5.1-luaossl = " \
 compat-lua-libs \
 glibc \
 openssl-libs \
 "
