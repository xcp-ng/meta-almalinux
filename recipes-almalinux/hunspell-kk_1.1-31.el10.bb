# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-kk"
PV = "1.1"
PR = "31.el10"
PACKAGES = " \
 hunspell-kk \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-kk-1.1-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bbcc149a649e4cc67ed005d6b3332a21f9eb9b9ce8f29cf0b37bd3a8b7a3eb5f"

URI_x86_64_v2_hunspell-kk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-kk-1.1-31.el10.noarch.rpm;name=x86_64_v2_hunspell-kk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-kk}"
SRC_URI[x86_64_v2_hunspell-kk.sha256sum] = "2ddfee64137373799798f2b3747e13eea8403c64dce915830d756e390f7ee34b"

URI_aarch64_hunspell-kk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-kk-1.1-31.el10.noarch.rpm;name=aarch64_hunspell-kk;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-kk}"
SRC_URI[aarch64_hunspell-kk.sha256sum] = "2ddfee64137373799798f2b3747e13eea8403c64dce915830d756e390f7ee34b"

RDEPENDS:hunspell-kk = " \
 hunspell-filesystem \
 "
