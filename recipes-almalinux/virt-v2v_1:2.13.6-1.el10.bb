# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "virt-v2v"
PE = "1"
PV = "2.13.6"
PR = "1.el10"
PACKAGES:x86_64_v2 = " \
 virt-v2v \
 virt-v2v-bash-completion \
 virt-v2v-man-pages-ja \
 virt-v2v-man-pages-uk \
"
PACKAGES:aarch64 = " \
 virt-v2v-bash-completion \
 virt-v2v-man-pages-ja \
 virt-v2v-man-pages-uk \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/virt-v2v-2.13.6-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9956401e8d1f2a2b616c5380dc27fb51f32c7aa3ca548953ba1b389c62609eb5"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - virt-v2v-bash-completion: virt-v2v = 1:2.13.6-1.el10
# - virt-v2v-man-pages-ja: virt-v2v = 1:2.13.6-1.el10
# - virt-v2v-man-pages-uk: virt-v2v = 1:2.13.6-1.el10

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/virt-v2v-2.13.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_virt-v2v;unpack=0"
SRC_URI[x86_64_v2_virt-v2v.sha256sum] = "f42ffa6ae94112a669a08a013842f0dce5957d29ea4da65604d6d75d06cf0901"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/virt-v2v-bash-completion-2.13.6-1.el10.noarch.rpm;name=x86_64_v2_virt-v2v-bash-completion;unpack=0"
SRC_URI[x86_64_v2_virt-v2v-bash-completion.sha256sum] = "d8dc2390c533e4b9db560c53e80b0cf78d246d9f27985484049d4cacf8e8048e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/virt-v2v-man-pages-ja-2.13.6-1.el10.noarch.rpm;name=x86_64_v2_virt-v2v-man-pages-ja;unpack=0"
SRC_URI[x86_64_v2_virt-v2v-man-pages-ja.sha256sum] = "a78fcbbf235bfb5b9001985d7597fca02576f403ccf14780749d3e0f261f3a15"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/virt-v2v-man-pages-uk-2.13.6-1.el10.noarch.rpm;name=x86_64_v2_virt-v2v-man-pages-uk;unpack=0"
SRC_URI[x86_64_v2_virt-v2v-man-pages-uk.sha256sum] = "b08a918e88f2fabe74142013578a7971af23116b370a2afba8e092663ac53f21"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/virt-v2v-bash-completion-2.13.6-1.el10.noarch.rpm;name=aarch64_virt-v2v-bash-completion;unpack=0"
SRC_URI[aarch64_virt-v2v-bash-completion.sha256sum] = "d8dc2390c533e4b9db560c53e80b0cf78d246d9f27985484049d4cacf8e8048e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/virt-v2v-man-pages-ja-2.13.6-1.el10.noarch.rpm;name=aarch64_virt-v2v-man-pages-ja;unpack=0"
SRC_URI[aarch64_virt-v2v-man-pages-ja.sha256sum] = "a78fcbbf235bfb5b9001985d7597fca02576f403ccf14780749d3e0f261f3a15"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/virt-v2v-man-pages-uk-2.13.6-1.el10.noarch.rpm;name=aarch64_virt-v2v-man-pages-uk;unpack=0"
SRC_URI[aarch64_virt-v2v-man-pages-uk.sha256sum] = "b08a918e88f2fabe74142013578a7971af23116b370a2afba8e092663ac53f21"

RDEPENDS:virt-v2v = " \
 curl \
 edk2-ovmf \
 gawk \
 glib2 \
 glibc \
 guestfs-tools \
 gzip \
 json-c \
 libgcc \
 libguestfs \
 libguestfs-winsupport \
 libguestfs-xfs \
 libnbd \
 libosinfo \
 libvirt-client \
 libvirt-libs \
 libxcrypt \
 libxml2 \
 mingw-srvany-redistributable \
 nbdkit-basic-filters \
 nbdkit-basic-plugins \
 nbdkit-curl-plugin \
 nbdkit-nbd-plugin \
 nbdkit-python-plugin \
 nbdkit-server \
 nbdkit-ssh-plugin \
 nbdkit-vddk-plugin \
 openssh-clients \
 openssl \
 pcre2 \
 python3 \
 qemu-img \
 unzip \
 "
RDEPENDS:virt-v2v-bash-completion:x86_64_v2 = " \
 bash-completion \
 virt-v2v \
"
RDEPENDS:virt-v2v-bash-completion:aarch64 = " \
 bash-completion \
"
RDEPENDS:virt-v2v-man-pages-ja:x86_64_v2 = " \
 virt-v2v \
"
RDEPENDS:virt-v2v-man-pages-ja:aarch64 = " \
  \
"
RDEPENDS:virt-v2v-man-pages-uk:x86_64_v2 = " \
 virt-v2v \
"
RDEPENDS:virt-v2v-man-pages-uk:aarch64 = " \
  \
"
