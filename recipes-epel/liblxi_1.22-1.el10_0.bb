# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "liblxi"
PV = "1.22"
PR = "1.el10_0"
PACKAGES = " \
 liblxi \
 liblxi-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/liblxi-1.22-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e6b97e421b20c2872531428ad8846117a0a0028ee67d360070ebf6ea06d7d99"

URI_x86_64_v2_liblxi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liblxi-1.22-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liblxi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liblxi}"
SRC_URI[x86_64_v2_liblxi.sha256sum] = "26c4ae85258c47845fae5056abd38adb3e9990075463a58f1ba149babb738d9b"

URI_x86_64_v2_liblxi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liblxi-devel-1.22-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liblxi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liblxi-devel}"
SRC_URI[x86_64_v2_liblxi-devel.sha256sum] = "9f173634d37366cb3984c4b7dcefe9425b1fe422c8d5882e57929c03707e3be7"

URI_aarch64_liblxi = "${EPEL_MIRROR}/aarch64/Packages/l/liblxi-1.22-1.el10_0.aarch64.rpm;name=aarch64_liblxi;unpack=0"
SRC_URI:append = " ${URI_aarch64_liblxi}"
SRC_URI[aarch64_liblxi.sha256sum] = "8d540177cf447fdd51dfa720116aa823c180a86eeb4bf55114ca9f2570de2f43"

URI_aarch64_liblxi-devel = "${EPEL_MIRROR}/aarch64/Packages/l/liblxi-devel-1.22-1.el10_0.aarch64.rpm;name=aarch64_liblxi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_liblxi-devel}"
SRC_URI[aarch64_liblxi-devel.sha256sum] = "e839b9a4bd3fbbc69c0696e04e6961a9729f6627e65ce5188aa4fdb0f8fc7136"

RDEPENDS:liblxi = " \
 avahi-libs \
 glibc \
 libxml2 \
 "
RDEPENDS:liblxi-devel = " \
 liblxi \
 pkgconf-pkg-config \
 "
