# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libreswan"
PV = "5.2"
PR = "1.el10_0"
PACKAGES = " \
 libreswan \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libreswan-5.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "defa519dc81d9de9bb55bd6a699ffb7863a7051ab45c55455ceddf959835c00e"

URI_x86_64_v2_libreswan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libreswan-5.2-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_libreswan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libreswan}"
SRC_URI[x86_64_v2_libreswan.sha256sum] = "27bc52ab502708ef096b32cb56775fe4e85724983dff1aad65c868ba25244e12"

URI_aarch64_libreswan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libreswan-5.2-1.el10_0.aarch64.rpm;name=aarch64_libreswan;unpack=0"
SRC_URI:append = " ${URI_aarch64_libreswan}"
SRC_URI[aarch64_libreswan.sha256sum] = "a7043879ffc50c8176c3eb8040bf00839e3986e8ee4fa1cd90ef4b85bc8c59ed"

RDEPENDS:libreswan = " \
 audit-libs \
 bash \
 glibc \
 iproute \
 ldns \
 libcap-ng \
 libevent \
 libgcc \
 libseccomp \
 libselinux \
 libxcrypt \
 logrotate \
 nspr \
 nss \
 nss-softokn \
 nss-tools \
 nss-util \
 openldap \
 pam-libs \
 procps-ng \
 systemd \
 unbound-libs \
 virtual/coreutils \
 virtual/libcurl.so.4___64bit_ \
 "
