# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xorg-x11-server-Xwayland"
PV = "24.1.5"
PR = "5.el10_0"
PACKAGES = " \
 xorg-x11-server-Xwayland \
 xorg-x11-server-Xwayland-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xorg-x11-server-Xwayland-24.1.5-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf4872913481ac32170816dc02166cf49db31b12ec863ffd44ab0ca9809c88d6"

URI_x86_64_v2_xorg-x11-server-Xwayland = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xorg-x11-server-Xwayland-24.1.5-5.el10_0.x86_64_v2.rpm;name=x86_64_v2_xorg-x11-server-Xwayland;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xorg-x11-server-Xwayland}"
SRC_URI[x86_64_v2_xorg-x11-server-Xwayland.sha256sum] = "87de622f9850bbed37768cf901e6ee44fdd14d9ba956200f4bb63d256c3eb383"

URI_x86_64_v2_xorg-x11-server-Xwayland-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xorg-x11-server-Xwayland-devel-24.1.5-5.el10_0.x86_64_v2.rpm;name=x86_64_v2_xorg-x11-server-Xwayland-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xorg-x11-server-Xwayland-devel}"
SRC_URI[x86_64_v2_xorg-x11-server-Xwayland-devel.sha256sum] = "4fbed2a1e870f006ef8fc34316359bbddb3d308d3642ff9925ad43cc8d4c2b5a"

URI_aarch64_xorg-x11-server-Xwayland = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xorg-x11-server-Xwayland-24.1.5-5.el10_0.aarch64.rpm;name=aarch64_xorg-x11-server-Xwayland;unpack=0"
SRC_URI:append = " ${URI_aarch64_xorg-x11-server-Xwayland}"
SRC_URI[aarch64_xorg-x11-server-Xwayland.sha256sum] = "b34c7f90813659da1242280fe37f4a36b19bdcc6ffcb75b1348442fb47116ec7"

URI_aarch64_xorg-x11-server-Xwayland-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xorg-x11-server-Xwayland-devel-24.1.5-5.el10_0.aarch64.rpm;name=aarch64_xorg-x11-server-Xwayland-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xorg-x11-server-Xwayland-devel}"
SRC_URI[aarch64_xorg-x11-server-Xwayland-devel.sha256sum] = "570bd197bbc0b2cccd5a63ee53a676098eb1a04cc682f147919911bf834e9884"

RDEPENDS:xorg-x11-server-Xwayland = " \
 audit-libs \
 glibc \
 libXau \
 libXdmcp \
 libXfont2 \
 libdecor \
 libdrm \
 libei \
 libepoxy \
 libglvnd-egl \
 libglvnd-glx \
 liboeffis \
 libselinux \
 libtirpc \
 libwayland-client \
 libxcvt \
 libxshmfence \
 mesa-libgbm \
 openssl-libs \
 pixman \
 xkbcomp \
 xkeyboard-config \
 "
RDEPENDS:xorg-x11-server-Xwayland-devel = " \
 pkgconf-pkg-config \
 xorg-x11-server-Xwayland \
 "
