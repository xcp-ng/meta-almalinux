# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-deunicode"
PV = "1.6.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-deunicode+alloc-devel \
 rust-deunicode+default-devel \
 rust-deunicode-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-deunicode-1.6.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d04cd32e632d633d1aa26eeb874f20b39f6fe183ed4bda6c5ee0cff3fc906597"

URI_x86_64_v2_rust-deunicode+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deunicode+alloc-devel-1.6.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deunicode+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deunicode+alloc-devel}"
SRC_URI[x86_64_v2_rust-deunicode+alloc-devel.sha256sum] = "b18db7ee67593cd9269efc3812130eca9f666084ce91ed9299de2894ed94226c"

URI_x86_64_v2_rust-deunicode+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deunicode+default-devel-1.6.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deunicode+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deunicode+default-devel}"
SRC_URI[x86_64_v2_rust-deunicode+default-devel.sha256sum] = "b8c384d895ae8017f04258582fb9ffa6c337b5a54da05b0ff7b3994a9f701552"

URI_x86_64_v2_rust-deunicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deunicode-devel-1.6.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deunicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deunicode-devel}"
SRC_URI[x86_64_v2_rust-deunicode-devel.sha256sum] = "fbcf0a83368653670ca951feb368795ae397949ee6f09b09e03e074efdfa17ef"

URI_aarch64_rust-deunicode+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deunicode+alloc-devel-1.6.2-1.el10_1.noarch.rpm;name=aarch64_rust-deunicode+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deunicode+alloc-devel}"
SRC_URI[aarch64_rust-deunicode+alloc-devel.sha256sum] = "277370684b54a2e49e6127b930b2db46050f2171b373860b150c3763041b2e69"

URI_aarch64_rust-deunicode+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deunicode+default-devel-1.6.2-1.el10_1.noarch.rpm;name=aarch64_rust-deunicode+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deunicode+default-devel}"
SRC_URI[aarch64_rust-deunicode+default-devel.sha256sum] = "18cd6f88377ab173c09854d99157fcb82d2e6a00c7a08d1cd3c0ed5dc087690e"

URI_aarch64_rust-deunicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deunicode-devel-1.6.2-1.el10_1.noarch.rpm;name=aarch64_rust-deunicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deunicode-devel}"
SRC_URI[aarch64_rust-deunicode-devel.sha256sum] = "540139c1dbe47350b577da7e3459e72ffbf29199fa7dd5812b7351ed699f1c83"

RDEPENDS:rust-deunicode+alloc-devel = " \
 cargo \
 rust-deunicode-devel \
 "
RDEPENDS:rust-deunicode+default-devel = " \
 cargo \
 rust-deunicode+alloc-devel \
 rust-deunicode-devel \
 "
RDEPENDS:rust-deunicode-devel = " \
 cargo \
 rust \
 "
