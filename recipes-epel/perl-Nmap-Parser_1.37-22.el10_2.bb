# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Nmap-Parser"
PV = "1.37"
PR = "22.el10_2"
PACKAGES = " \
 perl-Nmap-Parser \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Nmap-Parser-1.37-22.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c9265e87d802a21e89897c8bd1b5fe549d4ef4d1f6ef0403556472fed9023313"

URI_x86_64_v2_perl-Nmap-Parser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Nmap-Parser-1.37-22.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Nmap-Parser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Nmap-Parser}"
SRC_URI[x86_64_v2_perl-Nmap-Parser.sha256sum] = "2119266dc40bf36f20706df4276dfea75750aaa0940b90071489ae03cf019d86"

URI_aarch64_perl-Nmap-Parser = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Nmap-Parser-1.37-22.el10_2.noarch.rpm;name=aarch64_perl-Nmap-Parser;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Nmap-Parser}"
SRC_URI[aarch64_perl-Nmap-Parser.sha256sum] = "bfe155e9f1a9d0f2919c2cf663f5104b93b56f80dbea28941538a010de2a0e5d"

RDEPENDS:perl-Nmap-Parser = " \
 perl-XML-Twig \
 perl-libs \
 perl-vars \
 "
