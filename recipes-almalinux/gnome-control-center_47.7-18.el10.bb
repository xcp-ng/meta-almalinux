# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-control-center"
PV = "47.7"
PR = "18.el10"
PACKAGES = " \
 gnome-control-center \
 gnome-control-center-filesystem \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-control-center-47.7-18.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "91f9cd01feeb9d421d75d373e2fecf106a8d4cfa6fef7018d6d873a0e9e46629"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-control-center-47.7-18.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-control-center;unpack=0"
SRC_URI[x86_64_v2_gnome-control-center.sha256sum] = "08ed925374016e8218dac15a00972da4b135f404463cdebefd11bbc81c7df7be"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-control-center-filesystem-47.7-18.el10.noarch.rpm;name=x86_64_v2_gnome-control-center-filesystem;unpack=0"
SRC_URI[x86_64_v2_gnome-control-center-filesystem.sha256sum] = "8cee1a59df248ab73a6a9f3359642afcba863c2771b96562456f9bb6f35d4cfd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-control-center-47.7-18.el10.aarch64.rpm;name=aarch64_gnome-control-center;unpack=0"
SRC_URI[aarch64_gnome-control-center.sha256sum] = "a17064fc9ef53a5c30080fd63388588ddff21fabe4c78851813f55bc0a6aabfe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-control-center-filesystem-47.7-18.el10.noarch.rpm;name=aarch64_gnome-control-center-filesystem;unpack=0"
SRC_URI[aarch64_gnome-control-center-filesystem.sha256sum] = "8cee1a59df248ab73a6a9f3359642afcba863c2771b96562456f9bb6f35d4cfd"

RDEPENDS:gnome-control-center = " \
 ModemManager-glib \
 NetworkManager-libnm \
 accountsservice \
 accountsservice-libs \
 alsa-lib \
 cairo \
 colord \
 colord-gtk4 \
 colord-libs \
 cups-libs \
 cups-pk-helper \
 dbus \
 fontconfig \
 gcr-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gnome-bluetooth-libs \
 gnome-control-center-filesystem \
 gnome-desktop4 \
 gnome-online-accounts \
 gnome-settings-daemon \
 gnutls \
 graphene \
 gsettings-desktop-schemas \
 gsound \
 gtk4 \
 ibus-libs \
 iso-codes \
 json-glib \
 krb5-libs \
 libX11 \
 libXi \
 libadwaita \
 libepoxy \
 libgcc \
 libgtop2 \
 libgudev \
 libnma-gtk4 \
 libpwquality \
 libsecret \
 libsmbclient \
 libsoup3 \
 libudisks2 \
 libwacom \
 libxml2 \
 pango \
 pkgconf-pkg-config \
 polkit-libs \
 pulseaudio-libs \
 pulseaudio-libs-glib2 \
 tecla \
 upower \
 upower-libs \
 "
RDEPENDS:gnome-control-center-filesystem = " \
 "
