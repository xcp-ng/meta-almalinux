# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "R-RUnit"
PV = "0.4.33.1"
PR = "5.el10_3"
PACKAGES = " \
 R-RUnit \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/R-RUnit-0.4.33.1-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0bad835f5d5be8da1ac72bd174c0f5fca3b4747d2df5e2c953a0f37d0879a223"

URI_x86_64_v2_R-RUnit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-RUnit-0.4.33.1-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_R-RUnit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-RUnit}"
SRC_URI[x86_64_v2_R-RUnit.sha256sum] = "2d4d04b7187bbfd70c1bf27854c466741ae9a9cd60616f1fbb2b0b41fd577792"

URI_aarch64_R-RUnit = "${EPEL_MIRROR}/aarch64/Packages/r/R-RUnit-0.4.33.1-5.el10_3.noarch.rpm;name=aarch64_R-RUnit;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-RUnit}"
SRC_URI[aarch64_R-RUnit.sha256sum] = "7bcc4671438f726112f3455b2e29111110a59d65545523870ce79a5f09c4ffd6"

RDEPENDS:R-RUnit = " \
 R-core \
 "
