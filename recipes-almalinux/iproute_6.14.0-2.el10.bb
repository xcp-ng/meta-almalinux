# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iproute"
PV = "6.14.0"
PR = "2.el10"
PACKAGES = " \
 iproute \
 iproute-devel \
 iproute-tc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/iproute-6.14.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6ba688c2ee8a1c064178779b9b543b77c7501304b66f3b77b3b6c487898f3743"

URI_x86_64_v2_iproute = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iproute-6.14.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_iproute;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iproute}"
SRC_URI[x86_64_v2_iproute.sha256sum] = "287ef784cf95f7e9abb037cd4f237eb05e5d59282c23b5ab4693e38c74772763"

URI_x86_64_v2_iproute-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/iproute-devel-6.14.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_iproute-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iproute-devel}"
SRC_URI[x86_64_v2_iproute-devel.sha256sum] = "500338f1cb95e49d15f3371d2d1309639d6de927412735a55f73898aed624e2a"

URI_x86_64_v2_iproute-tc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iproute-tc-6.14.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_iproute-tc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iproute-tc}"
SRC_URI[x86_64_v2_iproute-tc.sha256sum] = "17d7109573f8dc972f3e858a3da072e79ad681ac23c0ccf91126d399554764f5"

URI_aarch64_iproute = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iproute-6.14.0-2.el10.aarch64.rpm;name=aarch64_iproute;unpack=0"
SRC_URI:append = " ${URI_aarch64_iproute}"
SRC_URI[aarch64_iproute.sha256sum] = "da577b7e3df1a38e5c624d19213cbe2d25da276feaa13993971741bc792c7805"

URI_aarch64_iproute-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/iproute-devel-6.14.0-2.el10.aarch64.rpm;name=aarch64_iproute-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_iproute-devel}"
SRC_URI[aarch64_iproute-devel.sha256sum] = "7bd8c75e48307287b84cf2be3609d6ec7e6b2f36c4c59398e16c265361cdad6b"

URI_aarch64_iproute-tc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iproute-tc-6.14.0-2.el10.aarch64.rpm;name=aarch64_iproute-tc;unpack=0"
SRC_URI:append = " ${URI_aarch64_iproute-tc}"
SRC_URI[aarch64_iproute-tc.sha256sum] = "99fbaaaaceb20c762618f6a62f33194ba60ff16e276bc125efd09ca16964c705"

RDEPENDS:iproute = " \
 bash \
 elfutils-libelf \
 glibc \
 libbpf \
 libcap \
 libmnl \
 libselinux \
 psmisc \
 "
RDEPENDS:iproute-devel = " \
 iproute \
 "
RDEPENDS:iproute-tc = " \
 elfutils-libelf \
 glibc \
 iproute \
 iptables-libs \
 libbpf \
 libcap \
 libmnl \
 "
