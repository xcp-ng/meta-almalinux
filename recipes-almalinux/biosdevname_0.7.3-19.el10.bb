# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "biosdevname"
PV = "0.7.3"
PR = "19.el10"
PACKAGES:x86_64_v2 = " \
 biosdevname \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/biosdevname-0.7.3-19.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f8aa99149f5a61681102b3ed886b92fde150f83bb65dc078bddb678331fd73d"

URI_x86_64_v2_biosdevname = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/biosdevname-0.7.3-19.el10.x86_64_v2.rpm;name=x86_64_v2_biosdevname;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_biosdevname}"
SRC_URI[x86_64_v2_biosdevname.sha256sum] = "4d2bbeae673546076b2d40a290b9a54b609bed91e6db2f096cff55ae7dd05740"

RDEPENDS:biosdevname = " \
 glibc \
 pciutils-libs \
 "
