# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-signal"
PV = "0.2.14"
PR = "1.el10_3"
PACKAGES = " \
 rust-async-signal+default-devel \
 rust-async-signal-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-async-signal-0.2.14-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7047722b47026316c44ee71c7c37f3668b2cf06cfb491b7ff8ccfaa608d26a57"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-signal+default-devel-0.2.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-signal+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-async-signal+default-devel.sha256sum] = "0e09316e90d0b8d24fc302fc1ed49ea5480b83b7e806fb37c54061deba75ec73"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-signal-devel-0.2.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-signal-devel;unpack=0"
SRC_URI[x86_64_v2_rust-async-signal-devel.sha256sum] = "9f9449f03b6f7bab8d42feb48975359fd4120cbf977dc99757ddc299a5501b59"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-async-signal+default-devel-0.2.14-1.el10_3.noarch.rpm;name=aarch64_rust-async-signal+default-devel;unpack=0"
SRC_URI[aarch64_rust-async-signal+default-devel.sha256sum] = "6ce4beb7016fba4383d0845e66ad2d7a2816d623c951e52511111c590ad7b978"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-async-signal-devel-0.2.14-1.el10_3.noarch.rpm;name=aarch64_rust-async-signal-devel;unpack=0"
SRC_URI[aarch64_rust-async-signal-devel.sha256sum] = "879ad6d0fac103a238f6ff0f180b7d5167222ee2966e760852df913445bb1ece"

RDEPENDS:rust-async-signal+default-devel = " \
 cargo \
 rust-async-signal-devel \
 "
RDEPENDS:rust-async-signal-devel = " \
 cargo \
 rust \
 rust-async-io+default-devel \
 rust-cfg-if+default-devel \
 rust-futures-core+default-devel \
 rust-futures-io+default-devel \
 rust-rustix+process-devel \
 rust-rustix+std-devel \
 rust-rustix-devel \
 rust-signal-hook-registry+default-devel \
 "
