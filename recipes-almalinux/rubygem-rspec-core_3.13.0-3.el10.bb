# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-rspec-core"
PV = "3.13.0"
PR = "3.el10"
PACKAGES = " \
 rubygem-rspec-core \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/rubygem-rspec-core-3.13.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1359967391fb2fc7d106df73d56da01d9ab0817c31553472342e190e6dbbcfed"

URI_x86_64_v2_rubygem-rspec-core = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rubygem-rspec-core-3.13.0-3.el10.noarch.rpm;name=x86_64_v2_rubygem-rspec-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rspec-core}"
SRC_URI[x86_64_v2_rubygem-rspec-core.sha256sum] = "a75c8b86fd476e648b95e5ea7f73d9993204398c806b490dd6b274c0282bbe9f"

URI_aarch64_rubygem-rspec-core = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rubygem-rspec-core-3.13.0-3.el10.noarch.rpm;name=aarch64_rubygem-rspec-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rspec-core}"
SRC_URI[aarch64_rubygem-rspec-core.sha256sum] = "a75c8b86fd476e648b95e5ea7f73d9993204398c806b490dd6b274c0282bbe9f"

RDEPENDS:rubygem-rspec-core = " \
 ruby \
 rubygem-rake \
 rubygem-rspec-support \
 rubygems \
 virtual//usr/bin/env \
 "
