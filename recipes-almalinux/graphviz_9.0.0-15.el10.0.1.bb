# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "graphviz"
PV = "9.0.0"
PR = "15.el10.0.1"
PACKAGES:x86_64_v2 = " \
 graphviz \
 graphviz-devel \
 graphviz-doc \
 graphviz-gd \
 graphviz-python3 \
 graphviz-ruby \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/graphviz-9.0.0-15.el10.0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "083b03abd5875014a27c52fde74c69c4f148319c989338f93e612a6d044684c4"

URI_x86_64_v2_graphviz = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/graphviz-9.0.0-15.el10.0.1.x86_64_v2.rpm;name=x86_64_v2_graphviz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_graphviz}"
SRC_URI[x86_64_v2_graphviz.sha256sum] = "b8b2852f04f0f862969ac435b6b24dbaa5e55f4a882a7284a4f6539896532fdf"

URI_x86_64_v2_graphviz-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/graphviz-devel-9.0.0-15.el10.0.1.x86_64_v2.rpm;name=x86_64_v2_graphviz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_graphviz-devel}"
SRC_URI[x86_64_v2_graphviz-devel.sha256sum] = "f35a0f5a66b876633850965413e433c8b232c2ff7093904ccead95e9d749eb5f"

URI_x86_64_v2_graphviz-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/graphviz-doc-9.0.0-15.el10.0.1.x86_64_v2.rpm;name=x86_64_v2_graphviz-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_graphviz-doc}"
SRC_URI[x86_64_v2_graphviz-doc.sha256sum] = "2060fbee071137243c3d3d1ce5695ce4d5bc4a8b479c8295cb06a9e327fcafee"

URI_x86_64_v2_graphviz-gd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/graphviz-gd-9.0.0-15.el10.0.1.x86_64_v2.rpm;name=x86_64_v2_graphviz-gd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_graphviz-gd}"
SRC_URI[x86_64_v2_graphviz-gd.sha256sum] = "14b089e24f2f96fd64218f783b3ce7fcff8e1c2b48e1ae06bc0eef580ec5017b"

URI_x86_64_v2_graphviz-python3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/graphviz-python3-9.0.0-15.el10.0.1.x86_64_v2.rpm;name=x86_64_v2_graphviz-python3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_graphviz-python3}"
SRC_URI[x86_64_v2_graphviz-python3.sha256sum] = "581fcb21222fb6608ce350c6ea225661911550a119925184e0989042d6f7947a"

URI_x86_64_v2_graphviz-ruby = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/graphviz-ruby-9.0.0-15.el10.0.1.x86_64_v2.rpm;name=x86_64_v2_graphviz-ruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_graphviz-ruby}"
SRC_URI[x86_64_v2_graphviz-ruby.sha256sum] = "c1815b4fcae7747409fd99d23fd26a6f3df675f28329fd792f9c1f71c50d4b3d"

RDEPENDS:graphviz = " \
 bash \
 cairo \
 expat \
 fontconfig \
 freetype \
 gd \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 harfbuzz \
 libX11 \
 libXrender \
 libgcc \
 libgs \
 librsvg2 \
 libstdc++ \
 libtool-ltdl \
 libwebp \
 pango \
 poppler-glib \
 urw-base35-fonts \
 zlib-ng-compat \
 "
RDEPENDS:graphviz-devel = " \
 graphviz \
 graphviz-gd \
 pkgconf-pkg-config \
 "
RDEPENDS:graphviz-doc = " \
 "
RDEPENDS:graphviz-gd = " \
 cairo \
 expat \
 gd \
 glib2 \
 glibc \
 graphviz \
 harfbuzz \
 libtool-ltdl \
 pango \
 zlib-ng-compat \
 "
RDEPENDS:graphviz-python3 = " \
 expat \
 glibc \
 graphviz \
 libgcc \
 libstdc++ \
 libtool-ltdl \
 python3 \
 zlib-ng-compat \
 "
RDEPENDS:graphviz-ruby = " \
 expat \
 glibc \
 graphviz \
 libgcc \
 libstdc++ \
 libtool-ltdl \
 ruby \
 ruby-libs \
 zlib-ng-compat \
 "
