# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Canary-Stability"
PV = "2013"
PR = "20.el10"
PACKAGES = " \
 perl-Canary-Stability \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Canary-Stability-2013-20.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "dfd152325503ee7e659704d46bca51c44ef4a1cf5767ac44023f971d4bae9ee4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Canary-Stability-2013-20.el10.noarch.rpm;name=x86_64_v2_perl-Canary-Stability;unpack=0"
SRC_URI[x86_64_v2_perl-Canary-Stability.sha256sum] = "194ee7035be0369d4510dc47e280a861de037cbb89992dc8d76b0acfbb2b00e6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Canary-Stability-2013-20.el10.noarch.rpm;name=aarch64_perl-Canary-Stability;unpack=0"
SRC_URI[aarch64_perl-Canary-Stability.sha256sum] = "194ee7035be0369d4510dc47e280a861de037cbb89992dc8d76b0acfbb2b00e6"

RDEPENDS:perl-Canary-Stability = " \
 perl-ExtUtils-MakeMaker \
 perl-libs \
 "
