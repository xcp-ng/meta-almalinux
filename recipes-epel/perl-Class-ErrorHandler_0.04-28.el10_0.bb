# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Class-ErrorHandler"
PV = "0.04"
PR = "28.el10_0"
PACKAGES = " \
 perl-Class-ErrorHandler \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Class-ErrorHandler-0.04-28.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f9b2579e97db8e99f953a3f4f22a78e0c0ae8218a036f043c377c5c2162e3c9"

URI_x86_64_v2_perl-Class-ErrorHandler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Class-ErrorHandler-0.04-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Class-ErrorHandler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Class-ErrorHandler}"
SRC_URI[x86_64_v2_perl-Class-ErrorHandler.sha256sum] = "53bc7725d0a991ed7517bee22a5b4c39d6fed61e3f0c360418a3432d20cc678f"

URI_aarch64_perl-Class-ErrorHandler = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Class-ErrorHandler-0.04-28.el10_0.noarch.rpm;name=aarch64_perl-Class-ErrorHandler;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Class-ErrorHandler}"
SRC_URI[aarch64_perl-Class-ErrorHandler.sha256sum] = "4ce09aa21bf8e223fbb7ed697e46e631cd6ec35a8f8c4038c5c101b86cecce0f"

RDEPENDS:perl-Class-ErrorHandler = " \
 perl-libs \
 perl-vars \
 "
