# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pysnmp"
PV = "7.1.21"
PR = "4.el10_1"
PACKAGES = " \
 python3-pysnmp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pysnmp-7.1.21-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ed8d465f0222e9490d81be74276c3469be6eda000919980cf0e42174c2a0bea"

URI_x86_64_v2_python3-pysnmp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pysnmp-7.1.21-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pysnmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pysnmp}"
SRC_URI[x86_64_v2_python3-pysnmp.sha256sum] = "f18604ed1883d69aebedaef7f526ffa709556381d9a238ce08987c49ecfacfc7"

URI_aarch64_python3-pysnmp = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pysnmp-7.1.21-4.el10_1.noarch.rpm;name=aarch64_python3-pysnmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pysnmp}"
SRC_URI[aarch64_python3-pysnmp.sha256sum] = "0c3a9a4ef66e5cceb9e62b16671d8de43f809831dc46d47c88cc1f3c502a04ca"

RDEPENDS:python3-pysnmp = " \
 python3 \
 python3-pyasn1 \
 "
