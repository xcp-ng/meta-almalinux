# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-yesod-persistent"
PV = "1.6.0.8"
PR = "7.el10_0"
PACKAGES = " \
 ghc-yesod-persistent \
 ghc-yesod-persistent-devel \
 ghc-yesod-persistent-doc \
 ghc-yesod-persistent-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-yesod-persistent-1.6.0.8-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df89ce2115f3f812c9569f91d26543e76487ee8cf464f99e6ca9b394826c842c"

URI_x86_64_v2_ghc-yesod-persistent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-yesod-persistent-1.6.0.8-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-yesod-persistent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-yesod-persistent}"
SRC_URI[x86_64_v2_ghc-yesod-persistent.sha256sum] = "f0ec28dc312b80e62d000b7326e10a3c6e21625b6963d63774cbdf2ce43c42d1"

URI_x86_64_v2_ghc-yesod-persistent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-yesod-persistent-devel-1.6.0.8-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-yesod-persistent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-yesod-persistent-devel}"
SRC_URI[x86_64_v2_ghc-yesod-persistent-devel.sha256sum] = "b9f45e3a86784c0f48d48280a2567a645f31e23dba6f1bbec23bad192f79ad82"

URI_x86_64_v2_ghc-yesod-persistent-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-yesod-persistent-doc-1.6.0.8-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-yesod-persistent-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-yesod-persistent-doc}"
SRC_URI[x86_64_v2_ghc-yesod-persistent-doc.sha256sum] = "be86214cd312959d8aa57eeca1df2dbdd512e76011b5241a03f9cba2c152eefc"

URI_x86_64_v2_ghc-yesod-persistent-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-yesod-persistent-prof-1.6.0.8-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-yesod-persistent-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-yesod-persistent-prof}"
SRC_URI[x86_64_v2_ghc-yesod-persistent-prof.sha256sum] = "0ec84fed1e265fab8eee5b8cc7893afaca12600c6f81a4affa94d84c6597c032"

URI_aarch64_ghc-yesod-persistent = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-yesod-persistent-1.6.0.8-7.el10_0.aarch64.rpm;name=aarch64_ghc-yesod-persistent;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-yesod-persistent}"
SRC_URI[aarch64_ghc-yesod-persistent.sha256sum] = "9968941a3cfede8ac90dccce27d0e5352b6b872503004a527622eb4aca6d1e37"

URI_aarch64_ghc-yesod-persistent-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-yesod-persistent-devel-1.6.0.8-7.el10_0.aarch64.rpm;name=aarch64_ghc-yesod-persistent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-yesod-persistent-devel}"
SRC_URI[aarch64_ghc-yesod-persistent-devel.sha256sum] = "daa1b7fbd0389e7087d288b23ac0df103fc57212d6a01792b3111b8b79cd295a"

URI_aarch64_ghc-yesod-persistent-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-yesod-persistent-doc-1.6.0.8-7.el10_0.noarch.rpm;name=aarch64_ghc-yesod-persistent-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-yesod-persistent-doc}"
SRC_URI[aarch64_ghc-yesod-persistent-doc.sha256sum] = "f606b6bbe0d6bed99a1a4016933e443d70308320a74b2b8adeeec6f6e35f1a36"

URI_aarch64_ghc-yesod-persistent-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-yesod-persistent-prof-1.6.0.8-7.el10_0.aarch64.rpm;name=aarch64_ghc-yesod-persistent-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-yesod-persistent-prof}"
SRC_URI[aarch64_ghc-yesod-persistent-prof.sha256sum] = "fff49a6900a975dfa02c839d11c9fd5ad65ed31f8effe99e40d5e7c665ab98f1"

RDEPENDS:ghc-yesod-persistent = " \
 ghc-HUnit \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-appar \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-attoparsec-iso8601 \
 ghc-auto-update \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-basement \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-bsb-http-chunked \
 ghc-byteorder \
 ghc-bytestring \
 ghc-call-stack \
 ghc-case-insensitive \
 ghc-cereal \
 ghc-clientsession \
 ghc-colour \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-crypto-api \
 ghc-crypton \
 ghc-crypton-x509 \
 ghc-cryptonite \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-easy-file \
 ghc-entropy \
 ghc-exceptions \
 ghc-fast-logger \
 ghc-file-embed \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hourglass \
 ghc-http-api-data \
 ghc-http-date \
 ghc-http-types \
 ghc-http2 \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-conversion \
 ghc-integer-logarithms \
 ghc-iproute \
 ghc-lift-type \
 ghc-lifted-base \
 ghc-memory \
 ghc-monad-control \
 ghc-monad-logger \
 ghc-monad-loops \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-network-byte-order \
 ghc-network-control \
 ghc-old-locale \
 ghc-old-time \
 ghc-os-string \
 ghc-parsec \
 ghc-path-pieces \
 ghc-pem \
 ghc-persistent \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-psqueues \
 ghc-random \
 ghc-recv \
 ghc-resource-pool \
 ghc-resourcet \
 ghc-safe-exceptions \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-setenv \
 ghc-shakespeare \
 ghc-silently \
 ghc-simple-sendfile \
 ghc-skein \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-stm-chans \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-lift \
 ghc-th-lift-instances \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-time-manager \
 ghc-transformers \
 ghc-transformers-base \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-unix \
 ghc-unix-compat \
 ghc-unix-time \
 ghc-unliftio \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vault \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-wai \
 ghc-wai-extra \
 ghc-wai-logger \
 ghc-warp \
 ghc-witherable \
 ghc-word8 \
 ghc-yesod-core \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-yesod-persistent-devel = " \
 ghc-base-devel \
 ghc-blaze-builder-devel \
 ghc-compiler \
 ghc-conduit-devel \
 ghc-persistent-devel \
 ghc-resource-pool-devel \
 ghc-resourcet-devel \
 ghc-transformers-devel \
 ghc-yesod-core-devel \
 ghc-yesod-persistent \
 "
RDEPENDS:ghc-yesod-persistent-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-yesod-persistent-prof = " \
 ghc-base-prof \
 ghc-blaze-builder-prof \
 ghc-conduit-prof \
 ghc-persistent-prof \
 ghc-resource-pool-prof \
 ghc-resourcet-prof \
 ghc-transformers-prof \
 ghc-yesod-core-prof \
 ghc-yesod-persistent-devel \
 "
