# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-DBIx-Connector"
PV = "0.60"
PR = "1.el10_0"
PACKAGES = " \
 perl-DBIx-Connector \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-DBIx-Connector-0.60-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c33e18d0c392cfc40e6bb6a4f77ed03b1bad20a61300e899a232824f5b1239c"

URI_x86_64_v2_perl-DBIx-Connector = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DBIx-Connector-0.60-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-DBIx-Connector;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-DBIx-Connector}"
SRC_URI[x86_64_v2_perl-DBIx-Connector.sha256sum] = "1636f71e04245765614ae380e650952e695fd32de6303be7ebb41fcb8d14e5d8"

URI_aarch64_perl-DBIx-Connector = "${EPEL_MIRROR}/aarch64/Packages/p/perl-DBIx-Connector-0.60-1.el10_0.noarch.rpm;name=aarch64_perl-DBIx-Connector;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-DBIx-Connector}"
SRC_URI[aarch64_perl-DBIx-Connector.sha256sum] = "42a124e3f72ff43e8c2fd21a54398b3ec91f25625b1f4f1688837ae5e7630834"

RDEPENDS:perl-DBIx-Connector = " \
 perl-Carp \
 perl-DBI \
 perl-DBIx-Connector \
 perl-libs \
 perl-overload \
 "
