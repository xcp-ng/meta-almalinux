# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksshaskpass"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 ksshaskpass \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/ksshaskpass-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7accc5e7de1402a2d6b562f684c2fc0358cce8323e1330f6f93e102ddd1a048e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksshaskpass-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksshaskpass;unpack=0"
SRC_URI[x86_64_v2_ksshaskpass.sha256sum] = "64045eecaaf47f005266f846395adb071c4789453c0eadf445fd7d6cb7d4a965"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/ksshaskpass-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_ksshaskpass;unpack=0"
SRC_URI[aarch64_ksshaskpass.sha256sum] = "801b8eb24d0899987a77d016a2f9da55f524f57c4d3ed952ffc30b3629d43810"

RDEPENDS:ksshaskpass = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
