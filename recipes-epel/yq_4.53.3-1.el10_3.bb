# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yq"
PV = "4.53.3"
PR = "1.el10_3"
PACKAGES = " \
 yq \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/y/yq-4.53.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "82ba9b10e74737ac2e59b0f842eb96354db63effd2b37dfca91ac2fad79e33ff"

URI_x86_64_v2_yq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yq-4.53.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yq}"
SRC_URI[x86_64_v2_yq.sha256sum] = "66e6a96631c149c65bc9c90fa294015dc16201a508011ab4f190cc6c9207d331"

URI_aarch64_yq = "${EPEL_MIRROR}/aarch64/Packages/y/yq-4.53.3-1.el10_3.aarch64.rpm;name=aarch64_yq;unpack=0"
SRC_URI:append = " ${URI_aarch64_yq}"
SRC_URI[aarch64_yq.sha256sum] = "2b506baef05f420ad629cd7c059c3bd61e99e789d8a48a277f6de74d70a9931e"

RDEPENDS:yq = " \
 glibc \
 "
