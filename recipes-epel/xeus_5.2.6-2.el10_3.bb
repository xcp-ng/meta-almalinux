# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xeus"
PV = "5.2.6"
PR = "2.el10_3"
PACKAGES = " \
 xeus \
 xeus-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xeus-5.2.6-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1db250f8eb52a1a189642557125cafca0f123fc512890b31693bb8cdf6b0ae90"

URI_x86_64_v2_xeus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xeus-5.2.6-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xeus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xeus}"
SRC_URI[x86_64_v2_xeus.sha256sum] = "06d2a091c1964bbae324c56512449e8a8af826d816f694e36aa2edbdfac1e946"

URI_x86_64_v2_xeus-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xeus-devel-5.2.6-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xeus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xeus-devel}"
SRC_URI[x86_64_v2_xeus-devel.sha256sum] = "b494ffd22382c49c69d1388add11f17036f714be06c0827b927e0e93552da83a"

URI_aarch64_xeus = "${EPEL_MIRROR}/aarch64/Packages/x/xeus-5.2.6-2.el10_3.aarch64.rpm;name=aarch64_xeus;unpack=0"
SRC_URI:append = " ${URI_aarch64_xeus}"
SRC_URI[aarch64_xeus.sha256sum] = "7ce748b6d23a2b907d891b93886fb05adc13b84c7215bcbc394ce459fb9ccfe1"

URI_aarch64_xeus-devel = "${EPEL_MIRROR}/aarch64/Packages/x/xeus-devel-5.2.6-2.el10_3.aarch64.rpm;name=aarch64_xeus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xeus-devel}"
SRC_URI[aarch64_xeus-devel.sha256sum] = "2e227abf3b4bfeb7075ea8e5b878aac977d2e5975f675f944119324b7bbfeb13"

RDEPENDS:xeus = " \
 glibc \
 libgcc \
 libstdc++ \
 libuuid \
 "
RDEPENDS:xeus-devel = " \
 cmake-filesystem \
 xeus \
 "
