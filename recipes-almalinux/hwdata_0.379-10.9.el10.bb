# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hwdata"
PV = "0.379"
PR = "10.9.el10"
PACKAGES = " \
 hwdata \
 hwdata-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/hwdata-0.379-10.9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8b74c5116f458350294882f8ff2f1fdf05df14798511504a3948ed409e41ad5"

URI_x86_64_v2_hwdata = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/hwdata-0.379-10.9.el10.noarch.rpm;name=x86_64_v2_hwdata;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hwdata}"
SRC_URI[x86_64_v2_hwdata.sha256sum] = "6ad86d0596edd626ba5705c040e3bda0e23c707110d8acda2d3f6a97dfa9ae71"

URI_x86_64_v2_hwdata-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/hwdata-devel-0.379-10.9.el10.noarch.rpm;name=x86_64_v2_hwdata-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hwdata-devel}"
SRC_URI[x86_64_v2_hwdata-devel.sha256sum] = "e7a696cbe56b8272019cc030946c8693d5ea219fb1be6dfd0d7e7abe4d4157d6"

URI_aarch64_hwdata = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/hwdata-0.379-10.9.el10.noarch.rpm;name=aarch64_hwdata;unpack=0"
SRC_URI:append = " ${URI_aarch64_hwdata}"
SRC_URI[aarch64_hwdata.sha256sum] = "6ad86d0596edd626ba5705c040e3bda0e23c707110d8acda2d3f6a97dfa9ae71"

URI_aarch64_hwdata-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/hwdata-devel-0.379-10.9.el10.noarch.rpm;name=aarch64_hwdata-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_hwdata-devel}"
SRC_URI[aarch64_hwdata-devel.sha256sum] = "e7a696cbe56b8272019cc030946c8693d5ea219fb1be6dfd0d7e7abe4d4157d6"

RDEPENDS:hwdata = " \
 "
RDEPENDS:hwdata-devel = " \
 hwdata \
 pkgconf-pkg-config \
 "
