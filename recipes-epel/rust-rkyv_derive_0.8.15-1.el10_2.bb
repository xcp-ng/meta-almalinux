# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rkyv_derive"
PV = "0.8.15"
PR = "1.el10_2"
PACKAGES = " \
 rust-rkyv_derive+bytecheck-devel \
 rust-rkyv_derive+default-devel \
 rust-rkyv_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rkyv_derive-0.8.15-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb7258185f02ab55dc12dd901b71aac016ede352fd339aa61953a227c5a60230"

URI_x86_64_v2_rust-rkyv_derive+bytecheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv_derive+bytecheck-devel-0.8.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv_derive+bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv_derive+bytecheck-devel}"
SRC_URI[x86_64_v2_rust-rkyv_derive+bytecheck-devel.sha256sum] = "9eb815bb384353125f1c210a094d4ab24effd8c15fca189d5ec03a490cf508b5"

URI_x86_64_v2_rust-rkyv_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv_derive+default-devel-0.8.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv_derive+default-devel}"
SRC_URI[x86_64_v2_rust-rkyv_derive+default-devel.sha256sum] = "6680868a07a610f5c1f51fc1e244100b98f65908b5fd059f41b6db4376dacd27"

URI_x86_64_v2_rust-rkyv_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv_derive-devel-0.8.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv_derive-devel}"
SRC_URI[x86_64_v2_rust-rkyv_derive-devel.sha256sum] = "e9a2c480f78bccbe874cee2431e3d62a45da12451dcde2931969d778d0171e79"

URI_aarch64_rust-rkyv_derive+bytecheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv_derive+bytecheck-devel-0.8.15-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv_derive+bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv_derive+bytecheck-devel}"
SRC_URI[aarch64_rust-rkyv_derive+bytecheck-devel.sha256sum] = "e9a179e6ae4d11056b72c78d28d5b8f25669a8881bcfc521d18ede56f08916db"

URI_aarch64_rust-rkyv_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv_derive+default-devel-0.8.15-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv_derive+default-devel}"
SRC_URI[aarch64_rust-rkyv_derive+default-devel.sha256sum] = "564f13b83d4bc8f26ab6212166862f4432fa0e192c143aec3347a68cba22b3df"

URI_aarch64_rust-rkyv_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv_derive-devel-0.8.15-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv_derive-devel}"
SRC_URI[aarch64_rust-rkyv_derive-devel.sha256sum] = "7ef24aad1aba9e52d845a3d2a0fb6e76d140d0e5257460ac32f8750a8ae740a6"

RDEPENDS:rust-rkyv_derive+bytecheck-devel = " \
 cargo \
 rust-rkyv_derive-devel \
 "
RDEPENDS:rust-rkyv_derive+default-devel = " \
 cargo \
 rust-rkyv_derive-devel \
 "
RDEPENDS:rust-rkyv_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+proc-macro-devel \
 rust-proc-macro2-devel \
 rust-quote+proc-macro-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
