# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "librist"
PV = "0.2.7"
PR = "6.el10_0"
PACKAGES = " \
 librist \
 librist-devel \
 librist-doc \
 rist-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/librist-0.2.7-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e2ce64739658e5d2bf2127c49c07e2917e7d6f71f6ba688a1c704d532e0c351"

URI_x86_64_v2_librist = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librist-0.2.7-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librist}"
SRC_URI[x86_64_v2_librist.sha256sum] = "8f073b6a9b0f8ab342eb9974e7392f6791c523fee14609a876777820585deea9"

URI_x86_64_v2_librist-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librist-devel-0.2.7-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librist-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librist-devel}"
SRC_URI[x86_64_v2_librist-devel.sha256sum] = "53022156ae7446e923a79c88e29594912ab2e9b8289aa4338f4e1dbe5cbbd605"

URI_x86_64_v2_librist-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librist-doc-0.2.7-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_librist-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librist-doc}"
SRC_URI[x86_64_v2_librist-doc.sha256sum] = "7e363c5fb70831e6e816d621f85c026f7a6a6b01d7cce01e23828d0170af18e1"

URI_x86_64_v2_rist-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rist-tools-0.2.7-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rist-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rist-tools}"
SRC_URI[x86_64_v2_rist-tools.sha256sum] = "8dbb82e476ee08762fc9abc291bcd58f200a3764e92797c91d1dc8ddee8ad4b5"

URI_aarch64_librist = "${EPEL_MIRROR}/aarch64/Packages/l/librist-0.2.7-6.el10_0.aarch64.rpm;name=aarch64_librist;unpack=0"
SRC_URI:append = " ${URI_aarch64_librist}"
SRC_URI[aarch64_librist.sha256sum] = "a7b058ef598fcd5a14e9994fdb59cde26d331776e66017667a69a04765011c28"

URI_aarch64_librist-devel = "${EPEL_MIRROR}/aarch64/Packages/l/librist-devel-0.2.7-6.el10_0.aarch64.rpm;name=aarch64_librist-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_librist-devel}"
SRC_URI[aarch64_librist-devel.sha256sum] = "356af5594fa2d4f38afff96f76aea079585928afe3eba3c35cf00caebcdc8796"

URI_aarch64_librist-doc = "${EPEL_MIRROR}/aarch64/Packages/l/librist-doc-0.2.7-6.el10_0.noarch.rpm;name=aarch64_librist-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_librist-doc}"
SRC_URI[aarch64_librist-doc.sha256sum] = "55f164d1866944067991454d88447f656a5485c37f23a554256ec841c8e61238"

URI_aarch64_rist-tools = "${EPEL_MIRROR}/aarch64/Packages/r/rist-tools-0.2.7-6.el10_0.aarch64.rpm;name=aarch64_rist-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_rist-tools}"
SRC_URI[aarch64_rist-tools.sha256sum] = "52ca96de05d981024bdb389867af7cebd89100bd95f0c4d0463ab9c0dcab4f9f"

RDEPENDS:librist = " \
 cjson \
 glibc \
 mbedtls \
 "
RDEPENDS:librist-devel = " \
 cjson-devel \
 librist \
 mbedtls-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:librist-doc = " \
 "
RDEPENDS:rist-tools = " \
 glibc \
 librist \
 mbedtls \
 "
