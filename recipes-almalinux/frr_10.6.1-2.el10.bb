# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "frr"
PV = "10.6.1"
PR = "2.el10"
PACKAGES = " \
 frr \
 frr-selinux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/frr-10.6.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2330c52b9def0af6da348354842fe1357ce6ae5caafa7b4c01b92937f2d96675"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - frr: libcap.so.2()(64bit)

URI_x86_64_v2_frr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/frr-10.6.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_frr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_frr}"
SRC_URI[x86_64_v2_frr.sha256sum] = "0b268ca3be0e0b2b89f7ca3106cc48cd56fea787b9ec51baf3f1d3dda952d1ce"

URI_x86_64_v2_frr-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/frr-selinux-10.6.1-2.el10.noarch.rpm;name=x86_64_v2_frr-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_frr-selinux}"
SRC_URI[x86_64_v2_frr-selinux.sha256sum] = "b84ade7bb6d648018abec98a206a35f05f4d70d50ac7690b0355249fd9d44d94"

URI_aarch64_frr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/frr-10.6.1-2.el10.aarch64.rpm;name=aarch64_frr;unpack=0"
SRC_URI:append = " ${URI_aarch64_frr}"
SRC_URI[aarch64_frr.sha256sum] = "d5434ac2f7e6cb17bd7fa8df87638a8e4b1e898d927b7a28353f65343e6c3929"

URI_aarch64_frr-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/frr-selinux-10.6.1-2.el10.noarch.rpm;name=aarch64_frr-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_frr-selinux}"
SRC_URI[aarch64_frr-selinux.sha256sum] = "b84ade7bb6d648018abec98a206a35f05f4d70d50ac7690b0355249fd9d44d94"

RDEPENDS:frr:x86_64_v2 = " \
 bash \
 c-ares \
 frr-selinux \
 glibc \
 hostname \
 json-c \
 libcap \
 libgcc \
 libxcrypt \
 libyang \
 ncurses \
 net-snmp \
 net-snmp-agent-libs \
 net-snmp-libs \
 openssl-libs \
 protobuf-c \
 python3 \
 readline \
 shadow-utils \
 systemd \
"
RDEPENDS:frr:aarch64 = " \
 bash \
 c-ares \
 frr-selinux \
 glibc \
 hostname \
 json-c \
 libatomic \
 libgcc \
 libxcrypt \
 libyang \
 ncurses \
 net-snmp \
 net-snmp-agent-libs \
 net-snmp-libs \
 openssl-libs \
 protobuf-c \
 python3 \
 readline \
 shadow-utils \
 systemd \
"
RDEPENDS:frr-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
