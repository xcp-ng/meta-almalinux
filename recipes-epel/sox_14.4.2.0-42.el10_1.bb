# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sox"
PV = "14.4.2.0"
PR = "42.el10_1"
PACKAGES = " \
 sox \
 sox-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sox-14.4.2.0-42.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "83d0fffcb05d5af55d7ea55e46df44b4ca62bcc187ed572647a454c6455e6ce9"

URI_x86_64_v2_sox = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sox-14.4.2.0-42.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sox}"
SRC_URI[x86_64_v2_sox.sha256sum] = "00c55f56a5ede6c16d54c86a415017a29fa7bb45ae7e33258c49e9348b2a6822"

URI_x86_64_v2_sox-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sox-devel-14.4.2.0-42.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sox-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sox-devel}"
SRC_URI[x86_64_v2_sox-devel.sha256sum] = "045ff308a847233d7e5fec30486e4dacab3352db6dc8c56b64c35c9e0e4efda5"

URI_aarch64_sox = "${EPEL_MIRROR}/aarch64/Packages/s/sox-14.4.2.0-42.el10_1.aarch64.rpm;name=aarch64_sox;unpack=0"
SRC_URI:append = " ${URI_aarch64_sox}"
SRC_URI[aarch64_sox.sha256sum] = "f9175dd12b1b25352d48937b1012b393e154ef527637d1ff1b8ebc6c258e5213"

URI_aarch64_sox-devel = "${EPEL_MIRROR}/aarch64/Packages/s/sox-devel-14.4.2.0-42.el10_1.aarch64.rpm;name=aarch64_sox-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sox-devel}"
SRC_URI[aarch64_sox-devel.sha256sum] = "f0f39ca2e882b1abd9ee6e1bcb367653f6feeeb9ee9bc32b59119b92afe152a3"

RDEPENDS:sox = " \
 alsa-lib \
 flac-libs \
 glibc \
 gsm \
 lame-libs \
 libao \
 libgcc \
 libgomp \
 libid3tag \
 libmad \
 libogg \
 libpng \
 libsndfile \
 libtool-ltdl \
 libvorbis \
 opusfile \
 pulseaudio-libs \
 twolame-libs \
 wavpack \
 zlib-ng-compat \
 "
RDEPENDS:sox-devel = " \
 pkgconf-pkg-config \
 sox \
 "
