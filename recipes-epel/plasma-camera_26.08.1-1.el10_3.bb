# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-camera"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 plasma-camera \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma-camera-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5c6c25067e55e420ebcff6993cd6294a4823120fde9206096003d2d053438581"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-camera-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-camera;unpack=0"
SRC_URI[x86_64_v2_plasma-camera.sha256sum] = "5be530a9ba66f469ced8786f6f45bf126034f1628aa77445045be1ff565d3c50"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-camera-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_plasma-camera;unpack=0"
SRC_URI[aarch64_plasma-camera.sha256sum] = "72538c971be61ab7bafe871931bc1ae2c2be145a87cd01aec54f3335b2c73992"

RDEPENDS:plasma-camera = " \
 exiv2-libs \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 libcamera \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 qt6-qtsensors \
 "
