# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clamav"
PV = "1.4.6"
PR = "2.el10_2"
PACKAGES = " \
 clamav \
 clamav-data \
 clamav-devel \
 clamav-doc \
 clamav-filesystem \
 clamav-freshclam \
 clamav-lib \
 clamav-milter \
 clamd \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/clamav-1.4.6-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "dd5b009893b2b3837d1b4a969b8daf93c30354ffcb217d298e059ef6e2180048"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-1.4.6-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamav;unpack=0"
SRC_URI[x86_64_v2_clamav.sha256sum] = "1d348b71196a75efaf6daa6031fc56abcd531595982d8871b4ea4467250ed9d8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-data-1.4.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_clamav-data;unpack=0"
SRC_URI[x86_64_v2_clamav-data.sha256sum] = "d6975e7c19a9ed48107b36e5b51dc53e0f70b649b2d6ec08fbea2d6ee435b583"
RPROVIDES:clamav-data:append:x86_64_v2 = " virtual/data_clamav_"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-devel-1.4.6-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamav-devel;unpack=0"
SRC_URI[x86_64_v2_clamav-devel.sha256sum] = "73eb4bd8b4d12ab8f189eaedaf5d200a4ce0929faee608b25cf084387f6d443a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-doc-1.4.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_clamav-doc;unpack=0"
SRC_URI[x86_64_v2_clamav-doc.sha256sum] = "05a60d8741b1463280a8987e396e2631a25959c0b72739e4e4cd478bfdf15bf6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-filesystem-1.4.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_clamav-filesystem;unpack=0"
SRC_URI[x86_64_v2_clamav-filesystem.sha256sum] = "56ad1e00e3390489cf78d16bc7f4bc3ff30e817e062bd4397c284b242499f49e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-freshclam-1.4.6-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamav-freshclam;unpack=0"
SRC_URI[x86_64_v2_clamav-freshclam.sha256sum] = "6a5d6729f8e7020e7931e210d193d5792811b0808c93484bddefeccea872fb94"
RPROVIDES:clamav-freshclam:append:x86_64_v2 = " virtual/data_clamav_"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-lib-1.4.6-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamav-lib;unpack=0"
SRC_URI[x86_64_v2_clamav-lib.sha256sum] = "729e453ba55a4e7c91522c37a1a9454fb6e522ac7ecf87f5ff02b97563fae643"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-milter-1.4.6-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamav-milter;unpack=0"
SRC_URI[x86_64_v2_clamav-milter.sha256sum] = "37bf61676dd1abe5a3746ef04a013a054ca08f8ceed30ef0d9a6ff67c90be34e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamd-1.4.6-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamd;unpack=0"
SRC_URI[x86_64_v2_clamd.sha256sum] = "6d75609a93438e63e0234ee4acadb69f7b1952cd0988d54467447790488309a3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/clamav-1.4.6-2.el10_2.aarch64.rpm;name=aarch64_clamav;unpack=0"
SRC_URI[aarch64_clamav.sha256sum] = "3964bb8a3ae463421c5c32f3b3d1e18e225f0b6b85e1d26ee02099fdaf681ce5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/clamav-data-1.4.6-2.el10_2.noarch.rpm;name=aarch64_clamav-data;unpack=0"
SRC_URI[aarch64_clamav-data.sha256sum] = "3aac1e89b9ea0e6759f45c8091fad340a77f65a0fd56d35ee870e65da0ff48f3"
RPROVIDES:clamav-data:append:aarch64 = " virtual/data_clamav_"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/clamav-devel-1.4.6-2.el10_2.aarch64.rpm;name=aarch64_clamav-devel;unpack=0"
SRC_URI[aarch64_clamav-devel.sha256sum] = "8ace0ac9741c2cd7051da2ad40f3a76a6007541c2a1b40e18f03e585eb1b7735"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/clamav-doc-1.4.6-2.el10_2.noarch.rpm;name=aarch64_clamav-doc;unpack=0"
SRC_URI[aarch64_clamav-doc.sha256sum] = "f4838e96331cd86c9023500731c489ccec185280ad7b4739bd33638b9e279dc0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/clamav-filesystem-1.4.6-2.el10_2.noarch.rpm;name=aarch64_clamav-filesystem;unpack=0"
SRC_URI[aarch64_clamav-filesystem.sha256sum] = "cb151b59a33eab8eddcc962cfab7ad592dde9103482ec180f903094c2e81c532"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/clamav-freshclam-1.4.6-2.el10_2.aarch64.rpm;name=aarch64_clamav-freshclam;unpack=0"
SRC_URI[aarch64_clamav-freshclam.sha256sum] = "dfb65603543a405152fe7f33f7949ea67f0696f6707797a11bfabd28b95dacd8"
RPROVIDES:clamav-freshclam:append:aarch64 = " virtual/data_clamav_"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/clamav-lib-1.4.6-2.el10_2.aarch64.rpm;name=aarch64_clamav-lib;unpack=0"
SRC_URI[aarch64_clamav-lib.sha256sum] = "71de15f0c24ae2482f751466bac2c047782a599df909d471dcc976b1d943ef32"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/clamav-milter-1.4.6-2.el10_2.aarch64.rpm;name=aarch64_clamav-milter;unpack=0"
SRC_URI[aarch64_clamav-milter.sha256sum] = "128b826adaecad2f9a8f5f6e2a532cb6104cead120013b036ff0f658c2aafd3d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/clamd-1.4.6-2.el10_2.aarch64.rpm;name=aarch64_clamd;unpack=0"
SRC_URI[aarch64_clamd.sha256sum] = "ba0dc5e1a047e9129025532e003ce1318679e33efd1240d943702236577c88e2"

RDEPENDS:clamav = " \
 bash \
 clamav-filesystem \
 clamav-lib \
 glibc \
 json-c \
 libgcc \
 ncurses-libs \
 shadow-utils \
 systemd \
 virtual/data_clamav_ \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:clamav-data = " \
 bash \
 clamav-filesystem \
 "
RDEPENDS:clamav-devel = " \
 bash \
 clamav-filesystem \
 clamav-freshclam \
 clamav-lib \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:clamav-doc = " \
 clamav-filesystem \
 "
RDEPENDS:clamav-filesystem = " \
 bash \
 "
RDEPENDS:clamav-freshclam = " \
 bash \
 clamav-filesystem \
 clamav-lib \
 glibc \
 libgcc \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:clamav-lib = " \
 bzip2-libs \
 glibc \
 json-c \
 libgcc \
 libxml2 \
 openssl-libs \
 pcre2 \
 zlib-ng-compat \
 "
RDEPENDS:clamav-milter = " \
 bash \
 clamav-filesystem \
 clamav-lib \
 clamd \
 glibc \
 sendmail-milter \
 "
RDEPENDS:clamd = " \
 bash \
 clamav-filesystem \
 clamav-lib \
 glibc \
 systemd-libs \
 virtual/coreutils \
 virtual/data_clamav_ \
 "
