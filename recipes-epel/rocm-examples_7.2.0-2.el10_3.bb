# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocm-examples"
PV = "7.2.0"
PR = "2.el10_3"
PACKAGES:x86_64_v2 = " \
 rocm-examples \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocm-examples-7.2.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e098b6fa5433fef2ec3f4cea739c5fb54b30b0b34aa5db6a17228137248e9c1"

URI_x86_64_v2_rocm-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-examples-7.2.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-examples}"
SRC_URI[x86_64_v2_rocm-examples.sha256sum] = "e1da67278bf70195a1a6e22a6f5cca10c9338abf512d35e32bc04fe40a0ea669"

RDEPENDS:rocm-examples = " \
 glibc \
 hipblas \
 hipblaslt \
 hipfft \
 hiprand \
 hipsolver \
 hipsparse \
 libgcc \
 libstdc++ \
 libtiff \
 rocblas \
 rocfft \
 rocm-hip \
 rocrand \
 rocsolver \
 rocsparse \
 "
