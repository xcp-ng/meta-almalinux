# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tiny-keccak"
PV = "2.0.2"
PR = "11.el10_0"
PACKAGES = " \
 rust-tiny-keccak+cshake-devel \
 rust-tiny-keccak+default-devel \
 rust-tiny-keccak+fips202-devel \
 rust-tiny-keccak+k12-devel \
 rust-tiny-keccak+keccak-devel \
 rust-tiny-keccak+kmac-devel \
 rust-tiny-keccak+parallel_hash-devel \
 rust-tiny-keccak+sha3-devel \
 rust-tiny-keccak+shake-devel \
 rust-tiny-keccak+sp800-devel \
 rust-tiny-keccak+tuple_hash-devel \
 rust-tiny-keccak-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tiny-keccak-2.0.2-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a46a38335507e90a66774be795e3a08395bff8b059fc8e82b1c7c97ec1f9ee8"

URI_x86_64_v2_rust-tiny-keccak+cshake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiny-keccak+cshake-devel-2.0.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiny-keccak+cshake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiny-keccak+cshake-devel}"
SRC_URI[x86_64_v2_rust-tiny-keccak+cshake-devel.sha256sum] = "f0e54e8065069ffdd1c3c14fe5ecb35c10d7739e60b7f7e8d09eb66bc9afb7e9"

URI_x86_64_v2_rust-tiny-keccak+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiny-keccak+default-devel-2.0.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiny-keccak+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiny-keccak+default-devel}"
SRC_URI[x86_64_v2_rust-tiny-keccak+default-devel.sha256sum] = "249466bcdac6a40d126f97342fa226fede58ad7d40b946e6053cea78bbaf26dd"

URI_x86_64_v2_rust-tiny-keccak+fips202-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiny-keccak+fips202-devel-2.0.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiny-keccak+fips202-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiny-keccak+fips202-devel}"
SRC_URI[x86_64_v2_rust-tiny-keccak+fips202-devel.sha256sum] = "f6f09952c342b255ab75b86bdae472ed93a035708fce192cdea3b21eb74a9205"

URI_x86_64_v2_rust-tiny-keccak+k12-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiny-keccak+k12-devel-2.0.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiny-keccak+k12-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiny-keccak+k12-devel}"
SRC_URI[x86_64_v2_rust-tiny-keccak+k12-devel.sha256sum] = "2637fe5668b3d3b3b8153e58d6f9323ade21c85105c32afab6c5244703b920ad"

URI_x86_64_v2_rust-tiny-keccak+keccak-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiny-keccak+keccak-devel-2.0.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiny-keccak+keccak-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiny-keccak+keccak-devel}"
SRC_URI[x86_64_v2_rust-tiny-keccak+keccak-devel.sha256sum] = "6a85d6fe2d8be5083677ecc8e26b81310f84d62d7b44cd337f3c8be90f06919d"

URI_x86_64_v2_rust-tiny-keccak+kmac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiny-keccak+kmac-devel-2.0.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiny-keccak+kmac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiny-keccak+kmac-devel}"
SRC_URI[x86_64_v2_rust-tiny-keccak+kmac-devel.sha256sum] = "8829bcdcf825516cd12a2d72fd55588618f56bd4f17d87ed361995bd31dcf31c"

URI_x86_64_v2_rust-tiny-keccak+parallel_hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiny-keccak+parallel_hash-devel-2.0.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiny-keccak+parallel_hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiny-keccak+parallel_hash-devel}"
SRC_URI[x86_64_v2_rust-tiny-keccak+parallel_hash-devel.sha256sum] = "b2c119c2ffa87200ed838eb7acf400c1d76c526b89196e290723f2938cd23bbd"

URI_x86_64_v2_rust-tiny-keccak+sha3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiny-keccak+sha3-devel-2.0.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiny-keccak+sha3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiny-keccak+sha3-devel}"
SRC_URI[x86_64_v2_rust-tiny-keccak+sha3-devel.sha256sum] = "9fb9b537e0b76f56a2a1167ec48bba6de28d21083a541140183ea15c5d9e10f8"

URI_x86_64_v2_rust-tiny-keccak+shake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiny-keccak+shake-devel-2.0.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiny-keccak+shake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiny-keccak+shake-devel}"
SRC_URI[x86_64_v2_rust-tiny-keccak+shake-devel.sha256sum] = "3014f9d819409acbdb0365fff4970ff641f6aea79775a5e19c5d70a389f2c56d"

URI_x86_64_v2_rust-tiny-keccak+sp800-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiny-keccak+sp800-devel-2.0.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiny-keccak+sp800-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiny-keccak+sp800-devel}"
SRC_URI[x86_64_v2_rust-tiny-keccak+sp800-devel.sha256sum] = "956df4ace52ec648e62832025e979e775f9662e289015b33d82449f74a3ebdc9"

URI_x86_64_v2_rust-tiny-keccak+tuple_hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiny-keccak+tuple_hash-devel-2.0.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiny-keccak+tuple_hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiny-keccak+tuple_hash-devel}"
SRC_URI[x86_64_v2_rust-tiny-keccak+tuple_hash-devel.sha256sum] = "d6dce281d76ac0d5fed52ff86fe512eef1b63a329485016093118a71a7ee392e"

URI_x86_64_v2_rust-tiny-keccak-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiny-keccak-devel-2.0.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiny-keccak-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiny-keccak-devel}"
SRC_URI[x86_64_v2_rust-tiny-keccak-devel.sha256sum] = "b80a1de7eb0bcc0ba7f969122b899535f204bd9b5574e23363db2c48ca4b9eb9"

URI_aarch64_rust-tiny-keccak+cshake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiny-keccak+cshake-devel-2.0.2-11.el10_0.noarch.rpm;name=aarch64_rust-tiny-keccak+cshake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiny-keccak+cshake-devel}"
SRC_URI[aarch64_rust-tiny-keccak+cshake-devel.sha256sum] = "e679a91558265ab04a77e49dac7e8fb4bf55a0b5f994d57560f33d1371bc43b4"

URI_aarch64_rust-tiny-keccak+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiny-keccak+default-devel-2.0.2-11.el10_0.noarch.rpm;name=aarch64_rust-tiny-keccak+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiny-keccak+default-devel}"
SRC_URI[aarch64_rust-tiny-keccak+default-devel.sha256sum] = "3e123ee4e6706d68e7b2aef05d1bfe05251611f3b146b9afff29e94364046bf5"

URI_aarch64_rust-tiny-keccak+fips202-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiny-keccak+fips202-devel-2.0.2-11.el10_0.noarch.rpm;name=aarch64_rust-tiny-keccak+fips202-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiny-keccak+fips202-devel}"
SRC_URI[aarch64_rust-tiny-keccak+fips202-devel.sha256sum] = "960d11726694e3d49e420bdea607fdc50425ed8245fcbb9c6d41f5b6359f1b27"

URI_aarch64_rust-tiny-keccak+k12-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiny-keccak+k12-devel-2.0.2-11.el10_0.noarch.rpm;name=aarch64_rust-tiny-keccak+k12-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiny-keccak+k12-devel}"
SRC_URI[aarch64_rust-tiny-keccak+k12-devel.sha256sum] = "d1e1ff7901edd496773bb4b6381de1e1887bccd6305d7c484b96d8ee64bc1ed8"

URI_aarch64_rust-tiny-keccak+keccak-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiny-keccak+keccak-devel-2.0.2-11.el10_0.noarch.rpm;name=aarch64_rust-tiny-keccak+keccak-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiny-keccak+keccak-devel}"
SRC_URI[aarch64_rust-tiny-keccak+keccak-devel.sha256sum] = "ceee3854b99a25a7871198eb02b09230be3cb37699e5a9f86ee2d95b3890be0f"

URI_aarch64_rust-tiny-keccak+kmac-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiny-keccak+kmac-devel-2.0.2-11.el10_0.noarch.rpm;name=aarch64_rust-tiny-keccak+kmac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiny-keccak+kmac-devel}"
SRC_URI[aarch64_rust-tiny-keccak+kmac-devel.sha256sum] = "9f8b017ce0e60cc0026bf6041c7905cb137e04a1a36f7bc6ac354ecd41776a96"

URI_aarch64_rust-tiny-keccak+parallel_hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiny-keccak+parallel_hash-devel-2.0.2-11.el10_0.noarch.rpm;name=aarch64_rust-tiny-keccak+parallel_hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiny-keccak+parallel_hash-devel}"
SRC_URI[aarch64_rust-tiny-keccak+parallel_hash-devel.sha256sum] = "198523e05674157ec42c5899ed98b033818e0e8a4c8c3de3c515488ee6f2564b"

URI_aarch64_rust-tiny-keccak+sha3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiny-keccak+sha3-devel-2.0.2-11.el10_0.noarch.rpm;name=aarch64_rust-tiny-keccak+sha3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiny-keccak+sha3-devel}"
SRC_URI[aarch64_rust-tiny-keccak+sha3-devel.sha256sum] = "552ccf00f54bfcd43476030588224050ad4907f657ad02e175ea984980be1179"

URI_aarch64_rust-tiny-keccak+shake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiny-keccak+shake-devel-2.0.2-11.el10_0.noarch.rpm;name=aarch64_rust-tiny-keccak+shake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiny-keccak+shake-devel}"
SRC_URI[aarch64_rust-tiny-keccak+shake-devel.sha256sum] = "94b371153862c7c4c42f25302a9345dfc81f595092d604247662d23afa56e945"

URI_aarch64_rust-tiny-keccak+sp800-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiny-keccak+sp800-devel-2.0.2-11.el10_0.noarch.rpm;name=aarch64_rust-tiny-keccak+sp800-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiny-keccak+sp800-devel}"
SRC_URI[aarch64_rust-tiny-keccak+sp800-devel.sha256sum] = "957f8416b5e072199ae172204c585dcb0a77f2e519b487ca5abe538aa4a10d3c"

URI_aarch64_rust-tiny-keccak+tuple_hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiny-keccak+tuple_hash-devel-2.0.2-11.el10_0.noarch.rpm;name=aarch64_rust-tiny-keccak+tuple_hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiny-keccak+tuple_hash-devel}"
SRC_URI[aarch64_rust-tiny-keccak+tuple_hash-devel.sha256sum] = "6247aff01f1863e78b1ddf6951eec63ea349c90d78d40879eb9693f27780910c"

URI_aarch64_rust-tiny-keccak-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiny-keccak-devel-2.0.2-11.el10_0.noarch.rpm;name=aarch64_rust-tiny-keccak-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiny-keccak-devel}"
SRC_URI[aarch64_rust-tiny-keccak-devel.sha256sum] = "fab9844617bd6a160da2c408ffad681f953a410a7b76654f5f040ec42ba8c67d"

RDEPENDS:rust-tiny-keccak+cshake-devel = " \
 cargo \
 rust-tiny-keccak-devel \
 "
RDEPENDS:rust-tiny-keccak+default-devel = " \
 cargo \
 rust-tiny-keccak-devel \
 "
RDEPENDS:rust-tiny-keccak+fips202-devel = " \
 cargo \
 rust-tiny-keccak+keccak-devel \
 rust-tiny-keccak+sha3-devel \
 rust-tiny-keccak+shake-devel \
 rust-tiny-keccak-devel \
 "
RDEPENDS:rust-tiny-keccak+k12-devel = " \
 cargo \
 rust-tiny-keccak-devel \
 "
RDEPENDS:rust-tiny-keccak+keccak-devel = " \
 cargo \
 rust-tiny-keccak-devel \
 "
RDEPENDS:rust-tiny-keccak+kmac-devel = " \
 cargo \
 rust-tiny-keccak+cshake-devel \
 rust-tiny-keccak-devel \
 "
RDEPENDS:rust-tiny-keccak+parallel_hash-devel = " \
 cargo \
 rust-tiny-keccak+cshake-devel \
 rust-tiny-keccak-devel \
 "
RDEPENDS:rust-tiny-keccak+sha3-devel = " \
 cargo \
 rust-tiny-keccak-devel \
 "
RDEPENDS:rust-tiny-keccak+shake-devel = " \
 cargo \
 rust-tiny-keccak-devel \
 "
RDEPENDS:rust-tiny-keccak+sp800-devel = " \
 cargo \
 rust-tiny-keccak+cshake-devel \
 rust-tiny-keccak+kmac-devel \
 rust-tiny-keccak+tuple_hash-devel \
 rust-tiny-keccak-devel \
 "
RDEPENDS:rust-tiny-keccak+tuple_hash-devel = " \
 cargo \
 rust-tiny-keccak+cshake-devel \
 rust-tiny-keccak-devel \
 "
RDEPENDS:rust-tiny-keccak-devel = " \
 cargo \
 rust-crunchy+default-devel \
 "
