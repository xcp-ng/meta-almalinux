# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-geomdl"
PV = "5.3.1"
PR = "32.el10_1"
PACKAGES = " \
 python-geomdl-doc \
 python3-geomdl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-geomdl-5.3.1-32.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4924b4220e659cd36b0f2e19d416f1b196ad5120b75c7c8a4743e0205a7f7642"

URI_x86_64_v2_python-geomdl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-geomdl-doc-5.3.1-32.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-geomdl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-geomdl-doc}"
SRC_URI[x86_64_v2_python-geomdl-doc.sha256sum] = "5087c740dd8aafac7ee451076d3f7dcb72afe5f33a08e1c615111c51e56aa18e"

URI_x86_64_v2_python3-geomdl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-geomdl-5.3.1-32.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-geomdl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-geomdl}"
SRC_URI[x86_64_v2_python3-geomdl.sha256sum] = "a191d5738edddd94b941c42464448504d05c4fd060042c66ea5be4f8c4e69f79"

URI_aarch64_python-geomdl-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-geomdl-doc-5.3.1-32.el10_1.noarch.rpm;name=aarch64_python-geomdl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-geomdl-doc}"
SRC_URI[aarch64_python-geomdl-doc.sha256sum] = "74dccc13d8a1b6a15d23cf4cd5d72a6d0f2f053f537442e10f5d9d1b8b0a4a1b"

URI_aarch64_python3-geomdl = "${EPEL_MIRROR}/aarch64/Packages/p/python3-geomdl-5.3.1-32.el10_1.aarch64.rpm;name=aarch64_python3-geomdl;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-geomdl}"
SRC_URI[aarch64_python3-geomdl.sha256sum] = "8f4460f063bfac29b936cf08eeb6dc8a7a8527a16901c985de7fd93af8d9e077"

RDEPENDS:python-geomdl-doc = " \
 "
RDEPENDS:python3-geomdl = " \
 glibc \
 python3 \
 "
