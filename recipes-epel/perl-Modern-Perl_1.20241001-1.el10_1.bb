# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Modern-Perl"
PV = "1.20241001"
PR = "1.el10_1"
PACKAGES = " \
 perl-Modern-Perl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Modern-Perl-1.20241001-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6ece793fe34973bd7e3683b2ab4bb9a861b41c81c629489203a31a42ab5c98db"

URI_x86_64_v2_perl-Modern-Perl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Modern-Perl-1.20241001-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Modern-Perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Modern-Perl}"
SRC_URI[x86_64_v2_perl-Modern-Perl.sha256sum] = "8146b756b7200f897c16b1bdbbd57c167e4c802e2bea527fd4b803e0089907b9"

URI_aarch64_perl-Modern-Perl = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Modern-Perl-1.20241001-1.el10_1.noarch.rpm;name=aarch64_perl-Modern-Perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Modern-Perl}"
SRC_URI[aarch64_perl-Modern-Perl.sha256sum] = "0b763d39e3d249a93f901a7c4f2b26d8b13e0d8bc0015c2a39b01be6b932b318"

RDEPENDS:perl-Modern-Perl = " \
 perl-IO \
 perl-Modern-Perl \
 perl-libs \
 perl-mro \
 "
