# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-astral-reqwest-middleware"
PV = "0.4.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-astral-reqwest-middleware+charset-devel \
 rust-astral-reqwest-middleware+default-devel \
 rust-astral-reqwest-middleware+http2-devel \
 rust-astral-reqwest-middleware+json-devel \
 rust-astral-reqwest-middleware+multipart-devel \
 rust-astral-reqwest-middleware+rustls-tls-devel \
 rust-astral-reqwest-middleware-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-astral-reqwest-middleware-0.4.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cec9a09e307d2609ed6fcc2560116ec7771bbec9a52c1fe6cc30cbb4c2017e2b"

URI_x86_64_v2_rust-astral-reqwest-middleware+charset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-reqwest-middleware+charset-devel-0.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-reqwest-middleware+charset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-reqwest-middleware+charset-devel}"
SRC_URI[x86_64_v2_rust-astral-reqwest-middleware+charset-devel.sha256sum] = "ea15dda4aa77b674f66d61f343c8fba3937664ecba32357395eb16de5df3a10c"

URI_x86_64_v2_rust-astral-reqwest-middleware+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-reqwest-middleware+default-devel-0.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-reqwest-middleware+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-reqwest-middleware+default-devel}"
SRC_URI[x86_64_v2_rust-astral-reqwest-middleware+default-devel.sha256sum] = "2f42b62029a3ddedb8f5cdcdd859c548f191f1455ed7aa664b2208bd215225aa"

URI_x86_64_v2_rust-astral-reqwest-middleware+http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-reqwest-middleware+http2-devel-0.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-reqwest-middleware+http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-reqwest-middleware+http2-devel}"
SRC_URI[x86_64_v2_rust-astral-reqwest-middleware+http2-devel.sha256sum] = "6544946feaaad2fdf9e3671cb51b3ea1dd621c2607ca4ff1c571d724edc04b6f"

URI_x86_64_v2_rust-astral-reqwest-middleware+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-reqwest-middleware+json-devel-0.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-reqwest-middleware+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-reqwest-middleware+json-devel}"
SRC_URI[x86_64_v2_rust-astral-reqwest-middleware+json-devel.sha256sum] = "24ad13e26ce39cb602a293bc30638c84a8695f150a70c5b7b0c0f8071783bcd4"

URI_x86_64_v2_rust-astral-reqwest-middleware+multipart-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-reqwest-middleware+multipart-devel-0.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-reqwest-middleware+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-reqwest-middleware+multipart-devel}"
SRC_URI[x86_64_v2_rust-astral-reqwest-middleware+multipart-devel.sha256sum] = "3fc37003100d5bbd9b8803b82bf7c6dbfd1b63b56ae7e14e1c0c33ef5934da8a"

URI_x86_64_v2_rust-astral-reqwest-middleware+rustls-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-reqwest-middleware+rustls-tls-devel-0.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-reqwest-middleware+rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-reqwest-middleware+rustls-tls-devel}"
SRC_URI[x86_64_v2_rust-astral-reqwest-middleware+rustls-tls-devel.sha256sum] = "111260792fd64e54642b88f0bb843f62813b22569d4c9065e4a9774962efd700"

URI_x86_64_v2_rust-astral-reqwest-middleware-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-reqwest-middleware-devel-0.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-reqwest-middleware-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-reqwest-middleware-devel}"
SRC_URI[x86_64_v2_rust-astral-reqwest-middleware-devel.sha256sum] = "eba289099d8dda8fe0c9d07da31eec96f1f84c0d1f4f27bca26b9c63ee140ec2"

URI_aarch64_rust-astral-reqwest-middleware+charset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-reqwest-middleware+charset-devel-0.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-astral-reqwest-middleware+charset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-reqwest-middleware+charset-devel}"
SRC_URI[aarch64_rust-astral-reqwest-middleware+charset-devel.sha256sum] = "83af6c9c21d7721cd77e853993008c18888e579eae62920b8eb728bcb7a50b65"

URI_aarch64_rust-astral-reqwest-middleware+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-reqwest-middleware+default-devel-0.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-astral-reqwest-middleware+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-reqwest-middleware+default-devel}"
SRC_URI[aarch64_rust-astral-reqwest-middleware+default-devel.sha256sum] = "520dfa337869e84a45b3c71ca662b4a1dd9726e0c31f54393c607c5df8d79b01"

URI_aarch64_rust-astral-reqwest-middleware+http2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-reqwest-middleware+http2-devel-0.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-astral-reqwest-middleware+http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-reqwest-middleware+http2-devel}"
SRC_URI[aarch64_rust-astral-reqwest-middleware+http2-devel.sha256sum] = "ceed708735add3c3bca03130f33a1535bc8462c895769d123728338f3c6c2d73"

URI_aarch64_rust-astral-reqwest-middleware+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-reqwest-middleware+json-devel-0.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-astral-reqwest-middleware+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-reqwest-middleware+json-devel}"
SRC_URI[aarch64_rust-astral-reqwest-middleware+json-devel.sha256sum] = "3a7bca4c1b91f673a0b1d374f5675025543f89125aeb1d308ab16b3434439f72"

URI_aarch64_rust-astral-reqwest-middleware+multipart-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-reqwest-middleware+multipart-devel-0.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-astral-reqwest-middleware+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-reqwest-middleware+multipart-devel}"
SRC_URI[aarch64_rust-astral-reqwest-middleware+multipart-devel.sha256sum] = "041170341c8967c9d1f99df960a0e309454c0bdc37fd4ba1fb86f583d7c95ef2"

URI_aarch64_rust-astral-reqwest-middleware+rustls-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-reqwest-middleware+rustls-tls-devel-0.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-astral-reqwest-middleware+rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-reqwest-middleware+rustls-tls-devel}"
SRC_URI[aarch64_rust-astral-reqwest-middleware+rustls-tls-devel.sha256sum] = "1c50335c0cddfcbe7168a0e37e243565352ed764d2afff9025a44a7017519565"

URI_aarch64_rust-astral-reqwest-middleware-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-reqwest-middleware-devel-0.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-astral-reqwest-middleware-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-reqwest-middleware-devel}"
SRC_URI[aarch64_rust-astral-reqwest-middleware-devel.sha256sum] = "dcc1c67abe4c09c5cd25ecca719d6b42bb5a59ffbe4c9ca8702af886c0898d64"

RDEPENDS:rust-astral-reqwest-middleware+charset-devel = " \
 cargo \
 rust-astral-reqwest-middleware-devel \
 rust-reqwest0.12+charset-devel \
 "
RDEPENDS:rust-astral-reqwest-middleware+default-devel = " \
 cargo \
 rust-astral-reqwest-middleware-devel \
 "
RDEPENDS:rust-astral-reqwest-middleware+http2-devel = " \
 cargo \
 rust-astral-reqwest-middleware-devel \
 rust-reqwest0.12+http2-devel \
 "
RDEPENDS:rust-astral-reqwest-middleware+json-devel = " \
 cargo \
 rust-astral-reqwest-middleware-devel \
 rust-reqwest0.12+json-devel \
 "
RDEPENDS:rust-astral-reqwest-middleware+multipart-devel = " \
 cargo \
 rust-astral-reqwest-middleware-devel \
 rust-reqwest0.12+multipart-devel \
 "
RDEPENDS:rust-astral-reqwest-middleware+rustls-tls-devel = " \
 cargo \
 rust-astral-reqwest-middleware-devel \
 rust-reqwest0.12+rustls-tls-devel \
 "
RDEPENDS:rust-astral-reqwest-middleware-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-async-trait+default-devel \
 rust-http+default-devel \
 rust-reqwest0.12-devel \
 rust-serde+default-devel \
 rust-thiserror+default-devel \
 rust-tower-service+default-devel \
 "
