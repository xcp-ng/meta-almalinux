# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-click"
PV = "8.1.7"
PR = "7.el10_2"
PACKAGES = " \
 python3-click \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-click-8.1.7-7.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6b553ac8dd11b497529a1e196c86a2f48bee545ebf3fb1a9ca109d5391a3828"

URI_x86_64_v2_python3-click = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-click-8.1.7-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-click;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-click}"
SRC_URI[x86_64_v2_python3-click.sha256sum] = "9b8acbcb289e1894b0adbff534aa5447439849c67ab6618a4c5f2c110f2a6010"

URI_aarch64_python3-click = "${EPEL_MIRROR}/aarch64/Packages/p/python3-click-8.1.7-7.el10_2.noarch.rpm;name=aarch64_python3-click;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-click}"
SRC_URI[aarch64_python3-click.sha256sum] = "575a783e1dad7af8fb59464c55344c8f4e19be2123296c59da19bd289e4a9deb"

RDEPENDS:python3-click = " \
 python3 \
 "
