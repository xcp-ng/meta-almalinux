# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-ahmetb-linq-3"
PV = "3.2.0"
PR = "6.el10_0"
PACKAGES = " \
 golang-github-ahmetb-linq-3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-ahmetb-linq-3-3.2.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5282d199cd0a6d74bfe30545c0b033f8c3e4ce51f98798fba3bd93b01b837c91"

URI_x86_64_v2_golang-github-ahmetb-linq-3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-ahmetb-linq-3-devel-3.2.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-ahmetb-linq-3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-ahmetb-linq-3-devel}"
SRC_URI[x86_64_v2_golang-github-ahmetb-linq-3-devel.sha256sum] = "30dcfe01813eb3237f614e93d21fb8697092d025cbc35c1ee8e9d6da931e924f"

URI_aarch64_golang-github-ahmetb-linq-3-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-ahmetb-linq-3-devel-3.2.0-6.el10_0.noarch.rpm;name=aarch64_golang-github-ahmetb-linq-3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-ahmetb-linq-3-devel}"
SRC_URI[aarch64_golang-github-ahmetb-linq-3-devel.sha256sum] = "aeff88e9dd1319bd001f9f3752d215cbe0b531baf059fa1bc9b0e42673e0a7f5"

RDEPENDS:golang-github-ahmetb-linq-3-devel = " \
 go-filesystem \
 "
