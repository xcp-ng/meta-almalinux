# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-yaml"
PV = "0.7.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-tree-sitter-yaml+default-devel \
 rust-tree-sitter-yaml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-yaml-0.7.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a3e3a7a7f72fcb31e186379e64d07d00cf4a4ab9355466ddc9fa266e33d87913"

URI_x86_64_v2_rust-tree-sitter-yaml+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-yaml+default-devel-0.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-yaml+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-yaml+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-yaml+default-devel.sha256sum] = "c07372792da846a4218f37ee6230c952e5b8c91595dcb60160f0be793b4d4bd4"

URI_x86_64_v2_rust-tree-sitter-yaml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-yaml-devel-0.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-yaml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-yaml-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-yaml-devel.sha256sum] = "8d22aee0614cba78bed0c5cf610afac3ab5f6093c0e4d66eef8ed73805c95f63"

URI_aarch64_rust-tree-sitter-yaml+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-yaml+default-devel-0.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-yaml+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-yaml+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-yaml+default-devel.sha256sum] = "571cbfc4e94a30b6521928d2c78f7d4c6d7e571491074441802e153fa1498f2c"

URI_aarch64_rust-tree-sitter-yaml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-yaml-devel-0.7.0-1.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-yaml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-yaml-devel}"
SRC_URI[aarch64_rust-tree-sitter-yaml-devel.sha256sum] = "90673da6ee41d6f33c40111eae0cfda47b0bfa4a57b99793b9473629d20a8cdb"

RDEPENDS:rust-tree-sitter-yaml+default-devel = " \
 cargo \
 rust-tree-sitter-yaml-devel \
 "
RDEPENDS:rust-tree-sitter-yaml-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
