# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libcutl"
PV = "1.10.0"
PR = "31.el10_0"
PACKAGES = " \
 libcutl \
 libcutl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libcutl-1.10.0-31.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52a22a29db02ebe9f43c7dd6c4cdab5f361865d69a42a469e42ddd1388a5dbd4"

URI_x86_64_v2_libcutl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcutl-1.10.0-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcutl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcutl}"
SRC_URI[x86_64_v2_libcutl.sha256sum] = "c412f2ac4aec4fb3ef0d39bc8a85442ecb5f2d0820e0f9fbf0aad4d100c52f84"

URI_x86_64_v2_libcutl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcutl-devel-1.10.0-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcutl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcutl-devel}"
SRC_URI[x86_64_v2_libcutl-devel.sha256sum] = "14278d6a7ee2293a09d68171152669f889076f49b82fef1bc5174d8c72473a94"

URI_aarch64_libcutl = "${EPEL_MIRROR}/aarch64/Packages/l/libcutl-1.10.0-31.el10_0.aarch64.rpm;name=aarch64_libcutl;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcutl}"
SRC_URI[aarch64_libcutl.sha256sum] = "3e363b1cda7af7fd67e1f006d3661f70cfc21e9c8a1ac6947aad704866bed2d6"

URI_aarch64_libcutl-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libcutl-devel-1.10.0-31.el10_0.aarch64.rpm;name=aarch64_libcutl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcutl-devel}"
SRC_URI[aarch64_libcutl-devel.sha256sum] = "14f558996fe0371472eae137c6a446b98cf5457a5dd28cdcfe882ce9b095f528"

RDEPENDS:libcutl = " \
 expat \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libcutl-devel = " \
 libcutl \
 pkgconf-pkg-config \
 "
