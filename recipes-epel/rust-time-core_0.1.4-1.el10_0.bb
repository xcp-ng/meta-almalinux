# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-time-core"
PV = "0.1.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-time-core+default-devel \
 rust-time-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-time-core-0.1.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac97e7b67b35b7905489fb1d5f783123dd7bf2c8d04024a0a3bcbb5388898331"

URI_x86_64_v2_rust-time-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time-core+default-devel-0.1.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time-core+default-devel}"
SRC_URI[x86_64_v2_rust-time-core+default-devel.sha256sum] = "4d914b8e4497f74139ae1f88a3192258642af3e92d3b16411662333f277255bf"

URI_x86_64_v2_rust-time-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time-core-devel-0.1.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time-core-devel}"
SRC_URI[x86_64_v2_rust-time-core-devel.sha256sum] = "07a4e9c5809d1c367981dbaea45f68fa83c68406a8fa3d040554c44df10e7051"

URI_aarch64_rust-time-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time-core+default-devel-0.1.4-1.el10_0.noarch.rpm;name=aarch64_rust-time-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time-core+default-devel}"
SRC_URI[aarch64_rust-time-core+default-devel.sha256sum] = "d8917516eed3e92795eae81692db9a93bc9d02844a6cc428cb4130c6926525db"

URI_aarch64_rust-time-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time-core-devel-0.1.4-1.el10_0.noarch.rpm;name=aarch64_rust-time-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time-core-devel}"
SRC_URI[aarch64_rust-time-core-devel.sha256sum] = "75e2f4157c411115d118ac073ad682cd8f89f557463b8aae9253c52b45ab8152"

RDEPENDS:rust-time-core+default-devel = " \
 cargo \
 rust-time-core-devel \
 "
RDEPENDS:rust-time-core-devel = " \
 cargo \
 rust \
 "
