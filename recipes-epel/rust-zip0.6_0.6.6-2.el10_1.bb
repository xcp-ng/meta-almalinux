# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zip0.6"
PV = "0.6.6"
PR = "2.el10_1"
PACKAGES = " \
 rust-zip0.6+aes-crypto-devel \
 rust-zip0.6+aes-devel \
 rust-zip0.6+bzip2-devel \
 rust-zip0.6+constant_time_eq-devel \
 rust-zip0.6+default-devel \
 rust-zip0.6+deflate-devel \
 rust-zip0.6+deflate-miniz-devel \
 rust-zip0.6+deflate-zlib-devel \
 rust-zip0.6+flate2-devel \
 rust-zip0.6+hmac-devel \
 rust-zip0.6+pbkdf2-devel \
 rust-zip0.6+sha1-devel \
 rust-zip0.6+time-devel \
 rust-zip0.6+unreserved-devel \
 rust-zip0.6+zstd-devel \
 rust-zip0.6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zip0.6-0.6.6-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b21f351d4405334157b965568ebe523035494e92ea1c5a4472d0a443a6807612"

URI_x86_64_v2_rust-zip0.6+aes-crypto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip0.6+aes-crypto-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip0.6+aes-crypto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip0.6+aes-crypto-devel}"
SRC_URI[x86_64_v2_rust-zip0.6+aes-crypto-devel.sha256sum] = "0c9c44140fa0425ef4e8c8cde82d531d1cd1c2bea3cef9a9891e29db5b3aaecd"

URI_x86_64_v2_rust-zip0.6+aes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip0.6+aes-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip0.6+aes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip0.6+aes-devel}"
SRC_URI[x86_64_v2_rust-zip0.6+aes-devel.sha256sum] = "a9648ca5c9d9df7f3fa01a5f37c083293ef7d3b39ce59f39586d150f8d08a0b5"

URI_x86_64_v2_rust-zip0.6+bzip2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip0.6+bzip2-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip0.6+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip0.6+bzip2-devel}"
SRC_URI[x86_64_v2_rust-zip0.6+bzip2-devel.sha256sum] = "709a14125839f02d06565d31128adc0d77b55d01f817e0fedf2011a7b2d452ef"
RPROVIDES:rust-zip0.6+bzip2-devel:append:x86_64_v2 = " virtual/crate_zip/bzip2__ge_0.6.0_with_crate_zip/bzip2__lt_7.0.0~"

URI_x86_64_v2_rust-zip0.6+constant_time_eq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip0.6+constant_time_eq-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip0.6+constant_time_eq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip0.6+constant_time_eq-devel}"
SRC_URI[x86_64_v2_rust-zip0.6+constant_time_eq-devel.sha256sum] = "2e120da522c1b20840773320c466338e6adbdf94706a65d7b52cd634441ac3c5"

URI_x86_64_v2_rust-zip0.6+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip0.6+default-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip0.6+default-devel}"
SRC_URI[x86_64_v2_rust-zip0.6+default-devel.sha256sum] = "f00a691a427c44ac3a32c2bd892310cd733840e15ca8086cac9797d8c7d01642"

URI_x86_64_v2_rust-zip0.6+deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip0.6+deflate-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip0.6+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip0.6+deflate-devel}"
SRC_URI[x86_64_v2_rust-zip0.6+deflate-devel.sha256sum] = "d61bb1e3fdb10b8e07f210dad97eb9bbd60072c4e74377cdec584c4f3e2a6a0e"
RPROVIDES:rust-zip0.6+deflate-devel:append:x86_64_v2 = " virtual/crate_zip/deflate__ge_0.6.0_with_crate_zip/deflate__lt_7.0.0~"

URI_x86_64_v2_rust-zip0.6+deflate-miniz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip0.6+deflate-miniz-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip0.6+deflate-miniz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip0.6+deflate-miniz-devel}"
SRC_URI[x86_64_v2_rust-zip0.6+deflate-miniz-devel.sha256sum] = "0becc9b439df9029c979a2b28002bfcf7bd587c2917e8e47f9013a7dca9d8e36"

URI_x86_64_v2_rust-zip0.6+deflate-zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip0.6+deflate-zlib-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip0.6+deflate-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip0.6+deflate-zlib-devel}"
SRC_URI[x86_64_v2_rust-zip0.6+deflate-zlib-devel.sha256sum] = "d41c344e7cc02b8f53cc9bad2be7ff988cfec0d8c1f38686029a90baa86b0535"

URI_x86_64_v2_rust-zip0.6+flate2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip0.6+flate2-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip0.6+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip0.6+flate2-devel}"
SRC_URI[x86_64_v2_rust-zip0.6+flate2-devel.sha256sum] = "6109e29fbd3838b7dd570ad35a092545e098909db735ad2c7dcc6fa51ead316b"

URI_x86_64_v2_rust-zip0.6+hmac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip0.6+hmac-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip0.6+hmac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip0.6+hmac-devel}"
SRC_URI[x86_64_v2_rust-zip0.6+hmac-devel.sha256sum] = "d4f20ee385b9578d722e6b543ba947dc35cf0c1ac8cd120e74fe1adf6d254d05"

URI_x86_64_v2_rust-zip0.6+pbkdf2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip0.6+pbkdf2-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip0.6+pbkdf2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip0.6+pbkdf2-devel}"
SRC_URI[x86_64_v2_rust-zip0.6+pbkdf2-devel.sha256sum] = "2e38295706754d778c98cc55fca656064044b27d8b3826bd68042da1aa59e080"

URI_x86_64_v2_rust-zip0.6+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip0.6+sha1-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip0.6+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip0.6+sha1-devel}"
SRC_URI[x86_64_v2_rust-zip0.6+sha1-devel.sha256sum] = "b6b722e9e911d79f259bfe88b3858ba13fb6f4aa4285aa5653568a3760ea950b"

URI_x86_64_v2_rust-zip0.6+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip0.6+time-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip0.6+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip0.6+time-devel}"
SRC_URI[x86_64_v2_rust-zip0.6+time-devel.sha256sum] = "153a73f6fa8cd73cb17df14cd5970f227dbf524fcf594f20a84e91446969e11b"

URI_x86_64_v2_rust-zip0.6+unreserved-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip0.6+unreserved-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip0.6+unreserved-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip0.6+unreserved-devel}"
SRC_URI[x86_64_v2_rust-zip0.6+unreserved-devel.sha256sum] = "dcac1c4c2b8eeec89af635a050153399df6ac3c02219ff952888020ca1675c62"

URI_x86_64_v2_rust-zip0.6+zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip0.6+zstd-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip0.6+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip0.6+zstd-devel}"
SRC_URI[x86_64_v2_rust-zip0.6+zstd-devel.sha256sum] = "3499831f6f159d224bbb5945a75c7c471809ba0a501dad2c1037200cb6fbf55c"

URI_x86_64_v2_rust-zip0.6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip0.6-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip0.6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip0.6-devel}"
SRC_URI[x86_64_v2_rust-zip0.6-devel.sha256sum] = "7c2dd0d195fb0b3e415e84f0bb36802436046ef5a61d5ade6c60e3b4a427c6bc"
RPROVIDES:rust-zip0.6-devel:append:x86_64_v2 = " virtual/crate_zip__ge_0.6.0_with_crate_zip__lt_7.0.0~"

URI_aarch64_rust-zip0.6+aes-crypto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip0.6+aes-crypto-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-zip0.6+aes-crypto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip0.6+aes-crypto-devel}"
SRC_URI[aarch64_rust-zip0.6+aes-crypto-devel.sha256sum] = "a223170d70f12ef5ad571a65e3d70a6e0376c9ea5d9ebba380ff2d63a923993c"

URI_aarch64_rust-zip0.6+aes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip0.6+aes-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-zip0.6+aes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip0.6+aes-devel}"
SRC_URI[aarch64_rust-zip0.6+aes-devel.sha256sum] = "053e34c95c36e52b16997cac133ec141eb54ffbcec3f0f31822e49be0bd91500"

URI_aarch64_rust-zip0.6+bzip2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip0.6+bzip2-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-zip0.6+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip0.6+bzip2-devel}"
SRC_URI[aarch64_rust-zip0.6+bzip2-devel.sha256sum] = "6167fcd648aeb92ca05b34863c39cc147ebb54019f7ce9c03322fc45ff9ee552"
RPROVIDES:rust-zip0.6+bzip2-devel:append:aarch64 = " virtual/crate_zip/bzip2__ge_0.6.0_with_crate_zip/bzip2__lt_7.0.0~"

URI_aarch64_rust-zip0.6+constant_time_eq-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip0.6+constant_time_eq-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-zip0.6+constant_time_eq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip0.6+constant_time_eq-devel}"
SRC_URI[aarch64_rust-zip0.6+constant_time_eq-devel.sha256sum] = "58c86a1c1b7d7abcd36ac048bfb1816ae54955feee5a5fb0207ed286f619fc24"

URI_aarch64_rust-zip0.6+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip0.6+default-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-zip0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip0.6+default-devel}"
SRC_URI[aarch64_rust-zip0.6+default-devel.sha256sum] = "84460e5f13117791b9426e73810e816a062da1d167b7edd6746987f5932edf75"

URI_aarch64_rust-zip0.6+deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip0.6+deflate-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-zip0.6+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip0.6+deflate-devel}"
SRC_URI[aarch64_rust-zip0.6+deflate-devel.sha256sum] = "78125f931a6ecea4fa51245f4338fba7327510d8064ccb492098a27becd9198c"
RPROVIDES:rust-zip0.6+deflate-devel:append:aarch64 = " virtual/crate_zip/deflate__ge_0.6.0_with_crate_zip/deflate__lt_7.0.0~"

URI_aarch64_rust-zip0.6+deflate-miniz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip0.6+deflate-miniz-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-zip0.6+deflate-miniz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip0.6+deflate-miniz-devel}"
SRC_URI[aarch64_rust-zip0.6+deflate-miniz-devel.sha256sum] = "1fbdb3c352d7aecde6e1d1b1263b2cb9a781be3d8992898a22857a0d1b7044e9"

URI_aarch64_rust-zip0.6+deflate-zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip0.6+deflate-zlib-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-zip0.6+deflate-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip0.6+deflate-zlib-devel}"
SRC_URI[aarch64_rust-zip0.6+deflate-zlib-devel.sha256sum] = "477c585bd293aeb91fa8a2febb16a02183c242aebfcb840ba7b0003b3ae2560e"

URI_aarch64_rust-zip0.6+flate2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip0.6+flate2-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-zip0.6+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip0.6+flate2-devel}"
SRC_URI[aarch64_rust-zip0.6+flate2-devel.sha256sum] = "1ca84208f8133c87763fa8dd912f30edf69fcfa2c6f219ed4cfb0f7b675bc1ec"

URI_aarch64_rust-zip0.6+hmac-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip0.6+hmac-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-zip0.6+hmac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip0.6+hmac-devel}"
SRC_URI[aarch64_rust-zip0.6+hmac-devel.sha256sum] = "c663148b229ebff54d6e3b1de8ffe315cc1888e1c417e0126f57b0e9f992eca3"

URI_aarch64_rust-zip0.6+pbkdf2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip0.6+pbkdf2-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-zip0.6+pbkdf2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip0.6+pbkdf2-devel}"
SRC_URI[aarch64_rust-zip0.6+pbkdf2-devel.sha256sum] = "80d317c552aa786d95209fcfffaf36a21211322a822f82d2beaf0e5ba5ec3f9b"

URI_aarch64_rust-zip0.6+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip0.6+sha1-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-zip0.6+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip0.6+sha1-devel}"
SRC_URI[aarch64_rust-zip0.6+sha1-devel.sha256sum] = "f351d4398114b8d90a0c20068f613ef9b2584d84d4372500a0abb030b0123f4c"

URI_aarch64_rust-zip0.6+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip0.6+time-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-zip0.6+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip0.6+time-devel}"
SRC_URI[aarch64_rust-zip0.6+time-devel.sha256sum] = "44d661d50eb68b28d485f218d1ef3ff14b0a344a724e9235f4c50616ddd2cd95"

URI_aarch64_rust-zip0.6+unreserved-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip0.6+unreserved-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-zip0.6+unreserved-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip0.6+unreserved-devel}"
SRC_URI[aarch64_rust-zip0.6+unreserved-devel.sha256sum] = "b2ea62416625a6c5d9e9d432d05aa33211f2f7d29127fc316b306c8fbc1e9c9c"

URI_aarch64_rust-zip0.6+zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip0.6+zstd-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-zip0.6+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip0.6+zstd-devel}"
SRC_URI[aarch64_rust-zip0.6+zstd-devel.sha256sum] = "705e34335e10e4e12d25b1de4a1e7f50198a06dad3fd6d2a5e5aab078893c33a"

URI_aarch64_rust-zip0.6-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip0.6-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-zip0.6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip0.6-devel}"
SRC_URI[aarch64_rust-zip0.6-devel.sha256sum] = "cb632bb7f795ef117709c44e79b67910f87135bec45c0a429ec1d23b6aff2043"
RPROVIDES:rust-zip0.6-devel:append:aarch64 = " virtual/crate_zip__ge_0.6.0_with_crate_zip__lt_7.0.0~"

RDEPENDS:rust-zip0.6+aes-crypto-devel = " \
 cargo \
 rust-zip0.6+aes-devel \
 rust-zip0.6+constant_time_eq-devel \
 rust-zip0.6+hmac-devel \
 rust-zip0.6+pbkdf2-devel \
 rust-zip0.6+sha1-devel \
 rust-zip0.6-devel \
 "
RDEPENDS:rust-zip0.6+aes-devel = " \
 cargo \
 rust-aes+default-devel \
 rust-zip0.6-devel \
 "
RDEPENDS:rust-zip0.6+bzip2-devel = " \
 cargo \
 rust-bzip2+default-devel \
 rust-zip0.6-devel \
 "
RDEPENDS:rust-zip0.6+constant_time_eq-devel = " \
 cargo \
 rust-constant_time_eq+default-devel \
 rust-zip0.6-devel \
 "
RDEPENDS:rust-zip0.6+default-devel = " \
 cargo \
 rust-zip0.6+aes-crypto-devel \
 rust-zip0.6+bzip2-devel \
 rust-zip0.6+deflate-devel \
 rust-zip0.6+time-devel \
 rust-zip0.6+zstd-devel \
 rust-zip0.6-devel \
 "
RDEPENDS:rust-zip0.6+deflate-devel = " \
 cargo \
 rust-flate2+rust_backend-devel \
 rust-flate2-devel \
 rust-zip0.6-devel \
 "
RDEPENDS:rust-zip0.6+deflate-miniz-devel = " \
 cargo \
 rust-flate2+default-devel \
 rust-flate2-devel \
 rust-zip0.6-devel \
 "
RDEPENDS:rust-zip0.6+deflate-zlib-devel = " \
 cargo \
 rust-flate2+zlib-devel \
 rust-flate2-devel \
 rust-zip0.6-devel \
 "
RDEPENDS:rust-zip0.6+flate2-devel = " \
 cargo \
 rust-flate2-devel \
 rust-zip0.6-devel \
 "
RDEPENDS:rust-zip0.6+hmac-devel = " \
 cargo \
 rust-hmac+default-devel \
 rust-hmac+reset-devel \
 rust-zip0.6-devel \
 "
RDEPENDS:rust-zip0.6+pbkdf2-devel = " \
 cargo \
 rust-pbkdf2+default-devel \
 rust-zip0.6-devel \
 "
RDEPENDS:rust-zip0.6+sha1-devel = " \
 cargo \
 rust-sha1+default-devel \
 rust-zip0.6-devel \
 "
RDEPENDS:rust-zip0.6+time-devel = " \
 cargo \
 rust-time+std-devel \
 rust-time-devel \
 rust-zip0.6-devel \
 "
RDEPENDS:rust-zip0.6+unreserved-devel = " \
 cargo \
 rust-zip0.6-devel \
 "
RDEPENDS:rust-zip0.6+zstd-devel = " \
 cargo \
 rust-zip0.6-devel \
 rust-zstd+default-devel \
 "
RDEPENDS:rust-zip0.6-devel = " \
 cargo \
 rust \
 rust-byteorder+default-devel \
 rust-crc32fast+default-devel \
 rust-crossbeam-utils+default-devel \
 "
