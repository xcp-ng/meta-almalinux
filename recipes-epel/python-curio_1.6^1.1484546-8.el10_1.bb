# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-curio"
PV = "1.6^1.1484546"
PR = "8.el10_1"
PACKAGES = " \
 python3-curio \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-curio-1.6^1.1484546-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "83e0241630f65a4a132209a3c2c001cee1cf920b4a11772b7bdaf59b3db15eb5"

URI_x86_64_v2_python3-curio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-curio-1.6^1.1484546-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-curio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-curio}"
SRC_URI[x86_64_v2_python3-curio.sha256sum] = "29605e26cd063bd8717f79d847d3eb85799ead0f6cc3cfce7ca61dd86fed5742"

URI_aarch64_python3-curio = "${EPEL_MIRROR}/aarch64/Packages/p/python3-curio-1.6^1.1484546-8.el10_1.noarch.rpm;name=aarch64_python3-curio;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-curio}"
SRC_URI[aarch64_python3-curio.sha256sum] = "548658cbd6e1f11a824c9eb0d66bf6159c797bba10c3ebfa1c377cf4d10aff80"

RDEPENDS:python3-curio = " \
 python3 \
 "
