# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-databake"
PV = "0.2.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-databake+default-devel \
 rust-databake+derive-devel \
 rust-databake-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-databake-0.2.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c742aecb3ad8a6d68276333dd93d1a8686856ab6e3eef85c908341d188fef725"

URI_x86_64_v2_rust-databake+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-databake+default-devel-0.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-databake+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-databake+default-devel}"
SRC_URI[x86_64_v2_rust-databake+default-devel.sha256sum] = "3e1b096ee7171ff1ddcb7836acdd6e179a8f3db5f4f5e574535c030987be26dd"

URI_x86_64_v2_rust-databake+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-databake+derive-devel-0.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-databake+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-databake+derive-devel}"
SRC_URI[x86_64_v2_rust-databake+derive-devel.sha256sum] = "f1d1a71805e757028aad8a83181853aaff393b539872fd8e1ba81e566738505a"

URI_x86_64_v2_rust-databake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-databake-devel-0.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-databake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-databake-devel}"
SRC_URI[x86_64_v2_rust-databake-devel.sha256sum] = "02b242893c3fda9d6193185e3c68c9beb547d2b1aa2675c0627c75cd90b78dbc"

URI_aarch64_rust-databake+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-databake+default-devel-0.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-databake+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-databake+default-devel}"
SRC_URI[aarch64_rust-databake+default-devel.sha256sum] = "684424cee8fdeaf7b169d23771c2622dd9e2daa117ca46368523454fa8b64c62"

URI_aarch64_rust-databake+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-databake+derive-devel-0.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-databake+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-databake+derive-devel}"
SRC_URI[aarch64_rust-databake+derive-devel.sha256sum] = "419adaa76721bd326acb6d10036637707913354d392fe7c65d76fb67b7dfd37c"

URI_aarch64_rust-databake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-databake-devel-0.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-databake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-databake-devel}"
SRC_URI[aarch64_rust-databake-devel.sha256sum] = "0dcb0104988e4ac70833b0702293639962ab948fdc3f09709ab876d8c0a29ad4"

RDEPENDS:rust-databake+default-devel = " \
 cargo \
 rust-databake-devel \
 "
RDEPENDS:rust-databake+derive-devel = " \
 cargo \
 rust-databake-derive-devel \
 rust-databake-devel \
 "
RDEPENDS:rust-databake-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 "
