# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-inotify-survey"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kde-inotify-survey \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kde-inotify-survey-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "08540533a098e2adc2b5ac5750735ac2635caca785dd6521dd37354a2efcde98"

URI_x86_64_v2_kde-inotify-survey = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-inotify-survey-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-inotify-survey;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-inotify-survey}"
SRC_URI[x86_64_v2_kde-inotify-survey.sha256sum] = "9acf895ecd4ba9567d5d3acf6aa0ae71d6aba417ef4f37dc049aa0e1d6595fcf"

URI_aarch64_kde-inotify-survey = "${EPEL_MIRROR}/aarch64/Packages/k/kde-inotify-survey-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kde-inotify-survey;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-inotify-survey}"
SRC_URI[aarch64_kde-inotify-survey.sha256sum] = "c39653cdf583f0ca50b677e77f002cadcf0446adb9f0816b48fe5c8de6341174"

RDEPENDS:kde-inotify-survey = " \
 dbus-common \
 glibc \
 kf6-kauth \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kded \
 kf6-ki18n \
 kf6-knotifications \
 libstdc++ \
 polkit \
 qt6-qtbase \
 "
