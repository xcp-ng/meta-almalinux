# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sys-CPU"
PV = "0.61"
PR = "41.el10_1"
PACKAGES = " \
 perl-Sys-CPU \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Sys-CPU-0.61-41.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "297a382c60f6630b156d6774a3bf7bcfb0293c53c44ce93d014f0d6fa084c630"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sys-CPU-0.61-41.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Sys-CPU;unpack=0"
SRC_URI[x86_64_v2_perl-Sys-CPU.sha256sum] = "f604a4f3736cb2d9ff18fa2ad815ada40323ccd1f0bdb59e0c6d68c36c0eea2b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Sys-CPU-0.61-41.el10_1.aarch64.rpm;name=aarch64_perl-Sys-CPU;unpack=0"
SRC_URI[aarch64_perl-Sys-CPU.sha256sum] = "14943c10c1fe2bafef013f2da5ecb6ec621e36f9152f1e5c3ab598a712672073"

RDEPENDS:perl-Sys-CPU = " \
 glibc \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
