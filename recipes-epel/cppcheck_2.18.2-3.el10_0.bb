# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cppcheck"
PV = "2.18.2"
PR = "3.el10_0"
PACKAGES = " \
 cppcheck \
 cppcheck-gui \
 cppcheck-htmlreport \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cppcheck-2.18.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb2c9a5e6ae6a9a450fafa8278260b914f5547bdc182729fbc73c717e25e06b9"

URI_x86_64_v2_cppcheck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cppcheck-2.18.2-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cppcheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cppcheck}"
SRC_URI[x86_64_v2_cppcheck.sha256sum] = "4a48123d91f90804230539ba82dbc50621d4f67048f97225793462fbae5539e7"

URI_x86_64_v2_cppcheck-gui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cppcheck-gui-2.18.2-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cppcheck-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cppcheck-gui}"
SRC_URI[x86_64_v2_cppcheck-gui.sha256sum] = "d0da57ca73892713eb22aa3b068e0cd76db83a35dd59a0b7fc4cc511ab20daea"

URI_x86_64_v2_cppcheck-htmlreport = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cppcheck-htmlreport-2.18.2-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cppcheck-htmlreport;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cppcheck-htmlreport}"
SRC_URI[x86_64_v2_cppcheck-htmlreport.sha256sum] = "672f784437fd4150833dc2fb3cc64d75d51cdad5d48c454cca94b51343f59c21"

URI_aarch64_cppcheck = "${EPEL_MIRROR}/aarch64/Packages/c/cppcheck-2.18.2-3.el10_0.aarch64.rpm;name=aarch64_cppcheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_cppcheck}"
SRC_URI[aarch64_cppcheck.sha256sum] = "207f5c6f02a454e78f2f124a4a0972f096646e6ef37feffc4497aa45eba02387"

URI_aarch64_cppcheck-gui = "${EPEL_MIRROR}/aarch64/Packages/c/cppcheck-gui-2.18.2-3.el10_0.aarch64.rpm;name=aarch64_cppcheck-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_cppcheck-gui}"
SRC_URI[aarch64_cppcheck-gui.sha256sum] = "772d9a49b0a5ec48a3596eeaab544afbfc419fc909b9b88057dde9291c119991"

URI_aarch64_cppcheck-htmlreport = "${EPEL_MIRROR}/aarch64/Packages/c/cppcheck-htmlreport-2.18.2-3.el10_0.aarch64.rpm;name=aarch64_cppcheck-htmlreport;unpack=0"
SRC_URI:append = " ${URI_aarch64_cppcheck-htmlreport}"
SRC_URI[aarch64_cppcheck-htmlreport.sha256sum] = "29d0dd64897260dcb52dc2b9b7d33255e97fd7913bbdd20d1248774d2bbb8d5c"

RDEPENDS:cppcheck = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 tinyxml2 \
 "
RDEPENDS:cppcheck-gui = " \
 cppcheck \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-libs-help \
 tinyxml2 \
 "
RDEPENDS:cppcheck-htmlreport = " \
 cppcheck \
 python3 \
 python3-pygments \
 "
