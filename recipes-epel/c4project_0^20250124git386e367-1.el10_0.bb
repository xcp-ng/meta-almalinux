# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "c4project"
PV = "0^20250124git386e367"
PR = "1.el10_0"
PACKAGES = " \
 c4project \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/c4project-0^20250124git386e367-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "530b9aac6104dd1c83390eefa9f23d876e81bf808a5de5212ddedfb5952ce230"

URI_x86_64_v2_c4project = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/c4project-0^20250124git386e367-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_c4project;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_c4project}"
SRC_URI[x86_64_v2_c4project.sha256sum] = "5d00443805ad9d22de895306c384800208dc956a0f4c84e10b773082b11b914e"

URI_aarch64_c4project = "${EPEL_MIRROR}/aarch64/Packages/c/c4project-0^20250124git386e367-1.el10_0.noarch.rpm;name=aarch64_c4project;unpack=0"
SRC_URI:append = " ${URI_aarch64_c4project}"
SRC_URI[aarch64_c4project.sha256sum] = "65b38f7a1013462a0aed6484c4d48e72c849fe503f3e650224e630288f28b2be"

RDEPENDS:c4project = " \
 cmake-filesystem \
 git-core \
 "
