# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libz-sys"
PV = "1.1.29"
PR = "1.el10_2"
PACKAGES = " \
 rust-libz-sys+default-devel \
 rust-libz-sys+libc-devel \
 rust-libz-sys+stock-zlib-devel \
 rust-libz-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libz-sys-1.1.29-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "32885036146a6f33b0cef671188b289500482a90e6561ab163a2a92622bf60f5"

URI_x86_64_v2_rust-libz-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-sys+default-devel-1.1.29-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libz-sys+default-devel.sha256sum] = "a99887dd0e01c189fb7f6071f2d2d262987a74b2f426adaf80b9810b57297758"

URI_x86_64_v2_rust-libz-sys+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-sys+libc-devel-1.1.29-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-sys+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-sys+libc-devel}"
SRC_URI[x86_64_v2_rust-libz-sys+libc-devel.sha256sum] = "3e0769de2581793092d2cc5d144b5139c0b373d3b765f621a4d1cb10a20d639e"

URI_x86_64_v2_rust-libz-sys+stock-zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-sys+stock-zlib-devel-1.1.29-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-sys+stock-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-sys+stock-zlib-devel}"
SRC_URI[x86_64_v2_rust-libz-sys+stock-zlib-devel.sha256sum] = "aa915e9580819b3439e7036279ee2aa920b6c35be24a8b524e8abe8f3f4ddf01"

URI_x86_64_v2_rust-libz-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-sys-devel-1.1.29-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-sys-devel}"
SRC_URI[x86_64_v2_rust-libz-sys-devel.sha256sum] = "2c11f82db1f2ebd498c721a72754559fad44b3113a6bcf073003d835d6f8b451"

URI_aarch64_rust-libz-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-sys+default-devel-1.1.29-1.el10_2.noarch.rpm;name=aarch64_rust-libz-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-sys+default-devel}"
SRC_URI[aarch64_rust-libz-sys+default-devel.sha256sum] = "8d198818bca189b8f65607fefd7f0caa275fde8f79d8832b55780de1eedf6a5d"

URI_aarch64_rust-libz-sys+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-sys+libc-devel-1.1.29-1.el10_2.noarch.rpm;name=aarch64_rust-libz-sys+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-sys+libc-devel}"
SRC_URI[aarch64_rust-libz-sys+libc-devel.sha256sum] = "91cdd6084ddc6b49e16588c6870a1e1b7978b1b17e780501d421a538d3443cfe"

URI_aarch64_rust-libz-sys+stock-zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-sys+stock-zlib-devel-1.1.29-1.el10_2.noarch.rpm;name=aarch64_rust-libz-sys+stock-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-sys+stock-zlib-devel}"
SRC_URI[aarch64_rust-libz-sys+stock-zlib-devel.sha256sum] = "e5cca3a8835471f32601c51702d5efd83fc3a7adb7b77f8a065a374170f6e6ab"

URI_aarch64_rust-libz-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-sys-devel-1.1.29-1.el10_2.noarch.rpm;name=aarch64_rust-libz-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-sys-devel}"
SRC_URI[aarch64_rust-libz-sys-devel.sha256sum] = "2ef5419ab5c142a35d8866fa435a8a471528b2c381740525bb0e2a43c9c167c8"

RDEPENDS:rust-libz-sys+default-devel = " \
 cargo \
 rust-libz-sys+libc-devel \
 rust-libz-sys+stock-zlib-devel \
 rust-libz-sys-devel \
 "
RDEPENDS:rust-libz-sys+libc-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-libz-sys-devel \
 "
RDEPENDS:rust-libz-sys+stock-zlib-devel = " \
 cargo \
 rust-libz-sys-devel \
 "
RDEPENDS:rust-libz-sys-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-pkg-config+default-devel \
 zlib-ng-compat-devel \
 "
