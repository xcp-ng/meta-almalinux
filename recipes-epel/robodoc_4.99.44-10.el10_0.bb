# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "robodoc"
PV = "4.99.44"
PR = "10.el10_0"
PACKAGES = " \
 robodoc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/robodoc-4.99.44-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e794751e3eed159b6307762ccfe5e060303483e37b5f0a4a3e8e3cd9eab2835b"

URI_x86_64_v2_robodoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/robodoc-4.99.44-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_robodoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_robodoc}"
SRC_URI[x86_64_v2_robodoc.sha256sum] = "e39c63568936e5cef295ba108eae65366c3092594f145bdd2154bc1c5b4ee474"

URI_aarch64_robodoc = "${EPEL_MIRROR}/aarch64/Packages/r/robodoc-4.99.44-10.el10_0.aarch64.rpm;name=aarch64_robodoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_robodoc}"
SRC_URI[aarch64_robodoc.sha256sum] = "70b5b499f6737e20d4de7674228752acddb5ebc39c5a64ce239368a5a24edb2e"

RDEPENDS:robodoc = " \
 glibc \
 "
