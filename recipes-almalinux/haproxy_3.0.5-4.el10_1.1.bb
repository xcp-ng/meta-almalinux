# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "haproxy"
PV = "3.0.5"
PR = "4.el10_1.1"
PACKAGES = " \
 haproxy \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/haproxy-3.0.5-4.el10_1.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9eae7b77e1d01d801f3f245a80289715e22c059f93f13e97bb2175feab1e2d0e"

URI_x86_64_v2_haproxy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/haproxy-3.0.5-4.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_haproxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_haproxy}"
SRC_URI[x86_64_v2_haproxy.sha256sum] = "aa6ad1ed6eaf3c00999c739185390912e2f908541131929be8935399b4beb99c"

URI_aarch64_haproxy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/haproxy-3.0.5-4.el10_1.1.aarch64.rpm;name=aarch64_haproxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_haproxy}"
SRC_URI[aarch64_haproxy.sha256sum] = "6abaa596728d9ef6b180579f67bcd04df8413e9f07cd20fad9fad7c55da1c7b9"

RDEPENDS:haproxy = " \
 bash \
 glibc \
 libxcrypt \
 lua-libs \
 openssl-libs \
 pcre2 \
 shadow-utils \
 systemd \
 "
