# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-strum_macros"
PV = "0.28.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-strum_macros+default-devel \
 rust-strum_macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-strum_macros-0.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "31a4bc060f98132f64e1cf7d8d0e856e5eb95765b9c4be3554ec880c2cbda345"

URI_x86_64_v2_rust-strum_macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum_macros+default-devel-0.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum_macros+default-devel}"
SRC_URI[x86_64_v2_rust-strum_macros+default-devel.sha256sum] = "dea7b60ddf67a1fa497a6d080f7e10d2b1382dc0de48dea3ee26f494a0018106"

URI_x86_64_v2_rust-strum_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum_macros-devel-0.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum_macros-devel}"
SRC_URI[x86_64_v2_rust-strum_macros-devel.sha256sum] = "2956f1f21843cb77559f248af6c8ca9a656327431e43d42bdd3b68eacd2b21b7"

URI_aarch64_rust-strum_macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum_macros+default-devel-0.28.0-1.el10_3.noarch.rpm;name=aarch64_rust-strum_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum_macros+default-devel}"
SRC_URI[aarch64_rust-strum_macros+default-devel.sha256sum] = "6c2836ffcc5a4ef5a3649fdaf4486d53f18d6e731e10c627918cc0d84cf6cc3e"

URI_aarch64_rust-strum_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum_macros-devel-0.28.0-1.el10_3.noarch.rpm;name=aarch64_rust-strum_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum_macros-devel}"
SRC_URI[aarch64_rust-strum_macros-devel.sha256sum] = "221bf9242e36bbf2a9dfe661d2d07a1605c7f417cc2b0ce2f8e56aa921813711"

RDEPENDS:rust-strum_macros+default-devel = " \
 cargo \
 rust-strum_macros-devel \
 "
RDEPENDS:rust-strum_macros-devel = " \
 cargo \
 rust \
 rust-heck+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+parsing-devel \
 "
