# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-lens-family-core"
PV = "2.1.3"
PR = "1.el10_0"
PACKAGES = " \
 ghc-lens-family-core \
 ghc-lens-family-core-devel \
 ghc-lens-family-core-doc \
 ghc-lens-family-core-prof \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/ghc-lens-family-core-2.1.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1549dcc9b587b61224a0206feb5a94d049837127e64753cd22873a6ed9ccb97a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-lens-family-core-2.1.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-lens-family-core;unpack=0"
SRC_URI[x86_64_v2_ghc-lens-family-core.sha256sum] = "9d1a624dac7a40fb0e1618720c075ffa4b366494f19bc2cc1f35c795e917f062"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-lens-family-core-devel-2.1.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-lens-family-core-devel;unpack=0"
SRC_URI[x86_64_v2_ghc-lens-family-core-devel.sha256sum] = "ff3e29b31c56e4e88cc4a11a9850e6365e74b999df6dd6f99f70cc03038d6a73"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-lens-family-core-doc-2.1.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-lens-family-core-doc;unpack=0"
SRC_URI[x86_64_v2_ghc-lens-family-core-doc.sha256sum] = "e8c8c60871051fdc594b6ccaa8bf58762cd8b9dcae36f0b1974ff04165936803"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-lens-family-core-prof-2.1.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-lens-family-core-prof;unpack=0"
SRC_URI[x86_64_v2_ghc-lens-family-core-prof.sha256sum] = "ad31d35032e6c9c5da9c239edde41acdb21e7d09589cd90d2aca774a3dae3f98"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-lens-family-core-2.1.3-1.el10_0.aarch64.rpm;name=aarch64_ghc-lens-family-core;unpack=0"
SRC_URI[aarch64_ghc-lens-family-core.sha256sum] = "45c49970387af4f84c97ba6320bd32df0231b3653e3ac183bd2241366568530d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-lens-family-core-devel-2.1.3-1.el10_0.aarch64.rpm;name=aarch64_ghc-lens-family-core-devel;unpack=0"
SRC_URI[aarch64_ghc-lens-family-core-devel.sha256sum] = "07efb2a026aee02a36a88f192c5047b60f732d14cc88459000ce4ce75c44dc60"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-lens-family-core-doc-2.1.3-1.el10_0.noarch.rpm;name=aarch64_ghc-lens-family-core-doc;unpack=0"
SRC_URI[aarch64_ghc-lens-family-core-doc.sha256sum] = "e1a83d0dde81d3b5816f30d31c61ae89edf3012554d7cbb6f45b105558d871ec"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-lens-family-core-prof-2.1.3-1.el10_0.aarch64.rpm;name=aarch64_ghc-lens-family-core-prof;unpack=0"
SRC_URI[aarch64_ghc-lens-family-core-prof.sha256sum] = "8be5d3c3013fcd9f35d9a4dd387bc9968f07ea5f04968567c0629cca22e828f3"

RDEPENDS:ghc-lens-family-core = " \
 ghc-array \
 ghc-base \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-lens-family-core-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-lens-family-core \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-lens-family-core-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-lens-family-core-prof = " \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-lens-family-core-devel \
 ghc-transformers-prof \
 "
