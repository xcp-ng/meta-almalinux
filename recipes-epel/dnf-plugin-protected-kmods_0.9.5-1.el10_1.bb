# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnf-plugin-protected-kmods"
PV = "0.9.5"
PR = "1.el10_1"
PACKAGES = " \
 python3-dnf-plugin-protected-kmods \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dnf-plugin-protected-kmods-0.9.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8fdbb3a64646dea7e7f34c757bf6ee102c167e15d03acda09d9324709ee1b2b2"

URI_x86_64_v2_python3-dnf-plugin-protected-kmods = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-dnf-plugin-protected-kmods-0.9.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-dnf-plugin-protected-kmods;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dnf-plugin-protected-kmods}"
SRC_URI[x86_64_v2_python3-dnf-plugin-protected-kmods.sha256sum] = "3c466127e2d1de0591f3048c8ac5f5b5b525b26a2fdd09a8a817adb587eec737"

URI_aarch64_python3-dnf-plugin-protected-kmods = "${EPEL_MIRROR}/aarch64/Packages/p/python3-dnf-plugin-protected-kmods-0.9.5-1.el10_1.noarch.rpm;name=aarch64_python3-dnf-plugin-protected-kmods;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dnf-plugin-protected-kmods}"
SRC_URI[aarch64_python3-dnf-plugin-protected-kmods.sha256sum] = "f559bfd90aa633c47d66332298588a6a3b7b1f0f9fc1f50b38bfa42bd7ae04d1"

RDEPENDS:python3-dnf-plugin-protected-kmods = " \
 python3 \
 python3-dnf \
 "
