# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sha1_smol"
PV = "1.0.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-sha1_smol+alloc-devel \
 rust-sha1_smol+default-devel \
 rust-sha1_smol+serde-devel \
 rust-sha1_smol+std-devel \
 rust-sha1_smol-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sha1_smol-1.0.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5999a74465574ab7fffba3065883d76dc9a4d33ec45d1fb1065105d7b3c134e7"

URI_x86_64_v2_rust-sha1_smol+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1_smol+alloc-devel-1.0.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1_smol+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1_smol+alloc-devel}"
SRC_URI[x86_64_v2_rust-sha1_smol+alloc-devel.sha256sum] = "aec7b6672f568fa689b81e7d6287409bf68846969a4c8a66aff4a019dace0b7e"

URI_x86_64_v2_rust-sha1_smol+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1_smol+default-devel-1.0.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1_smol+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1_smol+default-devel}"
SRC_URI[x86_64_v2_rust-sha1_smol+default-devel.sha256sum] = "64b215b4703e7dc1c80c68af6bf83a5989e4618aa4fb382c01df42ff7427df8e"

URI_x86_64_v2_rust-sha1_smol+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1_smol+serde-devel-1.0.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1_smol+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1_smol+serde-devel}"
SRC_URI[x86_64_v2_rust-sha1_smol+serde-devel.sha256sum] = "3a7e5b688f6cba2ba0374a28dd8217fba23030ae2453ea38a8f793ce656925df"

URI_x86_64_v2_rust-sha1_smol+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1_smol+std-devel-1.0.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1_smol+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1_smol+std-devel}"
SRC_URI[x86_64_v2_rust-sha1_smol+std-devel.sha256sum] = "6bd35be21b04c0d0415dec01e68addaba0a6be0246039e1a3471b3ca21570115"

URI_x86_64_v2_rust-sha1_smol-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1_smol-devel-1.0.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1_smol-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1_smol-devel}"
SRC_URI[x86_64_v2_rust-sha1_smol-devel.sha256sum] = "50bc1601d5ad9283235f4d23a746e2ba872026f95f4161bf421f3d7551d228cf"

URI_aarch64_rust-sha1_smol+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1_smol+alloc-devel-1.0.1-2.el10_0.noarch.rpm;name=aarch64_rust-sha1_smol+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1_smol+alloc-devel}"
SRC_URI[aarch64_rust-sha1_smol+alloc-devel.sha256sum] = "c68b0ba6baf91e8c02e68a8c3ae96df2bd057addd7a2a2baedbfa6ce0debfeec"

URI_aarch64_rust-sha1_smol+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1_smol+default-devel-1.0.1-2.el10_0.noarch.rpm;name=aarch64_rust-sha1_smol+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1_smol+default-devel}"
SRC_URI[aarch64_rust-sha1_smol+default-devel.sha256sum] = "faf2453287dfd16a76533d46bd8593e2355202d105bbf871adb235fdefed431b"

URI_aarch64_rust-sha1_smol+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1_smol+serde-devel-1.0.1-2.el10_0.noarch.rpm;name=aarch64_rust-sha1_smol+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1_smol+serde-devel}"
SRC_URI[aarch64_rust-sha1_smol+serde-devel.sha256sum] = "5355eb45898afa18acf96dafa1d5fa4baea7bdc1fd80fc7975e70338ff5a82e5"

URI_aarch64_rust-sha1_smol+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1_smol+std-devel-1.0.1-2.el10_0.noarch.rpm;name=aarch64_rust-sha1_smol+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1_smol+std-devel}"
SRC_URI[aarch64_rust-sha1_smol+std-devel.sha256sum] = "806f05556cbd156d9dc823846d88edaab68de40fd34138961c8db8f3fc023f49"

URI_aarch64_rust-sha1_smol-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1_smol-devel-1.0.1-2.el10_0.noarch.rpm;name=aarch64_rust-sha1_smol-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1_smol-devel}"
SRC_URI[aarch64_rust-sha1_smol-devel.sha256sum] = "ae5260a510e7fc12265373de50f385c1710e4018c363c02936671c6c22def755"

RDEPENDS:rust-sha1_smol+alloc-devel = " \
 cargo \
 rust-sha1_smol-devel \
 "
RDEPENDS:rust-sha1_smol+default-devel = " \
 cargo \
 rust-sha1_smol-devel \
 "
RDEPENDS:rust-sha1_smol+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-sha1_smol-devel \
 "
RDEPENDS:rust-sha1_smol+std-devel = " \
 cargo \
 rust-sha1_smol+alloc-devel \
 rust-sha1_smol-devel \
 "
RDEPENDS:rust-sha1_smol-devel = " \
 cargo \
 "
