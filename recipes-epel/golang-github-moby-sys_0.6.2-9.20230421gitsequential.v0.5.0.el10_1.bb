# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-moby-sys"
PV = "0.6.2"
PR = "9.20230421gitsequential.v0.5.0.el10_1"
PACKAGES = " \
 golang-github-moby-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-moby-sys-0.6.2-9.20230421gitsequential.v0.5.0.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c0a317f73f26e395ebd43d5314b30c26a11546701687c3dd6f0aa22dcb0e3b4"

URI_aarch64_golang-github-moby-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-moby-sys-devel-0.6.2-9.20230421gitsequential.v0.5.0.el10_1.noarch.rpm;name=aarch64_golang-github-moby-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-moby-sys-devel}"
SRC_URI[aarch64_golang-github-moby-sys-devel.sha256sum] = "56a05d3f192784de7ef1c47a6efd09817e80aac5beb846a3e546934deb9ac463"

RDEPENDS:golang-github-moby-sys-devel = " \
 go-filesystem \
 golang-x-sys-devel \
 "
