# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-signal-hook0.1"
PV = "0.1.17"
PR = "15.el10_2"
PACKAGES = " \
 rust-signal-hook0.1+default-devel \
 rust-signal-hook0.1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-signal-hook0.1-0.1.17-15.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6bdc7e709d885d0faa927dbd695224fb246d2d635bf34eb3eb5e320f0223918f"

URI_x86_64_v2_rust-signal-hook0.1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook0.1+default-devel-0.1.17-15.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook0.1+default-devel}"
SRC_URI[x86_64_v2_rust-signal-hook0.1+default-devel.sha256sum] = "9441121a26dfd55ef41c582f8e0c5de8275b2522fbae7c0cc307dd69555e68b3"

URI_x86_64_v2_rust-signal-hook0.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook0.1-devel-0.1.17-15.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook0.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook0.1-devel}"
SRC_URI[x86_64_v2_rust-signal-hook0.1-devel.sha256sum] = "79c5183b991f26265bf0962bcf6c49ca24bd018688fecd740011839c9bb95eed"

URI_aarch64_rust-signal-hook0.1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook0.1+default-devel-0.1.17-15.el10_2.noarch.rpm;name=aarch64_rust-signal-hook0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook0.1+default-devel}"
SRC_URI[aarch64_rust-signal-hook0.1+default-devel.sha256sum] = "70ae58ebdf408e2ec7732ad58923af8c99072c53b42c18ff5c127c03df1bed95"

URI_aarch64_rust-signal-hook0.1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook0.1-devel-0.1.17-15.el10_2.noarch.rpm;name=aarch64_rust-signal-hook0.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook0.1-devel}"
SRC_URI[aarch64_rust-signal-hook0.1-devel.sha256sum] = "0da4e94111a437265c4ffb27ca86009d59c2b38122ef9f801e3ab60281152eee"

RDEPENDS:rust-signal-hook0.1+default-devel = " \
 cargo \
 rust-signal-hook0.1-devel \
 "
RDEPENDS:rust-signal-hook0.1-devel = " \
 bash \
 cargo \
 rust-libc+default-devel \
 rust-signal-hook-registry+default-devel \
 "
