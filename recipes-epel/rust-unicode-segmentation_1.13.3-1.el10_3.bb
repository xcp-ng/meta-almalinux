# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unicode-segmentation"
PV = "1.13.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-unicode-segmentation+default-devel \
 rust-unicode-segmentation+no_std-devel \
 rust-unicode-segmentation-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unicode-segmentation-1.13.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "060fd49cf98e0998e006e2683195dc6df9f23406b92289d270a5be58d8f9a398"

URI_x86_64_v2_rust-unicode-segmentation+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-segmentation+default-devel-1.13.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-segmentation+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-segmentation+default-devel}"
SRC_URI[x86_64_v2_rust-unicode-segmentation+default-devel.sha256sum] = "e05a6243c2ba090a3d29201ce46cf1bacd3f209caa7ced33bf9d8a14044a67be"

URI_x86_64_v2_rust-unicode-segmentation+no_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-segmentation+no_std-devel-1.13.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-segmentation+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-segmentation+no_std-devel}"
SRC_URI[x86_64_v2_rust-unicode-segmentation+no_std-devel.sha256sum] = "4dd5ac02d40a3677826ea585b417bcc5838949f0ec3b48abbacd5bed16c4fef5"

URI_x86_64_v2_rust-unicode-segmentation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-segmentation-devel-1.13.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-segmentation-devel}"
SRC_URI[x86_64_v2_rust-unicode-segmentation-devel.sha256sum] = "1c154977f2952cfe90d7ccdbe54566761d7a3147f96115886b0c94ddd64bcae4"

URI_aarch64_rust-unicode-segmentation+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-segmentation+default-devel-1.13.3-1.el10_3.noarch.rpm;name=aarch64_rust-unicode-segmentation+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-segmentation+default-devel}"
SRC_URI[aarch64_rust-unicode-segmentation+default-devel.sha256sum] = "c1d394553d79a7149837177eabffb533ece08d8a77ced29ba20fd0dacd24a12b"

URI_aarch64_rust-unicode-segmentation+no_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-segmentation+no_std-devel-1.13.3-1.el10_3.noarch.rpm;name=aarch64_rust-unicode-segmentation+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-segmentation+no_std-devel}"
SRC_URI[aarch64_rust-unicode-segmentation+no_std-devel.sha256sum] = "8c428f3f4dd7801236a1708c37c770cf7a30706ddc4f7a1a9c255db9d9138e8f"

URI_aarch64_rust-unicode-segmentation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-segmentation-devel-1.13.3-1.el10_3.noarch.rpm;name=aarch64_rust-unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-segmentation-devel}"
SRC_URI[aarch64_rust-unicode-segmentation-devel.sha256sum] = "d416873ad28791525892ad89f6ade9fcd983670737fcab4140487d6d4dda0dad"

RDEPENDS:rust-unicode-segmentation+default-devel = " \
 cargo \
 rust-unicode-segmentation-devel \
 "
RDEPENDS:rust-unicode-segmentation+no_std-devel = " \
 cargo \
 rust-unicode-segmentation-devel \
 "
RDEPENDS:rust-unicode-segmentation-devel = " \
 cargo \
 rust \
 "
