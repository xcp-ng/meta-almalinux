# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_time"
PV = "2.2.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-icu_time+alloc-devel \
 rust-icu_time+compiled_data-devel \
 rust-icu_time+datagen-devel \
 rust-icu_time+default-devel \
 rust-icu_time+ixdtf-devel \
 rust-icu_time+serde-devel \
 rust-icu_time+unstable-devel \
 rust-icu_time+unstable_chrono_0_4-devel \
 rust-icu_time+unstable_jiff_0_2-devel \
 rust-icu_time+unstable_time_0_3-devel \
 rust-icu_time-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_time-2.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90d397f3ce9c036ddc3bf4c756a7016f963b0c24742265259f2f88a3b40a8369"

URI_x86_64_v2_rust-icu_time+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_time+alloc-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_time+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_time+alloc-devel}"
SRC_URI[x86_64_v2_rust-icu_time+alloc-devel.sha256sum] = "40cbc4a68a3f2ef1e651e1b0090fec0587efdf31b6ede42daf3a83e1e58e5422"

URI_x86_64_v2_rust-icu_time+compiled_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_time+compiled_data-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_time+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_time+compiled_data-devel}"
SRC_URI[x86_64_v2_rust-icu_time+compiled_data-devel.sha256sum] = "84fefa042d12068c13b9f77eac834c97be58feed436163705afa482faa50166b"

URI_x86_64_v2_rust-icu_time+datagen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_time+datagen-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_time+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_time+datagen-devel}"
SRC_URI[x86_64_v2_rust-icu_time+datagen-devel.sha256sum] = "d9361effb1f55e803551b1ac7a49a046d70223714b2e19a62e63dc78bd5ffb84"

URI_x86_64_v2_rust-icu_time+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_time+default-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_time+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_time+default-devel}"
SRC_URI[x86_64_v2_rust-icu_time+default-devel.sha256sum] = "fa3d8b6f6eb3af7c86548c47843ba42e317cd326fac982fda260f969f887b7d6"

URI_x86_64_v2_rust-icu_time+ixdtf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_time+ixdtf-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_time+ixdtf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_time+ixdtf-devel}"
SRC_URI[x86_64_v2_rust-icu_time+ixdtf-devel.sha256sum] = "77c07b3c4263f215b1c32b0d28f7e2e0732e5d3a740645ba972841d83234209d"

URI_x86_64_v2_rust-icu_time+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_time+serde-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_time+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_time+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_time+serde-devel.sha256sum] = "60463d2deff74276580467ff423dabef7e7cc21444ca66d644aad44e12a8976e"

URI_x86_64_v2_rust-icu_time+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_time+unstable-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_time+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_time+unstable-devel}"
SRC_URI[x86_64_v2_rust-icu_time+unstable-devel.sha256sum] = "7f9ecaab76211f6d470cfc428a3f7036ef84a4d58143ab6355bb48d9a803d151"

URI_x86_64_v2_rust-icu_time+unstable_chrono_0_4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_time+unstable_chrono_0_4-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_time+unstable_chrono_0_4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_time+unstable_chrono_0_4-devel}"
SRC_URI[x86_64_v2_rust-icu_time+unstable_chrono_0_4-devel.sha256sum] = "7d2f70479910460ceae8d1c8bfc4d1b76620032f07ff7d75ab0f2433bdb03b3d"

URI_x86_64_v2_rust-icu_time+unstable_jiff_0_2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_time+unstable_jiff_0_2-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_time+unstable_jiff_0_2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_time+unstable_jiff_0_2-devel}"
SRC_URI[x86_64_v2_rust-icu_time+unstable_jiff_0_2-devel.sha256sum] = "45a6bb9b494e95b2c72742d165c6941680e481e6f8c18da84bdd2560692116ca"

URI_x86_64_v2_rust-icu_time+unstable_time_0_3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_time+unstable_time_0_3-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_time+unstable_time_0_3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_time+unstable_time_0_3-devel}"
SRC_URI[x86_64_v2_rust-icu_time+unstable_time_0_3-devel.sha256sum] = "95c4ff86e594018751f87959dea5feb568e5a979ea750008dc15e4cc0546760c"

URI_x86_64_v2_rust-icu_time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_time-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_time-devel}"
SRC_URI[x86_64_v2_rust-icu_time-devel.sha256sum] = "8fbde94e55e04e7b465bcbd6b239b2a62e564784b90a73d5463c3139dabab6b1"

URI_aarch64_rust-icu_time+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_time+alloc-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_time+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_time+alloc-devel}"
SRC_URI[aarch64_rust-icu_time+alloc-devel.sha256sum] = "25a44e96e9f022499490650a503a0d437a7ef577494ecc75eb0d0f571a8c7dd1"

URI_aarch64_rust-icu_time+compiled_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_time+compiled_data-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_time+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_time+compiled_data-devel}"
SRC_URI[aarch64_rust-icu_time+compiled_data-devel.sha256sum] = "144e0b812707d87e8bc44adaf6ede96f45024eb1441d4116817a50a03b8ca12d"

URI_aarch64_rust-icu_time+datagen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_time+datagen-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_time+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_time+datagen-devel}"
SRC_URI[aarch64_rust-icu_time+datagen-devel.sha256sum] = "247b979081da759fa3b1c1c63c8ff9608f890e12b0f8e5a1df09e3dea8d6b926"

URI_aarch64_rust-icu_time+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_time+default-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_time+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_time+default-devel}"
SRC_URI[aarch64_rust-icu_time+default-devel.sha256sum] = "4359e6ecf67613715b383e80838ea852c81e0e4622bc022e0ff4cd1851cc7656"

URI_aarch64_rust-icu_time+ixdtf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_time+ixdtf-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_time+ixdtf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_time+ixdtf-devel}"
SRC_URI[aarch64_rust-icu_time+ixdtf-devel.sha256sum] = "96754a75f17b63311530f2dd12ae8c05667bcf77d24a0befe431c99fe934a4f5"

URI_aarch64_rust-icu_time+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_time+serde-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_time+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_time+serde-devel}"
SRC_URI[aarch64_rust-icu_time+serde-devel.sha256sum] = "5374a7c82dd41c7a59c1238f43cddc5161bde27e260d9bda5ffd8c844530e5bd"

URI_aarch64_rust-icu_time+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_time+unstable-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_time+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_time+unstable-devel}"
SRC_URI[aarch64_rust-icu_time+unstable-devel.sha256sum] = "180bbefea718672257940382e5429a17b4974f926bad51d8c845b1d8f88758f5"

URI_aarch64_rust-icu_time+unstable_chrono_0_4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_time+unstable_chrono_0_4-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_time+unstable_chrono_0_4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_time+unstable_chrono_0_4-devel}"
SRC_URI[aarch64_rust-icu_time+unstable_chrono_0_4-devel.sha256sum] = "3812a62d4ae3618e6f47626a167e3873323110d0ffb96c8287134cfb856a8dbd"

URI_aarch64_rust-icu_time+unstable_jiff_0_2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_time+unstable_jiff_0_2-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_time+unstable_jiff_0_2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_time+unstable_jiff_0_2-devel}"
SRC_URI[aarch64_rust-icu_time+unstable_jiff_0_2-devel.sha256sum] = "7d82f9e8511f70dd016cfd58d3a135037280881126cb0d6fd2982486f009e803"

URI_aarch64_rust-icu_time+unstable_time_0_3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_time+unstable_time_0_3-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_time+unstable_time_0_3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_time+unstable_time_0_3-devel}"
SRC_URI[aarch64_rust-icu_time+unstable_time_0_3-devel.sha256sum] = "1ad4b1befb2c4429b28b4e07ee497c806480e8c5088f9ebc49e227ef44ac19b7"

URI_aarch64_rust-icu_time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_time-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_time-devel}"
SRC_URI[aarch64_rust-icu_time-devel.sha256sum] = "e5512273d11fd00862129a1556fce7733faebb42eb50d27af4008d01da690741"

RDEPENDS:rust-icu_time+alloc-devel = " \
 cargo \
 rust-icu_time-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerotrie+alloc-devel \
 rust-zerovec+alloc-devel \
 "
RDEPENDS:rust-icu_time+compiled_data-devel = " \
 cargo \
 rust-icu_calendar+compiled_data-devel \
 rust-icu_provider+baked-devel \
 rust-icu_time-devel \
 rust-icu_time_data-devel \
 "
RDEPENDS:rust-icu_time+datagen-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-icu_locale_core+databake-devel \
 rust-icu_provider+export-devel \
 rust-icu_time+alloc-devel \
 rust-icu_time+serde-devel \
 rust-icu_time-devel \
 rust-zerotrie+databake-devel \
 rust-zerovec+databake-devel \
 "
RDEPENDS:rust-icu_time+default-devel = " \
 cargo \
 rust-icu_time+compiled_data-devel \
 rust-icu_time+ixdtf-devel \
 rust-icu_time-devel \
 "
RDEPENDS:rust-icu_time+ixdtf-devel = " \
 cargo \
 rust-icu_calendar+ixdtf-devel \
 rust-icu_time-devel \
 rust-ixdtf-devel \
 "
RDEPENDS:rust-icu_time+serde-devel = " \
 cargo \
 rust-icu_locale_core+serde-devel \
 rust-icu_provider+serde-devel \
 rust-icu_time+alloc-devel \
 rust-icu_time-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerotrie+serde-devel \
 rust-zerovec+serde-devel \
 "
RDEPENDS:rust-icu_time+unstable-devel = " \
 cargo \
 rust-icu_time-devel \
 "
RDEPENDS:rust-icu_time+unstable_chrono_0_4-devel = " \
 cargo \
 rust-chrono-devel \
 rust-chrono-tz-devel \
 rust-icu_calendar+unstable_chrono_0_4-devel \
 rust-icu_time-devel \
 "
RDEPENDS:rust-icu_time+unstable_jiff_0_2-devel = " \
 cargo \
 rust-icu_calendar+unstable_jiff_0_2-devel \
 rust-icu_time-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-icu_time+unstable_time_0_3-devel = " \
 cargo \
 rust-icu_calendar+unstable_time_0_3-devel \
 rust-icu_time-devel \
 rust-time-devel \
 "
RDEPENDS:rust-icu_time-devel = " \
 cargo \
 rust \
 rust-calendrical_calculations-devel \
 rust-displaydoc-devel \
 rust-icu_calendar-devel \
 rust-icu_locale_core+zerovec-devel \
 rust-icu_locale_core-devel \
 rust-icu_provider-devel \
 rust-zerotrie+yoke-devel \
 rust-zerotrie+zerofrom-devel \
 rust-zerotrie-devel \
 rust-zerovec+derive-devel \
 rust-zerovec+yoke-devel \
 rust-zerovec-devel \
 "
