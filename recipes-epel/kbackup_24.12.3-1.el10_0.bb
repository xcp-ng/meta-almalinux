# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kbackup"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kbackup \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kbackup-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6c9a39417a6aeaae3fb0db58b04494b0cd8b4ed067bfc867502dcf94d6b29f1"

URI_x86_64_v2_kbackup = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kbackup-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kbackup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kbackup}"
SRC_URI[x86_64_v2_kbackup.sha256sum] = "45f0c81b0cf951b9b667b46c8a3fc00665f806411512c6d3587cf6a38aa54679"

URI_aarch64_kbackup = "${EPEL_MIRROR}/aarch64/Packages/k/kbackup-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kbackup;unpack=0"
SRC_URI:append = " ${URI_aarch64_kbackup}"
SRC_URI[aarch64_kbackup.sha256sum] = "bfde0dd1f6d600fcc17f98002a4d5dadbfa7b89ab565b48fa00dd031adb42912"

RDEPENDS:kbackup = " \
 glibc \
 hicolor-icon-theme \
 kf6-karchive \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libarchive \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
