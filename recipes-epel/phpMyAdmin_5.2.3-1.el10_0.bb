# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "phpMyAdmin"
PV = "5.2.3"
PR = "1.el10_0"
PACKAGES = " \
 phpMyAdmin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/phpMyAdmin-5.2.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "46a034387269169c77febb1341124102cd4cd79623bef1796dfee09942f7d8c0"

URI_x86_64_v2_phpMyAdmin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/phpMyAdmin-5.2.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_phpMyAdmin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_phpMyAdmin}"
SRC_URI[x86_64_v2_phpMyAdmin.sha256sum] = "8f08e1047883d8cf33b6a9ca3b34e3f360a80db3927c22ccca7ee8f1613ed4eb"

URI_aarch64_phpMyAdmin = "${EPEL_MIRROR}/aarch64/Packages/p/phpMyAdmin-5.2.3-1.el10_0.noarch.rpm;name=aarch64_phpMyAdmin;unpack=0"
SRC_URI:append = " ${URI_aarch64_phpMyAdmin}"
SRC_URI[aarch64_phpMyAdmin.sha256sum] = "1ce86acec909843136d9a9a57030d9febfce26c94c8024953dad18b715342f34"

RDEPENDS:phpMyAdmin = " \
 bash \
 ca-certificates \
 httpd-filesystem \
 nginx-filesystem \
 php-common \
 php-fpm \
 php-gd \
 php-intl \
 php-mbstring \
 php-mysqlnd \
 php-pecl-zip \
 php-process \
 php-xml \
 sed \
 virtual/coreutils \
 virtual/webserver \
 "
