# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ctrlc"
PV = "3.5.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-ctrlc+default-devel \
 rust-ctrlc+termination-devel \
 rust-ctrlc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ctrlc-3.5.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "76e109e5e6aa9ff4236188e3474d2710c37f1adb5802caaa20c222bad8ec69eb"

URI_x86_64_v2_rust-ctrlc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctrlc+default-devel-3.5.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctrlc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ctrlc+default-devel}"
SRC_URI[x86_64_v2_rust-ctrlc+default-devel.sha256sum] = "4739a32422a55228ab613b8319ee6ac1f5b50e86167289a76e081aa9a8ecb154"

URI_x86_64_v2_rust-ctrlc+termination-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctrlc+termination-devel-3.5.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctrlc+termination-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ctrlc+termination-devel}"
SRC_URI[x86_64_v2_rust-ctrlc+termination-devel.sha256sum] = "dfb3ade17c29680524bd1679f8d9ef44a67337ccd2ecd8ba0436ed12a7da3618"

URI_x86_64_v2_rust-ctrlc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctrlc-devel-3.5.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctrlc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ctrlc-devel}"
SRC_URI[x86_64_v2_rust-ctrlc-devel.sha256sum] = "d544470cee7d208b3e8adb6232c3bd14626b9028690679318505dc7d7e7e7be4"

URI_aarch64_rust-ctrlc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ctrlc+default-devel-3.5.1-1.el10_1.noarch.rpm;name=aarch64_rust-ctrlc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ctrlc+default-devel}"
SRC_URI[aarch64_rust-ctrlc+default-devel.sha256sum] = "4f17849c8408988f7e83fcc59c0521888339ff6377b6e3262e4799e06087e640"

URI_aarch64_rust-ctrlc+termination-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ctrlc+termination-devel-3.5.1-1.el10_1.noarch.rpm;name=aarch64_rust-ctrlc+termination-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ctrlc+termination-devel}"
SRC_URI[aarch64_rust-ctrlc+termination-devel.sha256sum] = "000a018e1a6e4b3eb00ad8d1f1a3848a6adccc4c483b03bcbad7e24bf2a8f2a8"

URI_aarch64_rust-ctrlc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ctrlc-devel-3.5.1-1.el10_1.noarch.rpm;name=aarch64_rust-ctrlc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ctrlc-devel}"
SRC_URI[aarch64_rust-ctrlc-devel.sha256sum] = "0f3177e19bc3ba8c3cbd14d0b929f2e828906c3d39e1c1dd70e2aba4fa313a41"

RDEPENDS:rust-ctrlc+default-devel = " \
 cargo \
 rust-ctrlc-devel \
 "
RDEPENDS:rust-ctrlc+termination-devel = " \
 cargo \
 rust-ctrlc-devel \
 "
RDEPENDS:rust-ctrlc-devel = " \
 cargo \
 rust \
 rust-nix+signal-devel \
 rust-nix-devel \
 "
