# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-damo"
PV = "2.9.0"
PR = "1.el10_1"
PACKAGES = " \
 damo \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-damo-2.9.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "377049eeb34a24b4bf6a38203fba989e1db082e40e93c005d110b1d5efc48a7a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/damo-2.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_damo;unpack=0"
SRC_URI[x86_64_v2_damo.sha256sum] = "8d9d626001ed43c2db44444ef01f279152d574acfd348442044809251fdd89eb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/damo-2.9.0-1.el10_1.noarch.rpm;name=aarch64_damo;unpack=0"
SRC_URI[aarch64_damo.sha256sum] = "e7103d73ef3adec40e83005aba983e00b20e1fd029d7ed62176c13cc5e79286a"

RDEPENDS:damo = " \
 python3 \
 "
