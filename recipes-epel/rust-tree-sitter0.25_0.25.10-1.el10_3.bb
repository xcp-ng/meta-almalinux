# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter0.25"
PV = "0.25.10"
PR = "1.el10_3"
PACKAGES = " \
 rust-tree-sitter0.25+default-devel \
 rust-tree-sitter0.25+std-devel \
 rust-tree-sitter0.25-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter0.25-0.25.10-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d6bee5502ef6b92c19d4e8f255c12424066a9ac14394aef795a5df5aad28a8e"

URI_x86_64_v2_rust-tree-sitter0.25+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter0.25+default-devel-0.25.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter0.25+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter0.25+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter0.25+default-devel.sha256sum] = "35268bd2ef2c238c61f7682dfdf7eef305103968208f3cd32d348d4d8d3b2dfc"

URI_x86_64_v2_rust-tree-sitter0.25+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter0.25+std-devel-0.25.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter0.25+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter0.25+std-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter0.25+std-devel.sha256sum] = "c6b043ddfbf9899cb48331633872782f8a78cc37b6bc463c36c83b4787bdf6ea"

URI_x86_64_v2_rust-tree-sitter0.25-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter0.25-devel-0.25.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter0.25-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter0.25-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter0.25-devel.sha256sum] = "e61ec9fa76fd394fe1874bcfb715c4ea8d9c01b4a0f8eb1588a561e76e459470"

URI_aarch64_rust-tree-sitter0.25+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter0.25+default-devel-0.25.10-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter0.25+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter0.25+default-devel}"
SRC_URI[aarch64_rust-tree-sitter0.25+default-devel.sha256sum] = "d3213d40e9fc6cba6d368513f659c99d97dc00745e8043acef13ddad7768c555"

URI_aarch64_rust-tree-sitter0.25+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter0.25+std-devel-0.25.10-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter0.25+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter0.25+std-devel}"
SRC_URI[aarch64_rust-tree-sitter0.25+std-devel.sha256sum] = "a09b54e15f693a3f53040f598a57c8575858c91fbd079b911e761d8f089d599e"

URI_aarch64_rust-tree-sitter0.25-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter0.25-devel-0.25.10-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter0.25-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter0.25-devel}"
SRC_URI[aarch64_rust-tree-sitter0.25-devel.sha256sum] = "94f28b28879e89f954957ceda91fe2ada748f8fce9972f345c2fbf437f0b8492"

RDEPENDS:rust-tree-sitter0.25+default-devel = " \
 cargo \
 rust-tree-sitter0.25+std-devel \
 rust-tree-sitter0.25-devel \
 "
RDEPENDS:rust-tree-sitter0.25+std-devel = " \
 cargo \
 rust-regex+perf-devel \
 rust-regex+std-devel \
 rust-regex-syntax+unicode-devel \
 rust-tree-sitter0.25-devel \
 "
RDEPENDS:rust-tree-sitter0.25-devel = " \
 cargo \
 rust \
 rust-bindgen+default-devel \
 rust-cc+default-devel \
 rust-regex+unicode-devel \
 rust-regex-devel \
 rust-regex-syntax-devel \
 rust-serde_json+default-devel \
 rust-serde_json+preserve_order-devel \
 rust-streaming-iterator+default-devel \
 rust-tree-sitter-language+default-devel \
 "
