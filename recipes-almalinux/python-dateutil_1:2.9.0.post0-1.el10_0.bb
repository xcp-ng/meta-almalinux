# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-dateutil"
PE = "1"
PV = "2.9.0.post0"
PR = "1.el10_0"
PACKAGES = " \
 python-dateutil-doc \
 python3-dateutil \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python-dateutil-2.9.0.post0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ee112f4a35d8b790dfa58520bf01bf43c197814e46d538b7a57a139fe3c44a7"

URI_x86_64_v2_python-dateutil-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python-dateutil-doc-2.9.0.post0-1.el10_0.noarch.rpm;name=x86_64_v2_python-dateutil-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-dateutil-doc}"
SRC_URI[x86_64_v2_python-dateutil-doc.sha256sum] = "796ef12a8ad7d73633a9aa3e6d568310d809ebb3858fa6f3e226e98fa85908b1"

URI_x86_64_v2_python3-dateutil = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-dateutil-2.9.0.post0-1.el10_0.noarch.rpm;name=x86_64_v2_python3-dateutil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dateutil}"
SRC_URI[x86_64_v2_python3-dateutil.sha256sum] = "413ef82c586930a630f04ecd4f19416b4e48a677db2ff3b3fe3ca35a0353b5e4"

URI_aarch64_python-dateutil-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python-dateutil-doc-2.9.0.post0-1.el10_0.noarch.rpm;name=aarch64_python-dateutil-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-dateutil-doc}"
SRC_URI[aarch64_python-dateutil-doc.sha256sum] = "796ef12a8ad7d73633a9aa3e6d568310d809ebb3858fa6f3e226e98fa85908b1"

URI_aarch64_python3-dateutil = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-dateutil-2.9.0.post0-1.el10_0.noarch.rpm;name=aarch64_python3-dateutil;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dateutil}"
SRC_URI[aarch64_python3-dateutil.sha256sum] = "413ef82c586930a630f04ecd4f19416b4e48a677db2ff3b3fe3ca35a0353b5e4"

RDEPENDS:python-dateutil-doc = " \
 "
RDEPENDS:python3-dateutil = " \
 python3 \
 python3-six \
 tzdata \
 "
