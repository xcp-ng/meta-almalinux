# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gtk4"
PV = "4.16.7"
PR = "6.el10"
PACKAGES = " \
 gtk4 \
 gtk4-devel \
 gtk4-devel-docs \
 gtk4-devel-tools \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gtk4-4.16.7-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d829fc9c75daa85f911031a6fafccdb8e86772bc465b80de882c79f89f85dd56"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gtk4-4.16.7-6.el10.x86_64_v2.rpm;name=x86_64_v2_gtk4;unpack=0"
SRC_URI[x86_64_v2_gtk4.sha256sum] = "a671c1318be92c2572901180aadaf79122ea84414bb0f5f3f732b13569f27f78"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gtk4-devel-4.16.7-6.el10.x86_64_v2.rpm;name=x86_64_v2_gtk4-devel;unpack=0"
SRC_URI[x86_64_v2_gtk4-devel.sha256sum] = "dc22b2ad02f4e0192a1ddc300c373821b6d91f60f9f17d709307d4c1800c54f2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gtk4-devel-docs-4.16.7-6.el10.noarch.rpm;name=x86_64_v2_gtk4-devel-docs;unpack=0"
SRC_URI[x86_64_v2_gtk4-devel-docs.sha256sum] = "597d878b742d2accda5bb8716b20221df11bb55b6192471501914f0985549bb4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gtk4-devel-tools-4.16.7-6.el10.x86_64_v2.rpm;name=x86_64_v2_gtk4-devel-tools;unpack=0"
SRC_URI[x86_64_v2_gtk4-devel-tools.sha256sum] = "1f197a4f5aa15dd8554b61b0f8a7357a1b39d91455ac146f645ca424b90e5370"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gtk4-4.16.7-6.el10.aarch64.rpm;name=aarch64_gtk4;unpack=0"
SRC_URI[aarch64_gtk4.sha256sum] = "ada79e63d881949e0d9ee5ec45a1ce146588284c73a8b5d3e128921901a6a089"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gtk4-devel-4.16.7-6.el10.aarch64.rpm;name=aarch64_gtk4-devel;unpack=0"
SRC_URI[aarch64_gtk4-devel.sha256sum] = "5b5d399a45924a9bf26cf35d76c5e0b691ad58d78a106f9af10b3a6933069306"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gtk4-devel-docs-4.16.7-6.el10.noarch.rpm;name=aarch64_gtk4-devel-docs;unpack=0"
SRC_URI[aarch64_gtk4-devel-docs.sha256sum] = "597d878b742d2accda5bb8716b20221df11bb55b6192471501914f0985549bb4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gtk4-devel-tools-4.16.7-6.el10.aarch64.rpm;name=aarch64_gtk4-devel-tools;unpack=0"
SRC_URI[aarch64_gtk4-devel-tools.sha256sum] = "c18898ea04b67e32710bffbcb3c86731aaf31ac9b8d4360e64da90f27deabb1e"

RDEPENDS:gtk4 = " \
 adwaita-icon-theme \
 cairo \
 cairo-gobject \
 colord-libs \
 cups-libs \
 fontconfig \
 fribidi \
 gdk-pixbuf2 \
 gdk-pixbuf2-modules \
 glib2 \
 glibc \
 graphene \
 gstreamer1 \
 gstreamer1-plugins-bad-free-libs \
 gstreamer1-plugins-base \
 gtk-update-icon-cache \
 harfbuzz \
 hicolor-icon-theme \
 libX11 \
 libXcursor \
 libXdamage \
 libXext \
 libXfixes \
 libXi \
 libXinerama \
 libXrandr \
 libepoxy \
 libjpeg-turbo \
 libpng \
 libtiff \
 libtracker-sparql \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 libxkbcommon \
 pango \
 vulkan-loader \
 "
RDEPENDS:gtk4-devel = " \
 cairo \
 cairo-devel \
 cairo-gobject \
 cairo-gobject-devel \
 fontconfig \
 fribidi \
 gdk-pixbuf2 \
 gdk-pixbuf2-devel \
 glib2 \
 glib2-devel \
 glibc \
 graphene \
 graphene-devel \
 gtk4 \
 gtk4-devel \
 harfbuzz \
 libX11 \
 libX11-devel \
 libXcursor \
 libXdamage \
 libXext \
 libXfixes \
 libXi \
 libXinerama \
 libXrandr \
 libepoxy \
 libjpeg-turbo \
 libpng \
 libtiff \
 libtracker-sparql \
 libwayland-client \
 libwayland-egl \
 libxkbcommon \
 pango \
 pango-devel \
 pkgconf-pkg-config \
 vulkan-loader \
 vulkan-loader-devel \
 wayland-devel \
 "
RDEPENDS:gtk4-devel-docs = " \
 gtk4 \
 "
RDEPENDS:gtk4-devel-tools = " \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 graphene \
 gtk4 \
 harfbuzz \
 libepoxy \
 pango \
 "
