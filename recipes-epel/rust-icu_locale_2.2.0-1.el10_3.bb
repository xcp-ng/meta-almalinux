# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_locale"
PV = "2.2.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-icu_locale+compiled_data-devel \
 rust-icu_locale+datagen-devel \
 rust-icu_locale+default-devel \
 rust-icu_locale+serde-devel \
 rust-icu_locale-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_locale-2.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cd0b541594ea0710d20d3af60217ad73a9bd843df61e43a700a0911681c5e2c3"

URI_x86_64_v2_rust-icu_locale+compiled_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locale+compiled_data-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locale+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locale+compiled_data-devel}"
SRC_URI[x86_64_v2_rust-icu_locale+compiled_data-devel.sha256sum] = "1824de3eaf855b168a932c223d00d113aa9b094419cf03723f5caf3d83322a3f"

URI_x86_64_v2_rust-icu_locale+datagen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locale+datagen-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locale+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locale+datagen-devel}"
SRC_URI[x86_64_v2_rust-icu_locale+datagen-devel.sha256sum] = "feab87b57cc00376f95020d0cd162ac2ed34d12f75091dd0670f96d36d1356dd"

URI_x86_64_v2_rust-icu_locale+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locale+default-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locale+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locale+default-devel}"
SRC_URI[x86_64_v2_rust-icu_locale+default-devel.sha256sum] = "88f70074cb37bf53cd4fa0f4f6cc3695fbd8ac3d0d0c00c7cee923b308077927"

URI_x86_64_v2_rust-icu_locale+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locale+serde-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locale+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locale+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_locale+serde-devel.sha256sum] = "ef798e9c7552d04a60cb6b1921b8279ff2d787e273fb9f40d49eb91ae6bbb27c"

URI_x86_64_v2_rust-icu_locale-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locale-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locale-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locale-devel}"
SRC_URI[x86_64_v2_rust-icu_locale-devel.sha256sum] = "6faaa9e2e48cedbc878ba62086990cc3c53837c9660185c12405933a008a86ff"

URI_aarch64_rust-icu_locale+compiled_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locale+compiled_data-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_locale+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locale+compiled_data-devel}"
SRC_URI[aarch64_rust-icu_locale+compiled_data-devel.sha256sum] = "1ad4657cb00666ecc9d462ea96621fa2bd79de64c797b9e1ae9feafd114b06a1"

URI_aarch64_rust-icu_locale+datagen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locale+datagen-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_locale+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locale+datagen-devel}"
SRC_URI[aarch64_rust-icu_locale+datagen-devel.sha256sum] = "a1208dc8dbd82dd519cf89d05a0997647d494706fc016087ca55cb25e07c8a3a"

URI_aarch64_rust-icu_locale+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locale+default-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_locale+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locale+default-devel}"
SRC_URI[aarch64_rust-icu_locale+default-devel.sha256sum] = "7acfa0ca94aff68e2a0e8f1be982644f1f805351d641bceafccc48d0ca3325aa"

URI_aarch64_rust-icu_locale+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locale+serde-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_locale+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locale+serde-devel}"
SRC_URI[aarch64_rust-icu_locale+serde-devel.sha256sum] = "643ae176ef63c5f28816ca6efe20f427647fc66e576cc73875fb96d1f2dfe0ce"

URI_aarch64_rust-icu_locale-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locale-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_locale-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locale-devel}"
SRC_URI[aarch64_rust-icu_locale-devel.sha256sum] = "e13c33ca0cc446d161de09229906f9df5e5323d39124bbffc0628fe0930e9100"

RDEPENDS:rust-icu_locale+compiled_data-devel = " \
 cargo \
 rust-icu_locale-devel \
 rust-icu_locale_data-devel \
 rust-icu_provider+baked-devel \
 "
RDEPENDS:rust-icu_locale+datagen-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-icu_collections+databake-devel \
 rust-icu_locale+serde-devel \
 rust-icu_locale-devel \
 rust-icu_locale_core+databake-devel \
 rust-icu_provider+export-devel \
 rust-tinystr+databake-devel \
 rust-zerovec+databake-devel \
 "
RDEPENDS:rust-icu_locale+default-devel = " \
 cargo \
 rust-icu_locale+compiled_data-devel \
 rust-icu_locale-devel \
 "
RDEPENDS:rust-icu_locale+serde-devel = " \
 cargo \
 rust-icu_collections+serde-devel \
 rust-icu_locale-devel \
 rust-icu_locale_core+serde-devel \
 rust-icu_provider+serde-devel \
 rust-potential_utf+serde-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-tinystr+serde-devel \
 rust-zerovec+serde-devel \
 "
RDEPENDS:rust-icu_locale-devel = " \
 cargo \
 rust \
 rust-icu_collections-devel \
 rust-icu_locale_core+alloc-devel \
 rust-icu_locale_core+zerovec-devel \
 rust-icu_locale_core-devel \
 rust-icu_provider+alloc-devel \
 rust-icu_provider-devel \
 rust-potential_utf+alloc-devel \
 rust-potential_utf+zerovec-devel \
 rust-potential_utf-devel \
 rust-tinystr+alloc-devel \
 rust-tinystr+zerovec-devel \
 rust-tinystr-devel \
 rust-zerovec+alloc-devel \
 rust-zerovec+yoke-devel \
 rust-zerovec-devel \
 "
