# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Business-ISSN"
PV = "1.008"
PR = "3.el10_1"
PACKAGES = " \
 perl-Business-ISSN \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Business-ISSN-1.008-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d87d4fe651a1f8ce7dc19ae4b330cebc1ec926691abadd2bce4fa0306c21add8"

URI_x86_64_v2_perl-Business-ISSN = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Business-ISSN-1.008-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Business-ISSN;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Business-ISSN}"
SRC_URI[x86_64_v2_perl-Business-ISSN.sha256sum] = "227bf16b43e31d8e779d771867a5182cc8b862cbccf0c18d1cc7beb35bf6c3b9"

URI_aarch64_perl-Business-ISSN = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Business-ISSN-1.008-3.el10_1.noarch.rpm;name=aarch64_perl-Business-ISSN;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Business-ISSN}"
SRC_URI[aarch64_perl-Business-ISSN.sha256sum] = "e445d3ee2447b35e5390230c67141d28e436195996d600ed86795191911b74e8"

RDEPENDS:perl-Business-ISSN = " \
 perl-Exporter \
 perl-libs \
 perl-subs \
 "
