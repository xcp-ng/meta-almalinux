# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-partitionmanager"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kde-partitionmanager \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kde-partitionmanager-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "93b243515d37234c29ee5f25a1654fbe266121dcdf90431aeebb9ca4d2235b40"

URI_x86_64_v2_kde-partitionmanager = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-partitionmanager-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-partitionmanager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-partitionmanager}"
SRC_URI[x86_64_v2_kde-partitionmanager.sha256sum] = "95746ce9015bc6f81095751be8cf729dda99161e9b7e517da33ad80cedeec22d"

URI_aarch64_kde-partitionmanager = "${EPEL_MIRROR}/aarch64/Packages/k/kde-partitionmanager-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kde-partitionmanager;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-partitionmanager}"
SRC_URI[aarch64_kde-partitionmanager.sha256sum] = "582a635a1d45257a7adb5a18c4b0f8fcaa7815168f873fedac714443126cb4a3"

RDEPENDS:kde-partitionmanager = " \
 glibc \
 kf6-filesystem \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kpmcore \
 libstdc++ \
 polkit-qt6-1 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
