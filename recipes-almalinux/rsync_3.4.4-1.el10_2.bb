# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rsync"
PV = "3.4.4"
PR = "1.el10_2"
PACKAGES = " \
 rsync \
 rsync-daemon \
 rsync-rrsync \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/rsync-3.4.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ef96ee193b45ac6f416b9644f26fc09f75eabff1c3337ecacbfd2efa38c19f66"

URI_x86_64_v2_rsync = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rsync-3.4.4-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_rsync;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsync}"
SRC_URI[x86_64_v2_rsync.sha256sum] = "463cbb511da217900efb7bae6f577cc9195bec5b316912aa57c6bdd973bc8429"

URI_x86_64_v2_rsync-daemon = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsync-daemon-3.4.4-1.el10_2.noarch.rpm;name=x86_64_v2_rsync-daemon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsync-daemon}"
SRC_URI[x86_64_v2_rsync-daemon.sha256sum] = "c41feb2a21f43ce9aa84fc833bcabb0d96f6b707a7ee6ccbb51ade3b02c7e18a"

URI_x86_64_v2_rsync-rrsync = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsync-rrsync-3.4.4-1.el10_2.noarch.rpm;name=x86_64_v2_rsync-rrsync;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsync-rrsync}"
SRC_URI[x86_64_v2_rsync-rrsync.sha256sum] = "540a428308cad863c69c33ed960b0bc940301aa9b2b59258a14f1fc3273c97b0"

URI_aarch64_rsync = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rsync-3.4.4-1.el10_2.aarch64.rpm;name=aarch64_rsync;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsync}"
SRC_URI[aarch64_rsync.sha256sum] = "fccdaa6860f95f0746e2d026bc073dd9361c55ee23147f8c3545263885cabecd"

URI_aarch64_rsync-daemon = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsync-daemon-3.4.4-1.el10_2.noarch.rpm;name=aarch64_rsync-daemon;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsync-daemon}"
SRC_URI[aarch64_rsync-daemon.sha256sum] = "c41feb2a21f43ce9aa84fc833bcabb0d96f6b707a7ee6ccbb51ade3b02c7e18a"

URI_aarch64_rsync-rrsync = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsync-rrsync-3.4.4-1.el10_2.noarch.rpm;name=aarch64_rsync-rrsync;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsync-rrsync}"
SRC_URI[aarch64_rsync-rrsync.sha256sum] = "540a428308cad863c69c33ed960b0bc940301aa9b2b59258a14f1fc3273c97b0"

RDEPENDS:rsync = " \
 bash \
 glibc \
 libacl \
 libzstd \
 lz4-libs \
 openssl-libs \
 popt \
 "
RDEPENDS:rsync-daemon = " \
 bash \
 rsync \
 systemd \
 "
RDEPENDS:rsync-rrsync = " \
 python3 \
 rsync \
 "
