# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Math-BigInt-GMP"
PV = "1.7001"
PR = "5.el10_0"
PACKAGES = " \
 perl-Math-BigInt-GMP \
 perl-Math-BigInt-GMP-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Math-BigInt-GMP-1.7001-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "14a6635604e7fc2b77d260a0f01216d4575b1082baf6e773633850f58abbd054"

URI_x86_64_v2_perl-Math-BigInt-GMP = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Math-BigInt-GMP-1.7001-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Math-BigInt-GMP;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Math-BigInt-GMP}"
SRC_URI[x86_64_v2_perl-Math-BigInt-GMP.sha256sum] = "97449d3fcdbfc8ba3665909395ec622460a3cad3d016c8c71f1d31680ff572bf"

URI_x86_64_v2_perl-Math-BigInt-GMP-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Math-BigInt-GMP-tests-1.7001-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Math-BigInt-GMP-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Math-BigInt-GMP-tests}"
SRC_URI[x86_64_v2_perl-Math-BigInt-GMP-tests.sha256sum] = "d10067f1d141500f8e176cc5588e91616b7bf86fc6931c1017b42c7d2cc84065"

URI_aarch64_perl-Math-BigInt-GMP = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Math-BigInt-GMP-1.7001-5.el10_0.aarch64.rpm;name=aarch64_perl-Math-BigInt-GMP;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Math-BigInt-GMP}"
SRC_URI[aarch64_perl-Math-BigInt-GMP.sha256sum] = "5433bcbf0685f3b17c58802da36e20af123dd9d17b4be14f1b6182008406fab7"

URI_aarch64_perl-Math-BigInt-GMP-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Math-BigInt-GMP-tests-1.7001-5.el10_0.aarch64.rpm;name=aarch64_perl-Math-BigInt-GMP-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Math-BigInt-GMP-tests}"
SRC_URI[aarch64_perl-Math-BigInt-GMP-tests.sha256sum] = "65f4f2b2c5712e942dc109bfe38891f4b244b6fbbaa9b0e2b9297a5e2f98d8e6"

RDEPENDS:perl-Math-BigInt-GMP = " \
 glibc \
 gmp \
 perl-Math-BigInt \
 perl-libs \
 "
RDEPENDS:perl-Math-BigInt-GMP-tests = " \
 bash \
 perl-Exporter \
 perl-Math-BigInt \
 perl-Math-BigInt-GMP \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-libs \
 perl-threads \
 "
