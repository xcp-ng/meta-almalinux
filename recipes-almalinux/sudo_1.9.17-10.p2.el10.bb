# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sudo"
PV = "1.9.17"
PR = "10.p2.el10"
PACKAGES = " \
 sudo \
 sudo-python-plugin \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/sudo-1.9.17-10.p2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "044a71f1c6b2de0e7bfe23f780de23c26ad0e9eb55ede38dc3075ac5a9c59848"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sudo-1.9.17-10.p2.el10.x86_64_v2.rpm;name=x86_64_v2_sudo;unpack=0"
SRC_URI[x86_64_v2_sudo.sha256sum] = "1f3ef2605bca7ecaf98379a7c476d4455970f9b84e812a821f544acac2eca5c8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sudo-python-plugin-1.9.17-10.p2.el10.x86_64_v2.rpm;name=x86_64_v2_sudo-python-plugin;unpack=0"
SRC_URI[x86_64_v2_sudo-python-plugin.sha256sum] = "7e36c00b7d26f02ef7dc39ddea2757817c3d6c4893262953b936540f9f144c2f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sudo-1.9.17-10.p2.el10.aarch64.rpm;name=aarch64_sudo;unpack=0"
SRC_URI[aarch64_sudo.sha256sum] = "e69d03fab305a6a787b5a6b23007521dc96a31549d5276285fbeac0d4982cf68"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sudo-python-plugin-1.9.17-10.p2.el10.aarch64.rpm;name=aarch64_sudo-python-plugin;unpack=0"
SRC_URI[aarch64_sudo-python-plugin.sha256sum] = "d408a7ce32689033f9a763a77b20ad698c9171806da6c4641f93d750c4417ce5"

RDEPENDS:sudo = " \
 audit-libs \
 glibc \
 libselinux \
 openldap \
 pam \
 pam-libs \
 zlib-ng-compat \
 "
RDEPENDS:sudo-python-plugin = " \
 glibc \
 python3-libs \
 sudo \
 "
