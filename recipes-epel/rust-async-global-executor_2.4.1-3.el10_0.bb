# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-global-executor"
PV = "2.4.1"
PR = "3.el10_0"
PACKAGES = " \
 rust-async-global-executor+async-io-devel \
 rust-async-global-executor+default-devel \
 rust-async-global-executor+tokio-crate-devel \
 rust-async-global-executor+tokio-devel \
 rust-async-global-executor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-global-executor-2.4.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b67c16a4dc892da815b6a01fbc779884cb04c678fe651f84adc836c03fc7e268"

URI_x86_64_v2_rust-async-global-executor+async-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-global-executor+async-io-devel-2.4.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-global-executor+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-global-executor+async-io-devel}"
SRC_URI[x86_64_v2_rust-async-global-executor+async-io-devel.sha256sum] = "4330fc8523926d4d438516ed5a2c21a7f2e01b7e6b52602c4926dd8540ca7b60"

URI_x86_64_v2_rust-async-global-executor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-global-executor+default-devel-2.4.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-global-executor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-global-executor+default-devel}"
SRC_URI[x86_64_v2_rust-async-global-executor+default-devel.sha256sum] = "4c14e93c885c3300ef264fa62998e5e16ae5e60f2e348efc6a1f3ff368480f3a"

URI_x86_64_v2_rust-async-global-executor+tokio-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-global-executor+tokio-crate-devel-2.4.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-global-executor+tokio-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-global-executor+tokio-crate-devel}"
SRC_URI[x86_64_v2_rust-async-global-executor+tokio-crate-devel.sha256sum] = "f8745a64af1d4109eecd1518a212b1de4d92ce02848dbaf52a94ebca577b3124"

URI_x86_64_v2_rust-async-global-executor+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-global-executor+tokio-devel-2.4.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-global-executor+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-global-executor+tokio-devel}"
SRC_URI[x86_64_v2_rust-async-global-executor+tokio-devel.sha256sum] = "7fa68b0cde55df34d4dc46248413500011ac1b0afaaaecf286a90a3f07634b89"

URI_x86_64_v2_rust-async-global-executor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-global-executor-devel-2.4.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-global-executor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-global-executor-devel}"
SRC_URI[x86_64_v2_rust-async-global-executor-devel.sha256sum] = "fa78b7731c4bae35dbc17227310efae8111967d3486b8d83c92b9a5dca82d1fc"

URI_aarch64_rust-async-global-executor+async-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-global-executor+async-io-devel-2.4.1-3.el10_0.noarch.rpm;name=aarch64_rust-async-global-executor+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-global-executor+async-io-devel}"
SRC_URI[aarch64_rust-async-global-executor+async-io-devel.sha256sum] = "fa1e1e33781c3895f0f8068db10e903a41ad5da7e6e41ee72007d6902801d3f1"

URI_aarch64_rust-async-global-executor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-global-executor+default-devel-2.4.1-3.el10_0.noarch.rpm;name=aarch64_rust-async-global-executor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-global-executor+default-devel}"
SRC_URI[aarch64_rust-async-global-executor+default-devel.sha256sum] = "35e560f1ddf2400ea6c6db9d10650a26104fe59347cef26f602655bf7af5afef"

URI_aarch64_rust-async-global-executor+tokio-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-global-executor+tokio-crate-devel-2.4.1-3.el10_0.noarch.rpm;name=aarch64_rust-async-global-executor+tokio-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-global-executor+tokio-crate-devel}"
SRC_URI[aarch64_rust-async-global-executor+tokio-crate-devel.sha256sum] = "9813d5db7825c1bc7b3f1c9f86b2733bb4095fb38451e0195ec7a914ca90470b"

URI_aarch64_rust-async-global-executor+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-global-executor+tokio-devel-2.4.1-3.el10_0.noarch.rpm;name=aarch64_rust-async-global-executor+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-global-executor+tokio-devel}"
SRC_URI[aarch64_rust-async-global-executor+tokio-devel.sha256sum] = "0f1b9624b6027a7cf95d68bcd8896e3d69676a24031db28ee49986a81aa93e94"

URI_aarch64_rust-async-global-executor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-global-executor-devel-2.4.1-3.el10_0.noarch.rpm;name=aarch64_rust-async-global-executor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-global-executor-devel}"
SRC_URI[aarch64_rust-async-global-executor-devel.sha256sum] = "cf8f2628847189af013a6dce93b9d934245b9d9b8e76c900fb71c6246fa7094d"

RDEPENDS:rust-async-global-executor+async-io-devel = " \
 cargo \
 rust-async-global-executor-devel \
 rust-async-io+default-devel \
 "
RDEPENDS:rust-async-global-executor+default-devel = " \
 cargo \
 rust-async-global-executor+async-io-devel \
 rust-async-global-executor-devel \
 "
RDEPENDS:rust-async-global-executor+tokio-crate-devel = " \
 cargo \
 rust-async-global-executor-devel \
 rust-tokio+rt-devel \
 rust-tokio+rt-multi-thread-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-async-global-executor+tokio-devel = " \
 cargo \
 rust-async-global-executor+tokio-crate-devel \
 rust-async-global-executor-devel \
 "
RDEPENDS:rust-async-global-executor-devel = " \
 cargo \
 rust \
 rust-async-channel+default-devel \
 rust-async-executor+default-devel \
 rust-async-lock+default-devel \
 rust-blocking+default-devel \
 rust-futures-lite+default-devel \
 rust-once_cell+default-devel \
 "
