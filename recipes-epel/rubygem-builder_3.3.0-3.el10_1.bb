# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-builder"
PV = "3.3.0"
PR = "3.el10_1"
PACKAGES = " \
 rubygem-builder \
 rubygem-builder-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-builder-3.3.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1993b36ae8a83387d974bd0522519ce2720b8a85c051ac51e21be8e0a8aab24b"

URI_x86_64_v2_rubygem-builder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-builder-3.3.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-builder}"
SRC_URI[x86_64_v2_rubygem-builder.sha256sum] = "10ccfc8123dace7e41b45fb90e156b0e78c054d7a7e15ee758213ba659011ae4"

URI_x86_64_v2_rubygem-builder-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-builder-doc-3.3.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-builder-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-builder-doc}"
SRC_URI[x86_64_v2_rubygem-builder-doc.sha256sum] = "27856e72319de6d5ac291312d2b6ef6ba4d7f212290171d8e1d2acfca8f928d5"

URI_aarch64_rubygem-builder = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-builder-3.3.0-3.el10_1.noarch.rpm;name=aarch64_rubygem-builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-builder}"
SRC_URI[aarch64_rubygem-builder.sha256sum] = "6dba5475eb6b6afe522c5dc88c80065eee85e8287a292604f3464b546b46a005"

URI_aarch64_rubygem-builder-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-builder-doc-3.3.0-3.el10_1.noarch.rpm;name=aarch64_rubygem-builder-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-builder-doc}"
SRC_URI[aarch64_rubygem-builder-doc.sha256sum] = "cbc2f4c6887e727b5ffa9daedd4912c9d8b407749da356abcd259bb14537f3ca"

RDEPENDS:rubygem-builder = " \
 rubygems \
 "
RDEPENDS:rubygem-builder-doc = " \
 rubygem-builder \
 "
