# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-memchr"
PV = "2.7.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-memchr+alloc-devel \
 rust-memchr+default-devel \
 rust-memchr+libc-devel \
 rust-memchr+logging-devel \
 rust-memchr+std-devel \
 rust-memchr+use_std-devel \
 rust-memchr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-memchr-2.7.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0f3a40fcf14ce4e95e607b1bd3b7dc97619043645d821f8f04073ed26c1e2a7d"

URI_x86_64_v2_rust-memchr+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memchr+alloc-devel-2.7.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memchr+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memchr+alloc-devel}"
SRC_URI[x86_64_v2_rust-memchr+alloc-devel.sha256sum] = "591645853154596cc98cd030e9262555724f0040b6cd70020b8327e92ea7d48b"

URI_x86_64_v2_rust-memchr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memchr+default-devel-2.7.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memchr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memchr+default-devel}"
SRC_URI[x86_64_v2_rust-memchr+default-devel.sha256sum] = "d1104aa3e990f8af23dd3d632302a9eb48d0ec3252fd3a552eddbb55f82a5643"

URI_x86_64_v2_rust-memchr+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memchr+libc-devel-2.7.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memchr+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memchr+libc-devel}"
SRC_URI[x86_64_v2_rust-memchr+libc-devel.sha256sum] = "8dc228904a7eba4a4e9a2551f924f0de9c1f2388faa61701c18006bda4873275"

URI_x86_64_v2_rust-memchr+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memchr+logging-devel-2.7.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memchr+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memchr+logging-devel}"
SRC_URI[x86_64_v2_rust-memchr+logging-devel.sha256sum] = "9fcce3f2a14e46025e0927481a6768fabb3f26de8d844689350395003c5d3983"

URI_x86_64_v2_rust-memchr+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memchr+std-devel-2.7.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memchr+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memchr+std-devel}"
SRC_URI[x86_64_v2_rust-memchr+std-devel.sha256sum] = "eed0863b9853c360a80ab8b136014789a17a58d98149a294e7684073866e1b9b"

URI_x86_64_v2_rust-memchr+use_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memchr+use_std-devel-2.7.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memchr+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memchr+use_std-devel}"
SRC_URI[x86_64_v2_rust-memchr+use_std-devel.sha256sum] = "1b42f027a23bd35f156be4b04a14a290680b7ecfd4ec429f11be1f47a22d5533"

URI_x86_64_v2_rust-memchr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memchr-devel-2.7.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memchr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memchr-devel}"
SRC_URI[x86_64_v2_rust-memchr-devel.sha256sum] = "acab378183728ed51d91cb33ef8b6e05e8d3e958e9cd44c87c15ede9ade70506"

URI_aarch64_rust-memchr+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memchr+alloc-devel-2.7.6-1.el10_0.noarch.rpm;name=aarch64_rust-memchr+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memchr+alloc-devel}"
SRC_URI[aarch64_rust-memchr+alloc-devel.sha256sum] = "4665e0cc1e6a48563cdd9336c61a5dffb384acc5f159cdfd8e8250930626172c"

URI_aarch64_rust-memchr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memchr+default-devel-2.7.6-1.el10_0.noarch.rpm;name=aarch64_rust-memchr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memchr+default-devel}"
SRC_URI[aarch64_rust-memchr+default-devel.sha256sum] = "2f672be23ec607b5fe393d40b6ec57c0bb608447239ea4a8a222023a7180c0b0"

URI_aarch64_rust-memchr+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memchr+libc-devel-2.7.6-1.el10_0.noarch.rpm;name=aarch64_rust-memchr+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memchr+libc-devel}"
SRC_URI[aarch64_rust-memchr+libc-devel.sha256sum] = "89c84848290207ccfb9c19a547a13b45e11a2f1e22685a6233780c28d774a765"

URI_aarch64_rust-memchr+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memchr+logging-devel-2.7.6-1.el10_0.noarch.rpm;name=aarch64_rust-memchr+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memchr+logging-devel}"
SRC_URI[aarch64_rust-memchr+logging-devel.sha256sum] = "de198676e1e6e23da98c4147c344b75f81abfdc28180bab5cc62f43184b28e99"

URI_aarch64_rust-memchr+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memchr+std-devel-2.7.6-1.el10_0.noarch.rpm;name=aarch64_rust-memchr+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memchr+std-devel}"
SRC_URI[aarch64_rust-memchr+std-devel.sha256sum] = "b5d70ff1d8233153969b490c36895024ca7cf16e36ee70acda464646834e6f42"

URI_aarch64_rust-memchr+use_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memchr+use_std-devel-2.7.6-1.el10_0.noarch.rpm;name=aarch64_rust-memchr+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memchr+use_std-devel}"
SRC_URI[aarch64_rust-memchr+use_std-devel.sha256sum] = "ad696ef0b4c08a2f23df1b1703dc90f561ad7b012b62b9d5e4ef60ba95ebe478"

URI_aarch64_rust-memchr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memchr-devel-2.7.6-1.el10_0.noarch.rpm;name=aarch64_rust-memchr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memchr-devel}"
SRC_URI[aarch64_rust-memchr-devel.sha256sum] = "9f2b4e2729213583d4bbaa38c11df86f510f26584f450623c3a63bcee07c2ed8"

RDEPENDS:rust-memchr+alloc-devel = " \
 cargo \
 rust-memchr-devel \
 "
RDEPENDS:rust-memchr+default-devel = " \
 cargo \
 rust-memchr+std-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-memchr+libc-devel = " \
 cargo \
 rust-memchr-devel \
 "
RDEPENDS:rust-memchr+logging-devel = " \
 cargo \
 rust-log+default-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-memchr+std-devel = " \
 cargo \
 rust-memchr+alloc-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-memchr+use_std-devel = " \
 cargo \
 rust-memchr+std-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-memchr-devel = " \
 cargo \
 rust \
 "
