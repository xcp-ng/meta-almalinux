# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-v_frame0.3"
PV = "0.3.9"
PR = "1.el10_2"
PACKAGES = " \
 rust-v_frame0.3+default-devel \
 rust-v_frame0.3+serde-devel \
 rust-v_frame0.3+serialize-devel \
 rust-v_frame0.3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-v_frame0.3-0.3.9-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "18f4bc23b2f9fa2ff6b60553814325f0b1cc309f787775cbfa1fa71426a079f9"

URI_x86_64_v2_rust-v_frame0.3+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-v_frame0.3+default-devel-0.3.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-v_frame0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-v_frame0.3+default-devel}"
SRC_URI[x86_64_v2_rust-v_frame0.3+default-devel.sha256sum] = "26e7da1f650870de1f1a910bb733d5756bd085bc4110a944cb79b19d918c06be"

URI_x86_64_v2_rust-v_frame0.3+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-v_frame0.3+serde-devel-0.3.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-v_frame0.3+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-v_frame0.3+serde-devel}"
SRC_URI[x86_64_v2_rust-v_frame0.3+serde-devel.sha256sum] = "334761771519c21c1551d92e351fe9679e4d09948683dd56566ed31ba32aa34b"

URI_x86_64_v2_rust-v_frame0.3+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-v_frame0.3+serialize-devel-0.3.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-v_frame0.3+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-v_frame0.3+serialize-devel}"
SRC_URI[x86_64_v2_rust-v_frame0.3+serialize-devel.sha256sum] = "c8656e397656b1a49ffbb60be4dc70ddd1eeea1d769805fa615125920a4c99a0"

URI_x86_64_v2_rust-v_frame0.3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-v_frame0.3-devel-0.3.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-v_frame0.3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-v_frame0.3-devel}"
SRC_URI[x86_64_v2_rust-v_frame0.3-devel.sha256sum] = "1336051f1ef03faf1d7bbd2fcc442a5209ca918a436f63d39362ec5c7a77646f"

URI_aarch64_rust-v_frame0.3+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-v_frame0.3+default-devel-0.3.9-1.el10_2.noarch.rpm;name=aarch64_rust-v_frame0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-v_frame0.3+default-devel}"
SRC_URI[aarch64_rust-v_frame0.3+default-devel.sha256sum] = "6352596cc5c0c93ee5a725e0941aa8248e529261c646ec69c17601b9ba0bd6d6"

URI_aarch64_rust-v_frame0.3+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-v_frame0.3+serde-devel-0.3.9-1.el10_2.noarch.rpm;name=aarch64_rust-v_frame0.3+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-v_frame0.3+serde-devel}"
SRC_URI[aarch64_rust-v_frame0.3+serde-devel.sha256sum] = "8abf8eb158ee0c1beec5c87b334c8ac87525f20f4705e2a8ae094f784360c202"

URI_aarch64_rust-v_frame0.3+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-v_frame0.3+serialize-devel-0.3.9-1.el10_2.noarch.rpm;name=aarch64_rust-v_frame0.3+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-v_frame0.3+serialize-devel}"
SRC_URI[aarch64_rust-v_frame0.3+serialize-devel.sha256sum] = "069230e5c69d410676247cbe83c2162c6e12b5791c7931f593d241c58f0774e3"

URI_aarch64_rust-v_frame0.3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-v_frame0.3-devel-0.3.9-1.el10_2.noarch.rpm;name=aarch64_rust-v_frame0.3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-v_frame0.3-devel}"
SRC_URI[aarch64_rust-v_frame0.3-devel.sha256sum] = "448cbefe366b42045d99855548833b3ef04fc1eca3155cf360ede5b3e028b03c"

RDEPENDS:rust-v_frame0.3+default-devel = " \
 cargo \
 rust-v_frame0.3-devel \
 "
RDEPENDS:rust-v_frame0.3+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-v_frame0.3-devel \
 "
RDEPENDS:rust-v_frame0.3+serialize-devel = " \
 cargo \
 rust-aligned-vec+serde-devel \
 rust-v_frame0.3+serde-devel \
 rust-v_frame0.3-devel \
 "
RDEPENDS:rust-v_frame0.3-devel = " \
 cargo \
 rust \
 rust-aligned-vec+default-devel \
 rust-num-traits+default-devel \
 "
