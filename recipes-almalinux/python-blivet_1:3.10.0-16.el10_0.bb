# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-blivet"
PE = "1"
PV = "3.10.0"
PR = "16.el10_0"
PACKAGES = " \
 blivet-data \
 python3-blivet \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-blivet-3.10.0-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e40c34728c5f9794c84977bf5a615a6204fe7be44aa04d34c17176d30a28242a"

URI_x86_64_v2_blivet-data = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/blivet-data-3.10.0-16.el10_0.noarch.rpm;name=x86_64_v2_blivet-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blivet-data}"
SRC_URI[x86_64_v2_blivet-data.sha256sum] = "0d2849fabc93b9a0b2b0f962e96d42198a242aaf45a05d81f2ebb0c194a08593"

URI_x86_64_v2_python3-blivet = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-blivet-3.10.0-16.el10_0.noarch.rpm;name=x86_64_v2_python3-blivet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-blivet}"
SRC_URI[x86_64_v2_python3-blivet.sha256sum] = "5ddcbe8586aa3afbbb1a0a15be08584de7c0467fc8d0d5845f849a8826f49946"

URI_aarch64_blivet-data = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/blivet-data-3.10.0-16.el10_0.noarch.rpm;name=aarch64_blivet-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_blivet-data}"
SRC_URI[aarch64_blivet-data.sha256sum] = "0d2849fabc93b9a0b2b0f962e96d42198a242aaf45a05d81f2ebb0c194a08593"

URI_aarch64_python3-blivet = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-blivet-3.10.0-16.el10_0.noarch.rpm;name=aarch64_python3-blivet;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-blivet}"
SRC_URI[aarch64_python3-blivet.sha256sum] = "5ddcbe8586aa3afbbb1a0a15be08584de7c0467fc8d0d5845f849a8826f49946"

RDEPENDS:blivet-data = " \
 python3 \
 "
RDEPENDS:python3-blivet = " \
 blivet-data \
 lsof \
 parted \
 python3 \
 python3-blockdev \
 python3-bytesize \
 python3-gobject-base \
 python3-libmount \
 python3-libselinux \
 python3-pyparted \
 python3-pyudev \
 systemd-udev \
 util-linux \
 "
