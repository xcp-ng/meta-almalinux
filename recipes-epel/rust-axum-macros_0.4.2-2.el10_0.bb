# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-axum-macros"
PV = "0.4.2"
PR = "2.el10_0"
PACKAGES = " \
 rust-axum-macros+__private-devel \
 rust-axum-macros+default-devel \
 rust-axum-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-axum-macros-0.4.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45a804d635263cb85f788167ce75effc477ce0ef178b47fac8d6cb5fe589a071"

URI_x86_64_v2_rust-axum-macros+__private-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum-macros+__private-devel-0.4.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum-macros+__private-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum-macros+__private-devel}"
SRC_URI[x86_64_v2_rust-axum-macros+__private-devel.sha256sum] = "6734ac81d028f079303f24a6e30220774643cabcb9f667ac62f48173a262839d"

URI_x86_64_v2_rust-axum-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum-macros+default-devel-0.4.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum-macros+default-devel}"
SRC_URI[x86_64_v2_rust-axum-macros+default-devel.sha256sum] = "b7c41fa048aeac3072ea220c9000e5d9db75c15b768be880730c86998742f04d"

URI_x86_64_v2_rust-axum-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum-macros-devel-0.4.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum-macros-devel}"
SRC_URI[x86_64_v2_rust-axum-macros-devel.sha256sum] = "9d1ca098aef59e3c035a7f8c4a83253095841109c66a17579ced4ca79a464899"

URI_aarch64_rust-axum-macros+__private-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum-macros+__private-devel-0.4.2-2.el10_0.noarch.rpm;name=aarch64_rust-axum-macros+__private-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum-macros+__private-devel}"
SRC_URI[aarch64_rust-axum-macros+__private-devel.sha256sum] = "e660c8f28cdb2a7e2c89ea10fba148d71389812306fbea63e32ddd77c1b085f0"

URI_aarch64_rust-axum-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum-macros+default-devel-0.4.2-2.el10_0.noarch.rpm;name=aarch64_rust-axum-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum-macros+default-devel}"
SRC_URI[aarch64_rust-axum-macros+default-devel.sha256sum] = "e728bf0e8c786d65e7707d5218b3d1d7b73eee8a04068493a739fba8faa10cbc"

URI_aarch64_rust-axum-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum-macros-devel-0.4.2-2.el10_0.noarch.rpm;name=aarch64_rust-axum-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum-macros-devel}"
SRC_URI[aarch64_rust-axum-macros-devel.sha256sum] = "7639fbbb34d6000653d05fa1650514ab72e01eb7f362b875fb972b632b630859"

RDEPENDS:rust-axum-macros+__private-devel = " \
 cargo \
 rust-axum-macros-devel \
 rust-syn+visit-mut-devel \
 "
RDEPENDS:rust-axum-macros+default-devel = " \
 cargo \
 rust-axum-macros-devel \
 "
RDEPENDS:rust-axum-macros-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 "
