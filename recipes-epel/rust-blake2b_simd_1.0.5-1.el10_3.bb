# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-blake2b_simd"
PV = "1.0.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-blake2b_simd+default-devel \
 rust-blake2b_simd+std-devel \
 rust-blake2b_simd+uninline_portable-devel \
 rust-blake2b_simd-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-blake2b_simd-1.0.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d304e23af9bef38fa683246520c8226d2e4310231bec21a998bc9b4d3d7282e1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake2b_simd+default-devel-1.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake2b_simd+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-blake2b_simd+default-devel.sha256sum] = "60cb77309bd3d556a5238b4bf363f2017a6781beb4d4115c472d056cd94a9cd6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake2b_simd+std-devel-1.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake2b_simd+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-blake2b_simd+std-devel.sha256sum] = "6dc91dbbb351911a38e6d7cc04711dbf14def67f1b212150f149b81785b97629"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake2b_simd+uninline_portable-devel-1.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake2b_simd+uninline_portable-devel;unpack=0"
SRC_URI[x86_64_v2_rust-blake2b_simd+uninline_portable-devel.sha256sum] = "2d99db4b7bf3f09cf4e62bf6fad7501b03cbdd5c095afcc3d36eae9d115a98f2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake2b_simd-devel-1.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake2b_simd-devel;unpack=0"
SRC_URI[x86_64_v2_rust-blake2b_simd-devel.sha256sum] = "14fc63b08f133b47f6dc02f8ecc7b2300e838f79ea9eaa399d36b4adcf55d6f0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-blake2b_simd+default-devel-1.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-blake2b_simd+default-devel;unpack=0"
SRC_URI[aarch64_rust-blake2b_simd+default-devel.sha256sum] = "f92182b703b0857c30511247b61335d999fffe45366cc842c79190b84d5676da"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-blake2b_simd+std-devel-1.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-blake2b_simd+std-devel;unpack=0"
SRC_URI[aarch64_rust-blake2b_simd+std-devel.sha256sum] = "3e547c8b2e69a2bfbbbfe8f0c21a5816afc7dc76d6524202182c28e41232cd1c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-blake2b_simd+uninline_portable-devel-1.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-blake2b_simd+uninline_portable-devel;unpack=0"
SRC_URI[aarch64_rust-blake2b_simd+uninline_portable-devel.sha256sum] = "911d539e150bb94069ffb953708776024826f94a3b19ae772160efce08310403"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-blake2b_simd-devel-1.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-blake2b_simd-devel;unpack=0"
SRC_URI[aarch64_rust-blake2b_simd-devel.sha256sum] = "a4ffb9d1c4f5869f4a3f72e2d79c57419a76fe5e3822c2c9c0119ae9fb825c75"

RDEPENDS:rust-blake2b_simd+default-devel = " \
 cargo \
 rust-blake2b_simd+std-devel \
 rust-blake2b_simd-devel \
 "
RDEPENDS:rust-blake2b_simd+std-devel = " \
 cargo \
 rust-blake2b_simd-devel \
 rust-constant_time_eq+std-devel \
 "
RDEPENDS:rust-blake2b_simd+uninline_portable-devel = " \
 cargo \
 rust-blake2b_simd-devel \
 "
RDEPENDS:rust-blake2b_simd-devel = " \
 cargo \
 rust-arrayvec-devel \
 rust-constant_time_eq-devel \
 "
