# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua-unbound"
PV = "1.1.0"
PR = "1.el10_2"
PACKAGES = " \
 lua-unbound \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lua-unbound-1.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da3c8074b9a05b7bc8c2f88d97bae2093960064db96dff8579ad2c33079600c5"

URI_x86_64_v2_lua-unbound = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua-unbound-1.1.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lua-unbound;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-unbound}"
SRC_URI[x86_64_v2_lua-unbound.sha256sum] = "36f129ad472f89bd562743ba6af260a0c8e80a39e5cdba5f4b386d252bd15576"

URI_aarch64_lua-unbound = "${EPEL_MIRROR}/aarch64/Packages/l/lua-unbound-1.1.0-1.el10_2.aarch64.rpm;name=aarch64_lua-unbound;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-unbound}"
SRC_URI[aarch64_lua-unbound.sha256sum] = "f3658dd54f48dc4486edfc09f36373869771c306981fdd2b887331c92b5e10ec"

RDEPENDS:lua-unbound = " \
 glibc \
 lua-libs \
 unbound-libs \
 "
