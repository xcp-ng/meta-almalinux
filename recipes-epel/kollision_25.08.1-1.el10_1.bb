# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kollision"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kollision \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kollision-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3af0bed750ec1809d8520cd0d7f0837bb9959f3f74a79044f3fe3d4ff5460524"

URI_x86_64_v2_kollision = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kollision-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kollision;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kollision}"
SRC_URI[x86_64_v2_kollision.sha256sum] = "cb5737cfad260bdefe1fa07c949b5b57d44391925098b75d60af5c0a2cb4063b"

URI_aarch64_kollision = "${EPEL_MIRROR}/aarch64/Packages/k/kollision-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kollision;unpack=0"
SRC_URI:append = " ${URI_aarch64_kollision}"
SRC_URI[aarch64_kollision.sha256sum] = "00d4a7c45eef0967d45755f754c1df1185304d0d6da90b0b6e22362abb0495a6"

RDEPENDS:kollision = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
