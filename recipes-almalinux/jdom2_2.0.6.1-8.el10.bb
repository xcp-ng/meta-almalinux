# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jdom2"
PV = "2.0.6.1"
PR = "8.el10"
PACKAGES = " \
 jdom2 \
 jdom2-javadoc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/jdom2-2.0.6.1-8.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6a150b534ee829864f5516f7f2c3b146c022cca9164c3fb0a7affd033e6475e0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jdom2-2.0.6.1-8.el10.noarch.rpm;name=x86_64_v2_jdom2;unpack=0"
SRC_URI[x86_64_v2_jdom2.sha256sum] = "799341b1590988eef3236d7599243426df8677d925e0f08ad41a66b1f44571dd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jdom2-javadoc-2.0.6.1-8.el10.noarch.rpm;name=x86_64_v2_jdom2-javadoc;unpack=0"
SRC_URI[x86_64_v2_jdom2-javadoc.sha256sum] = "d2ac7c17bd0fd16aea1944740e329af89ee73f8dd44be27834cb0bff886dd55d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jdom2-2.0.6.1-8.el10.noarch.rpm;name=aarch64_jdom2;unpack=0"
SRC_URI[aarch64_jdom2.sha256sum] = "799341b1590988eef3236d7599243426df8677d925e0f08ad41a66b1f44571dd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jdom2-javadoc-2.0.6.1-8.el10.noarch.rpm;name=aarch64_jdom2-javadoc;unpack=0"
SRC_URI[aarch64_jdom2-javadoc.sha256sum] = "d2ac7c17bd0fd16aea1944740e329af89ee73f8dd44be27834cb0bff886dd55d"

RDEPENDS:jdom2 = " \
 javapackages-filesystem \
 "
RDEPENDS:jdom2-javadoc = " \
 javapackages-filesystem \
 "
