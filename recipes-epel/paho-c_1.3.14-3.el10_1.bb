# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "paho-c"
PV = "1.3.14"
PR = "3.el10_1"
PACKAGES = " \
 paho-c \
 paho-c-devel \
 paho-c-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/paho-c-1.3.14-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f519e1e49d989ce7f884e1736ebdff725b5290d904edd7e3dc6a4d56abb5e6fb"

URI_x86_64_v2_paho-c = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/paho-c-1.3.14-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_paho-c;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_paho-c}"
SRC_URI[x86_64_v2_paho-c.sha256sum] = "ec8239a4bfdf4abf692dff9f0731a847bf08d14799be6d89bbae57d4c7d6e809"

URI_x86_64_v2_paho-c-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/paho-c-devel-1.3.14-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_paho-c-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_paho-c-devel}"
SRC_URI[x86_64_v2_paho-c-devel.sha256sum] = "d480cf9e8b6b6aefd169fe3e4f181d8ef78f1b8304626e757fd7c36ff7ef98dc"

URI_x86_64_v2_paho-c-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/paho-c-doc-1.3.14-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_paho-c-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_paho-c-doc}"
SRC_URI[x86_64_v2_paho-c-doc.sha256sum] = "383cfae6452d088dc5f9285a723f6602b1794422673e828f9f85d8782114cf2d"

URI_aarch64_paho-c = "${EPEL_MIRROR}/aarch64/Packages/p/paho-c-1.3.14-3.el10_1.aarch64.rpm;name=aarch64_paho-c;unpack=0"
SRC_URI:append = " ${URI_aarch64_paho-c}"
SRC_URI[aarch64_paho-c.sha256sum] = "63fbd40371f0f73a1fd73f49c557624ed66a7060a938f46d941e7955f7e02f75"

URI_aarch64_paho-c-devel = "${EPEL_MIRROR}/aarch64/Packages/p/paho-c-devel-1.3.14-3.el10_1.aarch64.rpm;name=aarch64_paho-c-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_paho-c-devel}"
SRC_URI[aarch64_paho-c-devel.sha256sum] = "5298e694998ad24a6b7a621bc9c39d48623b15ae359144e2d37aef81354d0c2e"

URI_aarch64_paho-c-doc = "${EPEL_MIRROR}/aarch64/Packages/p/paho-c-doc-1.3.14-3.el10_1.noarch.rpm;name=aarch64_paho-c-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_paho-c-doc}"
SRC_URI[aarch64_paho-c-doc.sha256sum] = "76d855a203a278da4fe8cecb185613223786c018d2c390b4fdcfc764a00edf8d"

RDEPENDS:paho-c = " \
 glibc \
 openssl-libs \
 "
RDEPENDS:paho-c-devel = " \
 cmake-filesystem \
 glibc \
 paho-c \
 "
RDEPENDS:paho-c-doc = " \
 "
