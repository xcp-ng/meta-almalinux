# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aom"
PV = "3.12.0"
PR = "1.el10_0"
PACKAGES = " \
 aom \
 libaom \
 libaom-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aom-3.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12f59c1bdf4eca3a895863a74b18a9fc76209103a94c1e4136b14f6b106b6901"

URI_x86_64_v2_aom = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aom-3.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aom;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aom}"
SRC_URI[x86_64_v2_aom.sha256sum] = "415befc6e077ed509c7ab1640396cde1bcef0fa29d99432698a761c3da62b366"

URI_x86_64_v2_libaom = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libaom-3.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libaom;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libaom}"
SRC_URI[x86_64_v2_libaom.sha256sum] = "b3f9873fe5fe1ec62c4bdc1c0b570fa187137612f3ee503d8ab718a6eacecf41"

URI_x86_64_v2_libaom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libaom-devel-3.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libaom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libaom-devel}"
SRC_URI[x86_64_v2_libaom-devel.sha256sum] = "5a80dc445902a1eee9995e16256de87a70d963ff8fbf6ed36813eff64921965f"

URI_aarch64_aom = "${EPEL_MIRROR}/aarch64/Packages/a/aom-3.12.0-1.el10_0.aarch64.rpm;name=aarch64_aom;unpack=0"
SRC_URI:append = " ${URI_aarch64_aom}"
SRC_URI[aarch64_aom.sha256sum] = "2316b58fffcde3790c2de8344ec28c439c5d520c249a07a7376c15b283d1d3ac"

URI_aarch64_libaom = "${EPEL_MIRROR}/aarch64/Packages/l/libaom-3.12.0-1.el10_0.aarch64.rpm;name=aarch64_libaom;unpack=0"
SRC_URI:append = " ${URI_aarch64_libaom}"
SRC_URI[aarch64_libaom.sha256sum] = "174cd38dcaaad863a267f872ab0874b3af7806b533590616126781feead60f98"

URI_aarch64_libaom-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libaom-devel-3.12.0-1.el10_0.aarch64.rpm;name=aarch64_libaom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libaom-devel}"
SRC_URI[aarch64_libaom-devel.sha256sum] = "ae8ce3db2574ad7fa210e6b68e23be6607d59ce91a4e8c47226289ef745e3c8b"

RDEPENDS:aom = " \
 glibc \
 libaom \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libaom:x86_64_v2 = " \
 glibc \
 libvmaf \
"
RDEPENDS:libaom:aarch64 = " \
 glibc \
"
RDEPENDS:libaom-devel:x86_64_v2 = " \
 libaom \
 libvmaf-devel \
 pkgconf-pkg-config \
"
RDEPENDS:libaom-devel:aarch64 = " \
 libaom \
 pkgconf-pkg-config \
"
