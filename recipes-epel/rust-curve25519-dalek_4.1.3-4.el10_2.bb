# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-curve25519-dalek"
PV = "4.1.3"
PR = "4.el10_2"
PACKAGES = " \
 rust-curve25519-dalek+alloc-devel \
 rust-curve25519-dalek+default-devel \
 rust-curve25519-dalek+digest-devel \
 rust-curve25519-dalek+ff-devel \
 rust-curve25519-dalek+group-bits-devel \
 rust-curve25519-dalek+group-devel \
 rust-curve25519-dalek+legacy_compatibility-devel \
 rust-curve25519-dalek+precomputed-tables-devel \
 rust-curve25519-dalek+rand_core-devel \
 rust-curve25519-dalek+serde-devel \
 rust-curve25519-dalek+zeroize-devel \
 rust-curve25519-dalek-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-curve25519-dalek-4.1.3-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e289b9b2ad73e3186bc68846f4704b6381c931751f80a6e1a0d16827547eee59"

URI_x86_64_v2_rust-curve25519-dalek+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curve25519-dalek+alloc-devel-4.1.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curve25519-dalek+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curve25519-dalek+alloc-devel}"
SRC_URI[x86_64_v2_rust-curve25519-dalek+alloc-devel.sha256sum] = "9100254a34989474453de1e1be2fa605d8f9e8450bf5cf61378330aee7b06628"

URI_x86_64_v2_rust-curve25519-dalek+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curve25519-dalek+default-devel-4.1.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curve25519-dalek+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curve25519-dalek+default-devel}"
SRC_URI[x86_64_v2_rust-curve25519-dalek+default-devel.sha256sum] = "2bd09e4e8b77fde5aa0bbaacce5e01231a07b15a1be817fa9de4a0da8a03d876"

URI_x86_64_v2_rust-curve25519-dalek+digest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curve25519-dalek+digest-devel-4.1.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curve25519-dalek+digest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curve25519-dalek+digest-devel}"
SRC_URI[x86_64_v2_rust-curve25519-dalek+digest-devel.sha256sum] = "e6f11518fe52ec4825f0a819529e5a44ba49ad37fd31b15b92a1f4642126aec9"

URI_x86_64_v2_rust-curve25519-dalek+ff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curve25519-dalek+ff-devel-4.1.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curve25519-dalek+ff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curve25519-dalek+ff-devel}"
SRC_URI[x86_64_v2_rust-curve25519-dalek+ff-devel.sha256sum] = "b522fbb5b69c88f1a456cedf6cc2a71837c240737fcdf6cfb9f054efc8bbe1dc"

URI_x86_64_v2_rust-curve25519-dalek+group-bits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curve25519-dalek+group-bits-devel-4.1.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curve25519-dalek+group-bits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curve25519-dalek+group-bits-devel}"
SRC_URI[x86_64_v2_rust-curve25519-dalek+group-bits-devel.sha256sum] = "32fcc0421ae4e3a5a5b779d58006e57264979b8512108ac395ea5c2b1f6d10ee"

URI_x86_64_v2_rust-curve25519-dalek+group-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curve25519-dalek+group-devel-4.1.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curve25519-dalek+group-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curve25519-dalek+group-devel}"
SRC_URI[x86_64_v2_rust-curve25519-dalek+group-devel.sha256sum] = "2c877d4edc20fe82840515837c435fc4ca05adb640af6addd64c793908202bd6"

URI_x86_64_v2_rust-curve25519-dalek+legacy_compatibility-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curve25519-dalek+legacy_compatibility-devel-4.1.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curve25519-dalek+legacy_compatibility-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curve25519-dalek+legacy_compatibility-devel}"
SRC_URI[x86_64_v2_rust-curve25519-dalek+legacy_compatibility-devel.sha256sum] = "9dd31ab2643661f242253f01f4cc58b2eda1bb4111f5860a3649570bc01079b1"

URI_x86_64_v2_rust-curve25519-dalek+precomputed-tables-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curve25519-dalek+precomputed-tables-devel-4.1.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curve25519-dalek+precomputed-tables-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curve25519-dalek+precomputed-tables-devel}"
SRC_URI[x86_64_v2_rust-curve25519-dalek+precomputed-tables-devel.sha256sum] = "7238e8bdcbf97ca12aa7168da386ecee28717d6044f914b6ff454220a1695a05"

URI_x86_64_v2_rust-curve25519-dalek+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curve25519-dalek+rand_core-devel-4.1.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curve25519-dalek+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curve25519-dalek+rand_core-devel}"
SRC_URI[x86_64_v2_rust-curve25519-dalek+rand_core-devel.sha256sum] = "3f64f1e104c8dccb5c0458239d2bd1d9f38490c467b27b89f9596b607ab14d9e"

URI_x86_64_v2_rust-curve25519-dalek+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curve25519-dalek+serde-devel-4.1.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curve25519-dalek+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curve25519-dalek+serde-devel}"
SRC_URI[x86_64_v2_rust-curve25519-dalek+serde-devel.sha256sum] = "e42293b2d4b8a9609bd33dfbb3555ca1473748e59cfdbf6c46e4807a8a0c1f26"

URI_x86_64_v2_rust-curve25519-dalek+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curve25519-dalek+zeroize-devel-4.1.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curve25519-dalek+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curve25519-dalek+zeroize-devel}"
SRC_URI[x86_64_v2_rust-curve25519-dalek+zeroize-devel.sha256sum] = "b6ae90f446fe38538c4f6badf734420091e7e3e4dc0448c05db99ff7bb531f40"

URI_x86_64_v2_rust-curve25519-dalek-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curve25519-dalek-devel-4.1.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curve25519-dalek-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curve25519-dalek-devel}"
SRC_URI[x86_64_v2_rust-curve25519-dalek-devel.sha256sum] = "1d4cc3796e757720655bf2017cc0b376140af3867187847768de5f1eaaa549b5"

URI_aarch64_rust-curve25519-dalek+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curve25519-dalek+alloc-devel-4.1.3-4.el10_2.noarch.rpm;name=aarch64_rust-curve25519-dalek+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curve25519-dalek+alloc-devel}"
SRC_URI[aarch64_rust-curve25519-dalek+alloc-devel.sha256sum] = "02397ca533c735d3346474d004631a0f9796f250536d6b0fca881a70c110c08a"

URI_aarch64_rust-curve25519-dalek+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curve25519-dalek+default-devel-4.1.3-4.el10_2.noarch.rpm;name=aarch64_rust-curve25519-dalek+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curve25519-dalek+default-devel}"
SRC_URI[aarch64_rust-curve25519-dalek+default-devel.sha256sum] = "3012e761df1f8844c3f6419ed3ffe81f731680e66577aa55bdf04ffdc5b95e92"

URI_aarch64_rust-curve25519-dalek+digest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curve25519-dalek+digest-devel-4.1.3-4.el10_2.noarch.rpm;name=aarch64_rust-curve25519-dalek+digest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curve25519-dalek+digest-devel}"
SRC_URI[aarch64_rust-curve25519-dalek+digest-devel.sha256sum] = "b6d359104acb665c8167c346a0e76824de7d632103cd86a7df33fef1d72cc05d"

URI_aarch64_rust-curve25519-dalek+ff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curve25519-dalek+ff-devel-4.1.3-4.el10_2.noarch.rpm;name=aarch64_rust-curve25519-dalek+ff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curve25519-dalek+ff-devel}"
SRC_URI[aarch64_rust-curve25519-dalek+ff-devel.sha256sum] = "29b9fa3420cfcab8321c367afee3a69dd3c2d13d87cfeada8c7d7068d1ded8f1"

URI_aarch64_rust-curve25519-dalek+group-bits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curve25519-dalek+group-bits-devel-4.1.3-4.el10_2.noarch.rpm;name=aarch64_rust-curve25519-dalek+group-bits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curve25519-dalek+group-bits-devel}"
SRC_URI[aarch64_rust-curve25519-dalek+group-bits-devel.sha256sum] = "e396b736467c4d52b287a291096aff11a587439423be63ee1c716c5d9cc1ab25"

URI_aarch64_rust-curve25519-dalek+group-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curve25519-dalek+group-devel-4.1.3-4.el10_2.noarch.rpm;name=aarch64_rust-curve25519-dalek+group-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curve25519-dalek+group-devel}"
SRC_URI[aarch64_rust-curve25519-dalek+group-devel.sha256sum] = "113612d6d143c5430d874c04c22a3bae28997f4143b86b6a038a4194313b9084"

URI_aarch64_rust-curve25519-dalek+legacy_compatibility-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curve25519-dalek+legacy_compatibility-devel-4.1.3-4.el10_2.noarch.rpm;name=aarch64_rust-curve25519-dalek+legacy_compatibility-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curve25519-dalek+legacy_compatibility-devel}"
SRC_URI[aarch64_rust-curve25519-dalek+legacy_compatibility-devel.sha256sum] = "6cc74da74132af08c95ef4600bee56d4cbdfcecec6a417d8f9fcb32cf34ca500"

URI_aarch64_rust-curve25519-dalek+precomputed-tables-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curve25519-dalek+precomputed-tables-devel-4.1.3-4.el10_2.noarch.rpm;name=aarch64_rust-curve25519-dalek+precomputed-tables-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curve25519-dalek+precomputed-tables-devel}"
SRC_URI[aarch64_rust-curve25519-dalek+precomputed-tables-devel.sha256sum] = "6a7b789f476938173b73d399b9229a8f42fa65fb69e4c90ac665a0956ddc5344"

URI_aarch64_rust-curve25519-dalek+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curve25519-dalek+rand_core-devel-4.1.3-4.el10_2.noarch.rpm;name=aarch64_rust-curve25519-dalek+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curve25519-dalek+rand_core-devel}"
SRC_URI[aarch64_rust-curve25519-dalek+rand_core-devel.sha256sum] = "26c6f4638b60d26ce5ba26c1fd9ffcebcce34583af634832dc1bfc9c627a61a3"

URI_aarch64_rust-curve25519-dalek+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curve25519-dalek+serde-devel-4.1.3-4.el10_2.noarch.rpm;name=aarch64_rust-curve25519-dalek+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curve25519-dalek+serde-devel}"
SRC_URI[aarch64_rust-curve25519-dalek+serde-devel.sha256sum] = "89d36c842ae8a605aa3ab8aa5db1ff57d5bf86da0ac9572f5344f5396d1e24da"

URI_aarch64_rust-curve25519-dalek+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curve25519-dalek+zeroize-devel-4.1.3-4.el10_2.noarch.rpm;name=aarch64_rust-curve25519-dalek+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curve25519-dalek+zeroize-devel}"
SRC_URI[aarch64_rust-curve25519-dalek+zeroize-devel.sha256sum] = "194bd561b08f297d9d0ade2b3bb5484bf29eac0f8edeed73924227636959661e"

URI_aarch64_rust-curve25519-dalek-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curve25519-dalek-devel-4.1.3-4.el10_2.noarch.rpm;name=aarch64_rust-curve25519-dalek-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curve25519-dalek-devel}"
SRC_URI[aarch64_rust-curve25519-dalek-devel.sha256sum] = "a502a53ae5601d12f662f792f59a22c37340a9f0e23ba2b4cb8cb226179a341d"

RDEPENDS:rust-curve25519-dalek+alloc-devel = " \
 cargo \
 rust-curve25519-dalek-devel \
 rust-zeroize+alloc-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-curve25519-dalek+default-devel = " \
 cargo \
 rust-curve25519-dalek+alloc-devel \
 rust-curve25519-dalek+precomputed-tables-devel \
 rust-curve25519-dalek+zeroize-devel \
 rust-curve25519-dalek-devel \
 "
RDEPENDS:rust-curve25519-dalek+digest-devel = " \
 cargo \
 rust-curve25519-dalek-devel \
 rust-digest0.10-devel \
 "
RDEPENDS:rust-curve25519-dalek+ff-devel = " \
 cargo \
 rust-curve25519-dalek-devel \
 rust-ff0.13-devel \
 "
RDEPENDS:rust-curve25519-dalek+group-bits-devel = " \
 cargo \
 rust-curve25519-dalek+group-devel \
 rust-curve25519-dalek-devel \
 rust-ff0.13+bits-devel \
 rust-ff0.13-devel \
 "
RDEPENDS:rust-curve25519-dalek+group-devel = " \
 cargo \
 rust-curve25519-dalek+rand_core-devel \
 rust-curve25519-dalek-devel \
 rust-group0.13-devel \
 "
RDEPENDS:rust-curve25519-dalek+legacy_compatibility-devel = " \
 cargo \
 rust-curve25519-dalek-devel \
 "
RDEPENDS:rust-curve25519-dalek+precomputed-tables-devel = " \
 cargo \
 rust-curve25519-dalek-devel \
 "
RDEPENDS:rust-curve25519-dalek+rand_core-devel = " \
 cargo \
 rust-curve25519-dalek-devel \
 rust-rand_core0.6-devel \
 "
RDEPENDS:rust-curve25519-dalek+serde-devel = " \
 cargo \
 rust-curve25519-dalek-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-curve25519-dalek+zeroize-devel = " \
 cargo \
 rust-curve25519-dalek-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-curve25519-dalek-devel = " \
 bash \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-cpufeatures0.2+default-devel \
 rust-curve25519-dalek-derive+default-devel \
 rust-rustc_version+default-devel \
 rust-subtle-devel \
 "
