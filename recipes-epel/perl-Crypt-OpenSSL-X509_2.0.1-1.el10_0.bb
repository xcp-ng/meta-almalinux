# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-OpenSSL-X509"
PV = "2.0.1"
PR = "1.el10_0"
PACKAGES = " \
 perl-Crypt-OpenSSL-X509 \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-OpenSSL-X509-2.0.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c64cef6013bffffadb2be50933be9f8feca4b26119dd0ed21f9ef370c2d82736"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-OpenSSL-X509-2.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Crypt-OpenSSL-X509;unpack=0"
SRC_URI[x86_64_v2_perl-Crypt-OpenSSL-X509.sha256sum] = "73de3af3329b85b37d6a6ce6eb41badba67391f6f7bb91be4f07024592dc8691"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-OpenSSL-X509-2.0.1-1.el10_0.aarch64.rpm;name=aarch64_perl-Crypt-OpenSSL-X509;unpack=0"
SRC_URI[aarch64_perl-Crypt-OpenSSL-X509.sha256sum] = "d3e998dbd28322edd0d6a6b7a9cbb63a777f875dbc8cc9bacac6ecfa682a691c"

RDEPENDS:perl-Crypt-OpenSSL-X509 = " \
 glibc \
 openssl-libs \
 perl-Convert-ASN1 \
 perl-Exporter \
 perl-base \
 perl-libs \
 perl-version \
 "
