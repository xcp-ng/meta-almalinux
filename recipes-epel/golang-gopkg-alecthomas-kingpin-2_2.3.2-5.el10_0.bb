# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-gopkg-alecthomas-kingpin-2"
PV = "2.3.2"
PR = "5.el10_0"
PACKAGES = " \
 golang-gopkg-alecthomas-kingpin-2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-gopkg-alecthomas-kingpin-2-2.3.2-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4acb7222eaeb73db5cac7cb91e2231a5c5c5c6fb3fa5e0653423b5c15afe55f7"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - golang-gopkg-alecthomas-kingpin-2-devel: golang(github.com/alecthomas/units)

URI_x86_64_v2_golang-gopkg-alecthomas-kingpin-2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-gopkg-alecthomas-kingpin-2-devel-2.3.2-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-gopkg-alecthomas-kingpin-2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-gopkg-alecthomas-kingpin-2-devel}"
SRC_URI[x86_64_v2_golang-gopkg-alecthomas-kingpin-2-devel.sha256sum] = "0d1792948b0b3209372f8250d0770bce7be061d8a9f46c4236f22b84d6322c6b"

URI_aarch64_golang-gopkg-alecthomas-kingpin-2-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-gopkg-alecthomas-kingpin-2-devel-2.3.2-5.el10_0.noarch.rpm;name=aarch64_golang-gopkg-alecthomas-kingpin-2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-gopkg-alecthomas-kingpin-2-devel}"
SRC_URI[aarch64_golang-gopkg-alecthomas-kingpin-2-devel.sha256sum] = "5cce7ae6997cd244c27559b03ee771495581e1a056e2b2ed5356535e0d136969"

RDEPENDS:golang-gopkg-alecthomas-kingpin-2-devel:x86_64_v2 = " \
 go-filesystem \
 golang-github-xhit-str2duration2-devel \
"
RDEPENDS:golang-gopkg-alecthomas-kingpin-2-devel:aarch64 = " \
 go-filesystem \
 golang-github-alecthomas-units-devel \
 golang-github-xhit-str2duration2-devel \
"
