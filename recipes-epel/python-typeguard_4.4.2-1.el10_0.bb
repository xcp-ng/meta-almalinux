# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-typeguard"
PV = "4.4.2"
PR = "1.el10_0"
PACKAGES = " \
 python3-typeguard \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-typeguard-4.4.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c143590e1a270e9559a4ddba9dcf0ec7ade7af0d64ef88fc22a4ec8127c2007"

URI_x86_64_v2_python3-typeguard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-typeguard-4.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-typeguard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-typeguard}"
SRC_URI[x86_64_v2_python3-typeguard.sha256sum] = "3b3565b810b2ad16fc71bfe0b75d6ff315f760b42f28e14f6b17ea877fd5e7d7"

URI_aarch64_python3-typeguard = "${EPEL_MIRROR}/aarch64/Packages/p/python3-typeguard-4.4.2-1.el10_0.noarch.rpm;name=aarch64_python3-typeguard;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-typeguard}"
SRC_URI[aarch64_python3-typeguard.sha256sum] = "d36016b78e77b9d7eafc07fc186238953276ad59bdfeadf8e54ff5604df2f435"

RDEPENDS:python3-typeguard = " \
 python3 \
 python3-typing-extensions \
 "
