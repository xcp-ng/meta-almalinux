# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-concurrent-queue"
PV = "2.5.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-concurrent-queue+default-devel \
 rust-concurrent-queue+portable-atomic-devel \
 rust-concurrent-queue+std-devel \
 rust-concurrent-queue-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-concurrent-queue-2.5.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e80c63957ce29ba81cce38857b1553317c3b0c5624903aa05016b52949468e7"

URI_x86_64_v2_rust-concurrent-queue+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-concurrent-queue+default-devel-2.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-concurrent-queue+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-concurrent-queue+default-devel}"
SRC_URI[x86_64_v2_rust-concurrent-queue+default-devel.sha256sum] = "09c6d446b3622ed0483baef8b30073d82dceebbc9159dc11b7565f4546b46aca"

URI_x86_64_v2_rust-concurrent-queue+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-concurrent-queue+portable-atomic-devel-2.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-concurrent-queue+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-concurrent-queue+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-concurrent-queue+portable-atomic-devel.sha256sum] = "0db652be624ce291e6d3f1ebe02210ce81fdf82640959e4a78e2f037df1a0f15"

URI_x86_64_v2_rust-concurrent-queue+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-concurrent-queue+std-devel-2.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-concurrent-queue+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-concurrent-queue+std-devel}"
SRC_URI[x86_64_v2_rust-concurrent-queue+std-devel.sha256sum] = "75380172916a6d58504ab8802e02fe4ec5e80f68b242de0ebaf1de10a5928682"

URI_x86_64_v2_rust-concurrent-queue-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-concurrent-queue-devel-2.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-concurrent-queue-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-concurrent-queue-devel}"
SRC_URI[x86_64_v2_rust-concurrent-queue-devel.sha256sum] = "74b7e0aa27656ffc8572807a58f24cbfbae26d8b40358b68b69a07d897847f9d"

URI_aarch64_rust-concurrent-queue+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-concurrent-queue+default-devel-2.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-concurrent-queue+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-concurrent-queue+default-devel}"
SRC_URI[aarch64_rust-concurrent-queue+default-devel.sha256sum] = "80dec83da3e215d579f32ac6b3900f4c64685b0cc86409ed438e13f8f01eadb5"

URI_aarch64_rust-concurrent-queue+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-concurrent-queue+portable-atomic-devel-2.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-concurrent-queue+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-concurrent-queue+portable-atomic-devel}"
SRC_URI[aarch64_rust-concurrent-queue+portable-atomic-devel.sha256sum] = "877cedbea641f3e902dcbc320e6e1bbcf0e8c579eff09dc811f8fba99aba35fa"

URI_aarch64_rust-concurrent-queue+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-concurrent-queue+std-devel-2.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-concurrent-queue+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-concurrent-queue+std-devel}"
SRC_URI[aarch64_rust-concurrent-queue+std-devel.sha256sum] = "3441bd722c6ad1f62d6f9b45a496fca833209a09f2fed46e4a3d71582eb82fa3"

URI_aarch64_rust-concurrent-queue-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-concurrent-queue-devel-2.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-concurrent-queue-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-concurrent-queue-devel}"
SRC_URI[aarch64_rust-concurrent-queue-devel.sha256sum] = "c7b0d663ce8e9133df2f3dce40d3fd328126535365b808ea893477b38b201784"

RDEPENDS:rust-concurrent-queue+default-devel = " \
 cargo \
 rust-concurrent-queue+std-devel \
 rust-concurrent-queue-devel \
 "
RDEPENDS:rust-concurrent-queue+portable-atomic-devel = " \
 cargo \
 rust-concurrent-queue-devel \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-concurrent-queue+std-devel = " \
 cargo \
 rust-concurrent-queue-devel \
 "
RDEPENDS:rust-concurrent-queue-devel = " \
 cargo \
 rust \
 rust-crossbeam-utils-devel \
 "
