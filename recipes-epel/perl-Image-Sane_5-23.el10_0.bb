# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Image-Sane"
PV = "5"
PR = "23.el10_0"
PACKAGES = " \
 perl-Image-Sane \
 perl-Image-Sane-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Image-Sane-5-23.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "826a87f58548dfbbaca23ffdc4acc8a523742a28f78b408151502c28720823f4"

URI_x86_64_v2_perl-Image-Sane = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Image-Sane-5-23.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Image-Sane;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Image-Sane}"
SRC_URI[x86_64_v2_perl-Image-Sane.sha256sum] = "c1a7e27719fb5f0af2e2d257a64f91dc8236e14c04aeccf3feedbe9821ac8a51"

URI_x86_64_v2_perl-Image-Sane-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Image-Sane-tests-5-23.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Image-Sane-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Image-Sane-tests}"
SRC_URI[x86_64_v2_perl-Image-Sane-tests.sha256sum] = "0ae0a5e5c34dd3c4326019815a3270c782397f203584a2dfe38ce7a11ea13109"

URI_aarch64_perl-Image-Sane = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Image-Sane-5-23.el10_0.aarch64.rpm;name=aarch64_perl-Image-Sane;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Image-Sane}"
SRC_URI[aarch64_perl-Image-Sane.sha256sum] = "88fcfb45f9a626408a6e18ad13e8fa2ffaff5beabb514718f14f1278e2130d89"

URI_aarch64_perl-Image-Sane-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Image-Sane-tests-5-23.el10_0.noarch.rpm;name=aarch64_perl-Image-Sane-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Image-Sane-tests}"
SRC_URI[aarch64_perl-Image-Sane-tests.sha256sum] = "6caf2564b31330fe794b7448a1ec493dfffc81c9ec21f11f73406cdd9060fd7d"

RDEPENDS:perl-Image-Sane = " \
 glibc \
 perl-Exception-Class \
 perl-Exporter \
 perl-Readonly \
 perl-base \
 perl-libs \
 sane-backends-libs \
 "
RDEPENDS:perl-Image-Sane-tests = " \
 ImageMagick \
 bash \
 perl-English \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-IO \
 perl-Image-Sane \
 perl-Readonly \
 perl-Test-Harness \
 perl-Test-Requires \
 perl-Test-Simple \
 perl-Try-Tiny \
 perl-interpreter \
 perl-libs \
 perl-sigtrap \
 sane-backends \
 sane-backends-drivers-scanners \
 virtual/coreutils \
 "
