# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand0.8"
PV = "0.8.8"
PR = "1.el10_2"
PACKAGES = " \
 rust-rand0.8+alloc-devel \
 rust-rand0.8+default-devel \
 rust-rand0.8+getrandom-devel \
 rust-rand0.8+libc-devel \
 rust-rand0.8+log-devel \
 rust-rand0.8+min_const_gen-devel \
 rust-rand0.8+rand_chacha-devel \
 rust-rand0.8+serde-devel \
 rust-rand0.8+serde1-devel \
 rust-rand0.8+small_rng-devel \
 rust-rand0.8+std-devel \
 rust-rand0.8+std_rng-devel \
 rust-rand0.8-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-rand0.8-0.8.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a07a4ca8816aad4b02c915d32ae09644ee5be32a633b16865a680add4b19acf8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+alloc-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand0.8+alloc-devel.sha256sum] = "001567a2344fe8b2e055d37a76ba55b290f00d8c697a7092e404d0aac973f0bf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+default-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand0.8+default-devel.sha256sum] = "4aa802848bbedc213f5b0ccae0a73704b54b9431168ab5a809da761ed0f2aa30"
RPROVIDES:rust-rand0.8+default-devel:append:x86_64_v2 = " virtual/crate_rand/default__ge_0.3.10_with_crate_rand/default__lt_0.9.0~"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+getrandom-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+getrandom-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand0.8+getrandom-devel.sha256sum] = "bb475fc47c8c6d96f663761f47cda22fc06604b2aa2c3aa2a49bc7a19bf1686d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+libc-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+libc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand0.8+libc-devel.sha256sum] = "60a70c16afcf47ddfd728836ac72adef50bb51c0ca050f4464771d7dada11dd7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+log-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+log-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand0.8+log-devel.sha256sum] = "1322a59e4440feba2076669847120206ce924ce89fec349e7720947db6f2b99f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+min_const_gen-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+min_const_gen-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand0.8+min_const_gen-devel.sha256sum] = "6196096219e91d26d2528a8ec25e3f361a54c7f80cc023000c94955206a481c7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+rand_chacha-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+rand_chacha-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand0.8+rand_chacha-devel.sha256sum] = "7324a79993af204b22cacca670c8b03b3a4f2fd7d8a2cadb9cc4c918d01b180f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+serde-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand0.8+serde-devel.sha256sum] = "bb5d20cd7b24caf01b59f42dc287cb2a88d5a5bcbdfdce8f54ba23e145d78eeb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+serde1-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+serde1-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand0.8+serde1-devel.sha256sum] = "d6b8c3d22e40cebb8acb887b5d73e15539d7c1ddb960b0f287ccf14f2a5c1a6b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+small_rng-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+small_rng-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand0.8+small_rng-devel.sha256sum] = "258aa53ed26da37edea31a3540f0cd4b19faf24195b6d7776a6b1daa4d7b652f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+std-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand0.8+std-devel.sha256sum] = "c55c142f55459d1654dac4b70a67b49fd1f837f8014c74723d3505fa1302443f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+std_rng-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+std_rng-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand0.8+std_rng-devel.sha256sum] = "814371c917364bd32969a66ce2aaa048d4e65e2c88c3e6a46b1bfb28c73f27aa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand0.8-devel.sha256sum] = "0df363dc2a1bf63e8d5a977fcb5596d687b0307fa5fdcc5f7eecb8a288c9ab0d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+alloc-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.8+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-rand0.8+alloc-devel.sha256sum] = "8c6067c5a0f207b37bc1dd1c3e3eb944abe5362ce3966415d0fa005dcf0c06c3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+default-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.8+default-devel;unpack=0"
SRC_URI[aarch64_rust-rand0.8+default-devel.sha256sum] = "4e4322d62df8fbe7264dbbaea000efc857969ac36acf2591ffe417810bc9accc"
RPROVIDES:rust-rand0.8+default-devel:append:aarch64 = " virtual/crate_rand/default__ge_0.3.10_with_crate_rand/default__lt_0.9.0~"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+getrandom-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.8+getrandom-devel;unpack=0"
SRC_URI[aarch64_rust-rand0.8+getrandom-devel.sha256sum] = "e271fe9f8730a66b030c5c8deb040fa8c7a7fb1ef47aa78477598439192380df"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+libc-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.8+libc-devel;unpack=0"
SRC_URI[aarch64_rust-rand0.8+libc-devel.sha256sum] = "a3cb842e8a1753d45123e6c11827919d5e1c0f684b5303d6ed2d0012759ad4c9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+log-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.8+log-devel;unpack=0"
SRC_URI[aarch64_rust-rand0.8+log-devel.sha256sum] = "ffb5a5c66021f3a648bc3ddb18008176fb2a65415a50ec5666e342ce89f81dfa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+min_const_gen-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.8+min_const_gen-devel;unpack=0"
SRC_URI[aarch64_rust-rand0.8+min_const_gen-devel.sha256sum] = "7982532f05c07494cfbddde22a606889c399e1aeb6e0ada25baeab39726b154f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+rand_chacha-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.8+rand_chacha-devel;unpack=0"
SRC_URI[aarch64_rust-rand0.8+rand_chacha-devel.sha256sum] = "6cd6ee21355098bdb689763da4c6cca3af8a0b38c6a67446889f4f23d4f2cfe3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+serde-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.8+serde-devel;unpack=0"
SRC_URI[aarch64_rust-rand0.8+serde-devel.sha256sum] = "ce6569c0ef535b00cf2578bdde7115263cfb3414b0c984893fe1e7d432437d95"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+serde1-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.8+serde1-devel;unpack=0"
SRC_URI[aarch64_rust-rand0.8+serde1-devel.sha256sum] = "192b18fda442a985a3ff0f47b71d7fa44a908122ffd6b08f6804e2796511bb49"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+small_rng-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.8+small_rng-devel;unpack=0"
SRC_URI[aarch64_rust-rand0.8+small_rng-devel.sha256sum] = "5309613d9b4d0b361bdc5f8c8dab1df5e609e7652ff268c08ff1d77ce1339cc3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+std-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.8+std-devel;unpack=0"
SRC_URI[aarch64_rust-rand0.8+std-devel.sha256sum] = "50259d9161773bc7e5e8018b2266765c395f1465effddf6b8abeef6f86fd9320"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+std_rng-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.8+std_rng-devel;unpack=0"
SRC_URI[aarch64_rust-rand0.8+std_rng-devel.sha256sum] = "15e8923402594f1a8c0bbef79a455452fa486b61dced7225fbda0ae821b4d0cc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.8-devel;unpack=0"
SRC_URI[aarch64_rust-rand0.8-devel.sha256sum] = "bc436e2a164952764659a150353744754c77adbfb82c4a24e053b6bc4f5898e2"

RDEPENDS:rust-rand0.8+alloc-devel = " \
 cargo \
 rust-rand0.8-devel \
 rust-rand_core0.6+alloc-devel \
 "
RDEPENDS:rust-rand0.8+default-devel = " \
 cargo \
 rust-rand0.8+std-devel \
 rust-rand0.8+std_rng-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-rand0.8+getrandom-devel = " \
 cargo \
 rust-rand0.8-devel \
 rust-rand_core0.6+getrandom-devel \
 "
RDEPENDS:rust-rand0.8+libc-devel = " \
 cargo \
 rust-libc-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-rand0.8+log-devel = " \
 cargo \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-rand0.8+min_const_gen-devel = " \
 cargo \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-rand0.8+rand_chacha-devel = " \
 cargo \
 rust-rand0.8-devel \
 rust-rand_chacha0.3-devel \
 "
RDEPENDS:rust-rand0.8+serde-devel = " \
 cargo \
 rust-rand0.8-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand0.8+serde1-devel = " \
 cargo \
 rust-rand0.8+serde-devel \
 rust-rand0.8-devel \
 rust-rand_core0.6+serde1-devel \
 "
RDEPENDS:rust-rand0.8+small_rng-devel = " \
 cargo \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-rand0.8+std-devel = " \
 cargo \
 rust-rand0.8+alloc-devel \
 rust-rand0.8+getrandom-devel \
 rust-rand0.8+libc-devel \
 rust-rand0.8-devel \
 rust-rand_chacha0.3+std-devel \
 rust-rand_chacha0.3-devel \
 rust-rand_core0.6+std-devel \
 "
RDEPENDS:rust-rand0.8+std_rng-devel = " \
 cargo \
 rust-rand0.8+rand_chacha-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-rand0.8-devel = " \
 cargo \
 rust-rand_core0.6+default-devel \
 "
