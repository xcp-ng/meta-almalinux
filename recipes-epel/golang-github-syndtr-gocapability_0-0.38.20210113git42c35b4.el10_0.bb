# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-syndtr-gocapability"
PV = "0"
PR = "0.38.20210113git42c35b4.el10_0"
PACKAGES = " \
 golang-github-syndtr-gocapability-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-syndtr-gocapability-0-0.38.20210113git42c35b4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b3f9631f2c0249576ca5ce2bbd5049888d3332bffc096dd06c6de146ab69832"

URI_aarch64_golang-github-syndtr-gocapability-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-syndtr-gocapability-devel-0-0.38.20210113git42c35b4.el10_0.noarch.rpm;name=aarch64_golang-github-syndtr-gocapability-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-syndtr-gocapability-devel}"
SRC_URI[aarch64_golang-github-syndtr-gocapability-devel.sha256sum] = "3db5b1741468d2d69e101ec6af731aa8960acd193e1782b32fd844179bd76ffa"

RDEPENDS:golang-github-syndtr-gocapability-devel = " \
 go-filesystem \
 "
