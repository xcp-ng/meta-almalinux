# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-jiff"
PV = "0.2.15"
PR = "1.el10_0"
PACKAGES = " \
 rust-jiff+alloc-devel \
 rust-jiff+default-devel \
 rust-jiff+logging-devel \
 rust-jiff+perf-inline-devel \
 rust-jiff+serde-devel \
 rust-jiff+std-devel \
 rust-jiff+tz-fat-devel \
 rust-jiff+tz-system-devel \
 rust-jiff+tzdb-bundle-platform-devel \
 rust-jiff+tzdb-concatenated-devel \
 rust-jiff+tzdb-zoneinfo-devel \
 rust-jiff-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-jiff-0.2.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1a4063a861911e599d64afe0f2cfb33dd4d78957ca5695674877e96664f6e9b2"

URI_x86_64_v2_rust-jiff+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+alloc-devel-0.2.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+alloc-devel}"
SRC_URI[x86_64_v2_rust-jiff+alloc-devel.sha256sum] = "76aec422817a65f597c3a5ea59746aa6532a08ef6630ba574de18a3615d8407b"

URI_x86_64_v2_rust-jiff+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+default-devel-0.2.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+default-devel}"
SRC_URI[x86_64_v2_rust-jiff+default-devel.sha256sum] = "4ed884d6e94d73087afd3bba8b54dabb6f67df7420ef11462bdc9e8ce0d92154"

URI_x86_64_v2_rust-jiff+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+logging-devel-0.2.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+logging-devel}"
SRC_URI[x86_64_v2_rust-jiff+logging-devel.sha256sum] = "fd59b4ccbcfaf254e85f5d1fc6519c96f6887228eefd7682cc8dd5053654addc"

URI_x86_64_v2_rust-jiff+perf-inline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+perf-inline-devel-0.2.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+perf-inline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+perf-inline-devel}"
SRC_URI[x86_64_v2_rust-jiff+perf-inline-devel.sha256sum] = "3700577cfbf4a7ae6c8ede178628c0ab92c9cb5dbb12178b7804444d87dfb8ac"

URI_x86_64_v2_rust-jiff+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+serde-devel-0.2.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+serde-devel}"
SRC_URI[x86_64_v2_rust-jiff+serde-devel.sha256sum] = "00c2898911d25ebb04b581c4ff7f35e676aeac75c70866bac164a309172d5d44"

URI_x86_64_v2_rust-jiff+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+std-devel-0.2.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+std-devel}"
SRC_URI[x86_64_v2_rust-jiff+std-devel.sha256sum] = "d68ee2cf5acc360b72287678fc18255699f3d1a6b5654ce9473e03d578d641fd"

URI_x86_64_v2_rust-jiff+tz-fat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+tz-fat-devel-0.2.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+tz-fat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+tz-fat-devel}"
SRC_URI[x86_64_v2_rust-jiff+tz-fat-devel.sha256sum] = "1048b85b7dfb9e38897150f245d1af40b8a5fd91954e63230fce33dc157d93c9"

URI_x86_64_v2_rust-jiff+tz-system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+tz-system-devel-0.2.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+tz-system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+tz-system-devel}"
SRC_URI[x86_64_v2_rust-jiff+tz-system-devel.sha256sum] = "47e01c5c8de9a1d3e7fb4afa3671db35f02bca875d8ae2217ddcb31d5b4a6a03"

URI_x86_64_v2_rust-jiff+tzdb-bundle-platform-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+tzdb-bundle-platform-devel-0.2.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+tzdb-bundle-platform-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+tzdb-bundle-platform-devel}"
SRC_URI[x86_64_v2_rust-jiff+tzdb-bundle-platform-devel.sha256sum] = "ace6149f92f3c5883c355f823b3483c0226361bf527889ebcafd6713b1e073bd"

URI_x86_64_v2_rust-jiff+tzdb-concatenated-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+tzdb-concatenated-devel-0.2.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+tzdb-concatenated-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+tzdb-concatenated-devel}"
SRC_URI[x86_64_v2_rust-jiff+tzdb-concatenated-devel.sha256sum] = "42167124ee3deb63a4efc9fffef3f22118e649f84212f69348b7ef974e44489e"

URI_x86_64_v2_rust-jiff+tzdb-zoneinfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+tzdb-zoneinfo-devel-0.2.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+tzdb-zoneinfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+tzdb-zoneinfo-devel}"
SRC_URI[x86_64_v2_rust-jiff+tzdb-zoneinfo-devel.sha256sum] = "c973dc089d1617bbc6e23dfdc90329472c63ccff1f43c4cd535e0f1f086d30e1"

URI_x86_64_v2_rust-jiff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff-devel-0.2.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff-devel}"
SRC_URI[x86_64_v2_rust-jiff-devel.sha256sum] = "a5abaaf86575b4b642ff5e11ba551f9bc00b5f155b79ae3fc9705ed164c1fde8"

URI_aarch64_rust-jiff+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+alloc-devel-0.2.15-1.el10_0.noarch.rpm;name=aarch64_rust-jiff+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+alloc-devel}"
SRC_URI[aarch64_rust-jiff+alloc-devel.sha256sum] = "e41185a1ec501fad2f526d5f3ffbdbce45b8bac5d3d093c27c7722b4b29eef6d"

URI_aarch64_rust-jiff+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+default-devel-0.2.15-1.el10_0.noarch.rpm;name=aarch64_rust-jiff+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+default-devel}"
SRC_URI[aarch64_rust-jiff+default-devel.sha256sum] = "fc7104eb65b0ff3204f1ac9f13bc6274793cf294469c554c153330a42045e42e"

URI_aarch64_rust-jiff+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+logging-devel-0.2.15-1.el10_0.noarch.rpm;name=aarch64_rust-jiff+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+logging-devel}"
SRC_URI[aarch64_rust-jiff+logging-devel.sha256sum] = "3dc7e2fffde9df639148272836b5af1e9fd1be83a91e2d6342d53955dfba2b04"

URI_aarch64_rust-jiff+perf-inline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+perf-inline-devel-0.2.15-1.el10_0.noarch.rpm;name=aarch64_rust-jiff+perf-inline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+perf-inline-devel}"
SRC_URI[aarch64_rust-jiff+perf-inline-devel.sha256sum] = "38fa94b88a2a223a43bab5762e951d0c79059775e602f4597bca3cef75696ee1"

URI_aarch64_rust-jiff+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+serde-devel-0.2.15-1.el10_0.noarch.rpm;name=aarch64_rust-jiff+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+serde-devel}"
SRC_URI[aarch64_rust-jiff+serde-devel.sha256sum] = "ff34735aadd80568f4cd38ae6ac3e85701203ab65b31219a08343e2c14b21233"

URI_aarch64_rust-jiff+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+std-devel-0.2.15-1.el10_0.noarch.rpm;name=aarch64_rust-jiff+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+std-devel}"
SRC_URI[aarch64_rust-jiff+std-devel.sha256sum] = "0f3570a146f65a91588326713a2150a5a6c069b5921363520ca2e3390d3e523a"

URI_aarch64_rust-jiff+tz-fat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+tz-fat-devel-0.2.15-1.el10_0.noarch.rpm;name=aarch64_rust-jiff+tz-fat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+tz-fat-devel}"
SRC_URI[aarch64_rust-jiff+tz-fat-devel.sha256sum] = "2af17cdaefdd59dfa8d74d600125a863b22e3af4c37f5777b831fd07b368fce6"

URI_aarch64_rust-jiff+tz-system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+tz-system-devel-0.2.15-1.el10_0.noarch.rpm;name=aarch64_rust-jiff+tz-system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+tz-system-devel}"
SRC_URI[aarch64_rust-jiff+tz-system-devel.sha256sum] = "ceb99b858b041d8ca24feb228bc14f23b911db2ecc0beb3ee7e82f9f496f18fb"

URI_aarch64_rust-jiff+tzdb-bundle-platform-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+tzdb-bundle-platform-devel-0.2.15-1.el10_0.noarch.rpm;name=aarch64_rust-jiff+tzdb-bundle-platform-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+tzdb-bundle-platform-devel}"
SRC_URI[aarch64_rust-jiff+tzdb-bundle-platform-devel.sha256sum] = "87dbdccf95bbb8d02a908882b223bbc3a44c5ba30c5a4886640c91f8c78f4edb"

URI_aarch64_rust-jiff+tzdb-concatenated-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+tzdb-concatenated-devel-0.2.15-1.el10_0.noarch.rpm;name=aarch64_rust-jiff+tzdb-concatenated-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+tzdb-concatenated-devel}"
SRC_URI[aarch64_rust-jiff+tzdb-concatenated-devel.sha256sum] = "613ea366ed68c69161254d2f0037a918b0e49911b788b2cd17ce8b234f3eebd9"

URI_aarch64_rust-jiff+tzdb-zoneinfo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+tzdb-zoneinfo-devel-0.2.15-1.el10_0.noarch.rpm;name=aarch64_rust-jiff+tzdb-zoneinfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+tzdb-zoneinfo-devel}"
SRC_URI[aarch64_rust-jiff+tzdb-zoneinfo-devel.sha256sum] = "3e868835a0211046cb3120360b3d14ac0c6db241471239f33d44db40eccc49ca"

URI_aarch64_rust-jiff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff-devel-0.2.15-1.el10_0.noarch.rpm;name=aarch64_rust-jiff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff-devel}"
SRC_URI[aarch64_rust-jiff-devel.sha256sum] = "4351e8e657f5fc33fba4250e739ade1587c10e4be342b05174e562eca81e68a5"

RDEPENDS:rust-jiff+alloc-devel = " \
 cargo \
 rust-jiff-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-jiff+default-devel = " \
 cargo \
 rust-jiff+perf-inline-devel \
 rust-jiff+std-devel \
 rust-jiff+tz-fat-devel \
 rust-jiff+tz-system-devel \
 rust-jiff+tzdb-bundle-platform-devel \
 rust-jiff+tzdb-concatenated-devel \
 rust-jiff+tzdb-zoneinfo-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff+logging-devel = " \
 cargo \
 rust-jiff-devel \
 rust-log-devel \
 "
RDEPENDS:rust-jiff+perf-inline-devel = " \
 cargo \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff+serde-devel = " \
 cargo \
 rust-jiff-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-jiff+std-devel = " \
 cargo \
 rust-jiff+alloc-devel \
 rust-jiff-devel \
 rust-log+std-devel \
 rust-log-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-jiff+tz-fat-devel = " \
 cargo \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff+tz-system-devel = " \
 cargo \
 rust-jiff+std-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff+tzdb-bundle-platform-devel = " \
 cargo \
 rust-jiff+alloc-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff+tzdb-concatenated-devel = " \
 cargo \
 rust-jiff+std-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff+tzdb-zoneinfo-devel = " \
 cargo \
 rust-jiff+std-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff-devel = " \
 cargo \
 rust \
 "
