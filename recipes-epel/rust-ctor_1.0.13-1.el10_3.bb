# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ctor"
PV = "1.0.13"
PR = "1.el10_3"
PACKAGES = " \
 rust-ctor+default-devel \
 rust-ctor+priority-devel \
 rust-ctor+proc_macro-devel \
 rust-ctor+std-devel \
 rust-ctor-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-ctor-1.0.13-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "301adbf8f4691525cf8eb588fb9310af292d247efd4b64d094519bd84dbf5fbc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctor+default-devel-1.0.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctor+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ctor+default-devel.sha256sum] = "63e0bf72c5742ac41e8105af18a4d30df4ddfdb1f22c8534690fdb8e9d668d91"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctor+priority-devel-1.0.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctor+priority-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ctor+priority-devel.sha256sum] = "1c22820b9ed29723325ae68b06d556a07f6fe70d7edf631ac59e5d090d8329a6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctor+proc_macro-devel-1.0.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctor+proc_macro-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ctor+proc_macro-devel.sha256sum] = "a394ec882ad1d9554b297e11b6c468a40cc0f0c26b57ca11b9c46267d747b820"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctor+std-devel-1.0.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctor+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ctor+std-devel.sha256sum] = "fc70d4aa97c6eaed56c6992f28aaf03b201406808f3a9a4d0d64e5829bff647d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctor-devel-1.0.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctor-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ctor-devel.sha256sum] = "c93638fa1a7ae04e9059a82ad0c3e375252ab821b48d790f621fe1c13ff9580e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ctor+default-devel-1.0.13-1.el10_3.noarch.rpm;name=aarch64_rust-ctor+default-devel;unpack=0"
SRC_URI[aarch64_rust-ctor+default-devel.sha256sum] = "27e8b2a18a6b007dc71296365c2c2450e953a66beb0d975962662098329984d9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ctor+priority-devel-1.0.13-1.el10_3.noarch.rpm;name=aarch64_rust-ctor+priority-devel;unpack=0"
SRC_URI[aarch64_rust-ctor+priority-devel.sha256sum] = "865bc2eed86ac9e642bb5be68f5563799935bfabdec558e7fecdfe4ea9339d21"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ctor+proc_macro-devel-1.0.13-1.el10_3.noarch.rpm;name=aarch64_rust-ctor+proc_macro-devel;unpack=0"
SRC_URI[aarch64_rust-ctor+proc_macro-devel.sha256sum] = "b4281c30132791eca18f26ac1044a0a842553dd0f0f3659461111ce91d7ea2b9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ctor+std-devel-1.0.13-1.el10_3.noarch.rpm;name=aarch64_rust-ctor+std-devel;unpack=0"
SRC_URI[aarch64_rust-ctor+std-devel.sha256sum] = "f651c491d1f61001ab187e34ff2d8e061310bf163c313fa722646cc35dc7bc43"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ctor-devel-1.0.13-1.el10_3.noarch.rpm;name=aarch64_rust-ctor-devel;unpack=0"
SRC_URI[aarch64_rust-ctor-devel.sha256sum] = "ca5d37991a2786d2d1769fe7347dfb8026d7c478704098420237a64519b241fc"

RDEPENDS:rust-ctor+default-devel = " \
 cargo \
 rust-ctor+priority-devel \
 rust-ctor+proc_macro-devel \
 rust-ctor+std-devel \
 rust-ctor-devel \
 "
RDEPENDS:rust-ctor+priority-devel = " \
 cargo \
 rust-ctor-devel \
 rust-link-section-devel \
 "
RDEPENDS:rust-ctor+proc_macro-devel = " \
 cargo \
 rust-ctor-devel \
 rust-linktime-proc-macro+ctor-devel \
 rust-linktime-proc-macro+default-devel \
 "
RDEPENDS:rust-ctor+std-devel = " \
 cargo \
 rust-ctor-devel \
 "
RDEPENDS:rust-ctor-devel = " \
 cargo \
 rust \
 "
