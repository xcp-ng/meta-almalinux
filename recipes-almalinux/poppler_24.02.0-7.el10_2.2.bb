# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "poppler"
PV = "24.02.0"
PR = "7.el10_2.2"
PACKAGES = " \
 poppler \
 poppler-cpp \
 poppler-cpp-devel \
 poppler-devel \
 poppler-glib \
 poppler-glib-devel \
 poppler-glib-doc \
 poppler-qt6 \
 poppler-qt6-devel \
 poppler-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/poppler-24.02.0-7.el10_2.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4efc1b7438c9643b41fe87ea785e252976b83c3dcca98b8ee202ab7adbb5d7a4"

URI_x86_64_v2_poppler = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/poppler-24.02.0-7.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_poppler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poppler}"
SRC_URI[x86_64_v2_poppler.sha256sum] = "38a1245eb58b5004b344676b8f53fbc1ceb9cfde2b6a115ad12aee7632db539f"

URI_x86_64_v2_poppler-cpp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/poppler-cpp-24.02.0-7.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_poppler-cpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poppler-cpp}"
SRC_URI[x86_64_v2_poppler-cpp.sha256sum] = "5c61c163bfbb035fb8b04073120cd844414227d973a43dc2e136b244d2d49415"

URI_x86_64_v2_poppler-cpp-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/poppler-cpp-devel-24.02.0-7.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_poppler-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poppler-cpp-devel}"
SRC_URI[x86_64_v2_poppler-cpp-devel.sha256sum] = "4769acddbd20d2e4331b002c8097bc0620c8410c955289f8c0160e936a3908dd"

URI_x86_64_v2_poppler-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/poppler-devel-24.02.0-7.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_poppler-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poppler-devel}"
SRC_URI[x86_64_v2_poppler-devel.sha256sum] = "1840c1b79f9103ec56345ce33442ad21ec733659698a2ccb6d2480df75ad0faf"

URI_x86_64_v2_poppler-glib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/poppler-glib-24.02.0-7.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_poppler-glib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poppler-glib}"
SRC_URI[x86_64_v2_poppler-glib.sha256sum] = "89250732893718850ee028135d66bc5ed3babf58ffd2713a76239bcf91051280"

URI_x86_64_v2_poppler-glib-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/poppler-glib-devel-24.02.0-7.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_poppler-glib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poppler-glib-devel}"
SRC_URI[x86_64_v2_poppler-glib-devel.sha256sum] = "18942a3e2435ea6d168a9d34296f1686aecf86748b4d41e4a935cbbc5e426d78"

URI_x86_64_v2_poppler-glib-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/poppler-glib-doc-24.02.0-7.el10_2.2.noarch.rpm;name=x86_64_v2_poppler-glib-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poppler-glib-doc}"
SRC_URI[x86_64_v2_poppler-glib-doc.sha256sum] = "db944170f7397aa5dc0f76041aa8a845f45fb3b697972932e97a17ef5e15cf48"

URI_x86_64_v2_poppler-qt6 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/poppler-qt6-24.02.0-7.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_poppler-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poppler-qt6}"
SRC_URI[x86_64_v2_poppler-qt6.sha256sum] = "14cde8cc52188ee609acac05c78c653c76c304045a519823140c5673c5bde60c"

URI_x86_64_v2_poppler-qt6-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/poppler-qt6-devel-24.02.0-7.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_poppler-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poppler-qt6-devel}"
SRC_URI[x86_64_v2_poppler-qt6-devel.sha256sum] = "8c94701ac59c68b482cfc0eeeb03119cac94590f29557f31a2f4f783f0d915ac"

URI_x86_64_v2_poppler-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/poppler-utils-24.02.0-7.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_poppler-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poppler-utils}"
SRC_URI[x86_64_v2_poppler-utils.sha256sum] = "e3b8a6da5f1c1678f661f1ae9947208773140a4054d1170c2477033513670f83"

URI_aarch64_poppler = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/poppler-24.02.0-7.el10_2.2.aarch64.rpm;name=aarch64_poppler;unpack=0"
SRC_URI:append = " ${URI_aarch64_poppler}"
SRC_URI[aarch64_poppler.sha256sum] = "e64440c341a78c7ebf74e39de386bfb3c5a94944f2368282aa58141aa2ad99b4"

URI_aarch64_poppler-cpp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/poppler-cpp-24.02.0-7.el10_2.2.aarch64.rpm;name=aarch64_poppler-cpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_poppler-cpp}"
SRC_URI[aarch64_poppler-cpp.sha256sum] = "87879eddb478b056046aa7fe72fa05256ed064311a4e734265708f762bece473"

URI_aarch64_poppler-cpp-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/poppler-cpp-devel-24.02.0-7.el10_2.2.aarch64.rpm;name=aarch64_poppler-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_poppler-cpp-devel}"
SRC_URI[aarch64_poppler-cpp-devel.sha256sum] = "f7300edeccbeda55818a7d1b2106da9c3281a8039ef0fef1b8d5844e4aa26822"

URI_aarch64_poppler-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/poppler-devel-24.02.0-7.el10_2.2.aarch64.rpm;name=aarch64_poppler-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_poppler-devel}"
SRC_URI[aarch64_poppler-devel.sha256sum] = "5f009650cc5d36c17fcc5968f870515947ef82256d0429cd1074c0d447d61c91"

URI_aarch64_poppler-glib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/poppler-glib-24.02.0-7.el10_2.2.aarch64.rpm;name=aarch64_poppler-glib;unpack=0"
SRC_URI:append = " ${URI_aarch64_poppler-glib}"
SRC_URI[aarch64_poppler-glib.sha256sum] = "628b49d9a04c25287aee6b1611a55d1aff3cc35303426d563b681cc09635025d"

URI_aarch64_poppler-glib-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/poppler-glib-devel-24.02.0-7.el10_2.2.aarch64.rpm;name=aarch64_poppler-glib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_poppler-glib-devel}"
SRC_URI[aarch64_poppler-glib-devel.sha256sum] = "3173889078900acb9b7593e4023e07e2ea5f18d96ac5d52b01c65505a4c27274"

URI_aarch64_poppler-glib-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/poppler-glib-doc-24.02.0-7.el10_2.2.noarch.rpm;name=aarch64_poppler-glib-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_poppler-glib-doc}"
SRC_URI[aarch64_poppler-glib-doc.sha256sum] = "db944170f7397aa5dc0f76041aa8a845f45fb3b697972932e97a17ef5e15cf48"

URI_aarch64_poppler-qt6 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/poppler-qt6-24.02.0-7.el10_2.2.aarch64.rpm;name=aarch64_poppler-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_poppler-qt6}"
SRC_URI[aarch64_poppler-qt6.sha256sum] = "7ccef2a3a5310a5f6078fbda04de35686bb1730cf536f82a844ba545c6f49098"

URI_aarch64_poppler-qt6-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/poppler-qt6-devel-24.02.0-7.el10_2.2.aarch64.rpm;name=aarch64_poppler-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_poppler-qt6-devel}"
SRC_URI[aarch64_poppler-qt6-devel.sha256sum] = "94be59959a129311e2d50162e519c059f9c60c18defe9f42ea50463d7fd0f0f8"

URI_aarch64_poppler-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/poppler-utils-24.02.0-7.el10_2.2.aarch64.rpm;name=aarch64_poppler-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_poppler-utils}"
SRC_URI[aarch64_poppler-utils.sha256sum] = "e8c4d8236d5076cb52919e084b3d58b3c4702d068661e1311433ec7bfad84efd"

RDEPENDS:poppler = " \
 fontconfig \
 freetype \
 glibc \
 gpgmepp \
 lcms2 \
 libgcc \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 libtiff \
 nspr \
 nss \
 openjpeg2 \
 poppler-data \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:poppler-cpp = " \
 glibc \
 libgcc \
 libstdc++ \
 poppler \
 "
RDEPENDS:poppler-cpp-devel = " \
 pkgconf-pkg-config \
 poppler-cpp \
 poppler-devel \
 "
RDEPENDS:poppler-devel = " \
 pkgconf-pkg-config \
 poppler \
 "
RDEPENDS:poppler-glib = " \
 cairo \
 freetype \
 glib2 \
 glibc \
 libgcc \
 libstdc++ \
 poppler \
 "
RDEPENDS:poppler-glib-devel = " \
 cairo-devel \
 glib2-devel \
 pkgconf-pkg-config \
 poppler-devel \
 poppler-glib \
 "
RDEPENDS:poppler-glib-doc = " \
 "
RDEPENDS:poppler-qt6 = " \
 freetype \
 glibc \
 lcms2 \
 libgcc \
 libstdc++ \
 poppler \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:poppler-qt6-devel = " \
 pkgconf-pkg-config \
 poppler-devel \
 poppler-qt6 \
 qt6-qtbase-devel \
 "
RDEPENDS:poppler-utils = " \
 cairo \
 freetype \
 glibc \
 lcms2 \
 libgcc \
 libstdc++ \
 poppler \
 "
