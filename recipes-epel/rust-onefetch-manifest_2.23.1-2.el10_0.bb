# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-onefetch-manifest"
PV = "2.23.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-onefetch-manifest+default-devel \
 rust-onefetch-manifest-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-onefetch-manifest-2.23.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "10cd4be8a7d2d641fa978df3054ee31229c7cb576484beef961746d0c7e1d4c9"

URI_x86_64_v2_rust-onefetch-manifest+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onefetch-manifest+default-devel-2.23.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onefetch-manifest+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onefetch-manifest+default-devel}"
SRC_URI[x86_64_v2_rust-onefetch-manifest+default-devel.sha256sum] = "2a3c59358ee9bb70a6e83cb8c7b767ff240a83be4b2539b16c7cf1e08ff79dea"

URI_x86_64_v2_rust-onefetch-manifest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onefetch-manifest-devel-2.23.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onefetch-manifest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onefetch-manifest-devel}"
SRC_URI[x86_64_v2_rust-onefetch-manifest-devel.sha256sum] = "79173776ac9148f7851f915e3a8b8d743ea24c57299840f267d5be366df60de7"

URI_aarch64_rust-onefetch-manifest+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onefetch-manifest+default-devel-2.23.1-2.el10_0.noarch.rpm;name=aarch64_rust-onefetch-manifest+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onefetch-manifest+default-devel}"
SRC_URI[aarch64_rust-onefetch-manifest+default-devel.sha256sum] = "5203ccd4646ea0a566d895abb06ae99f0e547a43ffbb6fce755722310e57948e"

URI_aarch64_rust-onefetch-manifest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onefetch-manifest-devel-2.23.1-2.el10_0.noarch.rpm;name=aarch64_rust-onefetch-manifest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onefetch-manifest-devel}"
SRC_URI[aarch64_rust-onefetch-manifest-devel.sha256sum] = "c7d1d999a19864be3090c74cf7a7d1cd87132bedcbbd8067c896b7d0097da94b"

RDEPENDS:rust-onefetch-manifest+default-devel = " \
 cargo \
 rust-onefetch-manifest-devel \
 "
RDEPENDS:rust-onefetch-manifest-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-cargo_toml+default-devel \
 rust-npm-package-json+default-devel \
 rust-strum+default-devel \
 rust-strum+derive-devel \
 "
