# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-trio-websocket"
PV = "0.12.2"
PR = "1.el10_2"
PACKAGES = " \
 python-trio-websocket-doc \
 python3-trio-websocket \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-trio-websocket-0.12.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f1831a08820e18053805d22698643143b4b1147379e9296600d6d6f52ef88cd0"

URI_x86_64_v2_python-trio-websocket-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-trio-websocket-doc-0.12.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-trio-websocket-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-trio-websocket-doc}"
SRC_URI[x86_64_v2_python-trio-websocket-doc.sha256sum] = "b423ff4ff02c9693a2fbc770179d3e5803c4b0f3a57eed8b3320964e1608b4c5"

URI_x86_64_v2_python3-trio-websocket = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-trio-websocket-0.12.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-trio-websocket;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-trio-websocket}"
SRC_URI[x86_64_v2_python3-trio-websocket.sha256sum] = "ab4b16d90f2c5e87b8014a3ed63ddd90f9fdd8f1feb1b00dc3c10d922a24bdbf"

URI_aarch64_python-trio-websocket-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-trio-websocket-doc-0.12.2-1.el10_2.noarch.rpm;name=aarch64_python-trio-websocket-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-trio-websocket-doc}"
SRC_URI[aarch64_python-trio-websocket-doc.sha256sum] = "50ecbc8f6001ebd446b06e2ef19913bf1269db83aab3ad81462120f07dc446cc"

URI_aarch64_python3-trio-websocket = "${EPEL_MIRROR}/aarch64/Packages/p/python3-trio-websocket-0.12.2-1.el10_2.noarch.rpm;name=aarch64_python3-trio-websocket;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-trio-websocket}"
SRC_URI[aarch64_python3-trio-websocket.sha256sum] = "b89facebc2e40e7441a888e6b8afe9cd414614a1e2a9cb389e787f523aeee0dd"

RDEPENDS:python-trio-websocket-doc = " \
 "
RDEPENDS:python3-trio-websocket = " \
 python3 \
 python3-outcome \
 python3-trio \
 python3-wsproto \
 "
