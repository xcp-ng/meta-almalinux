# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sys-Virt"
PV = "11.6.0"
PR = "1.el10_2"
PACKAGES = " \
 perl-Sys-Virt \
 perl-Sys-Virt-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Sys-Virt-11.6.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "44bd5291ff526c8ec8b3775234b65cd03357e1b84178b023d09d057663b82832"

URI_x86_64_v2_perl-Sys-Virt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sys-Virt-11.6.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Sys-Virt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sys-Virt}"
SRC_URI[x86_64_v2_perl-Sys-Virt.sha256sum] = "9dab5c666fea60fb54d9a1198ab0e60ec452805df8a38c9eae84aa637cd02493"

URI_x86_64_v2_perl-Sys-Virt-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sys-Virt-tests-11.6.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Sys-Virt-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sys-Virt-tests}"
SRC_URI[x86_64_v2_perl-Sys-Virt-tests.sha256sum] = "d61b69c4a146e16adc1a14c6e5a81c6a6aec584c7a0b535dfad7da4b7a0e7cbe"

URI_aarch64_perl-Sys-Virt = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Sys-Virt-11.6.0-1.el10_2.aarch64.rpm;name=aarch64_perl-Sys-Virt;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sys-Virt}"
SRC_URI[aarch64_perl-Sys-Virt.sha256sum] = "b7cf528b96fafd0c696d7076cfe1f889a5f6d1a6f3c828330865c5b36c6c261c"

URI_aarch64_perl-Sys-Virt-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Sys-Virt-tests-11.6.0-1.el10_2.aarch64.rpm;name=aarch64_perl-Sys-Virt-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sys-Virt-tests}"
SRC_URI[aarch64_perl-Sys-Virt-tests.sha256sum] = "55fcb5ade11a244bfb0ef12a7a802cc68f7a7f8b902f6f1c05b56b87e22493a2"

RDEPENDS:perl-Sys-Virt = " \
 glibc \
 libvirt-libs \
 perl-libs \
 perl-overload \
 perl-parent \
 "
RDEPENDS:perl-Sys-Virt-tests = " \
 bash \
 perl-Sys-Hostname \
 perl-Sys-Virt \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Time-HiRes \
 perl-XML-XPath \
 perl-base \
 perl-interpreter \
 perl-libs \
 "
