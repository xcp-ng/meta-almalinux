# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pest_generator"
PV = "2.8.6"
PR = "1.el10_2"
PACKAGES = " \
 rust-pest_generator+default-devel \
 rust-pest_generator+export-internal-devel \
 rust-pest_generator+grammar-extras-devel \
 rust-pest_generator+std-devel \
 rust-pest_generator-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pest_generator-2.8.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80c4d253e41f100280e81df8de0409c47cd3f8f71e2be43e523cb53bf11399e7"

URI_x86_64_v2_rust-pest_generator+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_generator+default-devel-2.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_generator+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_generator+default-devel}"
SRC_URI[x86_64_v2_rust-pest_generator+default-devel.sha256sum] = "f1a597a2c59e63b56f4d8ae6d11ce54b5fbb8a7d0d215f7344ee3cd6bbf6c49b"

URI_x86_64_v2_rust-pest_generator+export-internal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_generator+export-internal-devel-2.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_generator+export-internal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_generator+export-internal-devel}"
SRC_URI[x86_64_v2_rust-pest_generator+export-internal-devel.sha256sum] = "7c7534b91b72ea0bfe6457c16b0d90a763f26e7dbf76ca29af3d5a8e6ffba36f"

URI_x86_64_v2_rust-pest_generator+grammar-extras-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_generator+grammar-extras-devel-2.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_generator+grammar-extras-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_generator+grammar-extras-devel}"
SRC_URI[x86_64_v2_rust-pest_generator+grammar-extras-devel.sha256sum] = "4d5f2b663a3661bb78ed30d47d49a2a101cac7c3f2720c0226ffb7fe0a1077b7"

URI_x86_64_v2_rust-pest_generator+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_generator+std-devel-2.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_generator+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_generator+std-devel}"
SRC_URI[x86_64_v2_rust-pest_generator+std-devel.sha256sum] = "ea4d17cccd797a73c017e7fd0b53ddd02259d6d7fb5b03ae605cddbe209e57da"

URI_x86_64_v2_rust-pest_generator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_generator-devel-2.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_generator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_generator-devel}"
SRC_URI[x86_64_v2_rust-pest_generator-devel.sha256sum] = "eddf1427166ee80069a5c0468fc385065df262e9726c1114acbf9b40f7da840a"

URI_aarch64_rust-pest_generator+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_generator+default-devel-2.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-pest_generator+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_generator+default-devel}"
SRC_URI[aarch64_rust-pest_generator+default-devel.sha256sum] = "f96362a8b59e5fde3c816473bd7562a39a743cd8218692ca82d255896ac5664c"

URI_aarch64_rust-pest_generator+export-internal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_generator+export-internal-devel-2.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-pest_generator+export-internal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_generator+export-internal-devel}"
SRC_URI[aarch64_rust-pest_generator+export-internal-devel.sha256sum] = "3a3459a2905c8a327da7b9aad18c27c11b4558645771d14dcf32ec0810a8ab2c"

URI_aarch64_rust-pest_generator+grammar-extras-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_generator+grammar-extras-devel-2.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-pest_generator+grammar-extras-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_generator+grammar-extras-devel}"
SRC_URI[aarch64_rust-pest_generator+grammar-extras-devel.sha256sum] = "657e6d4fec0bed24ab5dd19fe7fa5a690dabbdaa0180847ffce7ebf7cd18abf3"

URI_aarch64_rust-pest_generator+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_generator+std-devel-2.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-pest_generator+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_generator+std-devel}"
SRC_URI[aarch64_rust-pest_generator+std-devel.sha256sum] = "000dbdb4617343f7d11338a856fd4c7a808aca7aede3db8edc974ccbb17e3e29"

URI_aarch64_rust-pest_generator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_generator-devel-2.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-pest_generator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_generator-devel}"
SRC_URI[aarch64_rust-pest_generator-devel.sha256sum] = "618d4d2528397023dc701ce298a096b19640dd84679ad3484afc7489d383eddf"

RDEPENDS:rust-pest_generator+default-devel = " \
 cargo \
 rust-pest_generator+std-devel \
 rust-pest_generator-devel \
 "
RDEPENDS:rust-pest_generator+export-internal-devel = " \
 cargo \
 rust-pest_generator-devel \
 "
RDEPENDS:rust-pest_generator+grammar-extras-devel = " \
 cargo \
 rust-pest_generator-devel \
 rust-pest_meta+grammar-extras-devel \
 "
RDEPENDS:rust-pest_generator+std-devel = " \
 cargo \
 rust-pest+std-devel \
 rust-pest_generator-devel \
 "
RDEPENDS:rust-pest_generator-devel = " \
 cargo \
 rust \
 rust-pest-devel \
 rust-pest_meta+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
