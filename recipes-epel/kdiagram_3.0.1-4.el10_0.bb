# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdiagram"
PV = "3.0.1"
PR = "4.el10_0"
PACKAGES = " \
 kdiagram \
 kdiagram-devel \
 kdiagram-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdiagram-3.0.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "01db5af56dfb7eb6eba659c5e1ab204696327b42075db6f3beffb3947a458063"

URI_x86_64_v2_kdiagram = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdiagram-3.0.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdiagram;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdiagram}"
SRC_URI[x86_64_v2_kdiagram.sha256sum] = "30859a7bdcb8a3d3fa64c84d6c7cbe0c9ce6287b1bed149b9f3766f03f9fef2f"

URI_x86_64_v2_kdiagram-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdiagram-devel-3.0.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdiagram-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdiagram-devel}"
SRC_URI[x86_64_v2_kdiagram-devel.sha256sum] = "bec5a53d0811ab6a9f331d3cd66b695a825b42bb63837b734c9757433a277d89"

URI_x86_64_v2_kdiagram-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdiagram-doc-3.0.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdiagram-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdiagram-doc}"
SRC_URI[x86_64_v2_kdiagram-doc.sha256sum] = "77e694ba1064d5af118b42c80f3942793002ce00b175d26d6c5703f7c75015a5"

URI_aarch64_kdiagram = "${EPEL_MIRROR}/aarch64/Packages/k/kdiagram-3.0.1-4.el10_0.aarch64.rpm;name=aarch64_kdiagram;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdiagram}"
SRC_URI[aarch64_kdiagram.sha256sum] = "eb8f8164627e108439950e41966c9ec3a34d477e59cb87b499de345d4c851e7e"

URI_aarch64_kdiagram-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kdiagram-devel-3.0.1-4.el10_0.aarch64.rpm;name=aarch64_kdiagram-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdiagram-devel}"
SRC_URI[aarch64_kdiagram-devel.sha256sum] = "a0d4a855dc144807aaba205e3cb750faf30c7f76531e0a2160ff8ee3e5792227"

URI_aarch64_kdiagram-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kdiagram-doc-3.0.1-4.el10_0.aarch64.rpm;name=aarch64_kdiagram-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdiagram-doc}"
SRC_URI[aarch64_kdiagram-doc.sha256sum] = "6a105a2efd824805cc097e8f994106294f986203e798a8c8b8e56c6e07996ba0"

RDEPENDS:kdiagram = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
RDEPENDS:kdiagram-devel = " \
 cmake-filesystem \
 kdiagram \
 qt6-qtbase-devel \
 qt6-qtsvg-devel \
 "
RDEPENDS:kdiagram-doc = " \
 "
