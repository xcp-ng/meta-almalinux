# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "NetworkManager-libreswan"
PV = "1.2.31"
PR = "1.el10"
PACKAGES = " \
 NetworkManager-libreswan \
 NetworkManager-libreswan-gnome \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/NetworkManager-libreswan-1.2.31-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "43663cd64155ec59336282d9b22e099a47704a3e1886f37f4ddc8b685395a2ba"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/NetworkManager-libreswan-1.2.31-1.el10.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-libreswan;unpack=0"
SRC_URI[x86_64_v2_NetworkManager-libreswan.sha256sum] = "73bc21fac563af5cc1d6df19829d8d282e330f13935035b4d27c0afd40523257"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/NetworkManager-libreswan-gnome-1.2.31-1.el10.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-libreswan-gnome;unpack=0"
SRC_URI[x86_64_v2_NetworkManager-libreswan-gnome.sha256sum] = "6ebf7c445dafc28f12a83446d42af1d4ef4412ffe8856c7b90e24f782d58b6ae"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/NetworkManager-libreswan-1.2.31-1.el10.aarch64.rpm;name=aarch64_NetworkManager-libreswan;unpack=0"
SRC_URI[aarch64_NetworkManager-libreswan.sha256sum] = "972945a388d9e12b443eabf2333bfa7b1940efb26f1bc13403ba254f0452eb84"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/NetworkManager-libreswan-gnome-1.2.31-1.el10.aarch64.rpm;name=aarch64_NetworkManager-libreswan-gnome;unpack=0"
SRC_URI[aarch64_NetworkManager-libreswan-gnome.sha256sum] = "b677619b9cb3b559952bd52d084e68c5c304ab398e9bebcecda06dfbe666520e"

RDEPENDS:NetworkManager-libreswan = " \
 NetworkManager \
 NetworkManager-libnm \
 dbus-common \
 glib2 \
 glibc \
 libgcc \
 libnl3 \
 libreswan-minimal \
 "
RDEPENDS:NetworkManager-libreswan-gnome = " \
 NetworkManager-libnm \
 NetworkManager-libreswan \
 atk \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 graphene \
 gtk3 \
 gtk4 \
 harfbuzz \
 libgcc \
 libnma \
 libnma-gtk4 \
 libsecret \
 pango \
 shared-mime-info \
 vulkan-loader \
 "
