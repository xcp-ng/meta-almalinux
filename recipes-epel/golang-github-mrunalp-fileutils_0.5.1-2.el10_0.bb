# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-mrunalp-fileutils"
PV = "0.5.1"
PR = "2.el10_0"
PACKAGES = " \
 golang-github-mrunalp-fileutils-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-mrunalp-fileutils-0.5.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b215522d20d1223410e2148ebe29ea27bfcf74475e9489613623807ae59bfcd9"

URI_x86_64_v2_golang-github-mrunalp-fileutils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-mrunalp-fileutils-devel-0.5.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-mrunalp-fileutils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-mrunalp-fileutils-devel}"
SRC_URI[x86_64_v2_golang-github-mrunalp-fileutils-devel.sha256sum] = "644d0fb9e398eb4b3304cc4d922634947c1be7bfeea84fe500384fed5e212e94"

URI_aarch64_golang-github-mrunalp-fileutils-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-mrunalp-fileutils-devel-0.5.1-2.el10_0.noarch.rpm;name=aarch64_golang-github-mrunalp-fileutils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-mrunalp-fileutils-devel}"
SRC_URI[aarch64_golang-github-mrunalp-fileutils-devel.sha256sum] = "ac1076e073f91f2f73083495c672aaa4413b913b3e5825499b56ea418a3d2af1"

RDEPENDS:golang-github-mrunalp-fileutils-devel = " \
 go-filesystem \
 "
