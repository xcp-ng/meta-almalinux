# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fd-find"
PV = "10.3.0"
PR = "1.el10_0"
PACKAGES = " \
 fd-find \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fd-find-10.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f171f59ed4168ceb5db19f74928273893b010e73558c301943383752a7d2b2d9"

URI_x86_64_v2_fd-find = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fd-find-10.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fd-find;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fd-find}"
SRC_URI[x86_64_v2_fd-find.sha256sum] = "5c96fe0f6960a738016a153a57211cba8b34e3bb647f70975bbe260f6ee741c4"

URI_aarch64_fd-find = "${EPEL_MIRROR}/aarch64/Packages/f/fd-find-10.3.0-1.el10_0.aarch64.rpm;name=aarch64_fd-find;unpack=0"
SRC_URI:append = " ${URI_aarch64_fd-find}"
SRC_URI[aarch64_fd-find.sha256sum] = "86dbe87b60f3f2337f0e1922d25312d5939e8d154bc0de91c45dfcbf1fefabfb"

RDEPENDS:fd-find = " \
 glibc \
 libgcc \
 "
