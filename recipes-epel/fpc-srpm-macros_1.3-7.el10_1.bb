# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fpc-srpm-macros"
PV = "1.3"
PR = "7.el10_1"
PACKAGES = " \
 fpc-srpm-macros \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fpc-srpm-macros-1.3-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "db37b5870b8f2e49302d507cc3de1da49134eafad788cb4e4b9313855916c2e3"

URI_x86_64_v2_fpc-srpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fpc-srpm-macros-1.3-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_fpc-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fpc-srpm-macros}"
SRC_URI[x86_64_v2_fpc-srpm-macros.sha256sum] = "1808665b8c084ba2d0cca8c01196338c24a0944c442ea4cd75ec48b99d6fa9b2"

URI_aarch64_fpc-srpm-macros = "${EPEL_MIRROR}/aarch64/Packages/f/fpc-srpm-macros-1.3-7.el10_1.noarch.rpm;name=aarch64_fpc-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_fpc-srpm-macros}"
SRC_URI[aarch64_fpc-srpm-macros.sha256sum] = "7dc3a4e325137d0f40f0b45e46c30b6e1d11c4fba3d7aff72ec8cc0bb27c0783"

RDEPENDS:fpc-srpm-macros = " \
 "
