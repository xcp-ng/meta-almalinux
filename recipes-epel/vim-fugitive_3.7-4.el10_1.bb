# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vim-fugitive"
PV = "3.7"
PR = "4.el10_1"
PACKAGES = " \
 vim-fugitive \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vim-fugitive-3.7-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2349f9103513c536a3351ae0de422a531ecd82090a692e127a06f29a053d8638"

URI_x86_64_v2_vim-fugitive = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vim-fugitive-3.7-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_vim-fugitive;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vim-fugitive}"
SRC_URI[x86_64_v2_vim-fugitive.sha256sum] = "a1e37647850fcae339708209aad3c49b7890b4075e3049868d887ccddcf42d8a"

URI_aarch64_vim-fugitive = "${EPEL_MIRROR}/aarch64/Packages/v/vim-fugitive-3.7-4.el10_1.noarch.rpm;name=aarch64_vim-fugitive;unpack=0"
SRC_URI:append = " ${URI_aarch64_vim-fugitive}"
SRC_URI[aarch64_vim-fugitive.sha256sum] = "349ce35aa9d839ba84001f39c4f896da87f914d28daf90e44245deab7fe12cbe"

RDEPENDS:vim-fugitive = " \
 vim-common \
 "
