# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Authen-PAM"
PV = "0.16"
PR = "54.el10_0"
PACKAGES = " \
 perl-Authen-PAM \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Authen-PAM-0.16-54.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5fc39803baf460dd1a2f819cd8e4a3587d2b49b2da18cfa2b4bda8699464e37d"

URI_x86_64_v2_perl-Authen-PAM = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Authen-PAM-0.16-54.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Authen-PAM;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Authen-PAM}"
SRC_URI[x86_64_v2_perl-Authen-PAM.sha256sum] = "b8b19c93a9109d9e509fc9a734162ba8bcd4623500debbcb5e36c5c768589375"

URI_aarch64_perl-Authen-PAM = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Authen-PAM-0.16-54.el10_0.aarch64.rpm;name=aarch64_perl-Authen-PAM;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Authen-PAM}"
SRC_URI[aarch64_perl-Authen-PAM.sha256sum] = "b994e1221b08da1fa53c5a0eb28c7d0621f2e754e89d1572cf05e9c8ce514a66"

RDEPENDS:perl-Authen-PAM = " \
 glibc \
 pam-libs \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-POSIX \
 perl-libs \
 perl-vars \
 "
