# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openoffice-lv"
PV = "1.4.0"
PR = "10.el10"
PACKAGES = " \
 hunspell-lv \
 hyphen-lv \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/openoffice-lv-1.4.0-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e0ceae2c89e8da5317d80cc765ed85a24a73c37fcbfd12ca0f2c6c49bb37d2a"

URI_x86_64_v2_hunspell-lv = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-lv-1.4.0-10.el10.noarch.rpm;name=x86_64_v2_hunspell-lv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-lv}"
SRC_URI[x86_64_v2_hunspell-lv.sha256sum] = "3d5abaa6b724f09e6596f10beebe43a9cfbd5c2b3bd063e92b7293e70808ffe4"

URI_x86_64_v2_hyphen-lv = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-lv-1.4.0-10.el10.noarch.rpm;name=x86_64_v2_hyphen-lv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyphen-lv}"
SRC_URI[x86_64_v2_hyphen-lv.sha256sum] = "91fb2930350d63268927a1c8d3b371b155f283f22fe17219399d83dee1be6b2e"

URI_aarch64_hunspell-lv = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-lv-1.4.0-10.el10.noarch.rpm;name=aarch64_hunspell-lv;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-lv}"
SRC_URI[aarch64_hunspell-lv.sha256sum] = "3d5abaa6b724f09e6596f10beebe43a9cfbd5c2b3bd063e92b7293e70808ffe4"

URI_aarch64_hyphen-lv = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-lv-1.4.0-10.el10.noarch.rpm;name=aarch64_hyphen-lv;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyphen-lv}"
SRC_URI[aarch64_hyphen-lv.sha256sum] = "91fb2930350d63268927a1c8d3b371b155f283f22fe17219399d83dee1be6b2e"

RDEPENDS:hunspell-lv = " \
 hunspell \
 "
RDEPENDS:hyphen-lv = " \
 hyphen \
 "
