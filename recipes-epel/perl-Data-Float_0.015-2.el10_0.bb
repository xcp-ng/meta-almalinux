# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Data-Float"
PV = "0.015"
PR = "2.el10_0"
PACKAGES = " \
 perl-Data-Float \
 perl-Data-Float-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Data-Float-0.015-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b9f34dca189eca767e70d4eda9cc74edb8d166d86f1a19d5e43e8892904abc83"

URI_x86_64_v2_perl-Data-Float = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Data-Float-0.015-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Data-Float;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Data-Float}"
SRC_URI[x86_64_v2_perl-Data-Float.sha256sum] = "6a56cc1c4a1abda8c18e45c4dfaf9b7d342ec689f1aca78ff0ebb5ff215c72d7"

URI_x86_64_v2_perl-Data-Float-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Data-Float-tests-0.015-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Data-Float-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Data-Float-tests}"
SRC_URI[x86_64_v2_perl-Data-Float-tests.sha256sum] = "f87cb699cf51b5fba84ac82fd5458de23343d60dc2ea15da40fc5906f104bd1a"

URI_aarch64_perl-Data-Float = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Data-Float-0.015-2.el10_0.noarch.rpm;name=aarch64_perl-Data-Float;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Data-Float}"
SRC_URI[aarch64_perl-Data-Float.sha256sum] = "738fea34c58002652e281216197065e16029199ff1959c0dfe0e4711250a831e"

URI_aarch64_perl-Data-Float-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Data-Float-tests-0.015-2.el10_0.noarch.rpm;name=aarch64_perl-Data-Float-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Data-Float-tests}"
SRC_URI[aarch64_perl-Data-Float-tests.sha256sum] = "4e8744e46bf6617b90c50c79f5b2d2c3edea2967ab37ce2af3508dc7dda2a4d0"

RDEPENDS:perl-Data-Float = " \
 perl-Carp \
 perl-Exporter \
 perl-constant \
 perl-libs \
 perl-parent \
 "
RDEPENDS:perl-Data-Float-tests = " \
 bash \
 perl-Data-Float \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-libs \
 "
