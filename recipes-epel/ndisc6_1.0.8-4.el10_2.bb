# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ndisc6"
PV = "1.0.8"
PR = "4.el10_2"
PACKAGES = " \
 ndisc6 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/ndisc6-1.0.8-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bfd8c4e31a161a5abaf211f5d924a28a512fad87ff483b19b32cbfece3a6deb3"

URI_x86_64_v2_ndisc6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ndisc6-1.0.8-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ndisc6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ndisc6}"
SRC_URI[x86_64_v2_ndisc6.sha256sum] = "32b9183a307de686f319e795f57d540b7899a9c8fe376d93b4d05680840f0d89"

URI_aarch64_ndisc6 = "${EPEL_MIRROR}/aarch64/Packages/n/ndisc6-1.0.8-4.el10_2.aarch64.rpm;name=aarch64_ndisc6;unpack=0"
SRC_URI:append = " ${URI_aarch64_ndisc6}"
SRC_URI[aarch64_ndisc6.sha256sum] = "f0621118f14afcc90f6eb4ec8f3076ab9b29997baaac936569c28b0ee3caa01e"

RDEPENDS:ndisc6 = " \
 bash \
 glibc \
 perl-Getopt-Std \
 perl-interpreter \
 perl-libs \
 "
