# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-grep-searcher"
PV = "0.1.17"
PR = "1.el10_2"
PACKAGES = " \
 rust-grep-searcher+default-devel \
 rust-grep-searcher-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-grep-searcher-0.1.17-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "598978e416d381b952880b696995d15af364ff8ea1ba81f4890f061d9fac7a9b"

URI_x86_64_v2_rust-grep-searcher+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-searcher+default-devel-0.1.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-searcher+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-searcher+default-devel}"
SRC_URI[x86_64_v2_rust-grep-searcher+default-devel.sha256sum] = "7f3f1a27867bbccf75903b1821589afd698dcbc1bce8b6e554b57a95527c4ed6"

URI_x86_64_v2_rust-grep-searcher-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-searcher-devel-0.1.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-searcher-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-searcher-devel}"
SRC_URI[x86_64_v2_rust-grep-searcher-devel.sha256sum] = "8c5299a6c1439b209dd8d56dd036795ce404c3d4d56350f785eb2a187c12cc97"

URI_aarch64_rust-grep-searcher+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-searcher+default-devel-0.1.17-1.el10_2.noarch.rpm;name=aarch64_rust-grep-searcher+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-searcher+default-devel}"
SRC_URI[aarch64_rust-grep-searcher+default-devel.sha256sum] = "6fdaa8b6afcef0a0bd7fd78dc2069ecd6e05c62c504659d83d2af01a8f263372"

URI_aarch64_rust-grep-searcher-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-searcher-devel-0.1.17-1.el10_2.noarch.rpm;name=aarch64_rust-grep-searcher-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-searcher-devel}"
SRC_URI[aarch64_rust-grep-searcher-devel.sha256sum] = "d061b75ca0f67b4610475cf1d11599de9fa48b3a125684c85b88b5149ea2aaf6"

RDEPENDS:rust-grep-searcher+default-devel = " \
 cargo \
 rust-grep-searcher-devel \
 "
RDEPENDS:rust-grep-searcher-devel = " \
 cargo \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-encoding_rs+default-devel \
 rust-encoding_rs_io+default-devel \
 rust-grep-matcher+default-devel \
 rust-log+default-devel \
 rust-memchr+default-devel \
 rust-memmap2+default-devel \
 "
