# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kstatusnotifieritem"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kstatusnotifieritem \
 kf6-kstatusnotifieritem-devel \
 kf6-kstatusnotifieritem-doc \
 kf6-kstatusnotifieritem-html \
 python3-kf6-kstatusnotifieritem \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kstatusnotifieritem-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2bf1c3b440a2d60f7e0d7b196b8bb7fceaf775e7033128a13c567fb28e6186f"

URI_x86_64_v2_kf6-kstatusnotifieritem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kstatusnotifieritem-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kstatusnotifieritem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kstatusnotifieritem}"
SRC_URI[x86_64_v2_kf6-kstatusnotifieritem.sha256sum] = "9daac166305f98ad27c8dbdf11dd4a0d62584865c12a93a32d9d6bc1f0f64290"

URI_x86_64_v2_kf6-kstatusnotifieritem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kstatusnotifieritem-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kstatusnotifieritem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kstatusnotifieritem-devel}"
SRC_URI[x86_64_v2_kf6-kstatusnotifieritem-devel.sha256sum] = "40a5403e54ab4caee03259babca58a2d70c79135135d1eaceda761d8dd2731d2"

URI_x86_64_v2_kf6-kstatusnotifieritem-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kstatusnotifieritem-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kstatusnotifieritem-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kstatusnotifieritem-doc}"
SRC_URI[x86_64_v2_kf6-kstatusnotifieritem-doc.sha256sum] = "fb55584a67fbaf930bea9ace714e13292d7e1c754fedc8008f24752629bea2fc"

URI_x86_64_v2_kf6-kstatusnotifieritem-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kstatusnotifieritem-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kstatusnotifieritem-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kstatusnotifieritem-html}"
SRC_URI[x86_64_v2_kf6-kstatusnotifieritem-html.sha256sum] = "3eac1c7dd8ed963ce39b1f295c8305f827e1a36e5ca1f52dbf394fe27df89820"

URI_x86_64_v2_python3-kf6-kstatusnotifieritem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-kstatusnotifieritem-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-kstatusnotifieritem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kf6-kstatusnotifieritem}"
SRC_URI[x86_64_v2_python3-kf6-kstatusnotifieritem.sha256sum] = "254066cc8cdf8fc483f47236035fe15e5407ade5a2369ec6d6a9f1d073cdb8b5"

URI_aarch64_kf6-kstatusnotifieritem = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kstatusnotifieritem-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kstatusnotifieritem;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kstatusnotifieritem}"
SRC_URI[aarch64_kf6-kstatusnotifieritem.sha256sum] = "662bb45ce1061771c22a06fab4f7f704ecd4079b200bc1c801bb9edbdf54b87a"

URI_aarch64_kf6-kstatusnotifieritem-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kstatusnotifieritem-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kstatusnotifieritem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kstatusnotifieritem-devel}"
SRC_URI[aarch64_kf6-kstatusnotifieritem-devel.sha256sum] = "b5169a51069385c488832b220576bb665836e32e4d41ee9ccf2b77f0643799a5"

URI_aarch64_kf6-kstatusnotifieritem-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kstatusnotifieritem-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kstatusnotifieritem-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kstatusnotifieritem-doc}"
SRC_URI[aarch64_kf6-kstatusnotifieritem-doc.sha256sum] = "a453869dd5a44aea9802ee7316ca56ab9462c2f6116a618aade6f3b0b3538703"

URI_aarch64_kf6-kstatusnotifieritem-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kstatusnotifieritem-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kstatusnotifieritem-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kstatusnotifieritem-html}"
SRC_URI[aarch64_kf6-kstatusnotifieritem-html.sha256sum] = "7808dd657fe271ea82dc596c91a839f1be05703c434082bbd200ce21ee32e14f"

URI_aarch64_python3-kf6-kstatusnotifieritem = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-kstatusnotifieritem-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_python3-kf6-kstatusnotifieritem;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kf6-kstatusnotifieritem}"
SRC_URI[aarch64_python3-kf6-kstatusnotifieritem.sha256sum] = "4df8cec4a75ed3b73cc7f2cb8918b8e9d3558cfb4f61d185af335232ae43f814"

RDEPENDS:kf6-kstatusnotifieritem = " \
 glibc \
 kf6-filesystem \
 kf6-kwindowsystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kstatusnotifieritem-devel = " \
 cmake-filesystem \
 kf6-kstatusnotifieritem \
 "
RDEPENDS:kf6-kstatusnotifieritem-doc = " \
 "
RDEPENDS:kf6-kstatusnotifieritem-html = " \
 "
RDEPENDS:python3-kf6-kstatusnotifieritem = " \
 glibc \
 kf6-kstatusnotifieritem \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
