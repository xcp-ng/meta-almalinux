# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-task-slim-sprig3"
PV = "3.0.0"
PR = "4.el10_0"
PACKAGES = " \
 golang-github-task-slim-sprig3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-task-slim-sprig3-3.0.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "acf3eb4db089f0c790c2e735cfa5ec80b259468f116bd636a339e390cafabe46"

URI_x86_64_v2_golang-github-task-slim-sprig3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-task-slim-sprig3-devel-3.0.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-task-slim-sprig3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-task-slim-sprig3-devel}"
SRC_URI[x86_64_v2_golang-github-task-slim-sprig3-devel.sha256sum] = "c20b1f58628e598e0a07e25bcffca003fb2abb92c7112c6d668ef3991ed415c5"

URI_aarch64_golang-github-task-slim-sprig3-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-task-slim-sprig3-devel-3.0.0-4.el10_0.noarch.rpm;name=aarch64_golang-github-task-slim-sprig3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-task-slim-sprig3-devel}"
SRC_URI[aarch64_golang-github-task-slim-sprig3-devel.sha256sum] = "a9ce534a65c1e8d09c466e33c8f17cbae9b855f4b636d3b10b872d775b9ecb87"

RDEPENDS:golang-github-task-slim-sprig3-devel = " \
 go-filesystem \
 "
