# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-macro"
PV = "0.3.32"
PR = "1.el10_2"
PACKAGES = " \
 rust-futures-macro+default-devel \
 rust-futures-macro-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-futures-macro-0.3.32-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "27b8a8ee627686b4a5588f6ea720691061f8629bcd1760f124403dbd39f71a7d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-macro+default-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-macro+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-macro+default-devel.sha256sum] = "b2fa82ea38cfa20c8b60aa50620cdcf77977f06a229feb9154649a65e268d875"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-macro-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-macro-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-macro-devel.sha256sum] = "aebc365f0dae15591e597a8f27a831f5e1f53bb915ead0d44c15043113a917ad"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-macro+default-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-macro+default-devel;unpack=0"
SRC_URI[aarch64_rust-futures-macro+default-devel.sha256sum] = "97e11d5fdedff8b4ef05bdc2f4f5a7a459533b1557bc815d0bafb8bd6f7b58bb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-macro-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-macro-devel;unpack=0"
SRC_URI[aarch64_rust-futures-macro-devel.sha256sum] = "80629629d1bc90b35e1676dc1cd0589cde70a80044e25196955b6db711ce03c7"

RDEPENDS:rust-futures-macro+default-devel = " \
 cargo \
 rust-futures-macro-devel \
 "
RDEPENDS:rust-futures-macro-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
