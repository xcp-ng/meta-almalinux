# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gsi-proxy-ssl"
PV = "6.5"
PR = "6.el10_0"
PACKAGES = " \
 globus-gsi-proxy-ssl \
 globus-gsi-proxy-ssl-devel \
 globus-gsi-proxy-ssl-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gsi-proxy-ssl-6.5-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8288e4c7d2f5cd72a659b10ff0961e2af16a91a5029348621f434b9bfae3ceaf"

URI_x86_64_v2_globus-gsi-proxy-ssl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-proxy-ssl-6.5-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gsi-proxy-ssl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-proxy-ssl}"
SRC_URI[x86_64_v2_globus-gsi-proxy-ssl.sha256sum] = "3979a6b271b87d2796d58da41b618d6bc3eed254c4f42feb8f9d43906ee4e8e6"

URI_x86_64_v2_globus-gsi-proxy-ssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-proxy-ssl-devel-6.5-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gsi-proxy-ssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-proxy-ssl-devel}"
SRC_URI[x86_64_v2_globus-gsi-proxy-ssl-devel.sha256sum] = "a7577701f4ea98e867b4e69da20d6a1b56bb146297e066ed6b0697703701fb97"

URI_x86_64_v2_globus-gsi-proxy-ssl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-proxy-ssl-doc-6.5-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gsi-proxy-ssl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-proxy-ssl-doc}"
SRC_URI[x86_64_v2_globus-gsi-proxy-ssl-doc.sha256sum] = "1906bf6f0dff8ccaec6fa6ba6d736caf16adf34bee404264cbc275f6f3eb5205"

URI_aarch64_globus-gsi-proxy-ssl = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-proxy-ssl-6.5-6.el10_0.aarch64.rpm;name=aarch64_globus-gsi-proxy-ssl;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-proxy-ssl}"
SRC_URI[aarch64_globus-gsi-proxy-ssl.sha256sum] = "dc59a604b97bfb6f54363fa308751293ac96a614e7a7f1f24abc12d11fc56d9d"

URI_aarch64_globus-gsi-proxy-ssl-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-proxy-ssl-devel-6.5-6.el10_0.aarch64.rpm;name=aarch64_globus-gsi-proxy-ssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-proxy-ssl-devel}"
SRC_URI[aarch64_globus-gsi-proxy-ssl-devel.sha256sum] = "764e3ab064fbd549ae3a1e198dd6ea28896fcc7ee99a30936f164d8735753ecc"

URI_aarch64_globus-gsi-proxy-ssl-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-proxy-ssl-doc-6.5-6.el10_0.noarch.rpm;name=aarch64_globus-gsi-proxy-ssl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-proxy-ssl-doc}"
SRC_URI[aarch64_globus-gsi-proxy-ssl-doc.sha256sum] = "440b8675322e5c2e3818499af3354040c794193468bc031ce34ab3d1fe1ac118"

RDEPENDS:globus-gsi-proxy-ssl = " \
 glibc \
 openssl-libs \
 "
RDEPENDS:globus-gsi-proxy-ssl-devel = " \
 globus-gsi-proxy-ssl \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-gsi-proxy-ssl-doc = " \
 "
