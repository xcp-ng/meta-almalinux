# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-foldhash"
PV = "0.1.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-foldhash+default-devel \
 rust-foldhash+std-devel \
 rust-foldhash-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-foldhash-0.1.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b1aa95e3d6ac5161546298430dd3ae0083d4802c063c21de3856dc4dcf8185dd"

URI_x86_64_v2_rust-foldhash+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-foldhash+default-devel-0.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-foldhash+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-foldhash+default-devel}"
SRC_URI[x86_64_v2_rust-foldhash+default-devel.sha256sum] = "d5407ad4d394be2f439f8d45d8a9719bfef95fad67f238f63a274f7558a69644"

URI_x86_64_v2_rust-foldhash+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-foldhash+std-devel-0.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-foldhash+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-foldhash+std-devel}"
SRC_URI[x86_64_v2_rust-foldhash+std-devel.sha256sum] = "b07cabbc2a5dac3a1e28e0626da2aef5eecca0755221dc0b66c1564c770d580b"

URI_x86_64_v2_rust-foldhash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-foldhash-devel-0.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-foldhash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-foldhash-devel}"
SRC_URI[x86_64_v2_rust-foldhash-devel.sha256sum] = "323993728078cb8fe295bb1027d37d29d20d0d51890b4b1262bce5ad979077c6"

URI_aarch64_rust-foldhash+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-foldhash+default-devel-0.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-foldhash+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-foldhash+default-devel}"
SRC_URI[aarch64_rust-foldhash+default-devel.sha256sum] = "3be2376ad34b83a4cfc6ec896fa42525bea0eef9288fa084903f32d240153a72"

URI_aarch64_rust-foldhash+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-foldhash+std-devel-0.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-foldhash+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-foldhash+std-devel}"
SRC_URI[aarch64_rust-foldhash+std-devel.sha256sum] = "a052b5f20b9625f6da92c107dc99d5731ca8538e4e736ba57b265598e0ffdd82"

URI_aarch64_rust-foldhash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-foldhash-devel-0.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-foldhash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-foldhash-devel}"
SRC_URI[aarch64_rust-foldhash-devel.sha256sum] = "cb4e6b224f48959627b355691ef5edef3840f917681c289b44c3bb5dfa55c055"

RDEPENDS:rust-foldhash+default-devel = " \
 cargo \
 rust-foldhash+std-devel \
 rust-foldhash-devel \
 "
RDEPENDS:rust-foldhash+std-devel = " \
 cargo \
 rust-foldhash-devel \
 "
RDEPENDS:rust-foldhash-devel = " \
 cargo \
 rust \
 "
