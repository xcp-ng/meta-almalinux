# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Set-IntSpan"
PV = "1.19"
PR = "35.el10_0"
PACKAGES = " \
 perl-Set-IntSpan \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Set-IntSpan-1.19-35.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "94bb2b2ee88d8170b09879820371b4c6ba2992664013b9f4412233c4f4f64b6f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Set-IntSpan-1.19-35.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Set-IntSpan;unpack=0"
SRC_URI[x86_64_v2_perl-Set-IntSpan.sha256sum] = "1b801849c1461a651d50e77901ec674e9b91fd526c3ad20e06d823748ebd59f3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Set-IntSpan-1.19-35.el10_0.noarch.rpm;name=aarch64_perl-Set-IntSpan;unpack=0"
SRC_URI[aarch64_perl-Set-IntSpan.sha256sum] = "adcfea6a7d8c463ece4050deb140a67f038ab80653ef55cb1e1f9240040a7f42"

RDEPENDS:perl-Set-IntSpan = " \
 perl-Carp \
 perl-Exporter \
 perl-base \
 perl-constant \
 perl-if \
 perl-libs \
 perl-overload \
 "
