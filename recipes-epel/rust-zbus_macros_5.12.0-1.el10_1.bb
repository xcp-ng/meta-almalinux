# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zbus_macros"
PV = "5.12.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-zbus_macros+blocking-api-devel \
 rust-zbus_macros+default-devel \
 rust-zbus_macros+gvariant-devel \
 rust-zbus_macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zbus_macros-5.12.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e2c3e033676b86f36de0acd39af35cd0cca22ff4ae782cfbb00c26cd28bef75e"

URI_x86_64_v2_rust-zbus_macros+blocking-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus_macros+blocking-api-devel-5.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus_macros+blocking-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus_macros+blocking-api-devel}"
SRC_URI[x86_64_v2_rust-zbus_macros+blocking-api-devel.sha256sum] = "ce8ca3d5b83c258326257da56bce97e2b22ae2229058da96f08e5f83a926b9b0"

URI_x86_64_v2_rust-zbus_macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus_macros+default-devel-5.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus_macros+default-devel}"
SRC_URI[x86_64_v2_rust-zbus_macros+default-devel.sha256sum] = "97b7f669e3d3c4b5dc327a03fe5f0b90a4e60cb0e444a67427592de7583941c8"

URI_x86_64_v2_rust-zbus_macros+gvariant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus_macros+gvariant-devel-5.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus_macros+gvariant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus_macros+gvariant-devel}"
SRC_URI[x86_64_v2_rust-zbus_macros+gvariant-devel.sha256sum] = "a9b6317ab9c64bf6c9fa3de3c2d491ede784a48373d5ed95a2f3f690055ded55"

URI_x86_64_v2_rust-zbus_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus_macros-devel-5.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus_macros-devel}"
SRC_URI[x86_64_v2_rust-zbus_macros-devel.sha256sum] = "717d81defd84f2aaa3c65ce79c89c34692aacf5d7bbd93555eece9e2e946c595"

URI_aarch64_rust-zbus_macros+blocking-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus_macros+blocking-api-devel-5.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-zbus_macros+blocking-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus_macros+blocking-api-devel}"
SRC_URI[aarch64_rust-zbus_macros+blocking-api-devel.sha256sum] = "c85b78c7004669c08b0de15d97954c0bf9c46fb5dc12b8a4a6de63b1a0357554"

URI_aarch64_rust-zbus_macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus_macros+default-devel-5.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-zbus_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus_macros+default-devel}"
SRC_URI[aarch64_rust-zbus_macros+default-devel.sha256sum] = "ddac8fd51aea605189654fe8bd9494625a5ca7d93cd854dbc065fb3f6d6c6ebd"

URI_aarch64_rust-zbus_macros+gvariant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus_macros+gvariant-devel-5.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-zbus_macros+gvariant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus_macros+gvariant-devel}"
SRC_URI[aarch64_rust-zbus_macros+gvariant-devel.sha256sum] = "4b7bcc74b2cb3239ffd54190e0fc6c7c8e4a23ca0cbb33dad2270aed514e832e"

URI_aarch64_rust-zbus_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus_macros-devel-5.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-zbus_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus_macros-devel}"
SRC_URI[aarch64_rust-zbus_macros-devel.sha256sum] = "907b1e34823f2e23450cc5b5750151a5bbf6ccfc4f6e808e2538ba1b69fb7198"

RDEPENDS:rust-zbus_macros+blocking-api-devel = " \
 cargo \
 rust-zbus_macros-devel \
 "
RDEPENDS:rust-zbus_macros+default-devel = " \
 cargo \
 rust-zbus_macros-devel \
 "
RDEPENDS:rust-zbus_macros+gvariant-devel = " \
 cargo \
 rust-zbus_macros-devel \
 rust-zvariant+gvariant-devel \
 rust-zvariant_utils+gvariant-devel \
 "
RDEPENDS:rust-zbus_macros-devel = " \
 cargo \
 rust \
 rust-proc-macro-crate+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+fold-devel \
 rust-syn+full-devel \
 rust-zbus_names+default-devel \
 rust-zvariant+default-devel \
 rust-zvariant_utils+default-devel \
 "
