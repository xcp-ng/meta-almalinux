# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasmatube"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 plasmatube \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasmatube-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ef2a5bfac8ba3dc925df53be8b3040e3122aed68689e141f0a09ebfe19c02c1c"

URI_x86_64_v2_plasmatube = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasmatube-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasmatube;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasmatube}"
SRC_URI[x86_64_v2_plasmatube.sha256sum] = "bdc8857d19b602702a8184e814284e692464f91bf2f60787639af44c785cb744"

URI_aarch64_plasmatube = "${EPEL_MIRROR}/aarch64/Packages/p/plasmatube-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_plasmatube;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasmatube}"
SRC_URI[aarch64_plasmatube.sha256sum] = "cdc73a44a143e614027c40cf2869c1b8f132a90238e2a2268b057cf93de03b09"

RDEPENDS:plasmatube = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-knotifications \
 kf6-kwindowsystem \
 kf6-purpose \
 libstdc++ \
 mpvqt \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qtkeychain-qt6 \
 "
