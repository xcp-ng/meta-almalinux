# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cpuinfo"
PV = "24.09.26"
PR = "1.git1e83a2f.el10_0.1"
PACKAGES = " \
 cpuinfo \
 cpuinfo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cpuinfo-24.09.26-1.git1e83a2f.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df788e678650ee597af124bbb4828e4643c27d067ef89e698332f6f45ac467dd"

URI_x86_64_v2_cpuinfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cpuinfo-24.09.26-1.git1e83a2f.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_cpuinfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cpuinfo}"
SRC_URI[x86_64_v2_cpuinfo.sha256sum] = "43570a77c2bc0a9e0fc0898ee911da4e37c74212098003e01bbeed4f986441d4"

URI_x86_64_v2_cpuinfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cpuinfo-devel-24.09.26-1.git1e83a2f.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_cpuinfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cpuinfo-devel}"
SRC_URI[x86_64_v2_cpuinfo-devel.sha256sum] = "f1fe3154a6f93662c57a5c7ff211bc478945145ac49a95df783bb7373797afbc"

URI_aarch64_cpuinfo = "${EPEL_MIRROR}/aarch64/Packages/c/cpuinfo-24.09.26-1.git1e83a2f.el10_0.1.aarch64.rpm;name=aarch64_cpuinfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_cpuinfo}"
SRC_URI[aarch64_cpuinfo.sha256sum] = "9bf9d3c9f6b3063c3886dea8c657e240862df488e9514325b64d987c1ce8bf93"

URI_aarch64_cpuinfo-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cpuinfo-devel-24.09.26-1.git1e83a2f.el10_0.1.aarch64.rpm;name=aarch64_cpuinfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cpuinfo-devel}"
SRC_URI[aarch64_cpuinfo-devel.sha256sum] = "8e6a0d06373a47688550522c7e935ef29e103c766ee7f9e927e1966da1509a93"

RDEPENDS:cpuinfo = " \
 glibc \
 "
RDEPENDS:cpuinfo-devel = " \
 cpuinfo \
 pkgconf-pkg-config \
 "
