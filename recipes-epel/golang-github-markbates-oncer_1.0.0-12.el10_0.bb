# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-markbates-oncer"
PV = "1.0.0"
PR = "12.el10_0"
PACKAGES = " \
 golang-github-markbates-oncer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-markbates-oncer-1.0.0-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27367ac1a5e4570be9aa39cd7c41f104888332f42b4d0f05bad7294ceb2396a5"

URI_x86_64_v2_golang-github-markbates-oncer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-markbates-oncer-devel-1.0.0-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-markbates-oncer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-markbates-oncer-devel}"
SRC_URI[x86_64_v2_golang-github-markbates-oncer-devel.sha256sum] = "9203f7373d8eea04f296b3846f6fdcc7adf893823d1f889ca90fd387a063a6da"

URI_aarch64_golang-github-markbates-oncer-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-markbates-oncer-devel-1.0.0-12.el10_0.noarch.rpm;name=aarch64_golang-github-markbates-oncer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-markbates-oncer-devel}"
SRC_URI[aarch64_golang-github-markbates-oncer-devel.sha256sum] = "19e864158e9ade6354adddb3d6d1acff0949534cc524a92f1eeb0fd15c1d65e6"

RDEPENDS:golang-github-markbates-oncer-devel = " \
 go-filesystem \
 "
