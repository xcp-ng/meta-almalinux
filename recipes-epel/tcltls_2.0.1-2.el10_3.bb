# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tcltls"
PV = "2.0.1"
PR = "2.el10_3"
PACKAGES = " \
 tcltls \
 tcltls-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/t/tcltls-2.0.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "06e31fda08631a1d92078fc445fce863ed7f22133ae574d48c49bff60a90aa27"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tcltls-2.0.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tcltls;unpack=0"
SRC_URI[x86_64_v2_tcltls.sha256sum] = "a24dfcd91012baabec9af4c97ca460bf08bff7aa510c79660a1d9b28568a4044"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tcltls-devel-2.0.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tcltls-devel;unpack=0"
SRC_URI[x86_64_v2_tcltls-devel.sha256sum] = "f91479875fa499e59e5219a3b7f1a403d9f2ec158e2a5f4d3f1e36231c0d1720"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/tcltls-2.0.1-2.el10_3.aarch64.rpm;name=aarch64_tcltls;unpack=0"
SRC_URI[aarch64_tcltls.sha256sum] = "8e7a49ffa1627eb67c1eb305ec36d0dcc969cf73d9ae1f8b8cda0dfd47cb9c08"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/tcltls-devel-2.0.1-2.el10_3.aarch64.rpm;name=aarch64_tcltls-devel;unpack=0"
SRC_URI[aarch64_tcltls-devel.sha256sum] = "32a752f6e5c9de9c3fcd8fb13bf13ab4162aa1973b1fe3dd2dc2b2b5c7f4509a"

RDEPENDS:tcltls = " \
 glibc \
 openssl-libs \
 tcl \
 "
RDEPENDS:tcltls-devel = " \
 tcltls \
 "
