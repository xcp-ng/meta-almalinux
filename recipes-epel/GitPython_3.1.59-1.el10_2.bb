# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "GitPython"
PV = "3.1.59"
PR = "1.el10_2"
PACKAGES = " \
 python3-GitPython \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/GitPython-3.1.59-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc0a817e7ecd065a4d49a10128acc3256f1927a9b24e6b8d2841a1b05e5a20af"

URI_aarch64_python3-GitPython = "${EPEL_MIRROR}/aarch64/Packages/p/python3-GitPython-3.1.59-1.el10_2.noarch.rpm;name=aarch64_python3-GitPython;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-GitPython}"
SRC_URI[aarch64_python3-GitPython.sha256sum] = "490b47d7b836fa89354c1a948ca988a837002cb6e1f5ae69166a300e8d6cbc79"

RDEPENDS:python3-GitPython = " \
 git-core \
 python3 \
 python3-gitdb \
 "
