# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerocopy0.7"
PV = "0.7.35"
PR = "1.el10_0"
PACKAGES = " \
 rust-zerocopy0.7+__internal_use_only_features_that_work_on_stable-devel \
 rust-zerocopy0.7+alloc-devel \
 rust-zerocopy0.7+byteorder-devel \
 rust-zerocopy0.7+default-devel \
 rust-zerocopy0.7+derive-devel \
 rust-zerocopy0.7+simd-devel \
 rust-zerocopy0.7+simd-nightly-devel \
 rust-zerocopy0.7+zerocopy-derive-devel \
 rust-zerocopy0.7-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zerocopy0.7-0.7.35-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ea79d315f20312ed68c47f6749f02807412eff57cf68ca7194defb88b6f713a6"

URI_x86_64_v2_rust-zerocopy0.7+__internal_use_only_features_that_work_on_stable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy0.7+__internal_use_only_features_that_work_on_stable-devel-0.7.35-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy0.7+__internal_use_only_features_that_work_on_stable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy0.7+__internal_use_only_features_that_work_on_stable-devel}"
SRC_URI[x86_64_v2_rust-zerocopy0.7+__internal_use_only_features_that_work_on_stable-devel.sha256sum] = "4610d122344dc564c6be717138c5198bf361d09977eebfbfb00c59833b747960"

URI_x86_64_v2_rust-zerocopy0.7+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy0.7+alloc-devel-0.7.35-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy0.7+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy0.7+alloc-devel}"
SRC_URI[x86_64_v2_rust-zerocopy0.7+alloc-devel.sha256sum] = "6838963c1eed02733af03d8450e25ce19ea24893f1cab74aff30c35eddd74fe3"

URI_x86_64_v2_rust-zerocopy0.7+byteorder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy0.7+byteorder-devel-0.7.35-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy0.7+byteorder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy0.7+byteorder-devel}"
SRC_URI[x86_64_v2_rust-zerocopy0.7+byteorder-devel.sha256sum] = "8ca92f1ec1268c8b331ae36be4cbf7048ffd63e3a13a773f62fbdfd522996426"

URI_x86_64_v2_rust-zerocopy0.7+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy0.7+default-devel-0.7.35-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy0.7+default-devel}"
SRC_URI[x86_64_v2_rust-zerocopy0.7+default-devel.sha256sum] = "c3b19270a5c496c1daf41de8f966e93066bbccd8e05e1ee4add75b8af7c4ae94"

URI_x86_64_v2_rust-zerocopy0.7+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy0.7+derive-devel-0.7.35-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy0.7+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy0.7+derive-devel}"
SRC_URI[x86_64_v2_rust-zerocopy0.7+derive-devel.sha256sum] = "dad489ecd12fba73d05f570217b4005ff9c5c71d9dc18613d8e7df57c8be712c"

URI_x86_64_v2_rust-zerocopy0.7+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy0.7+simd-devel-0.7.35-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy0.7+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy0.7+simd-devel}"
SRC_URI[x86_64_v2_rust-zerocopy0.7+simd-devel.sha256sum] = "b03f4fdc8c57b4a20883783dbb651fb274165a7c7e79a691e3cc23e54f5a7705"

URI_x86_64_v2_rust-zerocopy0.7+simd-nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy0.7+simd-nightly-devel-0.7.35-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy0.7+simd-nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy0.7+simd-nightly-devel}"
SRC_URI[x86_64_v2_rust-zerocopy0.7+simd-nightly-devel.sha256sum] = "dafb28ad1d6635905897420c1712bd8c0f462b86f4bf5acb305a9d6d1fe4980f"

URI_x86_64_v2_rust-zerocopy0.7+zerocopy-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy0.7+zerocopy-derive-devel-0.7.35-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy0.7+zerocopy-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy0.7+zerocopy-derive-devel}"
SRC_URI[x86_64_v2_rust-zerocopy0.7+zerocopy-derive-devel.sha256sum] = "58ab9b7927431b7c61ff2e4d8be8da8ec080fc01aa79136eaee5248a9a098064"

URI_x86_64_v2_rust-zerocopy0.7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy0.7-devel-0.7.35-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy0.7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy0.7-devel}"
SRC_URI[x86_64_v2_rust-zerocopy0.7-devel.sha256sum] = "8830b58baa63278283bc553eb01b347c7766a941579115e8f81e15f08d610bca"

URI_aarch64_rust-zerocopy0.7+__internal_use_only_features_that_work_on_stable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy0.7+__internal_use_only_features_that_work_on_stable-devel-0.7.35-1.el10_0.noarch.rpm;name=aarch64_rust-zerocopy0.7+__internal_use_only_features_that_work_on_stable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy0.7+__internal_use_only_features_that_work_on_stable-devel}"
SRC_URI[aarch64_rust-zerocopy0.7+__internal_use_only_features_that_work_on_stable-devel.sha256sum] = "6e69964be6b8b45c223ba14f7c84d1db799f7568425772cbcd9290806bc9e387"

URI_aarch64_rust-zerocopy0.7+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy0.7+alloc-devel-0.7.35-1.el10_0.noarch.rpm;name=aarch64_rust-zerocopy0.7+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy0.7+alloc-devel}"
SRC_URI[aarch64_rust-zerocopy0.7+alloc-devel.sha256sum] = "d30355510b30724e4101372e9dea570e8d6db9d34b465304b6e177bd8f510a77"

URI_aarch64_rust-zerocopy0.7+byteorder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy0.7+byteorder-devel-0.7.35-1.el10_0.noarch.rpm;name=aarch64_rust-zerocopy0.7+byteorder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy0.7+byteorder-devel}"
SRC_URI[aarch64_rust-zerocopy0.7+byteorder-devel.sha256sum] = "252a4d938ea58c7f1ba053f7766bc3168718d4d0b7081e76ac4672b21148cd10"

URI_aarch64_rust-zerocopy0.7+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy0.7+default-devel-0.7.35-1.el10_0.noarch.rpm;name=aarch64_rust-zerocopy0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy0.7+default-devel}"
SRC_URI[aarch64_rust-zerocopy0.7+default-devel.sha256sum] = "f37cd99902d2c7e3061c8963c6b030f9f7097f91e4b080cdc0f4809fbbd03919"

URI_aarch64_rust-zerocopy0.7+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy0.7+derive-devel-0.7.35-1.el10_0.noarch.rpm;name=aarch64_rust-zerocopy0.7+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy0.7+derive-devel}"
SRC_URI[aarch64_rust-zerocopy0.7+derive-devel.sha256sum] = "0e42a51d0a95a4edb16268f0b69ed5eb454a7fe1c56c955fb2f85cd662a8c21d"

URI_aarch64_rust-zerocopy0.7+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy0.7+simd-devel-0.7.35-1.el10_0.noarch.rpm;name=aarch64_rust-zerocopy0.7+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy0.7+simd-devel}"
SRC_URI[aarch64_rust-zerocopy0.7+simd-devel.sha256sum] = "c9f224d28a0154f91588348b42b6e1aee55565bb39778a1515ccdcdd449b73a6"

URI_aarch64_rust-zerocopy0.7+simd-nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy0.7+simd-nightly-devel-0.7.35-1.el10_0.noarch.rpm;name=aarch64_rust-zerocopy0.7+simd-nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy0.7+simd-nightly-devel}"
SRC_URI[aarch64_rust-zerocopy0.7+simd-nightly-devel.sha256sum] = "d2e23bf7918dd9cb643fd005f036d85f2101a10fafb76ce7e469fc71ace21c5b"

URI_aarch64_rust-zerocopy0.7+zerocopy-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy0.7+zerocopy-derive-devel-0.7.35-1.el10_0.noarch.rpm;name=aarch64_rust-zerocopy0.7+zerocopy-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy0.7+zerocopy-derive-devel}"
SRC_URI[aarch64_rust-zerocopy0.7+zerocopy-derive-devel.sha256sum] = "ce5ab8b0ee88d1e7dec608b75c6bc0166e9cb4178419ec2014cef0cee7f4745f"

URI_aarch64_rust-zerocopy0.7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy0.7-devel-0.7.35-1.el10_0.noarch.rpm;name=aarch64_rust-zerocopy0.7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy0.7-devel}"
SRC_URI[aarch64_rust-zerocopy0.7-devel.sha256sum] = "60450000934bcbd20ff1e465af8ce39fdf55a315c63bcaec3e331bd9bbb8d39e"

RDEPENDS:rust-zerocopy0.7+__internal_use_only_features_that_work_on_stable-devel = " \
 cargo \
 rust-zerocopy0.7+alloc-devel \
 rust-zerocopy0.7+derive-devel \
 rust-zerocopy0.7+simd-devel \
 rust-zerocopy0.7-devel \
 "
RDEPENDS:rust-zerocopy0.7+alloc-devel = " \
 cargo \
 rust-zerocopy0.7-devel \
 "
RDEPENDS:rust-zerocopy0.7+byteorder-devel = " \
 cargo \
 rust-byteorder-devel \
 rust-zerocopy0.7-devel \
 "
RDEPENDS:rust-zerocopy0.7+default-devel = " \
 cargo \
 rust-zerocopy0.7+byteorder-devel \
 rust-zerocopy0.7-devel \
 "
RDEPENDS:rust-zerocopy0.7+derive-devel = " \
 cargo \
 rust-zerocopy0.7+zerocopy-derive-devel \
 rust-zerocopy0.7-devel \
 "
RDEPENDS:rust-zerocopy0.7+simd-devel = " \
 cargo \
 rust-zerocopy0.7-devel \
 "
RDEPENDS:rust-zerocopy0.7+simd-nightly-devel = " \
 cargo \
 rust-zerocopy0.7+simd-devel \
 rust-zerocopy0.7-devel \
 "
RDEPENDS:rust-zerocopy0.7+zerocopy-derive-devel = " \
 cargo \
 rust-zerocopy-derive0.7+default-devel \
 rust-zerocopy0.7-devel \
 "
RDEPENDS:rust-zerocopy0.7-devel = " \
 cargo \
 rust \
 rust-zerocopy-derive0.7+default-devel \
 "
