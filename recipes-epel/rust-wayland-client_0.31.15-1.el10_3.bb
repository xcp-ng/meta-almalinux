# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-client"
PV = "0.31.15"
PR = "1.el10_3"
PACKAGES = " \
 rust-wayland-client+default-devel \
 rust-wayland-client+dlopen-devel \
 rust-wayland-client+libwayland_1_23-devel \
 rust-wayland-client+log-devel \
 rust-wayland-client+system-devel \
 rust-wayland-client-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-client-0.31.15-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "50a36135f5770121152e5fe6d0a40fab3a6293fdf5f9b0fa98399d4a88d6f94b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-client+default-devel-0.31.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-client+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-client+default-devel.sha256sum] = "66042b5372ae77fb6e6d842b985213ad486c9c1c8da2861f8da6b819e4aae64c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-client+dlopen-devel-0.31.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-client+dlopen-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-client+dlopen-devel.sha256sum] = "dfadb40155ca3edf2bd3aa86f942d26e49637ef3a9ed9862dc0a2ef13c60f7f6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-client+libwayland_1_23-devel-0.31.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-client+libwayland_1_23-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-client+libwayland_1_23-devel.sha256sum] = "0ae486b7f48ffaa3698aba5f836795f1cc9ff9385e5ed7467216250e4020e56f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-client+log-devel-0.31.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-client+log-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-client+log-devel.sha256sum] = "41c62165345035e17c060ae2aee8d227bad83a73393ddb65da55ceede40601d6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-client+system-devel-0.31.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-client+system-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-client+system-devel.sha256sum] = "418c804ab33b0329171783242d147e5cd254808b08b8fa1a785ce93551cebbed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-client-devel-0.31.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-client-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-client-devel.sha256sum] = "4153af138f56e645c01aec0aa2ec2300d233e5036709842721dfb55c8b804e85"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-client+default-devel-0.31.15-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-client+default-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-client+default-devel.sha256sum] = "f9fc2b5c0c0a48af42c064c908da0aaf1bf0c877953d924d33694fd9f2cf6629"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-client+dlopen-devel-0.31.15-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-client+dlopen-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-client+dlopen-devel.sha256sum] = "a41cc4af23e4b7165efecbe9d5d418e2b1816a84160604c6a14b7a3570a84ca8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-client+libwayland_1_23-devel-0.31.15-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-client+libwayland_1_23-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-client+libwayland_1_23-devel.sha256sum] = "de887f30a5846e4609e90488b26adf8d6978cd37ce6b47d2aa0a104485445661"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-client+log-devel-0.31.15-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-client+log-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-client+log-devel.sha256sum] = "8722a5fcf8245f952f678333808d3c88bdc378af856b98232434e15135734693"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-client+system-devel-0.31.15-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-client+system-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-client+system-devel.sha256sum] = "7ac626b4a6181fd957d87fb8b213767a1d6ba65819b232c06f452e37487a6ae0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-client-devel-0.31.15-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-client-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-client-devel.sha256sum] = "4861e32db0cb04c9d9f25f140c0936036ac5d56f829f865a9e16741f7cbf206c"

RDEPENDS:rust-wayland-client+default-devel = " \
 cargo \
 rust-wayland-client-devel \
 "
RDEPENDS:rust-wayland-client+dlopen-devel = " \
 cargo \
 rust-wayland-backend+dlopen-devel \
 rust-wayland-client-devel \
 "
RDEPENDS:rust-wayland-client+libwayland_1_23-devel = " \
 cargo \
 rust-wayland-backend+libwayland_client_1_23-devel \
 rust-wayland-client-devel \
 "
RDEPENDS:rust-wayland-client+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-wayland-client-devel \
 "
RDEPENDS:rust-wayland-client+system-devel = " \
 cargo \
 rust-wayland-backend+client_system-devel \
 rust-wayland-client-devel \
 "
RDEPENDS:rust-wayland-client-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-rustix+default-devel \
 rust-rustix+event-devel \
 rust-wayland-backend+default-devel \
 rust-wayland-scanner+default-devel \
 "
