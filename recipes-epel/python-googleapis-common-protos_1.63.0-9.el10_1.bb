# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-googleapis-common-protos"
PV = "1.63.0"
PR = "9.el10_1"
PACKAGES = " \
 python3-googleapis-common-protos \
 python3-googleapis-common-protos+grpc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-googleapis-common-protos-1.63.0-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "480cbf104a7ce41e841d6ceb938bd04a0b9c148f25399931dde66b3da9ce1526"

URI_x86_64_v2_python3-googleapis-common-protos = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-googleapis-common-protos-1.63.0-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-googleapis-common-protos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-googleapis-common-protos}"
SRC_URI[x86_64_v2_python3-googleapis-common-protos.sha256sum] = "82f0ed270aabe5e9c41d3b13798532a831e0c2c2ebb38de6f847ee6b44b5e0a8"

URI_x86_64_v2_python3-googleapis-common-protos+grpc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-googleapis-common-protos+grpc-1.63.0-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-googleapis-common-protos+grpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-googleapis-common-protos+grpc}"
SRC_URI[x86_64_v2_python3-googleapis-common-protos+grpc.sha256sum] = "7fddde8a277935c96d171119cf79f486c3fc73e98ddbcdb20cfe1507478ae03e"

URI_aarch64_python3-googleapis-common-protos = "${EPEL_MIRROR}/aarch64/Packages/p/python3-googleapis-common-protos-1.63.0-9.el10_1.noarch.rpm;name=aarch64_python3-googleapis-common-protos;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-googleapis-common-protos}"
SRC_URI[aarch64_python3-googleapis-common-protos.sha256sum] = "7ccd4f56a5f7107b564a2bd1170433d0389936469410536134d793913404da0a"

URI_aarch64_python3-googleapis-common-protos+grpc = "${EPEL_MIRROR}/aarch64/Packages/p/python3-googleapis-common-protos+grpc-1.63.0-9.el10_1.noarch.rpm;name=aarch64_python3-googleapis-common-protos+grpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-googleapis-common-protos+grpc}"
SRC_URI[aarch64_python3-googleapis-common-protos+grpc.sha256sum] = "1ff8f64d789cd8c9258e59bd47b4c1c97ec4ea24075d1696b502fb25ee7b6107"

RDEPENDS:python3-googleapis-common-protos = " \
 python3 \
 python3-protobuf \
 "
RDEPENDS:python3-googleapis-common-protos+grpc = " \
 python3 \
 python3-googleapis-common-protos \
 python3-grpcio \
 "
