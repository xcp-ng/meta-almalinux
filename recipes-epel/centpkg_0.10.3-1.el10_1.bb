# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "centpkg"
PV = "0.10.3"
PR = "1.el10_1"
PACKAGES = " \
 centpkg \
 centpkg-sig \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/centpkg-0.10.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "41a7c2c8ed3d23de0387fead6bfd45561146312f781849b68709c21eb887442c"

URI_x86_64_v2_centpkg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/centpkg-0.10.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_centpkg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_centpkg}"
SRC_URI[x86_64_v2_centpkg.sha256sum] = "d8b93523cb139c243b39a2425137965c7481f9b2360c1c32ad439156c2912d94"

URI_x86_64_v2_centpkg-sig = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/centpkg-sig-0.10.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_centpkg-sig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_centpkg-sig}"
SRC_URI[x86_64_v2_centpkg-sig.sha256sum] = "9a42a6b4d45093f7b48298582a115f7f4a2ed3f40ffb7e7ff770f6ee960563ec"

URI_aarch64_centpkg = "${EPEL_MIRROR}/aarch64/Packages/c/centpkg-0.10.3-1.el10_1.noarch.rpm;name=aarch64_centpkg;unpack=0"
SRC_URI:append = " ${URI_aarch64_centpkg}"
SRC_URI[aarch64_centpkg.sha256sum] = "d7d26b80d287b4bf584d13d5687015e091f603522f8c3da04a036acba928d809"

URI_aarch64_centpkg-sig = "${EPEL_MIRROR}/aarch64/Packages/c/centpkg-sig-0.10.3-1.el10_1.noarch.rpm;name=aarch64_centpkg-sig;unpack=0"
SRC_URI:append = " ${URI_aarch64_centpkg-sig}"
SRC_URI[aarch64_centpkg-sig.sha256sum] = "fa922cbb77a2dde5db9aaf4f9ca67ecdd12579262e504192327008e298002a9d"

RDEPENDS:centpkg = " \
 python3 \
 python3-GitPython \
 python3-cryptography \
 python3-gitlab \
 python3-pycurl \
 python3-pyyaml \
 python3-rpkg \
 "
RDEPENDS:centpkg-sig = " \
 centpkg \
 python3 \
 "
