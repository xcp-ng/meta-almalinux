# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pagure-cli"
PV = "0.2.2"
PR = "1.el10_0"
PACKAGES = " \
 pagure-cli \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pagure-cli-0.2.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "197b5726ef9d99f370cea62cd1bcdbdb5e81c7acf2b295c1c6b8b7c8e75362c6"

URI_x86_64_v2_pagure-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pagure-cli-0.2.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pagure-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pagure-cli}"
SRC_URI[x86_64_v2_pagure-cli.sha256sum] = "9bf2b4447e29f9aee8c972f5f9156a6741fef50aa973b5a06408513da8a48894"

URI_aarch64_pagure-cli = "${EPEL_MIRROR}/aarch64/Packages/p/pagure-cli-0.2.2-1.el10_0.aarch64.rpm;name=aarch64_pagure-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_pagure-cli}"
SRC_URI[aarch64_pagure-cli.sha256sum] = "249f45d4f35ca515804a441f94de4b493ebc4fb62a01cc7eac190a234f278825"

RDEPENDS:pagure-cli = " \
 glibc \
 gmp \
 libffi \
 libyaml \
 zlib-ng-compat \
 "
