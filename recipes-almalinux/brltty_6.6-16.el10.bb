# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "brltty"
PV = "6.6"
PR = "16.el10"
PACKAGES = " \
 brlapi \
 brlapi-devel \
 brltty \
 brltty-at-spi2 \
 brltty-docs \
 brltty-dracut \
 brltty-espeak-ng \
 brltty-xw \
 ocaml-brlapi \
 python3-brlapi \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/brltty-6.6-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3acbb387f4ddd0b259bd18d647bf97c416ab1cd8682f68c21703a47b99267bd"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - ocaml-brlapi: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-brlapi: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-brlapi: ocaml(Stdlib__Array) = 75e38d886ba62047f48c000ae7d8f6f4
# - ocaml-brlapi: ocaml(Stdlib__Bigarray) = 8317b42277334e4ae5794d3cbabcaf4f
# - ocaml-brlapi: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-brlapi: ocaml(Stdlib__Complex) = 052959c6d02e4e692e7944dd137c4095
# - ocaml-brlapi: ocaml(Stdlib__Either) = d56b2e9ca14b69fdeef09f3b2fbd10ad
# - ocaml-brlapi: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-brlapi: ocaml(Stdlib__Seq) = ac22688c50c848ab417492a023ff76ab
# - ocaml-brlapi: ocaml(Unix) = 59e61ff7441dfacaa24d4eed6d45eeda
# - ocaml-brlapi: ocamlx(Stdlib__Array) = b3215f99afe054938b4b66df456093cb
# - ocaml-brlapi: ocamlx(Stdlib__Callback) = bafc96ea60f2aa399fe753ac0e40f764

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - ocaml-brlapi: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-brlapi: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-brlapi: ocaml(Stdlib__Array) = 75e38d886ba62047f48c000ae7d8f6f4
# - ocaml-brlapi: ocaml(Stdlib__Bigarray) = 8317b42277334e4ae5794d3cbabcaf4f
# - ocaml-brlapi: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-brlapi: ocaml(Stdlib__Complex) = 052959c6d02e4e692e7944dd137c4095
# - ocaml-brlapi: ocaml(Stdlib__Either) = d56b2e9ca14b69fdeef09f3b2fbd10ad
# - ocaml-brlapi: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-brlapi: ocaml(Stdlib__Seq) = ac22688c50c848ab417492a023ff76ab
# - ocaml-brlapi: ocaml(Unix) = 59e61ff7441dfacaa24d4eed6d45eeda
# - ocaml-brlapi: ocamlx(Stdlib__Array) = b3215f99afe054938b4b66df456093cb
# - ocaml-brlapi: ocamlx(Stdlib__Callback) = bafc96ea60f2aa399fe753ac0e40f764

URI_x86_64_v2_brlapi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/brlapi-0.8.5-16.el10.x86_64_v2.rpm;name=x86_64_v2_brlapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_brlapi}"
SRC_URI[x86_64_v2_brlapi.sha256sum] = "7d0b24837c266bd3cc2214130203d76c3f6bec1c45e6978f363049187b560323"

URI_x86_64_v2_brlapi-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/brlapi-devel-0.8.5-16.el10.x86_64_v2.rpm;name=x86_64_v2_brlapi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_brlapi-devel}"
SRC_URI[x86_64_v2_brlapi-devel.sha256sum] = "cb80a0e14a53b0ba675a6b3562f333b7e23b549054fdd71ab7db7b5defd49622"

URI_x86_64_v2_brltty = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/brltty-6.6-16.el10.x86_64_v2.rpm;name=x86_64_v2_brltty;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_brltty}"
SRC_URI[x86_64_v2_brltty.sha256sum] = "631f6ddc6c43d220b21383fbdbb971e62aedbe5901b6463a4f4d0fe08ef4d6c1"

URI_x86_64_v2_brltty-at-spi2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/brltty-at-spi2-6.6-16.el10.x86_64_v2.rpm;name=x86_64_v2_brltty-at-spi2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_brltty-at-spi2}"
SRC_URI[x86_64_v2_brltty-at-spi2.sha256sum] = "658acb5ba2ac939178b77be62df5a30d784b48e9f44c756571cfcdd768e744da"

URI_x86_64_v2_brltty-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/brltty-docs-6.6-16.el10.noarch.rpm;name=x86_64_v2_brltty-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_brltty-docs}"
SRC_URI[x86_64_v2_brltty-docs.sha256sum] = "e1bc4a341b20d051ab285f38c0e71f3a9e06ac9a76facd061badab46ce8b7b65"

URI_x86_64_v2_brltty-dracut = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/brltty-dracut-6.6-16.el10.x86_64_v2.rpm;name=x86_64_v2_brltty-dracut;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_brltty-dracut}"
SRC_URI[x86_64_v2_brltty-dracut.sha256sum] = "14a3367498fa24afbe9d881f259901229996515d93d2e42ea7dca9e47a733a35"

URI_x86_64_v2_brltty-espeak-ng = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/brltty-espeak-ng-6.6-16.el10.x86_64_v2.rpm;name=x86_64_v2_brltty-espeak-ng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_brltty-espeak-ng}"
SRC_URI[x86_64_v2_brltty-espeak-ng.sha256sum] = "58f0fb4127665a5bab11289542e2278a5630bb1edaf3a5c644d35b2e0bfd63cf"

URI_x86_64_v2_brltty-xw = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/brltty-xw-6.6-16.el10.x86_64_v2.rpm;name=x86_64_v2_brltty-xw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_brltty-xw}"
SRC_URI[x86_64_v2_brltty-xw.sha256sum] = "06162b1cf86f808d4a38bd99a399c64471a626d1c572d9930f2d920d7ffe366c"

URI_x86_64_v2_ocaml-brlapi = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ocaml-brlapi-0.8.5-16.el10.x86_64_v2.rpm;name=x86_64_v2_ocaml-brlapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ocaml-brlapi}"
SRC_URI[x86_64_v2_ocaml-brlapi.sha256sum] = "09bd2bec88a76a670f7570f7e0b0055e11abb45b59ffd5c05ee4d77c60bcc4f5"

URI_x86_64_v2_python3-brlapi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-brlapi-0.8.5-16.el10.x86_64_v2.rpm;name=x86_64_v2_python3-brlapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-brlapi}"
SRC_URI[x86_64_v2_python3-brlapi.sha256sum] = "dc1544399129de51fcbe89de1f45f3b37edda401a96c1aa02eb2f13d65eb0504"

URI_aarch64_brlapi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/brlapi-0.8.5-16.el10.aarch64.rpm;name=aarch64_brlapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_brlapi}"
SRC_URI[aarch64_brlapi.sha256sum] = "f72ca27debe0494fc746dcb699339a99c64b72a67a9c7f8989e57ed692337159"

URI_aarch64_brlapi-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/brlapi-devel-0.8.5-16.el10.aarch64.rpm;name=aarch64_brlapi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_brlapi-devel}"
SRC_URI[aarch64_brlapi-devel.sha256sum] = "2ab2d4fca43b499805759afd8c140565b76dbe98319f88c31025c650a67bd500"

URI_aarch64_brltty = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/brltty-6.6-16.el10.aarch64.rpm;name=aarch64_brltty;unpack=0"
SRC_URI:append = " ${URI_aarch64_brltty}"
SRC_URI[aarch64_brltty.sha256sum] = "c9360a66f0ee65af9839ba8d1324608d49143c8ef3d30ecc52244b17543c49e1"

URI_aarch64_brltty-at-spi2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/brltty-at-spi2-6.6-16.el10.aarch64.rpm;name=aarch64_brltty-at-spi2;unpack=0"
SRC_URI:append = " ${URI_aarch64_brltty-at-spi2}"
SRC_URI[aarch64_brltty-at-spi2.sha256sum] = "5efc0f453f7a888d2055c1848b38dc3d1986a48ce26e134f64bd3a6e40f8d9e7"

URI_aarch64_brltty-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/brltty-docs-6.6-16.el10.noarch.rpm;name=aarch64_brltty-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_brltty-docs}"
SRC_URI[aarch64_brltty-docs.sha256sum] = "e1bc4a341b20d051ab285f38c0e71f3a9e06ac9a76facd061badab46ce8b7b65"

URI_aarch64_brltty-dracut = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/brltty-dracut-6.6-16.el10.aarch64.rpm;name=aarch64_brltty-dracut;unpack=0"
SRC_URI:append = " ${URI_aarch64_brltty-dracut}"
SRC_URI[aarch64_brltty-dracut.sha256sum] = "b4304cc2dec289c614c24f7c226aa66a2838a1ae8105dde16ad54698fea116e9"

URI_aarch64_brltty-espeak-ng = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/brltty-espeak-ng-6.6-16.el10.aarch64.rpm;name=aarch64_brltty-espeak-ng;unpack=0"
SRC_URI:append = " ${URI_aarch64_brltty-espeak-ng}"
SRC_URI[aarch64_brltty-espeak-ng.sha256sum] = "8391734b9d1007090a49b26d06e6a4c660d3fcc9584b0b4344e0ce159a724dcb"

URI_aarch64_brltty-xw = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/brltty-xw-6.6-16.el10.aarch64.rpm;name=aarch64_brltty-xw;unpack=0"
SRC_URI:append = " ${URI_aarch64_brltty-xw}"
SRC_URI[aarch64_brltty-xw.sha256sum] = "8ea2d514c6c622333adc9a7bad860679ba19ed02f6f812590c159f4da31da74c"

URI_aarch64_ocaml-brlapi = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ocaml-brlapi-0.8.5-16.el10.aarch64.rpm;name=aarch64_ocaml-brlapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_ocaml-brlapi}"
SRC_URI[aarch64_ocaml-brlapi.sha256sum] = "a0029f09d2ac057992a14ab4c3767c1815552cb25a6637e3b7ea04680d21fa8e"

URI_aarch64_python3-brlapi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-brlapi-0.8.5-16.el10.aarch64.rpm;name=aarch64_python3-brlapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-brlapi}"
SRC_URI[aarch64_python3-brlapi.sha256sum] = "f1ec3a15811ff632bf811e5c6df8da8676f490a9aaf4cd148bd6ee64a9147aaf"

RDEPENDS:brlapi = " \
 bash \
 glibc \
 glibc-common \
 libX11 \
 libXfixes \
 libXtst \
 libicu \
 lua-libs \
 shadow-utils \
 util-linux \
 virtual/coreutils \
 "
RDEPENDS:brlapi-devel = " \
 brlapi \
 pkgconf-pkg-config \
 "
RDEPENDS:brltty = " \
 alsa-lib \
 bash \
 bluez-libs \
 brlapi \
 dbus-libs \
 glib2 \
 glibc \
 libicu \
 pcre2-utf32 \
 polkit-libs \
 python3 \
 shadow-utils \
 systemd \
 virtual/coreutils \
 "
RDEPENDS:brltty-at-spi2 = " \
 at-spi2-core \
 brltty \
 dbus-libs \
 glibc \
 libX11 \
 libXfixes \
 "
RDEPENDS:brltty-docs = " \
 brltty \
 "
RDEPENDS:brltty-dracut = " \
 bash \
 brltty \
 dracut \
 "
RDEPENDS:brltty-espeak-ng = " \
 brltty \
 espeak-ng \
 glibc \
 "
RDEPENDS:brltty-xw = " \
 brltty \
 glibc \
 libX11 \
 libXaw \
 libXt \
 xorg-x11-fonts-misc \
 "
RDEPENDS:ocaml-brlapi = " \
 brlapi \
 glibc \
 "
RDEPENDS:python3-brlapi = " \
 brlapi \
 glibc \
 python3 \
 "
