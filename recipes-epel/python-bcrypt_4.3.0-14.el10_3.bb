# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-bcrypt"
PV = "4.3.0"
PR = "14.el10_3"
PACKAGES = " \
 python3-bcrypt \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-bcrypt-4.3.0-14.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "97eaf3f05991e1e9398fb07caceb0460178dfc7efde11a971a3af06c0fe7f5f4"

URI_x86_64_v2_python3-bcrypt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-bcrypt-4.3.0-14.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-bcrypt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-bcrypt}"
SRC_URI[x86_64_v2_python3-bcrypt.sha256sum] = "68de21856c60c619c4e6d679dadac4fd0bb7a944e48cbcc8b4970e7b07104cbd"

URI_aarch64_python3-bcrypt = "${EPEL_MIRROR}/aarch64/Packages/p/python3-bcrypt-4.3.0-14.el10_3.aarch64.rpm;name=aarch64_python3-bcrypt;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-bcrypt}"
SRC_URI[aarch64_python3-bcrypt.sha256sum] = "3c84e09eeb6ee7b5085f5db9f1f37a5404a2db5c04c8892936cfb406e98a5975"

RDEPENDS:python3-bcrypt = " \
 glibc \
 libgcc \
 python3 \
 "
