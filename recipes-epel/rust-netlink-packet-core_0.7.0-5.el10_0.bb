# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-netlink-packet-core"
PV = "0.7.0"
PR = "5.el10_0"
PACKAGES = " \
 rust-netlink-packet-core+default-devel \
 rust-netlink-packet-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-netlink-packet-core-0.7.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0725942afdf1604a7ed9654c30b6fd8fe39c4185ef618ec17cdaf4b4ee149cb5"

URI_x86_64_v2_rust-netlink-packet-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netlink-packet-core+default-devel-0.7.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netlink-packet-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netlink-packet-core+default-devel}"
SRC_URI[x86_64_v2_rust-netlink-packet-core+default-devel.sha256sum] = "6ab479142a93fc1ad1bea95e53e45517d1facde9304e70fcdfce59283145cda6"

URI_x86_64_v2_rust-netlink-packet-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netlink-packet-core-devel-0.7.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netlink-packet-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netlink-packet-core-devel}"
SRC_URI[x86_64_v2_rust-netlink-packet-core-devel.sha256sum] = "e6b998a1b2d354225e7a891641a2b4948e63a6001e5aa9d008f4d65a0660bd77"

URI_aarch64_rust-netlink-packet-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netlink-packet-core+default-devel-0.7.0-5.el10_0.noarch.rpm;name=aarch64_rust-netlink-packet-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netlink-packet-core+default-devel}"
SRC_URI[aarch64_rust-netlink-packet-core+default-devel.sha256sum] = "dd30984aa08ffe8bc5de236df6eb99985703869c11ff1e0177ac36131e221562"

URI_aarch64_rust-netlink-packet-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netlink-packet-core-devel-0.7.0-5.el10_0.noarch.rpm;name=aarch64_rust-netlink-packet-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netlink-packet-core-devel}"
SRC_URI[aarch64_rust-netlink-packet-core-devel.sha256sum] = "acdb4c4af80f6375b7cdad089c742703809c30eb5e679e80aeed5a59dc4fbfb5"

RDEPENDS:rust-netlink-packet-core+default-devel = " \
 cargo \
 rust-netlink-packet-core-devel \
 "
RDEPENDS:rust-netlink-packet-core-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-byteorder+default-devel \
 rust-netlink-packet-utils+default-devel \
 "
