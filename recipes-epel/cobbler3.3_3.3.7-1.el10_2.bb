# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cobbler3.3"
PV = "3.3.7"
PR = "1.el10_2"
PACKAGES = " \
 cobbler3.3 \
 cobbler3.3-selinux \
 cobbler3.3-tests \
 cobbler3.3-tests-containers \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cobbler3.3-3.3.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "41e7d8c4a507c9f1c78af1aecfc70ebf85455f8f3260d8c7a15410421c6e7014"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - cobbler3.3: (syslinux if (filesystem.x86_64 or filesystem.i686))

URI_x86_64_v2_cobbler3.3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cobbler3.3-3.3.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_cobbler3.3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cobbler3.3}"
SRC_URI[x86_64_v2_cobbler3.3.sha256sum] = "b22d95ecac2544e98196cfdca16fcc85927148a6d2a83ee8cc301807c1ee54e6"

URI_x86_64_v2_cobbler3.3-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cobbler3.3-selinux-3.3.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_cobbler3.3-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cobbler3.3-selinux}"
SRC_URI[x86_64_v2_cobbler3.3-selinux.sha256sum] = "f7ca306497fd8e4ca9c08d1b0887a36b6247e1a23e22062faf98fcbf1e15b3d8"

URI_x86_64_v2_cobbler3.3-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cobbler3.3-tests-3.3.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_cobbler3.3-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cobbler3.3-tests}"
SRC_URI[x86_64_v2_cobbler3.3-tests.sha256sum] = "78647e6da7c9e3062c7e2b2b8a241966943f759559a952377a715a2417680d53"

URI_x86_64_v2_cobbler3.3-tests-containers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cobbler3.3-tests-containers-3.3.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_cobbler3.3-tests-containers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cobbler3.3-tests-containers}"
SRC_URI[x86_64_v2_cobbler3.3-tests-containers.sha256sum] = "dde688793d91c9d29f5508a10d24f4f239f4d7fe8fe32119f71af07e06caf124"

URI_aarch64_cobbler3.3 = "${EPEL_MIRROR}/aarch64/Packages/c/cobbler3.3-3.3.7-1.el10_2.noarch.rpm;name=aarch64_cobbler3.3;unpack=0"
SRC_URI:append = " ${URI_aarch64_cobbler3.3}"
SRC_URI[aarch64_cobbler3.3.sha256sum] = "ed51f69c3b4521f8bf281a40e23e3fea0a7b4095c8bd725e426f8a9683a9e9d8"

URI_aarch64_cobbler3.3-selinux = "${EPEL_MIRROR}/aarch64/Packages/c/cobbler3.3-selinux-3.3.7-1.el10_2.noarch.rpm;name=aarch64_cobbler3.3-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_cobbler3.3-selinux}"
SRC_URI[aarch64_cobbler3.3-selinux.sha256sum] = "4940e7d88c0015da1ef6a3caf7b286aec667f837813801e0a5e2092237b6f434"

URI_aarch64_cobbler3.3-tests = "${EPEL_MIRROR}/aarch64/Packages/c/cobbler3.3-tests-3.3.7-1.el10_2.noarch.rpm;name=aarch64_cobbler3.3-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_cobbler3.3-tests}"
SRC_URI[aarch64_cobbler3.3-tests.sha256sum] = "dd765d1727d47fb5267b3bf7ef2c5c922de20c8197151ddbf0fc52de3589cf6f"

URI_aarch64_cobbler3.3-tests-containers = "${EPEL_MIRROR}/aarch64/Packages/c/cobbler3.3-tests-containers-3.3.7-1.el10_2.noarch.rpm;name=aarch64_cobbler3.3-tests-containers;unpack=0"
SRC_URI:append = " ${URI_aarch64_cobbler3.3-tests-containers}"
SRC_URI[aarch64_cobbler3.3-tests-containers.sha256sum] = "b6bca2de7cef75d8d5b04ae4716967df681aa99a8443a03536a009c373a56db3"

RDEPENDS:cobbler3.3:x86_64_v2 = " \
 bash \
 cobbler3.3-selinux \
 createrepo_c \
 dnf-plugins-core \
 dosfstools \
 genisoimage \
 httpd \
 python3 \
 python3-cheetah \
 python3-distro \
 python3-dns \
 python3-file-magic \
 python3-ldap \
 python3-mod_wsgi \
 python3-netaddr \
 python3-pymongo \
 python3-pyyaml \
 python3-requests \
 python3-schema \
 rsync \
 syslinux \
 systemd \
 tftp-server \
 xorriso \
"
RDEPENDS:cobbler3.3:aarch64 = " \
 bash \
 cobbler3.3-selinux \
 createrepo_c \
 dnf-plugins-core \
 dosfstools \
 genisoimage \
 httpd \
 python3 \
 python3-cheetah \
 python3-distro \
 python3-dns \
 python3-file-magic \
 python3-ldap \
 python3-mod_wsgi \
 python3-netaddr \
 python3-pymongo \
 python3-pyyaml \
 python3-requests \
 python3-schema \
 rsync \
 systemd \
 tftp-server \
 xorriso \
"
RDEPENDS:cobbler3.3-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:cobbler3.3-tests = " \
 cobbler3.3 \
 "
RDEPENDS:cobbler3.3-tests-containers = " \
 bash \
 cobbler3.3 \
 "
