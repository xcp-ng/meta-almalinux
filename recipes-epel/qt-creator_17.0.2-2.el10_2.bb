# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt-creator"
PV = "17.0.2"
PR = "2.el10_2"
PACKAGES = " \
 qt-creator \
 qt-creator-data \
 qt-creator-doc \
 qt-creator-translations \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt-creator-17.0.2-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f558e4c3ef53e17d097bcf4762ae9aeca7236c92c34a59202be2ffd12f9b1654"

URI_x86_64_v2_qt-creator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt-creator-17.0.2-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt-creator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt-creator}"
SRC_URI[x86_64_v2_qt-creator.sha256sum] = "60360bc5a9f11cbeeafe67702b28b3e32086de988a889992382646dbe91741ab"

URI_x86_64_v2_qt-creator-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt-creator-data-17.0.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_qt-creator-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt-creator-data}"
SRC_URI[x86_64_v2_qt-creator-data.sha256sum] = "089207672b102c873ed206ef715b5a57a76bd017af5dd9e991b5a62b4495dd1d"

URI_x86_64_v2_qt-creator-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt-creator-doc-17.0.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_qt-creator-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt-creator-doc}"
SRC_URI[x86_64_v2_qt-creator-doc.sha256sum] = "164d08a125a52390399295fca355ef01ce8dc8cb8a3316cb9558d5fc203e06e2"

URI_x86_64_v2_qt-creator-translations = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt-creator-translations-17.0.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_qt-creator-translations;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt-creator-translations}"
SRC_URI[x86_64_v2_qt-creator-translations.sha256sum] = "e33d3f43bccaf7ba835f6ba3f84f9d19a6c637848455fda2e3709443f69bcf23"

URI_aarch64_qt-creator = "${EPEL_MIRROR}/aarch64/Packages/q/qt-creator-17.0.2-2.el10_2.aarch64.rpm;name=aarch64_qt-creator;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt-creator}"
SRC_URI[aarch64_qt-creator.sha256sum] = "d6dbad1ef0cb88f0f7865fea934aa80b042479bc0879ee99e37001a0bebd088f"

URI_aarch64_qt-creator-data = "${EPEL_MIRROR}/aarch64/Packages/q/qt-creator-data-17.0.2-2.el10_2.noarch.rpm;name=aarch64_qt-creator-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt-creator-data}"
SRC_URI[aarch64_qt-creator-data.sha256sum] = "41da77bda6127f8f73f8631620592302656272a9d7fb1f86e4604cffa6058ce2"

URI_aarch64_qt-creator-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt-creator-doc-17.0.2-2.el10_2.noarch.rpm;name=aarch64_qt-creator-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt-creator-doc}"
SRC_URI[aarch64_qt-creator-doc.sha256sum] = "2e9911f5310c7330de0fbd5e86c8141f0ba1144632459ed52e17c67905530309"

URI_aarch64_qt-creator-translations = "${EPEL_MIRROR}/aarch64/Packages/q/qt-creator-translations-17.0.2-2.el10_2.noarch.rpm;name=aarch64_qt-creator-translations;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt-creator-translations}"
SRC_URI[aarch64_qt-creator-translations.sha256sum] = "813682f364deb896a7ebc263e6b1087ceebf6b8ff9c0df26a8ca05f9e16f6c20"

RDEPENDS:qt-creator = " \
 bash \
 clang-libs \
 elfutils-libelf \
 elfutils-libs \
 glib2 \
 glibc \
 hicolor-icon-theme \
 libgcc \
 libstdc++ \
 libzstd \
 litehtml \
 llvm-libs \
 qt-creator-data \
 qt-creator-doc \
 qt-creator-translations \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtcharts \
 qt6-qtdeclarative \
 qt6-qtquick3d \
 qt6-qtserialport \
 qt6-qtsvg \
 qt6-qttools-libs-designer \
 qt6-qttools-libs-designercomponents \
 qt6-qttools-libs-help \
 qt6-qtwebengine \
 qt6-qtwebsockets \
 systemd-libs \
 xdg-utils \
 yaml-cpp \
 "
RDEPENDS:qt-creator-data = " \
 qt-creator \
 "
RDEPENDS:qt-creator-doc = " \
 qt-creator \
 "
RDEPENDS:qt-creator-translations = " \
 qt-creator-data \
 qt6-qttranslations \
 "
