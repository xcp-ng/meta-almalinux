# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libharu"
PV = "2.4.5"
PR = "1.el10_1"
PACKAGES = " \
 libharu \
 libharu-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libharu-2.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b441aec23f47330e203c5cf0a2905ca498d3f5955708b2f20842dad3e45845e5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libharu-2.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libharu;unpack=0"
SRC_URI[x86_64_v2_libharu.sha256sum] = "670c19716b453adaba986bd4163e7f0eb41871afa328596cc49b08db52de70c8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libharu-devel-2.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libharu-devel;unpack=0"
SRC_URI[x86_64_v2_libharu-devel.sha256sum] = "ed0ade5896dc94834a001287be3ac6f67e2c72bf29dc7726ec51aeb3fa93320f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libharu-2.4.5-1.el10_1.aarch64.rpm;name=aarch64_libharu;unpack=0"
SRC_URI[aarch64_libharu.sha256sum] = "c9cf4575d3b319e2c6fbebad7e2bb703e29763788634ef9c35262131e6503fdc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libharu-devel-2.4.5-1.el10_1.aarch64.rpm;name=aarch64_libharu-devel;unpack=0"
SRC_URI[aarch64_libharu-devel.sha256sum] = "1f566333f7ac0e3d8cd33802216a545607163dad4260f48c0f15c23a871860f5"

RDEPENDS:libharu = " \
 glibc \
 libpng \
 zlib-ng-compat \
 "
RDEPENDS:libharu-devel = " \
 libharu \
 "
