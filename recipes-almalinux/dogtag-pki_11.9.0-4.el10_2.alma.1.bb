# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dogtag-pki"
PV = "11.9.0"
PR = "4.el10_2.alma.1"
PACKAGES = " \
 idm-pki-acme \
 idm-pki-base \
 idm-pki-ca \
 idm-pki-java \
 idm-pki-kra \
 idm-pki-server \
 idm-pki-tools \
 python3-idm-pki \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dogtag-pki-11.9.0-4.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c64045f315a7a0f6fe3e5ff2c8771ba441bc934999b8e8aa056f328f583b9ed8"

URI_x86_64_v2_idm-pki-acme = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-acme-11.9.0-4.el10_2.alma.1.noarch.rpm;name=x86_64_v2_idm-pki-acme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idm-pki-acme}"
SRC_URI[x86_64_v2_idm-pki-acme.sha256sum] = "65f47e5c5837435369b77d7a6e0414cfd4e2ab76ac728e69b36043659fdf4ae8"

URI_x86_64_v2_idm-pki-base = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-base-11.9.0-4.el10_2.alma.1.noarch.rpm;name=x86_64_v2_idm-pki-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idm-pki-base}"
SRC_URI[x86_64_v2_idm-pki-base.sha256sum] = "2078148c1821766f42e07686376b4f47372e0d8d1f28117d64c14ecfa9c35ec2"

URI_x86_64_v2_idm-pki-ca = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-ca-11.9.0-4.el10_2.alma.1.noarch.rpm;name=x86_64_v2_idm-pki-ca;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idm-pki-ca}"
SRC_URI[x86_64_v2_idm-pki-ca.sha256sum] = "0b735f0dd0d261caa3582e67de71f6261dbab4015274cff710fc04879b00b9e9"

URI_x86_64_v2_idm-pki-java = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-java-11.9.0-4.el10_2.alma.1.noarch.rpm;name=x86_64_v2_idm-pki-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idm-pki-java}"
SRC_URI[x86_64_v2_idm-pki-java.sha256sum] = "19db97d8c3e96b064b9b644b115703383e1a284592656856fb4c10b17f0ff783"

URI_x86_64_v2_idm-pki-kra = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-kra-11.9.0-4.el10_2.alma.1.noarch.rpm;name=x86_64_v2_idm-pki-kra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idm-pki-kra}"
SRC_URI[x86_64_v2_idm-pki-kra.sha256sum] = "0969cdaf908804a41b9168709166a69e8aa7ae8fcc2e747357080f04a1172f5e"

URI_x86_64_v2_idm-pki-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-server-11.9.0-4.el10_2.alma.1.noarch.rpm;name=x86_64_v2_idm-pki-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idm-pki-server}"
SRC_URI[x86_64_v2_idm-pki-server.sha256sum] = "b82532ebd593f44ece5bc792082777393864e54da71878f86dc5d3f9abd9a78a"

URI_x86_64_v2_idm-pki-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-tools-11.9.0-4.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_idm-pki-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idm-pki-tools}"
SRC_URI[x86_64_v2_idm-pki-tools.sha256sum] = "52e152f0c8918344dec49d9c867448fde12d961064d0bc9094212bf4cb9fe88a"

URI_x86_64_v2_python3-idm-pki = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-idm-pki-11.9.0-4.el10_2.alma.1.noarch.rpm;name=x86_64_v2_python3-idm-pki;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-idm-pki}"
SRC_URI[x86_64_v2_python3-idm-pki.sha256sum] = "6e8938d303bc048889247d06f240b4f4e4629de2d3a8d8d05230791ef281e8a6"

URI_aarch64_idm-pki-acme = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-acme-11.9.0-4.el10_2.alma.1.noarch.rpm;name=aarch64_idm-pki-acme;unpack=0"
SRC_URI:append = " ${URI_aarch64_idm-pki-acme}"
SRC_URI[aarch64_idm-pki-acme.sha256sum] = "65f47e5c5837435369b77d7a6e0414cfd4e2ab76ac728e69b36043659fdf4ae8"

URI_aarch64_idm-pki-base = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-base-11.9.0-4.el10_2.alma.1.noarch.rpm;name=aarch64_idm-pki-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_idm-pki-base}"
SRC_URI[aarch64_idm-pki-base.sha256sum] = "2078148c1821766f42e07686376b4f47372e0d8d1f28117d64c14ecfa9c35ec2"

URI_aarch64_idm-pki-ca = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-ca-11.9.0-4.el10_2.alma.1.noarch.rpm;name=aarch64_idm-pki-ca;unpack=0"
SRC_URI:append = " ${URI_aarch64_idm-pki-ca}"
SRC_URI[aarch64_idm-pki-ca.sha256sum] = "0b735f0dd0d261caa3582e67de71f6261dbab4015274cff710fc04879b00b9e9"

URI_aarch64_idm-pki-java = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-java-11.9.0-4.el10_2.alma.1.noarch.rpm;name=aarch64_idm-pki-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_idm-pki-java}"
SRC_URI[aarch64_idm-pki-java.sha256sum] = "19db97d8c3e96b064b9b644b115703383e1a284592656856fb4c10b17f0ff783"

URI_aarch64_idm-pki-kra = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-kra-11.9.0-4.el10_2.alma.1.noarch.rpm;name=aarch64_idm-pki-kra;unpack=0"
SRC_URI:append = " ${URI_aarch64_idm-pki-kra}"
SRC_URI[aarch64_idm-pki-kra.sha256sum] = "0969cdaf908804a41b9168709166a69e8aa7ae8fcc2e747357080f04a1172f5e"

URI_aarch64_idm-pki-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-server-11.9.0-4.el10_2.alma.1.noarch.rpm;name=aarch64_idm-pki-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_idm-pki-server}"
SRC_URI[aarch64_idm-pki-server.sha256sum] = "b82532ebd593f44ece5bc792082777393864e54da71878f86dc5d3f9abd9a78a"

URI_aarch64_idm-pki-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-tools-11.9.0-4.el10_2.alma.1.aarch64.rpm;name=aarch64_idm-pki-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_idm-pki-tools}"
SRC_URI[aarch64_idm-pki-tools.sha256sum] = "911d56e54a90d54c502becd129b5c678560b834c3f624cfc4a1ab320c71ed902"

URI_aarch64_python3-idm-pki = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-idm-pki-11.9.0-4.el10_2.alma.1.noarch.rpm;name=aarch64_python3-idm-pki;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-idm-pki}"
SRC_URI[aarch64_python3-idm-pki.sha256sum] = "6e8938d303bc048889247d06f240b4f4e4629de2d3a8d8d05230791ef281e8a6"

RDEPENDS:idm-pki-acme = " \
 bash \
 idm-pki-server \
 "
RDEPENDS:idm-pki-base = " \
 bash \
 nss \
 python3-idm-pki \
 "
RDEPENDS:idm-pki-ca = " \
 bash \
 idm-pki-server \
 systemd \
 "
RDEPENDS:idm-pki-java = " \
 apache-commons-cli \
 apache-commons-codec \
 apache-commons-io \
 apache-commons-lang3 \
 apache-commons-logging \
 apache-commons-net \
 httpcomponents-client \
 idm-jss \
 idm-ldapjdk \
 idm-pki-base \
 java-21-openjdk-headless \
 slf4j \
 slf4j-jdk14 \
 "
RDEPENDS:idm-pki-kra = " \
 bash \
 idm-pki-server \
 systemd \
 "
RDEPENDS:idm-pki-server = " \
 bash \
 hostname \
 idm-jss-tomcat \
 idm-pki-tools \
 ipa-healthcheck-core \
 java-21-openjdk-headless \
 keyutils \
 openldap-clients \
 openssl \
 policycoreutils \
 policycoreutils-python-utils \
 procps-ng \
 python3 \
 python3-libselinux \
 python3-lxml \
 python3-policycoreutils \
 selinux-policy-targeted \
 shadow-utils \
 systemd \
 tomcat9 \
 unzip \
 "
RDEPENDS:idm-pki-tools = " \
 bash \
 file \
 glibc \
 idm-pki-java \
 libgcc \
 libstdc++ \
 nspr \
 nss \
 nss-tools \
 openldap \
 openldap-clients \
 openssl \
 p11-kit-trust \
 "
RDEPENDS:python3-idm-pki = " \
 idm-pki-base \
 python3 \
 python3-cryptography \
 python3-ldap \
 python3-lxml \
 python3-requests \
 python3-six \
 "
