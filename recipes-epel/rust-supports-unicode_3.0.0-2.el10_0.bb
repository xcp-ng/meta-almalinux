# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-supports-unicode"
PV = "3.0.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-supports-unicode+default-devel \
 rust-supports-unicode-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-supports-unicode-3.0.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ba009149219ee6a28ae6aa216059e200095950872e597f464c6c540ab9b8751"

URI_x86_64_v2_rust-supports-unicode+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-supports-unicode+default-devel-3.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-supports-unicode+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-supports-unicode+default-devel}"
SRC_URI[x86_64_v2_rust-supports-unicode+default-devel.sha256sum] = "e380867b601393b7b32ae14879fb5ebaf9bf81a31f7653a239402516b2b92bcc"

URI_x86_64_v2_rust-supports-unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-supports-unicode-devel-3.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-supports-unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-supports-unicode-devel}"
SRC_URI[x86_64_v2_rust-supports-unicode-devel.sha256sum] = "7c3205e0c55ca2edac3c80f292884ae5b0f53ca4de672c14001598b0c136eb73"

URI_aarch64_rust-supports-unicode+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-supports-unicode+default-devel-3.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-supports-unicode+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-supports-unicode+default-devel}"
SRC_URI[aarch64_rust-supports-unicode+default-devel.sha256sum] = "3e487a6b6b254f0090653d7f5095567134de4b8c9da92bdb4d4474c7b1f11fd2"

URI_aarch64_rust-supports-unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-supports-unicode-devel-3.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-supports-unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-supports-unicode-devel}"
SRC_URI[aarch64_rust-supports-unicode-devel.sha256sum] = "500968a3ec1f7c99be830e46e11f49d974ec91aa6d6f45b52ac5c153775a49aa"

RDEPENDS:rust-supports-unicode+default-devel = " \
 cargo \
 rust-supports-unicode-devel \
 "
RDEPENDS:rust-supports-unicode-devel = " \
 cargo \
 rust \
 "
