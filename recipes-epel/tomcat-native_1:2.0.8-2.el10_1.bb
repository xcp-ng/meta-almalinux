# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tomcat-native"
PE = "1"
PV = "2.0.8"
PR = "2.el10_1"
PACKAGES = " \
 tomcat-native \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tomcat-native-2.0.8-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a1c66b3481cff963bdb6b47df29b01d7c53b2a9339153b3ceb54170a3c5253f6"

URI_x86_64_v2_tomcat-native = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tomcat-native-2.0.8-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tomcat-native;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat-native}"
SRC_URI[x86_64_v2_tomcat-native.sha256sum] = "7052e7ad25bbd6252a75b2cca7daec26a53b298e8a578ab885578974063d74be"

URI_aarch64_tomcat-native = "${EPEL_MIRROR}/aarch64/Packages/t/tomcat-native-2.0.8-2.el10_1.aarch64.rpm;name=aarch64_tomcat-native;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat-native}"
SRC_URI[aarch64_tomcat-native.sha256sum] = "ba8ebcf8a9c8204f8e355d2f5efd8f0510098cf92c7bb525190ae4b78622c67e"

RDEPENDS:tomcat-native = " \
 apr \
 glibc \
 openssl-libs \
 "
