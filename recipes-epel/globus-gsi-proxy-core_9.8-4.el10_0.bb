# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gsi-proxy-core"
PV = "9.8"
PR = "4.el10_0"
PACKAGES = " \
 globus-gsi-proxy-core \
 globus-gsi-proxy-core-devel \
 globus-gsi-proxy-core-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gsi-proxy-core-9.8-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d41f4dd2382e20b9be67d8e7fa543becc1f7cf4c6cdf456dbb85ed2420507b5f"

URI_x86_64_v2_globus-gsi-proxy-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-proxy-core-9.8-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gsi-proxy-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-proxy-core}"
SRC_URI[x86_64_v2_globus-gsi-proxy-core.sha256sum] = "2a0f67cf3dfdd8dd211f1ab05008e2f4241cf6c68fd19f2bb1e0d02639e10d48"

URI_x86_64_v2_globus-gsi-proxy-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-proxy-core-devel-9.8-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gsi-proxy-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-proxy-core-devel}"
SRC_URI[x86_64_v2_globus-gsi-proxy-core-devel.sha256sum] = "61ce7a84ef1bb54ba91e27ab32fc53069576adb3ea2c62f6b9995726cceed36d"

URI_x86_64_v2_globus-gsi-proxy-core-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-proxy-core-doc-9.8-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gsi-proxy-core-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-proxy-core-doc}"
SRC_URI[x86_64_v2_globus-gsi-proxy-core-doc.sha256sum] = "fdf58e99b461647b0e61e4ec2408c6bf319b933e0ff000c7156bc8f8e0d72a09"

URI_aarch64_globus-gsi-proxy-core = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-proxy-core-9.8-4.el10_0.aarch64.rpm;name=aarch64_globus-gsi-proxy-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-proxy-core}"
SRC_URI[aarch64_globus-gsi-proxy-core.sha256sum] = "86cce39cfc2d688d158396d65e62f2863b00ce7193e14e393414dbef7517fc92"

URI_aarch64_globus-gsi-proxy-core-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-proxy-core-devel-9.8-4.el10_0.aarch64.rpm;name=aarch64_globus-gsi-proxy-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-proxy-core-devel}"
SRC_URI[aarch64_globus-gsi-proxy-core-devel.sha256sum] = "7a6c3c2bd573a2b4c4d50d60cb118a6f167e2eebaf4fd35c49a4b98c32688ee1"

URI_aarch64_globus-gsi-proxy-core-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-proxy-core-doc-9.8-4.el10_0.noarch.rpm;name=aarch64_globus-gsi-proxy-core-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-proxy-core-doc}"
SRC_URI[aarch64_globus-gsi-proxy-core-doc.sha256sum] = "5652b910e43cd246029cdea661406353c126e04e5018b42f8643c93f658b20f1"

RDEPENDS:globus-gsi-proxy-core = " \
 glibc \
 globus-common \
 globus-gsi-credential \
 globus-gsi-openssl-error \
 globus-gsi-proxy-ssl \
 globus-openssl-module \
 openssl-libs \
 "
RDEPENDS:globus-gsi-proxy-core-devel = " \
 globus-common-devel \
 globus-gsi-cert-utils-devel \
 globus-gsi-credential-devel \
 globus-gsi-openssl-error-devel \
 globus-gsi-proxy-core \
 globus-gsi-proxy-ssl-devel \
 globus-gsi-sysconfig-devel \
 globus-openssl-module-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-gsi-proxy-core-doc = " \
 "
