# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yasm"
PV = "1.3.0^20250625git121ab15"
PR = "1.el10_1"
PACKAGES = " \
 yasm \
 yasm-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/y/yasm-1.3.0^20250625git121ab15-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64f1d9041b3a4dd8989865d71dc1ce10d6dc19a2d5f75bf22ec9c701657fa6ac"

URI_x86_64_v2_yasm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yasm-1.3.0^20250625git121ab15-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yasm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yasm}"
SRC_URI[x86_64_v2_yasm.sha256sum] = "0cb8dd04580fd4b0154bcd890bbfb204cd29d9c4c2cec90d29a8125038a4924e"

URI_x86_64_v2_yasm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yasm-devel-1.3.0^20250625git121ab15-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yasm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yasm-devel}"
SRC_URI[x86_64_v2_yasm-devel.sha256sum] = "b21180c07951a37d1e485886fbb00ee5dc262af199131f06800366a719a0eab2"

URI_aarch64_yasm = "${EPEL_MIRROR}/aarch64/Packages/y/yasm-1.3.0^20250625git121ab15-1.el10_1.aarch64.rpm;name=aarch64_yasm;unpack=0"
SRC_URI:append = " ${URI_aarch64_yasm}"
SRC_URI[aarch64_yasm.sha256sum] = "118198262e71bc7b6e965d5685d63d2c2edb5003b8ab6665f4576ff42513eb42"

URI_aarch64_yasm-devel = "${EPEL_MIRROR}/aarch64/Packages/y/yasm-devel-1.3.0^20250625git121ab15-1.el10_1.aarch64.rpm;name=aarch64_yasm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_yasm-devel}"
SRC_URI[aarch64_yasm-devel.sha256sum] = "527be3a7f73374e7e314ed22a7682cde08854f22dc95d8d568c7c867016fba2f"

RDEPENDS:yasm = " \
 glibc \
 "
RDEPENDS:yasm-devel = " \
 yasm \
 "
