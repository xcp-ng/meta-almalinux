# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-syn"
PV = "3.0.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-syn+clone-impls-devel \
 rust-syn+default-devel \
 rust-syn+derive-devel \
 rust-syn+extra-traits-devel \
 rust-syn+fold-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn+test-devel \
 rust-syn+visit-devel \
 rust-syn+visit-mut-devel \
 rust-syn-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-syn-3.0.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "848b3fc19e83189ae8d9b8cf4a3d2f87a39b739c7d0afc848639efa871a4b399"

URI_x86_64_v2_rust-syn+clone-impls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+clone-impls-devel-3.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+clone-impls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+clone-impls-devel}"
SRC_URI[x86_64_v2_rust-syn+clone-impls-devel.sha256sum] = "8d20785a9fe1148640b16a6b0a15fbaf3ba29dc2bcadcd371f4a6eea6366cce0"

URI_x86_64_v2_rust-syn+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+default-devel-3.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+default-devel}"
SRC_URI[x86_64_v2_rust-syn+default-devel.sha256sum] = "54ac96986ce85412380281049549618858f9e66e37791f3eb2979bd6b9c88751"

URI_x86_64_v2_rust-syn+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+derive-devel-3.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+derive-devel}"
SRC_URI[x86_64_v2_rust-syn+derive-devel.sha256sum] = "d11aa8ce59d1ee6c96ac9e232c8b96db49996b8ab834f79c98002798543ead5c"

URI_x86_64_v2_rust-syn+extra-traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+extra-traits-devel-3.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+extra-traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+extra-traits-devel}"
SRC_URI[x86_64_v2_rust-syn+extra-traits-devel.sha256sum] = "d8303c168d4831d27d3929a6ab36bf1a1b8c4b95ca0d6762caf9510860ea6db4"

URI_x86_64_v2_rust-syn+fold-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+fold-devel-3.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+fold-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+fold-devel}"
SRC_URI[x86_64_v2_rust-syn+fold-devel.sha256sum] = "4e50323d14916b245af4fcdbbe1c71102ee0e06e1efa2e7e2be12a26833793ef"

URI_x86_64_v2_rust-syn+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+full-devel-3.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+full-devel}"
SRC_URI[x86_64_v2_rust-syn+full-devel.sha256sum] = "a3f7568b62a0f6a28132d94e244516261e6edb9a3e0cc8cf1f5e73b354f34314"

URI_x86_64_v2_rust-syn+parsing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+parsing-devel-3.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+parsing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+parsing-devel}"
SRC_URI[x86_64_v2_rust-syn+parsing-devel.sha256sum] = "e868e163c86767e06e002bd53ff2eb1bd2e0ce574d2f2d9a267d790bb3932f09"

URI_x86_64_v2_rust-syn+printing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+printing-devel-3.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+printing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+printing-devel}"
SRC_URI[x86_64_v2_rust-syn+printing-devel.sha256sum] = "f3b51971d520705c8ce791fb42c43f01ef0b695d720394b42368b109a1f7ba78"

URI_x86_64_v2_rust-syn+proc-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+proc-macro-devel-3.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+proc-macro-devel}"
SRC_URI[x86_64_v2_rust-syn+proc-macro-devel.sha256sum] = "822e9271a7847929c82480a02a88ce37d6123600babbc2e2af601f5aac0effc9"

URI_x86_64_v2_rust-syn+test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+test-devel-3.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+test-devel}"
SRC_URI[x86_64_v2_rust-syn+test-devel.sha256sum] = "8adb6317b551723eded740a44aeaf2c4abaa23d6fb1078891ce8aafc19db5b30"

URI_x86_64_v2_rust-syn+visit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+visit-devel-3.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+visit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+visit-devel}"
SRC_URI[x86_64_v2_rust-syn+visit-devel.sha256sum] = "42a1dbe73c0c9550cfae7e8e4f139bf2c6bb8a02642787a17766eafb2251df4e"

URI_x86_64_v2_rust-syn+visit-mut-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+visit-mut-devel-3.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+visit-mut-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+visit-mut-devel}"
SRC_URI[x86_64_v2_rust-syn+visit-mut-devel.sha256sum] = "0678b75bde0cfad44e5be8b93ebdd8b462d2df470cc7f5351efd0ecf5afa2f46"

URI_x86_64_v2_rust-syn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn-devel-3.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn-devel}"
SRC_URI[x86_64_v2_rust-syn-devel.sha256sum] = "a74ac1473cf92620600dcb41c749ad066df2c585be9547c5bf347f30f8efacc6"

URI_aarch64_rust-syn+clone-impls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+clone-impls-devel-3.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-syn+clone-impls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+clone-impls-devel}"
SRC_URI[aarch64_rust-syn+clone-impls-devel.sha256sum] = "91a46185bde0e037a62793ec76e9aeeb8e1a4eccd32cd779c738dcc78a31d153"

URI_aarch64_rust-syn+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+default-devel-3.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-syn+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+default-devel}"
SRC_URI[aarch64_rust-syn+default-devel.sha256sum] = "a02232657e0f679144ea9693df688f7ee9bb089c3f920552593bd49b032031ee"

URI_aarch64_rust-syn+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+derive-devel-3.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-syn+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+derive-devel}"
SRC_URI[aarch64_rust-syn+derive-devel.sha256sum] = "92acf478975960bf7ef2be85152529fa74580aac17c502e978ea36db77cd0951"

URI_aarch64_rust-syn+extra-traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+extra-traits-devel-3.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-syn+extra-traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+extra-traits-devel}"
SRC_URI[aarch64_rust-syn+extra-traits-devel.sha256sum] = "1a2b9abe26f52eefab5f17a9b17ee2335330014753e0766b08bdda9a3e5e518e"

URI_aarch64_rust-syn+fold-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+fold-devel-3.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-syn+fold-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+fold-devel}"
SRC_URI[aarch64_rust-syn+fold-devel.sha256sum] = "043ab3f63b24d415dcc436c218cb4abab934a0768433e538722d63e3a7068471"

URI_aarch64_rust-syn+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+full-devel-3.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-syn+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+full-devel}"
SRC_URI[aarch64_rust-syn+full-devel.sha256sum] = "d178f26efceed69aa4e0c13e16fae0563428125a8339c545588b4b1da3fb1c6d"

URI_aarch64_rust-syn+parsing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+parsing-devel-3.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-syn+parsing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+parsing-devel}"
SRC_URI[aarch64_rust-syn+parsing-devel.sha256sum] = "990f9c2fb628a8e27f86c35fc77bf9b60b3f4e98a076544db3803b51dd3e6cb7"

URI_aarch64_rust-syn+printing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+printing-devel-3.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-syn+printing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+printing-devel}"
SRC_URI[aarch64_rust-syn+printing-devel.sha256sum] = "50b91591dc8751538f3e2a893f3009436b101abf6b1415b6252cb2618f5cf6f0"

URI_aarch64_rust-syn+proc-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+proc-macro-devel-3.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-syn+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+proc-macro-devel}"
SRC_URI[aarch64_rust-syn+proc-macro-devel.sha256sum] = "98cf827c96f22575b74bdcc0840aa17562216963f35362ed7c0cbc63c20edeba"

URI_aarch64_rust-syn+test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+test-devel-3.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-syn+test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+test-devel}"
SRC_URI[aarch64_rust-syn+test-devel.sha256sum] = "9a9550761da708878b5ba7a733a35c5036109a998ca502de5d93b0362f742f42"

URI_aarch64_rust-syn+visit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+visit-devel-3.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-syn+visit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+visit-devel}"
SRC_URI[aarch64_rust-syn+visit-devel.sha256sum] = "eb17a079fbaae874177d3d902615c2972aff875dea2d7532676aa8884d95c0be"

URI_aarch64_rust-syn+visit-mut-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+visit-mut-devel-3.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-syn+visit-mut-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+visit-mut-devel}"
SRC_URI[aarch64_rust-syn+visit-mut-devel.sha256sum] = "4ba67e1460c980d31e9fd2949e43f00c1f99c26d3a689f4c9beab7205ceff1fe"

URI_aarch64_rust-syn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn-devel-3.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-syn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn-devel}"
SRC_URI[aarch64_rust-syn-devel.sha256sum] = "ebbf354bb9ff041b2c425390b785969d0199d023ed294cc8d172a55e0105df5a"

RDEPENDS:rust-syn+clone-impls-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+default-devel = " \
 cargo \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+derive-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+extra-traits-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+fold-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+full-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+parsing-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+printing-devel = " \
 cargo \
 rust-quote-devel \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+proc-macro-devel = " \
 cargo \
 rust-proc-macro2+proc-macro-devel \
 rust-quote+proc-macro-devel \
 rust-quote-devel \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+test-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+visit-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+visit-mut-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 rust-unicode-ident+default-devel \
 "
