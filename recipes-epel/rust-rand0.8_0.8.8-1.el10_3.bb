# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand0.8"
PV = "0.8.8"
PR = "1.el10_3"
PACKAGES = " \
 rust-rand0.8+alloc-devel \
 rust-rand0.8+default-devel \
 rust-rand0.8+getrandom-devel \
 rust-rand0.8+libc-devel \
 rust-rand0.8+log-devel \
 rust-rand0.8+min_const_gen-devel \
 rust-rand0.8+rand_chacha-devel \
 rust-rand0.8+serde-devel \
 rust-rand0.8+serde1-devel \
 rust-rand0.8+small_rng-devel \
 rust-rand0.8+std-devel \
 rust-rand0.8+std_rng-devel \
 rust-rand0.8-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-rand0.8-0.8.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "217d193441367d0a6f92e2fbb2c3c0538e47062aa48a589206694c6a34b95d2b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+alloc-devel-0.8.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand0.8+alloc-devel.sha256sum] = "77edd5e74de65b4cd8ff0c4c1404b1752678648e5cf6c176f809034340f56dec"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+default-devel-0.8.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand0.8+default-devel.sha256sum] = "b27c2f0dac525732706d420a5a81d4e3f88788249fde88ed2558473c069e0d19"
RPROVIDES:rust-rand0.8+default-devel:append:x86_64_v2 = " virtual/crate_rand/default__ge_0.3.10_with_crate_rand/default__lt_0.9.0~"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+getrandom-devel-0.8.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+getrandom-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand0.8+getrandom-devel.sha256sum] = "24ccdf9dac215d07cff832fbd8fcd33fbce02e21932820d19d48c9203f13b2d2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+libc-devel-0.8.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+libc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand0.8+libc-devel.sha256sum] = "070a02b98086e600d3f3e2506c869f89586418799b83ce50cfcf4de45c233daf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+log-devel-0.8.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+log-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand0.8+log-devel.sha256sum] = "32252937699e13fd45d65738fe21644a9160502981837910f3522cc7072ea69d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+min_const_gen-devel-0.8.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+min_const_gen-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand0.8+min_const_gen-devel.sha256sum] = "3e1f699c7ec9a7425ff01c3c12618ca94bcb8b63722fae5ee72fc0da8a21442f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+rand_chacha-devel-0.8.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+rand_chacha-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand0.8+rand_chacha-devel.sha256sum] = "ad3dbed6ed330a7e8b091cf0d8dc786618725e8947c71a1850688b0b0a25754e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+serde-devel-0.8.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand0.8+serde-devel.sha256sum] = "2a988cf8482fdf141004e5401d0af03987f6f260e1c7a91ce2828551de943758"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+serde1-devel-0.8.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+serde1-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand0.8+serde1-devel.sha256sum] = "f86f383333ee96cbf9fcc5900219a36f81ef125c7977863db8e43667df16d60b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+small_rng-devel-0.8.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+small_rng-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand0.8+small_rng-devel.sha256sum] = "544bc7f41ab0a85f9f5c4adfe34964627d6bd92220b8f22c4af033c8193c75c6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+std-devel-0.8.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand0.8+std-devel.sha256sum] = "86778580bd51d61ccb0092f255aa12294c332771b68b8a6a8cd4d2b609b8fffd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+std_rng-devel-0.8.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+std_rng-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand0.8+std_rng-devel.sha256sum] = "8502179ed6dfa58140e95034b1ec264f56b068c0bb676264f352db7a576a772b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8-devel-0.8.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand0.8-devel.sha256sum] = "d52a670a4b1fdb214891d182f045ca0627367f5c5442980fe5cc6d7043adfd88"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+alloc-devel-0.8.8-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.8+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-rand0.8+alloc-devel.sha256sum] = "c020a854b26593812fc41fb3340ec39f398728d26af2f06d2456168bb2fdad0e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+default-devel-0.8.8-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.8+default-devel;unpack=0"
SRC_URI[aarch64_rust-rand0.8+default-devel.sha256sum] = "99e062a303d43df35bd25842bc6f047f8935b9afec24663d4aab09d9994f9e9c"
RPROVIDES:rust-rand0.8+default-devel:append:aarch64 = " virtual/crate_rand/default__ge_0.3.10_with_crate_rand/default__lt_0.9.0~"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+getrandom-devel-0.8.8-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.8+getrandom-devel;unpack=0"
SRC_URI[aarch64_rust-rand0.8+getrandom-devel.sha256sum] = "dac087e503933123cfa1230d2b953f19ed4ec75fea6ee699d6c6e1d82ccaef36"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+libc-devel-0.8.8-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.8+libc-devel;unpack=0"
SRC_URI[aarch64_rust-rand0.8+libc-devel.sha256sum] = "2ce61c0fb5dad5e383c6ab2c571ae23a2a7effe11fd809764cf31f1669170a6a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+log-devel-0.8.8-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.8+log-devel;unpack=0"
SRC_URI[aarch64_rust-rand0.8+log-devel.sha256sum] = "4661ad8cbc0ff9011b670055dbbfa8fe16f808fefdb90ce530ac28941787987f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+min_const_gen-devel-0.8.8-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.8+min_const_gen-devel;unpack=0"
SRC_URI[aarch64_rust-rand0.8+min_const_gen-devel.sha256sum] = "d89be4207eeea98a3fcfbb8ff158cf7eae3d7f03082f9806a52c5372e7461362"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+rand_chacha-devel-0.8.8-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.8+rand_chacha-devel;unpack=0"
SRC_URI[aarch64_rust-rand0.8+rand_chacha-devel.sha256sum] = "054366f3358c74a8a4fb648ff204011dad9d2b8253e5fd9c3bc232642b5982fb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+serde-devel-0.8.8-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.8+serde-devel;unpack=0"
SRC_URI[aarch64_rust-rand0.8+serde-devel.sha256sum] = "363294eee67cd9a0bc439900c9469a9b7b90452f9ae575fb3fb70a09c25e8e90"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+serde1-devel-0.8.8-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.8+serde1-devel;unpack=0"
SRC_URI[aarch64_rust-rand0.8+serde1-devel.sha256sum] = "82aa38d0e3c793d4685a36216a9a045ffceb8cea63d872fb4c335ca6935b56fb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+small_rng-devel-0.8.8-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.8+small_rng-devel;unpack=0"
SRC_URI[aarch64_rust-rand0.8+small_rng-devel.sha256sum] = "c0dc4712b16891351cc4c5942e6007d668ca41c8cc0a63b8a3b7527134ac54aa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+std-devel-0.8.8-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.8+std-devel;unpack=0"
SRC_URI[aarch64_rust-rand0.8+std-devel.sha256sum] = "7134480d3d51ad33e187e9306cb9e7c299c46fe410341dac7ef0907f8e966f89"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+std_rng-devel-0.8.8-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.8+std_rng-devel;unpack=0"
SRC_URI[aarch64_rust-rand0.8+std_rng-devel.sha256sum] = "bf8e3ff19c3cb06adbcfe7207d9716fa9565eea1533bc05d6e29d6ff8a075232"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8-devel-0.8.8-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.8-devel;unpack=0"
SRC_URI[aarch64_rust-rand0.8-devel.sha256sum] = "f4e2b4d7963148498cb5200e1700522bafec26a0c72397a8032fbefa8105f37e"

RDEPENDS:rust-rand0.8+alloc-devel = " \
 cargo \
 rust-rand0.8-devel \
 rust-rand_core0.6+alloc-devel \
 "
RDEPENDS:rust-rand0.8+default-devel = " \
 cargo \
 rust-rand0.8+std-devel \
 rust-rand0.8+std_rng-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-rand0.8+getrandom-devel = " \
 cargo \
 rust-rand0.8-devel \
 rust-rand_core0.6+getrandom-devel \
 "
RDEPENDS:rust-rand0.8+libc-devel = " \
 cargo \
 rust-libc-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-rand0.8+log-devel = " \
 cargo \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-rand0.8+min_const_gen-devel = " \
 cargo \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-rand0.8+rand_chacha-devel = " \
 cargo \
 rust-rand0.8-devel \
 rust-rand_chacha0.3-devel \
 "
RDEPENDS:rust-rand0.8+serde-devel = " \
 cargo \
 rust-rand0.8-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand0.8+serde1-devel = " \
 cargo \
 rust-rand0.8+serde-devel \
 rust-rand0.8-devel \
 rust-rand_core0.6+serde1-devel \
 "
RDEPENDS:rust-rand0.8+small_rng-devel = " \
 cargo \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-rand0.8+std-devel = " \
 cargo \
 rust-rand0.8+alloc-devel \
 rust-rand0.8+getrandom-devel \
 rust-rand0.8+libc-devel \
 rust-rand0.8-devel \
 rust-rand_chacha0.3+std-devel \
 rust-rand_chacha0.3-devel \
 rust-rand_core0.6+std-devel \
 "
RDEPENDS:rust-rand0.8+std_rng-devel = " \
 cargo \
 rust-rand0.8+rand_chacha-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-rand0.8-devel = " \
 cargo \
 rust-rand_core0.6+default-devel \
 "
