# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dpdk"
PE = "2"
PV = "24.11.3"
PR = "1.el10_1"
PACKAGES = " \
 dpdk \
 dpdk-devel \
 dpdk-doc \
 dpdk-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dpdk-24.11.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e0001cebf4af5c708bc2561e531cdd311c2447307f706419df672d9852e4e95"

URI_x86_64_v2_dpdk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dpdk-24.11.3-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_dpdk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dpdk}"
SRC_URI[x86_64_v2_dpdk.sha256sum] = "66f621600b21fab49f1ac456f771cffd4bd029303280a590dc805e6f31c84d21"

URI_x86_64_v2_dpdk-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dpdk-devel-24.11.3-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_dpdk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dpdk-devel}"
SRC_URI[x86_64_v2_dpdk-devel.sha256sum] = "e6c2f7cd8776eacd0dd760158aef84cbaa9d45305ce5c33ca4b649cfe7d9481c"

URI_x86_64_v2_dpdk-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dpdk-doc-24.11.3-1.el10_1.noarch.rpm;name=x86_64_v2_dpdk-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dpdk-doc}"
SRC_URI[x86_64_v2_dpdk-doc.sha256sum] = "bf85b273fc5596d88e129a7a05afbd0c73da44f86219b2cc29ee8254cd9b7ba1"

URI_x86_64_v2_dpdk-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dpdk-tools-24.11.3-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_dpdk-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dpdk-tools}"
SRC_URI[x86_64_v2_dpdk-tools.sha256sum] = "34ba87b787392310dafeef672a64c1a227f0df2e4e0e082cdac90af5579014c1"

URI_aarch64_dpdk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dpdk-24.11.3-1.el10_1.aarch64.rpm;name=aarch64_dpdk;unpack=0"
SRC_URI:append = " ${URI_aarch64_dpdk}"
SRC_URI[aarch64_dpdk.sha256sum] = "12e5d641345dbdf00e78065f91233b3c222b858f44c0af823dc8c648f14919c4"

URI_aarch64_dpdk-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dpdk-devel-24.11.3-1.el10_1.aarch64.rpm;name=aarch64_dpdk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dpdk-devel}"
SRC_URI[aarch64_dpdk-devel.sha256sum] = "fd24a145e070d52b86f124c4949667940fd5f4324985e43accbb99b3a556ca88"

URI_aarch64_dpdk-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dpdk-doc-24.11.3-1.el10_1.noarch.rpm;name=aarch64_dpdk-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_dpdk-doc}"
SRC_URI[aarch64_dpdk-doc.sha256sum] = "bf85b273fc5596d88e129a7a05afbd0c73da44f86219b2cc29ee8254cd9b7ba1"

URI_aarch64_dpdk-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dpdk-tools-24.11.3-1.el10_1.aarch64.rpm;name=aarch64_dpdk-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_dpdk-tools}"
SRC_URI[aarch64_dpdk-tools.sha256sum] = "135799d0840f9ee9f711fab92cd2dc3d669b13d478a9acd82242deb6bed18795"

RDEPENDS:dpdk = " \
 glibc \
 libarchive \
 libibverbs \
 numactl-libs \
 "
RDEPENDS:dpdk-devel = " \
 bash \
 dpdk \
 dpdk-devel \
 libarchive-devel \
 pkgconf-pkg-config \
 python3 \
 rdma-core-devel \
 "
RDEPENDS:dpdk-doc = " \
 "
RDEPENDS:dpdk-tools = " \
 dpdk \
 findutils \
 iproute \
 kmod \
 pciutils \
 python3 \
 "
