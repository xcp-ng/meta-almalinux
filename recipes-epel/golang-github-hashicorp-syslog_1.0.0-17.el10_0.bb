# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-hashicorp-syslog"
PV = "1.0.0"
PR = "17.el10_0"
PACKAGES = " \
 golang-github-hashicorp-syslog-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-hashicorp-syslog-1.0.0-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0e069736e1a19c1716a6fde2241f9b93a5c102599c0ae1da8f5fcd8955145fe"

URI_x86_64_v2_golang-github-hashicorp-syslog-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-hashicorp-syslog-devel-1.0.0-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-hashicorp-syslog-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-hashicorp-syslog-devel}"
SRC_URI[x86_64_v2_golang-github-hashicorp-syslog-devel.sha256sum] = "e38134799126c6bb8493144f4d58ae548b672dd2565803b1261d15298cac551f"

URI_aarch64_golang-github-hashicorp-syslog-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-hashicorp-syslog-devel-1.0.0-17.el10_0.noarch.rpm;name=aarch64_golang-github-hashicorp-syslog-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-hashicorp-syslog-devel}"
SRC_URI[aarch64_golang-github-hashicorp-syslog-devel.sha256sum] = "0d7154452e776ee4328f8229a46c0806cb3390a467e7f99fcf9ddf117d7e7413"

RDEPENDS:golang-github-hashicorp-syslog-devel = " \
 go-filesystem \
 "
