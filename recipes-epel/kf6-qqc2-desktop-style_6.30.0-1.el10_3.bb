# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-qqc2-desktop-style"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-qqc2-desktop-style \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-qqc2-desktop-style-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7a27c6e50a58275fb13dfffcb9e4498020062062eef95e78790fe6debc3117fc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-qqc2-desktop-style-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-qqc2-desktop-style;unpack=0"
SRC_URI[x86_64_v2_kf6-qqc2-desktop-style.sha256sum] = "4ac2c44430628399ee5dbdb86eaf5b64130c46c615ada5a3f3595dbf520553e3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-qqc2-desktop-style-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-qqc2-desktop-style;unpack=0"
SRC_URI[aarch64_kf6-qqc2-desktop-style.sha256sum] = "7f4f6f5469852e8f54935d13a4b2a42f1b88763cdc15aea1c25a74e50f655669"

RDEPENDS:kf6-qqc2-desktop-style = " \
 cmake-filesystem \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kiconthemes \
 kf6-kirigami \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
