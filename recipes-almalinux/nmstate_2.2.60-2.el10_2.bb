# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nmstate"
PV = "2.2.60"
PR = "2.el10_2"
PACKAGES = " \
 nmstate \
 nmstate-devel \
 nmstate-libs \
 nmstate-static \
 python3-libnmstate \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nmstate-2.2.60-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "21c6d242fa5452794b5d95c97b14f99e42c86bac155eb2076fc26cfb5b4e62c5"

URI_x86_64_v2_nmstate = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nmstate-2.2.60-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_nmstate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nmstate}"
SRC_URI[x86_64_v2_nmstate.sha256sum] = "61327b232d6513d985e9cfb5f3e6f88d42a01c766a179965e5ae394c4c2045ca"

URI_x86_64_v2_nmstate-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nmstate-devel-2.2.60-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_nmstate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nmstate-devel}"
SRC_URI[x86_64_v2_nmstate-devel.sha256sum] = "e3d80d2b0d5e5c79dcd30a733e657900f6d3160516c275be5293eb1f906efe5d"

URI_x86_64_v2_nmstate-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nmstate-libs-2.2.60-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_nmstate-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nmstate-libs}"
SRC_URI[x86_64_v2_nmstate-libs.sha256sum] = "eab89c0523addeeddd51cd9fe6e6d44aa8cc631a2047e3d865a63c8694f034ed"

URI_x86_64_v2_nmstate-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nmstate-static-2.2.60-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_nmstate-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nmstate-static}"
SRC_URI[x86_64_v2_nmstate-static.sha256sum] = "61594c0a15372fd2a9a61f43df4fee4053eeaee2d6192c686e261b96f3659754"

URI_x86_64_v2_python3-libnmstate = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libnmstate-2.2.60-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3-libnmstate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libnmstate}"
SRC_URI[x86_64_v2_python3-libnmstate.sha256sum] = "5cb38fe6d2655b32794c6264b923f863feeb527ce40ca2b3d7dc80de1269c8e0"

URI_aarch64_nmstate = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nmstate-2.2.60-2.el10_2.aarch64.rpm;name=aarch64_nmstate;unpack=0"
SRC_URI:append = " ${URI_aarch64_nmstate}"
SRC_URI[aarch64_nmstate.sha256sum] = "fc23abb88f3c654258032f23ead4ac49d504ed9bc4bda5bd2aca26e7c295a81a"

URI_aarch64_nmstate-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nmstate-devel-2.2.60-2.el10_2.aarch64.rpm;name=aarch64_nmstate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nmstate-devel}"
SRC_URI[aarch64_nmstate-devel.sha256sum] = "11f41a6dad2f04556b0acd1e4d6ed0874de88ec4f38bfd6587cd28162c8574b8"

URI_aarch64_nmstate-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nmstate-libs-2.2.60-2.el10_2.aarch64.rpm;name=aarch64_nmstate-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nmstate-libs}"
SRC_URI[aarch64_nmstate-libs.sha256sum] = "db08ad681504b309c815a7bb2ba4a6ad03f1b3872a9b9d8b54f91295ae80c9a8"

URI_aarch64_nmstate-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nmstate-static-2.2.60-2.el10_2.aarch64.rpm;name=aarch64_nmstate-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_nmstate-static}"
SRC_URI[aarch64_nmstate-static.sha256sum] = "9f939acea58bb0bd0ea844e98e30a89221efe7dcdf9a88fc542b151b7013be10"

URI_aarch64_python3-libnmstate = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libnmstate-2.2.60-2.el10_2.aarch64.rpm;name=aarch64_python3-libnmstate;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libnmstate}"
SRC_URI[aarch64_python3-libnmstate.sha256sum] = "ea0e9e46add085693ba2387e67794b635e2efb4b0742af97c09a9e3bcdb2c1e0"

RDEPENDS:nmstate = " \
 glibc \
 libgcc \
 nmstate-libs \
 "
RDEPENDS:nmstate-devel = " \
 nmstate-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:nmstate-libs = " \
 glibc \
 libgcc \
 "
RDEPENDS:nmstate-static = " \
 nmstate-devel \
 "
RDEPENDS:python3-libnmstate = " \
 nmstate-libs \
 python3 \
 python3-pyyaml \
 "
