# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gawk"
PV = "5.3.0"
PR = "6.el10_2.1"
PACKAGES = " \
 gawk \
 gawk-all-langpacks \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/gawk-5.3.0-6.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "82acb2470933100a7fbf633984f2c19276c074d3c8dbfa16f3a28c1a7146f797"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/gawk-5.3.0-6.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_gawk;unpack=0"
SRC_URI[x86_64_v2_gawk.sha256sum] = "6ff378987297211a421dbe562d83007bd581f7caa5828b5143e1858e7a1e6926"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gawk-all-langpacks-5.3.0-6.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_gawk-all-langpacks;unpack=0"
SRC_URI[x86_64_v2_gawk-all-langpacks.sha256sum] = "3cff08accd1a136eb63df2141c4eab9ae3c6869ecd95a090f297ed0b68f50cd1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/gawk-5.3.0-6.el10_2.1.aarch64.rpm;name=aarch64_gawk;unpack=0"
SRC_URI[aarch64_gawk.sha256sum] = "6d1f321e6126573acd958d18faf3edda6c7bf10698104b85e93c4fb6c99560eb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gawk-all-langpacks-5.3.0-6.el10_2.1.aarch64.rpm;name=aarch64_gawk-all-langpacks;unpack=0"
SRC_URI[aarch64_gawk-all-langpacks.sha256sum] = "bb22ed0287f42ca79f6fbc317f37376835e2ad983212e1f421b86e3a03f89d4c"

RDEPENDS:gawk = " \
 bash \
 filesystem \
 glibc \
 gmp \
 mpfr \
 readline \
 "
RDEPENDS:gawk-all-langpacks = " \
 "
