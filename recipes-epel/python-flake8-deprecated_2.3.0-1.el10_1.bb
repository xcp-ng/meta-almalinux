# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-flake8-deprecated"
PV = "2.3.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-flake8-deprecated \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-flake8-deprecated-2.3.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "70363942f9a024ccfe4a0d71a28eb12808952c21d57bf17cb4a630f9f3e5290b"

URI_x86_64_v2_python3-flake8-deprecated = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-flake8-deprecated-2.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-flake8-deprecated;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-flake8-deprecated}"
SRC_URI[x86_64_v2_python3-flake8-deprecated.sha256sum] = "338c30d9414f25ceb3fb25c3e199f361ce9bf533dfd59284394d5b9ae3f0f139"

URI_aarch64_python3-flake8-deprecated = "${EPEL_MIRROR}/aarch64/Packages/p/python3-flake8-deprecated-2.3.0-1.el10_1.noarch.rpm;name=aarch64_python3-flake8-deprecated;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-flake8-deprecated}"
SRC_URI[aarch64_python3-flake8-deprecated.sha256sum] = "b23f3fb0021e9e1c377789ef74080904b093ec53c41857baad98f72ee29b02b3"

RDEPENDS:python3-flake8-deprecated = " \
 python3 \
 python3-flake8 \
 "
