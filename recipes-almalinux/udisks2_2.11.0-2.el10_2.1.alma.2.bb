# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "udisks2"
PV = "2.11.0"
PR = "2.el10_2.1.alma.2"
PACKAGES = " \
 libudisks2 \
 libudisks2-devel \
 udisks2 \
 udisks2-btrfs \
 udisks2-iscsi \
 udisks2-lsm \
 udisks2-lvm2 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/udisks2-2.11.0-2.el10_2.1.alma.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa168038e72486199c64b4065700f723953d41fb7df93b02aa458a57c1f649d8"

URI_x86_64_v2_libudisks2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libudisks2-2.11.0-2.el10_2.1.alma.2.x86_64_v2.rpm;name=x86_64_v2_libudisks2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libudisks2}"
SRC_URI[x86_64_v2_libudisks2.sha256sum] = "37924fa37533d86b8e30b7f3fbbcdc135ed96282d2e6711ff7df51caa673509b"

URI_x86_64_v2_libudisks2-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libudisks2-devel-2.11.0-2.el10_2.1.alma.2.x86_64_v2.rpm;name=x86_64_v2_libudisks2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libudisks2-devel}"
SRC_URI[x86_64_v2_libudisks2-devel.sha256sum] = "b97ed9b8900da3ed4bd120da40768f596c10bff1873bb93cc6c392cda34628a6"

URI_x86_64_v2_udisks2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/udisks2-2.11.0-2.el10_2.1.alma.2.x86_64_v2.rpm;name=x86_64_v2_udisks2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_udisks2}"
SRC_URI[x86_64_v2_udisks2.sha256sum] = "db06d6ab08781d1e57b4d6878ba550e5a31d37d0a7cfcf1b3f8ea6d867575844"

URI_x86_64_v2_udisks2-btrfs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/udisks2-btrfs-2.11.0-2.el10_2.1.alma.2.x86_64_v2.rpm;name=x86_64_v2_udisks2-btrfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_udisks2-btrfs}"
SRC_URI[x86_64_v2_udisks2-btrfs.sha256sum] = "c7e73c6587f9310b02f610dc0b1cd97a9314d81ae04c4aa3387a634f9ab6fbd0"

URI_x86_64_v2_udisks2-iscsi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/udisks2-iscsi-2.11.0-2.el10_2.1.alma.2.x86_64_v2.rpm;name=x86_64_v2_udisks2-iscsi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_udisks2-iscsi}"
SRC_URI[x86_64_v2_udisks2-iscsi.sha256sum] = "158186a1650bd037ad0cd9154302292e9c1d1f17ad8075973fc183c4f7854874"

URI_x86_64_v2_udisks2-lsm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/udisks2-lsm-2.11.0-2.el10_2.1.alma.2.x86_64_v2.rpm;name=x86_64_v2_udisks2-lsm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_udisks2-lsm}"
SRC_URI[x86_64_v2_udisks2-lsm.sha256sum] = "19285ef02dff2f45def5add063aebeeb312affa8939e5045e57a47d50e73d418"

URI_x86_64_v2_udisks2-lvm2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/udisks2-lvm2-2.11.0-2.el10_2.1.alma.2.x86_64_v2.rpm;name=x86_64_v2_udisks2-lvm2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_udisks2-lvm2}"
SRC_URI[x86_64_v2_udisks2-lvm2.sha256sum] = "17cc42fc5b71d82b33b1613969aee8518d8fa957d483de250c224606beaba8ea"

URI_aarch64_libudisks2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libudisks2-2.11.0-2.el10_2.1.alma.2.aarch64.rpm;name=aarch64_libudisks2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libudisks2}"
SRC_URI[aarch64_libudisks2.sha256sum] = "5bf60ddbfdd8ceba96ffc8e3579b6cf57b00eb8b78d20aa448db81c77eff8d94"

URI_aarch64_libudisks2-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libudisks2-devel-2.11.0-2.el10_2.1.alma.2.aarch64.rpm;name=aarch64_libudisks2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libudisks2-devel}"
SRC_URI[aarch64_libudisks2-devel.sha256sum] = "c51aacb8d41d55aa11ae9e2574428eea8f24cdc05be3e80c33c3686a354dbef3"

URI_aarch64_udisks2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/udisks2-2.11.0-2.el10_2.1.alma.2.aarch64.rpm;name=aarch64_udisks2;unpack=0"
SRC_URI:append = " ${URI_aarch64_udisks2}"
SRC_URI[aarch64_udisks2.sha256sum] = "24421a19130cf64be8c7c666d5d7ed3ebb937363f76a6c7790245ec2208a3555"

URI_aarch64_udisks2-btrfs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/udisks2-btrfs-2.11.0-2.el10_2.1.alma.2.aarch64.rpm;name=aarch64_udisks2-btrfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_udisks2-btrfs}"
SRC_URI[aarch64_udisks2-btrfs.sha256sum] = "0c07f244d0b83101aafe6fbffeebfad78fd78d061ad19c8c4f44b1e2a1278355"

URI_aarch64_udisks2-iscsi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/udisks2-iscsi-2.11.0-2.el10_2.1.alma.2.aarch64.rpm;name=aarch64_udisks2-iscsi;unpack=0"
SRC_URI:append = " ${URI_aarch64_udisks2-iscsi}"
SRC_URI[aarch64_udisks2-iscsi.sha256sum] = "b40c3c256af53b2bbce4bc3c3db829f7a6f2805998436c9c76d9414630d91581"

URI_aarch64_udisks2-lsm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/udisks2-lsm-2.11.0-2.el10_2.1.alma.2.aarch64.rpm;name=aarch64_udisks2-lsm;unpack=0"
SRC_URI:append = " ${URI_aarch64_udisks2-lsm}"
SRC_URI[aarch64_udisks2-lsm.sha256sum] = "4a8f0efe995b4b2f94944972ecc42df46e90a5e783f4a74511c97af2271aa731"

URI_aarch64_udisks2-lvm2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/udisks2-lvm2-2.11.0-2.el10_2.1.alma.2.aarch64.rpm;name=aarch64_udisks2-lvm2;unpack=0"
SRC_URI:append = " ${URI_aarch64_udisks2-lvm2}"
SRC_URI[aarch64_udisks2-lvm2.sha256sum] = "9e0d53531209172c6fc9f57850c1fc20614bdf5de8b6a1ea05d0e9ef322d05e7"

RDEPENDS:libudisks2 = " \
 glib2 \
 glibc \
 "
RDEPENDS:libudisks2-devel = " \
 glib2-devel \
 libudisks2 \
 libudisks2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:udisks2 = " \
 bash \
 dbus \
 glib2 \
 glibc \
 libacl \
 libblkid \
 libblockdev \
 libblockdev-crypto \
 libblockdev-fs \
 libblockdev-loop \
 libblockdev-mdraid \
 libblockdev-nvme \
 libblockdev-part \
 libblockdev-smart \
 libblockdev-swap \
 libblockdev-utils \
 libgcc \
 libgudev \
 libmount \
 libudisks2 \
 libuuid \
 polkit \
 polkit-libs \
 systemd-libs \
 systemd-udev \
 util-linux \
 "
RDEPENDS:udisks2-btrfs = " \
 glib2 \
 glibc \
 libacl \
 libblkid \
 libblockdev \
 libblockdev-btrfs \
 libblockdev-utils \
 libgcc \
 libgudev \
 libmount \
 libudisks2 \
 libuuid \
 polkit-libs \
 systemd-libs \
 "
RDEPENDS:udisks2-iscsi = " \
 glib2 \
 glibc \
 iscsi-initiator-utils \
 libacl \
 libblkid \
 libblockdev \
 libblockdev-utils \
 libgcc \
 libgudev \
 libmount \
 libudisks2 \
 libuuid \
 polkit-libs \
 systemd-libs \
 "
RDEPENDS:udisks2-lsm = " \
 glib2 \
 glibc \
 libacl \
 libblkid \
 libblockdev \
 libblockdev-utils \
 libconfig \
 libgcc \
 libgudev \
 libmount \
 libstoragemgmt \
 libudisks2 \
 libuuid \
 polkit-libs \
 systemd-libs \
 "
RDEPENDS:udisks2-lvm2 = " \
 glib2 \
 glibc \
 libacl \
 libblkid \
 libblockdev \
 libblockdev-lvm \
 libblockdev-utils \
 libgcc \
 libgudev \
 libmount \
 libudisks2 \
 libuuid \
 lvm2 \
 polkit-libs \
 systemd-libs \
 "
