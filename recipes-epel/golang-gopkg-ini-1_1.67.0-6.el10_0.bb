# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-gopkg-ini-1"
PV = "1.67.0"
PR = "6.el10_0"
PACKAGES = " \
 compat-golang-github-ini-devel \
 golang-gopkg-ini-1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-gopkg-ini-1-1.67.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a239a40439c3566f41f451736180290cbd6443ef1ade5d5c302d16bfc9f73c4c"

URI_x86_64_v2_compat-golang-github-ini-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/compat-golang-github-ini-devel-1.67.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_compat-golang-github-ini-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_compat-golang-github-ini-devel}"
SRC_URI[x86_64_v2_compat-golang-github-ini-devel.sha256sum] = "ec460199387776670d2204e19bc06885c612b588ea1287ea4221fcdb833b4c57"

URI_x86_64_v2_golang-gopkg-ini-1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-gopkg-ini-1-devel-1.67.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-gopkg-ini-1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-gopkg-ini-1-devel}"
SRC_URI[x86_64_v2_golang-gopkg-ini-1-devel.sha256sum] = "edf41e741138e80fab856f84b21adb247a41ce3ddda5ac7580ece57577c15d81"

URI_aarch64_compat-golang-github-ini-devel = "${EPEL_MIRROR}/aarch64/Packages/c/compat-golang-github-ini-devel-1.67.0-6.el10_0.noarch.rpm;name=aarch64_compat-golang-github-ini-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_compat-golang-github-ini-devel}"
SRC_URI[aarch64_compat-golang-github-ini-devel.sha256sum] = "45efc808c0c9df55bfb0738f4819327a42519ecb5a7f602c52978f0120763268"

URI_aarch64_golang-gopkg-ini-1-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-gopkg-ini-1-devel-1.67.0-6.el10_0.noarch.rpm;name=aarch64_golang-gopkg-ini-1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-gopkg-ini-1-devel}"
SRC_URI[aarch64_golang-gopkg-ini-1-devel.sha256sum] = "80802392d637f852ebd85c2b6de854dfc0a2a1726388060b1318d784d4c50ec3"

RDEPENDS:compat-golang-github-ini-devel = " \
 go-filesystem \
 golang-gopkg-ini-1-devel \
 "
RDEPENDS:golang-gopkg-ini-1-devel = " \
 go-filesystem \
 "
