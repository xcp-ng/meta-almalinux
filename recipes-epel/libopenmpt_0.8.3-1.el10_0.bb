# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libopenmpt"
PV = "0.8.3"
PR = "1.el10_0"
PACKAGES = " \
 libopenmpt \
 libopenmpt-devel \
 openmpt123 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libopenmpt-0.8.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "196dcdd70a5943e057437b1cd501c5be3f7dc61e650d9b12b2977a4f46f5d541"

URI_x86_64_v2_libopenmpt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libopenmpt-0.8.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libopenmpt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libopenmpt}"
SRC_URI[x86_64_v2_libopenmpt.sha256sum] = "352555d99573177c43c1107d6bdfa4fa760d19bfab9a9e25990b4d0421a6462e"

URI_x86_64_v2_libopenmpt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libopenmpt-devel-0.8.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libopenmpt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libopenmpt-devel}"
SRC_URI[x86_64_v2_libopenmpt-devel.sha256sum] = "e5a096144c8d2e5e566f688f1c751346fee08fb944bc841e75f21e07c30b52e6"

URI_x86_64_v2_openmpt123 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openmpt123-0.8.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openmpt123;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openmpt123}"
SRC_URI[x86_64_v2_openmpt123.sha256sum] = "a39a297282a90eee5ce774a57f5a8a0e2a791df29478bc3d32e43a7066eda9dd"

URI_aarch64_libopenmpt = "${EPEL_MIRROR}/aarch64/Packages/l/libopenmpt-0.8.3-1.el10_0.aarch64.rpm;name=aarch64_libopenmpt;unpack=0"
SRC_URI:append = " ${URI_aarch64_libopenmpt}"
SRC_URI[aarch64_libopenmpt.sha256sum] = "128576b0f8bfaea4e030f556c57c3ed26c906b255511bffb7d0629c3a69e9512"

URI_aarch64_libopenmpt-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libopenmpt-devel-0.8.3-1.el10_0.aarch64.rpm;name=aarch64_libopenmpt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libopenmpt-devel}"
SRC_URI[aarch64_libopenmpt-devel.sha256sum] = "26e6b588b1b024426afafe37ac22a42d0eb758742eadd9ebae61d2ee52428cdf"

URI_aarch64_openmpt123 = "${EPEL_MIRROR}/aarch64/Packages/o/openmpt123-0.8.3-1.el10_0.aarch64.rpm;name=aarch64_openmpt123;unpack=0"
SRC_URI:append = " ${URI_aarch64_openmpt123}"
SRC_URI[aarch64_openmpt123.sha256sum] = "28c80e0bc2570c40b7fce35f949ca2c2316ea1977672b9778007e7af1aae9e9c"

RDEPENDS:libopenmpt = " \
 glibc \
 libgcc \
 libogg \
 libstdc++ \
 libvorbis \
 mpg123-libs \
 zlib-ng-compat \
 "
RDEPENDS:libopenmpt-devel = " \
 libogg-devel \
 libopenmpt \
 libvorbis-devel \
 mpg123-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:openmpt123 = " \
 flac-libs \
 glibc \
 libgcc \
 libopenmpt \
 libsndfile \
 libstdc++ \
 pulseaudio-libs \
 "
