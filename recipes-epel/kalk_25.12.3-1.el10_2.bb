# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kalk"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kalk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kalk-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "31604da3f725245a4e1ff37de983c8e8d506026d89221f52221cbe27aa9d28b9"

URI_x86_64_v2_kalk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kalk-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kalk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kalk}"
SRC_URI[x86_64_v2_kalk.sha256sum] = "143efceafcc920d03f81dbfa41b3798839ec6562991e62ece1a69b8caf247da1"

URI_aarch64_kalk = "${EPEL_MIRROR}/aarch64/Packages/k/kalk-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kalk;unpack=0"
SRC_URI:append = " ${URI_aarch64_kalk}"
SRC_URI[aarch64_kalk.sha256sum] = "492370369f79a3687691a5b5661148dce043f83bcb67c840dca8b5aa57963678"

RDEPENDS:kalk = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kunitconversion \
 kf6-qqc2-desktop-style \
 kf6-sonnet \
 libqalculate \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
