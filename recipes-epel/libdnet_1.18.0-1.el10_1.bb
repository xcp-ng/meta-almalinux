# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdnet"
PV = "1.18.0"
PR = "1.el10_1"
PACKAGES = " \
 libdnet \
 libdnet-devel \
 libdnet-progs \
 python3-libdnet \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libdnet-1.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b73982008e5611679b7d548993efe79805ff2568a9da3c598ad445dcd7ba83ae"

URI_x86_64_v2_libdnet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdnet-1.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdnet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdnet}"
SRC_URI[x86_64_v2_libdnet.sha256sum] = "0550f6628ed15f79497669cb7884b93924b16f5cf74b98b08a7759f141d9245d"

URI_x86_64_v2_libdnet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdnet-devel-1.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdnet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdnet-devel}"
SRC_URI[x86_64_v2_libdnet-devel.sha256sum] = "008baefd7c15ff1f42de0b8ef76024ccfebbdefcdf30f95f2a6216e585ff4e87"

URI_x86_64_v2_libdnet-progs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdnet-progs-1.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdnet-progs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdnet-progs}"
SRC_URI[x86_64_v2_libdnet-progs.sha256sum] = "d953535a8349fdc5e55411189b0b67e1fba3b6cfba2fa59d2ba4b9a4b30cd536"

URI_x86_64_v2_python3-libdnet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-libdnet-1.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-libdnet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libdnet}"
SRC_URI[x86_64_v2_python3-libdnet.sha256sum] = "2b6500bcba89acc08043299f6e6248323a78040b337da0115df7f8f5be7e4950"

URI_aarch64_libdnet = "${EPEL_MIRROR}/aarch64/Packages/l/libdnet-1.18.0-1.el10_1.aarch64.rpm;name=aarch64_libdnet;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdnet}"
SRC_URI[aarch64_libdnet.sha256sum] = "5d1989b3b675d8171d7fecb4a230c63e6f45d1f11b6349bb030d6d2e2a737959"

URI_aarch64_libdnet-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libdnet-devel-1.18.0-1.el10_1.aarch64.rpm;name=aarch64_libdnet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdnet-devel}"
SRC_URI[aarch64_libdnet-devel.sha256sum] = "7c46385e0396897f552225c68280d87ec05ac840d59c1d9cade45bd954b9c4fb"

URI_aarch64_libdnet-progs = "${EPEL_MIRROR}/aarch64/Packages/l/libdnet-progs-1.18.0-1.el10_1.aarch64.rpm;name=aarch64_libdnet-progs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdnet-progs}"
SRC_URI[aarch64_libdnet-progs.sha256sum] = "24768c6ea029fe8942c1cafc4c231c660c1540a3b876f26f07729f875073f606"

URI_aarch64_python3-libdnet = "${EPEL_MIRROR}/aarch64/Packages/p/python3-libdnet-1.18.0-1.el10_1.aarch64.rpm;name=aarch64_python3-libdnet;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libdnet}"
SRC_URI[aarch64_python3-libdnet.sha256sum] = "37cf2b4d3381c992a38a8999c80640682db9f6e638c6f19de96261874d79ccec"

RDEPENDS:libdnet = " \
 glibc \
 "
RDEPENDS:libdnet-devel = " \
 bash \
 libdnet \
 "
RDEPENDS:libdnet-progs = " \
 glibc \
 libdnet \
 "
RDEPENDS:python3-libdnet = " \
 libdnet \
 python3 \
 "
