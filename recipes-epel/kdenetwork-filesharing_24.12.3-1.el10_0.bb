# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdenetwork-filesharing"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kdenetwork-filesharing \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdenetwork-filesharing-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6ef5cc328f224cabe199e4c1758e048a3689786fc341d7c67495605c501d4883"

URI_x86_64_v2_kdenetwork-filesharing = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdenetwork-filesharing-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdenetwork-filesharing;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdenetwork-filesharing}"
SRC_URI[x86_64_v2_kdenetwork-filesharing.sha256sum] = "8cb1f46d635efcf78ff62862f6e02bbd00e69eac7d9ab7bc178d96b7c040212d"

URI_aarch64_kdenetwork-filesharing = "${EPEL_MIRROR}/aarch64/Packages/k/kdenetwork-filesharing-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kdenetwork-filesharing;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdenetwork-filesharing}"
SRC_URI[aarch64_kdenetwork-filesharing.sha256sum] = "eda8dd76100c60e74f3587c2f52b7c05191b1539073c87cf9d6e738b91c6f44e"

RDEPENDS:kdenetwork-filesharing = " \
 PackageKit-Qt6 \
 glibc \
 kf6-kauth \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
