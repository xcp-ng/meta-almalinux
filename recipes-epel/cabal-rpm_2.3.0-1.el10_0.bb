# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cabal-rpm"
PV = "2.3.0"
PR = "1.el10_0"
PACKAGES = " \
 cabal-rpm \
 ghc-html-entities \
 ghc-html-entities-devel \
 ghc-html-entities-doc \
 ghc-html-entities-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cabal-rpm-2.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "569898392c937e317374d341f7e3334cde09f3dcc923ced8d63eb5008d1fc86f"

URI_x86_64_v2_cabal-rpm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cabal-rpm-2.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cabal-rpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cabal-rpm}"
SRC_URI[x86_64_v2_cabal-rpm.sha256sum] = "1c397f4fb77c8c78a39c52b866d629a8c8abb1f356e5bab14fcf95b9c5c8d9cc"

URI_x86_64_v2_ghc-html-entities = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-html-entities-1.1.4.7-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-html-entities;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-html-entities}"
SRC_URI[x86_64_v2_ghc-html-entities.sha256sum] = "4cffc8700a8c347b2b8f55ab265323d0f72f4af57f5fb89aaad56c6c8531b183"

URI_x86_64_v2_ghc-html-entities-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-html-entities-devel-1.1.4.7-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-html-entities-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-html-entities-devel}"
SRC_URI[x86_64_v2_ghc-html-entities-devel.sha256sum] = "a96b2e1300b36ddbd4e81fef32cbb1091d62b56b722c47ffed3f2767c19d373a"

URI_x86_64_v2_ghc-html-entities-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-html-entities-doc-1.1.4.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-html-entities-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-html-entities-doc}"
SRC_URI[x86_64_v2_ghc-html-entities-doc.sha256sum] = "e7fe09263d6af78dbc2f0657c09514b0c8cb9650c352da82c7dd7a18222d37fc"

URI_x86_64_v2_ghc-html-entities-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-html-entities-prof-1.1.4.7-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-html-entities-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-html-entities-prof}"
SRC_URI[x86_64_v2_ghc-html-entities-prof.sha256sum] = "86f5640cf182214d4d1fe62be47d0eaf0d6d65ab5814ed966d22289aadf2866e"

URI_aarch64_cabal-rpm = "${EPEL_MIRROR}/aarch64/Packages/c/cabal-rpm-2.3.0-1.el10_0.aarch64.rpm;name=aarch64_cabal-rpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_cabal-rpm}"
SRC_URI[aarch64_cabal-rpm.sha256sum] = "835249b560c81e0b6f90ec2707c482f9b458fff483b54248183fa8e6080fac17"

URI_aarch64_ghc-html-entities = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-html-entities-1.1.4.7-1.el10_0.aarch64.rpm;name=aarch64_ghc-html-entities;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-html-entities}"
SRC_URI[aarch64_ghc-html-entities.sha256sum] = "e3df752b98c650f3019909b8d2994efe626261a09990da692c60928f73021eae"

URI_aarch64_ghc-html-entities-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-html-entities-devel-1.1.4.7-1.el10_0.aarch64.rpm;name=aarch64_ghc-html-entities-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-html-entities-devel}"
SRC_URI[aarch64_ghc-html-entities-devel.sha256sum] = "d12aeec4dc4fea6dbdaefed9263b35ca4485b5ed4194b10a5e855e0a466d5073"

URI_aarch64_ghc-html-entities-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-html-entities-doc-1.1.4.7-1.el10_0.noarch.rpm;name=aarch64_ghc-html-entities-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-html-entities-doc}"
SRC_URI[aarch64_ghc-html-entities-doc.sha256sum] = "18dfe27914a486a95cb2030fa33ab1faff95c1a72936238f3c5cb9ff4b4ba8a9"

URI_aarch64_ghc-html-entities-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-html-entities-prof-1.1.4.7-1.el10_0.aarch64.rpm;name=aarch64_ghc-html-entities-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-html-entities-prof}"
SRC_URI[aarch64_ghc-html-entities-prof.sha256sum] = "534c393c86e2a98b04d474589b04c608a5d51e15c86891fd91eb1d7ed136e056"

RDEPENDS:cabal-rpm = " \
 cabal-install \
 dnf-plugins-core \
 dos2unix \
 ghc-rpm-macros \
 glibc \
 gmp \
 libffi \
 rpm-build \
 rpmdevtools \
 wget \
 zlib-ng-compat \
 "
RDEPENDS:ghc-html-entities = " \
 ghc-array \
 ghc-attoparsec \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-integer-logarithms \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-scientific \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 ghc-unordered-containers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-html-entities-devel = " \
 ghc-attoparsec-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-html-entities \
 ghc-text-devel \
 ghc-unordered-containers-devel \
 "
RDEPENDS:ghc-html-entities-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-html-entities-prof = " \
 ghc-attoparsec-prof \
 ghc-base-prof \
 ghc-html-entities-devel \
 ghc-text-prof \
 ghc-unordered-containers-prof \
 "
