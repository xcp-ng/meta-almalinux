# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-Class"
PV = "0.52"
PR = "10.el10_0"
PACKAGES = " \
 perl-Test-Class \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Test-Class-0.52-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "44357dc43f5d609f23ee7f1076b17d26c7892a468efb731c738d534cfea451dd"

URI_x86_64_v2_perl-Test-Class = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-Class-0.52-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-Class;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-Class}"
SRC_URI[x86_64_v2_perl-Test-Class.sha256sum] = "4eaf084ef67add17de748cc39215f2923f5a5067964f358aeb698e6a68f2c500"

URI_aarch64_perl-Test-Class = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-Class-0.52-10.el10_0.noarch.rpm;name=aarch64_perl-Test-Class;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-Class}"
SRC_URI[aarch64_perl-Test-Class.sha256sum] = "68302a51bc2f13f8e9a269ecb5d03af8c59a17a15a6c9575444f528e14bbdf43"

RDEPENDS:perl-Test-Class = " \
 perl-Attribute-Handlers \
 perl-Carp \
 perl-File-Find \
 perl-MRO-Compat \
 perl-Module-Runtime \
 perl-PathTools \
 perl-Storable \
 perl-Test-Class \
 perl-Test-Simple \
 perl-Try-Tiny \
 perl-constant \
 perl-libs \
 "
