# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dovecot"
PE = "1"
PV = "2.3.21"
PR = "19.el10"
PACKAGES = " \
 dovecot \
 dovecot-devel \
 dovecot-mysql \
 dovecot-pgsql \
 dovecot-pigeonhole \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dovecot-2.3.21-19.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4dd0683b92ee85c2b6bfb23cfbc06113d12d4aa03b89e283d67ca231be86ea68"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - dovecot: libcap.so.2()(64bit)

URI_x86_64_v2_dovecot = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dovecot-2.3.21-19.el10.x86_64_v2.rpm;name=x86_64_v2_dovecot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dovecot}"
SRC_URI[x86_64_v2_dovecot.sha256sum] = "c20723e14b224995a42430857bc923dfd52ff13deba309e2182599600a917ffd"

URI_x86_64_v2_dovecot-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dovecot-devel-2.3.21-19.el10.x86_64_v2.rpm;name=x86_64_v2_dovecot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dovecot-devel}"
SRC_URI[x86_64_v2_dovecot-devel.sha256sum] = "475e6482ed718e1276d95b53eabe49b7f9db70a816fd01d77b5625bf7a10a315"

URI_x86_64_v2_dovecot-mysql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dovecot-mysql-2.3.21-19.el10.x86_64_v2.rpm;name=x86_64_v2_dovecot-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dovecot-mysql}"
SRC_URI[x86_64_v2_dovecot-mysql.sha256sum] = "f25599c4b7e62f611f560543afbc047e03c063ef232649c184ed83a6932ef4db"

URI_x86_64_v2_dovecot-pgsql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dovecot-pgsql-2.3.21-19.el10.x86_64_v2.rpm;name=x86_64_v2_dovecot-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dovecot-pgsql}"
SRC_URI[x86_64_v2_dovecot-pgsql.sha256sum] = "e9ed77586a3a8c3adab26ea60cffd0b8ce65ac2af5463d5ab315c8464abf709e"

URI_x86_64_v2_dovecot-pigeonhole = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dovecot-pigeonhole-2.3.21-19.el10.x86_64_v2.rpm;name=x86_64_v2_dovecot-pigeonhole;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dovecot-pigeonhole}"
SRC_URI[x86_64_v2_dovecot-pigeonhole.sha256sum] = "27aa6cbca614356809033544a1bdc03fabc31871f3d4ace522768be869ad74c3"

URI_aarch64_dovecot = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dovecot-2.3.21-19.el10.aarch64.rpm;name=aarch64_dovecot;unpack=0"
SRC_URI:append = " ${URI_aarch64_dovecot}"
SRC_URI[aarch64_dovecot.sha256sum] = "0778f374c5a044fb0887860ac2903b9b3a74f367f7a7968534f3164feffbb661"

URI_aarch64_dovecot-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dovecot-devel-2.3.21-19.el10.aarch64.rpm;name=aarch64_dovecot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dovecot-devel}"
SRC_URI[aarch64_dovecot-devel.sha256sum] = "ac527f93f8c5617c33dce8c5338caf8ac3e23c63360c5dd7a2d00ab6369d6ac8"

URI_aarch64_dovecot-mysql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dovecot-mysql-2.3.21-19.el10.aarch64.rpm;name=aarch64_dovecot-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_dovecot-mysql}"
SRC_URI[aarch64_dovecot-mysql.sha256sum] = "5a40de43f4c989c2f107b2cfecd186066190b7eacae7fc870fa485678b723e78"

URI_aarch64_dovecot-pgsql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dovecot-pgsql-2.3.21-19.el10.aarch64.rpm;name=aarch64_dovecot-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_dovecot-pgsql}"
SRC_URI[aarch64_dovecot-pgsql.sha256sum] = "bde7b8a110847a5c8f36a55035f4d5f7910504c4a76cc78aff03108b19166167"

URI_aarch64_dovecot-pigeonhole = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dovecot-pigeonhole-2.3.21-19.el10.aarch64.rpm;name=aarch64_dovecot-pigeonhole;unpack=0"
SRC_URI:append = " ${URI_aarch64_dovecot-pigeonhole}"
SRC_URI[aarch64_dovecot-pigeonhole.sha256sum] = "2607b7b54c322fd050a7556476c9480d6a63a3ed008d8273713d04051e4d18a9"

RDEPENDS:dovecot:x86_64_v2 = " \
 bash \
 bzip2-libs \
 expat \
 glibc \
 krb5-libs \
 libcap \
 libcom_err \
 libicu \
 libxcrypt \
 libzstd \
 lz4-libs \
 openldap \
 openssl \
 openssl-libs \
 pam-libs \
 shadow-utils \
 sqlite-libs \
 systemd \
 systemd-libs \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:dovecot:aarch64 = " \
 bash \
 bzip2-libs \
 expat \
 glibc \
 krb5-libs \
 libcom_err \
 libicu \
 libxcrypt \
 libzstd \
 lz4-libs \
 openldap \
 openssl \
 openssl-libs \
 pam-libs \
 shadow-utils \
 sqlite-libs \
 systemd \
 systemd-libs \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:dovecot-devel = " \
 dovecot \
 "
RDEPENDS:dovecot-mysql = " \
 dovecot \
 glibc \
 mariadb-connector-c \
 "
RDEPENDS:dovecot-pgsql = " \
 dovecot \
 glibc \
 libpq \
 "
RDEPENDS:dovecot-pigeonhole = " \
 dovecot \
 glibc \
 "
