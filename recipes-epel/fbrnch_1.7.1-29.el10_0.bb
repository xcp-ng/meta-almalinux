# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fbrnch"
PV = "1.7.1"
PR = "29.el10_0"
PACKAGES:x86_64_v2 = " \
 fbrnch \
 ghc-copr-api \
 ghc-copr-api-devel \
 ghc-copr-api-doc \
 ghc-fedora-krb \
 ghc-fedora-krb-devel \
 ghc-fedora-krb-doc \
 ghc-say \
 ghc-say-devel \
 ghc-say-doc \
"
PACKAGES:aarch64 = " \
 fbrnch \
 ghc-copr-api \
 ghc-copr-api-devel \
 ghc-copr-api-doc \
 ghc-copr-api-prof \
 ghc-fedora-krb \
 ghc-fedora-krb-devel \
 ghc-fedora-krb-doc \
 ghc-fedora-krb-prof \
 ghc-say \
 ghc-say-devel \
 ghc-say-doc \
 ghc-say-prof \
"

URI_src = "${EPELSRC_MIRROR}/Packages/f/fbrnch-1.7.1-29.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "754d126a96768da3b991507cdf9e417691bf34057b277755fa3f900360c7c148"

URI_x86_64_v2_fbrnch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fbrnch-1.7.1-29.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fbrnch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fbrnch}"
SRC_URI[x86_64_v2_fbrnch.sha256sum] = "c7d4005fb790f2aa096e41fa097cce04745ffcddb7d523eafce8dd49787d6fb9"

URI_x86_64_v2_ghc-copr-api = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-copr-api-0.2.0-29.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-copr-api;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-copr-api}"
SRC_URI[x86_64_v2_ghc-copr-api.sha256sum] = "c01e3ff70521a857173d4d33b1491f869b33c303c88e79bb16cc3ac59b04e1fd"

URI_x86_64_v2_ghc-copr-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-copr-api-devel-0.2.0-29.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-copr-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-copr-api-devel}"
SRC_URI[x86_64_v2_ghc-copr-api-devel.sha256sum] = "3656f5812b5491fd8647847dd95178380a5056ad3073312fca91f7e92c5e9a64"

URI_x86_64_v2_ghc-copr-api-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-copr-api-doc-0.2.0-29.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-copr-api-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-copr-api-doc}"
SRC_URI[x86_64_v2_ghc-copr-api-doc.sha256sum] = "2aead6775ae22029e9194e57f94e490da712f890a25af351d065a6d13c32ee44"

URI_x86_64_v2_ghc-fedora-krb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-fedora-krb-0.1.0-29.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-fedora-krb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-fedora-krb}"
SRC_URI[x86_64_v2_ghc-fedora-krb.sha256sum] = "c3da5afeb0dcd6d13f2e33d28f42b393dd3c41b2f56df3c4047075b7821f25eb"

URI_x86_64_v2_ghc-fedora-krb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-fedora-krb-devel-0.1.0-29.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-fedora-krb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-fedora-krb-devel}"
SRC_URI[x86_64_v2_ghc-fedora-krb-devel.sha256sum] = "c31e671425b8e8224e2374ddb14760d99ef56aaca4a56c6d6f0f2bbea9129e1d"

URI_x86_64_v2_ghc-fedora-krb-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-fedora-krb-doc-0.1.0-29.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-fedora-krb-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-fedora-krb-doc}"
SRC_URI[x86_64_v2_ghc-fedora-krb-doc.sha256sum] = "451392c5fc91123f4f51abe392610e9dda5a822d6112eb4fab912cc3ba259a08"

URI_x86_64_v2_ghc-say = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-say-0.1.0.1-29.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-say;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-say}"
SRC_URI[x86_64_v2_ghc-say.sha256sum] = "8c7359d93c15625accc624b5567374e4d659b1d4d05fadb2e8271112f2622d49"

URI_x86_64_v2_ghc-say-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-say-devel-0.1.0.1-29.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-say-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-say-devel}"
SRC_URI[x86_64_v2_ghc-say-devel.sha256sum] = "4d2745cb3251fe3d1300bccf4263d1d2f0b3839ddae48825384b12e8cd8bc010"

URI_x86_64_v2_ghc-say-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-say-doc-0.1.0.1-29.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-say-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-say-doc}"
SRC_URI[x86_64_v2_ghc-say-doc.sha256sum] = "a6af98043fd51c856fb9ec9387075bb998a2b669f14465bb02857202bc65a722"

URI_aarch64_fbrnch = "${EPEL_MIRROR}/aarch64/Packages/f/fbrnch-1.7.1-29.el10_0.aarch64.rpm;name=aarch64_fbrnch;unpack=0"
SRC_URI:append = " ${URI_aarch64_fbrnch}"
SRC_URI[aarch64_fbrnch.sha256sum] = "d0476efbd98cf1b98eff7685ac6fe0d298c34f5764880dc8be75288b3675b3d1"

URI_aarch64_ghc-copr-api = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-copr-api-0.2.0-29.el10_0.aarch64.rpm;name=aarch64_ghc-copr-api;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-copr-api}"
SRC_URI[aarch64_ghc-copr-api.sha256sum] = "d5740cb0adc25a96bf4e7b660c718f385e5e75e332d7d3fc5797f72399a72085"

URI_aarch64_ghc-copr-api-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-copr-api-devel-0.2.0-29.el10_0.aarch64.rpm;name=aarch64_ghc-copr-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-copr-api-devel}"
SRC_URI[aarch64_ghc-copr-api-devel.sha256sum] = "3558202a896a9b5bd8eb8728a39c561f49abf12a07b21f7d4d63bd44385b76fb"

URI_aarch64_ghc-copr-api-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-copr-api-doc-0.2.0-29.el10_0.noarch.rpm;name=aarch64_ghc-copr-api-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-copr-api-doc}"
SRC_URI[aarch64_ghc-copr-api-doc.sha256sum] = "d69843ecd88304d7a34f42fb85252dc03df24e3580e9a41a7d5a3f0a4eb05b93"

URI_aarch64_ghc-copr-api-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-copr-api-prof-0.2.0-29.el10_0.aarch64.rpm;name=aarch64_ghc-copr-api-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-copr-api-prof}"
SRC_URI[aarch64_ghc-copr-api-prof.sha256sum] = "3ebb5dcb0ea0d308e242e9ea641529f5f67e4854efc783cbd34109730b4d9611"

URI_aarch64_ghc-fedora-krb = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-fedora-krb-0.1.0-29.el10_0.aarch64.rpm;name=aarch64_ghc-fedora-krb;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-fedora-krb}"
SRC_URI[aarch64_ghc-fedora-krb.sha256sum] = "e1ef254cbd2991c37fac9cd09350ec8cc23f487d2f89ad7a2e4eb353f8d7fabb"

URI_aarch64_ghc-fedora-krb-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-fedora-krb-devel-0.1.0-29.el10_0.aarch64.rpm;name=aarch64_ghc-fedora-krb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-fedora-krb-devel}"
SRC_URI[aarch64_ghc-fedora-krb-devel.sha256sum] = "4fedc8e6906e601fa5ae84ec4a1ff22ecc340f5a47a12bd4f278ef43c3ed1792"

URI_aarch64_ghc-fedora-krb-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-fedora-krb-doc-0.1.0-29.el10_0.noarch.rpm;name=aarch64_ghc-fedora-krb-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-fedora-krb-doc}"
SRC_URI[aarch64_ghc-fedora-krb-doc.sha256sum] = "4e3d2e2299010647a99a6a87281249e254b59a396375e84dc52b554e5410df12"

URI_aarch64_ghc-fedora-krb-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-fedora-krb-prof-0.1.0-29.el10_0.aarch64.rpm;name=aarch64_ghc-fedora-krb-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-fedora-krb-prof}"
SRC_URI[aarch64_ghc-fedora-krb-prof.sha256sum] = "a60298edf2208658a23d2fa2ed4a2abcfe3de21b2933e5449755a7a50a4f1563"

URI_aarch64_ghc-say = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-say-0.1.0.1-29.el10_0.aarch64.rpm;name=aarch64_ghc-say;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-say}"
SRC_URI[aarch64_ghc-say.sha256sum] = "5f47ef097f5da726cb65c19713044849bb1cc8019ddf9afd53d577fc0f5c6f50"

URI_aarch64_ghc-say-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-say-devel-0.1.0.1-29.el10_0.aarch64.rpm;name=aarch64_ghc-say-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-say-devel}"
SRC_URI[aarch64_ghc-say-devel.sha256sum] = "94fe31dfdac7883e83a112dc21f54306835158cb99b6afddf594972e4a1c81a7"

URI_aarch64_ghc-say-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-say-doc-0.1.0.1-29.el10_0.noarch.rpm;name=aarch64_ghc-say-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-say-doc}"
SRC_URI[aarch64_ghc-say-doc.sha256sum] = "56a3d46d403fcddda3763b7815ce754a143479c1dfd354f3b998e8d08e1027d2"

URI_aarch64_ghc-say-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-say-prof-0.1.0.1-29.el10_0.aarch64.rpm;name=aarch64_ghc-say-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-say-prof}"
SRC_URI[aarch64_ghc-say-prof.sha256sum] = "80c4891f680bac66b3cfbff9b133a44137b91b8df32c1d24d92a75b2336e0b69"

RDEPENDS:fbrnch = " \
 bodhi-client \
 curl \
 fedpkg \
 git-core \
 glibc \
 gmp \
 koji \
 libffi \
 ncurses-libs \
 openssh-clients \
 openssl-libs \
 rpm-build \
 rpmautospec \
 rpmdevtools \
 zlib-ng-compat \
 "
RDEPENDS:ghc-copr-api = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-appar \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-basement \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-byteorder \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-cereal \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-crypton \
 ghc-crypton-connection \
 ghc-crypton-x509 \
 ghc-crypton-x509-store \
 ghc-crypton-x509-system \
 ghc-crypton-x509-validation \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hourglass \
 ghc-http-client \
 ghc-http-client-tls \
 ghc-http-conduit \
 ghc-http-query \
 ghc-http-types \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-iproute \
 ghc-memory \
 ghc-mime-types \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-network-uri \
 ghc-old-locale \
 ghc-old-time \
 ghc-os-string \
 ghc-parsec \
 ghc-pem \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-resourcet \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-socks \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-compat \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-tls \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-unix \
 ghc-unix-time \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-witherable \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-copr-api-devel = " \
 ghc-aeson-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-copr-api \
 ghc-http-query-devel \
 ghc-text-devel \
 ghc-unordered-containers-devel \
 "
RDEPENDS:ghc-copr-api-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-fedora-krb = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-clock \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-extra \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-process \
 ghc-simple-cmd \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-fedora-krb-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-fedora-krb \
 ghc-simple-cmd-devel \
 "
RDEPENDS:ghc-fedora-krb-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-say = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-say-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-say \
 ghc-text-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-say-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-copr-api-prof = " \
 ghc-aeson-prof \
 ghc-base-prof \
 ghc-copr-api-devel \
 ghc-http-query-prof \
 ghc-text-prof \
 ghc-unordered-containers-prof \
 "
RDEPENDS:ghc-fedora-krb-prof = " \
 ghc-base-prof \
 ghc-fedora-krb-devel \
 ghc-simple-cmd-prof \
 "
RDEPENDS:ghc-say-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-say-devel \
 ghc-text-prof \
 ghc-transformers-prof \
 "
