# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-x-arch"
PV = "0.7.0"
PR = "4.el10_0"
PACKAGES = " \
 golang-x-arch-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-x-arch-0.7.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ec424bf7709fb19085b7b21282121c8ae70f5ecb8093fd7286d3a41bb9b48c0"

URI_x86_64_v2_golang-x-arch-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-x-arch-devel-0.7.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-x-arch-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-x-arch-devel}"
SRC_URI[x86_64_v2_golang-x-arch-devel.sha256sum] = "510949769327da45371b1cb40670557b45b19dd84fc6ba91d63431c553114b92"

URI_aarch64_golang-x-arch-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-x-arch-devel-0.7.0-4.el10_0.noarch.rpm;name=aarch64_golang-x-arch-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-x-arch-devel}"
SRC_URI[aarch64_golang-x-arch-devel.sha256sum] = "bfbe1c400c32c7daea45268236fbbb1e65dd2aa935d01a0aed63c4ac6e5b3f5f"

RDEPENDS:golang-x-arch-devel = " \
 go-filesystem \
 golang-rsc-pdf-devel \
 "
