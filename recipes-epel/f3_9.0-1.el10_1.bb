# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "f3"
PV = "9.0"
PR = "1.el10_1"
PACKAGES = " \
 f3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/f3-9.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "70d5f134f66ff2d09b244429f09fae881fb8667505b713233e25cf9eb78892bb"

URI_x86_64_v2_f3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f3-9.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_f3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f3}"
SRC_URI[x86_64_v2_f3.sha256sum] = "8354111f021f49d01f9a0e9ff657c4b22fb841c81bb7c34036762cdbf5216300"

URI_aarch64_f3 = "${EPEL_MIRROR}/aarch64/Packages/f/f3-9.0-1.el10_1.aarch64.rpm;name=aarch64_f3;unpack=0"
SRC_URI:append = " ${URI_aarch64_f3}"
SRC_URI[aarch64_f3.sha256sum] = "fa91c84e982dae0551b623a4229b77b977f30883e5324aecc76d3b3b94b28172"

RDEPENDS:f3 = " \
 glibc \
 parted \
 systemd-libs \
 "
