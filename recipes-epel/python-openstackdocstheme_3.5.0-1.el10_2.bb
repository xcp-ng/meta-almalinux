# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-openstackdocstheme"
PV = "3.5.0"
PR = "1.el10_2"
PACKAGES = " \
 python-openstackdocstheme-doc \
 python3-openstackdocstheme \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-openstackdocstheme-3.5.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "db7fb101b7bdc4971f026d7a6ac8b72fccebf24c9a3061470a61187bb9b2d3ce"

URI_x86_64_v2_python-openstackdocstheme-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-openstackdocstheme-doc-3.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-openstackdocstheme-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-openstackdocstheme-doc}"
SRC_URI[x86_64_v2_python-openstackdocstheme-doc.sha256sum] = "62f888bc31f4fd9459c3165485adc1811ed43970969ab71392e91ecb55da5f09"

URI_x86_64_v2_python3-openstackdocstheme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-openstackdocstheme-3.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-openstackdocstheme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-openstackdocstheme}"
SRC_URI[x86_64_v2_python3-openstackdocstheme.sha256sum] = "bda7ddc5893adedd700ffbf8c2e02d0a9767b7b61ed43aa2a25e7280fb0eeaf9"

URI_aarch64_python-openstackdocstheme-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-openstackdocstheme-doc-3.5.0-1.el10_2.noarch.rpm;name=aarch64_python-openstackdocstheme-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-openstackdocstheme-doc}"
SRC_URI[aarch64_python-openstackdocstheme-doc.sha256sum] = "f6229e91f14ced0dec5e8709a5a13ed41d3867106623009668fa5213eb51df01"

URI_aarch64_python3-openstackdocstheme = "${EPEL_MIRROR}/aarch64/Packages/p/python3-openstackdocstheme-3.5.0-1.el10_2.noarch.rpm;name=aarch64_python3-openstackdocstheme;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-openstackdocstheme}"
SRC_URI[aarch64_python3-openstackdocstheme.sha256sum] = "9c37e8f97d59169ab6dd9ce261a2e8fcc37a6b98d1eeb2fd9f055cfe799241a9"

RDEPENDS:python-openstackdocstheme-doc = " \
 "
RDEPENDS:python3-openstackdocstheme = " \
 bash \
 python3 \
 python3-babel \
 python3-dulwich \
 python3-pbr \
 python3-sphinx \
 "
