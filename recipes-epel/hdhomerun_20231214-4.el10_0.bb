# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hdhomerun"
PV = "20231214"
PR = "4.el10_0"
PACKAGES = " \
 hdhomerun \
 hdhomerun-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/hdhomerun-20231214-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3857afe0860d3389346e376db457b4f2656d80544dd18eaa185c983d414a2a6c"

URI_x86_64_v2_hdhomerun = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hdhomerun-20231214-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hdhomerun;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hdhomerun}"
SRC_URI[x86_64_v2_hdhomerun.sha256sum] = "3634c942f3b8c7f5a95fb462531b26c60ca31084566abaa93cb49aabe3833f54"

URI_x86_64_v2_hdhomerun-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hdhomerun-devel-20231214-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hdhomerun-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hdhomerun-devel}"
SRC_URI[x86_64_v2_hdhomerun-devel.sha256sum] = "62608c5790ccb688fe418988c58fdd34892eb81c20aa6ffd663e6089c60de53f"

URI_aarch64_hdhomerun = "${EPEL_MIRROR}/aarch64/Packages/h/hdhomerun-20231214-4.el10_0.aarch64.rpm;name=aarch64_hdhomerun;unpack=0"
SRC_URI:append = " ${URI_aarch64_hdhomerun}"
SRC_URI[aarch64_hdhomerun.sha256sum] = "eee0d95e77d6e151100424e18e88ef3c855896eb85b2bfb1963932ff933f236c"

URI_aarch64_hdhomerun-devel = "${EPEL_MIRROR}/aarch64/Packages/h/hdhomerun-devel-20231214-4.el10_0.aarch64.rpm;name=aarch64_hdhomerun-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_hdhomerun-devel}"
SRC_URI[aarch64_hdhomerun-devel.sha256sum] = "d452d7eec661c095f61d55c610fb06622546dcab10c7998c4ddcb753db529315"

RDEPENDS:hdhomerun = " \
 glib2 \
 glibc \
 gtk2 \
 libgcc \
 libstdc++ \
 "
RDEPENDS:hdhomerun-devel = " \
 hdhomerun \
 "
