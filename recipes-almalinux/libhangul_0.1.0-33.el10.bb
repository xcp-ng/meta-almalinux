# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libhangul"
PV = "0.1.0"
PR = "33.el10"
PACKAGES = " \
 libhangul \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libhangul-0.1.0-33.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7139010f32996aeded566363ddf982b9b4f628e93f24f535db4807ba92656e35"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libhangul-0.1.0-33.el10.x86_64_v2.rpm;name=x86_64_v2_libhangul;unpack=0"
SRC_URI[x86_64_v2_libhangul.sha256sum] = "8a84170f782c2263e31f57b84af6a7856331e4d036c3e4bab7e54c3453f5d883"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libhangul-0.1.0-33.el10.aarch64.rpm;name=aarch64_libhangul;unpack=0"
SRC_URI[aarch64_libhangul.sha256sum] = "55296ddfdff20d118a2f9f87650a09fec40dd9e7112e006e010aa55734a86497"

RDEPENDS:libhangul = " \
 glibc \
 "
