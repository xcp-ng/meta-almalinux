# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nmstate"
PV = "2.2.60"
PR = "2.el10"
PACKAGES = " \
 nmstate \
 nmstate-devel \
 nmstate-libs \
 nmstate-static \
 python3-libnmstate \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nmstate-2.2.60-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "33a4d40e2a2258f6cea247b10665d2fa48077362c3ba120bf0a18366f9597646"

URI_x86_64_v2_nmstate = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nmstate-2.2.60-2.el10.x86_64_v2.rpm;name=x86_64_v2_nmstate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nmstate}"
SRC_URI[x86_64_v2_nmstate.sha256sum] = "4ce32d7afc0c0b115a74cd66927fc524d1ff73ca81a2e28012a1b97f1eb4565f"

URI_x86_64_v2_nmstate-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nmstate-devel-2.2.60-2.el10.x86_64_v2.rpm;name=x86_64_v2_nmstate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nmstate-devel}"
SRC_URI[x86_64_v2_nmstate-devel.sha256sum] = "627cd2c8b72dfea516e336ff0a0dfbc41be17ebc11ddd0cff0b58e6d254e57bb"

URI_x86_64_v2_nmstate-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nmstate-libs-2.2.60-2.el10.x86_64_v2.rpm;name=x86_64_v2_nmstate-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nmstate-libs}"
SRC_URI[x86_64_v2_nmstate-libs.sha256sum] = "aa07eab304945f767206586610fff4af43694dcbea8017c2b5f68c70c4af1595"

URI_x86_64_v2_nmstate-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nmstate-static-2.2.60-2.el10.x86_64_v2.rpm;name=x86_64_v2_nmstate-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nmstate-static}"
SRC_URI[x86_64_v2_nmstate-static.sha256sum] = "efff49ca2f9356cf4f3b0378dc2f63417d9416374471533690ef05fa8e85e75e"

URI_x86_64_v2_python3-libnmstate = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libnmstate-2.2.60-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libnmstate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libnmstate}"
SRC_URI[x86_64_v2_python3-libnmstate.sha256sum] = "4a4d8e5c56b091401c128c7d9dfbd3bbd8e3fb61c672d04363d74a04b620712f"

URI_aarch64_nmstate = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nmstate-2.2.60-2.el10.aarch64.rpm;name=aarch64_nmstate;unpack=0"
SRC_URI:append = " ${URI_aarch64_nmstate}"
SRC_URI[aarch64_nmstate.sha256sum] = "663b925517f8bae01b71517fff1dc0ee2bd6a04d3d2738193a7950e7eda926f8"

URI_aarch64_nmstate-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nmstate-devel-2.2.60-2.el10.aarch64.rpm;name=aarch64_nmstate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nmstate-devel}"
SRC_URI[aarch64_nmstate-devel.sha256sum] = "b9a17525c5c7dd901fade9413602fb65934b5f2f4398653fde7c752c0a32d8c0"

URI_aarch64_nmstate-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nmstate-libs-2.2.60-2.el10.aarch64.rpm;name=aarch64_nmstate-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nmstate-libs}"
SRC_URI[aarch64_nmstate-libs.sha256sum] = "eac7f225ee37dad2c6a305ed92c7ee08b595d68ccd5dc0214df18d2fe47fe527"

URI_aarch64_nmstate-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nmstate-static-2.2.60-2.el10.aarch64.rpm;name=aarch64_nmstate-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_nmstate-static}"
SRC_URI[aarch64_nmstate-static.sha256sum] = "ff174193c828b436f0a3b4320692e1b1c1085fb0d202e013aa7813c6f973faa9"

URI_aarch64_python3-libnmstate = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libnmstate-2.2.60-2.el10.aarch64.rpm;name=aarch64_python3-libnmstate;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libnmstate}"
SRC_URI[aarch64_python3-libnmstate.sha256sum] = "324861b0772ac09b595838823fe56c03b95d35a54c1cd22a22acc63f2f23ecf9"

RDEPENDS:nmstate = " \
 glibc \
 libgcc \
 nmstate-libs \
 "
RDEPENDS:nmstate-devel = " \
 nmstate-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:nmstate-libs = " \
 glibc \
 libgcc \
 "
RDEPENDS:nmstate-static = " \
 nmstate-devel \
 "
RDEPENDS:python3-libnmstate = " \
 nmstate-libs \
 python3 \
 python3-pyyaml \
 "
