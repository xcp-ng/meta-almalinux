# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libreswan"
PV = "5.4"
PR = "1.el10"
PACKAGES = " \
 libreswan \
 libreswan-minimal \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libreswan-5.4-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "82125a8f7abee96f0da0eabe3092ae3bdf778d08f73b001f930e3d1717d38495"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libreswan-5.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_libreswan;unpack=0"
SRC_URI[x86_64_v2_libreswan.sha256sum] = "4d8f64c5f7038efd1ffade39a4621f84b0e7ce9d1783fa3358ad1ffbec27cd10"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libreswan-minimal-5.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_libreswan-minimal;unpack=0"
SRC_URI[x86_64_v2_libreswan-minimal.sha256sum] = "0b378dc78db49b6c2a68dca11db481472fec182d3d64e905df1d912ab5101a47"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libreswan-5.4-1.el10.aarch64.rpm;name=aarch64_libreswan;unpack=0"
SRC_URI[aarch64_libreswan.sha256sum] = "f0768d87ff57cfb0ca6d7a00a6624367ac662b82b63cab8ba53fbf95122960b7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libreswan-minimal-5.4-1.el10.aarch64.rpm;name=aarch64_libreswan-minimal;unpack=0"
SRC_URI[aarch64_libreswan-minimal.sha256sum] = "8cf6a34c30a1cb99bcbad43a167160c3108e7fd2f2e36336fd1641db140b2b8d"

RDEPENDS:libreswan = " \
 bash \
 iproute \
 libreswan-minimal \
 logrotate \
 nss \
 nss-softokn \
 procps-ng \
 systemd \
 "
RDEPENDS:libreswan-minimal = " \
 audit-libs \
 bash \
 glibc \
 ldns \
 libcap-ng \
 libevent \
 libgcc \
 libseccomp \
 libselinux \
 libxcrypt \
 nspr \
 nss \
 nss-tools \
 nss-util \
 openldap \
 pam-libs \
 unbound-libs \
 virtual/coreutils \
 virtual/libcurl.so.4___64bit_ \
 "
