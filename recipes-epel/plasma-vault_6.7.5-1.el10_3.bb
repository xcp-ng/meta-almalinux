# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-vault"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 plasma-vault \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma-vault-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "651772622b9911bff10c0e6198c63e831fb0fcb6bc1e7f9df7bd104150d2d662"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-vault-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-vault;unpack=0"
SRC_URI[x86_64_v2_plasma-vault.sha256sum] = "c4f4d239d5e3c92cc9ba4ff014189f9305b63662a646ef59dfe1158ee9b49387"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-vault-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-vault;unpack=0"
SRC_URI[aarch64_plasma-vault.sha256sum] = "96f6f4ea8b69dbbe6135b8e92611d553393cc203f4a24e75d19f261466202f57"

RDEPENDS:plasma-vault = " \
 glibc \
 gocryptfs \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libgcc \
 libksysguard \
 libplasma \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
