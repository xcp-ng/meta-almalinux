# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "francis"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 francis \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/francis-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "21c54feae37debdf61e5d56febe4203aef4ae5bdc3a14650066ecafaf1ef65f7"

URI_x86_64_v2_francis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/francis-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_francis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_francis}"
SRC_URI[x86_64_v2_francis.sha256sum] = "03d82062c42da8d6b2ed050f0c9775450aef4818aa099798fe177d2dc63b5166"

URI_aarch64_francis = "${EPEL_MIRROR}/aarch64/Packages/f/francis-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_francis;unpack=0"
SRC_URI:append = " ${URI_aarch64_francis}"
SRC_URI[aarch64_francis.sha256sum] = "410441d59e4378281fb40e667ca4bdce1fe056ef43f174c6fce4d9e535f8772b"

RDEPENDS:francis = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-knotifications \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
