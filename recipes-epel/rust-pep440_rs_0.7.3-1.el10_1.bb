# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pep440_rs"
PV = "0.7.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-pep440_rs+default-devel \
 rust-pep440_rs+rkyv-devel \
 rust-pep440_rs+tracing-devel \
 rust-pep440_rs+version-ranges-devel \
 rust-pep440_rs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pep440_rs-0.7.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b8bd2277c97045b226611fc9c64c1e7d265745d0bba5356df643a3ad5b90af7"

URI_x86_64_v2_rust-pep440_rs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pep440_rs+default-devel-0.7.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pep440_rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pep440_rs+default-devel}"
SRC_URI[x86_64_v2_rust-pep440_rs+default-devel.sha256sum] = "de38d5ffd9f4cfe265618fbd6944d0750a99ee40abd1cedb3eddd87d9a983db9"

URI_x86_64_v2_rust-pep440_rs+rkyv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pep440_rs+rkyv-devel-0.7.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pep440_rs+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pep440_rs+rkyv-devel}"
SRC_URI[x86_64_v2_rust-pep440_rs+rkyv-devel.sha256sum] = "c85c6cc194764f629026b0ecaa76244747310066ea96c9c8518fd035a514e711"

URI_x86_64_v2_rust-pep440_rs+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pep440_rs+tracing-devel-0.7.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pep440_rs+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pep440_rs+tracing-devel}"
SRC_URI[x86_64_v2_rust-pep440_rs+tracing-devel.sha256sum] = "b2ebcfab9011c02ec91fda75f7551c84d24e2dbde3254337232d0c97ef9bed1e"

URI_x86_64_v2_rust-pep440_rs+version-ranges-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pep440_rs+version-ranges-devel-0.7.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pep440_rs+version-ranges-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pep440_rs+version-ranges-devel}"
SRC_URI[x86_64_v2_rust-pep440_rs+version-ranges-devel.sha256sum] = "ab131908998a1204f4ee08a226a7b87b2b974ca4c3eb0fc9a87fee3d9e469df0"

URI_x86_64_v2_rust-pep440_rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pep440_rs-devel-0.7.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pep440_rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pep440_rs-devel}"
SRC_URI[x86_64_v2_rust-pep440_rs-devel.sha256sum] = "94e0407a2b73fb1ec63f32f925f55f8d139b714e3ca397d26b36b2488917fddf"

URI_aarch64_rust-pep440_rs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pep440_rs+default-devel-0.7.3-1.el10_1.noarch.rpm;name=aarch64_rust-pep440_rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pep440_rs+default-devel}"
SRC_URI[aarch64_rust-pep440_rs+default-devel.sha256sum] = "64d5c83428464a5ea2923a3e4fdbe4b469297d7e5ae4c95e084e3df21908608f"

URI_aarch64_rust-pep440_rs+rkyv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pep440_rs+rkyv-devel-0.7.3-1.el10_1.noarch.rpm;name=aarch64_rust-pep440_rs+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pep440_rs+rkyv-devel}"
SRC_URI[aarch64_rust-pep440_rs+rkyv-devel.sha256sum] = "d7686578cdaf581e338e864bec85164d3b586c7d78c602325c7f433cd1bc60f5"

URI_aarch64_rust-pep440_rs+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pep440_rs+tracing-devel-0.7.3-1.el10_1.noarch.rpm;name=aarch64_rust-pep440_rs+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pep440_rs+tracing-devel}"
SRC_URI[aarch64_rust-pep440_rs+tracing-devel.sha256sum] = "5b3a059ee0290883abfb7b2964c95a1290e017bdfca3e90bfd02726a0ae28b83"

URI_aarch64_rust-pep440_rs+version-ranges-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pep440_rs+version-ranges-devel-0.7.3-1.el10_1.noarch.rpm;name=aarch64_rust-pep440_rs+version-ranges-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pep440_rs+version-ranges-devel}"
SRC_URI[aarch64_rust-pep440_rs+version-ranges-devel.sha256sum] = "a08d8dc7350d086d31910e394928ca551ac461669781c2e89a147a6172698179"

URI_aarch64_rust-pep440_rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pep440_rs-devel-0.7.3-1.el10_1.noarch.rpm;name=aarch64_rust-pep440_rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pep440_rs-devel}"
SRC_URI[aarch64_rust-pep440_rs-devel.sha256sum] = "e46a6b16bb90970cbcf56bdd0ec30c9fbc84d77f86dfc86f177155d9b3ae7ce2"

RDEPENDS:rust-pep440_rs+default-devel = " \
 cargo \
 rust-pep440_rs-devel \
 "
RDEPENDS:rust-pep440_rs+rkyv-devel = " \
 cargo \
 rust-pep440_rs-devel \
 rust-rkyv+default-devel \
 "
RDEPENDS:rust-pep440_rs+tracing-devel = " \
 cargo \
 rust-pep440_rs-devel \
 rust-tracing+default-devel \
 "
RDEPENDS:rust-pep440_rs+version-ranges-devel = " \
 cargo \
 rust-pep440_rs-devel \
 rust-version-ranges+default-devel \
 "
RDEPENDS:rust-pep440_rs-devel = " \
 cargo \
 rust-once_cell+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-unicode-width+default-devel \
 rust-unscanny+default-devel \
 "
