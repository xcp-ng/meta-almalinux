# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openssl"
PE = "1"
PV = "3.5.5"
PR = "6.el10_2.alma.1"
PACKAGES = " \
 openssl \
 openssl-devel \
 openssl-fips-provider \
 openssl-libs \
 openssl-perl \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/openssl-3.5.5-6.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a9d1ab12877a51e913078b9851e4c924316d2a887bd90daf5374ef8d09022534"

URI_x86_64_v2_openssl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssl-3.5.5-6.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssl}"
SRC_URI[x86_64_v2_openssl.sha256sum] = "8f24d9b7351f07d702884327fc2eca9cb4c4531db8578fd310c97fe2fd4787eb"

URI_x86_64_v2_openssl-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openssl-devel-3.5.5-6.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssl-devel}"
SRC_URI[x86_64_v2_openssl-devel.sha256sum] = "52c67a52be3cbbf9f135fc8bf9332888e535f3cf52daed2110673eac89fa15ed"

URI_x86_64_v2_openssl-fips-provider = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssl-fips-provider-3.5.5-6.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssl-fips-provider;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssl-fips-provider}"
SRC_URI[x86_64_v2_openssl-fips-provider.sha256sum] = "cfe21669ae78ca93d9d5cd5716f7857039997982bd88df85d77495b3f5407ef3"

URI_x86_64_v2_openssl-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssl-libs-3.5.5-6.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssl-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssl-libs}"
SRC_URI[x86_64_v2_openssl-libs.sha256sum] = "b458bada3775070e8e484184a7e9a181d115cb1976970e5c2eb044046f4b324d"

URI_x86_64_v2_openssl-perl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openssl-perl-3.5.5-6.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssl-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssl-perl}"
SRC_URI[x86_64_v2_openssl-perl.sha256sum] = "3a0a40870d6c167fd4b45c75c9344b4375f5998c582398f1fb61e5364e6de904"

URI_aarch64_openssl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssl-3.5.5-6.el10_2.alma.1.aarch64.rpm;name=aarch64_openssl;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssl}"
SRC_URI[aarch64_openssl.sha256sum] = "8e745da04223ac87244f8a9388f5e7f13e16f3e96816ae081895a12c1e7dfcc2"

URI_aarch64_openssl-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openssl-devel-3.5.5-6.el10_2.alma.1.aarch64.rpm;name=aarch64_openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssl-devel}"
SRC_URI[aarch64_openssl-devel.sha256sum] = "09b9073163f01a799e2e1048e77f7cc8d90e0eed6d3e5627a716655440c8789d"

URI_aarch64_openssl-fips-provider = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssl-fips-provider-3.5.5-6.el10_2.alma.1.aarch64.rpm;name=aarch64_openssl-fips-provider;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssl-fips-provider}"
SRC_URI[aarch64_openssl-fips-provider.sha256sum] = "8c20e21b3bd1d3f4f8e334aeb39abd04406484d10c34335a5a7c22422bfe24aa"

URI_aarch64_openssl-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssl-libs-3.5.5-6.el10_2.alma.1.aarch64.rpm;name=aarch64_openssl-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssl-libs}"
SRC_URI[aarch64_openssl-libs.sha256sum] = "a2f075994921bfb56c250233d1973dfacc6f687c3d3eb2501287a142ee477ad7"

URI_aarch64_openssl-perl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openssl-perl-3.5.5-6.el10_2.alma.1.aarch64.rpm;name=aarch64_openssl-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssl-perl}"
SRC_URI[aarch64_openssl-perl.sha256sum] = "7d1ff14ee20299b8bb526ea5f3ea5a8515d6caca5e5f1e4362fac4c6a25458f2"

RDEPENDS:openssl = " \
 bash \
 glibc \
 openssl-libs \
 virtual/coreutils \
 "
RDEPENDS:openssl-devel = " \
 openssl-devel \
 openssl-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:openssl-fips-provider = " \
 glibc \
 openssl-libs \
 "
RDEPENDS:openssl-libs = " \
 ca-certificates \
 crypto-policies \
 glibc \
 openssl-fips-provider \
 zlib-ng-compat \
 "
RDEPENDS:openssl-perl = " \
 openssl \
 perl-interpreter \
 "
