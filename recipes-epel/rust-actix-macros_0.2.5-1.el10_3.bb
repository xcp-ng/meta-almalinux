# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-actix-macros"
PV = "0.2.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-actix-macros+default-devel \
 rust-actix-macros-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-actix-macros-0.2.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a06e07e91d25f289d6346dad510bd59097815fea530ad32468aec873ed971d08"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-actix-macros+default-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-actix-macros+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-actix-macros+default-devel.sha256sum] = "fa67ff60f20edd22f3faa170c659edcfb340d21988e9ab50f899de75a603f871"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-actix-macros-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-actix-macros-devel;unpack=0"
SRC_URI[x86_64_v2_rust-actix-macros-devel.sha256sum] = "bb4da9edb92088b1c88e44d9cea9620f89a978a3a275e33a20cca5dc5720cc8b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-actix-macros+default-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-actix-macros+default-devel;unpack=0"
SRC_URI[aarch64_rust-actix-macros+default-devel.sha256sum] = "24b0cf2b9953e0dfe826b6809b5d527e483caec8ab2f17b94aed0ef640c77ccd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-actix-macros-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-actix-macros-devel;unpack=0"
SRC_URI[aarch64_rust-actix-macros-devel.sha256sum] = "75c5ca25b4a12c54d1ebb290f5ccaa2ddb74e4e61015f8eee2ab584f960583af"

RDEPENDS:rust-actix-macros+default-devel = " \
 cargo \
 rust-actix-macros-devel \
 "
RDEPENDS:rust-actix-macros-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
