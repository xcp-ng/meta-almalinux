# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ipnet"
PV = "2.11.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-ipnet+default-devel \
 rust-ipnet+heapless-devel \
 rust-ipnet+ser_as_str-devel \
 rust-ipnet+serde-devel \
 rust-ipnet+std-devel \
 rust-ipnet-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ipnet-2.11.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "efb83432f260386d31aa8f7af9a2e17300cd7c9b3937580d0560443228667003"

URI_x86_64_v2_rust-ipnet+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+default-devel-2.11.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ipnet+default-devel}"
SRC_URI[x86_64_v2_rust-ipnet+default-devel.sha256sum] = "0e284c67c0c5b0961c42443328c5040c385b44ad9df4de6bc2050a3349550f21"

URI_x86_64_v2_rust-ipnet+heapless-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+heapless-devel-2.11.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ipnet+heapless-devel}"
SRC_URI[x86_64_v2_rust-ipnet+heapless-devel.sha256sum] = "6aa0607243936c05f841178f4d330c632e618322738ca18e86af133bb96022ec"

URI_x86_64_v2_rust-ipnet+ser_as_str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+ser_as_str-devel-2.11.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+ser_as_str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ipnet+ser_as_str-devel}"
SRC_URI[x86_64_v2_rust-ipnet+ser_as_str-devel.sha256sum] = "2f78816110a65dc7d2dac520d180a16de90d3cae519f531a9ca1d6449876db49"

URI_x86_64_v2_rust-ipnet+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+serde-devel-2.11.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ipnet+serde-devel}"
SRC_URI[x86_64_v2_rust-ipnet+serde-devel.sha256sum] = "91ca383a51a6b61c48118a6dbdd5ead16a72fa9f10b84e9ffc44d014d16da9a4"

URI_x86_64_v2_rust-ipnet+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+std-devel-2.11.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ipnet+std-devel}"
SRC_URI[x86_64_v2_rust-ipnet+std-devel.sha256sum] = "98c729ef1d4da2959ea5c1b690c4b157c0d2d956dbf93208c8473b74f67682e4"

URI_x86_64_v2_rust-ipnet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet-devel-2.11.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ipnet-devel}"
SRC_URI[x86_64_v2_rust-ipnet-devel.sha256sum] = "de1d6c8d48127be3a8f4fc56a418d41f560035cb7c8bd204b639c385fa0f7762"

URI_aarch64_rust-ipnet+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+default-devel-2.11.0-1.el10_0.noarch.rpm;name=aarch64_rust-ipnet+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ipnet+default-devel}"
SRC_URI[aarch64_rust-ipnet+default-devel.sha256sum] = "98efdc3242aa5de3da43d75f3569e518ce4a48ef0fbeac1ef8c7287bf7f03628"

URI_aarch64_rust-ipnet+heapless-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+heapless-devel-2.11.0-1.el10_0.noarch.rpm;name=aarch64_rust-ipnet+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ipnet+heapless-devel}"
SRC_URI[aarch64_rust-ipnet+heapless-devel.sha256sum] = "de9c6bc9047c5e949581c517197171127b712944ce98ba84008a9f4275e586e7"

URI_aarch64_rust-ipnet+ser_as_str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+ser_as_str-devel-2.11.0-1.el10_0.noarch.rpm;name=aarch64_rust-ipnet+ser_as_str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ipnet+ser_as_str-devel}"
SRC_URI[aarch64_rust-ipnet+ser_as_str-devel.sha256sum] = "277e4326415a47f5fb9de0c3e2d89fc0feb3457b498ed3d04590609c840908b3"

URI_aarch64_rust-ipnet+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+serde-devel-2.11.0-1.el10_0.noarch.rpm;name=aarch64_rust-ipnet+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ipnet+serde-devel}"
SRC_URI[aarch64_rust-ipnet+serde-devel.sha256sum] = "ac3c5514e51ccd885ccb91401a8ecbd65245fd8afaf183686022865a9cfcd599"

URI_aarch64_rust-ipnet+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+std-devel-2.11.0-1.el10_0.noarch.rpm;name=aarch64_rust-ipnet+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ipnet+std-devel}"
SRC_URI[aarch64_rust-ipnet+std-devel.sha256sum] = "2a3ee09a0c30930fd3a512f608a66f6a75416e375fcb08ab5d0632ccd54f22d3"

URI_aarch64_rust-ipnet-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet-devel-2.11.0-1.el10_0.noarch.rpm;name=aarch64_rust-ipnet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ipnet-devel}"
SRC_URI[aarch64_rust-ipnet-devel.sha256sum] = "7fadd0c0d9fb5971bd3964c7f96202615a1d250ac80b3a3dd12230b0918c74fb"

RDEPENDS:rust-ipnet+default-devel = " \
 cargo \
 rust-ipnet+std-devel \
 rust-ipnet-devel \
 "
RDEPENDS:rust-ipnet+heapless-devel = " \
 cargo \
 rust-ipnet-devel \
 virtual/crate_heapless/default__ge_0.0.0_with_crate_heapless/default__lt_1.0.0~ \
 "
RDEPENDS:rust-ipnet+ser_as_str-devel = " \
 cargo \
 rust-ipnet+heapless-devel \
 rust-ipnet-devel \
 "
RDEPENDS:rust-ipnet+serde-devel = " \
 cargo \
 rust-ipnet-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-ipnet+std-devel = " \
 cargo \
 rust-ipnet-devel \
 "
RDEPENDS:rust-ipnet-devel = " \
 cargo \
 "
