# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-reflection"
PV = "2.1.8"
PR = "1.el10_0"
PACKAGES = " \
 ghc-reflection \
 ghc-reflection-devel \
 ghc-reflection-doc \
 ghc-reflection-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-reflection-2.1.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "407a11f095f770300e464061cb742469b23b1c3e16103f4e667c5962b2774118"

URI_x86_64_v2_ghc-reflection = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-reflection-2.1.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-reflection;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-reflection}"
SRC_URI[x86_64_v2_ghc-reflection.sha256sum] = "163dfa154857b3b61ea9cb25ec832f6425813b025e2c4d1fa33fd886f5ef8d95"

URI_x86_64_v2_ghc-reflection-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-reflection-devel-2.1.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-reflection-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-reflection-devel}"
SRC_URI[x86_64_v2_ghc-reflection-devel.sha256sum] = "ac81bc1d7f59152f1c167a0cd7a3ffc0c11cb1d5c825d5545a536984c2b85d8d"

URI_x86_64_v2_ghc-reflection-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-reflection-doc-2.1.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-reflection-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-reflection-doc}"
SRC_URI[x86_64_v2_ghc-reflection-doc.sha256sum] = "a2d022baf6bc63ba4e392f82ae905b77f72c61765a9551ab07f661af14ce5259"

URI_x86_64_v2_ghc-reflection-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-reflection-prof-2.1.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-reflection-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-reflection-prof}"
SRC_URI[x86_64_v2_ghc-reflection-prof.sha256sum] = "e6b9c480d53d8e85f795fd6add12c3f2aa0a2367e88fcda709f9e28399d4cb08"

URI_aarch64_ghc-reflection = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-reflection-2.1.8-1.el10_0.aarch64.rpm;name=aarch64_ghc-reflection;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-reflection}"
SRC_URI[aarch64_ghc-reflection.sha256sum] = "1fe9d3e9569a47ea7f44f90a682804529d9dd4be224dd9d2318c6075d43feda3"

URI_aarch64_ghc-reflection-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-reflection-devel-2.1.8-1.el10_0.aarch64.rpm;name=aarch64_ghc-reflection-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-reflection-devel}"
SRC_URI[aarch64_ghc-reflection-devel.sha256sum] = "789889865f11a9550fd043cfaa43003f6049c14e8b3804e0b6d96b4e3e686d0d"

URI_aarch64_ghc-reflection-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-reflection-doc-2.1.8-1.el10_0.noarch.rpm;name=aarch64_ghc-reflection-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-reflection-doc}"
SRC_URI[aarch64_ghc-reflection-doc.sha256sum] = "510e6d864dc7616f5c926fa666ffab48b4a427cd033d7be679ef58c247c815a3"

URI_aarch64_ghc-reflection-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-reflection-prof-2.1.8-1.el10_0.aarch64.rpm;name=aarch64_ghc-reflection-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-reflection-prof}"
SRC_URI[aarch64_ghc-reflection-prof.sha256sum] = "0394d2101533dcea925d67c3884886db9df53cd4655e1a0b25033c75f0a6770c"

RDEPENDS:ghc-reflection = " \
 ghc-array \
 ghc-base \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-reflection-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-reflection \
 ghc-template-haskell-devel \
 "
RDEPENDS:ghc-reflection-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-reflection-prof = " \
 ghc-base-prof \
 ghc-reflection-devel \
 ghc-template-haskell-prof \
 "
