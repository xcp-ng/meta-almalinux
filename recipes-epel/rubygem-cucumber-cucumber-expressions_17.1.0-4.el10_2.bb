# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-cucumber-cucumber-expressions"
PV = "17.1.0"
PR = "4.el10_2"
PACKAGES = " \
 rubygem-cucumber-cucumber-expressions \
 rubygem-cucumber-cucumber-expressions-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-cucumber-cucumber-expressions-17.1.0-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2617097f7423b20de6647a6ccde86a43ba805722fb0523d20dde3d132396ac7e"

URI_x86_64_v2_rubygem-cucumber-cucumber-expressions = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-cucumber-cucumber-expressions-17.1.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-cucumber-cucumber-expressions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-cucumber-cucumber-expressions}"
SRC_URI[x86_64_v2_rubygem-cucumber-cucumber-expressions.sha256sum] = "f740f9706dbfe4469528b898044bc96cdd16772816864161925a285d27346313"

URI_x86_64_v2_rubygem-cucumber-cucumber-expressions-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-cucumber-cucumber-expressions-doc-17.1.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-cucumber-cucumber-expressions-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-cucumber-cucumber-expressions-doc}"
SRC_URI[x86_64_v2_rubygem-cucumber-cucumber-expressions-doc.sha256sum] = "ee82b1613d87f540f43ba12175f04c2a6f67a77796eb5e07759b5c8e031ab68d"

URI_aarch64_rubygem-cucumber-cucumber-expressions = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-cucumber-cucumber-expressions-17.1.0-4.el10_2.noarch.rpm;name=aarch64_rubygem-cucumber-cucumber-expressions;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-cucumber-cucumber-expressions}"
SRC_URI[aarch64_rubygem-cucumber-cucumber-expressions.sha256sum] = "e3ff13602f56eb2d3eb009639f264ad3dd02569730f29d8b7db7240a4d12ac54"

URI_aarch64_rubygem-cucumber-cucumber-expressions-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-cucumber-cucumber-expressions-doc-17.1.0-4.el10_2.noarch.rpm;name=aarch64_rubygem-cucumber-cucumber-expressions-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-cucumber-cucumber-expressions-doc}"
SRC_URI[aarch64_rubygem-cucumber-cucumber-expressions-doc.sha256sum] = "45978f0fa2dee3e5dbc5f28802141202ca4312232eba398100b90352e7e52114"

RDEPENDS:rubygem-cucumber-cucumber-expressions = " \
 rubygem-bigdecimal \
 rubygems \
 "
RDEPENDS:rubygem-cucumber-cucumber-expressions-doc = " \
 rubygem-cucumber-cucumber-expressions \
 "
