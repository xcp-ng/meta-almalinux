# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bytecheck"
PV = "0.8.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-bytecheck+default-devel \
 rust-bytecheck+simdutf8-devel \
 rust-bytecheck+uuid-1-devel \
 rust-bytecheck-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bytecheck-0.8.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e937d2b07cf4808cdd6e10de91251532f0e16dcb2dfc06da617a00d1a80b923"

URI_x86_64_v2_rust-bytecheck+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecheck+default-devel-0.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecheck+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecheck+default-devel}"
SRC_URI[x86_64_v2_rust-bytecheck+default-devel.sha256sum] = "f97386ba2247bd803cf737dc1896a18f5125f5e851b8e3a805d295df5065b361"

URI_x86_64_v2_rust-bytecheck+simdutf8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecheck+simdutf8-devel-0.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecheck+simdutf8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecheck+simdutf8-devel}"
SRC_URI[x86_64_v2_rust-bytecheck+simdutf8-devel.sha256sum] = "f96dd45aa07ec418afdb1137622fae1dd0ec06150d9651a4f6cee5d2ab2b0cbc"

URI_x86_64_v2_rust-bytecheck+uuid-1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecheck+uuid-1-devel-0.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecheck+uuid-1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecheck+uuid-1-devel}"
SRC_URI[x86_64_v2_rust-bytecheck+uuid-1-devel.sha256sum] = "8a6c721d3516f46a4611664550f1aa6bd5d85ace53dd7fc58045ba37026383d9"

URI_x86_64_v2_rust-bytecheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytecheck-devel-0.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytecheck-devel}"
SRC_URI[x86_64_v2_rust-bytecheck-devel.sha256sum] = "6d595edf78ddee7e09a5acda2e6b955063b498587feed92c9edf3701dd05ef69"

URI_aarch64_rust-bytecheck+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecheck+default-devel-0.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-bytecheck+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecheck+default-devel}"
SRC_URI[aarch64_rust-bytecheck+default-devel.sha256sum] = "841daf57a82a1d667363579b05318a2cfd3ffcdb865e0fefa8f90ed35f133d19"

URI_aarch64_rust-bytecheck+simdutf8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecheck+simdutf8-devel-0.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-bytecheck+simdutf8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecheck+simdutf8-devel}"
SRC_URI[aarch64_rust-bytecheck+simdutf8-devel.sha256sum] = "386ac6fb5675603f8992b7836deae8acc5c57ed92ce4b6a384bb264e2720adac"

URI_aarch64_rust-bytecheck+uuid-1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecheck+uuid-1-devel-0.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-bytecheck+uuid-1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecheck+uuid-1-devel}"
SRC_URI[aarch64_rust-bytecheck+uuid-1-devel.sha256sum] = "e88899dc9bff73fea236ce5a0ec7fef76047483efb860ae859b17cafe44c09c2"

URI_aarch64_rust-bytecheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytecheck-devel-0.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytecheck-devel}"
SRC_URI[aarch64_rust-bytecheck-devel.sha256sum] = "d300d884950787fbca9815ab1cc17a589013993e8a4d3d57d7e4bc4db015ccee"

RDEPENDS:rust-bytecheck+default-devel = " \
 cargo \
 rust-bytecheck+simdutf8-devel \
 rust-bytecheck-devel \
 "
RDEPENDS:rust-bytecheck+simdutf8-devel = " \
 cargo \
 rust-bytecheck-devel \
 rust-simdutf8-devel \
 "
RDEPENDS:rust-bytecheck+uuid-1-devel = " \
 cargo \
 rust-bytecheck-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-bytecheck-devel = " \
 cargo \
 rust \
 rust-bytecheck_derive-devel \
 rust-ptr_meta-devel \
 rust-rancor-devel \
 "
