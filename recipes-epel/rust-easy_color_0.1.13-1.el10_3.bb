# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-easy_color"
PV = "0.1.13"
PR = "1.el10_3"
PACKAGES = " \
 rust-easy_color+default-devel \
 rust-easy_color-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-easy_color-0.1.13-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2fa43b2908e5478a4ba7d49cc33e32581ddab346937a847cbeda46eb42b6b68e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-easy_color+default-devel-0.1.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-easy_color+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-easy_color+default-devel.sha256sum] = "d114fafde87f750b7613b42f6f2c9e07cf90ec7991782de54687aac2d3005f95"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-easy_color-devel-0.1.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-easy_color-devel;unpack=0"
SRC_URI[x86_64_v2_rust-easy_color-devel.sha256sum] = "5d34731527114590d5a752824e7666ed8b4c0aaba79e66a9e2d473b6c2298544"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-easy_color+default-devel-0.1.13-1.el10_3.noarch.rpm;name=aarch64_rust-easy_color+default-devel;unpack=0"
SRC_URI[aarch64_rust-easy_color+default-devel.sha256sum] = "9e077ac4823adc44422d929ba2be04cbbd6cabd8613a543cb64b052dfe5d544d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-easy_color-devel-0.1.13-1.el10_3.noarch.rpm;name=aarch64_rust-easy_color-devel;unpack=0"
SRC_URI[aarch64_rust-easy_color-devel.sha256sum] = "ad819efcf15c02cc571c70de8657da5ddebd19abf300defe96cf4ee524877ea9"

RDEPENDS:rust-easy_color+default-devel = " \
 cargo \
 rust-easy_color-devel \
 "
RDEPENDS:rust-easy_color-devel = " \
 cargo \
 rust-rand+default-devel \
 "
