# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "procps-ng"
PV = "4.0.4"
PR = "7.el10"
PACKAGES = " \
 procps-ng \
 procps-ng-devel \
 procps-ng-i18n \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/procps-ng-4.0.4-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b0ab4dc76b6ab72f056282a1de173423aa471dc4156b340c5dde423b0fb938f2"

URI_x86_64_v2_procps-ng = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/procps-ng-4.0.4-7.el10.x86_64_v2.rpm;name=x86_64_v2_procps-ng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_procps-ng}"
SRC_URI[x86_64_v2_procps-ng.sha256sum] = "6fbeb1138d2318ab6e495c858a18f965725544d963810a10af9edb1980296c6d"

URI_x86_64_v2_procps-ng-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/procps-ng-devel-4.0.4-7.el10.x86_64_v2.rpm;name=x86_64_v2_procps-ng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_procps-ng-devel}"
SRC_URI[x86_64_v2_procps-ng-devel.sha256sum] = "9ec80964ed89173df8ec498336a66ec2088f1b6482f9ad8c054b5d70bc5043ec"

URI_x86_64_v2_procps-ng-i18n = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/procps-ng-i18n-4.0.4-7.el10.noarch.rpm;name=x86_64_v2_procps-ng-i18n;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_procps-ng-i18n}"
SRC_URI[x86_64_v2_procps-ng-i18n.sha256sum] = "b73acc001607a80a909922a57830b4b938dfe7d7976b604c397f9268dfde4c6f"

URI_aarch64_procps-ng = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/procps-ng-4.0.4-7.el10.aarch64.rpm;name=aarch64_procps-ng;unpack=0"
SRC_URI:append = " ${URI_aarch64_procps-ng}"
SRC_URI[aarch64_procps-ng.sha256sum] = "03635ccac26ed00071094b05b167fed92348648c8c8f86a66551318b64d2dfe8"

URI_aarch64_procps-ng-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/procps-ng-devel-4.0.4-7.el10.aarch64.rpm;name=aarch64_procps-ng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_procps-ng-devel}"
SRC_URI[aarch64_procps-ng-devel.sha256sum] = "d142bd555314f650147b5b30743266139667fad300f7dd7700b73ffe21656bba"

URI_aarch64_procps-ng-i18n = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/procps-ng-i18n-4.0.4-7.el10.noarch.rpm;name=aarch64_procps-ng-i18n;unpack=0"
SRC_URI:append = " ${URI_aarch64_procps-ng-i18n}"
SRC_URI[aarch64_procps-ng-i18n.sha256sum] = "b73acc001607a80a909922a57830b4b938dfe7d7976b604c397f9268dfde4c6f"

RDEPENDS:procps-ng = " \
 glibc \
 ncurses-libs \
 systemd-libs \
 "
RDEPENDS:procps-ng-devel = " \
 pkgconf-pkg-config \
 procps-ng \
 "
RDEPENDS:procps-ng-i18n = " \
 procps-ng \
 "
