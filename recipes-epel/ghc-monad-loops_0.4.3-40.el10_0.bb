# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-monad-loops"
PV = "0.4.3"
PR = "40.el10_0"
PACKAGES = " \
 ghc-monad-loops \
 ghc-monad-loops-devel \
 ghc-monad-loops-doc \
 ghc-monad-loops-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-monad-loops-0.4.3-40.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f779a3afe96ee2f33bc96c0dc5eab80ff36c5a1f7ed02738eb4d6005ce19bdae"

URI_x86_64_v2_ghc-monad-loops = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-monad-loops-0.4.3-40.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-monad-loops;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-monad-loops}"
SRC_URI[x86_64_v2_ghc-monad-loops.sha256sum] = "2c6d13b5580dc82fa34aeb04d893e91bf78db91879e06b2a444a830495d511e7"

URI_x86_64_v2_ghc-monad-loops-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-monad-loops-devel-0.4.3-40.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-monad-loops-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-monad-loops-devel}"
SRC_URI[x86_64_v2_ghc-monad-loops-devel.sha256sum] = "1016f0fd493a72caa69ee9daab259607f4a4d1182eb31a92f355fa278a236888"

URI_x86_64_v2_ghc-monad-loops-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-monad-loops-doc-0.4.3-40.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-monad-loops-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-monad-loops-doc}"
SRC_URI[x86_64_v2_ghc-monad-loops-doc.sha256sum] = "f3f52ea027c7d9b7775598beb7f4c53d0b6e1fea66fae494a3fd6631e693903b"

URI_x86_64_v2_ghc-monad-loops-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-monad-loops-prof-0.4.3-40.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-monad-loops-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-monad-loops-prof}"
SRC_URI[x86_64_v2_ghc-monad-loops-prof.sha256sum] = "e497c088cf7fe96928e1f2404acddef8014a643735b03ae05ad4b59bd578a105"

URI_aarch64_ghc-monad-loops = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-monad-loops-0.4.3-40.el10_0.aarch64.rpm;name=aarch64_ghc-monad-loops;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-monad-loops}"
SRC_URI[aarch64_ghc-monad-loops.sha256sum] = "fb3c7e76b0d95fa8752e409850e9e9c1bdc1954b2b585b7cac9625a2d3b612a7"

URI_aarch64_ghc-monad-loops-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-monad-loops-devel-0.4.3-40.el10_0.aarch64.rpm;name=aarch64_ghc-monad-loops-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-monad-loops-devel}"
SRC_URI[aarch64_ghc-monad-loops-devel.sha256sum] = "4dafa30a4b8e5acae78c49c069f72480985ba995cf59d5c8afa50c036ae99735"

URI_aarch64_ghc-monad-loops-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-monad-loops-doc-0.4.3-40.el10_0.noarch.rpm;name=aarch64_ghc-monad-loops-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-monad-loops-doc}"
SRC_URI[aarch64_ghc-monad-loops-doc.sha256sum] = "6ec6b2f7d27ba640f5ac2d57b000e066bac0ad3824d32fd4ce291afb0a28b6cc"

URI_aarch64_ghc-monad-loops-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-monad-loops-prof-0.4.3-40.el10_0.aarch64.rpm;name=aarch64_ghc-monad-loops-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-monad-loops-prof}"
SRC_URI[aarch64_ghc-monad-loops-prof.sha256sum] = "896b0845a4a06720855074ba8de92cc49a7774c56ff71702db4f0fe45e84bc2c"

RDEPENDS:ghc-monad-loops = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-monad-loops-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-monad-loops \
 "
RDEPENDS:ghc-monad-loops-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-monad-loops-prof = " \
 ghc-base-prof \
 ghc-monad-loops-devel \
 "
