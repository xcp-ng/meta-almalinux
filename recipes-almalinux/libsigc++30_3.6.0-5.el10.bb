# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsigc++30"
PV = "3.6.0"
PR = "5.el10"
PACKAGES = " \
 libsigc++30 \
 libsigc++30-devel \
 libsigc++30-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libsigc++30-3.6.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7664004b1a74c2e9149666ee68fa60081eb8938fe55b5c3a06b7643629846ab0"

URI_x86_64_v2_libsigc++30 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsigc++30-3.6.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_libsigc++30;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsigc++30}"
SRC_URI[x86_64_v2_libsigc++30.sha256sum] = "90c4832ccdc4a3a1c0b46aefd90dd85e50a33a62d4d1fc50047d2c6a2e743158"

URI_x86_64_v2_libsigc++30-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsigc++30-devel-3.6.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_libsigc++30-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsigc++30-devel}"
SRC_URI[x86_64_v2_libsigc++30-devel.sha256sum] = "1f706e45aa7054c0a619668cfa7bc33c5160759ee7bf295ee07a9670727c2d2c"

URI_x86_64_v2_libsigc++30-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsigc++30-doc-3.6.0-5.el10.noarch.rpm;name=x86_64_v2_libsigc++30-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsigc++30-doc}"
SRC_URI[x86_64_v2_libsigc++30-doc.sha256sum] = "4d9a22b9bf36a6820a1b6beec6f4aea531c82ed48fcbaf512276dd16e04af2d4"

URI_aarch64_libsigc++30 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsigc++30-3.6.0-5.el10.aarch64.rpm;name=aarch64_libsigc++30;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsigc++30}"
SRC_URI[aarch64_libsigc++30.sha256sum] = "0f670cb7e62bfe966c96c1e9fcf5ff1b2546bfe0c9d347977d3c8bd6e750bf3b"

URI_aarch64_libsigc++30-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsigc++30-devel-3.6.0-5.el10.aarch64.rpm;name=aarch64_libsigc++30-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsigc++30-devel}"
SRC_URI[aarch64_libsigc++30-devel.sha256sum] = "e80d9e0dee81877b50a0d9570ff414888bb7797e53545608bd40b2850f237584"

URI_aarch64_libsigc++30-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsigc++30-doc-3.6.0-5.el10.noarch.rpm;name=aarch64_libsigc++30-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsigc++30-doc}"
SRC_URI[aarch64_libsigc++30-doc.sha256sum] = "4d9a22b9bf36a6820a1b6beec6f4aea531c82ed48fcbaf512276dd16e04af2d4"

RDEPENDS:libsigc++30 = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libsigc++30-devel = " \
 libsigc++30 \
 pkgconf-pkg-config \
 "
RDEPENDS:libsigc++30-doc = " \
 libsigc++30 \
 "
