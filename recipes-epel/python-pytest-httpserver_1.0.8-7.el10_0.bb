# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-httpserver"
PV = "1.0.8"
PR = "7.el10_0"
PACKAGES = " \
 python3-pytest-httpserver \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-httpserver-1.0.8-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f2221fca51c2f83960f34a51826aea30d416555212b4954970710acfd85c88d1"

URI_x86_64_v2_python3-pytest-httpserver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-httpserver-1.0.8-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-httpserver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-httpserver}"
SRC_URI[x86_64_v2_python3-pytest-httpserver.sha256sum] = "eb97abe086e28638f4a8f2404a7ff881fb5e84dca2cc484c85da6159ae4042b1"

URI_aarch64_python3-pytest-httpserver = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-httpserver-1.0.8-7.el10_0.noarch.rpm;name=aarch64_python3-pytest-httpserver;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-httpserver}"
SRC_URI[aarch64_python3-pytest-httpserver.sha256sum] = "2abc9a2d680fb6abde66b209cabd3673f7559a4ccc0a9f9c52339723b70155e9"

RDEPENDS:python3-pytest-httpserver = " \
 python3 \
 python3-werkzeug \
 "
