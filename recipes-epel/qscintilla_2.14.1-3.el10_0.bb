# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qscintilla"
PV = "2.14.1"
PR = "3.el10_0"
PACKAGES = " \
 python3-qscintilla-qt6 \
 python3-qscintilla-qt6-devel \
 qscintilla-qt5 \
 qscintilla-qt5-devel \
 qscintilla-qt6 \
 qscintilla-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qscintilla-2.14.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec9dc9a0ec5f7849be67b6373efad0eb508458eb378631b94bb7c74c9897a7c7"

URI_x86_64_v2_python3-qscintilla-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-qscintilla-qt6-2.14.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-qscintilla-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-qscintilla-qt6}"
SRC_URI[x86_64_v2_python3-qscintilla-qt6.sha256sum] = "3ddc973b88e103151ed9ff135ec5da41f746e56fd96974033fc4983ff24fbb67"

URI_x86_64_v2_python3-qscintilla-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-qscintilla-qt6-devel-2.14.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-qscintilla-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-qscintilla-qt6-devel}"
SRC_URI[x86_64_v2_python3-qscintilla-qt6-devel.sha256sum] = "4f9f1951dfae83cedf7d9289403274c749dda061127e6a2ac92305354556897e"

URI_x86_64_v2_qscintilla-qt5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qscintilla-qt5-2.14.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qscintilla-qt5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qscintilla-qt5}"
SRC_URI[x86_64_v2_qscintilla-qt5.sha256sum] = "9767c26990fc500f2f2318830b7da3b8766730276a9cc986369ffc4a48369a40"

URI_x86_64_v2_qscintilla-qt5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qscintilla-qt5-devel-2.14.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qscintilla-qt5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qscintilla-qt5-devel}"
SRC_URI[x86_64_v2_qscintilla-qt5-devel.sha256sum] = "515620eade877e49342cf605946cdd22716e33fb91bd51fafdc9799aec0f9d64"

URI_x86_64_v2_qscintilla-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qscintilla-qt6-2.14.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qscintilla-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qscintilla-qt6}"
SRC_URI[x86_64_v2_qscintilla-qt6.sha256sum] = "58074983414dc1d6e9a8f07e40ccfa17bff60de222c79ef443787b1b831e2652"

URI_x86_64_v2_qscintilla-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qscintilla-qt6-devel-2.14.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qscintilla-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qscintilla-qt6-devel}"
SRC_URI[x86_64_v2_qscintilla-qt6-devel.sha256sum] = "2f5f7f12b20ebdefc2c9fc729551c7e9ae472dd314ee6a717acca23979884705"

URI_aarch64_python3-qscintilla-qt6 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-qscintilla-qt6-2.14.1-3.el10_0.aarch64.rpm;name=aarch64_python3-qscintilla-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-qscintilla-qt6}"
SRC_URI[aarch64_python3-qscintilla-qt6.sha256sum] = "b08e527bb2fd7b24146bd020dffba2be9509dea4436a3939e3f1819b45ad2235"

URI_aarch64_python3-qscintilla-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/p/python3-qscintilla-qt6-devel-2.14.1-3.el10_0.aarch64.rpm;name=aarch64_python3-qscintilla-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-qscintilla-qt6-devel}"
SRC_URI[aarch64_python3-qscintilla-qt6-devel.sha256sum] = "f365918f441e77c2416a87b42e3756b60013bc9acee75ba16be18f98ffc75877"

URI_aarch64_qscintilla-qt5 = "${EPEL_MIRROR}/aarch64/Packages/q/qscintilla-qt5-2.14.1-3.el10_0.aarch64.rpm;name=aarch64_qscintilla-qt5;unpack=0"
SRC_URI:append = " ${URI_aarch64_qscintilla-qt5}"
SRC_URI[aarch64_qscintilla-qt5.sha256sum] = "74bb1242346f6d3de87864b0d06d4a11ac25474e5b77194ac0aa730ce322a42d"

URI_aarch64_qscintilla-qt5-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qscintilla-qt5-devel-2.14.1-3.el10_0.aarch64.rpm;name=aarch64_qscintilla-qt5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qscintilla-qt5-devel}"
SRC_URI[aarch64_qscintilla-qt5-devel.sha256sum] = "cd449686ad03ae02f74b9ad789aef4e39edaf22a36300817389cceea3c642c47"

URI_aarch64_qscintilla-qt6 = "${EPEL_MIRROR}/aarch64/Packages/q/qscintilla-qt6-2.14.1-3.el10_0.aarch64.rpm;name=aarch64_qscintilla-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_qscintilla-qt6}"
SRC_URI[aarch64_qscintilla-qt6.sha256sum] = "7e4b6c3f334b37d6d93ffcaa16e46fa2dfaa1720bb517caa53bcdeebf990a321"

URI_aarch64_qscintilla-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qscintilla-qt6-devel-2.14.1-3.el10_0.aarch64.rpm;name=aarch64_qscintilla-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qscintilla-qt6-devel}"
SRC_URI[aarch64_qscintilla-qt6-devel.sha256sum] = "bf412ff4b39601365c1c0d12bfcfeec1e587436abf15340ec2e9de3044d3f4e8"

RDEPENDS:python3-qscintilla-qt6 = " \
 glibc \
 libgcc \
 libglvnd-glx \
 libglvnd-opengl \
 libstdc++ \
 python3 \
 python3-pyqt6 \
 python3-pyqt6-base \
 python3-pyqt6-sip \
 qscintilla-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:python3-qscintilla-qt6-devel = " \
 python3-pyqt6-devel \
 "
RDEPENDS:qscintilla-qt5 = " \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
RDEPENDS:qscintilla-qt5-devel = " \
 qscintilla-qt5 \
 qt5-qtbase-devel \
 "
RDEPENDS:qscintilla-qt6 = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:qscintilla-qt6-devel = " \
 qscintilla-qt6 \
 qt6-qtbase-devel \
 "
