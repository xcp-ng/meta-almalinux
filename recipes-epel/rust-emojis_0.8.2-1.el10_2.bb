# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-emojis"
PV = "0.8.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-emojis+default-devel \
 rust-emojis+serde-devel \
 rust-emojis-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-emojis-0.8.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "beb690f096a8c290323af663d6e7325cd3a10efce57e68567d7bcad62775e441"

URI_x86_64_v2_rust-emojis+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-emojis+default-devel-0.8.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-emojis+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-emojis+default-devel}"
SRC_URI[x86_64_v2_rust-emojis+default-devel.sha256sum] = "c21a10bf1f7cf22e6630e707490a30a693b0d830d947b80464eb5ebcc1a6cb84"

URI_x86_64_v2_rust-emojis+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-emojis+serde-devel-0.8.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-emojis+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-emojis+serde-devel}"
SRC_URI[x86_64_v2_rust-emojis+serde-devel.sha256sum] = "9734388a11ff34a63354102c4015a995c384d3ced65cf3ee5e25c9388fe06b65"

URI_x86_64_v2_rust-emojis-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-emojis-devel-0.8.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-emojis-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-emojis-devel}"
SRC_URI[x86_64_v2_rust-emojis-devel.sha256sum] = "583b22a9f2dceb9d1066b6b5f079014a4cacb20aefcebafc0ecdf7e45413aa63"

URI_aarch64_rust-emojis+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-emojis+default-devel-0.8.2-1.el10_2.noarch.rpm;name=aarch64_rust-emojis+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-emojis+default-devel}"
SRC_URI[aarch64_rust-emojis+default-devel.sha256sum] = "c29dc1651de5ee9ab998bb26f0f2a9ca215488bced7630a09d7475490f39df76"

URI_aarch64_rust-emojis+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-emojis+serde-devel-0.8.2-1.el10_2.noarch.rpm;name=aarch64_rust-emojis+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-emojis+serde-devel}"
SRC_URI[aarch64_rust-emojis+serde-devel.sha256sum] = "bcb25e4a5301b6824bfa9a792f35fa5cd667a6e78f7595d19a1d8f4a12514f27"

URI_aarch64_rust-emojis-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-emojis-devel-0.8.2-1.el10_2.noarch.rpm;name=aarch64_rust-emojis-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-emojis-devel}"
SRC_URI[aarch64_rust-emojis-devel.sha256sum] = "907938cd62264f507082a133a50698053090c9a0aec8abc08d0236c30a1b0099"

RDEPENDS:rust-emojis+default-devel = " \
 cargo \
 rust-emojis-devel \
 "
RDEPENDS:rust-emojis+serde-devel = " \
 cargo \
 rust-emojis-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-emojis-devel = " \
 cargo \
 rust \
 rust-phf-devel \
 "
