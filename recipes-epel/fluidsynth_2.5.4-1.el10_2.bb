# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fluidsynth"
PV = "2.5.4"
PR = "1.el10_2"
PACKAGES = " \
 fluidsynth \
 fluidsynth-devel \
 fluidsynth-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fluidsynth-2.5.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "56cfb1c84ada51abb0d027c03162ea8240a52e3bcf74c580756f50eb8f2710b8"

URI_x86_64_v2_fluidsynth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fluidsynth-2.5.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fluidsynth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fluidsynth}"
SRC_URI[x86_64_v2_fluidsynth.sha256sum] = "6f465d41717f510ca0dfee7fc4e252fd07dd1960f3d0536e260e8dcd2d937e1f"

URI_x86_64_v2_fluidsynth-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fluidsynth-devel-2.5.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fluidsynth-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fluidsynth-devel}"
SRC_URI[x86_64_v2_fluidsynth-devel.sha256sum] = "5a8e17f36ed4879f10afcadd83f9799c83d835373ff7e004dc2479257ce44f42"

URI_x86_64_v2_fluidsynth-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fluidsynth-libs-2.5.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fluidsynth-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fluidsynth-libs}"
SRC_URI[x86_64_v2_fluidsynth-libs.sha256sum] = "1b2e1b41b96e6343bfd910cc4e9a42144ba77c188b6266efdd83cdad1ba13fb2"

URI_aarch64_fluidsynth = "${EPEL_MIRROR}/aarch64/Packages/f/fluidsynth-2.5.4-1.el10_2.aarch64.rpm;name=aarch64_fluidsynth;unpack=0"
SRC_URI:append = " ${URI_aarch64_fluidsynth}"
SRC_URI[aarch64_fluidsynth.sha256sum] = "f8b9a706427f79f7a5376dd04fc4306319c6cf9bcc98545ad9871837de9398f7"

URI_aarch64_fluidsynth-devel = "${EPEL_MIRROR}/aarch64/Packages/f/fluidsynth-devel-2.5.4-1.el10_2.aarch64.rpm;name=aarch64_fluidsynth-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_fluidsynth-devel}"
SRC_URI[aarch64_fluidsynth-devel.sha256sum] = "fe64908aa435915503d4a3d9a55176e41ea4cd5caa8b1cb7a7a095030b178fc0"

URI_aarch64_fluidsynth-libs = "${EPEL_MIRROR}/aarch64/Packages/f/fluidsynth-libs-2.5.4-1.el10_2.aarch64.rpm;name=aarch64_fluidsynth-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_fluidsynth-libs}"
SRC_URI[aarch64_fluidsynth-libs.sha256sum] = "6d27c3f8b90c3d693eebf4ce99de72d66cb29319b8ed9b50c336d3e1a4cae01b"

RDEPENDS:fluidsynth = " \
 fluidsynth-libs \
 glib2 \
 glibc \
 pipewire-libs \
 systemd-libs \
 "
RDEPENDS:fluidsynth-devel = " \
 alsa-lib-devel \
 cmake-filesystem \
 dbus-devel \
 fluidsynth \
 fluidsynth-libs \
 glib2-devel \
 libsndfile-devel \
 pipewire-devel \
 pipewire-jack-audio-connection-kit-devel \
 pkgconf-pkg-config \
 pulseaudio-libs-devel \
 readline-devel \
 systemd-devel \
 "
RDEPENDS:fluidsynth-libs = " \
 alsa-lib \
 dbus-libs \
 glib2 \
 glibc \
 libgcc \
 libgomp \
 libsndfile \
 libstdc++ \
 pipewire-jack-audio-connection-kit-libs \
 pipewire-libs \
 pulseaudio-libs \
 readline \
 "
