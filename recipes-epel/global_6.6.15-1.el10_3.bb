# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "global"
PV = "6.6.15"
PR = "1.el10_3"
PACKAGES = " \
 global \
 global-ctags \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/global-6.6.15-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43d498673467c7c25a84f9a8460a21b8ccb692ff858e1655e2edc370cc54c39e"

URI_x86_64_v2_global = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/global-6.6.15-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_global;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_global}"
SRC_URI[x86_64_v2_global.sha256sum] = "72c5135f5d2feb26c184bb2cccf57cefc0db159b132ae1f8827fa1d2a7540d9b"

URI_x86_64_v2_global-ctags = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/global-ctags-6.6.15-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_global-ctags;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_global-ctags}"
SRC_URI[x86_64_v2_global-ctags.sha256sum] = "ebdae353aaf1b8dfa677a8eff812abb5656ee440d217897de265ccb94983383d"

URI_aarch64_global = "${EPEL_MIRROR}/aarch64/Packages/g/global-6.6.15-1.el10_3.aarch64.rpm;name=aarch64_global;unpack=0"
SRC_URI:append = " ${URI_aarch64_global}"
SRC_URI[aarch64_global.sha256sum] = "ca2dd5c5a7be2433e9e20aa41e9b5825041ac4d31e27b17bf08d32033359e2ec"

URI_aarch64_global-ctags = "${EPEL_MIRROR}/aarch64/Packages/g/global-ctags-6.6.15-1.el10_3.aarch64.rpm;name=aarch64_global-ctags;unpack=0"
SRC_URI:append = " ${URI_aarch64_global-ctags}"
SRC_URI[aarch64_global-ctags.sha256sum] = "821d81336d84de6545cbc6c348c4798e07129995afc1d1f6aa2c50b970840512"

RDEPENDS:global = " \
 bash \
 emacs-filesystem \
 glibc \
 libtool-ltdl \
 ncurses-libs \
 perl-interpreter \
 python3 \
 "
RDEPENDS:global-ctags = " \
 glibc \
 global \
 python3-pygments \
 "
