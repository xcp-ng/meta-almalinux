# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zune-jpeg0.4"
PV = "0.4.21"
PR = "1.el10_2"
PACKAGES = " \
 rust-zune-jpeg0.4+default-devel \
 rust-zune-jpeg0.4+log-devel \
 rust-zune-jpeg0.4+neon-devel \
 rust-zune-jpeg0.4+std-devel \
 rust-zune-jpeg0.4+x86-devel \
 rust-zune-jpeg0.4-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zune-jpeg0.4-0.4.21-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a2f2f90326595dce93a83ea138e4e4104f886e20f75e078d8c55fe820f16ea7b"

URI_x86_64_v2_rust-zune-jpeg0.4+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg0.4+default-devel-0.4.21-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-jpeg0.4+default-devel}"
SRC_URI[x86_64_v2_rust-zune-jpeg0.4+default-devel.sha256sum] = "18d16e910892e094d4c7f38e16b956181b29704c23134d48b59bfe0148470205"

URI_x86_64_v2_rust-zune-jpeg0.4+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg0.4+log-devel-0.4.21-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg0.4+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-jpeg0.4+log-devel}"
SRC_URI[x86_64_v2_rust-zune-jpeg0.4+log-devel.sha256sum] = "a980832ab68e4c4dcac7d67c0c5989b9c54d14a661a09bcda3074655899ab5a9"

URI_x86_64_v2_rust-zune-jpeg0.4+neon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg0.4+neon-devel-0.4.21-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg0.4+neon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-jpeg0.4+neon-devel}"
SRC_URI[x86_64_v2_rust-zune-jpeg0.4+neon-devel.sha256sum] = "21fd5913fc9d39cc70612188e99893c3710559272d7674f160a8e3821137b1e1"

URI_x86_64_v2_rust-zune-jpeg0.4+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg0.4+std-devel-0.4.21-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg0.4+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-jpeg0.4+std-devel}"
SRC_URI[x86_64_v2_rust-zune-jpeg0.4+std-devel.sha256sum] = "d3f14777f5182ae716c762e25325edbec941ad7b68fe35917c82a0cc275b5b73"

URI_x86_64_v2_rust-zune-jpeg0.4+x86-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg0.4+x86-devel-0.4.21-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg0.4+x86-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-jpeg0.4+x86-devel}"
SRC_URI[x86_64_v2_rust-zune-jpeg0.4+x86-devel.sha256sum] = "21d13b890d2ec041ae54d39c98433d039050688c10dd50b98d3e9703a1a52a38"

URI_x86_64_v2_rust-zune-jpeg0.4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg0.4-devel-0.4.21-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg0.4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-jpeg0.4-devel}"
SRC_URI[x86_64_v2_rust-zune-jpeg0.4-devel.sha256sum] = "d46c49b075ece85f689de94c0f86380416e822c2b7ae59c1e82a585842d90001"

URI_aarch64_rust-zune-jpeg0.4+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg0.4+default-devel-0.4.21-1.el10_2.noarch.rpm;name=aarch64_rust-zune-jpeg0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-jpeg0.4+default-devel}"
SRC_URI[aarch64_rust-zune-jpeg0.4+default-devel.sha256sum] = "418180d85a2b34d986910341f5000c729172e2e25fdab4aae8cc3589e1536440"

URI_aarch64_rust-zune-jpeg0.4+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg0.4+log-devel-0.4.21-1.el10_2.noarch.rpm;name=aarch64_rust-zune-jpeg0.4+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-jpeg0.4+log-devel}"
SRC_URI[aarch64_rust-zune-jpeg0.4+log-devel.sha256sum] = "6ca224ccbc5661e33ab5f8ec1116d00fb0c29ae99d7c8525231782dec57c146d"

URI_aarch64_rust-zune-jpeg0.4+neon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg0.4+neon-devel-0.4.21-1.el10_2.noarch.rpm;name=aarch64_rust-zune-jpeg0.4+neon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-jpeg0.4+neon-devel}"
SRC_URI[aarch64_rust-zune-jpeg0.4+neon-devel.sha256sum] = "00e290470e94d3f9d3e0b67e8fcfb3255cc0d0fc7140b4aaa49c6ca1a647039c"

URI_aarch64_rust-zune-jpeg0.4+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg0.4+std-devel-0.4.21-1.el10_2.noarch.rpm;name=aarch64_rust-zune-jpeg0.4+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-jpeg0.4+std-devel}"
SRC_URI[aarch64_rust-zune-jpeg0.4+std-devel.sha256sum] = "bbe1b841bb2948332b473e26a5f6a3c0cc039126af89a853fde163b761ecc56c"

URI_aarch64_rust-zune-jpeg0.4+x86-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg0.4+x86-devel-0.4.21-1.el10_2.noarch.rpm;name=aarch64_rust-zune-jpeg0.4+x86-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-jpeg0.4+x86-devel}"
SRC_URI[aarch64_rust-zune-jpeg0.4+x86-devel.sha256sum] = "d215d103109e4a234f8ec0266f2fd603ba156becd827328595ec7b8bcc72e263"

URI_aarch64_rust-zune-jpeg0.4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg0.4-devel-0.4.21-1.el10_2.noarch.rpm;name=aarch64_rust-zune-jpeg0.4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-jpeg0.4-devel}"
SRC_URI[aarch64_rust-zune-jpeg0.4-devel.sha256sum] = "20a3dd46034ec99546b8ed01b37feddbd2a55a9d2fb65860ef1e13aa07d5e6a0"

RDEPENDS:rust-zune-jpeg0.4+default-devel = " \
 cargo \
 rust-zune-jpeg0.4+neon-devel \
 rust-zune-jpeg0.4+std-devel \
 rust-zune-jpeg0.4+x86-devel \
 rust-zune-jpeg0.4-devel \
 "
RDEPENDS:rust-zune-jpeg0.4+log-devel = " \
 cargo \
 rust-zune-core0.4+log-devel \
 rust-zune-jpeg0.4-devel \
 "
RDEPENDS:rust-zune-jpeg0.4+neon-devel = " \
 cargo \
 rust-zune-jpeg0.4-devel \
 "
RDEPENDS:rust-zune-jpeg0.4+std-devel = " \
 cargo \
 rust-zune-core0.4+std-devel \
 rust-zune-jpeg0.4-devel \
 "
RDEPENDS:rust-zune-jpeg0.4+x86-devel = " \
 cargo \
 rust-zune-jpeg0.4-devel \
 "
RDEPENDS:rust-zune-jpeg0.4-devel = " \
 cargo \
 rust-zune-core0.4+default-devel \
 "
