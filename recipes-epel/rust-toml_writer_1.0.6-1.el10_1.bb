# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-toml_writer"
PV = "1.0.6"
PR = "1.el10_1"
PACKAGES = " \
 rust-toml_writer+alloc-devel \
 rust-toml_writer+default-devel \
 rust-toml_writer+std-devel \
 rust-toml_writer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-toml_writer-1.0.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12d65750d20db65e2b0cbcc11e062239e1257a7126ef48f500d0143754509aa9"

URI_x86_64_v2_rust-toml_writer+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_writer+alloc-devel-1.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_writer+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_writer+alloc-devel}"
SRC_URI[x86_64_v2_rust-toml_writer+alloc-devel.sha256sum] = "36e4c084390b7778d67a0b17ce558226cf1a6cc071c9b397e288edd8a51a2449"

URI_x86_64_v2_rust-toml_writer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_writer+default-devel-1.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_writer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_writer+default-devel}"
SRC_URI[x86_64_v2_rust-toml_writer+default-devel.sha256sum] = "8ede2e2fc26efb10d5fc383afb6ddf3c723498d7103623aec3b7e029e098def1"

URI_x86_64_v2_rust-toml_writer+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_writer+std-devel-1.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_writer+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_writer+std-devel}"
SRC_URI[x86_64_v2_rust-toml_writer+std-devel.sha256sum] = "a0fee36e217722fb5553b364426fdce21b750a82dbd547ffb4ac79957299903c"

URI_x86_64_v2_rust-toml_writer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_writer-devel-1.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_writer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_writer-devel}"
SRC_URI[x86_64_v2_rust-toml_writer-devel.sha256sum] = "dba44ddbf449d63c218e0acfb06ca98addbc1d53c6119b2dabdc6a4e188038bc"

URI_aarch64_rust-toml_writer+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_writer+alloc-devel-1.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-toml_writer+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_writer+alloc-devel}"
SRC_URI[aarch64_rust-toml_writer+alloc-devel.sha256sum] = "4a97a8a6f73c62bf3b24f4dc531b6af15589ab0f4f11c1832e7e8cfb68bcaf8b"

URI_aarch64_rust-toml_writer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_writer+default-devel-1.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-toml_writer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_writer+default-devel}"
SRC_URI[aarch64_rust-toml_writer+default-devel.sha256sum] = "f58a71134f7af519a7cafef12d6f4332df068c370ed0475955a3fd8a4b1e71a2"

URI_aarch64_rust-toml_writer+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_writer+std-devel-1.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-toml_writer+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_writer+std-devel}"
SRC_URI[aarch64_rust-toml_writer+std-devel.sha256sum] = "65b2e08d0be70d0fd36e62a360e4f3a638929e83f837b249f413c9e963776cc4"

URI_aarch64_rust-toml_writer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_writer-devel-1.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-toml_writer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_writer-devel}"
SRC_URI[aarch64_rust-toml_writer-devel.sha256sum] = "dd358a3b3ab6fbb576220741c5a35ba2b5715e4608d3c9966450049983d90a3c"

RDEPENDS:rust-toml_writer+alloc-devel = " \
 cargo \
 rust-toml_writer-devel \
 "
RDEPENDS:rust-toml_writer+default-devel = " \
 cargo \
 rust-toml_writer+std-devel \
 rust-toml_writer-devel \
 "
RDEPENDS:rust-toml_writer+std-devel = " \
 cargo \
 rust-toml_writer+alloc-devel \
 rust-toml_writer-devel \
 "
RDEPENDS:rust-toml_writer-devel = " \
 cargo \
 rust \
 "
