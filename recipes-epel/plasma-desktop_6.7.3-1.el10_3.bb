# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-desktop"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 plasma-desktop \
 plasma-desktop-doc \
 sddm-breeze \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-desktop-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2b59ca4d49ac9df605067dca1812054b600ee1789614921888870944655386ae"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - sddm-breeze: kde-settings-sddm

URI_x86_64_v2_plasma-desktop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-desktop-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-desktop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-desktop}"
SRC_URI[x86_64_v2_plasma-desktop.sha256sum] = "f687abda735b27ad1d46b08b4eec0e7ffa287cd2e7207cea96950f7da5125a87"

URI_x86_64_v2_plasma-desktop-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-desktop-doc-6.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-desktop-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-desktop-doc}"
SRC_URI[x86_64_v2_plasma-desktop-doc.sha256sum] = "4ce6fcf0c5c3b41ede9ffb4816d9d942226e7149c8cb4a88268b42d836d8944e"

URI_x86_64_v2_sddm-breeze = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sddm-breeze-6.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_sddm-breeze;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sddm-breeze}"
SRC_URI[x86_64_v2_sddm-breeze.sha256sum] = "d85030ddc1771ba81317b7486d126c201bc131a77f1fa38fa2f75f59f4646ffb"

URI_aarch64_plasma-desktop = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-desktop-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-desktop;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-desktop}"
SRC_URI[aarch64_plasma-desktop.sha256sum] = "8922526abe8618029b991e8f69b5f98207f089758cc32d0fb46d49b8a9ba4e12"

URI_aarch64_plasma-desktop-doc = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-desktop-doc-6.7.3-1.el10_3.noarch.rpm;name=aarch64_plasma-desktop-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-desktop-doc}"
SRC_URI[aarch64_plasma-desktop-doc.sha256sum] = "31fed591c30d991225d56c267f487069e513db775f0958e837f09c2d784965e2"

URI_aarch64_sddm-breeze = "${EPEL_MIRROR}/aarch64/Packages/s/sddm-breeze-6.7.3-1.el10_3.noarch.rpm;name=aarch64_sddm-breeze;unpack=0"
SRC_URI:append = " ${URI_aarch64_sddm-breeze}"
SRC_URI[aarch64_sddm-breeze.sha256sum] = "a156f1bd3310970b5f78f6a7509b62866ea5a7007c376e0886f5cb9b38e4b50e"

RDEPENDS:plasma-desktop = " \
 PackageKit-Qt6 \
 accountsservice \
 bash \
 glib2 \
 glibc \
 google-noto-color-emoji-fonts \
 ibus-libs \
 kaccounts-integration-qt6 \
 kde-cli-tools \
 kf6-attica \
 kf6-baloo-libs \
 kf6-kbookmarks \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kjobwidgets \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kpackage \
 kf6-krunner \
 kf6-kservice \
 kf6-ksvg \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-qqc2-desktop-style \
 kf6-solid \
 kf6-sonnet \
 kio-extras \
 kmenuedit \
 kpipewire \
 kwin \
 kwrited \
 libX11 \
 libXi \
 libaccounts-qt6 \
 libcanberra \
 libksysguard \
 libkworkspace6 \
 libplasma \
 libstdc++ \
 libwacom \
 libwayland-client \
 libxcb \
 libxkbcommon \
 libxkbfile \
 plasma-activities \
 plasma-activities-stats \
 plasma-integration \
 plasma-systemsettings \
 plasma-workspace \
 plasma-workspace-libs \
 plasma5support \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtlocation \
 signon-plugin-oauth2 \
 systemd-libs \
 virtual/libSDL2-2.0.so.0___64bit_ \
 xcb-util-keysyms \
 xdg-utils \
 "
RDEPENDS:plasma-desktop-doc = " \
 "
RDEPENDS:sddm-breeze:x86_64_v2 = " \
 kf6-kimageformats \
 libplasma \
 plasma-workspace \
 qt6-qtvirtualkeyboard \
 virtual/desktop-backgrounds-compat \
"
RDEPENDS:sddm-breeze:aarch64 = " \
 kde-settings-sddm \
 kf6-kimageformats \
 libplasma \
 plasma-workspace \
 qt6-qtvirtualkeyboard \
 virtual/desktop-backgrounds-compat \
"
