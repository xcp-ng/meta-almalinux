# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hipfft"
PV = "7.1.0"
PR = "4.el10_2"
PACKAGES:x86_64_v2 = " \
 hipfft \
 hipfft-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/h/hipfft-7.1.0-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9830516f51aed549e4661a261a171fc19da49d67356f6cb9eb79dc590658ab9"

URI_x86_64_v2_hipfft = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipfft-7.1.0-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipfft;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipfft}"
SRC_URI[x86_64_v2_hipfft.sha256sum] = "3aaa8766da28dffc0d89dc77ab4b4b3a0c4112cdb423edb193c17bcc09d610e4"

URI_x86_64_v2_hipfft-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipfft-devel-7.1.0-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipfft-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipfft-devel}"
SRC_URI[x86_64_v2_hipfft-devel.sha256sum] = "bc5dd6c4c8f8ceaf93342a879ed0d3ee9cbe844838b44c74e7d6d1701171787f"

RDEPENDS:hipfft = " \
 glibc \
 libgcc \
 libstdc++ \
 rocfft \
 rocm-hip \
 "
RDEPENDS:hipfft-devel = " \
 cmake-filesystem \
 hipfft \
 "
