# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "asahi-installer"
PV = "0.7.8"
PR = "4.el10_1"
PACKAGES:x86_64_v2 = " \
 python3-asahi_firmware \
"
PACKAGES:aarch64 = " \
 asahi-installer-package \
 python3-asahi_firmware \
"

URI_src = "${EPELSRC_MIRROR}/Packages/a/asahi-installer-0.7.8-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "355efd8ab8c97162ab3d1ed3e4de5fda47facaed3bf61614436fbab46f66dfc0"

URI_x86_64_v2_python3-asahi_firmware = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-asahi_firmware-0.7.8-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-asahi_firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-asahi_firmware}"
SRC_URI[x86_64_v2_python3-asahi_firmware.sha256sum] = "6e3d8d2e4c352c5977711ad8e46dec8e0177379a487c8b48eb6b4680b12b4f92"

URI_aarch64_asahi-installer-package = "${EPEL_MIRROR}/aarch64/Packages/a/asahi-installer-package-0.7.8-4.el10_1.aarch64.rpm;name=aarch64_asahi-installer-package;unpack=0"
SRC_URI:append = " ${URI_aarch64_asahi-installer-package}"
SRC_URI[aarch64_asahi-installer-package.sha256sum] = "1d2615dc990e9381201192e9a67ca613271dc89018b232722b42d470cad67bfc"

URI_aarch64_python3-asahi_firmware = "${EPEL_MIRROR}/aarch64/Packages/p/python3-asahi_firmware-0.7.8-4.el10_1.aarch64.rpm;name=aarch64_python3-asahi_firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-asahi_firmware}"
SRC_URI[aarch64_python3-asahi_firmware.sha256sum] = "1beb4bb33ac9c8e892a9e7035c9547889ccbfc230fe86844b5c13520ba2cc4a7"

RDEPENDS:python3-asahi_firmware = " \
 lzfse-libs \
 python3 \
 python3-asn1 \
 tar \
 "
RDEPENDS:asahi-installer-package = " \
 "
