# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-config"
PV = "0.58.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-config+default-devel \
 rust-gix-config+document-features-devel \
 rust-gix-config+serde-devel \
 rust-gix-config+sha1-devel \
 rust-gix-config+sha256-devel \
 rust-gix-config-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-config-0.58.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ea96549529c9c1bd50b4361ddbee7048b028926580bcdb9ad01ee84aae3af38"

URI_x86_64_v2_rust-gix-config+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config+default-devel-0.58.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config+default-devel}"
SRC_URI[x86_64_v2_rust-gix-config+default-devel.sha256sum] = "95f7b9bffac45440985f9a74209bad1e15b116771c0f34400d58ac73daa2ff80"

URI_x86_64_v2_rust-gix-config+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config+document-features-devel-0.58.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-config+document-features-devel.sha256sum] = "0822bcb26310fe29d3f9523820169c83a68c80bd0e00b98abe7eefde572cf2bb"

URI_x86_64_v2_rust-gix-config+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config+serde-devel-0.58.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-config+serde-devel.sha256sum] = "6f0ef3e7d6063f02b4d275eb9ad1088194314700d22ba4a9a039f4ae3f57a93e"

URI_x86_64_v2_rust-gix-config+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config+sha1-devel-0.58.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config+sha1-devel}"
SRC_URI[x86_64_v2_rust-gix-config+sha1-devel.sha256sum] = "dabba4d5ac08e653ec53fd044b20a1c20c7d57d1de927d077fc0e9c7eac1082d"

URI_x86_64_v2_rust-gix-config+sha256-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config+sha256-devel-0.58.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config+sha256-devel}"
SRC_URI[x86_64_v2_rust-gix-config+sha256-devel.sha256sum] = "ddfaa910f3bfb0dd72ebe42a7c84d2e9a8e67b7cb6cfe37983f7866f8a6b19cd"

URI_x86_64_v2_rust-gix-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config-devel-0.58.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config-devel}"
SRC_URI[x86_64_v2_rust-gix-config-devel.sha256sum] = "f699a51dadfcf28a15a45990114960fe17ac120122a144e0e65609ac8448c256"

URI_aarch64_rust-gix-config+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config+default-devel-0.58.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config+default-devel}"
SRC_URI[aarch64_rust-gix-config+default-devel.sha256sum] = "3616ccc25fd200cc98202f69cf04bae4b7847a557170a31fce0b45ddb757fee9"

URI_aarch64_rust-gix-config+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config+document-features-devel-0.58.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-config+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config+document-features-devel}"
SRC_URI[aarch64_rust-gix-config+document-features-devel.sha256sum] = "bbd1e0dae6c80682d41f040a07f1dd6cc7e628a2fa8974800197d71c0e791e10"

URI_aarch64_rust-gix-config+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config+serde-devel-0.58.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-config+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config+serde-devel}"
SRC_URI[aarch64_rust-gix-config+serde-devel.sha256sum] = "d485b8bf1e28a9ea2a7b39cb4ec9485ce945cf1b0553508414e89819337dbaee"

URI_aarch64_rust-gix-config+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config+sha1-devel-0.58.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-config+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config+sha1-devel}"
SRC_URI[aarch64_rust-gix-config+sha1-devel.sha256sum] = "4f58383aaff18faa35209d29f7571a8936d6315c02f01475c93c504eaad7e802"

URI_aarch64_rust-gix-config+sha256-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config+sha256-devel-0.58.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-config+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config+sha256-devel}"
SRC_URI[aarch64_rust-gix-config+sha256-devel.sha256sum] = "15becec55dd0b4fcac08a988ff5cb583542ac43f8a24252a1f16eee115e1319f"

URI_aarch64_rust-gix-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config-devel-0.58.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config-devel}"
SRC_URI[aarch64_rust-gix-config-devel.sha256sum] = "99445b5f0324b059a38a7a5e3f67592c48c3a06059ab0018430298af3cbf9bda"

RDEPENDS:rust-gix-config+default-devel = " \
 cargo \
 rust-gix-config-devel \
 "
RDEPENDS:rust-gix-config+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-config-devel \
 "
RDEPENDS:rust-gix-config+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-config-devel \
 rust-gix-config-value+serde-devel \
 rust-gix-glob+serde-devel \
 rust-gix-ref+serde-devel \
 rust-gix-sec+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-config+sha1-devel = " \
 cargo \
 rust-gix-config-devel \
 rust-gix-ref+sha1-devel \
 "
RDEPENDS:rust-gix-config+sha256-devel = " \
 cargo \
 rust-gix-config-devel \
 rust-gix-ref+sha256-devel \
 "
RDEPENDS:rust-gix-config-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-config-value+default-devel \
 rust-gix-features+default-devel \
 rust-gix-glob+default-devel \
 rust-gix-path+default-devel \
 rust-gix-ref+default-devel \
 rust-gix-sec+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 rust-unicode-bom+default-devel \
 "
