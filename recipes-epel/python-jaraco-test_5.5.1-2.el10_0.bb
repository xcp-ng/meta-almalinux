# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jaraco-test"
PV = "5.5.1"
PR = "2.el10_0"
PACKAGES = " \
 python3-jaraco-test \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-jaraco-test-5.5.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c5a4473bc6149c5f05b36e82458b3fb3aaa50e5dfafa675bb29c61347d2748c"

URI_x86_64_v2_python3-jaraco-test = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jaraco-test-5.5.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jaraco-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jaraco-test}"
SRC_URI[x86_64_v2_python3-jaraco-test.sha256sum] = "32d15079dc14312bc6b3d73c15a7d856c3548a36cfbe9528d1f245f4aa9a354a"

URI_aarch64_python3-jaraco-test = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jaraco-test-5.5.1-2.el10_0.noarch.rpm;name=aarch64_python3-jaraco-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jaraco-test}"
SRC_URI[aarch64_python3-jaraco-test.sha256sum] = "5e278eb35ae090756f6d2b905bdb649f8cdf7a0dc2a4cb05eab6e46f353025d0"

RDEPENDS:python3-jaraco-test = " \
 python3 \
 python3-jaraco-collections \
 python3-jaraco-context \
 python3-jaraco-functools \
 python3-test \
 "
