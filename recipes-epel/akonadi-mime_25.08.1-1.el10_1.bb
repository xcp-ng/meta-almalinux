# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-mime"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 akonadi-mime \
 akonadi-mime-devel \
 akonadi-mime-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akonadi-mime-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9f282e44bc51b16ac83562f1d85faef412789679d9324f55b88d7ffd01b6a2e"

URI_x86_64_v2_akonadi-mime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-mime-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-mime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-mime}"
SRC_URI[x86_64_v2_akonadi-mime.sha256sum] = "c634574699c0f3058abd3bbab949e64a5be4c1feffce62f02ccd551396c85dd3"

URI_x86_64_v2_akonadi-mime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-mime-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-mime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-mime-devel}"
SRC_URI[x86_64_v2_akonadi-mime-devel.sha256sum] = "77ff0bba7e11dbcb56d706fedbc4afc78f517fc1db6a95de7ff77b34ba33fc52"

URI_x86_64_v2_akonadi-mime-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-mime-doc-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_akonadi-mime-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-mime-doc}"
SRC_URI[x86_64_v2_akonadi-mime-doc.sha256sum] = "8cb4e86405463deb5f20a7c16c38a52699f47de9c7e0c0ddccd05d5df5f37e10"

URI_aarch64_akonadi-mime = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-mime-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_akonadi-mime;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-mime}"
SRC_URI[aarch64_akonadi-mime.sha256sum] = "0f0825011cace8be562695184e2ea0582553368605739010d59d4dc1f72fbd7b"

URI_aarch64_akonadi-mime-devel = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-mime-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_akonadi-mime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-mime-devel}"
SRC_URI[aarch64_akonadi-mime-devel.sha256sum] = "c27d3c12310a87769968c3c4fec6505ca2dee2b5d5526234bbcc7bfe0bc53319"

URI_aarch64_akonadi-mime-doc = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-mime-doc-25.08.1-1.el10_1.noarch.rpm;name=aarch64_akonadi-mime-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-mime-doc}"
SRC_URI[aarch64_akonadi-mime-doc.sha256sum] = "cdf2dc561fe2e8acafa332a4089453c2bdff994e12bd22cb82bd95d5c4a5aab8"

RDEPENDS:akonadi-mime = " \
 akonadi-server \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kmime \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:akonadi-mime-devel = " \
 akonadi-mime \
 akonadi-server-devel \
 cmake-filesystem \
 "
RDEPENDS:akonadi-mime-doc = " \
 "
