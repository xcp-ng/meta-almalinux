# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua-unbound"
PV = "1.0.0"
PR = "9.el10_0"
PACKAGES = " \
 lua-unbound \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lua-unbound-1.0.0-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27a785cbd0064270c56cae66ab5dfef9a5a21ba575dfeaa4b10456dabb68adb4"

URI_x86_64_v2_lua-unbound = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua-unbound-1.0.0-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lua-unbound;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-unbound}"
SRC_URI[x86_64_v2_lua-unbound.sha256sum] = "e9fe12ee2c3581a078a4a847ff375bce1f66b63d18224b15895062499e59208d"

URI_aarch64_lua-unbound = "${EPEL_MIRROR}/aarch64/Packages/l/lua-unbound-1.0.0-9.el10_0.aarch64.rpm;name=aarch64_lua-unbound;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-unbound}"
SRC_URI[aarch64_lua-unbound.sha256sum] = "7b4704019040e9175b66351212ead3c37bc50923bc27bd44ae0c3abd3c3e104c"

RDEPENDS:lua-unbound = " \
 glibc \
 lua-libs \
 unbound-libs \
 "
