# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "numactl"
PV = "2.0.19"
PR = "2.el10"
PACKAGES = " \
 numactl \
 numactl-devel \
 numactl-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/numactl-2.0.19-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "db10ef3b62941f106e027af92a02d161272c8ef6eeab7f385db75d46484d9d47"

URI_x86_64_v2_numactl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/numactl-2.0.19-2.el10.x86_64_v2.rpm;name=x86_64_v2_numactl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_numactl}"
SRC_URI[x86_64_v2_numactl.sha256sum] = "8f8a9ac9cef8118ec09022ea8c803208536f3b99fce9d453b90829c39c5343b9"

URI_x86_64_v2_numactl-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/numactl-devel-2.0.19-2.el10.x86_64_v2.rpm;name=x86_64_v2_numactl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_numactl-devel}"
SRC_URI[x86_64_v2_numactl-devel.sha256sum] = "c97fcf855e668f416cd9f6a28db2059c3269e0351907ba0271e07efaefd2a817"

URI_x86_64_v2_numactl-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/numactl-libs-2.0.19-2.el10.x86_64_v2.rpm;name=x86_64_v2_numactl-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_numactl-libs}"
SRC_URI[x86_64_v2_numactl-libs.sha256sum] = "6b3162df86b1e037e735f709fdf48920e0679625fe3214160eac16a74a3365d1"

URI_aarch64_numactl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/numactl-2.0.19-2.el10.aarch64.rpm;name=aarch64_numactl;unpack=0"
SRC_URI:append = " ${URI_aarch64_numactl}"
SRC_URI[aarch64_numactl.sha256sum] = "3b14ab05f6fde3dfc71dd5bb57a33b9f895c903c56aa4a6fe06c1abe4f1edc53"

URI_aarch64_numactl-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/numactl-devel-2.0.19-2.el10.aarch64.rpm;name=aarch64_numactl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_numactl-devel}"
SRC_URI[aarch64_numactl-devel.sha256sum] = "9cb937de0121c186f6e8a79bd4b609f8b2be66426d2206817f7d3d14351c0842"

URI_aarch64_numactl-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/numactl-libs-2.0.19-2.el10.aarch64.rpm;name=aarch64_numactl-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_numactl-libs}"
SRC_URI[aarch64_numactl-libs.sha256sum] = "0f52e9bd16bf1c99631d33c6ac0bec82dd64cc796c397694e81d2e1c05911635"

RDEPENDS:numactl = " \
 glibc \
 numactl-libs \
 "
RDEPENDS:numactl-devel = " \
 numactl-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:numactl-libs:x86_64_v2 = " \
 glibc \
"
RDEPENDS:numactl-libs:aarch64 = " \
 glibc \
 libatomic \
"
