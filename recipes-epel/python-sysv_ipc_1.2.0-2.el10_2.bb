# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sysv_ipc"
PV = "1.2.0"
PR = "2.el10_2"
PACKAGES = " \
 python-sysv_ipc-examples \
 python3-sysv_ipc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-sysv_ipc-1.2.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab1b70e175ff562fa43976c1ed6ab3a624786bac5abaf5eb89d50f71f6d18d0d"

URI_x86_64_v2_python-sysv_ipc-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-sysv_ipc-examples-1.2.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python-sysv_ipc-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-sysv_ipc-examples}"
SRC_URI[x86_64_v2_python-sysv_ipc-examples.sha256sum] = "a5654f5911503f62c7cfa2f3deeac85acb1aecf7dc5f3f88050744a9280dcd0a"

URI_x86_64_v2_python3-sysv_ipc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sysv_ipc-1.2.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-sysv_ipc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sysv_ipc}"
SRC_URI[x86_64_v2_python3-sysv_ipc.sha256sum] = "ac207bc984b70ddf59e017cd32b95ff22110d306c183239e781f670b4bbcb392"

URI_aarch64_python-sysv_ipc-examples = "${EPEL_MIRROR}/aarch64/Packages/p/python-sysv_ipc-examples-1.2.0-2.el10_2.aarch64.rpm;name=aarch64_python-sysv_ipc-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-sysv_ipc-examples}"
SRC_URI[aarch64_python-sysv_ipc-examples.sha256sum] = "a55fbbe5eea99175ad06eee95f23880e243ce9140684b62c180d33741895a0ec"

URI_aarch64_python3-sysv_ipc = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sysv_ipc-1.2.0-2.el10_2.aarch64.rpm;name=aarch64_python3-sysv_ipc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sysv_ipc}"
SRC_URI[aarch64_python3-sysv_ipc.sha256sum] = "5d709aa44f70633bad8add497938e2e3b21f2cf3835cc89de04007b25b5a1444"

RDEPENDS:python-sysv_ipc-examples = " \
 "
RDEPENDS:python3-sysv_ipc = " \
 glibc \
 python3 \
 "
