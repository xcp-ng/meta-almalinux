# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-extensible-exceptions"
PV = "0.1.1.4"
PR = "45.el10_0"
PACKAGES = " \
 ghc-extensible-exceptions \
 ghc-extensible-exceptions-devel \
 ghc-extensible-exceptions-doc \
 ghc-extensible-exceptions-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-extensible-exceptions-0.1.1.4-45.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ff76617f4e9ada2527aab723d062b13fcf3312e2d71a746d0019b5101e2c33f"

URI_x86_64_v2_ghc-extensible-exceptions = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-extensible-exceptions-0.1.1.4-45.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-extensible-exceptions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-extensible-exceptions}"
SRC_URI[x86_64_v2_ghc-extensible-exceptions.sha256sum] = "59f4829097cf6506be7d3c65958329234660ad6f068354caa89189a4f880abc1"

URI_x86_64_v2_ghc-extensible-exceptions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-extensible-exceptions-devel-0.1.1.4-45.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-extensible-exceptions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-extensible-exceptions-devel}"
SRC_URI[x86_64_v2_ghc-extensible-exceptions-devel.sha256sum] = "62ee0080d2e9241a67d329992f6ee66ed96b6764dbc2bfc7d682dd2cb0f96961"

URI_x86_64_v2_ghc-extensible-exceptions-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-extensible-exceptions-doc-0.1.1.4-45.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-extensible-exceptions-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-extensible-exceptions-doc}"
SRC_URI[x86_64_v2_ghc-extensible-exceptions-doc.sha256sum] = "b55ab17d0843512f02272d7efc34f6a6650072c52c760be93de3851f1ee24225"

URI_x86_64_v2_ghc-extensible-exceptions-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-extensible-exceptions-prof-0.1.1.4-45.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-extensible-exceptions-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-extensible-exceptions-prof}"
SRC_URI[x86_64_v2_ghc-extensible-exceptions-prof.sha256sum] = "89e8dbf3f3b4a7f3a8addb00c30db2f1a455cbed07a4ef8529d5e3edca08b7de"

URI_aarch64_ghc-extensible-exceptions = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-extensible-exceptions-0.1.1.4-45.el10_0.aarch64.rpm;name=aarch64_ghc-extensible-exceptions;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-extensible-exceptions}"
SRC_URI[aarch64_ghc-extensible-exceptions.sha256sum] = "17c9b38b3762799ec89edf13623af1a0c69ba7ad733e5ba11f3413434e831403"

URI_aarch64_ghc-extensible-exceptions-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-extensible-exceptions-devel-0.1.1.4-45.el10_0.aarch64.rpm;name=aarch64_ghc-extensible-exceptions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-extensible-exceptions-devel}"
SRC_URI[aarch64_ghc-extensible-exceptions-devel.sha256sum] = "d66972cb67221ae3a9b6260a1d8f42f771b7b7d8ae908919cd52f6db089c6431"

URI_aarch64_ghc-extensible-exceptions-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-extensible-exceptions-doc-0.1.1.4-45.el10_0.noarch.rpm;name=aarch64_ghc-extensible-exceptions-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-extensible-exceptions-doc}"
SRC_URI[aarch64_ghc-extensible-exceptions-doc.sha256sum] = "37db67a268df010b8678cada150e4360e3bb7d5940059a21e92bf9a29eef8c14"

URI_aarch64_ghc-extensible-exceptions-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-extensible-exceptions-prof-0.1.1.4-45.el10_0.aarch64.rpm;name=aarch64_ghc-extensible-exceptions-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-extensible-exceptions-prof}"
SRC_URI[aarch64_ghc-extensible-exceptions-prof.sha256sum] = "19a404c49d7aa2e4881c3fe144d4cf80f5ea952a45018593ded26832eadb74f5"

RDEPENDS:ghc-extensible-exceptions = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-extensible-exceptions-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-extensible-exceptions \
 "
RDEPENDS:ghc-extensible-exceptions-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-extensible-exceptions-prof = " \
 ghc-base-prof \
 ghc-extensible-exceptions-devel \
 "
