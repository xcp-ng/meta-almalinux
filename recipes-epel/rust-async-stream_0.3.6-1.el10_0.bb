# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-stream"
PV = "0.3.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-async-stream+default-devel \
 rust-async-stream-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-stream-0.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1fe1808820a13b9c6f1f66a2e4d75c98e6a0a58e3ea3f2770a79f3316487edb4"

URI_x86_64_v2_rust-async-stream+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-stream+default-devel-0.3.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-stream+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-stream+default-devel}"
SRC_URI[x86_64_v2_rust-async-stream+default-devel.sha256sum] = "ac0a9ef0069066dc03378e4fec5413211c211f481cdff606878e7324602d6768"

URI_x86_64_v2_rust-async-stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-stream-devel-0.3.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-stream-devel}"
SRC_URI[x86_64_v2_rust-async-stream-devel.sha256sum] = "33c011e8c95135bfe196f2ffe444f8ea29a2b37d9ea51af430a8f649355ce4c6"

URI_aarch64_rust-async-stream+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-stream+default-devel-0.3.6-1.el10_0.noarch.rpm;name=aarch64_rust-async-stream+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-stream+default-devel}"
SRC_URI[aarch64_rust-async-stream+default-devel.sha256sum] = "2a9028cebf16bb8e62a1df4fc0850a2aad561bed6f834d937d956200d2a6526c"

URI_aarch64_rust-async-stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-stream-devel-0.3.6-1.el10_0.noarch.rpm;name=aarch64_rust-async-stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-stream-devel}"
SRC_URI[aarch64_rust-async-stream-devel.sha256sum] = "651d0ea3a02359a00eb438dc66745c0542d729026db1da539637947906ee8bdc"

RDEPENDS:rust-async-stream+default-devel = " \
 cargo \
 rust-async-stream-devel \
 "
RDEPENDS:rust-async-stream-devel = " \
 cargo \
 rust \
 rust-async-stream-impl+default-devel \
 rust-futures-core+default-devel \
 rust-pin-project-lite+default-devel \
 "
