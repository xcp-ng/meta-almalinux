# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-deranged"
PV = "0.4.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-deranged+alloc-devel \
 rust-deranged+default-devel \
 rust-deranged+num-devel \
 rust-deranged+powerfmt-devel \
 rust-deranged+quickcheck-devel \
 rust-deranged+rand-devel \
 rust-deranged+rand08-devel \
 rust-deranged+rand09-devel \
 rust-deranged+serde-devel \
 rust-deranged+std-devel \
 rust-deranged-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-deranged-0.4.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c823a7c4e1180a554423396ce0a41d4d716baa0b19d4d7629a8bf986f03fbd8f"

URI_x86_64_v2_rust-deranged+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+alloc-devel-0.4.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+alloc-devel}"
SRC_URI[x86_64_v2_rust-deranged+alloc-devel.sha256sum] = "53a9ee03ee7263b4a8666e678b039b12e3a10b7585d0c2ba4d591aaf05461565"

URI_x86_64_v2_rust-deranged+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+default-devel-0.4.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+default-devel}"
SRC_URI[x86_64_v2_rust-deranged+default-devel.sha256sum] = "50f32a97796f2c897bfd1ef0a64b4c7a583a509950897cc39d0d71a121717812"

URI_x86_64_v2_rust-deranged+num-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+num-devel-0.4.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+num-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+num-devel}"
SRC_URI[x86_64_v2_rust-deranged+num-devel.sha256sum] = "f453bbe620532f8058ecc8d2e06332c45e49c1a77d0fe237624c53ec71da2581"

URI_x86_64_v2_rust-deranged+powerfmt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+powerfmt-devel-0.4.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+powerfmt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+powerfmt-devel}"
SRC_URI[x86_64_v2_rust-deranged+powerfmt-devel.sha256sum] = "b68f74d8c30655de97b5c77ddf580a5630afac8d73ca7e632431bdae0b3a4a32"

URI_x86_64_v2_rust-deranged+quickcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+quickcheck-devel-0.4.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+quickcheck-devel}"
SRC_URI[x86_64_v2_rust-deranged+quickcheck-devel.sha256sum] = "fa6337b8f5bf0ca51544c8a3e8992219519a9ab1fdded499611f2e3327ecadc6"

URI_x86_64_v2_rust-deranged+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+rand-devel-0.4.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+rand-devel}"
SRC_URI[x86_64_v2_rust-deranged+rand-devel.sha256sum] = "3bbc5b9411e5bea121010ee5c328a6a37fb29ac0746804b6991da00e4f48fa28"

URI_x86_64_v2_rust-deranged+rand08-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+rand08-devel-0.4.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+rand08-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+rand08-devel}"
SRC_URI[x86_64_v2_rust-deranged+rand08-devel.sha256sum] = "799d5afe164f822653e078832db411389598e6af134b4ded345dd5568cad652b"

URI_x86_64_v2_rust-deranged+rand09-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+rand09-devel-0.4.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+rand09-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+rand09-devel}"
SRC_URI[x86_64_v2_rust-deranged+rand09-devel.sha256sum] = "26ee94640643f1ebb58dec685a69286551c6720115874a100d016c851cf090f0"

URI_x86_64_v2_rust-deranged+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+serde-devel-0.4.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+serde-devel}"
SRC_URI[x86_64_v2_rust-deranged+serde-devel.sha256sum] = "19572ae78d457389ddea62191edac8f5b8f9edb3e6c7746ea82e6150dca2c5a5"

URI_x86_64_v2_rust-deranged+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+std-devel-0.4.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+std-devel}"
SRC_URI[x86_64_v2_rust-deranged+std-devel.sha256sum] = "e7d9be72e83301811ddf43ed4c08e69750ba40156c507f3bf452e0703c0773a2"

URI_x86_64_v2_rust-deranged-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged-devel-0.4.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged-devel}"
SRC_URI[x86_64_v2_rust-deranged-devel.sha256sum] = "0c3ad79fd898fd5e1fe9e2ad5993c43c652ee89b8c8e531c40e0da97554b8d49"

URI_aarch64_rust-deranged+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+alloc-devel-0.4.0-1.el10_0.noarch.rpm;name=aarch64_rust-deranged+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+alloc-devel}"
SRC_URI[aarch64_rust-deranged+alloc-devel.sha256sum] = "7d261b735c806c0da493bda1fcfa9958057635ff7784c9d844267c0c7a5f8dd8"

URI_aarch64_rust-deranged+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+default-devel-0.4.0-1.el10_0.noarch.rpm;name=aarch64_rust-deranged+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+default-devel}"
SRC_URI[aarch64_rust-deranged+default-devel.sha256sum] = "ea2d8877b7d2c2e2f45f1919f62f95484c60f7e25fb1b724c85b29996a40153f"

URI_aarch64_rust-deranged+num-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+num-devel-0.4.0-1.el10_0.noarch.rpm;name=aarch64_rust-deranged+num-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+num-devel}"
SRC_URI[aarch64_rust-deranged+num-devel.sha256sum] = "1348376adf2de336185df17f51c6243cc355d299d4164822078f5f7e7e1d6cbe"

URI_aarch64_rust-deranged+powerfmt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+powerfmt-devel-0.4.0-1.el10_0.noarch.rpm;name=aarch64_rust-deranged+powerfmt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+powerfmt-devel}"
SRC_URI[aarch64_rust-deranged+powerfmt-devel.sha256sum] = "72bda7dc25164b445f1db3f3f1c503d25582076e0aa2395ffec1f2c3560fef8a"

URI_aarch64_rust-deranged+quickcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+quickcheck-devel-0.4.0-1.el10_0.noarch.rpm;name=aarch64_rust-deranged+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+quickcheck-devel}"
SRC_URI[aarch64_rust-deranged+quickcheck-devel.sha256sum] = "e434294b50bc508edc3552664d172d92eb2713232a122bf9a3b8106b8343bb88"

URI_aarch64_rust-deranged+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+rand-devel-0.4.0-1.el10_0.noarch.rpm;name=aarch64_rust-deranged+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+rand-devel}"
SRC_URI[aarch64_rust-deranged+rand-devel.sha256sum] = "d2d55ad1b1be69f0f97ed4dfd700f9eb12afec7e207cac661d8b169693b39458"

URI_aarch64_rust-deranged+rand08-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+rand08-devel-0.4.0-1.el10_0.noarch.rpm;name=aarch64_rust-deranged+rand08-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+rand08-devel}"
SRC_URI[aarch64_rust-deranged+rand08-devel.sha256sum] = "ecf9278ff610c0a05c23d97709a4a82e4e34b70ff725a5fabcf4a42fc0bccd36"

URI_aarch64_rust-deranged+rand09-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+rand09-devel-0.4.0-1.el10_0.noarch.rpm;name=aarch64_rust-deranged+rand09-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+rand09-devel}"
SRC_URI[aarch64_rust-deranged+rand09-devel.sha256sum] = "e439edc977f209db648dde40068aca67dc462c93ec0004f9d32f9659cf255789"

URI_aarch64_rust-deranged+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+serde-devel-0.4.0-1.el10_0.noarch.rpm;name=aarch64_rust-deranged+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+serde-devel}"
SRC_URI[aarch64_rust-deranged+serde-devel.sha256sum] = "dadc7c97e774fec8f43806e042a4fa99ecb3ea8ffbd24b7a7e952c9be2005fb8"

URI_aarch64_rust-deranged+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+std-devel-0.4.0-1.el10_0.noarch.rpm;name=aarch64_rust-deranged+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+std-devel}"
SRC_URI[aarch64_rust-deranged+std-devel.sha256sum] = "cc7bb3aefb2943804efd26e334295ce90449332f6940781783a1bca93e0efce7"

URI_aarch64_rust-deranged-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged-devel-0.4.0-1.el10_0.noarch.rpm;name=aarch64_rust-deranged-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged-devel}"
SRC_URI[aarch64_rust-deranged-devel.sha256sum] = "eadf9d8923587f477478a5c5ba2e788b872b4ede950b4e066126357bf8bc3a39"

RDEPENDS:rust-deranged+alloc-devel = " \
 cargo \
 rust-deranged-devel \
 "
RDEPENDS:rust-deranged+default-devel = " \
 cargo \
 rust-deranged+std-devel \
 rust-deranged-devel \
 "
RDEPENDS:rust-deranged+num-devel = " \
 cargo \
 rust-deranged-devel \
 rust-num-traits-devel \
 "
RDEPENDS:rust-deranged+powerfmt-devel = " \
 cargo \
 rust-deranged-devel \
 rust-powerfmt-devel \
 "
RDEPENDS:rust-deranged+quickcheck-devel = " \
 cargo \
 rust-deranged+alloc-devel \
 rust-deranged-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-deranged+rand-devel = " \
 cargo \
 rust-deranged+rand08-devel \
 rust-deranged+rand09-devel \
 rust-deranged-devel \
 "
RDEPENDS:rust-deranged+rand08-devel = " \
 cargo \
 rust-deranged-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-deranged+rand09-devel = " \
 cargo \
 rust-deranged-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-deranged+serde-devel = " \
 cargo \
 rust-deranged-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-deranged+std-devel = " \
 cargo \
 rust-deranged+alloc-devel \
 rust-deranged-devel \
 "
RDEPENDS:rust-deranged-devel = " \
 cargo \
 rust \
 "
