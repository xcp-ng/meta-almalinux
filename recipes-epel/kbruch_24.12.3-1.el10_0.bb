# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kbruch"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kbruch \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kbruch-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8207b3902ff1f5d249c292365afb2571669821e3d6e66495ae7c5414c58a4ad8"

URI_x86_64_v2_kbruch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kbruch-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kbruch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kbruch}"
SRC_URI[x86_64_v2_kbruch.sha256sum] = "402ccb197bb9877bad5fc132a571c8b8707ed36cfe0b90cfacd5216cf9a0ca84"

URI_aarch64_kbruch = "${EPEL_MIRROR}/aarch64/Packages/k/kbruch-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kbruch;unpack=0"
SRC_URI:append = " ${URI_aarch64_kbruch}"
SRC_URI[aarch64_kbruch.sha256sum] = "4fd1a41de29d890f20a3b8593d45e4377d84b6cd55e3f9f2129299413056f1cf"

RDEPENDS:kbruch = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
