# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cargo2rpm"
PV = "0.3.3"
PR = "1.el10_3"
PACKAGES = " \
 cargo2rpm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cargo2rpm-0.3.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9019e9aeba7551095614dc0105fc6d40a1a969170f400219dac3a61f06dee7ac"

URI_x86_64_v2_cargo2rpm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cargo2rpm-0.3.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_cargo2rpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cargo2rpm}"
SRC_URI[x86_64_v2_cargo2rpm.sha256sum] = "f47e752c11ae1d3e7a3c21b3d2b1ac865a37699be9eb67c9ce66bbc8cdfb491c"

URI_aarch64_cargo2rpm = "${EPEL_MIRROR}/aarch64/Packages/c/cargo2rpm-0.3.3-1.el10_3.noarch.rpm;name=aarch64_cargo2rpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_cargo2rpm}"
SRC_URI[aarch64_cargo2rpm.sha256sum] = "b0dc2e7f2dce02b31e63e3e8bdd97e8628aac7f246d84b2782b6cd6b92da27c3"

RDEPENDS:cargo2rpm = " \
 cargo \
 python3 \
 "
