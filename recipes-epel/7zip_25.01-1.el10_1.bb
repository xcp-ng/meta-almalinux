# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "7zip"
PV = "25.01"
PR = "1.el10_1"
PACKAGES = " \
 7zip \
 7zip-reduced \
 7zip-standalone \
 7zip-standalone-all \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/7/7zip-25.01-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a89ef5add16b1752aca7342a22434f9750264cd7a47b3af86199a82b2a5370cf"

URI_x86_64_v2_7zip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/7zip-25.01-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_7zip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_7zip}"
SRC_URI[x86_64_v2_7zip.sha256sum] = "3e57d0a665432d8df0e69e78f719d0b0ec3ae76f1d94a1fe436a87bcda2daf26"

URI_x86_64_v2_7zip-reduced = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/7zip-reduced-25.01-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_7zip-reduced;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_7zip-reduced}"
SRC_URI[x86_64_v2_7zip-reduced.sha256sum] = "b5f5e4986328a98e770706a6a965b194cab5f027347df29d9ecce2601ed8478b"

URI_x86_64_v2_7zip-standalone = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/7zip-standalone-25.01-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_7zip-standalone;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_7zip-standalone}"
SRC_URI[x86_64_v2_7zip-standalone.sha256sum] = "3ebf81f5028b2909054842853203179ea09f35458cb1ecedbfd029fe407ea90a"

URI_x86_64_v2_7zip-standalone-all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/7zip-standalone-all-25.01-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_7zip-standalone-all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_7zip-standalone-all}"
SRC_URI[x86_64_v2_7zip-standalone-all.sha256sum] = "0d2a35a544b66e70974e592bfda9de72bf7cfce98a0c4cdbc689db71195cebea"

URI_aarch64_7zip = "${EPEL_MIRROR}/aarch64/Packages/7/7zip-25.01-1.el10_1.aarch64.rpm;name=aarch64_7zip;unpack=0"
SRC_URI:append = " ${URI_aarch64_7zip}"
SRC_URI[aarch64_7zip.sha256sum] = "c4a915bec9717c859725a101993929866c2273b0805541ce729b2bf0082cac96"

URI_aarch64_7zip-reduced = "${EPEL_MIRROR}/aarch64/Packages/7/7zip-reduced-25.01-1.el10_1.aarch64.rpm;name=aarch64_7zip-reduced;unpack=0"
SRC_URI:append = " ${URI_aarch64_7zip-reduced}"
SRC_URI[aarch64_7zip-reduced.sha256sum] = "5de79aa6c87b768f1548c1b1add2e04a9abc47df4ba7c32fa83ef5e0f00f9b35"

URI_aarch64_7zip-standalone = "${EPEL_MIRROR}/aarch64/Packages/7/7zip-standalone-25.01-1.el10_1.aarch64.rpm;name=aarch64_7zip-standalone;unpack=0"
SRC_URI:append = " ${URI_aarch64_7zip-standalone}"
SRC_URI[aarch64_7zip-standalone.sha256sum] = "54cb3796736db1898dba43226b126fb8899d3f6fede7ae6dfd5a6378dcc2f442"

URI_aarch64_7zip-standalone-all = "${EPEL_MIRROR}/aarch64/Packages/7/7zip-standalone-all-25.01-1.el10_1.aarch64.rpm;name=aarch64_7zip-standalone-all;unpack=0"
SRC_URI:append = " ${URI_aarch64_7zip-standalone-all}"
SRC_URI[aarch64_7zip-standalone-all.sha256sum] = "7a2035055e9d2e2b36a4f2cb8f28a2c23999d4dc36169271beadf2a6c119d9e5"

RDEPENDS:7zip = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:7zip-reduced = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:7zip-standalone = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:7zip-standalone-all = " \
 glibc \
 libgcc \
 libstdc++ \
 "
