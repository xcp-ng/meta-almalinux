# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ruby4.0"
PV = "4.0.6"
PR = "37.el10_2"
PACKAGES = " \
 ruby4.0 \
 ruby4.0-devel \
 ruby4.0-doc \
 ruby4.0-rubygem-mysql2 \
 ruby4.0-rubygem-pg \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ruby4.0-4.0.6-37.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ccfd2ccea6343d1005b97e93f61febc877517ae2a378fad6df3dd2954b0c8c7f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby4.0-4.0.6-37.el10_2.x86_64_v2.rpm;name=x86_64_v2_ruby4.0;unpack=0"
SRC_URI[x86_64_v2_ruby4.0.sha256sum] = "3d458b9709e40fe8e47b54fb44f7bb2114f3367208ccce8b9d26507f614a0108"
RPROVIDES:ruby4.0:append:x86_64_v2 = " virtual/ruby_release_ virtual/ruby_runtime_executable_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby4.0-devel-4.0.6-37.el10_2.x86_64_v2.rpm;name=x86_64_v2_ruby4.0-devel;unpack=0"
SRC_URI[x86_64_v2_ruby4.0-devel.sha256sum] = "9a0ea607f1c54aaf231b238a560c275092db1ca678ab4dcc8f0c47f50824a121"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ruby4.0-doc-4.0.6-37.el10_2.noarch.rpm;name=x86_64_v2_ruby4.0-doc;unpack=0"
SRC_URI[x86_64_v2_ruby4.0-doc.sha256sum] = "52f1f690f25bf615ba7af684613c10e16165f150e3282b36f84909b5c8c9f9e4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby4.0-rubygem-mysql2-0.5.7-37.el10_2.x86_64_v2.rpm;name=x86_64_v2_ruby4.0-rubygem-mysql2;unpack=0"
SRC_URI[x86_64_v2_ruby4.0-rubygem-mysql2.sha256sum] = "c2ff4fc0394d987353454108864d09572d9ce2278a1fdd3903126c318bb7d451"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby4.0-rubygem-pg-1.6.3-37.el10_2.x86_64_v2.rpm;name=x86_64_v2_ruby4.0-rubygem-pg;unpack=0"
SRC_URI[x86_64_v2_ruby4.0-rubygem-pg.sha256sum] = "1ca616ba217cfe8dec58d4cc661cba77231a4361338cc1eb75139f7ba4fb47c9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby4.0-4.0.6-37.el10_2.aarch64.rpm;name=aarch64_ruby4.0;unpack=0"
SRC_URI[aarch64_ruby4.0.sha256sum] = "c7d621deba66b6c408689fa2c259d8dfa952f7d730463d8d64ed1b23998425e2"
RPROVIDES:ruby4.0:append:aarch64 = " virtual/ruby_release_ virtual/ruby_runtime_executable_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby4.0-devel-4.0.6-37.el10_2.aarch64.rpm;name=aarch64_ruby4.0-devel;unpack=0"
SRC_URI[aarch64_ruby4.0-devel.sha256sum] = "0df4d0529a9013cb23ea18a31e90e588268d018f1db4b88168c64180d9b45fd6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ruby4.0-doc-4.0.6-37.el10_2.noarch.rpm;name=aarch64_ruby4.0-doc;unpack=0"
SRC_URI[aarch64_ruby4.0-doc.sha256sum] = "52f1f690f25bf615ba7af684613c10e16165f150e3282b36f84909b5c8c9f9e4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby4.0-rubygem-mysql2-0.5.7-37.el10_2.aarch64.rpm;name=aarch64_ruby4.0-rubygem-mysql2;unpack=0"
SRC_URI[aarch64_ruby4.0-rubygem-mysql2.sha256sum] = "a40933b26e5ac193492c532de8215a50ceb8b745a6f9cad5f2094120e67c38f3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby4.0-rubygem-pg-1.6.3-37.el10_2.aarch64.rpm;name=aarch64_ruby4.0-rubygem-pg;unpack=0"
SRC_URI[aarch64_ruby4.0-rubygem-pg.sha256sum] = "d3b3df7c7e0e8d15eba750e8d25c727347b23a71e170264c8dc5110ba39b90f4"

RDEPENDS:ruby4.0 = " \
 glibc \
 gmp \
 libffi \
 libgcc \
 libxcrypt \
 libyaml \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:ruby4.0-devel = " \
 pkgconf-pkg-config \
 ruby4.0 \
 "
RDEPENDS:ruby4.0-doc = " \
 ruby4.0 \
 "
RDEPENDS:ruby4.0-rubygem-mysql2 = " \
 glibc \
 mariadb-connector-c \
 ruby4.0 \
 "
RDEPENDS:ruby4.0-rubygem-pg = " \
 glibc \
 libpq \
 ruby4.0 \
 "
