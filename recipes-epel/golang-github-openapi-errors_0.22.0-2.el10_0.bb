# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-openapi-errors"
PV = "0.22.0"
PR = "2.el10_0"
PACKAGES = " \
 golang-github-openapi-errors-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-openapi-errors-0.22.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe17563ca0af64732fb6e386e9b02b7dafce97a77bf4f3e276e51d9d299dd55b"

URI_x86_64_v2_golang-github-openapi-errors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-openapi-errors-devel-0.22.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-openapi-errors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-openapi-errors-devel}"
SRC_URI[x86_64_v2_golang-github-openapi-errors-devel.sha256sum] = "35b7878f6f164d86661defb24c72dd57ac605b502653abef2dac50683a17fc0c"

URI_aarch64_golang-github-openapi-errors-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-openapi-errors-devel-0.22.0-2.el10_0.noarch.rpm;name=aarch64_golang-github-openapi-errors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-openapi-errors-devel}"
SRC_URI[aarch64_golang-github-openapi-errors-devel.sha256sum] = "1c8f77493f3733da507a8d3c57b34b6ba4a68f8e696b209cbe325f53282ee9a7"

RDEPENDS:golang-github-openapi-errors-devel = " \
 go-filesystem \
 "
