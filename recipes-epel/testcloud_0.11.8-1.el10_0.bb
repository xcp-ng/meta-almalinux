# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "testcloud"
PV = "0.11.8"
PR = "1.el10_0"
PACKAGES = " \
 python3-testcloud \
 testcloud \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/testcloud-0.11.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "77e82d43accc90bf8e326a6093401a938bbee8abbc673841d849a36f68e6b799"

URI_x86_64_v2_python3-testcloud = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-testcloud-0.11.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-testcloud;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-testcloud}"
SRC_URI[x86_64_v2_python3-testcloud.sha256sum] = "dfcd09eeb37b6514d1ef925a98724eb5fb6b9986865f19008d728e45c117b9a4"

URI_x86_64_v2_testcloud = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/testcloud-0.11.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_testcloud;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_testcloud}"
SRC_URI[x86_64_v2_testcloud.sha256sum] = "226553b071a9e8a6ce7936428ffe4366466ece270730d158a2997b768c956a72"

URI_aarch64_python3-testcloud = "${EPEL_MIRROR}/aarch64/Packages/p/python3-testcloud-0.11.8-1.el10_0.noarch.rpm;name=aarch64_python3-testcloud;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-testcloud}"
SRC_URI[aarch64_python3-testcloud.sha256sum] = "eb8bc99e2af486d16a31adbeb9d4b6bc2cfc130a94961e7b990af687631f70bf"

URI_aarch64_testcloud = "${EPEL_MIRROR}/aarch64/Packages/t/testcloud-0.11.8-1.el10_0.noarch.rpm;name=aarch64_testcloud;unpack=0"
SRC_URI:append = " ${URI_aarch64_testcloud}"
SRC_URI[aarch64_testcloud.sha256sum] = "95198b48bed78910cf3edbd67114cd97044700bdcc1b03f6d4b1435ef301d479"

RDEPENDS:python3-testcloud = " \
 acl \
 genisoimage \
 libvirt-daemon \
 libvirt-daemon-config-network \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-storage-core \
 python3 \
 python3-libvirt \
 python3-packaging \
 python3-peewee \
 python3-requests \
 "
RDEPENDS:testcloud = " \
 bash \
 polkit \
 python3 \
 python3-testcloud \
 shadow-utils \
 "
