# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "highlight"
PV = "4.20"
PR = "3.el10_2"
PACKAGES = " \
 highlight \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/highlight-4.20-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "94638cf9f39cee1e53194f9936414d5e579e22f369628172557fb39b06d1173a"

URI_x86_64_v2_highlight = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/highlight-4.20-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_highlight;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_highlight}"
SRC_URI[x86_64_v2_highlight.sha256sum] = "aba4ae682d13dd50d35a0cfc5c682977e5d33c61c55c25a64c43c08384e36a6e"

URI_aarch64_highlight = "${EPEL_MIRROR}/aarch64/Packages/h/highlight-4.20-3.el10_2.aarch64.rpm;name=aarch64_highlight;unpack=0"
SRC_URI:append = " ${URI_aarch64_highlight}"
SRC_URI[aarch64_highlight.sha256sum] = "ddc166e1a06a6b45a6827bddb93709b07adeb012f7d8f648c67835eadb172a6c"

RDEPENDS:highlight = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 lua-libs \
 "
