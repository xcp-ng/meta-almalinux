# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-js-chart"
PV = "2.9.4.1"
PR = "6.el10_0"
PACKAGES = " \
 ghc-js-chart \
 ghc-js-chart-data \
 ghc-js-chart-devel \
 ghc-js-chart-doc \
 ghc-js-chart-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-js-chart-2.9.4.1-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c39403bc0b783ab13b6dd7fd22f2f674ded769db9e650809099134388a16cc60"

URI_x86_64_v2_ghc-js-chart = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-js-chart-2.9.4.1-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-js-chart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-js-chart}"
SRC_URI[x86_64_v2_ghc-js-chart.sha256sum] = "0a9976111e132c915db6bbfb32b4e4c597c54bc879a3de4347c869550042d885"

URI_x86_64_v2_ghc-js-chart-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-js-chart-data-2.9.4.1-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-js-chart-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-js-chart-data}"
SRC_URI[x86_64_v2_ghc-js-chart-data.sha256sum] = "ed18e62cba5a1e62234d1c22bd2277fbe5851d66c5229aebb334c9a98a747460"

URI_x86_64_v2_ghc-js-chart-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-js-chart-devel-2.9.4.1-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-js-chart-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-js-chart-devel}"
SRC_URI[x86_64_v2_ghc-js-chart-devel.sha256sum] = "90abf028001f263b8d0f780aaee44eac313322fdf5e21ce4dabe5455390eea37"

URI_x86_64_v2_ghc-js-chart-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-js-chart-doc-2.9.4.1-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-js-chart-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-js-chart-doc}"
SRC_URI[x86_64_v2_ghc-js-chart-doc.sha256sum] = "665755d9666237bff48150e375f68ca41e0daec60553790bb817e3034f08627e"

URI_x86_64_v2_ghc-js-chart-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-js-chart-prof-2.9.4.1-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-js-chart-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-js-chart-prof}"
SRC_URI[x86_64_v2_ghc-js-chart-prof.sha256sum] = "dff1206dae7f0311c6e987643b74b9dc4e8617f006695f56586bcd0b48dafdcd"

URI_aarch64_ghc-js-chart = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-js-chart-2.9.4.1-6.el10_0.aarch64.rpm;name=aarch64_ghc-js-chart;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-js-chart}"
SRC_URI[aarch64_ghc-js-chart.sha256sum] = "fdf86b360d40c5c574766402a2f54bbcfa9eee178f3af71d8680deebdd6217f0"

URI_aarch64_ghc-js-chart-data = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-js-chart-data-2.9.4.1-6.el10_0.noarch.rpm;name=aarch64_ghc-js-chart-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-js-chart-data}"
SRC_URI[aarch64_ghc-js-chart-data.sha256sum] = "d9abcbf19be01386828b26135df7500b859ea96a3a292890a85b238cc0b66c59"

URI_aarch64_ghc-js-chart-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-js-chart-devel-2.9.4.1-6.el10_0.aarch64.rpm;name=aarch64_ghc-js-chart-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-js-chart-devel}"
SRC_URI[aarch64_ghc-js-chart-devel.sha256sum] = "d55111c32a7a06a46bf64e1d0aefab96bc47fad6be29a9396781f23d8680bfab"

URI_aarch64_ghc-js-chart-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-js-chart-doc-2.9.4.1-6.el10_0.noarch.rpm;name=aarch64_ghc-js-chart-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-js-chart-doc}"
SRC_URI[aarch64_ghc-js-chart-doc.sha256sum] = "1c70c8922a59fb2d69db89ba8bdd210ff4b76f87aaff101bd15c3bfd57a3b939"

URI_aarch64_ghc-js-chart-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-js-chart-prof-2.9.4.1-6.el10_0.aarch64.rpm;name=aarch64_ghc-js-chart-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-js-chart-prof}"
SRC_URI[aarch64_ghc-js-chart-prof.sha256sum] = "0a29e8312ca5ce35bc2e1f5675d44c5cdefa5d47c12def72730c9f70ba3de83e"

RDEPENDS:ghc-js-chart = " \
 ghc-base \
 ghc-ghc-bignum \
 ghc-js-chart-data \
 glibc \
 gmp \
 "
RDEPENDS:ghc-js-chart-data = " \
 "
RDEPENDS:ghc-js-chart-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-js-chart \
 "
RDEPENDS:ghc-js-chart-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-js-chart-prof = " \
 ghc-base-prof \
 ghc-js-chart-devel \
 "
