# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-akutz-gosync"
PV = "0.1.0"
PR = "6.el10_0"
PACKAGES = " \
 golang-github-akutz-gosync-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-akutz-gosync-0.1.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d7830049fcc2e57717cc9ce59024c65dba452ae0ae0e7f3a6046e4a7c7169ebf"

URI_x86_64_v2_golang-github-akutz-gosync-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-akutz-gosync-devel-0.1.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-akutz-gosync-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-akutz-gosync-devel}"
SRC_URI[x86_64_v2_golang-github-akutz-gosync-devel.sha256sum] = "59c5b954284bf4f09e144337100c6707e79f9b16d73c16001c579af8dc612d6e"

URI_aarch64_golang-github-akutz-gosync-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-akutz-gosync-devel-0.1.0-6.el10_0.noarch.rpm;name=aarch64_golang-github-akutz-gosync-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-akutz-gosync-devel}"
SRC_URI[aarch64_golang-github-akutz-gosync-devel.sha256sum] = "22e75cd94fbd516560ab8c413c86035cb5699edde146f20a5a9ddd582ef4a01a"

RDEPENDS:golang-github-akutz-gosync-devel = " \
 go-filesystem \
 "
