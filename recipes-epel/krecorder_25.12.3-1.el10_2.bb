# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "krecorder"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 krecorder \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/krecorder-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "77f4aef9e0ccd06fc8b083e3ca7af897962e7e6baf1f8655de5a8c0f702abb79"

URI_x86_64_v2_krecorder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krecorder-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krecorder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krecorder}"
SRC_URI[x86_64_v2_krecorder.sha256sum] = "5960d9b5b333f9d8b54ebf905864211014042cf7f93df5dac2048d5b02631b9c"

URI_aarch64_krecorder = "${EPEL_MIRROR}/aarch64/Packages/k/krecorder-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_krecorder;unpack=0"
SRC_URI:append = " ${URI_aarch64_krecorder}"
SRC_URI[aarch64_krecorder.sha256sum] = "4f0d68e423b47c0d82d63bf94c3f67026a80e883a4de234ec3e78e6847ba3e64"

RDEPENDS:krecorder = " \
 glibc \
 gstreamer1-plugins-good \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
