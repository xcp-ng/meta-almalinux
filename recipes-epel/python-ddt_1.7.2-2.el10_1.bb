# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ddt"
PV = "1.7.2"
PR = "2.el10_1"
PACKAGES = " \
 python3-ddt \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-ddt-1.7.2-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a39c64b60f4ff9fb68841242a53fe53758989ffbcf857d8f2df020f0aeb33d59"

URI_x86_64_v2_python3-ddt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ddt-1.7.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ddt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ddt}"
SRC_URI[x86_64_v2_python3-ddt.sha256sum] = "1abeb9072474186d96045e212244a296ad637d19cadbe9c70cf227277a5d78ff"

URI_aarch64_python3-ddt = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ddt-1.7.2-2.el10_1.noarch.rpm;name=aarch64_python3-ddt;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ddt}"
SRC_URI[aarch64_python3-ddt.sha256sum] = "01d0349cdafe73d48f2cb88a5294f42c0be04eefa0fc6cc2ba0caf5f17e1f724"

RDEPENDS:python3-ddt = " \
 python3 \
 "
