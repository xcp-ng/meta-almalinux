# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bluedevil"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 bluedevil \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bluedevil-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "40ef1ab973a327dc32c3b2754621ee186e647408b891bd761cc0d6908dcd7b1d"

URI_x86_64_v2_bluedevil = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluedevil-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bluedevil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluedevil}"
SRC_URI[x86_64_v2_bluedevil.sha256sum] = "e371255bdd4d63773836cd486f5c5befa0ffe54ddce3bf869bf0c488b6824307"

URI_aarch64_bluedevil = "${EPEL_MIRROR}/aarch64/Packages/b/bluedevil-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_bluedevil;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluedevil}"
SRC_URI[aarch64_bluedevil.sha256sum] = "2cd3d680529c4335b06304ea841c1837857bf9cef89a8a2b251994c61b9f63fd"

RDEPENDS:bluedevil = " \
 bluez \
 bluez-obexd \
 glibc \
 kf6-bluez-qt \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kded \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libstdc++ \
 pipewire-pulseaudio \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
