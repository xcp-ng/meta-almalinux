# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Log-Dispatch-FileRotate"
PV = "1.38"
PR = "6.el10_0"
PACKAGES = " \
 perl-Log-Dispatch-FileRotate \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Log-Dispatch-FileRotate-1.38-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff082daa1f2ff97bb97607c569fa2f1236719a6fde29dcb8151593acf12811d7"

URI_x86_64_v2_perl-Log-Dispatch-FileRotate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Log-Dispatch-FileRotate-1.38-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Log-Dispatch-FileRotate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Log-Dispatch-FileRotate}"
SRC_URI[x86_64_v2_perl-Log-Dispatch-FileRotate.sha256sum] = "b1ebae7808ce00a40c19979ced233dafdd363edb2fcc10981d0aebcf7c03e25b"

URI_aarch64_perl-Log-Dispatch-FileRotate = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Log-Dispatch-FileRotate-1.38-6.el10_0.noarch.rpm;name=aarch64_perl-Log-Dispatch-FileRotate;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Log-Dispatch-FileRotate}"
SRC_URI[aarch64_perl-Log-Dispatch-FileRotate.sha256sum] = "67d7fa151accd86d5a7d752af8fb1f5e7867fc0109ed06bdd9740674673bd452"

RDEPENDS:perl-Log-Dispatch-FileRotate = " \
 perl-Carp \
 perl-Date-Manip \
 perl-Exporter \
 perl-Fcntl \
 perl-Log-Dispatch \
 perl-Log-Dispatch-FileRotate \
 perl-PathTools \
 perl-base \
 perl-libs \
 perl-version \
 "
