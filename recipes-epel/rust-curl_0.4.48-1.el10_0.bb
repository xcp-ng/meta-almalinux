# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-curl"
PV = "0.4.48"
PR = "1.el10_0"
PACKAGES = " \
 rust-curl+default-devel \
 rust-curl+http2-devel \
 rust-curl+ntlm-devel \
 rust-curl+openssl-probe-devel \
 rust-curl+openssl-sys-devel \
 rust-curl+poll_7_68_0-devel \
 rust-curl+protocol-ftp-devel \
 rust-curl+spnego-devel \
 rust-curl+ssl-devel \
 rust-curl+upkeep_7_62_0-devel \
 rust-curl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-curl-0.4.48-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8cf0695a093f6f650e60338d95bad159f442c8f82edf1dcbf4d104c6439cf57e"

URI_x86_64_v2_rust-curl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+default-devel-0.4.48-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+default-devel}"
SRC_URI[x86_64_v2_rust-curl+default-devel.sha256sum] = "a5a63fb3aa0bfd285378e5082acd729ada9c77142f4ccc9cf3093e8e5e6227a5"

URI_x86_64_v2_rust-curl+http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+http2-devel-0.4.48-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+http2-devel}"
SRC_URI[x86_64_v2_rust-curl+http2-devel.sha256sum] = "500f59ce47939b2d8bd9e1f5c79cc1ce4bb0a359dae26ccc753898dc30be862e"

URI_x86_64_v2_rust-curl+ntlm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+ntlm-devel-0.4.48-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+ntlm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+ntlm-devel}"
SRC_URI[x86_64_v2_rust-curl+ntlm-devel.sha256sum] = "bac736a3fcee9b2f6752c79b6e9d692f912b9c933301cd56c0625433153bf12e"

URI_x86_64_v2_rust-curl+openssl-probe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+openssl-probe-devel-0.4.48-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+openssl-probe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+openssl-probe-devel}"
SRC_URI[x86_64_v2_rust-curl+openssl-probe-devel.sha256sum] = "5608eb24c06e583d0e28f72fc6f3bf8e333cec1f072179d81fd557c157374b9f"

URI_x86_64_v2_rust-curl+openssl-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+openssl-sys-devel-0.4.48-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+openssl-sys-devel}"
SRC_URI[x86_64_v2_rust-curl+openssl-sys-devel.sha256sum] = "5700e071ab75798fca51672a48be8ae9bed361ceb5182f7c87a78a0f36837975"

URI_x86_64_v2_rust-curl+poll_7_68_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+poll_7_68_0-devel-0.4.48-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+poll_7_68_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+poll_7_68_0-devel}"
SRC_URI[x86_64_v2_rust-curl+poll_7_68_0-devel.sha256sum] = "7ada236d2f623ddf26ab47f96da5ce381a9c51711c892f1fc35d446ac9b20f3d"

URI_x86_64_v2_rust-curl+protocol-ftp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+protocol-ftp-devel-0.4.48-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+protocol-ftp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+protocol-ftp-devel}"
SRC_URI[x86_64_v2_rust-curl+protocol-ftp-devel.sha256sum] = "7ef9999b5d850fe06d1c729606eed6f99473dbb18cbfef972709ab2f644b90a8"

URI_x86_64_v2_rust-curl+spnego-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+spnego-devel-0.4.48-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+spnego-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+spnego-devel}"
SRC_URI[x86_64_v2_rust-curl+spnego-devel.sha256sum] = "a74a6699b253535315480a221077bbecef95edfd556d8eb7253ccbe89f97500e"

URI_x86_64_v2_rust-curl+ssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+ssl-devel-0.4.48-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+ssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+ssl-devel}"
SRC_URI[x86_64_v2_rust-curl+ssl-devel.sha256sum] = "a3db7dd2015f83c491fb22fb68a2fe8108683048554ef9b5e8a3c689a5434f54"

URI_x86_64_v2_rust-curl+upkeep_7_62_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+upkeep_7_62_0-devel-0.4.48-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+upkeep_7_62_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+upkeep_7_62_0-devel}"
SRC_URI[x86_64_v2_rust-curl+upkeep_7_62_0-devel.sha256sum] = "d8ae31b2243a1667cfecb9b13455721dae7a8dc8626cd2e6ab88984456ecd45c"

URI_x86_64_v2_rust-curl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-devel-0.4.48-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-devel}"
SRC_URI[x86_64_v2_rust-curl-devel.sha256sum] = "1e4253185b0ae4e2f4b80e93aedcbb7f0804b7b6f504ea9155fb274b19b84e51"

URI_aarch64_rust-curl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+default-devel-0.4.48-1.el10_0.noarch.rpm;name=aarch64_rust-curl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+default-devel}"
SRC_URI[aarch64_rust-curl+default-devel.sha256sum] = "b0344a5ff7e6220ed1f88f57a289652eca5565b6f05e9bf7823b04fed5df1e49"

URI_aarch64_rust-curl+http2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+http2-devel-0.4.48-1.el10_0.noarch.rpm;name=aarch64_rust-curl+http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+http2-devel}"
SRC_URI[aarch64_rust-curl+http2-devel.sha256sum] = "592f53632533180307e836912988266dd0908ba2e6a394803cd559c5ccc72b06"

URI_aarch64_rust-curl+ntlm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+ntlm-devel-0.4.48-1.el10_0.noarch.rpm;name=aarch64_rust-curl+ntlm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+ntlm-devel}"
SRC_URI[aarch64_rust-curl+ntlm-devel.sha256sum] = "e53092eea5083b0f757393fff33d5f4dc11ca252264da6ee665443494402ef2c"

URI_aarch64_rust-curl+openssl-probe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+openssl-probe-devel-0.4.48-1.el10_0.noarch.rpm;name=aarch64_rust-curl+openssl-probe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+openssl-probe-devel}"
SRC_URI[aarch64_rust-curl+openssl-probe-devel.sha256sum] = "af6fd2cbdd5792982f6c82fe21fa13d4938e5417549e39952c70a5503b76e9ac"

URI_aarch64_rust-curl+openssl-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+openssl-sys-devel-0.4.48-1.el10_0.noarch.rpm;name=aarch64_rust-curl+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+openssl-sys-devel}"
SRC_URI[aarch64_rust-curl+openssl-sys-devel.sha256sum] = "264a1941a8935cadbda42f65f6de20ce35ffc3e1385ace477af5e9e506c8e2b4"

URI_aarch64_rust-curl+poll_7_68_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+poll_7_68_0-devel-0.4.48-1.el10_0.noarch.rpm;name=aarch64_rust-curl+poll_7_68_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+poll_7_68_0-devel}"
SRC_URI[aarch64_rust-curl+poll_7_68_0-devel.sha256sum] = "82728ec184402a5d25bd4a6d9b632bb505c30196485ea234d1c45870bcb6a21d"

URI_aarch64_rust-curl+protocol-ftp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+protocol-ftp-devel-0.4.48-1.el10_0.noarch.rpm;name=aarch64_rust-curl+protocol-ftp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+protocol-ftp-devel}"
SRC_URI[aarch64_rust-curl+protocol-ftp-devel.sha256sum] = "ad505813f5e45a2191e362a86fb2fa795cce3f33bd5237f5fa4ef6190f0ae153"

URI_aarch64_rust-curl+spnego-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+spnego-devel-0.4.48-1.el10_0.noarch.rpm;name=aarch64_rust-curl+spnego-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+spnego-devel}"
SRC_URI[aarch64_rust-curl+spnego-devel.sha256sum] = "dff7d37d268cb87914216de957616de6c1c06656697e848c2fd29a2de2aefe86"

URI_aarch64_rust-curl+ssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+ssl-devel-0.4.48-1.el10_0.noarch.rpm;name=aarch64_rust-curl+ssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+ssl-devel}"
SRC_URI[aarch64_rust-curl+ssl-devel.sha256sum] = "1865ba12df92e2c04f93c05209073aa37b9828b27027607dc08bc202f92888c5"

URI_aarch64_rust-curl+upkeep_7_62_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+upkeep_7_62_0-devel-0.4.48-1.el10_0.noarch.rpm;name=aarch64_rust-curl+upkeep_7_62_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+upkeep_7_62_0-devel}"
SRC_URI[aarch64_rust-curl+upkeep_7_62_0-devel.sha256sum] = "a7b89d4206102dc34b554cad02910e855839a62279d9e05cce6167c5b5bbee2d"

URI_aarch64_rust-curl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-devel-0.4.48-1.el10_0.noarch.rpm;name=aarch64_rust-curl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-devel}"
SRC_URI[aarch64_rust-curl-devel.sha256sum] = "78221306901345c50b6e22146f85ae0a15201f3b1202a753ee327554225573a4"

RDEPENDS:rust-curl+default-devel = " \
 cargo \
 rust-curl+ssl-devel \
 rust-curl-devel \
 "
RDEPENDS:rust-curl+http2-devel = " \
 cargo \
 rust-curl-devel \
 rust-curl-sys+http2-devel \
 "
RDEPENDS:rust-curl+ntlm-devel = " \
 cargo \
 rust-curl-devel \
 rust-curl-sys+ntlm-devel \
 "
RDEPENDS:rust-curl+openssl-probe-devel = " \
 cargo \
 rust-curl-devel \
 rust-openssl-probe+default-devel \
 "
RDEPENDS:rust-curl+openssl-sys-devel = " \
 cargo \
 rust-curl-devel \
 rust-openssl-sys+default-devel \
 "
RDEPENDS:rust-curl+poll_7_68_0-devel = " \
 cargo \
 rust-curl-devel \
 rust-curl-sys+poll_7_68_0-devel \
 "
RDEPENDS:rust-curl+protocol-ftp-devel = " \
 cargo \
 rust-curl-devel \
 rust-curl-sys+protocol-ftp-devel \
 "
RDEPENDS:rust-curl+spnego-devel = " \
 cargo \
 rust-curl-devel \
 rust-curl-sys+spnego-devel \
 "
RDEPENDS:rust-curl+ssl-devel = " \
 cargo \
 rust-curl+openssl-probe-devel \
 rust-curl+openssl-sys-devel \
 rust-curl-devel \
 rust-curl-sys+ssl-devel \
 "
RDEPENDS:rust-curl+upkeep_7_62_0-devel = " \
 cargo \
 rust-curl-devel \
 rust-curl-sys+upkeep_7_62_0-devel \
 "
RDEPENDS:rust-curl-devel = " \
 cargo \
 rust-curl-sys-devel \
 rust-libc+default-devel \
 rust-socket2+default-devel \
 "
