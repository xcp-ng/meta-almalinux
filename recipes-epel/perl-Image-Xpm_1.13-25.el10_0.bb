# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Image-Xpm"
PV = "1.13"
PR = "25.el10_0"
PACKAGES = " \
 perl-Image-Xpm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Image-Xpm-1.13-25.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe9947eae3f460ce01591e18ee4eaf2618550e195ec3b3d3a1c727547e12b460"

URI_x86_64_v2_perl-Image-Xpm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Image-Xpm-1.13-25.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Image-Xpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Image-Xpm}"
SRC_URI[x86_64_v2_perl-Image-Xpm.sha256sum] = "7e64da5ece22f5d6a16760f5c8a720366e7ff2a4a762e8ae27d92222270603a4"

URI_aarch64_perl-Image-Xpm = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Image-Xpm-1.13-25.el10_0.noarch.rpm;name=aarch64_perl-Image-Xpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Image-Xpm}"
SRC_URI[aarch64_perl-Image-Xpm.sha256sum] = "de3dcf81b7e530ac59cb51978bd04c8beae61a31de9312524edff14d3d50e8ae"

RDEPENDS:perl-Image-Xpm = " \
 perl-Carp \
 perl-Image-Base \
 perl-Symbol \
 perl-libs \
 perl-vars \
 "
