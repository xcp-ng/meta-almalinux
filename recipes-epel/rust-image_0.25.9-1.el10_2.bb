# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-image"
PV = "0.25.9"
PR = "1.el10_2"
PACKAGES = " \
 rust-image+avif-devel \
 rust-image+avif-native-devel \
 rust-image+bmp-devel \
 rust-image+color_quant-devel \
 rust-image+dds-devel \
 rust-image+default-devel \
 rust-image+default-formats-devel \
 rust-image+exr-devel \
 rust-image+ff-devel \
 rust-image+gif-devel \
 rust-image+hdr-devel \
 rust-image+ico-devel \
 rust-image+jpeg-devel \
 rust-image+nasm-devel \
 rust-image+png-devel \
 rust-image+pnm-devel \
 rust-image+qoi-devel \
 rust-image+rayon-devel \
 rust-image+serde-devel \
 rust-image+tga-devel \
 rust-image+tiff-devel \
 rust-image+webp-devel \
 rust-image-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-image-0.25.9-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "20b49ea70d324428a3a948f2aadefcebaa1eb38bdcac15bb98dcf33491653f23"

URI_x86_64_v2_rust-image+avif-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+avif-devel-0.25.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+avif-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+avif-devel}"
SRC_URI[x86_64_v2_rust-image+avif-devel.sha256sum] = "0bf93784f2175671541ef9313243232c564006513a5530e5cb40d75792f97bbc"

URI_x86_64_v2_rust-image+avif-native-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+avif-native-devel-0.25.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+avif-native-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+avif-native-devel}"
SRC_URI[x86_64_v2_rust-image+avif-native-devel.sha256sum] = "cc94f2bdd248c6325a85b3ee9766c831193abc3badc5024f99c35859a987279b"

URI_x86_64_v2_rust-image+bmp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+bmp-devel-0.25.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+bmp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+bmp-devel}"
SRC_URI[x86_64_v2_rust-image+bmp-devel.sha256sum] = "ef8cc47e8bbaaefc5ffc90f6c9afb7684bf8f08253c65732e3e800ef2a4a8ca9"

URI_x86_64_v2_rust-image+color_quant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+color_quant-devel-0.25.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+color_quant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+color_quant-devel}"
SRC_URI[x86_64_v2_rust-image+color_quant-devel.sha256sum] = "1709eec556d27469fd191a797a328ff202d2d292156f205590a4bd27072bc739"

URI_x86_64_v2_rust-image+dds-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+dds-devel-0.25.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+dds-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+dds-devel}"
SRC_URI[x86_64_v2_rust-image+dds-devel.sha256sum] = "75ebf5fcdf17f38ba7667c68f708c84b4590855245f947ee064fd50409f88b72"

URI_x86_64_v2_rust-image+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+default-devel-0.25.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+default-devel}"
SRC_URI[x86_64_v2_rust-image+default-devel.sha256sum] = "da14ecc92e8dc005cb4e425ef940eb0c6a0bef9ef86ac3612c2f22af95697174"

URI_x86_64_v2_rust-image+default-formats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+default-formats-devel-0.25.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+default-formats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+default-formats-devel}"
SRC_URI[x86_64_v2_rust-image+default-formats-devel.sha256sum] = "f7f3de6a238385a6f7a5a9a9b4275787d5d4ae344637cf76028ed66fa0c49089"

URI_x86_64_v2_rust-image+exr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+exr-devel-0.25.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+exr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+exr-devel}"
SRC_URI[x86_64_v2_rust-image+exr-devel.sha256sum] = "08fbdd2abd3dbf3c5f4bc6656a80deb9e6f387c0b58d06da11e419b7997a2446"

URI_x86_64_v2_rust-image+ff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+ff-devel-0.25.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+ff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+ff-devel}"
SRC_URI[x86_64_v2_rust-image+ff-devel.sha256sum] = "5cb9bae680544b7cd691a61178180fce1778a3a7c8716e727d632953f127e2e5"

URI_x86_64_v2_rust-image+gif-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+gif-devel-0.25.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+gif-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+gif-devel}"
SRC_URI[x86_64_v2_rust-image+gif-devel.sha256sum] = "9e0fbeeeb57bcc51d6b2abf037854b91eeea118d817b4a57251aa74607ec9b7a"

URI_x86_64_v2_rust-image+hdr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+hdr-devel-0.25.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+hdr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+hdr-devel}"
SRC_URI[x86_64_v2_rust-image+hdr-devel.sha256sum] = "68d5c3d86e3b35a2be0c995d295a047b769bb0f42d661e8f7524be0f3cd6ed1d"

URI_x86_64_v2_rust-image+ico-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+ico-devel-0.25.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+ico-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+ico-devel}"
SRC_URI[x86_64_v2_rust-image+ico-devel.sha256sum] = "d0b56a824af41ebf0246c68aaa410d1a005d20fe0f091789cfaa447a4ca1583b"

URI_x86_64_v2_rust-image+jpeg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+jpeg-devel-0.25.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+jpeg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+jpeg-devel}"
SRC_URI[x86_64_v2_rust-image+jpeg-devel.sha256sum] = "0842c647925c6d52b804221c5b56c3b725b6383fbe813c7fca77ac7bc39b2fef"

URI_x86_64_v2_rust-image+nasm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+nasm-devel-0.25.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+nasm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+nasm-devel}"
SRC_URI[x86_64_v2_rust-image+nasm-devel.sha256sum] = "fba0fc0629d07fafbbb19372292c824bea7320e6cb6efaca5b91cecba864e2b2"

URI_x86_64_v2_rust-image+png-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+png-devel-0.25.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+png-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+png-devel}"
SRC_URI[x86_64_v2_rust-image+png-devel.sha256sum] = "46cd8d24d75b1181a607bc41e2a6d1533fef9e6e94d0663bfaa17671ce960b38"

URI_x86_64_v2_rust-image+pnm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+pnm-devel-0.25.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+pnm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+pnm-devel}"
SRC_URI[x86_64_v2_rust-image+pnm-devel.sha256sum] = "74da6fc24b2d9a60718dac949cbe15df1a85651d0b22dac078021ab0be1255d2"

URI_x86_64_v2_rust-image+qoi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+qoi-devel-0.25.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+qoi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+qoi-devel}"
SRC_URI[x86_64_v2_rust-image+qoi-devel.sha256sum] = "38681b4caf8582603e9edf68c67b9dc63f6cb22bf5067d2dbc833b57bfbb9343"

URI_x86_64_v2_rust-image+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+rayon-devel-0.25.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+rayon-devel}"
SRC_URI[x86_64_v2_rust-image+rayon-devel.sha256sum] = "acb5509f7f1d7d2638224a2b68b89d1fd03febfdbd45b933036721f68d806208"

URI_x86_64_v2_rust-image+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+serde-devel-0.25.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+serde-devel}"
SRC_URI[x86_64_v2_rust-image+serde-devel.sha256sum] = "3bd323b401c78f46227140bae8f15b41a00af311068687448e820aa1cae87b27"

URI_x86_64_v2_rust-image+tga-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+tga-devel-0.25.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+tga-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+tga-devel}"
SRC_URI[x86_64_v2_rust-image+tga-devel.sha256sum] = "a9ac96ab58f003ca2eb8d516e7b94c2505c5d3cf7a99d484185c91c4eadfe9e2"

URI_x86_64_v2_rust-image+tiff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+tiff-devel-0.25.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+tiff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+tiff-devel}"
SRC_URI[x86_64_v2_rust-image+tiff-devel.sha256sum] = "1ed65585a370a0b19810fae5d27680f9fb4e98689dd0bc6391bee1fb7c94a7ab"

URI_x86_64_v2_rust-image+webp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+webp-devel-0.25.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+webp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+webp-devel}"
SRC_URI[x86_64_v2_rust-image+webp-devel.sha256sum] = "c11d871934ccd6627aa8b282c94ea398082c6115f679753576b734eaa0e41447"

URI_x86_64_v2_rust-image-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image-devel-0.25.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image-devel}"
SRC_URI[x86_64_v2_rust-image-devel.sha256sum] = "385ea1b00d6c8eed67b48404389767b0f48d27c38bec5ee5f345f814a6650176"

URI_aarch64_rust-image+avif-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+avif-devel-0.25.9-1.el10_2.noarch.rpm;name=aarch64_rust-image+avif-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+avif-devel}"
SRC_URI[aarch64_rust-image+avif-devel.sha256sum] = "299ed041de6eff42e2e53c1ae2fb5872af2f3673db825d58918123e47e9bed42"

URI_aarch64_rust-image+avif-native-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+avif-native-devel-0.25.9-1.el10_2.noarch.rpm;name=aarch64_rust-image+avif-native-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+avif-native-devel}"
SRC_URI[aarch64_rust-image+avif-native-devel.sha256sum] = "edf3ec45ee3481b02344fbe2ce689c463c4ac6ba73e079b74d815f9445b3e585"

URI_aarch64_rust-image+bmp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+bmp-devel-0.25.9-1.el10_2.noarch.rpm;name=aarch64_rust-image+bmp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+bmp-devel}"
SRC_URI[aarch64_rust-image+bmp-devel.sha256sum] = "002b639aeaf8d70b09f23058b27deedacfc2a8853068f4c624b8f1dc929221c1"

URI_aarch64_rust-image+color_quant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+color_quant-devel-0.25.9-1.el10_2.noarch.rpm;name=aarch64_rust-image+color_quant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+color_quant-devel}"
SRC_URI[aarch64_rust-image+color_quant-devel.sha256sum] = "313ff98496c2f180b76fbaf06dd81b2704b1d0a1ee5c42936e1bd2bb328b0375"

URI_aarch64_rust-image+dds-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+dds-devel-0.25.9-1.el10_2.noarch.rpm;name=aarch64_rust-image+dds-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+dds-devel}"
SRC_URI[aarch64_rust-image+dds-devel.sha256sum] = "29a2063511413d086b84e02e1e2da5bcfea975da948101557e5be99e50623389"

URI_aarch64_rust-image+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+default-devel-0.25.9-1.el10_2.noarch.rpm;name=aarch64_rust-image+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+default-devel}"
SRC_URI[aarch64_rust-image+default-devel.sha256sum] = "c065bd0cfd67e1da0c8946f64858b90213c6519f98eb93fb63cc37af5ee95a51"

URI_aarch64_rust-image+default-formats-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+default-formats-devel-0.25.9-1.el10_2.noarch.rpm;name=aarch64_rust-image+default-formats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+default-formats-devel}"
SRC_URI[aarch64_rust-image+default-formats-devel.sha256sum] = "278256d2a6eeadd2942f1b506429b4b7e69cbd2c123e30e915a2ded9e0f43d5a"

URI_aarch64_rust-image+exr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+exr-devel-0.25.9-1.el10_2.noarch.rpm;name=aarch64_rust-image+exr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+exr-devel}"
SRC_URI[aarch64_rust-image+exr-devel.sha256sum] = "789a40571b28a58db478cb7c8884bd5d096f70ac3ed675d11eec73f798462405"

URI_aarch64_rust-image+ff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+ff-devel-0.25.9-1.el10_2.noarch.rpm;name=aarch64_rust-image+ff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+ff-devel}"
SRC_URI[aarch64_rust-image+ff-devel.sha256sum] = "c7e3c73d484298866b0be4fb69f6f17261622f814881f1d789741b588f5e17fd"

URI_aarch64_rust-image+gif-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+gif-devel-0.25.9-1.el10_2.noarch.rpm;name=aarch64_rust-image+gif-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+gif-devel}"
SRC_URI[aarch64_rust-image+gif-devel.sha256sum] = "25af556dc8633fc643d4aa9100c6f1a0929b6faa167f0925fb315dce8ca1a955"

URI_aarch64_rust-image+hdr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+hdr-devel-0.25.9-1.el10_2.noarch.rpm;name=aarch64_rust-image+hdr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+hdr-devel}"
SRC_URI[aarch64_rust-image+hdr-devel.sha256sum] = "9f96f58d6a72eb39e82d5da45851b45bab19dba56b7477afc2b1f5e3d41234d1"

URI_aarch64_rust-image+ico-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+ico-devel-0.25.9-1.el10_2.noarch.rpm;name=aarch64_rust-image+ico-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+ico-devel}"
SRC_URI[aarch64_rust-image+ico-devel.sha256sum] = "a0b5ba12406615690c5956fbb5efa3665ba437980df06cb24029dd3d93ec9deb"

URI_aarch64_rust-image+jpeg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+jpeg-devel-0.25.9-1.el10_2.noarch.rpm;name=aarch64_rust-image+jpeg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+jpeg-devel}"
SRC_URI[aarch64_rust-image+jpeg-devel.sha256sum] = "262467111f67617f7f851b28b3c51d15e2c7ffc37c4abd53c68651def71bbd5b"

URI_aarch64_rust-image+nasm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+nasm-devel-0.25.9-1.el10_2.noarch.rpm;name=aarch64_rust-image+nasm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+nasm-devel}"
SRC_URI[aarch64_rust-image+nasm-devel.sha256sum] = "e57e8bcbd91b1db24a9b63f204bd7ebf48b324c5c92e3c4921adba13ea9a96da"

URI_aarch64_rust-image+png-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+png-devel-0.25.9-1.el10_2.noarch.rpm;name=aarch64_rust-image+png-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+png-devel}"
SRC_URI[aarch64_rust-image+png-devel.sha256sum] = "ff2abb019e1d1708753ce23e0bc7dbc20eaacee138582173fbb1e9c34eec05d2"

URI_aarch64_rust-image+pnm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+pnm-devel-0.25.9-1.el10_2.noarch.rpm;name=aarch64_rust-image+pnm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+pnm-devel}"
SRC_URI[aarch64_rust-image+pnm-devel.sha256sum] = "a4cbf9e6569c7df6a6bdde5497b8395ebca8e2d5bf0e7ea688212463dd950c0f"

URI_aarch64_rust-image+qoi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+qoi-devel-0.25.9-1.el10_2.noarch.rpm;name=aarch64_rust-image+qoi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+qoi-devel}"
SRC_URI[aarch64_rust-image+qoi-devel.sha256sum] = "31cd716bb2c637b0f0bcd9f2d63cdbab0d6fd49dffe9ac8768ad60d380df579b"

URI_aarch64_rust-image+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+rayon-devel-0.25.9-1.el10_2.noarch.rpm;name=aarch64_rust-image+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+rayon-devel}"
SRC_URI[aarch64_rust-image+rayon-devel.sha256sum] = "362402170aa352684000da00b19fd48731f535f22eec03e8fd545dd4cbe56fa0"

URI_aarch64_rust-image+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+serde-devel-0.25.9-1.el10_2.noarch.rpm;name=aarch64_rust-image+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+serde-devel}"
SRC_URI[aarch64_rust-image+serde-devel.sha256sum] = "de50fda1ae5216fc1a772041f5808eb19309bd3927b7007fca71b3bf8147c89f"

URI_aarch64_rust-image+tga-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+tga-devel-0.25.9-1.el10_2.noarch.rpm;name=aarch64_rust-image+tga-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+tga-devel}"
SRC_URI[aarch64_rust-image+tga-devel.sha256sum] = "029d9fc09f8a8bc95d4aa561814fe44b8ea91ec5e6bb3ee91b355119e0524642"

URI_aarch64_rust-image+tiff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+tiff-devel-0.25.9-1.el10_2.noarch.rpm;name=aarch64_rust-image+tiff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+tiff-devel}"
SRC_URI[aarch64_rust-image+tiff-devel.sha256sum] = "6d2e7fa706b923a71985b2e0375bddd2d3133f6ee7be674bba93c7a629d26860"

URI_aarch64_rust-image+webp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+webp-devel-0.25.9-1.el10_2.noarch.rpm;name=aarch64_rust-image+webp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+webp-devel}"
SRC_URI[aarch64_rust-image+webp-devel.sha256sum] = "bb992fc78f6ce1315e3a128642c2d27fe5b3c1df7e79ae514eb96af23f058a1f"

URI_aarch64_rust-image-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image-devel-0.25.9-1.el10_2.noarch.rpm;name=aarch64_rust-image-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image-devel}"
SRC_URI[aarch64_rust-image-devel.sha256sum] = "7ae2e005ee295e298fc19d7d984bd8a0fb718f6ea67781d7122bd77561a03e0c"

RDEPENDS:rust-image+avif-devel = " \
 cargo \
 rust-image-devel \
 rust-ravif-devel \
 rust-rgb-devel \
 "
RDEPENDS:rust-image+avif-native-devel = " \
 cargo \
 rust-dav1d+default-devel \
 rust-image-devel \
 rust-mp4parse+default-devel \
 "
RDEPENDS:rust-image+bmp-devel = " \
 cargo \
 rust-image-devel \
 "
RDEPENDS:rust-image+color_quant-devel = " \
 cargo \
 rust-color_quant+default-devel \
 rust-image-devel \
 "
RDEPENDS:rust-image+dds-devel = " \
 cargo \
 rust-image-devel \
 "
RDEPENDS:rust-image+default-devel = " \
 cargo \
 rust-image+default-formats-devel \
 rust-image+rayon-devel \
 rust-image-devel \
 "
RDEPENDS:rust-image+default-formats-devel = " \
 cargo \
 rust-image+avif-devel \
 rust-image+bmp-devel \
 rust-image+dds-devel \
 rust-image+exr-devel \
 rust-image+ff-devel \
 rust-image+gif-devel \
 rust-image+hdr-devel \
 rust-image+ico-devel \
 rust-image+jpeg-devel \
 rust-image+png-devel \
 rust-image+pnm-devel \
 rust-image+qoi-devel \
 rust-image+tga-devel \
 rust-image+tiff-devel \
 rust-image+webp-devel \
 rust-image-devel \
 "
RDEPENDS:rust-image+exr-devel = " \
 cargo \
 rust-exr-devel \
 rust-image-devel \
 "
RDEPENDS:rust-image+ff-devel = " \
 cargo \
 rust-image-devel \
 "
RDEPENDS:rust-image+gif-devel = " \
 cargo \
 rust-color_quant+default-devel \
 rust-gif+default-devel \
 rust-image-devel \
 "
RDEPENDS:rust-image+hdr-devel = " \
 cargo \
 rust-image-devel \
 "
RDEPENDS:rust-image+ico-devel = " \
 cargo \
 rust-image+bmp-devel \
 rust-image+png-devel \
 rust-image-devel \
 "
RDEPENDS:rust-image+jpeg-devel = " \
 cargo \
 rust-image-devel \
 rust-zune-core-devel \
 rust-zune-jpeg+default-devel \
 "
RDEPENDS:rust-image+nasm-devel = " \
 cargo \
 rust-image-devel \
 rust-ravif+asm-devel \
 rust-ravif-devel \
 "
RDEPENDS:rust-image+png-devel = " \
 cargo \
 rust-image-devel \
 rust-png+default-devel \
 "
RDEPENDS:rust-image+pnm-devel = " \
 cargo \
 rust-image-devel \
 "
RDEPENDS:rust-image+qoi-devel = " \
 cargo \
 rust-image-devel \
 rust-qoi+default-devel \
 "
RDEPENDS:rust-image+rayon-devel = " \
 cargo \
 rust-exr+rayon-devel \
 rust-exr-devel \
 rust-image-devel \
 rust-ravif+threading-devel \
 rust-ravif-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-image+serde-devel = " \
 cargo \
 rust-image-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-image+tga-devel = " \
 cargo \
 rust-image-devel \
 "
RDEPENDS:rust-image+tiff-devel = " \
 cargo \
 rust-image-devel \
 rust-tiff+default-devel \
 "
RDEPENDS:rust-image+webp-devel = " \
 cargo \
 rust-image-devel \
 rust-image-webp+default-devel \
 "
RDEPENDS:rust-image-devel = " \
 cargo \
 rust \
 rust-bytemuck+default-devel \
 rust-bytemuck+extern_crate_alloc-devel \
 rust-byteorder-lite+default-devel \
 rust-moxcms+default-devel \
 rust-num-traits+default-devel \
 "
