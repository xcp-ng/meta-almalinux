# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libnl3"
PV = "3.11.0"
PR = "1.el10"
PACKAGES = " \
 libnl3 \
 libnl3-cli \
 libnl3-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libnl3-3.11.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e76c24b692eddba4d279b1af99ed696810f14ee7a9e831251f19e9f854579e3"

URI_x86_64_v2_libnl3 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libnl3-3.11.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libnl3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnl3}"
SRC_URI[x86_64_v2_libnl3.sha256sum] = "163d73afcf0cf19e04417ccba6744b3413319faa008d7a50a86cbe5e66f3b511"

URI_x86_64_v2_libnl3-cli = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libnl3-cli-3.11.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libnl3-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnl3-cli}"
SRC_URI[x86_64_v2_libnl3-cli.sha256sum] = "8527d2b75f608b301672bf450e8546f7f04942fbd71a90fd9474fb8f127590db"

URI_x86_64_v2_libnl3-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libnl3-devel-3.11.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libnl3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnl3-devel}"
SRC_URI[x86_64_v2_libnl3-devel.sha256sum] = "1ea3c9a7824bc1a1e3099c2166fa184061aa90de4caf168e8f696227d86cbeaa"

URI_aarch64_libnl3 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libnl3-3.11.0-1.el10.aarch64.rpm;name=aarch64_libnl3;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnl3}"
SRC_URI[aarch64_libnl3.sha256sum] = "de9adbe1f2840157d9189d10ac2b91ec151ee20321f4afae4604e99c508b0128"

URI_aarch64_libnl3-cli = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libnl3-cli-3.11.0-1.el10.aarch64.rpm;name=aarch64_libnl3-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnl3-cli}"
SRC_URI[aarch64_libnl3-cli.sha256sum] = "1d27b516a80923181df3f345401b204e87717ed912bc06da2f0a0e38c8750457"

URI_aarch64_libnl3-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libnl3-devel-3.11.0-1.el10.aarch64.rpm;name=aarch64_libnl3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnl3-devel}"
SRC_URI[aarch64_libnl3-devel.sha256sum] = "60701b61f2e49c87fafe2523193da8a06665b1b9e745082f6002e14a3afebf50"

RDEPENDS:libnl3 = " \
 glibc \
 libgcc \
 "
RDEPENDS:libnl3-cli = " \
 glibc \
 libnl3 \
 "
RDEPENDS:libnl3-devel = " \
 kernel-headers \
 libnl3 \
 libnl3-cli \
 libnl3-devel \
 pkgconf-pkg-config \
 "
