# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qhull"
PE = "1"
PV = "8.0.2"
PR = "2.el10_0"
PACKAGES = " \
 libqhull \
 libqhull_p \
 libqhull_r \
 qhull \
 qhull-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/q/qhull-8.0.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "96acd99f66b36a9468edb0fa5d302dfc2a7f71f335cc7c44bf348614836e27ed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libqhull-8.0.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libqhull;unpack=0"
SRC_URI[x86_64_v2_libqhull.sha256sum] = "12d519871202ec068653411d0358ff467e14adba49d529470f9020da03e7f613"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libqhull_p-8.0.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libqhull_p;unpack=0"
SRC_URI[x86_64_v2_libqhull_p.sha256sum] = "8a2fd1e48bab06e66334700c688b5d97a701e2e9cddc8a849d424e62f829acce"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libqhull_r-8.0.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libqhull_r;unpack=0"
SRC_URI[x86_64_v2_libqhull_r.sha256sum] = "d1f5c8e5c8919480e040ff17f8a5d7a28ea97981d0383239a8cceb3b89009b13"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qhull-8.0.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qhull;unpack=0"
SRC_URI[x86_64_v2_qhull.sha256sum] = "c1fa76ee825eeb3c198ac0e8662c512255de63488bb43a206bc860b5e04f3f4a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qhull-devel-8.0.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qhull-devel;unpack=0"
SRC_URI[x86_64_v2_qhull-devel.sha256sum] = "bfe6e8498e8c042080828ca3410fd9bb2922dbd214f76a167f3528fb1f01952f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libqhull-8.0.2-2.el10_0.aarch64.rpm;name=aarch64_libqhull;unpack=0"
SRC_URI[aarch64_libqhull.sha256sum] = "a7d9103d32b9b8fb9a8db5df7199bf282416fd7db79178775dac2acd0b8a8e1b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libqhull_p-8.0.2-2.el10_0.aarch64.rpm;name=aarch64_libqhull_p;unpack=0"
SRC_URI[aarch64_libqhull_p.sha256sum] = "3afa07d5703404e511a2b73c0c9729f31bce451cd31d04b5d1b2771c3218cd7c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libqhull_r-8.0.2-2.el10_0.aarch64.rpm;name=aarch64_libqhull_r;unpack=0"
SRC_URI[aarch64_libqhull_r.sha256sum] = "0d1141e86f1f06d0967b41b690d5c48202b1865772447dc0568112ca94eca102"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qhull-8.0.2-2.el10_0.aarch64.rpm;name=aarch64_qhull;unpack=0"
SRC_URI[aarch64_qhull.sha256sum] = "ea6560e12035acdae7f620f03bf977c0e903e6f5e820f0586abbe067cba4d423"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qhull-devel-8.0.2-2.el10_0.aarch64.rpm;name=aarch64_qhull-devel;unpack=0"
SRC_URI[aarch64_qhull-devel.sha256sum] = "98b2d29309973c62507733885cbdfc456e87d749b10f6b90d44611a8417c0011"

RDEPENDS:libqhull = " \
 glibc \
 "
RDEPENDS:libqhull_p = " \
 glibc \
 "
RDEPENDS:libqhull_r = " \
 glibc \
 "
RDEPENDS:qhull = " \
 glibc \
 libqhull_r \
 "
RDEPENDS:qhull-devel = " \
 cmake-filesystem \
 libqhull \
 libqhull_p \
 libqhull_r \
 pkgconf-pkg-config \
 qhull \
 "
