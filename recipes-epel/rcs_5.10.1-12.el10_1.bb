# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rcs"
PV = "5.10.1"
PR = "12.el10_1"
PACKAGES = " \
 rcs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rcs-5.10.1-12.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9a537a29e318158b27aa951770b842f3e63786485e7e83ef145d38fd56183128"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rcs-5.10.1-12.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rcs;unpack=0"
SRC_URI[x86_64_v2_rcs.sha256sum] = "2756f730bd96e8a8280ddb888ee80e6b2f68ba6b9ff3980d6f5fcc4c6e628c64"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rcs-5.10.1-12.el10_1.aarch64.rpm;name=aarch64_rcs;unpack=0"
SRC_URI[aarch64_rcs.sha256sum] = "a476274c397af843916f9878c462655bac61d332835c7d0423b6cee80238000d"

RDEPENDS:rcs = " \
 bash \
 diffutils \
 glibc \
 "
