# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tar"
PV = "0.4.46"
PR = "1.el10_2"
PACKAGES = " \
 rust-tar+default-devel \
 rust-tar+xattr-devel \
 rust-tar-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tar-0.4.46-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad46ddd41600dc8646c666041f0ac2ca82d24c5a9c8f0e069c16f28e6cce8d77"

URI_x86_64_v2_rust-tar+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tar+default-devel-0.4.46-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tar+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tar+default-devel}"
SRC_URI[x86_64_v2_rust-tar+default-devel.sha256sum] = "149f0c2c262c34d2197348f7d0285bab1de46dd9f0c9ae2e2ac800e11c3746b5"

URI_x86_64_v2_rust-tar+xattr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tar+xattr-devel-0.4.46-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tar+xattr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tar+xattr-devel}"
SRC_URI[x86_64_v2_rust-tar+xattr-devel.sha256sum] = "ce4bcbbb46e08753c98bc4e891cbf52b48908e490f9d9728e75f81d3f38b86f1"

URI_x86_64_v2_rust-tar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tar-devel-0.4.46-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tar-devel}"
SRC_URI[x86_64_v2_rust-tar-devel.sha256sum] = "034492e5960c3365cf8a9b8b819056a99ef7dc5ea0cdce52cc027d31e5e27aca"

URI_aarch64_rust-tar+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tar+default-devel-0.4.46-1.el10_2.noarch.rpm;name=aarch64_rust-tar+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tar+default-devel}"
SRC_URI[aarch64_rust-tar+default-devel.sha256sum] = "2f5ccc5e28e7a226ccbcbe2899c4ac0e17981acc0340c11a7555116d8e7dd3f9"

URI_aarch64_rust-tar+xattr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tar+xattr-devel-0.4.46-1.el10_2.noarch.rpm;name=aarch64_rust-tar+xattr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tar+xattr-devel}"
SRC_URI[aarch64_rust-tar+xattr-devel.sha256sum] = "b75bb0d2114e105770a1e263e251222959b365e6525818bcdb5d64166a7aed8c"

URI_aarch64_rust-tar-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tar-devel-0.4.46-1.el10_2.noarch.rpm;name=aarch64_rust-tar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tar-devel}"
SRC_URI[aarch64_rust-tar-devel.sha256sum] = "e3989090e39c343b5cbd1c8ed31d3ff175bf0811d945761e65bf572323735664"

RDEPENDS:rust-tar+default-devel = " \
 cargo \
 rust-tar+xattr-devel \
 rust-tar-devel \
 "
RDEPENDS:rust-tar+xattr-devel = " \
 cargo \
 rust-tar-devel \
 rust-xattr+default-devel \
 "
RDEPENDS:rust-tar-devel = " \
 cargo \
 rust \
 rust-filetime+default-devel \
 rust-libc+default-devel \
 "
