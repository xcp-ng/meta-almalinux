# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gram-job-manager"
PV = "15.8"
PR = "8.el10_0"
PACKAGES = " \
 globus-gram-job-manager \
 globus-seg-job-manager \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gram-job-manager-15.8-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad9f7a674795aa35a31b4e4144e1f90cc257206cfce5260deb2c013252e58d44"

URI_x86_64_v2_globus-gram-job-manager = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-15.8-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-job-manager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager}"
SRC_URI[x86_64_v2_globus-gram-job-manager.sha256sum] = "22bb708d3fcf57369a6d8998422c46f1bd4e69e49999706f8b6759bee641b2ec"

URI_x86_64_v2_globus-seg-job-manager = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-seg-job-manager-15.8-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-seg-job-manager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-seg-job-manager}"
SRC_URI[x86_64_v2_globus-seg-job-manager.sha256sum] = "f814716e3a75c272e7b02ec3445fe436db7b40c2026256e64d2239ae7cebee1b"

URI_aarch64_globus-gram-job-manager = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-15.8-8.el10_0.aarch64.rpm;name=aarch64_globus-gram-job-manager;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager}"
SRC_URI[aarch64_globus-gram-job-manager.sha256sum] = "1c56b561524e1cff82e10fc074058e7322aabcfce41d3939f278034bb5da5ef6"

URI_aarch64_globus-seg-job-manager = "${EPEL_MIRROR}/aarch64/Packages/g/globus-seg-job-manager-15.8-8.el10_0.aarch64.rpm;name=aarch64_globus-seg-job-manager;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-seg-job-manager}"
SRC_URI[aarch64_globus-seg-job-manager.sha256sum] = "d1956594a8aaeeb487f29780486b0619a8e506a5dabc20367c005b92220f8149"

RDEPENDS:globus-gram-job-manager = " \
 bash \
 glibc \
 globus-callout \
 globus-common \
 globus-common-progs \
 globus-gass-cache \
 globus-gass-cache-program \
 globus-gass-copy-progs \
 globus-gass-transfer \
 globus-gatekeeper \
 globus-gram-client-tools \
 globus-gram-job-manager-callout-error \
 globus-gram-job-manager-scripts \
 globus-gram-protocol \
 globus-gsi-cert-utils-progs \
 globus-gsi-credential \
 globus-gsi-sysconfig \
 globus-gss-assist \
 globus-gssapi-gsi \
 globus-proxy-utils \
 globus-rsl \
 globus-scheduler-event-generator \
 globus-seg-job-manager \
 globus-xio \
 globus-xio-popen-driver \
 logrotate \
 openssl-libs \
 "
RDEPENDS:globus-seg-job-manager = " \
 glibc \
 globus-common \
 globus-gram-job-manager \
 globus-scheduler-event-generator \
 "
