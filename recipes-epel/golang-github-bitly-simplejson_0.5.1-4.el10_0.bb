# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-bitly-simplejson"
PV = "0.5.1"
PR = "4.el10_0"
PACKAGES = " \
 golang-github-bitly-simplejson-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/golang-github-bitly-simplejson-0.5.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3cce8dcdb05d7b790de9562ce488128c93543b19a1b71acd7c4e3ec4809e2bc6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-bitly-simplejson-devel-0.5.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-bitly-simplejson-devel;unpack=0"
SRC_URI[x86_64_v2_golang-github-bitly-simplejson-devel.sha256sum] = "889c2386ee421500f7e0d6294aedd50bce2660eef158856857ed8a0dbf47b8e1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-github-bitly-simplejson-devel-0.5.1-4.el10_0.noarch.rpm;name=aarch64_golang-github-bitly-simplejson-devel;unpack=0"
SRC_URI[aarch64_golang-github-bitly-simplejson-devel.sha256sum] = "2194639e0af1bc1ddc3f479050cb6fa7b85e2c939dd23db386df67dac53d2d7c"

RDEPENDS:golang-github-bitly-simplejson-devel = " \
 go-filesystem \
 "
