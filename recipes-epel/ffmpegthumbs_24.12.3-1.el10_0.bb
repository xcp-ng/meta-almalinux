# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ffmpegthumbs"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 ffmpegthumbs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/ffmpegthumbs-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d02646f64cc251440fbeddc1e8ab7797a871bd713f7cd339c0490f661b249370"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - ffmpegthumbs: libavcodec.so.61()(64bit)
# - ffmpegthumbs: libavcodec.so.61(LIBAVCODEC_61)(64bit)
# - ffmpegthumbs: libavfilter.so.10()(64bit)
# - ffmpegthumbs: libavfilter.so.10(LIBAVFILTER_10)(64bit)
# - ffmpegthumbs: libavformat.so.61()(64bit)
# - ffmpegthumbs: libavformat.so.61(LIBAVFORMAT_61)(64bit)
# - ffmpegthumbs: libavutil.so.59()(64bit)
# - ffmpegthumbs: libavutil.so.59(LIBAVUTIL_59)(64bit)
# - ffmpegthumbs: libswscale.so.8()(64bit)
# - ffmpegthumbs: libswscale.so.8(LIBSWSCALE_8)(64bit)

URI_x86_64_v2_ffmpegthumbs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ffmpegthumbs-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ffmpegthumbs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ffmpegthumbs}"
SRC_URI[x86_64_v2_ffmpegthumbs.sha256sum] = "4dbed9cec17daa648e5c6a1a89de4eb2879d15f22d5aafc8b688e823e8d00ebb"

URI_aarch64_ffmpegthumbs = "${EPEL_MIRROR}/aarch64/Packages/f/ffmpegthumbs-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_ffmpegthumbs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ffmpegthumbs}"
SRC_URI[aarch64_ffmpegthumbs.sha256sum] = "296cad28e280bac4638bc32aeb2bc1c522ea4a549fe1a7c54cf2d2e21791cfad"

RDEPENDS:ffmpegthumbs:x86_64_v2 = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kio-gui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
"
RDEPENDS:ffmpegthumbs:aarch64 = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kio-gui \
 libavcodec-free \
 libavfilter-free \
 libavformat-free \
 libavutil-free \
 libstdc++ \
 libswscale-free \
 qt6-qtbase \
 qt6-qtbase-gui \
"
