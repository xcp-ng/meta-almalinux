# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmousetool"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kmousetool \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kmousetool-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d01d16af37f76eb6e468bbaaf40b0a00374659d2a3a9f4385359750e1add3683"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmousetool-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmousetool;unpack=0"
SRC_URI[x86_64_v2_kmousetool.sha256sum] = "f89a600a16581679c8fbcf15ba1a5528602e1697d0853f94b0119e7d55a4bd6d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kmousetool-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kmousetool;unpack=0"
SRC_URI[aarch64_kmousetool.sha256sum] = "46af29d5e6f0759e4c5ca924579c73da92c4a434ac63051d77a78512c5b2153e"

RDEPENDS:kmousetool = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libX11 \
 libXtst \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 "
