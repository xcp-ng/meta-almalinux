# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-Works"
PV = "0.22"
PR = "15.el10_0"
PACKAGES = " \
 perl-Net-Works \
 perl-Net-Works-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-Works-0.22-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63a06bf05d59963f153ca81f65ee544efd87fb47e761cc201aa17844e9249f54"

URI_x86_64_v2_perl-Net-Works = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-Works-0.22-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-Works;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-Works}"
SRC_URI[x86_64_v2_perl-Net-Works.sha256sum] = "af1f5c5eeac38aa69ec0976a0abe4f07dfab2be2c534a91d7420ef2c61df2d3a"

URI_x86_64_v2_perl-Net-Works-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-Works-tests-0.22-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-Works-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-Works-tests}"
SRC_URI[x86_64_v2_perl-Net-Works-tests.sha256sum] = "10d95f54ed49e4416054eb8823fd234650cd82717b26f2ff43bd762b39e9368a"

URI_aarch64_perl-Net-Works = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-Works-0.22-15.el10_0.noarch.rpm;name=aarch64_perl-Net-Works;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-Works}"
SRC_URI[aarch64_perl-Net-Works.sha256sum] = "a70ddd7445b3e201ff1eb326404d4a4a22b8f4416a5488077c4a552307eaf1b6"

URI_aarch64_perl-Net-Works-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-Works-tests-0.22-15.el10_0.noarch.rpm;name=aarch64_perl-Net-Works-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-Works-tests}"
SRC_URI[aarch64_perl-Net-Works-tests.sha256sum] = "6096d4184c17303321c68e7e244c74f15383f42d294798e5f41ed9e818a63365"

RDEPENDS:perl-Net-Works = " \
 perl-Carp \
 perl-Exporter \
 perl-List-AllUtils \
 perl-Math-Int128 \
 perl-Moo \
 perl-Net-Works \
 perl-Scalar-List-Utils \
 perl-Socket \
 perl-Sub-Quote \
 perl-libs \
 perl-namespace-autoclean \
 perl-overload \
 "
RDEPENDS:perl-Net-Works-tests = " \
 bash \
 perl-B \
 perl-ExtUtils-MakeMaker \
 perl-List-AllUtils \
 perl-Math-BigInt \
 perl-Math-Int128 \
 perl-Net-Works \
 perl-PathTools \
 perl-Test-Fatal \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
