# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gsi-callback"
PV = "6.2"
PR = "8.el10_0"
PACKAGES = " \
 globus-gsi-callback \
 globus-gsi-callback-devel \
 globus-gsi-callback-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gsi-callback-6.2-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fce60189b82600aec8411bf16e834916ec590c7254309317cf33767afdbb3a9d"

URI_x86_64_v2_globus-gsi-callback = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-callback-6.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gsi-callback;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-callback}"
SRC_URI[x86_64_v2_globus-gsi-callback.sha256sum] = "1e1373ce35a8ecca257c1b034817d435ba73720b92b32ff51b48c283fa0d8237"

URI_x86_64_v2_globus-gsi-callback-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-callback-devel-6.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gsi-callback-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-callback-devel}"
SRC_URI[x86_64_v2_globus-gsi-callback-devel.sha256sum] = "229286294b2dc0e96c2f7f973abeda666ecf973adbfcd1edfb8a591690d1db96"

URI_x86_64_v2_globus-gsi-callback-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-callback-doc-6.2-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gsi-callback-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-callback-doc}"
SRC_URI[x86_64_v2_globus-gsi-callback-doc.sha256sum] = "3ba5b4fe71fa1d08e11cfd397eea15f3ecaf35b3c273c612b4d2604be396d57f"

URI_aarch64_globus-gsi-callback = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-callback-6.2-8.el10_0.aarch64.rpm;name=aarch64_globus-gsi-callback;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-callback}"
SRC_URI[aarch64_globus-gsi-callback.sha256sum] = "53b3b586d19e8e0a5b60c7f67aa5c270f00132b4408e06d1a39334ddc05bcc8c"

URI_aarch64_globus-gsi-callback-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-callback-devel-6.2-8.el10_0.aarch64.rpm;name=aarch64_globus-gsi-callback-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-callback-devel}"
SRC_URI[aarch64_globus-gsi-callback-devel.sha256sum] = "e38eb525fcd3a21fcd244dbcf3bcd39894a11a06c2e1be2c36bc53ed62214083"

URI_aarch64_globus-gsi-callback-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-callback-doc-6.2-8.el10_0.noarch.rpm;name=aarch64_globus-gsi-callback-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-callback-doc}"
SRC_URI[aarch64_globus-gsi-callback-doc.sha256sum] = "cc40ce655414c2e45a8187445a6d1c698c50980a4eca0818e7cdf503bc411709"

RDEPENDS:globus-gsi-callback = " \
 glibc \
 globus-common \
 globus-gsi-cert-utils \
 globus-gsi-openssl-error \
 globus-gsi-sysconfig \
 openssl-libs \
 "
RDEPENDS:globus-gsi-callback-devel = " \
 globus-common-devel \
 globus-gsi-callback \
 globus-gsi-cert-utils-devel \
 globus-gsi-openssl-error-devel \
 globus-gsi-sysconfig-devel \
 globus-openssl-module-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-gsi-callback-doc = " \
 "
