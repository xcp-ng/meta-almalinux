# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gi-docgen"
PV = "2025.5"
PR = "1.el10_0"
PACKAGES = " \
 gi-docgen \
 gi-docgen-doc \
 gi-docgen-fonts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gi-docgen-2025.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "722c7f9a4ea73fc99c9d3c776f8329dda44e6b8bc25e9d7802adbbe3dc29a9f5"

URI_x86_64_v2_gi-docgen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gi-docgen-2025.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gi-docgen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gi-docgen}"
SRC_URI[x86_64_v2_gi-docgen.sha256sum] = "c064771a6b1a56ce213f86b27b7ee25343c4ed1e56412bf60268f843ce3ae6ae"

URI_x86_64_v2_gi-docgen-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gi-docgen-doc-2025.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gi-docgen-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gi-docgen-doc}"
SRC_URI[x86_64_v2_gi-docgen-doc.sha256sum] = "72c27a4ba311a5345506b998b97a6fe86abf37cb9089df0e2d4e4405d5c2d4af"

URI_x86_64_v2_gi-docgen-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gi-docgen-fonts-2025.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gi-docgen-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gi-docgen-fonts}"
SRC_URI[x86_64_v2_gi-docgen-fonts.sha256sum] = "8cf2b3256c75b6d338e25473c420f535a7cc819d68a02954525e29367aaecba9"

URI_aarch64_gi-docgen = "${EPEL_MIRROR}/aarch64/Packages/g/gi-docgen-2025.5-1.el10_0.noarch.rpm;name=aarch64_gi-docgen;unpack=0"
SRC_URI:append = " ${URI_aarch64_gi-docgen}"
SRC_URI[aarch64_gi-docgen.sha256sum] = "591e306ed66bb34d226a93af6e34f29bd34e8e064c4575033790cd85246ee0d1"

URI_aarch64_gi-docgen-doc = "${EPEL_MIRROR}/aarch64/Packages/g/gi-docgen-doc-2025.5-1.el10_0.noarch.rpm;name=aarch64_gi-docgen-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gi-docgen-doc}"
SRC_URI[aarch64_gi-docgen-doc.sha256sum] = "baa48856979322099765cc4edf98bbb6a865db3caf25d6aea39c4041d936a9ba"

URI_aarch64_gi-docgen-fonts = "${EPEL_MIRROR}/aarch64/Packages/g/gi-docgen-fonts-2025.5-1.el10_0.noarch.rpm;name=aarch64_gi-docgen-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_gi-docgen-fonts}"
SRC_URI[aarch64_gi-docgen-fonts.sha256sum] = "ec3cf871a827d3db75107434b0d24d6d2afa57ea92d53e164249d23413f7d2a9"

RDEPENDS:gi-docgen = " \
 gi-docgen-fonts \
 pkgconf-pkg-config \
 python3 \
 python3-jinja2 \
 python3-markdown \
 python3-markupsafe \
 python3-packaging \
 python3-pygments \
 python3-typogrify \
 "
RDEPENDS:gi-docgen-doc = " \
 "
RDEPENDS:gi-docgen-fonts = " \
 redhat-display-fonts \
 redhat-mono-vf-fonts \
 redhat-text-fonts \
 virtual/font_redhatdisplay_ \
 virtual/font_redhattext_ \
 "
