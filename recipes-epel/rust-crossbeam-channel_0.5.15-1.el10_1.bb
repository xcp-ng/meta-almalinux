# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossbeam-channel"
PV = "0.5.15"
PR = "1.el10_1"
PACKAGES = " \
 rust-crossbeam-channel+default-devel \
 rust-crossbeam-channel+std-devel \
 rust-crossbeam-channel-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crossbeam-channel-0.5.15-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f988571463ad7486e9120658d99ef7e6b43e5c7dfc26bfb27ec655764cf58c1c"

URI_x86_64_v2_rust-crossbeam-channel+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-channel+default-devel-0.5.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-channel+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-channel+default-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-channel+default-devel.sha256sum] = "4eafad562dd84922c52cf5010c87b040cf70a3bd3f0afea3ce76713084a0d9e6"

URI_x86_64_v2_rust-crossbeam-channel+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-channel+std-devel-0.5.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-channel+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-channel+std-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-channel+std-devel.sha256sum] = "0720bebf8713e805552212ae306c5069c2d35ae4198f9213142c06d5e2162865"

URI_x86_64_v2_rust-crossbeam-channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-channel-devel-0.5.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-channel-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-channel-devel.sha256sum] = "24524f42d4cb90db42c0f18f0901dd9d99af1c28c05acedeb813d00b8ec063cb"

URI_aarch64_rust-crossbeam-channel+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-channel+default-devel-0.5.15-1.el10_1.noarch.rpm;name=aarch64_rust-crossbeam-channel+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-channel+default-devel}"
SRC_URI[aarch64_rust-crossbeam-channel+default-devel.sha256sum] = "01e05dd43cf2481445e7ed5e55659bbe0a81ce00c2ab425a7f95ebe2697cefab"

URI_aarch64_rust-crossbeam-channel+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-channel+std-devel-0.5.15-1.el10_1.noarch.rpm;name=aarch64_rust-crossbeam-channel+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-channel+std-devel}"
SRC_URI[aarch64_rust-crossbeam-channel+std-devel.sha256sum] = "661bb996b14ca960d93e35a9920c3f8f56d1af7e0c4db86da94aa34bc0d0dff7"

URI_aarch64_rust-crossbeam-channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-channel-devel-0.5.15-1.el10_1.noarch.rpm;name=aarch64_rust-crossbeam-channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-channel-devel}"
SRC_URI[aarch64_rust-crossbeam-channel-devel.sha256sum] = "cec54bf2674f8618a614f15aee7f0ec2aa71a82a24cacd1a61e2f338bed2f357"

RDEPENDS:rust-crossbeam-channel+default-devel = " \
 cargo \
 rust-crossbeam-channel+std-devel \
 rust-crossbeam-channel-devel \
 "
RDEPENDS:rust-crossbeam-channel+std-devel = " \
 cargo \
 rust-crossbeam-channel-devel \
 rust-crossbeam-utils+std-devel \
 "
RDEPENDS:rust-crossbeam-channel-devel = " \
 cargo \
 rust \
 rust-crossbeam-utils-devel \
 "
