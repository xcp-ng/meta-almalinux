# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rpkg"
PV = "1.68"
PR = "1.el10_0"
PACKAGES = " \
 python3-rpkg \
 rpkg-common \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rpkg-1.68-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f535c649f247d95628997ebba17d09c74e6f3753b85acf86cdcb1f48f468b8f"

URI_x86_64_v2_python3-rpkg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rpkg-1.68-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rpkg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rpkg}"
SRC_URI[x86_64_v2_python3-rpkg.sha256sum] = "d5bdecb14e77ecc6eb8526a9420ca501bd39df357a0049a1b5a6f163c1eab363"

URI_x86_64_v2_rpkg-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpkg-common-1.68-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rpkg-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpkg-common}"
SRC_URI[x86_64_v2_rpkg-common.sha256sum] = "818b26d2717260d024f02657fc5bc1ad385f535d1fc04c788a72a78a840c55ff"

URI_aarch64_python3-rpkg = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rpkg-1.68-1.el10_0.noarch.rpm;name=aarch64_python3-rpkg;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rpkg}"
SRC_URI[aarch64_python3-rpkg.sha256sum] = "1f69c816876815db5d85446cda253c28756adadb5fa472dab40c1f1a6fea11ea"

URI_aarch64_rpkg-common = "${EPEL_MIRROR}/aarch64/Packages/r/rpkg-common-1.68-1.el10_0.noarch.rpm;name=aarch64_rpkg-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpkg-common}"
SRC_URI[aarch64_rpkg-common.sha256sum] = "576f807f528568beee4889711dedab336b676900d54244b2b34efef81c287f11"

RDEPENDS:python3-rpkg = " \
 libmodulemd \
 mock \
 python3 \
 python3-GitPython \
 python3-argcomplete \
 python3-cccolutils \
 python3-gobject-base \
 python3-koji \
 python3-pycurl \
 python3-pyyaml \
 python3-requests \
 python3-requests-gssapi \
 python3-rpm \
 python3-six \
 redhat-rpm-config \
 rpkg-common \
 rpm-build \
 rpmdevtools \
 rpmlint \
 "
RDEPENDS:rpkg-common = " \
 "
