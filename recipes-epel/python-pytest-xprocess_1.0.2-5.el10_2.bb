# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-xprocess"
PV = "1.0.2"
PR = "5.el10_2"
PACKAGES = " \
 python3-pytest-xprocess \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-xprocess-1.0.2-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55779e2bbc77c6ef3cd1ed2cdd094bb483228da3d59b18714965b6ae767e4af9"

URI_x86_64_v2_python3-pytest-xprocess = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-xprocess-1.0.2-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-xprocess;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-xprocess}"
SRC_URI[x86_64_v2_python3-pytest-xprocess.sha256sum] = "67b4511b05b444cd9a24c41bde52384aa98bd87c45a23620b8ba295c15792ca0"

URI_aarch64_python3-pytest-xprocess = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-xprocess-1.0.2-5.el10_2.noarch.rpm;name=aarch64_python3-pytest-xprocess;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-xprocess}"
SRC_URI[aarch64_python3-pytest-xprocess.sha256sum] = "7f1e4ed67899d72ab33a58641a84a9b48484562caf9dd5b6c43c1f9a1b34ec06"

RDEPENDS:python3-pytest-xprocess = " \
 python3 \
 python3-psutil \
 python3-pytest \
 python3-setuptools \
 "
