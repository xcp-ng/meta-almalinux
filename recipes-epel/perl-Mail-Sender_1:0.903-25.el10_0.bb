# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Mail-Sender"
PE = "1"
PV = "0.903"
PR = "25.el10_0"
PACKAGES = " \
 perl-Mail-Sender \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Mail-Sender-0.903-25.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25d30d595b534836d7fc963749cfbd280e1a4f9aefe2bef96ac90b080f06123f"

URI_x86_64_v2_perl-Mail-Sender = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Mail-Sender-0.903-25.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Mail-Sender;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Mail-Sender}"
SRC_URI[x86_64_v2_perl-Mail-Sender.sha256sum] = "31d8461b8407724b54096d400e7b08175b6cf7b2188df9a063110ad4055fcde2"

URI_aarch64_perl-Mail-Sender = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Mail-Sender-0.903-25.el10_0.noarch.rpm;name=aarch64_perl-Mail-Sender;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Mail-Sender}"
SRC_URI[aarch64_perl-Mail-Sender.sha256sum] = "89328e13b413187769cecd5ae1c0d0a4037586651e6a7a8876e0bd21bc86549b"

RDEPENDS:perl-Mail-Sender = " \
 perl-Carp \
 perl-Encode \
 perl-Exporter \
 perl-File-Basename \
 perl-IO \
 perl-MIME-Base64 \
 perl-Mail-Sender \
 perl-Socket \
 perl-Time-Local \
 perl-base \
 perl-libs \
 "
