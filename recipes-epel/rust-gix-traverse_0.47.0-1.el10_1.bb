# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-traverse"
PV = "0.47.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-traverse+default-devel \
 rust-gix-traverse-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-traverse-0.47.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "108703cb26517054aa47d6a4e42438d3df91942f9b5f2d753f0ccaebb4cfd04e"

URI_x86_64_v2_rust-gix-traverse+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-traverse+default-devel-0.47.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-traverse+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-traverse+default-devel}"
SRC_URI[x86_64_v2_rust-gix-traverse+default-devel.sha256sum] = "19e1e8f26ae39610934cb6a2f01f813236136b68276e66494b052eefaa4f1e33"

URI_x86_64_v2_rust-gix-traverse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-traverse-devel-0.47.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-traverse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-traverse-devel}"
SRC_URI[x86_64_v2_rust-gix-traverse-devel.sha256sum] = "43c65eaee30c014bb8b4a5006526646e0ef672e05a3eddf377083223bcfb06c1"

URI_aarch64_rust-gix-traverse+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-traverse+default-devel-0.47.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-traverse+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-traverse+default-devel}"
SRC_URI[aarch64_rust-gix-traverse+default-devel.sha256sum] = "8f7912150caa734f6edc01403f228c85cc7c4b002a4295225c32ba1e9761353d"

URI_aarch64_rust-gix-traverse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-traverse-devel-0.47.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-traverse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-traverse-devel}"
SRC_URI[aarch64_rust-gix-traverse-devel.sha256sum] = "6691bc6ef83fa2ab2b10b287f78e3f5fbcc73662827568a655f5adabfc8cc515"

RDEPENDS:rust-gix-traverse+default-devel = " \
 cargo \
 rust-gix-traverse-devel \
 "
RDEPENDS:rust-gix-traverse-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-gix-commitgraph+default-devel \
 rust-gix-date+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-hashtable+default-devel \
 rust-gix-object+default-devel \
 rust-gix-revwalk+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 "
