# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openssl"
PE = "1"
PV = "3.5.8"
PR = "1.el10_2.alma.1"
PACKAGES = " \
 openssl \
 openssl-devel \
 openssl-fips-provider \
 openssl-libs \
 openssl-perl \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/openssl-3.5.8-1.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9678899bfd58d2344a9ae49bce1f2347865621eb3cc349fa2ee9310a06d89269"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssl-3.5.8-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssl;unpack=0"
SRC_URI[x86_64_v2_openssl.sha256sum] = "b3a5ffce9a426ee47554b1a5eef81db4d1a1ada7700f1e21bbc6f0068d368f5e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openssl-devel-3.5.8-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssl-devel;unpack=0"
SRC_URI[x86_64_v2_openssl-devel.sha256sum] = "aef8b2666fdb27f18d01640cbfff02d1de6a7892f971ad6978a82be4dfdea29b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssl-fips-provider-3.5.8-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssl-fips-provider;unpack=0"
SRC_URI[x86_64_v2_openssl-fips-provider.sha256sum] = "d4283d42893221131979574ab59f3bbb9138f3e3d1673d7003f34802d9456d9e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssl-libs-3.5.8-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssl-libs;unpack=0"
SRC_URI[x86_64_v2_openssl-libs.sha256sum] = "8c58b07b6c2963248512d6d5d847cb982f0dac27a65690fe2e7c7c6963bd45a4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openssl-perl-3.5.8-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssl-perl;unpack=0"
SRC_URI[x86_64_v2_openssl-perl.sha256sum] = "1f224efad4bdf0438be46932052cfacdea58dc25555138c867eb37ad6228d04e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssl-3.5.8-1.el10_2.alma.1.aarch64.rpm;name=aarch64_openssl;unpack=0"
SRC_URI[aarch64_openssl.sha256sum] = "c5ec9b98fca3b72c0395599a1448abe2d0f625577692224b11a75297d561d829"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openssl-devel-3.5.8-1.el10_2.alma.1.aarch64.rpm;name=aarch64_openssl-devel;unpack=0"
SRC_URI[aarch64_openssl-devel.sha256sum] = "dd8ee71e2f7d5c58717b19709ecf1f5cd8324060dd49cca0dbd2e160ac3d3572"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssl-fips-provider-3.5.8-1.el10_2.alma.1.aarch64.rpm;name=aarch64_openssl-fips-provider;unpack=0"
SRC_URI[aarch64_openssl-fips-provider.sha256sum] = "6de94b52ce52eebe274f7c59e7807cc60ae665a9ab8d052b40143acc99106f61"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssl-libs-3.5.8-1.el10_2.alma.1.aarch64.rpm;name=aarch64_openssl-libs;unpack=0"
SRC_URI[aarch64_openssl-libs.sha256sum] = "b3f734f43e7a39866c1c333a5fa83b44aad3e4c98555295446b9eedbfc0e4b0a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openssl-perl-3.5.8-1.el10_2.alma.1.aarch64.rpm;name=aarch64_openssl-perl;unpack=0"
SRC_URI[aarch64_openssl-perl.sha256sum] = "bcb3cbd1884c21c5d27c5cb3010349f43dd77f78388a6e064220d248826c20da"

RDEPENDS:openssl = " \
 bash \
 glibc \
 openssl-libs \
 virtual/coreutils \
 "
RDEPENDS:openssl-devel = " \
 openssl-devel \
 openssl-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:openssl-fips-provider = " \
 glibc \
 openssl-libs \
 "
RDEPENDS:openssl-libs = " \
 ca-certificates \
 crypto-policies \
 glibc \
 openssl-fips-provider \
 zlib-ng-compat \
 "
RDEPENDS:openssl-perl = " \
 openssl \
 perl-interpreter \
 "
