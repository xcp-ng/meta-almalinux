# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kauth"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kauth \
 kf6-kauth-devel \
 kf6-kauth-doc \
 kf6-kauth-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kauth-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f42d00fced956e435312cb9d4b7052052397e78911d5b18813bdd087cdb18570"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kauth-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kauth;unpack=0"
SRC_URI[x86_64_v2_kf6-kauth.sha256sum] = "d4e5ccda5cb80b2b62631a468e30266f426d38861f61d8f0d756c2f4fb51c078"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kauth-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kauth-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kauth-devel.sha256sum] = "714aa354d507f49cad3c295e64bdcb586b2987f67f1f73214c8becd928f18c75"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kauth-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kauth-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kauth-doc.sha256sum] = "8d2147a70dd7891146671b3990c93174f074bcba7006105d9e3ce631129e6fb5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kauth-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kauth-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kauth-html.sha256sum] = "7a2cf25df3f8f07163fb59266ca0f8206ca4ab268292585e8d1f42eac4a694c5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kauth-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kauth;unpack=0"
SRC_URI[aarch64_kf6-kauth.sha256sum] = "0d06786c2b4ad304b314d0864012e326f93ccc16a548f42078125540e8917434"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kauth-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kauth-devel;unpack=0"
SRC_URI[aarch64_kf6-kauth-devel.sha256sum] = "9e86e421c84368f751fa770d43c240cae85d69f2480ef348e19e034d548b3d1f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kauth-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kauth-doc;unpack=0"
SRC_URI[aarch64_kf6-kauth-doc.sha256sum] = "25d86dc4bdb1302b03ba3dca5ccc643e35de141e698fc51ed894cd2b391ac043"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kauth-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kauth-html;unpack=0"
SRC_URI[aarch64_kf6-kauth-html.sha256sum] = "4eeec29d58ab960c6d2aac3b03285311a4b13a7cd8b752b46522f16792314bbf"

RDEPENDS:kf6-kauth = " \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-kwindowsystem \
 libstdc++ \
 polkit-qt6-1 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kauth-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kauth \
 kf6-kcoreaddons-devel \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kauth-doc = " \
 "
RDEPENDS:kf6-kauth-html = " \
 "
