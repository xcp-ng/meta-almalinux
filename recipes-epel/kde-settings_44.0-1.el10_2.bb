# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-settings"
PV = "44.0"
PR = "1.el10_2"
PACKAGES = " \
 initial-setup-gui-wayland-plasma \
 kde-settings \
 kde-settings-plasma \
 kde-settings-plasmalogin \
 kde-settings-pulseaudio \
 kde-settings-sddm \
 qt-settings \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kde-settings-44.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7338896e06e357b3384f61ed13857db4cc56a8702798d09cc7d96d175a3af313"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/initial-setup-gui-wayland-plasma-44.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_initial-setup-gui-wayland-plasma;unpack=0"
SRC_URI[x86_64_v2_initial-setup-gui-wayland-plasma.sha256sum] = "dc406799de377e66466e7f7ec8c78db330d3724e124196102320d6a663fd7afd"
RPROVIDES:initial-setup-gui-wayland-plasma:append:x86_64_v2 = " virtual/firstboot_gui-backend_"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-settings-44.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kde-settings;unpack=0"
SRC_URI[x86_64_v2_kde-settings.sha256sum] = "53c6857f689809fa0937e56ee3b609c1125c034877e824a383f354dba61afaf7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-settings-plasma-44.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kde-settings-plasma;unpack=0"
SRC_URI[x86_64_v2_kde-settings-plasma.sha256sum] = "ee4e2384563aea38f8d595c9112c9089030d6265e1fb1a100e7b38565c5fe680"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-settings-plasmalogin-44.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kde-settings-plasmalogin;unpack=0"
SRC_URI[x86_64_v2_kde-settings-plasmalogin.sha256sum] = "c83fb3cb2b3b6bb25e2c26a280cc4fb23934b9baa681f5e824ed7eca8e7be369"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-settings-pulseaudio-44.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kde-settings-pulseaudio;unpack=0"
SRC_URI[x86_64_v2_kde-settings-pulseaudio.sha256sum] = "bda7613eb736ecba41446fe40be90115d5d2f227cf3a36649682a48031935885"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-settings-sddm-44.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kde-settings-sddm;unpack=0"
SRC_URI[x86_64_v2_kde-settings-sddm.sha256sum] = "9ce99f08e54d7dabc5d21971ddf073624104b9a5a08b2aef1649111e6e25bb3e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt-settings-44.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_qt-settings;unpack=0"
SRC_URI[x86_64_v2_qt-settings.sha256sum] = "ccce11571706524ca9eeaf379ace730a190fc0e159ce2ac54a6801467976efb5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/i/initial-setup-gui-wayland-plasma-44.0-1.el10_2.noarch.rpm;name=aarch64_initial-setup-gui-wayland-plasma;unpack=0"
SRC_URI[aarch64_initial-setup-gui-wayland-plasma.sha256sum] = "dbc662668949070a42982f8965e2f68df679788dc9254477f6c6adb2350a765b"
RPROVIDES:initial-setup-gui-wayland-plasma:append:aarch64 = " virtual/firstboot_gui-backend_"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kde-settings-44.0-1.el10_2.noarch.rpm;name=aarch64_kde-settings;unpack=0"
SRC_URI[aarch64_kde-settings.sha256sum] = "11b0913a4526f2b12861be31930fb4b07268b0082187fc8269ec50abdd1b2ed1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kde-settings-plasma-44.0-1.el10_2.noarch.rpm;name=aarch64_kde-settings-plasma;unpack=0"
SRC_URI[aarch64_kde-settings-plasma.sha256sum] = "9282b6485a079dd1da27326611ef1ebbd27893c5e587dea9e8b9dd7534d883de"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kde-settings-plasmalogin-44.0-1.el10_2.noarch.rpm;name=aarch64_kde-settings-plasmalogin;unpack=0"
SRC_URI[aarch64_kde-settings-plasmalogin.sha256sum] = "d385e0e9b67103b46d56a1af3828bf0c1eb7f3443ff0a9056a29f587c710d70e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kde-settings-pulseaudio-44.0-1.el10_2.noarch.rpm;name=aarch64_kde-settings-pulseaudio;unpack=0"
SRC_URI[aarch64_kde-settings-pulseaudio.sha256sum] = "5fbb1898700b6548edeb1ef9780ec98882a8ec6865d55f946c577d1dc944a378"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kde-settings-sddm-44.0-1.el10_2.noarch.rpm;name=aarch64_kde-settings-sddm;unpack=0"
SRC_URI[aarch64_kde-settings-sddm.sha256sum] = "be8810c064e13bed90d9c714dbe93849ee24bb17e51210d12274b4036c371258"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt-settings-44.0-1.el10_2.noarch.rpm;name=aarch64_qt-settings;unpack=0"
SRC_URI[aarch64_qt-settings.sha256sum] = "edf8164b52593c700c0a9acb1d0dc729adcbb0eed2b160ea5c97d0c45f19fb96"

RDEPENDS:initial-setup-gui-wayland-plasma = " \
 bash \
 initial-setup-gui \
 kwin \
 plasma-keyboard \
 xorg-x11-server-Xwayland \
 "
RDEPENDS:kde-settings = " \
 bash \
 breeze-icon-theme \
 kde-filesystem \
 shared-mime-info \
 xdg-user-dirs \
 "
RDEPENDS:kde-settings-plasma = " \
 almalinux-logos \
 google-noto-sans-fonts \
 google-noto-sans-mono-fonts \
 kde-settings \
 virtual/system-backgrounds-kde \
 "
RDEPENDS:kde-settings-plasmalogin = " \
 plasma-login-manager \
 virtual/system-backgrounds-kde \
 "
RDEPENDS:kde-settings-pulseaudio = " \
 alsa-plugins-pulseaudio \
 kde-settings \
 pipewire-alsa \
 pipewire-pulseaudio \
 "
RDEPENDS:kde-settings-sddm = " \
 breeze-cursor-theme \
 sddm \
 "
RDEPENDS:qt-settings = " \
 "
