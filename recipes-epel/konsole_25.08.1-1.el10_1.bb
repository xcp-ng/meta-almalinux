# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "konsole"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 konsole \
 konsole-part \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/konsole-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6fe4cb5095543e637f5a03f4712bad359896cefe70a9efacdadc03f6aece51b7"

URI_x86_64_v2_konsole = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konsole-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konsole;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_konsole}"
SRC_URI[x86_64_v2_konsole.sha256sum] = "db6143e416d7646fcb367a959bfca50d37373df458633e954900541d7247e180"

URI_x86_64_v2_konsole-part = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konsole-part-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konsole-part;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_konsole-part}"
SRC_URI[x86_64_v2_konsole-part.sha256sum] = "3d251f16b8f4b76ec0a56bc75ad1aa8ceb37ec12bdeeccc761fa9edec136de16"

URI_aarch64_konsole = "${EPEL_MIRROR}/aarch64/Packages/k/konsole-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_konsole;unpack=0"
SRC_URI:append = " ${URI_aarch64_konsole}"
SRC_URI[aarch64_konsole.sha256sum] = "172f1eb8e14f28c6c03a7e34475377b2a6b195cd7fe899a6e0d85076d9270dfa"

URI_aarch64_konsole-part = "${EPEL_MIRROR}/aarch64/Packages/k/konsole-part-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_konsole-part;unpack=0"
SRC_URI:append = " ${URI_aarch64_konsole-part}"
SRC_URI[aarch64_konsole-part.sha256sum] = "c8c5095cdde0b04295ac0274a6c9c9afdf8c49aa308979a04804b769c267ba3d"

RDEPENDS:konsole = " \
 bash \
 glibc \
 keditbookmarks \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kxmlgui \
 konsole-part \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:konsole-part = " \
 glibc \
 kf6-kbookmarks \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kparts \
 kf6-kpty \
 kf6-kservice \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libicu \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 "
