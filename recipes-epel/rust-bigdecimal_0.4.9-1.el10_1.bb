# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bigdecimal"
PV = "0.4.9"
PR = "1.el10_1"
PACKAGES = " \
 rust-bigdecimal+default-devel \
 rust-bigdecimal+serde-devel \
 rust-bigdecimal+serde-json-devel \
 rust-bigdecimal+serde_json-devel \
 rust-bigdecimal+std-devel \
 rust-bigdecimal+string-only-devel \
 rust-bigdecimal-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bigdecimal-0.4.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "00d3e83603a0c4b221004f43c5a6e1db1b09598939c99fb16ae29441b70cc2ca"

URI_x86_64_v2_rust-bigdecimal+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bigdecimal+default-devel-0.4.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bigdecimal+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bigdecimal+default-devel}"
SRC_URI[x86_64_v2_rust-bigdecimal+default-devel.sha256sum] = "9fd4977a9f8af248ed422825596f7ce0c2a3b3230444176644d7d0a8b512d911"

URI_x86_64_v2_rust-bigdecimal+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bigdecimal+serde-devel-0.4.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bigdecimal+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bigdecimal+serde-devel}"
SRC_URI[x86_64_v2_rust-bigdecimal+serde-devel.sha256sum] = "b510e184a6a198ae797843eb8526d8cb32b112437039615dbde97c8a502a580f"

URI_x86_64_v2_rust-bigdecimal+serde-json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bigdecimal+serde-json-devel-0.4.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bigdecimal+serde-json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bigdecimal+serde-json-devel}"
SRC_URI[x86_64_v2_rust-bigdecimal+serde-json-devel.sha256sum] = "0c300319fe812669f670cd563349e9198addf2006630e12cc0a51af74995ffb7"

URI_x86_64_v2_rust-bigdecimal+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bigdecimal+serde_json-devel-0.4.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bigdecimal+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bigdecimal+serde_json-devel}"
SRC_URI[x86_64_v2_rust-bigdecimal+serde_json-devel.sha256sum] = "75f3a2175abe40b003023811f6417a310de8fe28e8930fa4bad3943ae07e64ea"

URI_x86_64_v2_rust-bigdecimal+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bigdecimal+std-devel-0.4.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bigdecimal+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bigdecimal+std-devel}"
SRC_URI[x86_64_v2_rust-bigdecimal+std-devel.sha256sum] = "81cea7d74b70ca217f405ae67dbe0c8f7ddbe104a688c66e4e46c873b03bf850"

URI_x86_64_v2_rust-bigdecimal+string-only-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bigdecimal+string-only-devel-0.4.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bigdecimal+string-only-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bigdecimal+string-only-devel}"
SRC_URI[x86_64_v2_rust-bigdecimal+string-only-devel.sha256sum] = "edf4cc61989da58507bb83caa1b99ef0c6d0568dbf7d186089246ac70e72504b"

URI_x86_64_v2_rust-bigdecimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bigdecimal-devel-0.4.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bigdecimal-devel}"
SRC_URI[x86_64_v2_rust-bigdecimal-devel.sha256sum] = "47084404496117aec54552fecdfc2c238d33cb0584653b1eb58ed33957af61e8"

URI_aarch64_rust-bigdecimal+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bigdecimal+default-devel-0.4.9-1.el10_1.noarch.rpm;name=aarch64_rust-bigdecimal+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bigdecimal+default-devel}"
SRC_URI[aarch64_rust-bigdecimal+default-devel.sha256sum] = "f2e2d726bd83c8500f5ef7622c4b9bff1ba636a132639431df5e1cd12fdd838f"

URI_aarch64_rust-bigdecimal+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bigdecimal+serde-devel-0.4.9-1.el10_1.noarch.rpm;name=aarch64_rust-bigdecimal+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bigdecimal+serde-devel}"
SRC_URI[aarch64_rust-bigdecimal+serde-devel.sha256sum] = "4a0ee861ff0fc064326d6e4f947624037f83de54c9001acc10177ff39e86191a"

URI_aarch64_rust-bigdecimal+serde-json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bigdecimal+serde-json-devel-0.4.9-1.el10_1.noarch.rpm;name=aarch64_rust-bigdecimal+serde-json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bigdecimal+serde-json-devel}"
SRC_URI[aarch64_rust-bigdecimal+serde-json-devel.sha256sum] = "5d3e5f3168a6d80d72bc2c22f7d322c6486b6ce921ad954241523e1463a7fe95"

URI_aarch64_rust-bigdecimal+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bigdecimal+serde_json-devel-0.4.9-1.el10_1.noarch.rpm;name=aarch64_rust-bigdecimal+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bigdecimal+serde_json-devel}"
SRC_URI[aarch64_rust-bigdecimal+serde_json-devel.sha256sum] = "a7daac1b14419213f7c99c558f759bd684f3d68ef1ef2fca7b104a635165fd29"

URI_aarch64_rust-bigdecimal+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bigdecimal+std-devel-0.4.9-1.el10_1.noarch.rpm;name=aarch64_rust-bigdecimal+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bigdecimal+std-devel}"
SRC_URI[aarch64_rust-bigdecimal+std-devel.sha256sum] = "0a0cd34ff8ef74cc5a5f0a17906309393e4bb73ffb84ba786baaaa767bff2032"

URI_aarch64_rust-bigdecimal+string-only-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bigdecimal+string-only-devel-0.4.9-1.el10_1.noarch.rpm;name=aarch64_rust-bigdecimal+string-only-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bigdecimal+string-only-devel}"
SRC_URI[aarch64_rust-bigdecimal+string-only-devel.sha256sum] = "e01673ac30ca8a63702b54720dc10ae26c3f472c5a3090a531079b116e5cbcdc"

URI_aarch64_rust-bigdecimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bigdecimal-devel-0.4.9-1.el10_1.noarch.rpm;name=aarch64_rust-bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bigdecimal-devel}"
SRC_URI[aarch64_rust-bigdecimal-devel.sha256sum] = "791a5c669eb4e70f5e3d87dfa8df1c4544a4341a09807d1474dac0a358151152"

RDEPENDS:rust-bigdecimal+default-devel = " \
 cargo \
 rust-bigdecimal+std-devel \
 rust-bigdecimal-devel \
 "
RDEPENDS:rust-bigdecimal+serde-devel = " \
 cargo \
 rust-bigdecimal-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-bigdecimal+serde-json-devel = " \
 cargo \
 rust-bigdecimal+serde_json-devel \
 rust-bigdecimal-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-bigdecimal+serde_json-devel = " \
 cargo \
 rust-bigdecimal-devel \
 rust-serde_json+alloc-devel \
 rust-serde_json+arbitrary_precision-devel \
 rust-serde_json-devel \
 "
RDEPENDS:rust-bigdecimal+std-devel = " \
 cargo \
 rust-bigdecimal-devel \
 rust-num-bigint+std-devel \
 rust-num-integer+std-devel \
 rust-num-traits+std-devel \
 "
RDEPENDS:rust-bigdecimal+string-only-devel = " \
 cargo \
 rust-bigdecimal-devel \
 "
RDEPENDS:rust-bigdecimal-devel = " \
 cargo \
 rust-autocfg+default-devel \
 rust-libm+default-devel \
 rust-num-bigint-devel \
 rust-num-integer-devel \
 rust-num-traits-devel \
 "
