# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-knewstuff"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-knewstuff \
 kf6-knewstuff-devel \
 kf6-knewstuff-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-knewstuff-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c8aa184b53aa6cd320a8b921756ee96bf32048e4b5905da6fa9919d1f8b1be0b"

URI_x86_64_v2_kf6-knewstuff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knewstuff-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-knewstuff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knewstuff}"
SRC_URI[x86_64_v2_kf6-knewstuff.sha256sum] = "93af43badfbbfc1d993c2ea21b3136b02875832bc23aa94a3a9a562a111cd9a5"

URI_x86_64_v2_kf6-knewstuff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knewstuff-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-knewstuff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knewstuff-devel}"
SRC_URI[x86_64_v2_kf6-knewstuff-devel.sha256sum] = "87cc8db4863a61bf1b97416f89121dca6f9eeafa4b0fddf2ea69a5dd207c8bae"

URI_x86_64_v2_kf6-knewstuff-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knewstuff-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-knewstuff-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knewstuff-doc}"
SRC_URI[x86_64_v2_kf6-knewstuff-doc.sha256sum] = "6b875019c233894d669a3c75dbb0f2da91fcbad387f3ced9cf7e62feed53deea"

URI_aarch64_kf6-knewstuff = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knewstuff-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-knewstuff;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knewstuff}"
SRC_URI[aarch64_kf6-knewstuff.sha256sum] = "94df1037653fdadc001f3fb38a380cfdfc7dc5bdb11cc8becdb590334bcd2350"

URI_aarch64_kf6-knewstuff-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knewstuff-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-knewstuff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knewstuff-devel}"
SRC_URI[aarch64_kf6-knewstuff-devel.sha256sum] = "c52d461cb2d41a84f052e2ecfad2d20ff7258af229a68dba94e7f9c424eeb553"

URI_aarch64_kf6-knewstuff-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knewstuff-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-knewstuff-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knewstuff-doc}"
SRC_URI[aarch64_kf6-knewstuff-doc.sha256sum] = "938e55dbcb56786a669de7c400d992b24d55b8a7367c3babcf48af98c169c43b"

RDEPENDS:kf6-knewstuff = " \
 glibc \
 kf6-attica \
 kf6-filesystem \
 kf6-karchive \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kpackage \
 kf6-kwidgetsaddons \
 kf6-syndication \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-knewstuff-devel = " \
 cmake-filesystem \
 glibc \
 kf6-attica-devel \
 kf6-knewstuff \
 kf6-kservice-devel \
 kf6-kxmlgui-devel \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-knewstuff-doc = " \
 "
