# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kunitconversion"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kunitconversion \
 kf6-kunitconversion-devel \
 kf6-kunitconversion-doc \
 kf6-kunitconversion-html \
 python3-kf6-kunitconversion \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kunitconversion-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d4c456b8699c5550486d9c72312cfe027ab10eae6ad145e2b9172f8afc1d7a42"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kunitconversion-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kunitconversion;unpack=0"
SRC_URI[x86_64_v2_kf6-kunitconversion.sha256sum] = "208a97c1f95dc0d2a3e9688a61bd18835379039f780c660731c890bf77086959"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kunitconversion-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kunitconversion-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kunitconversion-devel.sha256sum] = "5e5c21d004884e53f1c5470a175148c0278e9ca51f59a1e6d2b45c65c14f68b5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kunitconversion-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kunitconversion-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kunitconversion-doc.sha256sum] = "921c1a076b82c52586bdc0b6165f26fe133f6fbe24a29c69119b1282a2fe6969"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kunitconversion-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kunitconversion-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kunitconversion-html.sha256sum] = "63ff3fce07c9701e17ae4c37c8ea58cd6d5ced3f2980a4e956c364195baa9850"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-kunitconversion-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-kunitconversion;unpack=0"
SRC_URI[x86_64_v2_python3-kf6-kunitconversion.sha256sum] = "fd531629646f11f28c9f895881cff128b90f946cc835d99c62ec749ac1943591"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kunitconversion-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kunitconversion;unpack=0"
SRC_URI[aarch64_kf6-kunitconversion.sha256sum] = "4720f9a31f84639f8d7551550cb259884f4e8a85fc55f8023d4c9e2978319513"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kunitconversion-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kunitconversion-devel;unpack=0"
SRC_URI[aarch64_kf6-kunitconversion-devel.sha256sum] = "7166cb6ed0a84c674c8162e75c0f2a54183cb152ffd98f068e2be8cb429aa414"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kunitconversion-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kunitconversion-doc;unpack=0"
SRC_URI[aarch64_kf6-kunitconversion-doc.sha256sum] = "32bdfa8afa1ff8ca00cbab5ea42b204464221be25003390d010abd20d4da2b80"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kunitconversion-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kunitconversion-html;unpack=0"
SRC_URI[aarch64_kf6-kunitconversion-html.sha256sum] = "b0a1df2172d129ca2fc45697726c2af4eec0e3305468a349c487f6e313cc091c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-kunitconversion-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_python3-kf6-kunitconversion;unpack=0"
SRC_URI[aarch64_python3-kf6-kunitconversion.sha256sum] = "46f441192a1d30692b5118795451888ad5bed8a9ba36b6732021c6093a32c6d7"

RDEPENDS:kf6-kunitconversion = " \
 glibc \
 kf6-filesystem \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kunitconversion-devel = " \
 cmake-filesystem \
 kf6-kunitconversion \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kunitconversion-doc = " \
 "
RDEPENDS:kf6-kunitconversion-html = " \
 "
RDEPENDS:python3-kf6-kunitconversion = " \
 glibc \
 kf6-kunitconversion \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 "
