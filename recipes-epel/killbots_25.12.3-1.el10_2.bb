# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "killbots"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 killbots \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/killbots-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f18d3a44eb53126685523d2f3022bcbe32eff9dd567c927d53eea2c36e8e4af7"

URI_x86_64_v2_killbots = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/killbots-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_killbots;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_killbots}"
SRC_URI[x86_64_v2_killbots.sha256sum] = "1226898f1f797073942fde0cb4295ad7b4710b4a743bf13977c6aff5cb44c815"

URI_aarch64_killbots = "${EPEL_MIRROR}/aarch64/Packages/k/killbots-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_killbots;unpack=0"
SRC_URI:append = " ${URI_aarch64_killbots}"
SRC_URI[aarch64_killbots.sha256sum] = "2a0dd452751414df1efedd5b8c6a337da7a0d148ea8c738b74a4bc1498913dfc"

RDEPENDS:killbots = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
