# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-validate"
PV = "0.9.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-validate+default-devel \
 rust-gix-validate-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-validate-0.9.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "541e09f4518e90c0fe4e0e0ce047d9b1ae1d5294d1fc49dbeaa85487464f5e23"

URI_x86_64_v2_rust-gix-validate+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-validate+default-devel-0.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-validate+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-validate+default-devel}"
SRC_URI[x86_64_v2_rust-gix-validate+default-devel.sha256sum] = "4d446668cdc1b7fe1d30d7ffe5e3a771f6bc0a619707327edbc8663eac25c474"

URI_x86_64_v2_rust-gix-validate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-validate-devel-0.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-validate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-validate-devel}"
SRC_URI[x86_64_v2_rust-gix-validate-devel.sha256sum] = "d75cb654bc5444df0074031ccdf2bfe9eefc64997ef17b228bbd160afcc9317c"

URI_aarch64_rust-gix-validate+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-validate+default-devel-0.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-gix-validate+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-validate+default-devel}"
SRC_URI[aarch64_rust-gix-validate+default-devel.sha256sum] = "99fa64737098da417ddf7c2f18cd48662a6408bd964181e69d40b331d2c3ca57"

URI_aarch64_rust-gix-validate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-validate-devel-0.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-gix-validate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-validate-devel}"
SRC_URI[aarch64_rust-gix-validate-devel.sha256sum] = "bff9611972e7b2152dc559fd866e99ca032f87d4594c666f3b02d5453346329c"

RDEPENDS:rust-gix-validate+default-devel = " \
 cargo \
 rust-gix-validate-devel \
 "
RDEPENDS:rust-gix-validate-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-thiserror+default-devel \
 "
