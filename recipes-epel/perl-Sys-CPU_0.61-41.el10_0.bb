# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sys-CPU"
PV = "0.61"
PR = "41.el10_0"
PACKAGES = " \
 perl-Sys-CPU \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Sys-CPU-0.61-41.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f84eb8d84d3b09aa49acc420d5dbb7e63b5c03e448762a3172255d82608c2a5"

URI_x86_64_v2_perl-Sys-CPU = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sys-CPU-0.61-41.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Sys-CPU;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sys-CPU}"
SRC_URI[x86_64_v2_perl-Sys-CPU.sha256sum] = "fec73757567e1184384cec45be8b96e5d01fc68bad33ee94a14f28a698d8533b"

URI_aarch64_perl-Sys-CPU = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Sys-CPU-0.61-41.el10_0.aarch64.rpm;name=aarch64_perl-Sys-CPU;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sys-CPU}"
SRC_URI[aarch64_perl-Sys-CPU.sha256sum] = "ea7e97f931773a1408e176f53fc0666e916edd1ce251dec09709eaeaec41f1dc"

RDEPENDS:perl-Sys-CPU = " \
 glibc \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
