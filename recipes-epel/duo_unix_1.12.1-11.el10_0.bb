# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "duo_unix"
PV = "1.12.1"
PR = "11.el10_0"
PACKAGES = " \
 duo_unix \
 duo_unix-devel \
 duo_unix-doc \
 duo_unix-selinux \
 pam_duo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/duo_unix-1.12.1-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "95a661888120689a06dde71c6ed3b5a902989e709adb2b95b2012a1b89dbeec2"

URI_x86_64_v2_duo_unix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/duo_unix-1.12.1-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_duo_unix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_duo_unix}"
SRC_URI[x86_64_v2_duo_unix.sha256sum] = "a61ca92de07502749b5cc0386845b9555eee958ac12c7f0e34f8329742748842"

URI_x86_64_v2_duo_unix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/duo_unix-devel-1.12.1-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_duo_unix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_duo_unix-devel}"
SRC_URI[x86_64_v2_duo_unix-devel.sha256sum] = "c8b61927ae4d100b1c3a0cd0654e840daca132ac96bf1cde18c31e36c4faf3e7"

URI_x86_64_v2_duo_unix-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/duo_unix-doc-1.12.1-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_duo_unix-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_duo_unix-doc}"
SRC_URI[x86_64_v2_duo_unix-doc.sha256sum] = "841ccc2e3e5db5419f27142f007996974b241a300417e4de960cad1a942a9cb7"

URI_x86_64_v2_duo_unix-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/duo_unix-selinux-1.12.1-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_duo_unix-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_duo_unix-selinux}"
SRC_URI[x86_64_v2_duo_unix-selinux.sha256sum] = "e9d9380d54f0fc22fe2da31d5a6e370157543bbe3daf7bc50ef224352bfd89f5"

URI_x86_64_v2_pam_duo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pam_duo-1.12.1-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pam_duo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam_duo}"
SRC_URI[x86_64_v2_pam_duo.sha256sum] = "96374609dcfe1627c1894f029b9f47bcc80472123fcd668aebf6c2c50e0d8809"

URI_aarch64_duo_unix = "${EPEL_MIRROR}/aarch64/Packages/d/duo_unix-1.12.1-11.el10_0.aarch64.rpm;name=aarch64_duo_unix;unpack=0"
SRC_URI:append = " ${URI_aarch64_duo_unix}"
SRC_URI[aarch64_duo_unix.sha256sum] = "2656d6acfa188ce83bb43f51ee590023a14fb52fa50eef4960c56bd0c5b9f22b"

URI_aarch64_duo_unix-devel = "${EPEL_MIRROR}/aarch64/Packages/d/duo_unix-devel-1.12.1-11.el10_0.aarch64.rpm;name=aarch64_duo_unix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_duo_unix-devel}"
SRC_URI[aarch64_duo_unix-devel.sha256sum] = "c8527cc06727b95a0b69409446d887e05356662853872e6dee83102c9bd20df0"

URI_aarch64_duo_unix-doc = "${EPEL_MIRROR}/aarch64/Packages/d/duo_unix-doc-1.12.1-11.el10_0.noarch.rpm;name=aarch64_duo_unix-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_duo_unix-doc}"
SRC_URI[aarch64_duo_unix-doc.sha256sum] = "bbc56521af380626d4056fba028d088dc86b450bf4f2ecb69d57ec99fe6be2e9"

URI_aarch64_duo_unix-selinux = "${EPEL_MIRROR}/aarch64/Packages/d/duo_unix-selinux-1.12.1-11.el10_0.aarch64.rpm;name=aarch64_duo_unix-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_duo_unix-selinux}"
SRC_URI[aarch64_duo_unix-selinux.sha256sum] = "06892bfa5eb17024ccca825f6d5c85c73d0365a84cdf6bb59ccbf1320999c01f"

URI_aarch64_pam_duo = "${EPEL_MIRROR}/aarch64/Packages/p/pam_duo-1.12.1-11.el10_0.aarch64.rpm;name=aarch64_pam_duo;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam_duo}"
SRC_URI[aarch64_pam_duo.sha256sum] = "3ce6393f12cc7fadd37e0ac0d6db83cd090d038249d1e9b1e152bf6732c68166"

RDEPENDS:duo_unix = " \
 bash \
 glibc \
 openssl-libs \
 "
RDEPENDS:duo_unix-devel = " \
 duo_unix \
 openssl-devel \
 pam_duo \
 pkgconf-pkg-config \
 "
RDEPENDS:duo_unix-doc = " \
 "
RDEPENDS:duo_unix-selinux = " \
 bash \
 libselinux-utils \
 pam_duo \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:pam_duo = " \
 duo_unix-selinux \
 glibc \
 openssl-libs \
 pam \
 pam-libs \
 "
