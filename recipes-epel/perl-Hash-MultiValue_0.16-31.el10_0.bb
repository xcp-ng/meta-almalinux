# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Hash-MultiValue"
PV = "0.16"
PR = "31.el10_0"
PACKAGES = " \
 perl-Hash-MultiValue \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Hash-MultiValue-0.16-31.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b46004c211ae8626f972327e4ba05fed8afff88376b9bd2e8167341f1ea112d6"

URI_x86_64_v2_perl-Hash-MultiValue = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Hash-MultiValue-0.16-31.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Hash-MultiValue;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Hash-MultiValue}"
SRC_URI[x86_64_v2_perl-Hash-MultiValue.sha256sum] = "d857018dc6c63c1b8bc3a853f8b8d4b3dd3d3fb64358f7c67e174ee86dc445bc"

URI_aarch64_perl-Hash-MultiValue = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Hash-MultiValue-0.16-31.el10_0.noarch.rpm;name=aarch64_perl-Hash-MultiValue;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Hash-MultiValue}"
SRC_URI[aarch64_perl-Hash-MultiValue.sha256sum] = "73254cc78dbe5912e186816f5684d00a5483de46423de448180f7e9f172b8ab4"

RDEPENDS:perl-Hash-MultiValue = " \
 perl-Carp \
 perl-Scalar-List-Utils \
 perl-constant \
 perl-libs \
 "
