# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "notmuch"
PV = "0.39"
PR = "7.el10_1"
PACKAGES = " \
 emacs-notmuch \
 notmuch \
 notmuch-devel \
 notmuch-git \
 python3-notmuch2 \
 ruby-notmuch \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/notmuch-0.39-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1a2ade155e1a43ddd48eadd1b075bf0a287f676ec5d566a788dc556bcbde607"

URI_x86_64_v2_emacs-notmuch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/emacs-notmuch-0.39-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_emacs-notmuch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_emacs-notmuch}"
SRC_URI[x86_64_v2_emacs-notmuch.sha256sum] = "43f0e01d50858d6382aadcf734e1df32440074cc7f52e6c90139eea53ec9f735"

URI_x86_64_v2_notmuch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/notmuch-0.39-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_notmuch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_notmuch}"
SRC_URI[x86_64_v2_notmuch.sha256sum] = "de4310d9d474a7a5cf41dac300882098ac8900e18b1ca84bfd1e2a3f0c75ec18"

URI_x86_64_v2_notmuch-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/notmuch-devel-0.39-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_notmuch-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_notmuch-devel}"
SRC_URI[x86_64_v2_notmuch-devel.sha256sum] = "c3054ee0c2203aafc185c48a7df35485eb91e853ab5e469599ab3f9712d3c927"

URI_x86_64_v2_notmuch-git = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/notmuch-git-0.39-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_notmuch-git;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_notmuch-git}"
SRC_URI[x86_64_v2_notmuch-git.sha256sum] = "f1569ca6e772c68e7068091ba3f107e2eaecf6b16d2a6231a8cb19e2029dc2db"

URI_x86_64_v2_python3-notmuch2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-notmuch2-0.39-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-notmuch2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-notmuch2}"
SRC_URI[x86_64_v2_python3-notmuch2.sha256sum] = "2d62103ca2713f961a895b8c3e5088f37107d3708b40e6c72da356e9c925efb5"

URI_x86_64_v2_ruby-notmuch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-notmuch-0.39-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ruby-notmuch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-notmuch}"
SRC_URI[x86_64_v2_ruby-notmuch.sha256sum] = "56c3eb0b0dfd749ca505ac3c2c70dc71ed44aa1fd9944c97714939df90593c30"

URI_aarch64_emacs-notmuch = "${EPEL_MIRROR}/aarch64/Packages/e/emacs-notmuch-0.39-7.el10_1.noarch.rpm;name=aarch64_emacs-notmuch;unpack=0"
SRC_URI:append = " ${URI_aarch64_emacs-notmuch}"
SRC_URI[aarch64_emacs-notmuch.sha256sum] = "10afaac454fac90f5e77c7883a88c239c4b11b5d536eda7a92eb1f57364a8bd4"

URI_aarch64_notmuch = "${EPEL_MIRROR}/aarch64/Packages/n/notmuch-0.39-7.el10_1.aarch64.rpm;name=aarch64_notmuch;unpack=0"
SRC_URI:append = " ${URI_aarch64_notmuch}"
SRC_URI[aarch64_notmuch.sha256sum] = "1719a66856847b9cbe25f4739bd69b45c7471df841ce84bad3a2fc12cc226ed5"

URI_aarch64_notmuch-devel = "${EPEL_MIRROR}/aarch64/Packages/n/notmuch-devel-0.39-7.el10_1.aarch64.rpm;name=aarch64_notmuch-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_notmuch-devel}"
SRC_URI[aarch64_notmuch-devel.sha256sum] = "c159c327ca980f8654622960826f0059dcf3358a5ab93de624a1d4f15d204387"

URI_aarch64_notmuch-git = "${EPEL_MIRROR}/aarch64/Packages/n/notmuch-git-0.39-7.el10_1.aarch64.rpm;name=aarch64_notmuch-git;unpack=0"
SRC_URI:append = " ${URI_aarch64_notmuch-git}"
SRC_URI[aarch64_notmuch-git.sha256sum] = "82aa3a5fad9ab0f09078c01381c7430a0fdf3dee1e27ea2af564f64e9aa235be"

URI_aarch64_python3-notmuch2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-notmuch2-0.39-7.el10_1.aarch64.rpm;name=aarch64_python3-notmuch2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-notmuch2}"
SRC_URI[aarch64_python3-notmuch2.sha256sum] = "05473760fff16b06fb23fb5d6803459e9f4c50fb07e3591c89b5cd57f2f21a7a"

URI_aarch64_ruby-notmuch = "${EPEL_MIRROR}/aarch64/Packages/r/ruby-notmuch-0.39-7.el10_1.aarch64.rpm;name=aarch64_ruby-notmuch;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-notmuch}"
SRC_URI[aarch64_ruby-notmuch.sha256sum] = "0838d2e9cf66487e048f4a02dc5d4e619ee4d8b6f0f2757e262d102bee7bebaf"

RDEPENDS:emacs-notmuch = " \
 bash \
 notmuch \
 virtual/emacs_bin__ge_29.4 \
 "
RDEPENDS:notmuch = " \
 glib2 \
 glibc \
 gmime30 \
 info \
 libgcc \
 libstdc++ \
 libtalloc \
 sfsexp \
 xapian-core-libs \
 zlib-ng-compat \
 "
RDEPENDS:notmuch-devel = " \
 notmuch \
 "
RDEPENDS:notmuch-git = " \
 git-core \
 notmuch \
 python3 \
 "
RDEPENDS:python3-notmuch2 = " \
 glibc \
 notmuch \
 python3 \
 python3-cffi \
 "
RDEPENDS:ruby-notmuch = " \
 glibc \
 libtalloc \
 notmuch \
 ruby-libs \
 "
