# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "korganizer"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 korganizer \
 korganizer-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/korganizer-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d31d2891a3e308b3d112865d12819e73abf5d33e9b639a24ff6c6dc1360c2d2c"

URI_x86_64_v2_korganizer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/korganizer-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_korganizer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_korganizer}"
SRC_URI[x86_64_v2_korganizer.sha256sum] = "bea0e4b6506f40a930bd1bd4dc72a348a1b2c16b9bcfa9c5308cf5eac4c9c587"

URI_x86_64_v2_korganizer-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/korganizer-libs-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_korganizer-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_korganizer-libs}"
SRC_URI[x86_64_v2_korganizer-libs.sha256sum] = "3f0ca119ddd186ea0e0674e9a5b27c4654b1760cc23bb2f6abdba0fc92ab1935"

URI_aarch64_korganizer = "${EPEL_MIRROR}/aarch64/Packages/k/korganizer-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_korganizer;unpack=0"
SRC_URI:append = " ${URI_aarch64_korganizer}"
SRC_URI[aarch64_korganizer.sha256sum] = "233be6bd031f2e729772c275ab861bae798eceaf33c6393926f3cbae7b527ef7"

URI_aarch64_korganizer-libs = "${EPEL_MIRROR}/aarch64/Packages/k/korganizer-libs-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_korganizer-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_korganizer-libs}"
SRC_URI[aarch64_korganizer-libs.sha256sum] = "4eebf87c71b519e6d96f1e59dd34915dc9a419390b40f3aaf20a12f4f37c8d37"

RDEPENDS:korganizer = " \
 akonadi-server \
 glibc \
 kdepim-runtime \
 kf6-kcalendarcore \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kparts \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kontactinterface \
 korganizer-libs \
 libgcc \
 libkdepim \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:korganizer-libs = " \
 akonadi-calendar \
 akonadi-contacts \
 akonadi-server \
 calendarsupport \
 eventviews \
 glibc \
 incidenceeditor \
 kcalutils \
 kf6-kcalendarcore \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-knewstuff \
 kf6-kparts \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kidentitymanagement \
 kmailtransport \
 kmime \
 kontactinterface \
 korganizer \
 libgcc \
 libkdepim \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
