# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-backend"
PV = "0.3.17"
PR = "1.el10_3"
PACKAGES = " \
 rust-wayland-backend+client_system-devel \
 rust-wayland-backend+default-devel \
 rust-wayland-backend+dlopen-devel \
 rust-wayland-backend+libwayland_client_1_23-devel \
 rust-wayland-backend+libwayland_server_1_22-devel \
 rust-wayland-backend+libwayland_server_1_23-devel \
 rust-wayland-backend+log-devel \
 rust-wayland-backend+raw-window-handle-devel \
 rust-wayland-backend+rwh_06-devel \
 rust-wayland-backend+server_system-devel \
 rust-wayland-backend-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-backend-0.3.17-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7f2be558c40df2430edf08025b45a8bcfa60f1f89f3f8f1bd43a26be2620aa16"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+client_system-devel-0.3.17-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+client_system-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-backend+client_system-devel.sha256sum] = "9a80d0c8af409302582f7e5b4024c982779721f8b33f92db50cd6a645d29c653"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+default-devel-0.3.17-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-backend+default-devel.sha256sum] = "6fa6145970f37e1c74442bdb4955057035d0afab4621361f4e25242fd05fcc00"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+dlopen-devel-0.3.17-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+dlopen-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-backend+dlopen-devel.sha256sum] = "77693602ed01722128626450d896d5a90742b813642525fa8bdaf648a1a64b81"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+libwayland_client_1_23-devel-0.3.17-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+libwayland_client_1_23-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-backend+libwayland_client_1_23-devel.sha256sum] = "c847fb4bc78e150123a376914475e0562e0153fa876d91f379db64397dc171cb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+libwayland_server_1_22-devel-0.3.17-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+libwayland_server_1_22-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-backend+libwayland_server_1_22-devel.sha256sum] = "38218eb30d4cfcf227b5b0265f859639bc4429222cdf4bdad65df6e295d71865"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+libwayland_server_1_23-devel-0.3.17-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+libwayland_server_1_23-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-backend+libwayland_server_1_23-devel.sha256sum] = "8bc62bf530c8dc5d4465fc3591aea8ecaa276bbf504c2f94aebe617587f61449"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+log-devel-0.3.17-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+log-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-backend+log-devel.sha256sum] = "528410fedecd3844281a22d755b6bfb4d72b0d1912259330995a444b65b31c11"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+raw-window-handle-devel-0.3.17-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+raw-window-handle-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-backend+raw-window-handle-devel.sha256sum] = "ce2fe8e1ade464d72283f0cc8595911924c3363201a1f4ee798a0f8d23a5ed1e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+rwh_06-devel-0.3.17-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+rwh_06-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-backend+rwh_06-devel.sha256sum] = "470d3f763a35baf0e28dd46785dd09987f3186c6956aa0551c29cde08000ade7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+server_system-devel-0.3.17-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+server_system-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-backend+server_system-devel.sha256sum] = "f412b33a0d4fa20e11ffcf654ea1b0ff49b50f8ca1c51f4498a5018d723f2cfc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend-devel-0.3.17-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-backend-devel.sha256sum] = "390144d16fff5abd299a9d9ef6463419c7c17d56980d8d7df7b614e0697456a8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+client_system-devel-0.3.17-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-backend+client_system-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-backend+client_system-devel.sha256sum] = "8af942505c741e216ad8e90f8101e9f35ea0cb687edf9d6286aac3164574148b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+default-devel-0.3.17-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-backend+default-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-backend+default-devel.sha256sum] = "303e01763064216c56c3c8f230d1467d2e9e73c45c4148dfeea64b17e978b9a0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+dlopen-devel-0.3.17-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-backend+dlopen-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-backend+dlopen-devel.sha256sum] = "a097d17e941970aa545a1e99ee0f64e90740d1b3594551b14d51ce0c896a7dd0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+libwayland_client_1_23-devel-0.3.17-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-backend+libwayland_client_1_23-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-backend+libwayland_client_1_23-devel.sha256sum] = "afb6ae273a56fc6a5574df3e09c8e3e1384bfa5af5f6b577256a5a26b54bb5de"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+libwayland_server_1_22-devel-0.3.17-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-backend+libwayland_server_1_22-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-backend+libwayland_server_1_22-devel.sha256sum] = "77468e9d681c3887658d3443c77e5ed3c40b8b8a4d2bbcc536885875c641ee0a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+libwayland_server_1_23-devel-0.3.17-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-backend+libwayland_server_1_23-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-backend+libwayland_server_1_23-devel.sha256sum] = "e03d888d0738b07e91b3fc867fc17ecac8db6aa9aefb7f84ef3def4961b6dfa5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+log-devel-0.3.17-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-backend+log-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-backend+log-devel.sha256sum] = "32c0d692dbd8a998c84285d8289fc48fb7fbb18d68d0fd4e3220503f5605ee72"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+raw-window-handle-devel-0.3.17-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-backend+raw-window-handle-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-backend+raw-window-handle-devel.sha256sum] = "8ce2ed2d8737f69942efed17cbb005df6782515b53182e5304e881d8f331df4c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+rwh_06-devel-0.3.17-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-backend+rwh_06-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-backend+rwh_06-devel.sha256sum] = "2de8c14fd00614c4862dfa97ee430049b872bc2998b80595c0a6ff348c52be46"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+server_system-devel-0.3.17-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-backend+server_system-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-backend+server_system-devel.sha256sum] = "0e2000684ec3c67b411aa0eeac1df6222d917da4fcea160a84fd9e230b5670e9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend-devel-0.3.17-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-backend-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-backend-devel.sha256sum] = "ec203f601877030e53f7b3b7d9883d51defecd943049b5d41dc9ca4fb873dbbe"

RDEPENDS:rust-wayland-backend+client_system-devel = " \
 cargo \
 rust-scoped-tls+default-devel \
 rust-wayland-backend-devel \
 rust-wayland-sys+client-devel \
 "
RDEPENDS:rust-wayland-backend+default-devel = " \
 cargo \
 rust-wayland-backend-devel \
 "
RDEPENDS:rust-wayland-backend+dlopen-devel = " \
 cargo \
 rust-wayland-backend-devel \
 rust-wayland-sys+dlopen-devel \
 "
RDEPENDS:rust-wayland-backend+libwayland_client_1_23-devel = " \
 cargo \
 rust-wayland-backend-devel \
 rust-wayland-sys+libwayland_client_1_23-devel \
 "
RDEPENDS:rust-wayland-backend+libwayland_server_1_22-devel = " \
 cargo \
 rust-wayland-backend-devel \
 rust-wayland-sys+libwayland_server_1_22-devel \
 "
RDEPENDS:rust-wayland-backend+libwayland_server_1_23-devel = " \
 cargo \
 rust-wayland-backend+libwayland_server_1_22-devel \
 rust-wayland-backend-devel \
 rust-wayland-sys+libwayland_server_1_23-devel \
 "
RDEPENDS:rust-wayland-backend+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-wayland-backend-devel \
 "
RDEPENDS:rust-wayland-backend+raw-window-handle-devel = " \
 cargo \
 rust-raw-window-handle0.5+default-devel \
 rust-wayland-backend-devel \
 "
RDEPENDS:rust-wayland-backend+rwh_06-devel = " \
 cargo \
 rust-raw-window-handle+default-devel \
 rust-wayland-backend-devel \
 "
RDEPENDS:rust-wayland-backend+server_system-devel = " \
 cargo \
 rust-scoped-tls+default-devel \
 rust-wayland-backend-devel \
 rust-wayland-sys+server-devel \
 "
RDEPENDS:rust-wayland-backend-devel = " \
 cargo \
 rust \
 rust-cc+default-devel \
 rust-downcast-rs1+default-devel \
 rust-rustix+default-devel \
 rust-rustix+event-devel \
 rust-rustix+fs-devel \
 rust-rustix+net-devel \
 rust-rustix+process-devel \
 rust-smallvec+const_generics-devel \
 rust-smallvec+const_new-devel \
 rust-smallvec+default-devel \
 rust-smallvec+union-devel \
 rust-wayland-sys+default-devel \
 "
