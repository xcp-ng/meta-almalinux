# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libreplaygain"
PV = "0"
PR = "0.27.20110810svn475.el10_0"
PACKAGES = " \
 libreplaygain \
 libreplaygain-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libreplaygain-0-0.27.20110810svn475.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "217c8d03030f241719216a834a1b80a1dbaad7198cced074a25fd45fa8b6bef5"

URI_x86_64_v2_libreplaygain = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libreplaygain-0-0.27.20110810svn475.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libreplaygain;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libreplaygain}"
SRC_URI[x86_64_v2_libreplaygain.sha256sum] = "0c8bd106774482f3dc26ee167866ae34717932271fd1d5ce0980c2f929891880"

URI_x86_64_v2_libreplaygain-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libreplaygain-devel-0-0.27.20110810svn475.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libreplaygain-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libreplaygain-devel}"
SRC_URI[x86_64_v2_libreplaygain-devel.sha256sum] = "d9201fd6ccb2f6b853e1b230092895578ed5c7a4d0dc55a7c69600e551132bbc"

URI_aarch64_libreplaygain = "${EPEL_MIRROR}/aarch64/Packages/l/libreplaygain-0-0.27.20110810svn475.el10_0.aarch64.rpm;name=aarch64_libreplaygain;unpack=0"
SRC_URI:append = " ${URI_aarch64_libreplaygain}"
SRC_URI[aarch64_libreplaygain.sha256sum] = "2573904e7ae03c89f99b22e013fa5506dd00c9446888a74d5f0b4d2e65e31cf8"

URI_aarch64_libreplaygain-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libreplaygain-devel-0-0.27.20110810svn475.el10_0.aarch64.rpm;name=aarch64_libreplaygain-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libreplaygain-devel}"
SRC_URI[aarch64_libreplaygain-devel.sha256sum] = "e9fee9710036f913fc361e1f0e6d6507d43580cb594b8615e963d6209231994a"

RDEPENDS:libreplaygain = " \
 glibc \
 "
RDEPENDS:libreplaygain-devel = " \
 libreplaygain \
 "
