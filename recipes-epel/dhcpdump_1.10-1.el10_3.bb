# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dhcpdump"
PV = "1.10"
PR = "1.el10_3"
PACKAGES = " \
 dhcpdump \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/dhcpdump-1.10-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4f952505e33a9d924518df6a1a78fdaaf26ce6d40641d8d40ac46b7adb69387d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dhcpdump-1.10-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dhcpdump;unpack=0"
SRC_URI[x86_64_v2_dhcpdump.sha256sum] = "4259c417b54b1ee60efb793224e4bb5be14579ab6205ff586ad274fcf1f2a11a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dhcpdump-1.10-1.el10_3.aarch64.rpm;name=aarch64_dhcpdump;unpack=0"
SRC_URI[aarch64_dhcpdump.sha256sum] = "b72d27d0b0101a852a3ec1d62713b6998ae7684cdd89516e4e18612da54c2016"

RDEPENDS:dhcpdump = " \
 glibc \
 libpcap \
 "
