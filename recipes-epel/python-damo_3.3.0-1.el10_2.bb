# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-damo"
PV = "3.3.0"
PR = "1.el10_2"
PACKAGES = " \
 damo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-damo-3.3.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "39b36820f73e8ced453b3b8497b7af0954fef7c86d4813546f42b6952414f313"

URI_x86_64_v2_damo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/damo-3.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_damo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_damo}"
SRC_URI[x86_64_v2_damo.sha256sum] = "d5f357c0703a481b16085cdc1db09a73ff84d6a8b6bec5753fd8d3cba13fc5f9"

URI_aarch64_damo = "${EPEL_MIRROR}/aarch64/Packages/d/damo-3.3.0-1.el10_2.noarch.rpm;name=aarch64_damo;unpack=0"
SRC_URI:append = " ${URI_aarch64_damo}"
SRC_URI[aarch64_damo.sha256sum] = "a12faa8ed16c038b71886137edd870a0468870cafcac4ad354fc2ba0a9e3f699"

RDEPENDS:damo = " \
 python3 \
 "
