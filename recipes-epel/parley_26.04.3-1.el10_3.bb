# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "parley"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 parley \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/parley-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0d62a72e8b76716df77f30f0ae7fe609d2c232b221bd8e18a1907e742f92146e"

URI_x86_64_v2_parley = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/parley-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_parley;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_parley}"
SRC_URI[x86_64_v2_parley.sha256sum] = "ec1f496a47bdbe07f5319f0160ee79d14b77c823a9f2a9f74328e711487802be"

URI_aarch64_parley = "${EPEL_MIRROR}/aarch64/Packages/p/parley-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_parley;unpack=0"
SRC_URI:append = " ${URI_aarch64_parley}"
SRC_URI[aarch64_parley.sha256sum] = "af047117d7bb85dac37bc06e30eb76c6900834869c3476a28c0e7625abab5471"

RDEPENDS:parley = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 libkeduvocdocument \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
 qt6-qtwebengine \
 "
