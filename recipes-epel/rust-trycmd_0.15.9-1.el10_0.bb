# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-trycmd"
PV = "0.15.9"
PR = "1.el10_0"
PACKAGES = " \
 rust-trycmd+color-auto-devel \
 rust-trycmd+color-devel \
 rust-trycmd+debug-devel \
 rust-trycmd+default-devel \
 rust-trycmd+diff-devel \
 rust-trycmd+escargot-devel \
 rust-trycmd+examples-devel \
 rust-trycmd+filesystem-devel \
 rust-trycmd+schema-devel \
 rust-trycmd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-trycmd-0.15.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca472ab39ac0cadb66f0552044a08ae8ff0fdc5045ac34bdb35d8964348a7129"

URI_x86_64_v2_rust-trycmd+color-auto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+color-auto-devel-0.15.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd+color-auto-devel}"
SRC_URI[x86_64_v2_rust-trycmd+color-auto-devel.sha256sum] = "7f12a26c10794018368cb558f63168ed89e1588b5a58241d143dc98cef6ec86a"

URI_x86_64_v2_rust-trycmd+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+color-devel-0.15.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd+color-devel}"
SRC_URI[x86_64_v2_rust-trycmd+color-devel.sha256sum] = "7e699da0a26874c074b7de5899b83dca13cbe5103ba2f167fd2592d4a71ef004"

URI_x86_64_v2_rust-trycmd+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+debug-devel-0.15.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd+debug-devel}"
SRC_URI[x86_64_v2_rust-trycmd+debug-devel.sha256sum] = "5be9c664b0d4a1906e21997d2efcbda01482ea53cc866426b6d17bad7f0256e0"

URI_x86_64_v2_rust-trycmd+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+default-devel-0.15.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd+default-devel}"
SRC_URI[x86_64_v2_rust-trycmd+default-devel.sha256sum] = "8e0fd1743a565830bcf1509cb43a12f32f3da906afae505c15e2ca0676fb2acc"

URI_x86_64_v2_rust-trycmd+diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+diff-devel-0.15.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd+diff-devel}"
SRC_URI[x86_64_v2_rust-trycmd+diff-devel.sha256sum] = "2dd89f5452c34bb930bbb34d11899778895bb0598b8866ec23c512276cff808b"

URI_x86_64_v2_rust-trycmd+escargot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+escargot-devel-0.15.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+escargot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd+escargot-devel}"
SRC_URI[x86_64_v2_rust-trycmd+escargot-devel.sha256sum] = "955a8cd7a078651bc37c588256f848c1558e7dd4c0b1987ce8d58f5c3a0b159f"

URI_x86_64_v2_rust-trycmd+examples-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+examples-devel-0.15.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+examples-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd+examples-devel}"
SRC_URI[x86_64_v2_rust-trycmd+examples-devel.sha256sum] = "29349d2dd2ec860d7deac50e5a061626f2a15c62f21b4c5d775f95bd849fe44b"

URI_x86_64_v2_rust-trycmd+filesystem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+filesystem-devel-0.15.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+filesystem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd+filesystem-devel}"
SRC_URI[x86_64_v2_rust-trycmd+filesystem-devel.sha256sum] = "5f36af2b974e0372fdecb42d54edfc48b618769369c8f3d7ab1800bf97ddae36"

URI_x86_64_v2_rust-trycmd+schema-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+schema-devel-0.15.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+schema-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd+schema-devel}"
SRC_URI[x86_64_v2_rust-trycmd+schema-devel.sha256sum] = "79781b5b0672538a7f0a4107dbed50f06dd3cb0d395c2cba2c64dccd885e882f"

URI_x86_64_v2_rust-trycmd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd-devel-0.15.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd-devel}"
SRC_URI[x86_64_v2_rust-trycmd-devel.sha256sum] = "8f7d809241eb36623b718625daed2c41e7f07918794888a217b7c8fabec5dd87"

URI_aarch64_rust-trycmd+color-auto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+color-auto-devel-0.15.9-1.el10_0.noarch.rpm;name=aarch64_rust-trycmd+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd+color-auto-devel}"
SRC_URI[aarch64_rust-trycmd+color-auto-devel.sha256sum] = "1b18b8b1f4bb9f841f53946ae1e0e74ae5163df8fef7e4ea3364d296112ab759"

URI_aarch64_rust-trycmd+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+color-devel-0.15.9-1.el10_0.noarch.rpm;name=aarch64_rust-trycmd+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd+color-devel}"
SRC_URI[aarch64_rust-trycmd+color-devel.sha256sum] = "8a4fb75e225e8aed9c857fdabab5c76f489a7f82fcffab0c59c47151340b77f3"

URI_aarch64_rust-trycmd+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+debug-devel-0.15.9-1.el10_0.noarch.rpm;name=aarch64_rust-trycmd+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd+debug-devel}"
SRC_URI[aarch64_rust-trycmd+debug-devel.sha256sum] = "b48b1505a8e386e7fb499a2cc8414c83ebeeb08ff341c55ad0dfb8dc6535f200"

URI_aarch64_rust-trycmd+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+default-devel-0.15.9-1.el10_0.noarch.rpm;name=aarch64_rust-trycmd+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd+default-devel}"
SRC_URI[aarch64_rust-trycmd+default-devel.sha256sum] = "06c335611deb980d651e5e0e68d1a27a2e91e1099d007b5d1bf9f2ff040210f8"

URI_aarch64_rust-trycmd+diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+diff-devel-0.15.9-1.el10_0.noarch.rpm;name=aarch64_rust-trycmd+diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd+diff-devel}"
SRC_URI[aarch64_rust-trycmd+diff-devel.sha256sum] = "90e933f9775c131e17373936b62eecf73f2db6010949dcb31437cce8c97e8d60"

URI_aarch64_rust-trycmd+escargot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+escargot-devel-0.15.9-1.el10_0.noarch.rpm;name=aarch64_rust-trycmd+escargot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd+escargot-devel}"
SRC_URI[aarch64_rust-trycmd+escargot-devel.sha256sum] = "1dd856b20bf02d8e0ff52d81c93ed6addd9e8091303e86526d81cb4270e9442b"

URI_aarch64_rust-trycmd+examples-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+examples-devel-0.15.9-1.el10_0.noarch.rpm;name=aarch64_rust-trycmd+examples-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd+examples-devel}"
SRC_URI[aarch64_rust-trycmd+examples-devel.sha256sum] = "b67d8faae71355680662128f3af74e7d85f6bd77e511ea3919d26a0d7c4f7455"

URI_aarch64_rust-trycmd+filesystem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+filesystem-devel-0.15.9-1.el10_0.noarch.rpm;name=aarch64_rust-trycmd+filesystem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd+filesystem-devel}"
SRC_URI[aarch64_rust-trycmd+filesystem-devel.sha256sum] = "95975c7b00d22bae8512938c5e530c2460f2b641256514bb0004802f9f803c87"

URI_aarch64_rust-trycmd+schema-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+schema-devel-0.15.9-1.el10_0.noarch.rpm;name=aarch64_rust-trycmd+schema-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd+schema-devel}"
SRC_URI[aarch64_rust-trycmd+schema-devel.sha256sum] = "59faca53efd34503cc02187f67a6651052176997f593c50d2b7ad77a6d95743e"

URI_aarch64_rust-trycmd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd-devel-0.15.9-1.el10_0.noarch.rpm;name=aarch64_rust-trycmd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd-devel}"
SRC_URI[aarch64_rust-trycmd-devel.sha256sum] = "345c2a50bb3b2996abd9698c648641cc71cbcf5353664286eccf1289244d3f52"

RDEPENDS:rust-trycmd+color-auto-devel = " \
 cargo \
 rust-snapbox+color-auto-devel \
 rust-trycmd+color-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd+color-devel = " \
 cargo \
 rust-anstream+default-devel \
 rust-snapbox+color-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd+debug-devel = " \
 cargo \
 rust-snapbox+debug-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd+default-devel = " \
 cargo \
 rust-trycmd+color-auto-devel \
 rust-trycmd+diff-devel \
 rust-trycmd+filesystem-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd+diff-devel = " \
 cargo \
 rust-snapbox+diff-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd+escargot-devel = " \
 cargo \
 rust-escargot+default-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd+examples-devel = " \
 cargo \
 rust-snapbox+examples-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd+filesystem-devel = " \
 cargo \
 rust-snapbox+dir-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd+schema-devel = " \
 cargo \
 rust-schemars+default-devel \
 rust-schemars+preserve_order-devel \
 rust-serde_json+default-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd-devel = " \
 cargo \
 rust \
 rust-automod+default-devel \
 rust-glob+default-devel \
 rust-humantime+default-devel \
 rust-humantime-serde+default-devel \
 rust-rayon+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-shlex+default-devel \
 rust-snapbox+cmd-devel \
 rust-snapbox-devel \
 rust-toml_edit+default-devel \
 rust-toml_edit+serde-devel \
 "
