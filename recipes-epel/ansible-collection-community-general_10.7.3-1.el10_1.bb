# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansible-collection-community-general"
PV = "10.7.3"
PR = "1.el10_1"
PACKAGES = " \
 ansible-collection-community-general \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/ansible-collection-community-general-10.7.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "73e921526fbe74c71c47144824002e6a80c33a2c3b0c9c4e8bad195915c56711"

URI_x86_64_v2_ansible-collection-community-general = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ansible-collection-community-general-10.7.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ansible-collection-community-general;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-collection-community-general}"
SRC_URI[x86_64_v2_ansible-collection-community-general.sha256sum] = "64f775e74daa7d5377ada735af92705a8da0f57f9c86173bec909ded289d9140"

URI_aarch64_ansible-collection-community-general = "${EPEL_MIRROR}/aarch64/Packages/a/ansible-collection-community-general-10.7.3-1.el10_1.noarch.rpm;name=aarch64_ansible-collection-community-general;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-collection-community-general}"
SRC_URI[aarch64_ansible-collection-community-general.sha256sum] = "2ff0753a88e52a538eba9d519445000ad1f47ed770cd3e16611b024bc439c9c5"

RDEPENDS:ansible-collection-community-general = " \
 ansible-core \
 "
