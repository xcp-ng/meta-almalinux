# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-escargot"
PV = "0.5.15"
PR = "1.el10_0"
PACKAGES = " \
 rust-escargot+cargo_unstable-devel \
 rust-escargot+default-devel \
 rust-escargot+print-devel \
 rust-escargot+strict_unstable-devel \
 rust-escargot+test_unstable-devel \
 rust-escargot-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-escargot-0.5.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bdf06d1c2009e1d002c975d88bd4c54fb9829f7aabc0713a13a09bc7d007bc2d"

URI_x86_64_v2_rust-escargot+cargo_unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-escargot+cargo_unstable-devel-0.5.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-escargot+cargo_unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-escargot+cargo_unstable-devel}"
SRC_URI[x86_64_v2_rust-escargot+cargo_unstable-devel.sha256sum] = "585ae2575adb174576a101e59e96cd8fd6bca5624f80165d1df2aec6d37acdc1"

URI_x86_64_v2_rust-escargot+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-escargot+default-devel-0.5.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-escargot+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-escargot+default-devel}"
SRC_URI[x86_64_v2_rust-escargot+default-devel.sha256sum] = "11c7bb54d5881da9d6fe127d1cf6d5c1f5d90eddcddc9311266717b3c29dc6bc"

URI_x86_64_v2_rust-escargot+print-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-escargot+print-devel-0.5.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-escargot+print-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-escargot+print-devel}"
SRC_URI[x86_64_v2_rust-escargot+print-devel.sha256sum] = "1d29f6dd9a211f9652e7a9a8b8cc3a7c3a5667f36ce558e41f369f40718910c1"

URI_x86_64_v2_rust-escargot+strict_unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-escargot+strict_unstable-devel-0.5.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-escargot+strict_unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-escargot+strict_unstable-devel}"
SRC_URI[x86_64_v2_rust-escargot+strict_unstable-devel.sha256sum] = "d50fdc5feba8bc88d3b80eed0fdf5d0abcbafbf717454fe5cef3a0d302ca7b58"

URI_x86_64_v2_rust-escargot+test_unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-escargot+test_unstable-devel-0.5.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-escargot+test_unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-escargot+test_unstable-devel}"
SRC_URI[x86_64_v2_rust-escargot+test_unstable-devel.sha256sum] = "27c64473c5ebcf3bfe9e6004ad8887a10676878bc862ebf95556ce916f5c50ea"

URI_x86_64_v2_rust-escargot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-escargot-devel-0.5.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-escargot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-escargot-devel}"
SRC_URI[x86_64_v2_rust-escargot-devel.sha256sum] = "410e3ad487979217b1ebc22104cbd217f75bc18ec1c7d40a3e3e31ef8c880eab"

URI_aarch64_rust-escargot+cargo_unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-escargot+cargo_unstable-devel-0.5.15-1.el10_0.noarch.rpm;name=aarch64_rust-escargot+cargo_unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-escargot+cargo_unstable-devel}"
SRC_URI[aarch64_rust-escargot+cargo_unstable-devel.sha256sum] = "7b57a8a41ee3b4e365d7f5ac808cd7f57d8d81335d0cad0c89b17defa9ccd828"

URI_aarch64_rust-escargot+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-escargot+default-devel-0.5.15-1.el10_0.noarch.rpm;name=aarch64_rust-escargot+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-escargot+default-devel}"
SRC_URI[aarch64_rust-escargot+default-devel.sha256sum] = "b6bf6a665e6995e752b982113ab0a014bdc26f82d2c58533dc81be706b6ae2ae"

URI_aarch64_rust-escargot+print-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-escargot+print-devel-0.5.15-1.el10_0.noarch.rpm;name=aarch64_rust-escargot+print-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-escargot+print-devel}"
SRC_URI[aarch64_rust-escargot+print-devel.sha256sum] = "1fcc035165cfe5f91c67383b081873ec4dd49a7439aa93342730598cd4a1b786"

URI_aarch64_rust-escargot+strict_unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-escargot+strict_unstable-devel-0.5.15-1.el10_0.noarch.rpm;name=aarch64_rust-escargot+strict_unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-escargot+strict_unstable-devel}"
SRC_URI[aarch64_rust-escargot+strict_unstable-devel.sha256sum] = "e3f283b53fbaae871a56d9c91d531e76f1494301a17cc833b7549b2dd1284832"

URI_aarch64_rust-escargot+test_unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-escargot+test_unstable-devel-0.5.15-1.el10_0.noarch.rpm;name=aarch64_rust-escargot+test_unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-escargot+test_unstable-devel}"
SRC_URI[aarch64_rust-escargot+test_unstable-devel.sha256sum] = "d7bc9a27a9558084f6e38e5ff6abc1d99a5a695dda1b383885c4818544af61ef"

URI_aarch64_rust-escargot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-escargot-devel-0.5.15-1.el10_0.noarch.rpm;name=aarch64_rust-escargot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-escargot-devel}"
SRC_URI[aarch64_rust-escargot-devel.sha256sum] = "57965d73fa7ea6a1621d3a313e3c1529e2dc6a7a01cfb316eb3ae00c117a0a00"

RDEPENDS:rust-escargot+cargo_unstable-devel = " \
 cargo \
 rust-escargot-devel \
 "
RDEPENDS:rust-escargot+default-devel = " \
 cargo \
 rust-escargot-devel \
 "
RDEPENDS:rust-escargot+print-devel = " \
 cargo \
 rust-escargot-devel \
 "
RDEPENDS:rust-escargot+strict_unstable-devel = " \
 cargo \
 rust-escargot-devel \
 "
RDEPENDS:rust-escargot+test_unstable-devel = " \
 cargo \
 rust-escargot-devel \
 "
RDEPENDS:rust-escargot-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 "
