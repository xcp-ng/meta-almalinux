# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-executor"
PV = "0.3.31"
PR = "1.el10_0"
PACKAGES = " \
 rust-futures-executor+default-devel \
 rust-futures-executor+num_cpus-devel \
 rust-futures-executor+std-devel \
 rust-futures-executor+thread-pool-devel \
 rust-futures-executor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-executor-0.3.31-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "767fd1d4c463408265908c0299cf7346d463ed71a945a785e4e4583108be3755"

URI_x86_64_v2_rust-futures-executor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-executor+default-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-executor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-executor+default-devel}"
SRC_URI[x86_64_v2_rust-futures-executor+default-devel.sha256sum] = "0b22b5a510bbad2fa87257806028e73765e4fa7689be313fe1c484fc1f50a11a"

URI_x86_64_v2_rust-futures-executor+num_cpus-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-executor+num_cpus-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-executor+num_cpus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-executor+num_cpus-devel}"
SRC_URI[x86_64_v2_rust-futures-executor+num_cpus-devel.sha256sum] = "a1bba6d09464c5b385ddee862fd88f5a5010a34e8c1935bf083e11a801f692bc"

URI_x86_64_v2_rust-futures-executor+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-executor+std-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-executor+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-executor+std-devel}"
SRC_URI[x86_64_v2_rust-futures-executor+std-devel.sha256sum] = "6aa45fb6e25b5630e9a9dc22a3f0cf7398492556a5127e508313b749b1399500"

URI_x86_64_v2_rust-futures-executor+thread-pool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-executor+thread-pool-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-executor+thread-pool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-executor+thread-pool-devel}"
SRC_URI[x86_64_v2_rust-futures-executor+thread-pool-devel.sha256sum] = "c7f10ac3693f1be39357787375fff871c29662f1b134070d2e3b3f6484c93a78"

URI_x86_64_v2_rust-futures-executor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-executor-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-executor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-executor-devel}"
SRC_URI[x86_64_v2_rust-futures-executor-devel.sha256sum] = "3d663d900211331bcef4d221405903efc56da821ec104b496ef3c82f1555433a"

URI_aarch64_rust-futures-executor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-executor+default-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-executor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-executor+default-devel}"
SRC_URI[aarch64_rust-futures-executor+default-devel.sha256sum] = "4c91d8f17eeec023c336363160e77383c4037ab2093803953ff965981495f3bc"

URI_aarch64_rust-futures-executor+num_cpus-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-executor+num_cpus-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-executor+num_cpus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-executor+num_cpus-devel}"
SRC_URI[aarch64_rust-futures-executor+num_cpus-devel.sha256sum] = "fc2dc4b2efcfd29a2dec1abd2ec96569e70a80112225def4c045ccc46d08fc3d"

URI_aarch64_rust-futures-executor+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-executor+std-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-executor+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-executor+std-devel}"
SRC_URI[aarch64_rust-futures-executor+std-devel.sha256sum] = "7425a7902c0daa17ef69ad31dcfb17cb0775a4f57fcf5a801aced9c3d7123010"

URI_aarch64_rust-futures-executor+thread-pool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-executor+thread-pool-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-executor+thread-pool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-executor+thread-pool-devel}"
SRC_URI[aarch64_rust-futures-executor+thread-pool-devel.sha256sum] = "d8098964b83f8783918f8b905b786479e306826ddef91f4080080fa5b922a314"

URI_aarch64_rust-futures-executor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-executor-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-executor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-executor-devel}"
SRC_URI[aarch64_rust-futures-executor-devel.sha256sum] = "18975cd9224d87595a7414eb67c38dd213f98e17d2080c500dfd600237c3870c"

RDEPENDS:rust-futures-executor+default-devel = " \
 cargo \
 rust-futures-executor+std-devel \
 rust-futures-executor-devel \
 "
RDEPENDS:rust-futures-executor+num_cpus-devel = " \
 cargo \
 rust-futures-executor-devel \
 rust-num_cpus+default-devel \
 "
RDEPENDS:rust-futures-executor+std-devel = " \
 cargo \
 rust-futures-core+std-devel \
 rust-futures-executor-devel \
 rust-futures-task+std-devel \
 rust-futures-util+std-devel \
 "
RDEPENDS:rust-futures-executor+thread-pool-devel = " \
 cargo \
 rust-futures-executor+num_cpus-devel \
 rust-futures-executor+std-devel \
 rust-futures-executor-devel \
 "
RDEPENDS:rust-futures-executor-devel = " \
 cargo \
 rust \
 rust-futures-core-devel \
 rust-futures-task-devel \
 rust-futures-util-devel \
 "
