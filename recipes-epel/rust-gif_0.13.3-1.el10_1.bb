# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gif"
PV = "0.13.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-gif+color_quant-devel \
 rust-gif+default-devel \
 rust-gif+raii_no_panic-devel \
 rust-gif+std-devel \
 rust-gif-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gif-0.13.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d938d9b6e4a3b32a89f9cd514870cf090de01d34e4684511d80f2eb4489fa9ee"

URI_x86_64_v2_rust-gif+color_quant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gif+color_quant-devel-0.13.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gif+color_quant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gif+color_quant-devel}"
SRC_URI[x86_64_v2_rust-gif+color_quant-devel.sha256sum] = "91db8807a882ceb08227ad5f2fa792d4faf9d3f5d6d82e103dda5104e893320e"

URI_x86_64_v2_rust-gif+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gif+default-devel-0.13.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gif+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gif+default-devel}"
SRC_URI[x86_64_v2_rust-gif+default-devel.sha256sum] = "c6e306dffad534e21cf7279d947c0bf0726e42126226367e754b594b4c430fd5"

URI_x86_64_v2_rust-gif+raii_no_panic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gif+raii_no_panic-devel-0.13.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gif+raii_no_panic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gif+raii_no_panic-devel}"
SRC_URI[x86_64_v2_rust-gif+raii_no_panic-devel.sha256sum] = "0ef9ce3f911bf555b41a233bf1ffcba5a65ea03500109d792e0850aa5d6bc032"

URI_x86_64_v2_rust-gif+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gif+std-devel-0.13.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gif+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gif+std-devel}"
SRC_URI[x86_64_v2_rust-gif+std-devel.sha256sum] = "8a76a6b44fa850ce5f588aa5e854c6bf9d493e088906776f01bb70878732e6eb"

URI_x86_64_v2_rust-gif-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gif-devel-0.13.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gif-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gif-devel}"
SRC_URI[x86_64_v2_rust-gif-devel.sha256sum] = "38e51dbb2db305b711ee8b00ef3723b44d142f25e750b9f26bf37f7b0efe92a0"

URI_aarch64_rust-gif+color_quant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gif+color_quant-devel-0.13.3-1.el10_1.noarch.rpm;name=aarch64_rust-gif+color_quant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gif+color_quant-devel}"
SRC_URI[aarch64_rust-gif+color_quant-devel.sha256sum] = "18032ef8f71993cdb9d81fa2038287b3e443c8be62fa36071e95da9dc0ff7af8"

URI_aarch64_rust-gif+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gif+default-devel-0.13.3-1.el10_1.noarch.rpm;name=aarch64_rust-gif+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gif+default-devel}"
SRC_URI[aarch64_rust-gif+default-devel.sha256sum] = "297d45deb25a30bda2ddfc42686ec66711cecf1bf38a56624cbdf68d5dfe6d39"

URI_aarch64_rust-gif+raii_no_panic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gif+raii_no_panic-devel-0.13.3-1.el10_1.noarch.rpm;name=aarch64_rust-gif+raii_no_panic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gif+raii_no_panic-devel}"
SRC_URI[aarch64_rust-gif+raii_no_panic-devel.sha256sum] = "55aabbcee59cefe5c9ddc1b2ce2fbad94b9b410847198c3817df4692f3aff14c"

URI_aarch64_rust-gif+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gif+std-devel-0.13.3-1.el10_1.noarch.rpm;name=aarch64_rust-gif+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gif+std-devel}"
SRC_URI[aarch64_rust-gif+std-devel.sha256sum] = "e2e0187e90e3e3dc654a65b9390a148c2a3874740600225bf8c82e166d320e98"

URI_aarch64_rust-gif-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gif-devel-0.13.3-1.el10_1.noarch.rpm;name=aarch64_rust-gif-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gif-devel}"
SRC_URI[aarch64_rust-gif-devel.sha256sum] = "0c5a2b6db54bcd5adc3301736ae6209bc3aa2cabbcf00bd40cb0b4a34c2fa24f"

RDEPENDS:rust-gif+color_quant-devel = " \
 cargo \
 rust-color_quant+default-devel \
 rust-gif-devel \
 "
RDEPENDS:rust-gif+default-devel = " \
 cargo \
 rust-gif+color_quant-devel \
 rust-gif+raii_no_panic-devel \
 rust-gif+std-devel \
 rust-gif-devel \
 "
RDEPENDS:rust-gif+raii_no_panic-devel = " \
 cargo \
 rust-gif-devel \
 "
RDEPENDS:rust-gif+std-devel = " \
 cargo \
 rust-gif-devel \
 "
RDEPENDS:rust-gif-devel = " \
 cargo \
 rust \
 rust-weezl+default-devel \
 "
