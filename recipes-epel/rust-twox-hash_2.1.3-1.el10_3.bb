# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-twox-hash"
PV = "2.1.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-twox-hash+alloc-devel \
 rust-twox-hash+default-devel \
 rust-twox-hash+random-devel \
 rust-twox-hash+serialize-devel \
 rust-twox-hash+std-devel \
 rust-twox-hash+xxhash32-devel \
 rust-twox-hash+xxhash3_128-devel \
 rust-twox-hash+xxhash3_64-devel \
 rust-twox-hash+xxhash64-devel \
 rust-twox-hash-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-twox-hash-2.1.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "08f34f971ebf8db827df9b96c4a50b7a6e1a08455be166b3ff576f47715912c6"

URI_x86_64_v2_rust-twox-hash+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+alloc-devel-2.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash+alloc-devel}"
SRC_URI[x86_64_v2_rust-twox-hash+alloc-devel.sha256sum] = "c17152a5726a047be6782b91eca0cb75c424d785f9279ca9903b54f0a6323ff1"

URI_x86_64_v2_rust-twox-hash+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+default-devel-2.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash+default-devel}"
SRC_URI[x86_64_v2_rust-twox-hash+default-devel.sha256sum] = "d30f8bef468effa959ff465e429c0cd8e1df94bf2fc73148bbac12295d91088e"

URI_x86_64_v2_rust-twox-hash+random-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+random-devel-2.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+random-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash+random-devel}"
SRC_URI[x86_64_v2_rust-twox-hash+random-devel.sha256sum] = "917743386a7a59b3bdc3d3eeae8373594119d7a8c78147edc65a79f66d924f47"

URI_x86_64_v2_rust-twox-hash+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+serialize-devel-2.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash+serialize-devel}"
SRC_URI[x86_64_v2_rust-twox-hash+serialize-devel.sha256sum] = "fe1d4a7b619959b17ced34e5793c04fdb40fac5ebbf648a0b24b5b120353b795"

URI_x86_64_v2_rust-twox-hash+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+std-devel-2.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash+std-devel}"
SRC_URI[x86_64_v2_rust-twox-hash+std-devel.sha256sum] = "8f8bb5ed4cb7554d5c3c85caedc5e5c3e660f27d9cf33684e04ea69d820da249"

URI_x86_64_v2_rust-twox-hash+xxhash32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+xxhash32-devel-2.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+xxhash32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash+xxhash32-devel}"
SRC_URI[x86_64_v2_rust-twox-hash+xxhash32-devel.sha256sum] = "91c491812e743f2c423c67d09435badb47cd0b4ade6ee587caea064193b044e3"

URI_x86_64_v2_rust-twox-hash+xxhash3_128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+xxhash3_128-devel-2.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+xxhash3_128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash+xxhash3_128-devel}"
SRC_URI[x86_64_v2_rust-twox-hash+xxhash3_128-devel.sha256sum] = "d53066b54b71d073e0b5c010e46bbf01b032068642257868ed04afb0a8b92278"

URI_x86_64_v2_rust-twox-hash+xxhash3_64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+xxhash3_64-devel-2.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+xxhash3_64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash+xxhash3_64-devel}"
SRC_URI[x86_64_v2_rust-twox-hash+xxhash3_64-devel.sha256sum] = "199bb98e39a9c3a28b21f1b74c6b78b836e42e9695a02b9ff292f30b281f94bd"

URI_x86_64_v2_rust-twox-hash+xxhash64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+xxhash64-devel-2.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+xxhash64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash+xxhash64-devel}"
SRC_URI[x86_64_v2_rust-twox-hash+xxhash64-devel.sha256sum] = "7b1874ca92352dfa0f7162aae3f97721227fc40917523d363dd85c92db3273dc"

URI_x86_64_v2_rust-twox-hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash-devel-2.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash-devel}"
SRC_URI[x86_64_v2_rust-twox-hash-devel.sha256sum] = "7d210f0dfcadd55f65b39fca9666bd9015cc0a881f4fda8dc954695427f55842"

URI_aarch64_rust-twox-hash+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+alloc-devel-2.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-twox-hash+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash+alloc-devel}"
SRC_URI[aarch64_rust-twox-hash+alloc-devel.sha256sum] = "aaff33400bf740899fe7f3576ce9a3571cd3b5569539b49cc2d00e179267acef"

URI_aarch64_rust-twox-hash+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+default-devel-2.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-twox-hash+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash+default-devel}"
SRC_URI[aarch64_rust-twox-hash+default-devel.sha256sum] = "ed30108eda359d1c698437fecf02f62df891d43d813b136ef3e5738f9f01976e"

URI_aarch64_rust-twox-hash+random-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+random-devel-2.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-twox-hash+random-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash+random-devel}"
SRC_URI[aarch64_rust-twox-hash+random-devel.sha256sum] = "955cff0ff5957e82ef7479de5e4e2207e15b463c242085f0f224b0c9220ea15f"

URI_aarch64_rust-twox-hash+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+serialize-devel-2.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-twox-hash+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash+serialize-devel}"
SRC_URI[aarch64_rust-twox-hash+serialize-devel.sha256sum] = "2c636671e2fc68bd8ab4aa62a39423b6693b09f4e607d32cb7c91eca782f321a"

URI_aarch64_rust-twox-hash+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+std-devel-2.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-twox-hash+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash+std-devel}"
SRC_URI[aarch64_rust-twox-hash+std-devel.sha256sum] = "f8796e47451d81afc30d221dbbead59322415da9d2a221ebd64ce16c3df01634"

URI_aarch64_rust-twox-hash+xxhash32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+xxhash32-devel-2.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-twox-hash+xxhash32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash+xxhash32-devel}"
SRC_URI[aarch64_rust-twox-hash+xxhash32-devel.sha256sum] = "445e6c87dfdc0b6e327546a5b037b8949522b23ed76e712214ab321e50c5381c"

URI_aarch64_rust-twox-hash+xxhash3_128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+xxhash3_128-devel-2.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-twox-hash+xxhash3_128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash+xxhash3_128-devel}"
SRC_URI[aarch64_rust-twox-hash+xxhash3_128-devel.sha256sum] = "8607050f296c9c6694cc99c096819580faea14e9ba7ddbe6ae0407d9b44b787b"

URI_aarch64_rust-twox-hash+xxhash3_64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+xxhash3_64-devel-2.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-twox-hash+xxhash3_64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash+xxhash3_64-devel}"
SRC_URI[aarch64_rust-twox-hash+xxhash3_64-devel.sha256sum] = "aeb40f8fd2ee33c0d830105182caaa6e1811251f2fa10e8b1fdc6175793a08b1"

URI_aarch64_rust-twox-hash+xxhash64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+xxhash64-devel-2.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-twox-hash+xxhash64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash+xxhash64-devel}"
SRC_URI[aarch64_rust-twox-hash+xxhash64-devel.sha256sum] = "8414bb9fdf2e7ca7148458cb1bb4d4aa9a6188610eb48c13bb07bc7d222a79a8"

URI_aarch64_rust-twox-hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash-devel-2.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-twox-hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash-devel}"
SRC_URI[aarch64_rust-twox-hash-devel.sha256sum] = "ea43909c9173a5e365877fbb98c467a1cc21d7f206b0bb87ab1c7729ded8a94f"

RDEPENDS:rust-twox-hash+alloc-devel = " \
 cargo \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+default-devel = " \
 cargo \
 rust-twox-hash+random-devel \
 rust-twox-hash+std-devel \
 rust-twox-hash+xxhash32-devel \
 rust-twox-hash+xxhash3_128-devel \
 rust-twox-hash+xxhash3_64-devel \
 rust-twox-hash+xxhash64-devel \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+random-devel = " \
 cargo \
 rust-twox-hash-devel \
 virtual/crate_rand/thread_rng__ge_0.9.0_with_crate_rand/thread_rng__le_0.11.0 \
 virtual/crate_rand__ge_0.9.0_with_crate_rand__le_0.11.0 \
 "
RDEPENDS:rust-twox-hash+serialize-devel = " \
 cargo \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+std-devel = " \
 cargo \
 rust-twox-hash+alloc-devel \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+xxhash32-devel = " \
 cargo \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+xxhash3_128-devel = " \
 cargo \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+xxhash3_64-devel = " \
 cargo \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+xxhash64-devel = " \
 cargo \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash-devel = " \
 cargo \
 rust \
 "
