# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansible-collection-community-internal_test_tools"
PV = "0.19.0"
PR = "1.el10_2"
PACKAGES = " \
 ansible-collection-community-internal_test_tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/ansible-collection-community-internal_test_tools-0.19.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a0e128da1d3e402c48be17ee967bc584abd7c97d01b5f67416a1ee9b5348bcf"

URI_x86_64_v2_ansible-collection-community-internal_test_tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ansible-collection-community-internal_test_tools-0.19.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ansible-collection-community-internal_test_tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-collection-community-internal_test_tools}"
SRC_URI[x86_64_v2_ansible-collection-community-internal_test_tools.sha256sum] = "cff73b8101f0aeab49d28e2320235005fff57c2de20937074d49eab02566384b"

URI_aarch64_ansible-collection-community-internal_test_tools = "${EPEL_MIRROR}/aarch64/Packages/a/ansible-collection-community-internal_test_tools-0.19.0-1.el10_2.noarch.rpm;name=aarch64_ansible-collection-community-internal_test_tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-collection-community-internal_test_tools}"
SRC_URI[aarch64_ansible-collection-community-internal_test_tools.sha256sum] = "e20deb9a20f3e7fe4317a32a0baf89b4b00a5bd1b17fb1e397dbb5d933639bc4"

RDEPENDS:ansible-collection-community-internal_test_tools = " \
 ansible-core \
 "
