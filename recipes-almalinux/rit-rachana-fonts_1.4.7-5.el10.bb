# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rit-rachana-fonts"
PV = "1.4.7"
PR = "5.el10"
PACKAGES = " \
 rit-rachana-fonts \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rit-rachana-fonts-1.4.7-5.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7e9e6308facf464427c128bf1c40e0c3762666604ef6614fd64fdddb15f6f95d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rit-rachana-fonts-1.4.7-5.el10.noarch.rpm;name=x86_64_v2_rit-rachana-fonts;unpack=0"
SRC_URI[x86_64_v2_rit-rachana-fonts.sha256sum] = "353db04b6ee0ce668708bdf092d2d607baef0fd35871d182598bcdce818fc435"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rit-rachana-fonts-1.4.7-5.el10.noarch.rpm;name=aarch64_rit-rachana-fonts;unpack=0"
SRC_URI[aarch64_rit-rachana-fonts.sha256sum] = "353db04b6ee0ce668708bdf092d2d607baef0fd35871d182598bcdce818fc435"

RDEPENDS:rit-rachana-fonts = " \
 fonts-filesystem \
 "
