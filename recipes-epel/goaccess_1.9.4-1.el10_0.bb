# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "goaccess"
PV = "1.9.4"
PR = "1.el10_0"
PACKAGES = " \
 goaccess \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/goaccess-1.9.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "37102bfb6a3564f0abe1c8ed433623c5de59663444460db9af6477414861f9bc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/goaccess-1.9.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_goaccess;unpack=0"
SRC_URI[x86_64_v2_goaccess.sha256sum] = "d6286332ba5625d391baeb48ffa7822876858999dcfe3412fe596ed005dc6481"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/goaccess-1.9.4-1.el10_0.aarch64.rpm;name=aarch64_goaccess;unpack=0"
SRC_URI[aarch64_goaccess.sha256sum] = "e166a6cf36884816c7fd6924ef3f878e82fe7960486f6afd236361e483b069d4"

RDEPENDS:goaccess = " \
 glibc \
 libmaxminddb \
 ncurses-libs \
 openssl-libs \
 "
