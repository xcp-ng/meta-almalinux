# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "stalld"
PV = "1.19.8"
PR = "2.el10_0"
PACKAGES = " \
 stalld \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/stalld-1.19.8-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c797983e8e115447094ebb29761876e23fcbff53a0815eb660915a7c57971358"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/stalld-1.19.8-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_stalld;unpack=0"
SRC_URI[x86_64_v2_stalld.sha256sum] = "779e132264f974ef1324e96df24506f8bc5729175cf6bcbd141a2826ac672963"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/stalld-1.19.8-2.el10_0.aarch64.rpm;name=aarch64_stalld;unpack=0"
SRC_URI[aarch64_stalld.sha256sum] = "ad2fd05c6acc69210553c0689719ec93859f0abe3e0fcc91c0b369ff2de9fd6d"

RDEPENDS:stalld = " \
 bash \
 glibc \
 libbpf \
 systemd \
 "
