# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "postgresql16"
PV = "16.13"
PR = "1.el10_1"
PACKAGES = " \
 postgresql \
 postgresql-contrib \
 postgresql-docs \
 postgresql-plperl \
 postgresql-plpython3 \
 postgresql-pltcl \
 postgresql-private-devel \
 postgresql-private-libs \
 postgresql-server \
 postgresql-server-devel \
 postgresql-static \
 postgresql-test \
 postgresql-test-rpm-macros \
 postgresql-upgrade \
 postgresql-upgrade-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/postgresql16-16.13-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "675e4d537cc55967caa4b5d2e28559c72c1f949d5520da8f8af64e4e3fefdedc"

URI_x86_64_v2_postgresql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-16.13-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql}"
SRC_URI[x86_64_v2_postgresql.sha256sum] = "64f0bc4ccad827634b6a30f1cdde99d0a3fb80026ef69b2d30cdd3046f946f3a"

URI_x86_64_v2_postgresql-contrib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-contrib-16.13-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_postgresql-contrib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-contrib}"
SRC_URI[x86_64_v2_postgresql-contrib.sha256sum] = "160c8c83438cec98f4872a45be0739ddbac52f40494149c11e06c2a242080da0"

URI_x86_64_v2_postgresql-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-docs-16.13-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_postgresql-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-docs}"
SRC_URI[x86_64_v2_postgresql-docs.sha256sum] = "3750400f0387cac326429132f0b8c74614a292d59d8e1c74e41ba35b352e759f"

URI_x86_64_v2_postgresql-plperl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-plperl-16.13-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_postgresql-plperl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-plperl}"
SRC_URI[x86_64_v2_postgresql-plperl.sha256sum] = "84573d5ad8e83e3b5762c8f48a1dce0e5b78af5509d9c162330f727d03b40abd"

URI_x86_64_v2_postgresql-plpython3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-plpython3-16.13-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_postgresql-plpython3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-plpython3}"
SRC_URI[x86_64_v2_postgresql-plpython3.sha256sum] = "f8fe91131b2c04a13e8999db7531cef59630f433ac48580c5053d9de0324f716"

URI_x86_64_v2_postgresql-pltcl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-pltcl-16.13-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_postgresql-pltcl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-pltcl}"
SRC_URI[x86_64_v2_postgresql-pltcl.sha256sum] = "77c5adecca7a63b18c8071cc30fe417e2a2722beb9e109edf7d4de66bb679ecf"

URI_x86_64_v2_postgresql-private-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-private-devel-16.13-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_postgresql-private-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-private-devel}"
SRC_URI[x86_64_v2_postgresql-private-devel.sha256sum] = "c4edaab22b12712a01134cb520c412ab1c8016a9acc0b2d49eaddbf378685d10"

URI_x86_64_v2_postgresql-private-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-private-libs-16.13-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_postgresql-private-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-private-libs}"
SRC_URI[x86_64_v2_postgresql-private-libs.sha256sum] = "07ae8741b16ab68513de2a05a937b0636c66c05f610c887926beaba08aae9b74"

URI_x86_64_v2_postgresql-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-server-16.13-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_postgresql-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-server}"
SRC_URI[x86_64_v2_postgresql-server.sha256sum] = "7184929aea3c12457df840352201ffb611de8d65a92a43acf0b5cfe3e8b509c2"

URI_x86_64_v2_postgresql-server-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-server-devel-16.13-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_postgresql-server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-server-devel}"
SRC_URI[x86_64_v2_postgresql-server-devel.sha256sum] = "5de47a6cb148c6e03b04aba88ea7aedcc5bd5d899c6f7ed33c147d7bb651ac9c"

URI_x86_64_v2_postgresql-static = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-static-16.13-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_postgresql-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-static}"
SRC_URI[x86_64_v2_postgresql-static.sha256sum] = "f62d8cffd7da1a8c6e49ce3ff85044bc34388f1d76316c82dd1f8c49b14fb801"

URI_x86_64_v2_postgresql-test = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-test-16.13-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_postgresql-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-test}"
SRC_URI[x86_64_v2_postgresql-test.sha256sum] = "14f90cbe3944bddf870e2abe5c7e118796fd18ba81693b9209607e6a0b01715e"

URI_x86_64_v2_postgresql-test-rpm-macros = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/postgresql-test-rpm-macros-16.13-1.el10_1.noarch.rpm;name=x86_64_v2_postgresql-test-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-test-rpm-macros}"
SRC_URI[x86_64_v2_postgresql-test-rpm-macros.sha256sum] = "e76feeb0d1858ecf41f6b5cb34ea1b10f2baece305c0899fb599b357716492c4"

URI_x86_64_v2_postgresql-upgrade = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-upgrade-16.13-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_postgresql-upgrade;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-upgrade}"
SRC_URI[x86_64_v2_postgresql-upgrade.sha256sum] = "d048ab72596f93f5bee8e7ea434840674a38fcd57eacd83412ac1053511fc452"

URI_x86_64_v2_postgresql-upgrade-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-upgrade-devel-16.13-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_postgresql-upgrade-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-upgrade-devel}"
SRC_URI[x86_64_v2_postgresql-upgrade-devel.sha256sum] = "673a27cbd1127a93570eecbcccd672277a5dac31c5e62661beac246abcf3bf57"

URI_aarch64_postgresql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-16.13-1.el10_1.aarch64.rpm;name=aarch64_postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql}"
SRC_URI[aarch64_postgresql.sha256sum] = "646371c4352aa11c3aa49953ff83c255b2724091c2ba53541206946823421cb1"

URI_aarch64_postgresql-contrib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-contrib-16.13-1.el10_1.aarch64.rpm;name=aarch64_postgresql-contrib;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-contrib}"
SRC_URI[aarch64_postgresql-contrib.sha256sum] = "cbf6039785887e3cf95228ae2cfa5910e37c94704f7dc50476429a1711cf5fad"

URI_aarch64_postgresql-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-docs-16.13-1.el10_1.aarch64.rpm;name=aarch64_postgresql-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-docs}"
SRC_URI[aarch64_postgresql-docs.sha256sum] = "b75f0ff9e579279b67f1aaa5f959ea4594c0a54c1181069b261acb7a1cdde53d"

URI_aarch64_postgresql-plperl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-plperl-16.13-1.el10_1.aarch64.rpm;name=aarch64_postgresql-plperl;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-plperl}"
SRC_URI[aarch64_postgresql-plperl.sha256sum] = "19ec93516c4a59a93a061476d21ab74734c8a3398c42bed158b7944fd02c6b8f"

URI_aarch64_postgresql-plpython3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-plpython3-16.13-1.el10_1.aarch64.rpm;name=aarch64_postgresql-plpython3;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-plpython3}"
SRC_URI[aarch64_postgresql-plpython3.sha256sum] = "734b0276748b16d42981e91d388da88e1b2ac58e73f6bf0ae184a642a23d7fe1"

URI_aarch64_postgresql-pltcl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-pltcl-16.13-1.el10_1.aarch64.rpm;name=aarch64_postgresql-pltcl;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-pltcl}"
SRC_URI[aarch64_postgresql-pltcl.sha256sum] = "5a3ef93902edb75a932c6df7170e11d365d7745409d853f15a85f8ab20134bb4"

URI_aarch64_postgresql-private-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-private-devel-16.13-1.el10_1.aarch64.rpm;name=aarch64_postgresql-private-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-private-devel}"
SRC_URI[aarch64_postgresql-private-devel.sha256sum] = "042eab0186c100a3dacca7a8d8347fb56cc6d68dae50c5842a7c540a787e1c92"

URI_aarch64_postgresql-private-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-private-libs-16.13-1.el10_1.aarch64.rpm;name=aarch64_postgresql-private-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-private-libs}"
SRC_URI[aarch64_postgresql-private-libs.sha256sum] = "cf9fdac82f90d9770899107fe6515c1e6fcc8dc24c7677a2951735835025ef14"

URI_aarch64_postgresql-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-server-16.13-1.el10_1.aarch64.rpm;name=aarch64_postgresql-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-server}"
SRC_URI[aarch64_postgresql-server.sha256sum] = "e470e80601184d35efbbf215adb0af43c69ebc803ee35eb5b1818af85d6578b0"

URI_aarch64_postgresql-server-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-server-devel-16.13-1.el10_1.aarch64.rpm;name=aarch64_postgresql-server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-server-devel}"
SRC_URI[aarch64_postgresql-server-devel.sha256sum] = "8d8819fd7a11570a7c4668e77f1f73f426fc15337d671abf7fc9d658b049a2f3"

URI_aarch64_postgresql-static = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-static-16.13-1.el10_1.aarch64.rpm;name=aarch64_postgresql-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-static}"
SRC_URI[aarch64_postgresql-static.sha256sum] = "bad05465aa170138c164da33d3c3ead764115619ae0d4078c77c4ec22a335c90"

URI_aarch64_postgresql-test = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-test-16.13-1.el10_1.aarch64.rpm;name=aarch64_postgresql-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-test}"
SRC_URI[aarch64_postgresql-test.sha256sum] = "37b4089fa07ba94cc69c96408121d2930ebeb2d15f719017a326b83afe2b16ce"

URI_aarch64_postgresql-test-rpm-macros = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/postgresql-test-rpm-macros-16.13-1.el10_1.noarch.rpm;name=aarch64_postgresql-test-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-test-rpm-macros}"
SRC_URI[aarch64_postgresql-test-rpm-macros.sha256sum] = "e76feeb0d1858ecf41f6b5cb34ea1b10f2baece305c0899fb599b357716492c4"

URI_aarch64_postgresql-upgrade = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-upgrade-16.13-1.el10_1.aarch64.rpm;name=aarch64_postgresql-upgrade;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-upgrade}"
SRC_URI[aarch64_postgresql-upgrade.sha256sum] = "29d7f182700c3326718d9c924d5658050056d588753a89c14014e4c4585abaf2"

URI_aarch64_postgresql-upgrade-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-upgrade-devel-16.13-1.el10_1.aarch64.rpm;name=aarch64_postgresql-upgrade-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-upgrade-devel}"
SRC_URI[aarch64_postgresql-upgrade-devel.sha256sum] = "fd11565f5329d23bbf3c384de6d175e5061d7825dc51806b387ab923f25f25b0"

RDEPENDS:postgresql = " \
 glibc \
 libzstd \
 lz4-libs \
 openssl-libs \
 postgresql-private-libs \
 readline \
 zlib-ng-compat \
 "
RDEPENDS:postgresql-contrib = " \
 glibc \
 libselinux \
 libxml2 \
 libxslt \
 libzstd \
 lz4-libs \
 openssl-libs \
 perl-libs \
 postgresql \
 postgresql-private-libs \
 python3-libs \
 uuid \
 zlib-ng-compat \
 "
RDEPENDS:postgresql-docs = " \
 glibc \
 postgresql \
 "
RDEPENDS:postgresql-plperl = " \
 glibc \
 perl-libs \
 postgresql-server \
 "
RDEPENDS:postgresql-plpython3 = " \
 glibc \
 postgresql-server \
 python3-libs \
 "
RDEPENDS:postgresql-pltcl = " \
 glibc \
 postgresql-server \
 tcl \
 "
RDEPENDS:postgresql-private-devel = " \
 openssl-devel \
 pkgconf-pkg-config \
 postgresql-private-libs \
 "
RDEPENDS:postgresql-private-libs = " \
 glibc \
 krb5-libs \
 openldap \
 openssl-libs \
 "
RDEPENDS:postgresql-server = " \
 bash \
 glibc \
 krb5-libs \
 libicu \
 libxml2 \
 libzstd \
 lz4-libs \
 openldap \
 openssl-libs \
 pam-libs \
 postgresql \
 postgresql-private-libs \
 shadow-utils \
 systemd \
 systemd-libs \
 util-linux \
 zlib-ng-compat \
 "
RDEPENDS:postgresql-server-devel = " \
 bash \
 glibc \
 krb5-devel \
 libicu-devel \
 postgresql-private-devel \
 postgresql-private-libs \
 "
RDEPENDS:postgresql-static = " \
 postgresql-server-devel \
 "
RDEPENDS:postgresql-test = " \
 bash \
 glibc \
 postgresql-contrib \
 postgresql-server \
 postgresql-server-devel \
 "
RDEPENDS:postgresql-test-rpm-macros = " \
 postgresql-server \
 "
RDEPENDS:postgresql-upgrade = " \
 glibc \
 krb5-libs \
 libicu \
 libselinux \
 libxml2 \
 libxslt \
 openldap \
 openssl-libs \
 pam-libs \
 perl-libs \
 postgresql-private-libs \
 postgresql-server \
 python3-libs \
 tcl \
 uuid \
 zlib-ng-compat \
 "
RDEPENDS:postgresql-upgrade-devel = " \
 bash \
 glibc \
 postgresql-upgrade \
 "
