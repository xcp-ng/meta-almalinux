# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pgpdump"
PV = "0.37"
PR = "1.el10_3"
PACKAGES = " \
 pgpdump \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/pgpdump-0.37-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cc34f2af7ec8326e7658822a50a3d0aadfcbf06457865dbde53bcc6306c4443d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pgpdump-0.37-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pgpdump;unpack=0"
SRC_URI[x86_64_v2_pgpdump.sha256sum] = "816f9a71c67a2ffe449e55d2df49438089816c5971110d4e4b60fce9dff3eb5f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pgpdump-0.37-1.el10_3.aarch64.rpm;name=aarch64_pgpdump;unpack=0"
SRC_URI[aarch64_pgpdump.sha256sum] = "35e01db5815a10809cbe4390218af15600552df2a0bbd9a1366fa6e0579fa984"

RDEPENDS:pgpdump = " \
 bzip2-libs \
 glibc \
 zlib-ng-compat \
 "
