# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "adoptium-temurin-java-repository"
PV = "1"
PR = "3.el10_0"
PACKAGES = " \
 adoptium-temurin-java-repository \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/adoptium-temurin-java-repository-1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b53092f5664304b94f6a7669f0975702a1420fa88d0b2ba6d936f217b578741a"

URI_x86_64_v2_adoptium-temurin-java-repository = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/adoptium-temurin-java-repository-1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_adoptium-temurin-java-repository;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_adoptium-temurin-java-repository}"
SRC_URI[x86_64_v2_adoptium-temurin-java-repository.sha256sum] = "8826bb03a758c6ef86bbb3e29e761e98bda185a4df9be4d907558a9ec7c3f9f1"

URI_aarch64_adoptium-temurin-java-repository = "${EPEL_MIRROR}/aarch64/Packages/a/adoptium-temurin-java-repository-1-3.el10_0.noarch.rpm;name=aarch64_adoptium-temurin-java-repository;unpack=0"
SRC_URI:append = " ${URI_aarch64_adoptium-temurin-java-repository}"
SRC_URI[aarch64_adoptium-temurin-java-repository.sha256sum] = "61f3b9b00193af9be8a3e8ccfdb913baee6b898a6b58254a91ce17d19b7c9ebe"

RDEPENDS:adoptium-temurin-java-repository = " \
 "
