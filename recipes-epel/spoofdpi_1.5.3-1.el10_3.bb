# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "spoofdpi"
PV = "1.5.3"
PR = "1.el10_3"
PACKAGES = " \
 spoofdpi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/spoofdpi-1.5.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9ec0c81d7bd53a1a5a38fcd1d8cb1433bbc205811e85eeda8b54cf13a25ffb4"

URI_x86_64_v2_spoofdpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/spoofdpi-1.5.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_spoofdpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spoofdpi}"
SRC_URI[x86_64_v2_spoofdpi.sha256sum] = "16a41314f60afcefb6658aaa0f8dc11ce4ceb058dff52c72cbff201cfbd4c52a"

URI_aarch64_spoofdpi = "${EPEL_MIRROR}/aarch64/Packages/s/spoofdpi-1.5.3-1.el10_3.aarch64.rpm;name=aarch64_spoofdpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_spoofdpi}"
SRC_URI[aarch64_spoofdpi.sha256sum] = "d85901aec16b10764ecba87e2e729c168b22a8620509e19d208a1795b9d1dc92"

RDEPENDS:spoofdpi = " \
 glibc \
 libpcap \
 "
