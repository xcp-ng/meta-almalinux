# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "krdc"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 krdc \
 krdc-devel \
 krdc-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/krdc-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "22749f57d08e13df003a11af3c8761df976facb23c2cbdd71980383cbe1d1e09"

URI_x86_64_v2_krdc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krdc-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krdc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krdc}"
SRC_URI[x86_64_v2_krdc.sha256sum] = "93161c5da1dfbd272ebed4b31f055a2f10ebbbefc73dae0ccc65c2aee1b21be6"

URI_x86_64_v2_krdc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krdc-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krdc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krdc-devel}"
SRC_URI[x86_64_v2_krdc-devel.sha256sum] = "0ed352ed4d0202f3bce997b4b0026158a3be2c9a7d011c727abbd9900560300e"

URI_x86_64_v2_krdc-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krdc-libs-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krdc-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krdc-libs}"
SRC_URI[x86_64_v2_krdc-libs.sha256sum] = "36134ee7c5e0f09dc8a7e6fc9550dfa81351d67e21844a8af6c291be81f2152a"

URI_aarch64_krdc = "${EPEL_MIRROR}/aarch64/Packages/k/krdc-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_krdc;unpack=0"
SRC_URI:append = " ${URI_aarch64_krdc}"
SRC_URI[aarch64_krdc.sha256sum] = "de08cdad1bae5d12ebfd4dc0ec237ad5cfbe1c92d1ba59d0423ab69f486e003e"

URI_aarch64_krdc-devel = "${EPEL_MIRROR}/aarch64/Packages/k/krdc-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_krdc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_krdc-devel}"
SRC_URI[aarch64_krdc-devel.sha256sum] = "9e617708217cb916fe3f2a32e1fd6d84ce79b7e6a8c3dd23dfe2502e429f144e"

URI_aarch64_krdc-libs = "${EPEL_MIRROR}/aarch64/Packages/k/krdc-libs-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_krdc-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_krdc-libs}"
SRC_URI[aarch64_krdc-libs.sha256sum] = "dbea9839b88da73ffd7cb518c7ccd7bcbec443c2ace8f45c09f2bceb4d20657e"

RDEPENDS:krdc = " \
 glibc \
 kf6-kbookmarks \
 kf6-kcmutils \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdnssd \
 kf6-ki18n \
 kf6-knotifyconfig \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 krdc-libs \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:krdc-devel = " \
 krdc-libs \
 "
RDEPENDS:krdc-libs = " \
 freerdp2-libs \
 glibc \
 kf6-kcmutils \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 krdc \
 libssh \
 libstdc++ \
 libvncserver \
 libwayland-client \
 libwinpr2 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwayland \
 "
