# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-webpki-roots"
PV = "0.26.10"
PR = "1.el10_0"
PACKAGES = " \
 rust-webpki-roots+default-devel \
 rust-webpki-roots-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-webpki-roots-0.26.10-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "701c842043d7c864334334f872ee6fb7492ba4f7ddd48a97c03352fd338985fc"

URI_x86_64_v2_rust-webpki-roots+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-webpki-roots+default-devel-0.26.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-webpki-roots+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-webpki-roots+default-devel}"
SRC_URI[x86_64_v2_rust-webpki-roots+default-devel.sha256sum] = "d5136f6ea55e72ab145b491b229cd03964f8c76f4713bd5091bed64cd10c4f10"

URI_x86_64_v2_rust-webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-webpki-roots-devel-0.26.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-webpki-roots-devel.sha256sum] = "e7246a7bcd41f58d81618c5153161a1e01b776f8de6ea47856c8707ea7aba383"

URI_aarch64_rust-webpki-roots+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-webpki-roots+default-devel-0.26.10-1.el10_0.noarch.rpm;name=aarch64_rust-webpki-roots+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-webpki-roots+default-devel}"
SRC_URI[aarch64_rust-webpki-roots+default-devel.sha256sum] = "3331a7fe01a65406818692399bd17cb6d6596638cb532f2246a052381c6a3f71"

URI_aarch64_rust-webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-webpki-roots-devel-0.26.10-1.el10_0.noarch.rpm;name=aarch64_rust-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-webpki-roots-devel}"
SRC_URI[aarch64_rust-webpki-roots-devel.sha256sum] = "6d4d2f91666fc3b5c4ccca5136d8354792512216dd1f9089ecb1f5a2b0ca08d0"

RDEPENDS:rust-webpki-roots+default-devel = " \
 cargo \
 rust-webpki-roots-devel \
 "
RDEPENDS:rust-webpki-roots-devel = " \
 cargo \
 rust-rustls-pki-types-devel \
 "
