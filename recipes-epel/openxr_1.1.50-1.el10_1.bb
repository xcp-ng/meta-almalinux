# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openxr"
PV = "1.1.50"
PR = "1.el10_1"
PACKAGES = " \
 openxr \
 openxr-devel \
 openxr-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/openxr-1.1.50-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b4332ffc8d4beffb15ef4fc76f3ebb3a4bccb4f106eccf9b628017f28af85813"

URI_x86_64_v2_openxr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openxr-1.1.50-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openxr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openxr}"
SRC_URI[x86_64_v2_openxr.sha256sum] = "1f549b3844f51e7582289088ce36a9d99b06def856aa890a13a5f9a89114e882"

URI_x86_64_v2_openxr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openxr-devel-1.1.50-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openxr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openxr-devel}"
SRC_URI[x86_64_v2_openxr-devel.sha256sum] = "91969c24a2c4ad651c5ddfd3d93915812e36c75f7046f65ee81d46b9f758b860"

URI_x86_64_v2_openxr-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openxr-libs-1.1.50-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openxr-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openxr-libs}"
SRC_URI[x86_64_v2_openxr-libs.sha256sum] = "6756a55806c2f583b88ab0e8bcedeaead20366f60a0c20662e421aff76665efa"

URI_aarch64_openxr = "${EPEL_MIRROR}/aarch64/Packages/o/openxr-1.1.50-1.el10_1.aarch64.rpm;name=aarch64_openxr;unpack=0"
SRC_URI:append = " ${URI_aarch64_openxr}"
SRC_URI[aarch64_openxr.sha256sum] = "64feaa0c1327d40e46dd4cf1e15734060d978600f68740f148c665ba3144dc11"

URI_aarch64_openxr-devel = "${EPEL_MIRROR}/aarch64/Packages/o/openxr-devel-1.1.50-1.el10_1.aarch64.rpm;name=aarch64_openxr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openxr-devel}"
SRC_URI[aarch64_openxr-devel.sha256sum] = "366c39052be18b3e50004c7457172e5853615306dd886bac541b5fcf24dc10d7"

URI_aarch64_openxr-libs = "${EPEL_MIRROR}/aarch64/Packages/o/openxr-libs-1.1.50-1.el10_1.aarch64.rpm;name=aarch64_openxr-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_openxr-libs}"
SRC_URI[aarch64_openxr-libs.sha256sum] = "c57cb7c3eb11a1ad9688f7791880cc7d8a878e016c20cfda3f46853c233a3436"

RDEPENDS:openxr = " \
 glibc \
 libX11 \
 libXxf86vm \
 libgcc \
 libstdc++ \
 openxr-libs \
 vulkan-loader \
 "
RDEPENDS:openxr-devel = " \
 cmake-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 openxr-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:openxr-libs = " \
 glibc \
 jsoncpp \
 libgcc \
 libstdc++ \
 "
