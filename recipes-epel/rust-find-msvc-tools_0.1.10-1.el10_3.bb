# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-find-msvc-tools"
PV = "0.1.10"
PR = "1.el10_3"
PACKAGES = " \
 rust-find-msvc-tools+default-devel \
 rust-find-msvc-tools-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-find-msvc-tools-0.1.10-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "99f59a6ddcb8b9708936a46a230b745e37347dc921dc4db70b4d017bcaae351e"

URI_x86_64_v2_rust-find-msvc-tools+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-find-msvc-tools+default-devel-0.1.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-find-msvc-tools+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-find-msvc-tools+default-devel}"
SRC_URI[x86_64_v2_rust-find-msvc-tools+default-devel.sha256sum] = "801412f56c98129e9309c06d460562a962c1db0996e3e6738c7c6d1fed0a5004"

URI_x86_64_v2_rust-find-msvc-tools-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-find-msvc-tools-devel-0.1.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-find-msvc-tools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-find-msvc-tools-devel}"
SRC_URI[x86_64_v2_rust-find-msvc-tools-devel.sha256sum] = "56ee500d813ff4fa9f779e41c5e64a796080f8374cd2d4b3c0df152f1516cdd9"

URI_aarch64_rust-find-msvc-tools+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-find-msvc-tools+default-devel-0.1.10-1.el10_3.noarch.rpm;name=aarch64_rust-find-msvc-tools+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-find-msvc-tools+default-devel}"
SRC_URI[aarch64_rust-find-msvc-tools+default-devel.sha256sum] = "e2061692014a3c225c6e4a2c440fc1897e81b4f94b64d5a1b73a61ed83f27e59"

URI_aarch64_rust-find-msvc-tools-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-find-msvc-tools-devel-0.1.10-1.el10_3.noarch.rpm;name=aarch64_rust-find-msvc-tools-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-find-msvc-tools-devel}"
SRC_URI[aarch64_rust-find-msvc-tools-devel.sha256sum] = "03689aca2a5f2165a2cac58f046166036db41b3d1873b9b8a4b1433a5606ef14"

RDEPENDS:rust-find-msvc-tools+default-devel = " \
 cargo \
 rust-find-msvc-tools-devel \
 "
RDEPENDS:rust-find-msvc-tools-devel = " \
 cargo \
 rust \
 "
