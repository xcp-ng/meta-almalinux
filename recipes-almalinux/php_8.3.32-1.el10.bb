# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php"
PV = "8.3.32"
PR = "1.el10"
PACKAGES = " \
 php \
 php-bcmath \
 php-cli \
 php-common \
 php-dba \
 php-dbg \
 php-devel \
 php-embedded \
 php-enchant \
 php-ffi \
 php-fpm \
 php-gd \
 php-gmp \
 php-intl \
 php-ldap \
 php-mbstring \
 php-mysqlnd \
 php-odbc \
 php-opcache \
 php-pdo \
 php-pgsql \
 php-process \
 php-snmp \
 php-soap \
 php-xml \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/php-8.3.32-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eea7c72e7342416d512bede67a9a12907b51e097bd0f4853bcd52f93a8fa4747"

URI_x86_64_v2_php = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-8.3.32-1.el10.x86_64_v2.rpm;name=x86_64_v2_php;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php}"
SRC_URI[x86_64_v2_php.sha256sum] = "661f50b27d1f1e2a0912b5104b48f056a2f59cfeac9e987ff9b9f9d74de6eff4"
RPROVIDES:php:x86_64_v2 = "virtual/php"

URI_x86_64_v2_php-bcmath = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-bcmath-8.3.32-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-bcmath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-bcmath}"
SRC_URI[x86_64_v2_php-bcmath.sha256sum] = "8434372145310f864fea80d4e1dd9118b363ebffa0a289685b4bcba49cd18b7b"
RPROVIDES:php-bcmath:x86_64_v2 = "virtual/php-bcmath"

URI_x86_64_v2_php-cli = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-cli-8.3.32-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-cli}"
SRC_URI[x86_64_v2_php-cli.sha256sum] = "798c13d2b265320822470d80da1535739ad5dd72472c785c01a530b75be237ef"
RPROVIDES:php-cli:x86_64_v2 = "virtual//usr/bin/php virtual/php-cli virtual/php-pcntl"

URI_x86_64_v2_php-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-common-8.3.32-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-common}"
SRC_URI[x86_64_v2_php-common.sha256sum] = "d1658a2b18516c95e96631959dae9ad3dadb284483867aa6d4e5445a1f5a4621"
RPROVIDES:php-common:x86_64_v2 = "virtual/php-bz2 virtual/php-ctype virtual/php-curl virtual/php-date virtual/php-exif virtual/php-fileinfo virtual/php-filter virtual/php-ftp virtual/php-gettext virtual/php-hash virtual/php-iconv virtual/php-iconv_x86-64_ virtual/php-json virtual/php-json_x86-64_ virtual/php-libxml virtual/php-mhash virtual/php-openssl virtual/php-pcre virtual/php-phar virtual/php-reflection virtual/php-session virtual/php-sockets virtual/php-sockets_x86-64_ virtual/php-spl virtual/php-spl_x86-64_ virtual/php-tokenizer virtual/php-tokenizer_x86-64_ virtual/php-zlib virtual/php_language__ge_5.3.0 virtual/php_language__ge_5.3.1 virtual/php_language__ge_5.3.3 virtual/php_language__ge_7.1 virtual/php_language__ge_7.2 virtual/php_language__ge_7.2.5 virtual/php_language__ge_7.3 virtual/php_language__ge_7.4 virtual/php_language__ge_8.1 virtual/php_language__gt_5.3 virtual/php_language__gt_5.4"

URI_x86_64_v2_php-dba = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-dba-8.3.32-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-dba;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-dba}"
SRC_URI[x86_64_v2_php-dba.sha256sum] = "5aa933bce9670a380cfc0977f8508e7a79ec0b387f8a76da376f5ea22760b00c"

URI_x86_64_v2_php-dbg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-dbg-8.3.32-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-dbg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-dbg}"
SRC_URI[x86_64_v2_php-dbg.sha256sum] = "e456d1da8def4a0c365ab6cb57907c7642131ca44abbe420755b3751479d270e"

URI_x86_64_v2_php-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-devel-8.3.32-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-devel}"
SRC_URI[x86_64_v2_php-devel.sha256sum] = "96190f51e1941811970089680986dc657e7f79d5c85122a9323374d1efa3be2b"

URI_x86_64_v2_php-embedded = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-embedded-8.3.32-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-embedded;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-embedded}"
SRC_URI[x86_64_v2_php-embedded.sha256sum] = "f0cce009b6ca89cd75f3917c8fb3f93eddf0cf7813b2d55000b9f549fc2bed9a"

URI_x86_64_v2_php-enchant = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-enchant-8.3.32-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-enchant;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-enchant}"
SRC_URI[x86_64_v2_php-enchant.sha256sum] = "e03ad27c6f1fa5a60ec0cfa16e4eace0d69de27f3840eea62629c3dd11acdb72"

URI_x86_64_v2_php-ffi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-ffi-8.3.32-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-ffi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-ffi}"
SRC_URI[x86_64_v2_php-ffi.sha256sum] = "251a48998aea2b3728a952df44cb7b2fc89ba31e428a182b9f1e075e2f89e77b"

URI_x86_64_v2_php-fpm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-fpm-8.3.32-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-fpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-fpm}"
SRC_URI[x86_64_v2_php-fpm.sha256sum] = "5562cd2e5ac71eb5895cabf669f3182cf9095e011c0450321d96f35f520db45a"
RPROVIDES:php-fpm:x86_64_v2 = "virtual/php-fpm virtual/php-fpm_ge_8.0 virtual/php_httpd_"

URI_x86_64_v2_php-gd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-gd-8.3.32-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-gd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-gd}"
SRC_URI[x86_64_v2_php-gd.sha256sum] = "bbea7f0657da84aa20809ce5d0ec568da6a7cc781e32754263278898f5dd8f2d"
RPROVIDES:php-gd:x86_64_v2 = "virtual/php-gd virtual/php-gd_x86-64_"

URI_x86_64_v2_php-gmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-gmp-8.3.32-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-gmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-gmp}"
SRC_URI[x86_64_v2_php-gmp.sha256sum] = "36ab44b33ce2a7dba7e23a712b85848c326537c7dbbd93488a65e717e8d2d3c5"
RPROVIDES:php-gmp:x86_64_v2 = "virtual/php-gmp"

URI_x86_64_v2_php-intl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-intl-8.3.32-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-intl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-intl}"
SRC_URI[x86_64_v2_php-intl.sha256sum] = "ad8506664363cbaa54f43b941d261eb697ad75f4d03d38148df6029e58fc409c"
RPROVIDES:php-intl:x86_64_v2 = "virtual/php-intl"

URI_x86_64_v2_php-ldap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-ldap-8.3.32-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-ldap}"
SRC_URI[x86_64_v2_php-ldap.sha256sum] = "ae34ff935b0c4f1d88769d1a968bf623381d4955bb837a36f47052f75678ef3e"
RPROVIDES:php-ldap:x86_64_v2 = "virtual/php-ldap"

URI_x86_64_v2_php-mbstring = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-mbstring-8.3.32-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-mbstring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-mbstring}"
SRC_URI[x86_64_v2_php-mbstring.sha256sum] = "39a67d98b16b030d51501ebac3d1ad306c99d7fbb0c54f3ad1088fa9e4ad07b7"
RPROVIDES:php-mbstring:x86_64_v2 = "virtual/php-mbstring"

URI_x86_64_v2_php-mysqlnd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-mysqlnd-8.3.32-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-mysqlnd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-mysqlnd}"
SRC_URI[x86_64_v2_php-mysqlnd.sha256sum] = "14b2a366b760bc1d6573d057aa81b6ae3b3215f7f2655411e805fc855390163c"
RPROVIDES:php-mysqlnd:x86_64_v2 = "virtual/php-mysqli virtual/php-mysqlnd"

URI_x86_64_v2_php-odbc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-odbc-8.3.32-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-odbc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-odbc}"
SRC_URI[x86_64_v2_php-odbc.sha256sum] = "a99ba96e3458711d2b904fca75eefbe3fcce8d2e841b40510c2980d012272bfb"

URI_x86_64_v2_php-opcache = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-opcache-8.3.32-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-opcache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-opcache}"
SRC_URI[x86_64_v2_php-opcache.sha256sum] = "8751d90b08f16f6d0f7e7ce03b4588f34206fb775e46cc4bd066e542aea3d3c9"
RPROVIDES:php-opcache:x86_64_v2 = "virtual/php-opcache"

URI_x86_64_v2_php-pdo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-pdo-8.3.32-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-pdo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pdo}"
SRC_URI[x86_64_v2_php-pdo.sha256sum] = "7d8f35486cde6f04717d1f18e6e318af451c47b7c2ace90c2885f8ae8288b606"
RPROVIDES:php-pdo:x86_64_v2 = "virtual/php-pdo virtual/php-sqlite3"

URI_x86_64_v2_php-pgsql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-pgsql-8.3.32-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pgsql}"
SRC_URI[x86_64_v2_php-pgsql.sha256sum] = "48e1efb11b86046ceb1d48d5566f3f2493fee2a2bafe4cfecc86ae1cb7630824"
RPROVIDES:php-pgsql:x86_64_v2 = "virtual/php-pgsql"

URI_x86_64_v2_php-process = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-process-8.3.32-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-process;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-process}"
SRC_URI[x86_64_v2_php-process.sha256sum] = "e6bcb7a42f97b7d0fc4e5d6d80554b80b34172fcc55801fe2e35dd730c49b89a"
RPROVIDES:php-process:x86_64_v2 = "virtual/php-posix virtual/php-process"

URI_x86_64_v2_php-snmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-snmp-8.3.32-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-snmp}"
SRC_URI[x86_64_v2_php-snmp.sha256sum] = "6eb34d9861931e8affb0663dacdfcc443af36f664ab04804c79933fe7322778e"

URI_x86_64_v2_php-soap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-soap-8.3.32-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-soap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-soap}"
SRC_URI[x86_64_v2_php-soap.sha256sum] = "31533589b6477defddee46b67f30f40872ffa4f56fdbbb10b30da1944d4b8f44"

URI_x86_64_v2_php-xml = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-xml-8.3.32-1.el10.x86_64_v2.rpm;name=x86_64_v2_php-xml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-xml}"
SRC_URI[x86_64_v2_php-xml.sha256sum] = "de752c1c0206d51894c03ce49475df63000ffd75267b15b1296254b941747166"
RPROVIDES:php-xml:x86_64_v2 = "virtual/php-dom virtual/php-simplexml virtual/php-xml virtual/php-xmlreader virtual/php-xmlwriter virtual/php-xsl"

URI_aarch64_php = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-8.3.32-1.el10.aarch64.rpm;name=aarch64_php;unpack=0"
SRC_URI:append = " ${URI_aarch64_php}"
SRC_URI[aarch64_php.sha256sum] = "6bf1f9ca2b9b1aa412fbc0e4d09df0de2fc8572fba4aa11bde8a918ca15e8782"
RPROVIDES:php:aarch64 = "virtual/php"

URI_aarch64_php-bcmath = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-bcmath-8.3.32-1.el10.aarch64.rpm;name=aarch64_php-bcmath;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-bcmath}"
SRC_URI[aarch64_php-bcmath.sha256sum] = "ae4f6409eacc12e3244dac35433ee39ec02511f28c6d071f3dec32310a5931cd"
RPROVIDES:php-bcmath:aarch64 = "virtual/php-bcmath"

URI_aarch64_php-cli = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-cli-8.3.32-1.el10.aarch64.rpm;name=aarch64_php-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-cli}"
SRC_URI[aarch64_php-cli.sha256sum] = "2f02e9b3ffc7236b52581853b46b8b88f6b5938fb21d81e637bb9d22d03638ee"
RPROVIDES:php-cli:aarch64 = "virtual//usr/bin/php virtual/php-cli virtual/php-pcntl"

URI_aarch64_php-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-common-8.3.32-1.el10.aarch64.rpm;name=aarch64_php-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-common}"
SRC_URI[aarch64_php-common.sha256sum] = "8e8e74a004fd29be27a61893dcb6b326131eedace8f60c1010423297e50147f1"
RPROVIDES:php-common:aarch64 = "virtual/php-bz2 virtual/php-ctype virtual/php-curl virtual/php-date virtual/php-exif virtual/php-fileinfo virtual/php-filter virtual/php-ftp virtual/php-gettext virtual/php-hash virtual/php-iconv virtual/php-iconv_aarch-64_ virtual/php-json virtual/php-json_aarch-64_ virtual/php-libxml virtual/php-mhash virtual/php-openssl virtual/php-pcre virtual/php-phar virtual/php-reflection virtual/php-session virtual/php-sockets virtual/php-sockets_aarch-64_ virtual/php-spl virtual/php-spl_aarch-64_ virtual/php-tokenizer virtual/php-tokenizer_aarch-64_ virtual/php-zlib virtual/php_language__ge_5.3.0 virtual/php_language__ge_5.3.1 virtual/php_language__ge_5.3.3 virtual/php_language__ge_7.1 virtual/php_language__ge_7.2 virtual/php_language__ge_7.2.5 virtual/php_language__ge_7.3 virtual/php_language__ge_7.4 virtual/php_language__ge_8.1 virtual/php_language__gt_5.3 virtual/php_language__gt_5.4"

URI_aarch64_php-dba = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-dba-8.3.32-1.el10.aarch64.rpm;name=aarch64_php-dba;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-dba}"
SRC_URI[aarch64_php-dba.sha256sum] = "fff50ae684452312dda448465eaf801cbb69babebc02843dba1f5608bc9b633d"

URI_aarch64_php-dbg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-dbg-8.3.32-1.el10.aarch64.rpm;name=aarch64_php-dbg;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-dbg}"
SRC_URI[aarch64_php-dbg.sha256sum] = "2a6a30ea15e39ccf361d10c6e1b17cdd8b92976a724462ddbe8628e83c8306f9"

URI_aarch64_php-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-devel-8.3.32-1.el10.aarch64.rpm;name=aarch64_php-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-devel}"
SRC_URI[aarch64_php-devel.sha256sum] = "99e9cd8039fdd7bbefd6c9eeba1d8ffbe1d807d4194afadbd734cc36e2789b71"

URI_aarch64_php-embedded = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-embedded-8.3.32-1.el10.aarch64.rpm;name=aarch64_php-embedded;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-embedded}"
SRC_URI[aarch64_php-embedded.sha256sum] = "19c2126f36b868687c188aa8051a8ba70c6c5624cf50b92378ea05354ab942e9"

URI_aarch64_php-enchant = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-enchant-8.3.32-1.el10.aarch64.rpm;name=aarch64_php-enchant;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-enchant}"
SRC_URI[aarch64_php-enchant.sha256sum] = "0ca3ece406e17d36eb52ffb111c501e428746bd9bddaa4d5339d6cd6db51f5e9"

URI_aarch64_php-ffi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-ffi-8.3.32-1.el10.aarch64.rpm;name=aarch64_php-ffi;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-ffi}"
SRC_URI[aarch64_php-ffi.sha256sum] = "1669b76b01afa37bbdc82cad732872b4f706643ff5e5df8ae09ddff97887dd2c"

URI_aarch64_php-fpm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-fpm-8.3.32-1.el10.aarch64.rpm;name=aarch64_php-fpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-fpm}"
SRC_URI[aarch64_php-fpm.sha256sum] = "68f91a68fcd4566bf479cf70f1f15d5bef024323d87b2f9bd5fdf19cb48f625d"
RPROVIDES:php-fpm:aarch64 = "virtual/php-fpm virtual/php-fpm_ge_8.0 virtual/php_httpd_"

URI_aarch64_php-gd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-gd-8.3.32-1.el10.aarch64.rpm;name=aarch64_php-gd;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-gd}"
SRC_URI[aarch64_php-gd.sha256sum] = "ea2850ac3c0dd311410c0b8e46e87aac2db9b69d97712464a7f1633f19ebd2cb"
RPROVIDES:php-gd:aarch64 = "virtual/php-gd virtual/php-gd_aarch-64_"

URI_aarch64_php-gmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-gmp-8.3.32-1.el10.aarch64.rpm;name=aarch64_php-gmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-gmp}"
SRC_URI[aarch64_php-gmp.sha256sum] = "9b4294a150beb5a20ab909838d293952346aa73c7685979a8d1c9334b67e4c1c"
RPROVIDES:php-gmp:aarch64 = "virtual/php-gmp"

URI_aarch64_php-intl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-intl-8.3.32-1.el10.aarch64.rpm;name=aarch64_php-intl;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-intl}"
SRC_URI[aarch64_php-intl.sha256sum] = "76e98136cb353ec0dfd6824888a8785d894772000cfd9beecd4af0197b324ef5"
RPROVIDES:php-intl:aarch64 = "virtual/php-intl"

URI_aarch64_php-ldap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-ldap-8.3.32-1.el10.aarch64.rpm;name=aarch64_php-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-ldap}"
SRC_URI[aarch64_php-ldap.sha256sum] = "510d00ed8da35c31f314c77548aa7804a30dde3efd597d4b16849c1e1d066037"
RPROVIDES:php-ldap:aarch64 = "virtual/php-ldap"

URI_aarch64_php-mbstring = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-mbstring-8.3.32-1.el10.aarch64.rpm;name=aarch64_php-mbstring;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-mbstring}"
SRC_URI[aarch64_php-mbstring.sha256sum] = "435335d3c5c0de5343cb51d15f3ed3376616bdfa7031187b10a4f07ad012351c"
RPROVIDES:php-mbstring:aarch64 = "virtual/php-mbstring"

URI_aarch64_php-mysqlnd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-mysqlnd-8.3.32-1.el10.aarch64.rpm;name=aarch64_php-mysqlnd;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-mysqlnd}"
SRC_URI[aarch64_php-mysqlnd.sha256sum] = "9f1da48c8930251e48f461c7c87fe35a5f2dc6c9f7601075e5749b6952b120c7"
RPROVIDES:php-mysqlnd:aarch64 = "virtual/php-mysqli virtual/php-mysqlnd"

URI_aarch64_php-odbc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-odbc-8.3.32-1.el10.aarch64.rpm;name=aarch64_php-odbc;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-odbc}"
SRC_URI[aarch64_php-odbc.sha256sum] = "6929ab9ab39ed7be355467f0c67b79b7e74729b322bf06a0628a102c277283ab"

URI_aarch64_php-opcache = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-opcache-8.3.32-1.el10.aarch64.rpm;name=aarch64_php-opcache;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-opcache}"
SRC_URI[aarch64_php-opcache.sha256sum] = "2298bbead3a8af7d7a03fb6c600d3fd2b4949e353cfef33a99d748596786d994"
RPROVIDES:php-opcache:aarch64 = "virtual/php-opcache"

URI_aarch64_php-pdo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-pdo-8.3.32-1.el10.aarch64.rpm;name=aarch64_php-pdo;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pdo}"
SRC_URI[aarch64_php-pdo.sha256sum] = "48269861fc5259d395525bf37d3670007ec67053f14411937d2eb8788b314247"
RPROVIDES:php-pdo:aarch64 = "virtual/php-pdo virtual/php-sqlite3"

URI_aarch64_php-pgsql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-pgsql-8.3.32-1.el10.aarch64.rpm;name=aarch64_php-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pgsql}"
SRC_URI[aarch64_php-pgsql.sha256sum] = "dee2c4d0b099277f5482220cb5ef56f660f5612ff405ba26df27cec3a211d4b9"
RPROVIDES:php-pgsql:aarch64 = "virtual/php-pgsql"

URI_aarch64_php-process = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-process-8.3.32-1.el10.aarch64.rpm;name=aarch64_php-process;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-process}"
SRC_URI[aarch64_php-process.sha256sum] = "f581858b778c1bea9cc10d8da3b3320cfbdaa12a67d7b74b24e6dce0646d2ac1"
RPROVIDES:php-process:aarch64 = "virtual/php-posix virtual/php-process"

URI_aarch64_php-snmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-snmp-8.3.32-1.el10.aarch64.rpm;name=aarch64_php-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-snmp}"
SRC_URI[aarch64_php-snmp.sha256sum] = "ccc8dd390d50b9ff7f29d99821cfff7d0a1816505f82c104ff20f7caa5ce9e21"

URI_aarch64_php-soap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-soap-8.3.32-1.el10.aarch64.rpm;name=aarch64_php-soap;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-soap}"
SRC_URI[aarch64_php-soap.sha256sum] = "8cb65f64a6fcc0a3db5a9e7afce169d7b4248aabdbf8496250ac6d7f2a2b7531"

URI_aarch64_php-xml = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-xml-8.3.32-1.el10.aarch64.rpm;name=aarch64_php-xml;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-xml}"
SRC_URI[aarch64_php-xml.sha256sum] = "0a25d793ac05aaf757814bc792b4dd49cd10527c6b58fdf381ae909b5b5dd13a"
RPROVIDES:php-xml:aarch64 = "virtual/php-dom virtual/php-simplexml virtual/php-xml virtual/php-xmlreader virtual/php-xmlwriter virtual/php-xsl"

RDEPENDS:php = " \
 php-common \
 "
RDEPENDS:php-bcmath = " \
 glibc \
 php-common \
 "
RDEPENDS:php-cli = " \
 bash \
 glibc \
 libedit \
 libxcrypt \
 libxml2 \
 openssl-libs \
 pcre2 \
 php-common \
 zlib-ng-compat \
 "
RDEPENDS:php-common = " \
 bzip2-libs \
 glibc \
 openssl-libs \
 tzdata \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:php-dba = " \
 glibc \
 lmdb-libs \
 php-common \
 tokyocabinet \
 "
RDEPENDS:php-dbg = " \
 glibc \
 libedit \
 libxcrypt \
 libxml2 \
 openssl-libs \
 pcre2 \
 php-common \
 zlib-ng-compat \
 "
RDEPENDS:php-devel = " \
 autoconf \
 automake \
 bash \
 gcc \
 gcc-c++ \
 krb5-devel \
 libtool \
 libxml2-devel \
 make \
 openssl-devel \
 pcre2-devel \
 php-cli \
 zlib-ng-compat-devel \
 "
RDEPENDS:php-embedded = " \
 glibc \
 krb5-libs \
 libcom_err \
 libxcrypt \
 libxml2 \
 openssl-libs \
 pcre2 \
 php-common \
 zlib-ng-compat \
 "
RDEPENDS:php-enchant = " \
 enchant2 \
 glibc \
 php-common \
 "
RDEPENDS:php-ffi = " \
 glibc \
 libffi \
 php-common \
 "
RDEPENDS:php-fpm = " \
 bash \
 glibc \
 httpd-filesystem \
 libacl \
 libselinux \
 libxcrypt \
 libxml2 \
 nginx-filesystem \
 openssl-libs \
 pcre2 \
 php-common \
 systemd \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:php-gd = " \
 gd \
 glibc \
 php-common \
 "
RDEPENDS:php-gmp = " \
 glibc \
 gmp \
 php-common \
 "
RDEPENDS:php-intl = " \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 php-common \
 "
RDEPENDS:php-ldap = " \
 cyrus-sasl-lib \
 glibc \
 openldap \
 php-common \
 "
RDEPENDS:php-mbstring = " \
 glibc \
 oniguruma \
 php-common \
 "
RDEPENDS:php-mysqlnd = " \
 glibc \
 php-pdo \
 "
RDEPENDS:php-odbc = " \
 glibc \
 php-pdo \
 unixODBC \
 "
RDEPENDS:php-opcache:x86_64_v2 = " \
 capstone \
 glibc \
 libgcc \
 php-common \
"
RDEPENDS:php-opcache:aarch64 = " \
 capstone \
 glibc \
 php-common \
"
RDEPENDS:php-pdo = " \
 glibc \
 php-common \
 sqlite-libs \
 "
RDEPENDS:php-pgsql = " \
 glibc \
 libpq \
 php-pdo \
 "
RDEPENDS:php-process = " \
 glibc \
 php-common \
 "
RDEPENDS:php-snmp = " \
 glibc \
 net-snmp \
 net-snmp-libs \
 openssl-libs \
 php-common \
 "
RDEPENDS:php-soap = " \
 glibc \
 libxml2 \
 php-common \
 "
RDEPENDS:php-xml = " \
 glibc \
 libxml2 \
 libxslt \
 php-common \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual//usr/bin/php rpm/virtual/php rpm/virtual/php-bcmath rpm/virtual/php-bz2 rpm/virtual/php-cli rpm/virtual/php-ctype rpm/virtual/php-curl rpm/virtual/php-date rpm/virtual/php-dom rpm/virtual/php-exif rpm/virtual/php-fileinfo rpm/virtual/php-filter rpm/virtual/php-fpm rpm/virtual/php-fpm_ge_8.0 rpm/virtual/php-ftp rpm/virtual/php-gd rpm/virtual/php-gd_x86-64_ rpm/virtual/php-gettext rpm/virtual/php-gmp rpm/virtual/php-hash rpm/virtual/php-iconv rpm/virtual/php-iconv_x86-64_ rpm/virtual/php-intl rpm/virtual/php-json rpm/virtual/php-json_x86-64_ rpm/virtual/php-ldap rpm/virtual/php-libxml rpm/virtual/php-mbstring rpm/virtual/php-mhash rpm/virtual/php-mysqli rpm/virtual/php-mysqlnd rpm/virtual/php-opcache rpm/virtual/php-openssl rpm/virtual/php-pcntl rpm/virtual/php-pcre rpm/virtual/php-pdo rpm/virtual/php-pgsql rpm/virtual/php-phar rpm/virtual/php-posix rpm/virtual/php-process rpm/virtual/php-reflection rpm/virtual/php-session rpm/virtual/php-simplexml rpm/virtual/php-sockets rpm/virtual/php-sockets_x86-64_ rpm/virtual/php-spl rpm/virtual/php-spl_x86-64_ rpm/virtual/php-sqlite3 rpm/virtual/php-tokenizer rpm/virtual/php-tokenizer_x86-64_ rpm/virtual/php-xml rpm/virtual/php-xmlreader rpm/virtual/php-xmlwriter rpm/virtual/php-xsl rpm/virtual/php-zlib rpm/virtual/php_httpd_ rpm/virtual/php_language__ge_5.3.0 rpm/virtual/php_language__ge_5.3.1 rpm/virtual/php_language__ge_5.3.3 rpm/virtual/php_language__ge_7.1 rpm/virtual/php_language__ge_7.2 rpm/virtual/php_language__ge_7.2.5 rpm/virtual/php_language__ge_7.3 rpm/virtual/php_language__ge_7.4 rpm/virtual/php_language__ge_8.1 rpm/virtual/php_language__gt_5.3 rpm/virtual/php_language__gt_5.4"

PROVIDES:append:aarch64 = " rpm/virtual//usr/bin/php rpm/virtual/php rpm/virtual/php-bcmath rpm/virtual/php-bz2 rpm/virtual/php-cli rpm/virtual/php-ctype rpm/virtual/php-curl rpm/virtual/php-date rpm/virtual/php-dom rpm/virtual/php-exif rpm/virtual/php-fileinfo rpm/virtual/php-filter rpm/virtual/php-fpm rpm/virtual/php-fpm_ge_8.0 rpm/virtual/php-ftp rpm/virtual/php-gd rpm/virtual/php-gd_aarch-64_ rpm/virtual/php-gettext rpm/virtual/php-gmp rpm/virtual/php-hash rpm/virtual/php-iconv rpm/virtual/php-iconv_aarch-64_ rpm/virtual/php-intl rpm/virtual/php-json rpm/virtual/php-json_aarch-64_ rpm/virtual/php-ldap rpm/virtual/php-libxml rpm/virtual/php-mbstring rpm/virtual/php-mhash rpm/virtual/php-mysqli rpm/virtual/php-mysqlnd rpm/virtual/php-opcache rpm/virtual/php-openssl rpm/virtual/php-pcntl rpm/virtual/php-pcre rpm/virtual/php-pdo rpm/virtual/php-pgsql rpm/virtual/php-phar rpm/virtual/php-posix rpm/virtual/php-process rpm/virtual/php-reflection rpm/virtual/php-session rpm/virtual/php-simplexml rpm/virtual/php-sockets rpm/virtual/php-sockets_aarch-64_ rpm/virtual/php-spl rpm/virtual/php-spl_aarch-64_ rpm/virtual/php-sqlite3 rpm/virtual/php-tokenizer rpm/virtual/php-tokenizer_aarch-64_ rpm/virtual/php-xml rpm/virtual/php-xmlreader rpm/virtual/php-xmlwriter rpm/virtual/php-xsl rpm/virtual/php-zlib rpm/virtual/php_httpd_ rpm/virtual/php_language__ge_5.3.0 rpm/virtual/php_language__ge_5.3.1 rpm/virtual/php_language__ge_5.3.3 rpm/virtual/php_language__ge_7.1 rpm/virtual/php_language__ge_7.2 rpm/virtual/php_language__ge_7.2.5 rpm/virtual/php_language__ge_7.3 rpm/virtual/php_language__ge_7.4 rpm/virtual/php_language__ge_8.1 rpm/virtual/php_language__gt_5.3 rpm/virtual/php_language__gt_5.4"
