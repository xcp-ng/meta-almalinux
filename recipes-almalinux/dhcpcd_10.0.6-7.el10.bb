# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dhcpcd"
PV = "10.0.6"
PR = "7.el10"
PACKAGES = " \
 dhcpcd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/dhcpcd-10.0.6-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5c72657744c3b9c884130c211a2d2ca498b72ad1c7f580b8420a65975f5fcf75"

URI_x86_64_v2_dhcpcd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dhcpcd-10.0.6-7.el10.x86_64_v2.rpm;name=x86_64_v2_dhcpcd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dhcpcd}"
SRC_URI[x86_64_v2_dhcpcd.sha256sum] = "38cb16e27b60cf9e71660db9ae4b6c5969b97841a09cad68553021651702ea03"

URI_aarch64_dhcpcd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dhcpcd-10.0.6-7.el10.aarch64.rpm;name=aarch64_dhcpcd;unpack=0"
SRC_URI:append = " ${URI_aarch64_dhcpcd}"
SRC_URI[aarch64_dhcpcd.sha256sum] = "444ae5a212b3ecf7cfa6776d5fa313faadf232d1297a00e804471595ef24590d"

RDEPENDS:dhcpcd = " \
 bash \
 glibc \
 systemd \
 systemd-libs \
 "
