# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.14-semantic_version"
PV = "2.10.0"
PR = "4.el10"
PACKAGES = " \
 python3.14-semantic_version \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/python3.14-semantic_version-2.10.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "738605659dc0f9f0c5ab0a22b42b949bc4d87d5f4a9de49d2578da651809a3ff"

URI_x86_64_v2_python3.14-semantic_version = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-semantic_version-2.10.0-4.el10.noarch.rpm;name=x86_64_v2_python3.14-semantic_version;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-semantic_version}"
SRC_URI[x86_64_v2_python3.14-semantic_version.sha256sum] = "b9f879ed3613eda32bdf2eae784476801852bc2ad785b672b6cd1e522fa094ad"

URI_aarch64_python3.14-semantic_version = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-semantic_version-2.10.0-4.el10.noarch.rpm;name=aarch64_python3.14-semantic_version;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-semantic_version}"
SRC_URI[aarch64_python3.14-semantic_version.sha256sum] = "b9f879ed3613eda32bdf2eae784476801852bc2ad785b672b6cd1e522fa094ad"

RDEPENDS:python3.14-semantic_version = " \
 python3.14 \
 "
