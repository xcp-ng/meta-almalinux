# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rosdistro"
PV = "1.1.0"
PR = "1.el10_2"
PACKAGES = " \
 python-rosdistro-doc \
 python3-rosdistro \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-rosdistro-1.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "63de7d4b61ba74fec7e0414653b101c2ea902bae0ff3f95140d84f570599c6b4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-rosdistro-doc-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-rosdistro-doc;unpack=0"
SRC_URI[x86_64_v2_python-rosdistro-doc.sha256sum] = "23a87df100f80476a07c3d8e79da9ecf789acc15c1dd4df45cdf42f22412af5d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rosdistro-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rosdistro;unpack=0"
SRC_URI[x86_64_v2_python3-rosdistro.sha256sum] = "91c8d36b6d5b4d219a893cc019ef0764e81632da7b15f1e0864b866b876cb96a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-rosdistro-doc-1.1.0-1.el10_2.noarch.rpm;name=aarch64_python-rosdistro-doc;unpack=0"
SRC_URI[aarch64_python-rosdistro-doc.sha256sum] = "7cfe0a62a1eb61c8361a75d67db4015121fd67732d42c8a5e3f262fc206cd372"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-rosdistro-1.1.0-1.el10_2.noarch.rpm;name=aarch64_python3-rosdistro;unpack=0"
SRC_URI[aarch64_python3-rosdistro.sha256sum] = "02c8c18812798a8e1e40ef64e6cb3758d494c7fc400f79ce538278355f160bdb"

RDEPENDS:python-rosdistro-doc = " \
 "
RDEPENDS:python3-rosdistro = " \
 python3 \
 python3-catkin_pkg \
 python3-packaging \
 python3-pyyaml \
 python3-rospkg \
 python3-setuptools \
 "
