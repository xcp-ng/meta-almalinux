# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libraw1394"
PV = "2.1.2"
PR = "21.el10_0"
PACKAGES = " \
 libraw1394 \
 libraw1394-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libraw1394-2.1.2-21.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6ea92717f2d954828cbc53611995e95332b7fb28180661e4751cc541acd1742e"

URI_x86_64_v2_libraw1394 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libraw1394-2.1.2-21.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libraw1394;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libraw1394}"
SRC_URI[x86_64_v2_libraw1394.sha256sum] = "478da5b856533356d2aeaf1c8e222503346a8be0f8fb79322d02fb58e631c0e8"

URI_x86_64_v2_libraw1394-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libraw1394-devel-2.1.2-21.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libraw1394-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libraw1394-devel}"
SRC_URI[x86_64_v2_libraw1394-devel.sha256sum] = "750adba75bdaa2ec1b1ab19f94172be49f60feafd127eaa7b53113620eff3fd7"

URI_aarch64_libraw1394 = "${EPEL_MIRROR}/aarch64/Packages/l/libraw1394-2.1.2-21.el10_0.aarch64.rpm;name=aarch64_libraw1394;unpack=0"
SRC_URI:append = " ${URI_aarch64_libraw1394}"
SRC_URI[aarch64_libraw1394.sha256sum] = "ad47e633458b039e25c466a091739883b3563a2d1a1c41f831efdfad7f4a9b97"

URI_aarch64_libraw1394-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libraw1394-devel-2.1.2-21.el10_0.aarch64.rpm;name=aarch64_libraw1394-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libraw1394-devel}"
SRC_URI[aarch64_libraw1394-devel.sha256sum] = "5a79a195291d32238e42ee487e95f4b233a32e13f95c213436ba484579789a61"

RDEPENDS:libraw1394 = " \
 glibc \
 "
RDEPENDS:libraw1394-devel = " \
 libraw1394 \
 pkgconf-pkg-config \
 "
