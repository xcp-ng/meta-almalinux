# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-der"
PV = "0.7.10"
PR = "1.el10_1"
PACKAGES = " \
 rust-der+alloc-devel \
 rust-der+arbitrary-devel \
 rust-der+bytes-devel \
 rust-der+default-devel \
 rust-der+derive-devel \
 rust-der+flagset-devel \
 rust-der+oid-devel \
 rust-der+pem-devel \
 rust-der+real-devel \
 rust-der+std-devel \
 rust-der+time-devel \
 rust-der+zeroize-devel \
 rust-der-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-der-0.7.10-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f39472d95014d8899bc519b2905ea686e789de3c1eafcce2c89b663879b97cee"

URI_x86_64_v2_rust-der+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+alloc-devel-0.7.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+alloc-devel}"
SRC_URI[x86_64_v2_rust-der+alloc-devel.sha256sum] = "9e4ab59297011497d742e092fed29e1a74a028ac14aa4bcfc53bcc1765717289"

URI_x86_64_v2_rust-der+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+arbitrary-devel-0.7.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-der+arbitrary-devel.sha256sum] = "961df95a6350b3a6724c1f7fe89ebc40b97cba41d493c7ec55a29fa9ad3840b6"

URI_x86_64_v2_rust-der+bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+bytes-devel-0.7.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+bytes-devel}"
SRC_URI[x86_64_v2_rust-der+bytes-devel.sha256sum] = "c4936829a0001ddef96848ff3f4d686051057bd35c94e0239d6513a432fc1e8d"

URI_x86_64_v2_rust-der+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+default-devel-0.7.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+default-devel}"
SRC_URI[x86_64_v2_rust-der+default-devel.sha256sum] = "5f561699640ab30ff5c1ccf80079f7b2ce03efc24d2a8f43b53d7b742d4c57e8"

URI_x86_64_v2_rust-der+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+derive-devel-0.7.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+derive-devel}"
SRC_URI[x86_64_v2_rust-der+derive-devel.sha256sum] = "9960f6f190f06c19616e93964d337b0373a9810ff0593e25419c5651d19e3979"

URI_x86_64_v2_rust-der+flagset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+flagset-devel-0.7.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+flagset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+flagset-devel}"
SRC_URI[x86_64_v2_rust-der+flagset-devel.sha256sum] = "7c4b04ecd9b4afe26b15facc9196d620d87b8ed0c146711c2e524f58d5d42b23"

URI_x86_64_v2_rust-der+oid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+oid-devel-0.7.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+oid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+oid-devel}"
SRC_URI[x86_64_v2_rust-der+oid-devel.sha256sum] = "e4434de48f92a3d6d40f953ff1df25f7afda570c4d8c756547b79ff1837a1d8e"

URI_x86_64_v2_rust-der+pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+pem-devel-0.7.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+pem-devel}"
SRC_URI[x86_64_v2_rust-der+pem-devel.sha256sum] = "ec58e06ded3cbddbc46e51b7250db711790993e0f0e6359a2b408e262a58411d"

URI_x86_64_v2_rust-der+real-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+real-devel-0.7.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+real-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+real-devel}"
SRC_URI[x86_64_v2_rust-der+real-devel.sha256sum] = "ca136169d4107b96285cfea97491382baf7eaea00403947b36b866cb22fddd8c"

URI_x86_64_v2_rust-der+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+std-devel-0.7.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+std-devel}"
SRC_URI[x86_64_v2_rust-der+std-devel.sha256sum] = "f4881ade749c4ca4a536b0ac884126f903e62d2ffcb5502d9ef7fe21b12813e8"

URI_x86_64_v2_rust-der+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+time-devel-0.7.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+time-devel}"
SRC_URI[x86_64_v2_rust-der+time-devel.sha256sum] = "3143e6528457d0b1cb966e87ac1b40c57dff6a534c4ee2aa0f01465c41ae43b0"

URI_x86_64_v2_rust-der+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+zeroize-devel-0.7.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der+zeroize-devel}"
SRC_URI[x86_64_v2_rust-der+zeroize-devel.sha256sum] = "2c1c2ca8a3ba87ebbc28e635409698768f6c281269278f61d650384973f94526"

URI_x86_64_v2_rust-der-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der-devel-0.7.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der-devel}"
SRC_URI[x86_64_v2_rust-der-devel.sha256sum] = "4c7d356f5cb6cb7fb26c5deca8b1fb566bd0d73b3f6b8367871b592abfbe1ed2"

URI_aarch64_rust-der+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+alloc-devel-0.7.10-1.el10_1.noarch.rpm;name=aarch64_rust-der+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+alloc-devel}"
SRC_URI[aarch64_rust-der+alloc-devel.sha256sum] = "216f4582ba36dbe218971b5bb4cd6026c5dcea7aaa493e28d9899c2daac9f837"

URI_aarch64_rust-der+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+arbitrary-devel-0.7.10-1.el10_1.noarch.rpm;name=aarch64_rust-der+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+arbitrary-devel}"
SRC_URI[aarch64_rust-der+arbitrary-devel.sha256sum] = "4db38cd1b5fe933ae503283e137a032aaddb02d5e1904075efaa70590f2ce169"

URI_aarch64_rust-der+bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+bytes-devel-0.7.10-1.el10_1.noarch.rpm;name=aarch64_rust-der+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+bytes-devel}"
SRC_URI[aarch64_rust-der+bytes-devel.sha256sum] = "22941c3f69fad6af0ef0e204206c396bc44d8c42b9dec821e6cc31d394c049b0"

URI_aarch64_rust-der+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+default-devel-0.7.10-1.el10_1.noarch.rpm;name=aarch64_rust-der+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+default-devel}"
SRC_URI[aarch64_rust-der+default-devel.sha256sum] = "1ea0812d1eb63af90f049ddf95f84faa431cecb4da5de05c853567d706a66a80"

URI_aarch64_rust-der+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+derive-devel-0.7.10-1.el10_1.noarch.rpm;name=aarch64_rust-der+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+derive-devel}"
SRC_URI[aarch64_rust-der+derive-devel.sha256sum] = "a08f861f836dbf4b1fdffb0429fbceb790555a87d03d4c4e2bf38e79f98948a4"

URI_aarch64_rust-der+flagset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+flagset-devel-0.7.10-1.el10_1.noarch.rpm;name=aarch64_rust-der+flagset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+flagset-devel}"
SRC_URI[aarch64_rust-der+flagset-devel.sha256sum] = "b75adcfd249fba280e5ef6bf6f7bb35f388f5e08d9f7a7488c00579bd85f2d11"

URI_aarch64_rust-der+oid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+oid-devel-0.7.10-1.el10_1.noarch.rpm;name=aarch64_rust-der+oid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+oid-devel}"
SRC_URI[aarch64_rust-der+oid-devel.sha256sum] = "65daed3d8942506943ba3909053936479a9c94566d639ea3e6e0afc67d4ece93"

URI_aarch64_rust-der+pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+pem-devel-0.7.10-1.el10_1.noarch.rpm;name=aarch64_rust-der+pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+pem-devel}"
SRC_URI[aarch64_rust-der+pem-devel.sha256sum] = "e293f502b19c0323b7c5629a747d703b6c7fcc6c52f67820cb95ddffbfea7ac0"

URI_aarch64_rust-der+real-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+real-devel-0.7.10-1.el10_1.noarch.rpm;name=aarch64_rust-der+real-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+real-devel}"
SRC_URI[aarch64_rust-der+real-devel.sha256sum] = "55be870341243000e7fc1490172e84a741814a9d464dc8b12ba7f33aa02ad972"

URI_aarch64_rust-der+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+std-devel-0.7.10-1.el10_1.noarch.rpm;name=aarch64_rust-der+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+std-devel}"
SRC_URI[aarch64_rust-der+std-devel.sha256sum] = "5ad9bf0eb19c7fa08dc801e3ee64c22e02e34f19d38fe61e4e77af40c077927f"

URI_aarch64_rust-der+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+time-devel-0.7.10-1.el10_1.noarch.rpm;name=aarch64_rust-der+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+time-devel}"
SRC_URI[aarch64_rust-der+time-devel.sha256sum] = "6dd6cb4a9ff67bfceb311944e336aa2a78635c94f650186530028d374ce75a93"

URI_aarch64_rust-der+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der+zeroize-devel-0.7.10-1.el10_1.noarch.rpm;name=aarch64_rust-der+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der+zeroize-devel}"
SRC_URI[aarch64_rust-der+zeroize-devel.sha256sum] = "50dc3067a9cc036c4ca5966c729567787ae92cce0d223efd5999b79ac760ecbf"

URI_aarch64_rust-der-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der-devel-0.7.10-1.el10_1.noarch.rpm;name=aarch64_rust-der-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der-devel}"
SRC_URI[aarch64_rust-der-devel.sha256sum] = "c3bd6415aee91c4a4d7037b999ed59dde0cd29677559d29698794ff0a97072e6"

RDEPENDS:rust-der+alloc-devel = " \
 cargo \
 rust-der-devel \
 rust-zeroize+alloc-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-der+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-const-oid+arbitrary-devel \
 rust-const-oid+default-devel \
 rust-der+std-devel \
 rust-der-devel \
 "
RDEPENDS:rust-der+bytes-devel = " \
 cargo \
 rust-bytes-devel \
 rust-der+alloc-devel \
 rust-der-devel \
 "
RDEPENDS:rust-der+default-devel = " \
 cargo \
 rust-der-devel \
 "
RDEPENDS:rust-der+derive-devel = " \
 cargo \
 rust-der-devel \
 rust-der_derive+default-devel \
 "
RDEPENDS:rust-der+flagset-devel = " \
 cargo \
 rust-der-devel \
 rust-flagset+default-devel \
 "
RDEPENDS:rust-der+oid-devel = " \
 cargo \
 rust-const-oid+default-devel \
 rust-der-devel \
 "
RDEPENDS:rust-der+pem-devel = " \
 cargo \
 rust-der+alloc-devel \
 rust-der+zeroize-devel \
 rust-der-devel \
 rust-pem-rfc7468+alloc-devel \
 rust-pem-rfc7468+default-devel \
 "
RDEPENDS:rust-der+real-devel = " \
 cargo \
 rust-der-devel \
 "
RDEPENDS:rust-der+std-devel = " \
 cargo \
 rust-der+alloc-devel \
 rust-der-devel \
 "
RDEPENDS:rust-der+time-devel = " \
 cargo \
 rust-der-devel \
 rust-time-devel \
 "
RDEPENDS:rust-der+zeroize-devel = " \
 cargo \
 rust-der-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-der-devel = " \
 cargo \
 rust \
 "
