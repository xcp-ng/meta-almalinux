# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-regex-syntax"
PV = "0.8.11"
PR = "1.el10_2"
PACKAGES = " \
 rust-regex-syntax+arbitrary-devel \
 rust-regex-syntax+default-devel \
 rust-regex-syntax+std-devel \
 rust-regex-syntax+unicode-age-devel \
 rust-regex-syntax+unicode-bool-devel \
 rust-regex-syntax+unicode-case-devel \
 rust-regex-syntax+unicode-devel \
 rust-regex-syntax+unicode-gencat-devel \
 rust-regex-syntax+unicode-perl-devel \
 rust-regex-syntax+unicode-script-devel \
 rust-regex-syntax+unicode-segment-devel \
 rust-regex-syntax-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-regex-syntax-0.8.11-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ea2121f857f3ed9d8ab5777c41bb8e91bf94c3ffabb01dc5c16c55d83103dd97"

URI_x86_64_v2_rust-regex-syntax+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+arbitrary-devel-0.8.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+arbitrary-devel.sha256sum] = "b73c5d93a6cd3294d4edd81023f7e18093cac0287a512c3a94d8377af96dcdfd"

URI_x86_64_v2_rust-regex-syntax+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+default-devel-0.8.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+default-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+default-devel.sha256sum] = "e857c708997b8e5c576528bfb9a1edc7aab58a4e511b29108329eaeedadb4546"

URI_x86_64_v2_rust-regex-syntax+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+std-devel-0.8.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+std-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+std-devel.sha256sum] = "716663fe1d7bcfe5638e3dcc9142e61583645e48a02ea5e19cc6d4b813e5de64"

URI_x86_64_v2_rust-regex-syntax+unicode-age-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+unicode-age-devel-0.8.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+unicode-age-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+unicode-age-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+unicode-age-devel.sha256sum] = "508622f31393c562fc356951d1cbd24f2ea19c247d2f9e52aac11cc6c245a35d"

URI_x86_64_v2_rust-regex-syntax+unicode-bool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+unicode-bool-devel-0.8.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+unicode-bool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+unicode-bool-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+unicode-bool-devel.sha256sum] = "f4a8f0ec2196f059c1e297554d20bbb7e4e6643b03bbe391d11fe3967c4de14c"

URI_x86_64_v2_rust-regex-syntax+unicode-case-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+unicode-case-devel-0.8.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+unicode-case-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+unicode-case-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+unicode-case-devel.sha256sum] = "977658e2b48041c3e2d4a544b5d3bd804899c0305f0f795b823441514b90aebe"

URI_x86_64_v2_rust-regex-syntax+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+unicode-devel-0.8.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+unicode-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+unicode-devel.sha256sum] = "393042143585d48e5054a3ac1f8e291da334a9809b045a3e7bfb5b211fd02338"

URI_x86_64_v2_rust-regex-syntax+unicode-gencat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+unicode-gencat-devel-0.8.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+unicode-gencat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+unicode-gencat-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+unicode-gencat-devel.sha256sum] = "d997879d3d111871632ff30e217ec6e65ac48d052d51b1b964e3ffc2b0dd1125"

URI_x86_64_v2_rust-regex-syntax+unicode-perl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+unicode-perl-devel-0.8.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+unicode-perl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+unicode-perl-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+unicode-perl-devel.sha256sum] = "d1c0a37a906d5e5f2e23daa7113b24657b9c3a454c58bf878349f829ceab6615"

URI_x86_64_v2_rust-regex-syntax+unicode-script-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+unicode-script-devel-0.8.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+unicode-script-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+unicode-script-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+unicode-script-devel.sha256sum] = "c32a8d8ecafe8c2793c6601a50dd24d82bd42e176263cc8c037e3e82bbdf0c0e"

URI_x86_64_v2_rust-regex-syntax+unicode-segment-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax+unicode-segment-devel-0.8.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax+unicode-segment-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax+unicode-segment-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax+unicode-segment-devel.sha256sum] = "6e138f2862c63f0cb59bc5616b3d72f3a046e7f433fe2a83433840f7aa8edf3b"

URI_x86_64_v2_rust-regex-syntax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-syntax-devel-0.8.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-syntax-devel}"
SRC_URI[x86_64_v2_rust-regex-syntax-devel.sha256sum] = "dacce38145cfe6a3ef38d2df7c547bd450209e0ea2abb8ab15f5ad926e76bfe1"

URI_aarch64_rust-regex-syntax+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+arbitrary-devel-0.8.11-1.el10_2.noarch.rpm;name=aarch64_rust-regex-syntax+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+arbitrary-devel}"
SRC_URI[aarch64_rust-regex-syntax+arbitrary-devel.sha256sum] = "21339731a511163741e5d0d8eae9a3bbfe00c9a77c7d544779edf4158baefee1"

URI_aarch64_rust-regex-syntax+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+default-devel-0.8.11-1.el10_2.noarch.rpm;name=aarch64_rust-regex-syntax+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+default-devel}"
SRC_URI[aarch64_rust-regex-syntax+default-devel.sha256sum] = "32be28a8f3d26643d01877ef015dae373e4865b320b9846008249341dc83a23c"

URI_aarch64_rust-regex-syntax+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+std-devel-0.8.11-1.el10_2.noarch.rpm;name=aarch64_rust-regex-syntax+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+std-devel}"
SRC_URI[aarch64_rust-regex-syntax+std-devel.sha256sum] = "268808f484902739e5567a4493011d017ff8b2fc9c2c9141383f154cc6aee0f1"

URI_aarch64_rust-regex-syntax+unicode-age-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+unicode-age-devel-0.8.11-1.el10_2.noarch.rpm;name=aarch64_rust-regex-syntax+unicode-age-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+unicode-age-devel}"
SRC_URI[aarch64_rust-regex-syntax+unicode-age-devel.sha256sum] = "dd5dcff8501c8b07d503d82affbc696b85fb03236f8e60d65f6dbf599c174028"

URI_aarch64_rust-regex-syntax+unicode-bool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+unicode-bool-devel-0.8.11-1.el10_2.noarch.rpm;name=aarch64_rust-regex-syntax+unicode-bool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+unicode-bool-devel}"
SRC_URI[aarch64_rust-regex-syntax+unicode-bool-devel.sha256sum] = "c57f0dfb0a557b0a434407aff9d7d84079490892cbe4fae5b9535b1396cb4657"

URI_aarch64_rust-regex-syntax+unicode-case-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+unicode-case-devel-0.8.11-1.el10_2.noarch.rpm;name=aarch64_rust-regex-syntax+unicode-case-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+unicode-case-devel}"
SRC_URI[aarch64_rust-regex-syntax+unicode-case-devel.sha256sum] = "c4288ed5133f9398bcdcd2cc8830e9e56aca2b1e216db9d4b398fad39ff4bce7"

URI_aarch64_rust-regex-syntax+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+unicode-devel-0.8.11-1.el10_2.noarch.rpm;name=aarch64_rust-regex-syntax+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+unicode-devel}"
SRC_URI[aarch64_rust-regex-syntax+unicode-devel.sha256sum] = "567e5f2f9a33999bbfa349a24a96a45d94bbb16e281846f3ab9d7c74b0958c95"

URI_aarch64_rust-regex-syntax+unicode-gencat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+unicode-gencat-devel-0.8.11-1.el10_2.noarch.rpm;name=aarch64_rust-regex-syntax+unicode-gencat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+unicode-gencat-devel}"
SRC_URI[aarch64_rust-regex-syntax+unicode-gencat-devel.sha256sum] = "05994aeb3f0f1dd26794b57bfa60c22c5849d10ae18221497ad6a4264a087676"

URI_aarch64_rust-regex-syntax+unicode-perl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+unicode-perl-devel-0.8.11-1.el10_2.noarch.rpm;name=aarch64_rust-regex-syntax+unicode-perl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+unicode-perl-devel}"
SRC_URI[aarch64_rust-regex-syntax+unicode-perl-devel.sha256sum] = "6b1a1661f755f4d995c0dbe90a953776237ef984f0daf82010d7e3a042dfca57"

URI_aarch64_rust-regex-syntax+unicode-script-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+unicode-script-devel-0.8.11-1.el10_2.noarch.rpm;name=aarch64_rust-regex-syntax+unicode-script-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+unicode-script-devel}"
SRC_URI[aarch64_rust-regex-syntax+unicode-script-devel.sha256sum] = "ff64c661eecec2d2dc75789235d3982eda617b060276eef7c388af461b11e4e9"

URI_aarch64_rust-regex-syntax+unicode-segment-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax+unicode-segment-devel-0.8.11-1.el10_2.noarch.rpm;name=aarch64_rust-regex-syntax+unicode-segment-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax+unicode-segment-devel}"
SRC_URI[aarch64_rust-regex-syntax+unicode-segment-devel.sha256sum] = "7d250cc057151ec8a331c0191e591a1dec3a93f073f88e54f6e4570f5cf01be3"

URI_aarch64_rust-regex-syntax-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-syntax-devel-0.8.11-1.el10_2.noarch.rpm;name=aarch64_rust-regex-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-syntax-devel}"
SRC_URI[aarch64_rust-regex-syntax-devel.sha256sum] = "8047efb3e70bfaeffb862cffce5fb3cd6a10d799f7cba1eddb0bf1f1dbcb7bc1"

RDEPENDS:rust-regex-syntax+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+default-devel = " \
 cargo \
 rust-regex-syntax+std-devel \
 rust-regex-syntax+unicode-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+std-devel = " \
 cargo \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+unicode-age-devel = " \
 cargo \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+unicode-bool-devel = " \
 cargo \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+unicode-case-devel = " \
 cargo \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+unicode-devel = " \
 cargo \
 rust-regex-syntax+unicode-age-devel \
 rust-regex-syntax+unicode-bool-devel \
 rust-regex-syntax+unicode-case-devel \
 rust-regex-syntax+unicode-gencat-devel \
 rust-regex-syntax+unicode-perl-devel \
 rust-regex-syntax+unicode-script-devel \
 rust-regex-syntax+unicode-segment-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+unicode-gencat-devel = " \
 cargo \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+unicode-perl-devel = " \
 cargo \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+unicode-script-devel = " \
 cargo \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax+unicode-segment-devel = " \
 cargo \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-syntax-devel = " \
 cargo \
 rust \
 "
