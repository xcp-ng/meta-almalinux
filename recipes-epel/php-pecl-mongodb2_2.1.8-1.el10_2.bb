# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-mongodb2"
PV = "2.1.8"
PR = "1.el10_2"
PACKAGES = " \
 php-pecl-mongodb2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-mongodb2-2.1.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb85b93ca4a7d51be1abaaa22739339550a7b09de88f4de9737469d0b9e0d706"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - php-pecl-mongodb2: libbson-1.0.so.0()(64bit)
# - php-pecl-mongodb2: libmongoc-1.0.so.0()(64bit)

URI_x86_64_v2_php-pecl-mongodb2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-mongodb2-2.1.8-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-mongodb2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-mongodb2}"
SRC_URI[x86_64_v2_php-pecl-mongodb2.sha256sum] = "6dc85e099884a85b96cdac73732a3c89434d8ea69ca205b20f407dba7185a94d"

URI_aarch64_php-pecl-mongodb2 = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-mongodb2-2.1.8-1.el10_2.aarch64.rpm;name=aarch64_php-pecl-mongodb2;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-mongodb2}"
SRC_URI[aarch64_php-pecl-mongodb2.sha256sum] = "bbacfcd5fb870828fbd99ef78d7e2f50bc2fd233ea3f6694c850d368be816a2e"

RDEPENDS:php-pecl-mongodb2:x86_64_v2 = " \
 glibc \
 libmongocrypt \
 php8.4-common \
 virtual/php-json_x86-64_ \
"
RDEPENDS:php-pecl-mongodb2:aarch64 = " \
 glibc \
 libbson \
 libmongocrypt \
 mongo-c-driver-libs \
 php8.4-common \
 virtual/php-json_aarch-64_ \
"
