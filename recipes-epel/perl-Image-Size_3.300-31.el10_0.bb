# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Image-Size"
PV = "3.300"
PR = "31.el10_0"
PACKAGES = " \
 perl-Image-Size \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Image-Size-3.300-31.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1b87e99840afdba9c6fe24502aa8a50f09105ec1f767dd9878cbab78123faaf"

URI_x86_64_v2_perl-Image-Size = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Image-Size-3.300-31.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Image-Size;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Image-Size}"
SRC_URI[x86_64_v2_perl-Image-Size.sha256sum] = "4112f72bdd711f7448952dc3a68f4ca01b7d56eead516baab919629db28ecfd9"

URI_aarch64_perl-Image-Size = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Image-Size-3.300-31.el10_0.noarch.rpm;name=aarch64_perl-Image-Size;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Image-Size}"
SRC_URI[aarch64_perl-Image-Size.sha256sum] = "7f60e9ec1c53ea8eb74344e6a7c700cbc9d8fca1c89db9ec3307503113504dda"

RDEPENDS:perl-Image-Size = " \
 perl-Exporter \
 perl-File-Basename \
 perl-Getopt-Std \
 perl-IO-Compress \
 perl-Image-Size \
 perl-PathTools \
 perl-Symbol \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
