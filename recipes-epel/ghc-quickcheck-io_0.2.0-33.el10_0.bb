# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-quickcheck-io"
PV = "0.2.0"
PR = "33.el10_0"
PACKAGES = " \
 ghc-quickcheck-io \
 ghc-quickcheck-io-devel \
 ghc-quickcheck-io-doc \
 ghc-quickcheck-io-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-quickcheck-io-0.2.0-33.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "75a1068e9b8ad87b2657238a43c7fd15aad5029393cb36b68096ee79f99e9a2c"

URI_x86_64_v2_ghc-quickcheck-io = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-quickcheck-io-0.2.0-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-quickcheck-io;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-quickcheck-io}"
SRC_URI[x86_64_v2_ghc-quickcheck-io.sha256sum] = "a6ab2b3698071934d6eed9627495dc6dbf5e19ac6250fe2ff59d6403874b499a"

URI_x86_64_v2_ghc-quickcheck-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-quickcheck-io-devel-0.2.0-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-quickcheck-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-quickcheck-io-devel}"
SRC_URI[x86_64_v2_ghc-quickcheck-io-devel.sha256sum] = "d292bb7bdf64b04c9cbb43df7892c3c371e9af50b393fca5356d3d6e9963b7be"

URI_x86_64_v2_ghc-quickcheck-io-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-quickcheck-io-doc-0.2.0-33.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-quickcheck-io-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-quickcheck-io-doc}"
SRC_URI[x86_64_v2_ghc-quickcheck-io-doc.sha256sum] = "5ba689a1ff35823138756fc4863a63758ce094a11e52fc6f1103efd6f03d4f20"

URI_x86_64_v2_ghc-quickcheck-io-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-quickcheck-io-prof-0.2.0-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-quickcheck-io-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-quickcheck-io-prof}"
SRC_URI[x86_64_v2_ghc-quickcheck-io-prof.sha256sum] = "f7fe16ba6a92aecf49ee1f3c07e57849ad95bd1a96874549fbb80ba5aa762396"

URI_aarch64_ghc-quickcheck-io = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-quickcheck-io-0.2.0-33.el10_0.aarch64.rpm;name=aarch64_ghc-quickcheck-io;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-quickcheck-io}"
SRC_URI[aarch64_ghc-quickcheck-io.sha256sum] = "7937c8fb70998b9605a92584007aa3baae74192832323e264e8ebb03d85f67ae"

URI_aarch64_ghc-quickcheck-io-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-quickcheck-io-devel-0.2.0-33.el10_0.aarch64.rpm;name=aarch64_ghc-quickcheck-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-quickcheck-io-devel}"
SRC_URI[aarch64_ghc-quickcheck-io-devel.sha256sum] = "9308a7f7102ca33d547490adfd026b69db852741b8cfc2ded7f7b42d0d4bccff"

URI_aarch64_ghc-quickcheck-io-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-quickcheck-io-doc-0.2.0-33.el10_0.noarch.rpm;name=aarch64_ghc-quickcheck-io-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-quickcheck-io-doc}"
SRC_URI[aarch64_ghc-quickcheck-io-doc.sha256sum] = "3b525eee084cc61089cb73ffa99d85488e06ee954c809c308fa849b829780e3e"

URI_aarch64_ghc-quickcheck-io-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-quickcheck-io-prof-0.2.0-33.el10_0.aarch64.rpm;name=aarch64_ghc-quickcheck-io-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-quickcheck-io-prof}"
SRC_URI[aarch64_ghc-quickcheck-io-prof.sha256sum] = "96467a4539f8e9151c022715ecf739e40184ccadcea2498f8efddb51ddb10e7a"

RDEPENDS:ghc-quickcheck-io = " \
 ghc-HUnit \
 ghc-QuickCheck \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-call-stack \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-random \
 ghc-splitmix \
 ghc-template-haskell \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-quickcheck-io-devel = " \
 ghc-HUnit-devel \
 ghc-QuickCheck-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-quickcheck-io \
 "
RDEPENDS:ghc-quickcheck-io-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-quickcheck-io-prof = " \
 ghc-HUnit-prof \
 ghc-QuickCheck-prof \
 ghc-base-prof \
 ghc-quickcheck-io-devel \
 "
