# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-urllib-gssapi"
PV = "1.0.2"
PR = "14.el10"
PACKAGES = " \
 python3-urllib-gssapi \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-urllib-gssapi-1.0.2-14.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5c51e5baa85ee6803275dc4cbf6d7de371b354804fa0951f1efd5d4a4f4619a2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-urllib-gssapi-1.0.2-14.el10.noarch.rpm;name=x86_64_v2_python3-urllib-gssapi;unpack=0"
SRC_URI[x86_64_v2_python3-urllib-gssapi.sha256sum] = "3c06b5eac0211cfba9bcd312e6c010e4df9e6ef4cd03b570acaee6792d7d6b2b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-urllib-gssapi-1.0.2-14.el10.noarch.rpm;name=aarch64_python3-urllib-gssapi;unpack=0"
SRC_URI[aarch64_python3-urllib-gssapi.sha256sum] = "3c06b5eac0211cfba9bcd312e6c010e4df9e6ef4cd03b570acaee6792d7d6b2b"

RDEPENDS:python3-urllib-gssapi = " \
 python3 \
 python3-gssapi \
 "
