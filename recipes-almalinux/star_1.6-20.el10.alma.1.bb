# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "star"
PV = "1.6"
PR = "20.el10.alma.1"
PACKAGES = " \
 rmt \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/star-1.6-20.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0d88aebce8d6c9ae62f31947f07a8a5aec53bcc526b5ccdd897d62b5c34f51c5"

URI_x86_64_v2_rmt = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rmt-1.6-20.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rmt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rmt}"
SRC_URI[x86_64_v2_rmt.sha256sum] = "b589f39431a231e6c6196a6687ec9234fd9173087e7bbd6b783d4eae6edec536"

URI_aarch64_rmt = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rmt-1.6-20.el10.alma.1.aarch64.rpm;name=aarch64_rmt;unpack=0"
SRC_URI:append = " ${URI_aarch64_rmt}"
SRC_URI[aarch64_rmt.sha256sum] = "befbc8a2c994657a7ec06de9987a04244dd155195ff8de39313d35afa64bb321"

RDEPENDS:rmt = " \
 glibc \
 "
