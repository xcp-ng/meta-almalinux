# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdjbsort"
PV = "20260621"
PR = "1.el10_3"
PACKAGES = " \
 libdjbsort \
 libdjbsort-devel \
 libdjbsort-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libdjbsort-20260621-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f77bb33b73e2e744a4b34e0de191c52e1e635fae0fedb2120609a1d616e21ef"

URI_x86_64_v2_libdjbsort = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdjbsort-20260621-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdjbsort;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdjbsort}"
SRC_URI[x86_64_v2_libdjbsort.sha256sum] = "a70567624e951379796d429b920cfad6b278fafcd7f06eaed02bb2db31242bc6"

URI_x86_64_v2_libdjbsort-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdjbsort-devel-20260621-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdjbsort-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdjbsort-devel}"
SRC_URI[x86_64_v2_libdjbsort-devel.sha256sum] = "ab8084faf51ae2337290a7ad23d54f26014eb8a67161c9cd3d8af3a192e9f4f9"

URI_x86_64_v2_libdjbsort-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdjbsort-static-20260621-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdjbsort-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdjbsort-static}"
SRC_URI[x86_64_v2_libdjbsort-static.sha256sum] = "66b3641cc30f865993caf941d9705be5f13957c75c097e28f143c0666ad77ef0"

URI_aarch64_libdjbsort = "${EPEL_MIRROR}/aarch64/Packages/l/libdjbsort-20260621-1.el10_3.aarch64.rpm;name=aarch64_libdjbsort;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdjbsort}"
SRC_URI[aarch64_libdjbsort.sha256sum] = "b34a33cbf689602c56fef1b7613a8dd043e387a404469a3e3bd4b962a216beb0"

URI_aarch64_libdjbsort-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libdjbsort-devel-20260621-1.el10_3.aarch64.rpm;name=aarch64_libdjbsort-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdjbsort-devel}"
SRC_URI[aarch64_libdjbsort-devel.sha256sum] = "ffad78bca7fcf2380afe43a634ea70df7a971ec4fb1c84fc9ae86af9bed85a41"

URI_aarch64_libdjbsort-static = "${EPEL_MIRROR}/aarch64/Packages/l/libdjbsort-static-20260621-1.el10_3.aarch64.rpm;name=aarch64_libdjbsort-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdjbsort-static}"
SRC_URI[aarch64_libdjbsort-static.sha256sum] = "2f2fc5de85ddb1307e8098118e578702861472f3f9ae4ed4203d100b656124bd"

RDEPENDS:libdjbsort = " \
 glibc \
 libcpucycles \
 python3 \
 "
RDEPENDS:libdjbsort-devel = " \
 libdjbsort \
 "
RDEPENDS:libdjbsort-static = " \
 libdjbsort-devel \
 "
