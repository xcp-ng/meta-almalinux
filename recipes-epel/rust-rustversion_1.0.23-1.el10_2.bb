# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustversion"
PV = "1.0.23"
PR = "1.el10_2"
PACKAGES = " \
 rust-rustversion+default-devel \
 rust-rustversion-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustversion-1.0.23-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "98ea238a2e4c2187224a5ddd2b41cd91e17a440c18dc42a8e67e642ba0e43def"

URI_x86_64_v2_rust-rustversion+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustversion+default-devel-1.0.23-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustversion+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustversion+default-devel}"
SRC_URI[x86_64_v2_rust-rustversion+default-devel.sha256sum] = "2087c8777e98ec8d5a78b5507000f04018b011ad48bca736ff77150251e11d57"

URI_x86_64_v2_rust-rustversion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustversion-devel-1.0.23-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustversion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustversion-devel}"
SRC_URI[x86_64_v2_rust-rustversion-devel.sha256sum] = "8bc41569f15301d876dd796ec47b6503bb186d739054aa6b5ad81c4f6f71fb18"

URI_aarch64_rust-rustversion+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustversion+default-devel-1.0.23-1.el10_2.noarch.rpm;name=aarch64_rust-rustversion+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustversion+default-devel}"
SRC_URI[aarch64_rust-rustversion+default-devel.sha256sum] = "7586508008c1c3e1a01c676eb0e971391dcf7c0c782c7e48b2d17f0580b2d64e"

URI_aarch64_rust-rustversion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustversion-devel-1.0.23-1.el10_2.noarch.rpm;name=aarch64_rust-rustversion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustversion-devel}"
SRC_URI[aarch64_rust-rustversion-devel.sha256sum] = "73d6707bed1abc781ff27a5359e9491d941045b633dc7ca5f91ae530b324bd69"

RDEPENDS:rust-rustversion+default-devel = " \
 cargo \
 rust-rustversion-devel \
 "
RDEPENDS:rust-rustversion-devel = " \
 cargo \
 rust \
 "
