# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nvtop"
PV = "3.3.1"
PR = "2.el10_1"
PACKAGES = " \
 nvtop \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nvtop-3.3.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4d3458ec671fd6687604c6c5ada9d18545772617af2780dd69f48ad76f5ad4f3"

URI_x86_64_v2_nvtop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nvtop-3.3.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nvtop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nvtop}"
SRC_URI[x86_64_v2_nvtop.sha256sum] = "b9a6d605b813c122212fff48dbd2ac16646431abeb06b620c1f1de9f3bd0c2ee"

URI_aarch64_nvtop = "${EPEL_MIRROR}/aarch64/Packages/n/nvtop-3.3.1-2.el10_1.aarch64.rpm;name=aarch64_nvtop;unpack=0"
SRC_URI:append = " ${URI_aarch64_nvtop}"
SRC_URI[aarch64_nvtop.sha256sum] = "f3eb344b368748be5169c05198fed7cc7560a7aed8384fdcd86e53f3fca24cab"

RDEPENDS:nvtop = " \
 glibc \
 hicolor-icon-theme \
 ncurses-libs \
 systemd-libs \
 "
