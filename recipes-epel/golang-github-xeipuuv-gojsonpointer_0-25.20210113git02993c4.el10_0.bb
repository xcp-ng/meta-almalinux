# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-xeipuuv-gojsonpointer"
PV = "0"
PR = "25.20210113git02993c4.el10_0"
PACKAGES = " \
 golang-github-xeipuuv-gojsonpointer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-xeipuuv-gojsonpointer-0-25.20210113git02993c4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c52e368db5fc865eae94f647214f5eb4eee06509d97017d1a1e02f9d34b74453"

URI_aarch64_golang-github-xeipuuv-gojsonpointer-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-xeipuuv-gojsonpointer-devel-0-25.20210113git02993c4.el10_0.noarch.rpm;name=aarch64_golang-github-xeipuuv-gojsonpointer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-xeipuuv-gojsonpointer-devel}"
SRC_URI[aarch64_golang-github-xeipuuv-gojsonpointer-devel.sha256sum] = "6ae5b2475f64e70b151a7b627226f45935863e583c121086c09f71b7f7c9f8fb"

RDEPENDS:golang-github-xeipuuv-gojsonpointer-devel = " \
 go-filesystem \
 "
