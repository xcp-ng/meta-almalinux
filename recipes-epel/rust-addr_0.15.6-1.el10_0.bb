# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-addr"
PV = "0.15.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-addr+default-devel \
 rust-addr+idna-devel \
 rust-addr+psl-devel \
 rust-addr+publicsuffix-devel \
 rust-addr+serde-devel \
 rust-addr+std-devel \
 rust-addr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-addr-0.15.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c1cf913823331acc36ce30b09da387bf580e38e34293e25a4ce5704ed83dfdf"

URI_x86_64_v2_rust-addr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-addr+default-devel-0.15.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-addr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-addr+default-devel}"
SRC_URI[x86_64_v2_rust-addr+default-devel.sha256sum] = "d729f2c5323c8ae6a39bcee24c6e8117eb346e575d45082913a9d6cb6aff1b5f"

URI_x86_64_v2_rust-addr+idna-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-addr+idna-devel-0.15.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-addr+idna-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-addr+idna-devel}"
SRC_URI[x86_64_v2_rust-addr+idna-devel.sha256sum] = "e04c6ab5142177dbf8b8ee7500df67d450189f09b5021f4bcdcc45b17f40447a"

URI_x86_64_v2_rust-addr+psl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-addr+psl-devel-0.15.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-addr+psl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-addr+psl-devel}"
SRC_URI[x86_64_v2_rust-addr+psl-devel.sha256sum] = "1be25bd284bfc7ec58c4533fcca52c0b6de18c8d9f47e47ecafa83bb0a77ed4a"

URI_x86_64_v2_rust-addr+publicsuffix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-addr+publicsuffix-devel-0.15.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-addr+publicsuffix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-addr+publicsuffix-devel}"
SRC_URI[x86_64_v2_rust-addr+publicsuffix-devel.sha256sum] = "ad61ba0c6c9a0630345b6ce86fb6879b68aca842f930882c86a8657f6893a5d1"

URI_x86_64_v2_rust-addr+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-addr+serde-devel-0.15.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-addr+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-addr+serde-devel}"
SRC_URI[x86_64_v2_rust-addr+serde-devel.sha256sum] = "072f8140bc35f0b9a3f67c96cfb9e161f9f3c714074486bf7f42552cd97b5e20"

URI_x86_64_v2_rust-addr+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-addr+std-devel-0.15.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-addr+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-addr+std-devel}"
SRC_URI[x86_64_v2_rust-addr+std-devel.sha256sum] = "de7dfcf6cca01c192dd3ae4849e9306cdddae086c2d72a101aca23c4f2ffcd03"

URI_x86_64_v2_rust-addr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-addr-devel-0.15.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-addr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-addr-devel}"
SRC_URI[x86_64_v2_rust-addr-devel.sha256sum] = "991143f6cb553ae10e607b84e2be89fe59934a2be6358d27c6f6f593c79df57d"

URI_aarch64_rust-addr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-addr+default-devel-0.15.6-1.el10_0.noarch.rpm;name=aarch64_rust-addr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-addr+default-devel}"
SRC_URI[aarch64_rust-addr+default-devel.sha256sum] = "cbd98510909717c4c185276ab7d6f2e6a373e221213dd458d51e31982b963f3e"

URI_aarch64_rust-addr+idna-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-addr+idna-devel-0.15.6-1.el10_0.noarch.rpm;name=aarch64_rust-addr+idna-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-addr+idna-devel}"
SRC_URI[aarch64_rust-addr+idna-devel.sha256sum] = "e900a4928880f5efbdd3f23c5069f57cb8266d3356eecb4f321fdcf1a58ca988"

URI_aarch64_rust-addr+psl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-addr+psl-devel-0.15.6-1.el10_0.noarch.rpm;name=aarch64_rust-addr+psl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-addr+psl-devel}"
SRC_URI[aarch64_rust-addr+psl-devel.sha256sum] = "7827f9d502e3b4be1bde7ec29ce74e22207e492120f806839829ef638fa4b58d"

URI_aarch64_rust-addr+publicsuffix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-addr+publicsuffix-devel-0.15.6-1.el10_0.noarch.rpm;name=aarch64_rust-addr+publicsuffix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-addr+publicsuffix-devel}"
SRC_URI[aarch64_rust-addr+publicsuffix-devel.sha256sum] = "0acbb91bbaeae6ee770a548a18ab9dad679fee6eef878595a7eeda4d43fc91c2"

URI_aarch64_rust-addr+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-addr+serde-devel-0.15.6-1.el10_0.noarch.rpm;name=aarch64_rust-addr+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-addr+serde-devel}"
SRC_URI[aarch64_rust-addr+serde-devel.sha256sum] = "85f445ca9bfa4e2ffcca9a78d065810d6b713004f58d8373aee83488ea3b1109"

URI_aarch64_rust-addr+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-addr+std-devel-0.15.6-1.el10_0.noarch.rpm;name=aarch64_rust-addr+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-addr+std-devel}"
SRC_URI[aarch64_rust-addr+std-devel.sha256sum] = "9ea4791d72c9479c8c523588cc7ad34048a76ff76a28cd6bd83d9d6615375b26"

URI_aarch64_rust-addr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-addr-devel-0.15.6-1.el10_0.noarch.rpm;name=aarch64_rust-addr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-addr-devel}"
SRC_URI[aarch64_rust-addr-devel.sha256sum] = "927158b3f6102f7cd503503b37de8573e5ba7cda01ad086ce7c910eb03d0dfd2"

RDEPENDS:rust-addr+default-devel = " \
 cargo \
 rust-addr+psl-devel \
 rust-addr+std-devel \
 rust-addr-devel \
 "
RDEPENDS:rust-addr+idna-devel = " \
 cargo \
 rust-addr-devel \
 "
RDEPENDS:rust-addr+psl-devel = " \
 cargo \
 rust-addr-devel \
 rust-psl+default-devel \
 "
RDEPENDS:rust-addr+publicsuffix-devel = " \
 cargo \
 rust-addr-devel \
 rust-publicsuffix+default-devel \
 "
RDEPENDS:rust-addr+serde-devel = " \
 cargo \
 rust-addr-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-addr+std-devel = " \
 cargo \
 rust-addr-devel \
 "
RDEPENDS:rust-addr-devel = " \
 cargo \
 rust-psl-types+default-devel \
 "
