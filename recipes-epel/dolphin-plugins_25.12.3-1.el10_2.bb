# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dolphin-plugins"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 dolphin-plugins \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dolphin-plugins-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd2704494261be12068a2b9c55a09b8d61a4ace0d8586f3f8b322b4f3aa1e863"

URI_x86_64_v2_dolphin-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dolphin-plugins-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dolphin-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dolphin-plugins}"
SRC_URI[x86_64_v2_dolphin-plugins.sha256sum] = "42a55516643523178e148ed48237c1d840f6b68aaf0de16a0622ce37a8cd3633"

URI_aarch64_dolphin-plugins = "${EPEL_MIRROR}/aarch64/Packages/d/dolphin-plugins-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_dolphin-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_dolphin-plugins}"
SRC_URI[aarch64_dolphin-plugins.sha256sum] = "65a7f6d43ddee4d4dee89ff61e68c8548cd51dd87e6ad887ed3c0cdd1f95ea11"

RDEPENDS:dolphin-plugins = " \
 dolphin \
 dolphin-libs \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kjobwidgets \
 kf6-kservice \
 kf6-ktexteditor \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-solid \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
