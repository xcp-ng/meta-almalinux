# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sequoia-openpgp"
PV = "2.4.1"
PR = "2.el10_3"
PACKAGES = " \
 rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel \
 rust-sequoia-openpgp+compression-bzip2-devel \
 rust-sequoia-openpgp+compression-deflate-devel \
 rust-sequoia-openpgp+compression-devel \
 rust-sequoia-openpgp+crypto-nettle-devel \
 rust-sequoia-openpgp+crypto-openssl-devel \
 rust-sequoia-openpgp+default-devel \
 rust-sequoia-openpgp-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-sequoia-openpgp-2.4.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1b69d3661eecdd2e580560cd9b67faac7006dfb5269525224d406177f1c60ec5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel-2.4.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel;unpack=0"
SRC_URI[x86_64_v2_rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel.sha256sum] = "f4d3c8162c34dfe58b946d9a0c7326d9b8744f3e53d4d11f3b4e70666d5f3693"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-openpgp+compression-bzip2-devel-2.4.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-openpgp+compression-bzip2-devel;unpack=0"
SRC_URI[x86_64_v2_rust-sequoia-openpgp+compression-bzip2-devel.sha256sum] = "e84496bfbaf6f36ae30cd718f8e5c71a03ccd2a5e739ed318b2ebad7a7d77b5f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-openpgp+compression-deflate-devel-2.4.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-openpgp+compression-deflate-devel;unpack=0"
SRC_URI[x86_64_v2_rust-sequoia-openpgp+compression-deflate-devel.sha256sum] = "530e17735d2fe51263e7d48898900ff12cfc319d81fae5c3bfe26514b8cfc7ca"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-openpgp+compression-devel-2.4.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-openpgp+compression-devel;unpack=0"
SRC_URI[x86_64_v2_rust-sequoia-openpgp+compression-devel.sha256sum] = "81453bea3a535dbf43dc921aa5c94775061acb5dfdaae429a3e6134f20d0aedc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-openpgp+crypto-nettle-devel-2.4.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-openpgp+crypto-nettle-devel;unpack=0"
SRC_URI[x86_64_v2_rust-sequoia-openpgp+crypto-nettle-devel.sha256sum] = "b9e10f6bea8dff6d10f11379c1297571a42e314d880fd76470b67a4293d1811e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-openpgp+crypto-openssl-devel-2.4.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-openpgp+crypto-openssl-devel;unpack=0"
SRC_URI[x86_64_v2_rust-sequoia-openpgp+crypto-openssl-devel.sha256sum] = "70fdbaa40b9ce2b3d6240fe9382b916447c3abca38a9582281f282e08eb5ab1f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-openpgp+default-devel-2.4.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-openpgp+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-sequoia-openpgp+default-devel.sha256sum] = "9117040ee5b5baec6a4b489040f051b280d87fd464fac2595eb86e3033577f38"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-openpgp-devel-2.4.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-openpgp-devel;unpack=0"
SRC_URI[x86_64_v2_rust-sequoia-openpgp-devel.sha256sum] = "3f235e518fdf23f79aaf15886e8b4bb4ee370fcf15bcfb3d96662026c4923a79"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel-2.4.1-2.el10_3.noarch.rpm;name=aarch64_rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel;unpack=0"
SRC_URI[aarch64_rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel.sha256sum] = "d8a65dce7930ac0693cd0c26443643c0bbdee0f3197b21d9018b197de4ff1273"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-openpgp+compression-bzip2-devel-2.4.1-2.el10_3.noarch.rpm;name=aarch64_rust-sequoia-openpgp+compression-bzip2-devel;unpack=0"
SRC_URI[aarch64_rust-sequoia-openpgp+compression-bzip2-devel.sha256sum] = "57f409ec18cfacf4d4939b897038ec67d9d2ec3e20df46f3a80d856e8d5d1191"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-openpgp+compression-deflate-devel-2.4.1-2.el10_3.noarch.rpm;name=aarch64_rust-sequoia-openpgp+compression-deflate-devel;unpack=0"
SRC_URI[aarch64_rust-sequoia-openpgp+compression-deflate-devel.sha256sum] = "1e3403fc353e50efefac27a752cf372c6fbf1d05b063041832b3de48881615fb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-openpgp+compression-devel-2.4.1-2.el10_3.noarch.rpm;name=aarch64_rust-sequoia-openpgp+compression-devel;unpack=0"
SRC_URI[aarch64_rust-sequoia-openpgp+compression-devel.sha256sum] = "737b9fffbb10c3e634268094ba79cdbe3fb6097e22c62170597303819c49d822"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-openpgp+crypto-nettle-devel-2.4.1-2.el10_3.noarch.rpm;name=aarch64_rust-sequoia-openpgp+crypto-nettle-devel;unpack=0"
SRC_URI[aarch64_rust-sequoia-openpgp+crypto-nettle-devel.sha256sum] = "67db5a03f97f875e50faa74d85def6c3fde679e052a012076df68a59174baafc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-openpgp+crypto-openssl-devel-2.4.1-2.el10_3.noarch.rpm;name=aarch64_rust-sequoia-openpgp+crypto-openssl-devel;unpack=0"
SRC_URI[aarch64_rust-sequoia-openpgp+crypto-openssl-devel.sha256sum] = "1df312c8f37177121e0dddb94072d0f7f070efac77c4c3a11e1659a2be3c0f17"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-openpgp+default-devel-2.4.1-2.el10_3.noarch.rpm;name=aarch64_rust-sequoia-openpgp+default-devel;unpack=0"
SRC_URI[aarch64_rust-sequoia-openpgp+default-devel.sha256sum] = "d34137f7d7ebf515a7d6b4e81f2004b05b8843270a9e3b319ec1851fc3b6655d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-openpgp-devel-2.4.1-2.el10_3.noarch.rpm;name=aarch64_rust-sequoia-openpgp-devel;unpack=0"
SRC_URI[aarch64_rust-sequoia-openpgp-devel.sha256sum] = "cdf47f588338e3ea87bddd42d1c85719e7c2474939ef3863d2ff625b7a66beb5"

RDEPENDS:rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel = " \
 cargo \
 rust-sequoia-openpgp-devel \
 "
RDEPENDS:rust-sequoia-openpgp+compression-bzip2-devel = " \
 cargo \
 rust-buffered-reader+compression-bzip2-devel \
 rust-bzip2+default-devel \
 rust-sequoia-openpgp-devel \
 "
RDEPENDS:rust-sequoia-openpgp+compression-deflate-devel = " \
 cargo \
 rust-buffered-reader+compression-deflate-devel \
 rust-flate2+default-devel \
 rust-sequoia-openpgp-devel \
 "
RDEPENDS:rust-sequoia-openpgp+compression-devel = " \
 cargo \
 rust-sequoia-openpgp+compression-bzip2-devel \
 rust-sequoia-openpgp+compression-deflate-devel \
 rust-sequoia-openpgp-devel \
 "
RDEPENDS:rust-sequoia-openpgp+crypto-nettle-devel = " \
 cargo \
 rust-nettle+default-devel \
 rust-sequoia-openpgp-devel \
 "
RDEPENDS:rust-sequoia-openpgp+crypto-openssl-devel = " \
 cargo \
 rust-ctor+default-devel \
 rust-openssl-sys+default-devel \
 rust-ossl+openssl-sys-devel \
 rust-ossl+rfc9580-devel \
 rust-ossl-devel \
 rust-sequoia-openpgp-devel \
 "
RDEPENDS:rust-sequoia-openpgp+default-devel = " \
 cargo \
 rust-sequoia-openpgp+compression-devel \
 rust-sequoia-openpgp+crypto-nettle-devel \
 rust-sequoia-openpgp-devel \
 "
RDEPENDS:rust-sequoia-openpgp-devel = " \
 bash \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-argon2+default-devel \
 rust-base64_0.22+default-devel \
 rust-buffered-reader-devel \
 rust-dyn-clone+default-devel \
 rust-idna+default-devel \
 rust-lalrpop-devel \
 rust-lalrpop-util+default-devel \
 rust-libc+default-devel \
 rust-memsec-devel \
 rust-regex+default-devel \
 rust-regex-syntax+default-devel \
 rust-sha1collisiondetection+std-devel \
 rust-sha1collisiondetection-devel \
 rust-xxhash-rust+default-devel \
 rust-xxhash-rust+xxh3-devel \
 virtual/crate_thiserror/default__ge_1.0.0_with_crate_thiserror/default__lt_3.0.0~ \
 "
