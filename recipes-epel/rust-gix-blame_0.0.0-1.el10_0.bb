# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-blame"
PV = "0.0.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-blame+default-devel \
 rust-gix-blame-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-blame-0.0.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "710eda40bea41d505e3e7b65ceecaf61923c23a140ed5cf55a5e3de8692c7e93"

URI_x86_64_v2_rust-gix-blame+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-blame+default-devel-0.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-blame+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-blame+default-devel}"
SRC_URI[x86_64_v2_rust-gix-blame+default-devel.sha256sum] = "e7a95bc0b081abfb6e46466b47196b966ff99f6c851f443973ef327489a4e568"

URI_x86_64_v2_rust-gix-blame-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-blame-devel-0.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-blame-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-blame-devel}"
SRC_URI[x86_64_v2_rust-gix-blame-devel.sha256sum] = "2799a37996461bc64c3b499ee9c0864a303a97a8337ee3235dba3e8b5c63671e"

URI_aarch64_rust-gix-blame+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-blame+default-devel-0.0.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-blame+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-blame+default-devel}"
SRC_URI[aarch64_rust-gix-blame+default-devel.sha256sum] = "b2789d3579687d7c25c45be5b8b0548832553215541f18225db3cc666189303f"

URI_aarch64_rust-gix-blame-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-blame-devel-0.0.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-blame-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-blame-devel}"
SRC_URI[aarch64_rust-gix-blame-devel.sha256sum] = "5b24e59d3088cdfd47f55eba064fa53853d93a1b0da3e9f02e0abac221e79f31"

RDEPENDS:rust-gix-blame+default-devel = " \
 cargo \
 rust-gix-blame-devel \
 "
RDEPENDS:rust-gix-blame-devel = " \
 cargo \
 rust \
 rust-gix-diff+blob-devel \
 rust-gix-diff-devel \
 rust-gix-hash+default-devel \
 rust-gix-object+default-devel \
 rust-gix-trace+default-devel \
 rust-gix-traverse+default-devel \
 rust-gix-worktree+attributes-devel \
 rust-gix-worktree-devel \
 rust-thiserror+default-devel \
 "
