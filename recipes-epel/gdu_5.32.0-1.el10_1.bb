# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gdu"
PV = "5.32.0"
PR = "1.el10_1"
PACKAGES = " \
 gdu \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gdu-5.32.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "570a73d1de07c5f1a20d95880555f2286feae6bda28e7f40c9dee4393a5a5f78"

URI_x86_64_v2_gdu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gdu-5.32.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gdu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdu}"
SRC_URI[x86_64_v2_gdu.sha256sum] = "e776a7b51c61013bba90a78ec10c4e7cfa1061e7e2e04d25b7af254bd334b628"

URI_aarch64_gdu = "${EPEL_MIRROR}/aarch64/Packages/g/gdu-5.32.0-1.el10_1.aarch64.rpm;name=aarch64_gdu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdu}"
SRC_URI[aarch64_gdu.sha256sum] = "4c5ec3ff5400b9232dc5dec4960f235d13b90e08dd726b9ccd8afe89c443c38b"

RDEPENDS:gdu = " \
 glibc \
 "
