# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-ds"
PV = "1.8.0"
PR = "2.el10_3"
PACKAGES = " \
 php-pecl-ds \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-ds-1.8.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6cad3baebc22ba2a79fff6cb9ed4af68fede9fcac4c7cf1696c926dbd0946a8"

URI_x86_64_v2_php-pecl-ds = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-ds-1.8.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-ds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-ds}"
SRC_URI[x86_64_v2_php-pecl-ds.sha256sum] = "b989689bf542a2e616ca249e7d9abee2fb615e10367d9791099c82a3c16d0ba4"

URI_aarch64_php-pecl-ds = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-ds-1.8.0-2.el10_3.aarch64.rpm;name=aarch64_php-pecl-ds;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-ds}"
SRC_URI[aarch64_php-pecl-ds.sha256sum] = "d814d47c86bc5ae6e0ae0c91980b2a600aaac97922df82254452addcfd47f4c9"

RDEPENDS:php-pecl-ds:x86_64_v2 = " \
 glibc \
 php-common \
 virtual/php-json_x86-64_ \
"
RDEPENDS:php-pecl-ds:aarch64 = " \
 glibc \
 php-common \
 virtual/php-json_aarch-64_ \
"
