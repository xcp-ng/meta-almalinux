# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnuastro"
PV = "0.23"
PR = "4.el10_2"
PACKAGES = " \
 gnuastro \
 gnuastro-devel \
 gnuastro-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gnuastro-0.23-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80d7fffbc2df782bc560799292225b002b866ba58ab4214fccc68d29f944b8fb"

URI_x86_64_v2_gnuastro = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnuastro-0.23-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gnuastro;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnuastro}"
SRC_URI[x86_64_v2_gnuastro.sha256sum] = "19037a2fd175050d917404229103870b9ff378db1a10ca22a29a7e445a64b966"

URI_x86_64_v2_gnuastro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnuastro-devel-0.23-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gnuastro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnuastro-devel}"
SRC_URI[x86_64_v2_gnuastro-devel.sha256sum] = "7f98eab91847884755cdfc31b9e121460d717cdb19590ea438999f962f426322"

URI_x86_64_v2_gnuastro-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnuastro-doc-0.23-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_gnuastro-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnuastro-doc}"
SRC_URI[x86_64_v2_gnuastro-doc.sha256sum] = "1d16b210aa90d46d83aa1fa425839971d2dc21075f6823d5f28538e3f42a0337"

URI_aarch64_gnuastro = "${EPEL_MIRROR}/aarch64/Packages/g/gnuastro-0.23-4.el10_2.aarch64.rpm;name=aarch64_gnuastro;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnuastro}"
SRC_URI[aarch64_gnuastro.sha256sum] = "7fb1c9ce13a83b28157dc9f0d3f1e107552147bfc59c94e7074820ad850004bb"

URI_aarch64_gnuastro-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gnuastro-devel-0.23-4.el10_2.aarch64.rpm;name=aarch64_gnuastro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnuastro-devel}"
SRC_URI[aarch64_gnuastro-devel.sha256sum] = "5a5c1df8b919989d859066212f881a101052ab9daf959df912c79b266b442bda"

URI_aarch64_gnuastro-doc = "${EPEL_MIRROR}/aarch64/Packages/g/gnuastro-doc-0.23-4.el10_2.noarch.rpm;name=aarch64_gnuastro-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnuastro-doc}"
SRC_URI[aarch64_gnuastro-doc.sha256sum] = "1ea1d6c7e2ea2250321417cf512ddaee1048453acd951025b2fec8d2d72d9aa7"

RDEPENDS:gnuastro = " \
 bash \
 cfitsio \
 glibc \
 gsl \
 libgit2 \
 libjpeg-turbo \
 libtiff \
 wcslib \
 zlib-ng-compat \
 "
RDEPENDS:gnuastro-devel:x86_64_v2 = " \
 cfitsio-devel \
 gnuastro \
 gsl-devel \
 libgit2-devel \
 libjpeg-turbo-devel \
 libtiff-devel \
 pkgconf-pkg-config \
 wcslib-devel \
"
RDEPENDS:gnuastro-devel:aarch64 = " \
 cfitsio-devel \
 gnuastro \
 gsl-devel \
 libjpeg-turbo-devel \
 libtiff-devel \
 pkgconf-pkg-config \
 virtual/pkgconfig_libgit2_ \
 wcslib-devel \
"
RDEPENDS:gnuastro-doc = " \
 "
