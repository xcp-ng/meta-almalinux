# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-below-model"
PV = "0.9.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-below-model+default-devel \
 rust-below-model-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-below-model-0.9.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c0749f3a4235311712ad8f988d60112d99837f0248a87b6cf60ebea2086aeb7"

URI_x86_64_v2_rust-below-model+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-model+default-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-model+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-model+default-devel}"
SRC_URI[x86_64_v2_rust-below-model+default-devel.sha256sum] = "67f922c1b09b96b03f11bec41742e8411c3df2944ab7039e6a2108ce293f8d38"

URI_x86_64_v2_rust-below-model-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-model-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-model-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-model-devel}"
SRC_URI[x86_64_v2_rust-below-model-devel.sha256sum] = "5ad2b1c625d7cf933faefe0f0581dd0e56e5219231a57fd33c5d1a6ab596d214"

URI_aarch64_rust-below-model+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-model+default-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-below-model+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-model+default-devel}"
SRC_URI[aarch64_rust-below-model+default-devel.sha256sum] = "06c89d6e1e204923d212291ebc1c78d3e3b65f70738bb316f788a7166437d695"

URI_aarch64_rust-below-model-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-model-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-below-model-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-model-devel}"
SRC_URI[aarch64_rust-below-model-devel.sha256sum] = "492ca46088ea49bade1436899e33f98be55e8aa0293f71a97e6ef860c8a10ff3"

RDEPENDS:rust-below-model+default-devel = " \
 cargo \
 rust-below-model-devel \
 "
RDEPENDS:rust-below-model-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-async-trait+default-devel \
 rust-below-btrfs+default-devel \
 rust-below-common+default-devel \
 rust-below-ethtool+default-devel \
 rust-below-gpu-stats+default-devel \
 rust-below-tc+default-devel \
 rust-below_derive+default-devel \
 rust-cgroupfs+default-devel \
 rust-enum-iterator+default-devel \
 rust-fb_procfs+default-devel \
 rust-hostname+default-devel \
 rust-os_info+default-devel \
 rust-regex+default-devel \
 rust-resctrlfs+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-serde_json+default-devel \
 rust-serde_json+float_roundtrip-devel \
 rust-serde_json+unbounded_depth-devel \
 rust-slog+default-devel \
 rust-slog+max_level_trace-devel \
 rust-slog+nested-values-devel \
 "
