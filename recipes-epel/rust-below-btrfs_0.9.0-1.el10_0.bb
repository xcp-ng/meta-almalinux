# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-below-btrfs"
PV = "0.9.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-below-btrfs+default-devel \
 rust-below-btrfs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-below-btrfs-0.9.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ffa0186397e4efecb66d1e53b37a610654d0d18f71292c936feea7984a48d019"

URI_x86_64_v2_rust-below-btrfs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-btrfs+default-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-btrfs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-btrfs+default-devel}"
SRC_URI[x86_64_v2_rust-below-btrfs+default-devel.sha256sum] = "8062e83b1b63f79f2f3ccc783b13d5db1592dcc8b27cb122bb634ed4c3838388"

URI_x86_64_v2_rust-below-btrfs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-btrfs-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-btrfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-btrfs-devel}"
SRC_URI[x86_64_v2_rust-below-btrfs-devel.sha256sum] = "a803fe533434d6aab80e8de4008553e12b2accda1c2ce4731c856b34e22164e7"

URI_aarch64_rust-below-btrfs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-btrfs+default-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-below-btrfs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-btrfs+default-devel}"
SRC_URI[aarch64_rust-below-btrfs+default-devel.sha256sum] = "6e9963545d302e3ba1b0facf6993511c60be1633c45cc31334fc14b6668be647"

URI_aarch64_rust-below-btrfs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-btrfs-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-below-btrfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-btrfs-devel}"
SRC_URI[aarch64_rust-below-btrfs-devel.sha256sum] = "9d536abf2b435a331d49ba20c9800759653c3d33c57e2348e1462599fa076b27"

RDEPENDS:rust-below-btrfs+default-devel = " \
 cargo \
 rust-below-btrfs-devel \
 "
RDEPENDS:rust-below-btrfs-devel = " \
 cargo \
 rust-below-common+default-devel \
 rust-libc+default-devel \
 rust-nix+default-devel \
 rust-nix+dir-devel \
 rust-nix+event-devel \
 rust-nix+hostname-devel \
 rust-nix+inotify-devel \
 rust-nix+ioctl-devel \
 rust-nix+mman-devel \
 rust-nix+mount-devel \
 rust-nix+net-devel \
 rust-nix+poll-devel \
 rust-nix+ptrace-devel \
 rust-nix+reboot-devel \
 rust-nix+resource-devel \
 rust-nix+sched-devel \
 rust-nix+signal-devel \
 rust-nix+term-devel \
 rust-nix+time-devel \
 rust-nix+user-devel \
 rust-nix+zerocopy-devel \
 rust-openat+default-devel \
 rust-rand0.8+default-devel \
 rust-rand0.8+small_rng-devel \
 rust-rand_distr0.4+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-slog+default-devel \
 rust-slog+max_level_trace-devel \
 rust-slog+nested-values-devel \
 rust-thiserror+default-devel \
 "
