# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tar"
PV = "0.4.44"
PR = "1.el10_0"
PACKAGES = " \
 rust-tar+default-devel \
 rust-tar+xattr-devel \
 rust-tar-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tar-0.4.44-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f5b5bb9d451e661902cec50c5c3a2c92a0090e3cccf2a40fee0c5fcdc50d50e"

URI_x86_64_v2_rust-tar+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tar+default-devel-0.4.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tar+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tar+default-devel}"
SRC_URI[x86_64_v2_rust-tar+default-devel.sha256sum] = "8a3d9c872d7b184bee47cb6709c6030b2d84151d297e687c66f53fec19a033b1"

URI_x86_64_v2_rust-tar+xattr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tar+xattr-devel-0.4.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tar+xattr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tar+xattr-devel}"
SRC_URI[x86_64_v2_rust-tar+xattr-devel.sha256sum] = "915204fc358e19862dcb77c8fc57f490860460c61e5c4df464cbee4b7c3bf6ae"

URI_x86_64_v2_rust-tar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tar-devel-0.4.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tar-devel}"
SRC_URI[x86_64_v2_rust-tar-devel.sha256sum] = "73ecd6ddb9624d5885416f36632e076a71013a4f04ec48af3a2234630d04b447"

URI_aarch64_rust-tar+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tar+default-devel-0.4.44-1.el10_0.noarch.rpm;name=aarch64_rust-tar+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tar+default-devel}"
SRC_URI[aarch64_rust-tar+default-devel.sha256sum] = "eaf1e0b8dc85c5f1bd2d273e75f94bf45be5458a1f5dced54f93787db3a438ac"

URI_aarch64_rust-tar+xattr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tar+xattr-devel-0.4.44-1.el10_0.noarch.rpm;name=aarch64_rust-tar+xattr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tar+xattr-devel}"
SRC_URI[aarch64_rust-tar+xattr-devel.sha256sum] = "c450472f75a8e1368de1c7c22c044979f3973ee18938e3445ebf4bf82768cad3"

URI_aarch64_rust-tar-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tar-devel-0.4.44-1.el10_0.noarch.rpm;name=aarch64_rust-tar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tar-devel}"
SRC_URI[aarch64_rust-tar-devel.sha256sum] = "b0ec1764098e63fe626c080252f9d233398ff4cdaa43449c0ccf3708eb61314b"

RDEPENDS:rust-tar+default-devel = " \
 cargo \
 rust-tar+xattr-devel \
 rust-tar-devel \
 "
RDEPENDS:rust-tar+xattr-devel = " \
 cargo \
 rust-tar-devel \
 rust-xattr+default-devel \
 "
RDEPENDS:rust-tar-devel = " \
 cargo \
 rust-filetime+default-devel \
 rust-libc+default-devel \
 "
