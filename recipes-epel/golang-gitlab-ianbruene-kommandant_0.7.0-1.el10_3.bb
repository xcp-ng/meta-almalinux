# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-gitlab-ianbruene-kommandant"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 golang-gitlab-ianbruene-kommandant-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-gitlab-ianbruene-kommandant-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7585b99b3d6cf32e4857cc39f7fc2f8aa8b81f6033c3871fe9ca90f639935e66"

URI_x86_64_v2_golang-gitlab-ianbruene-kommandant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-gitlab-ianbruene-kommandant-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_golang-gitlab-ianbruene-kommandant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-gitlab-ianbruene-kommandant-devel}"
SRC_URI[x86_64_v2_golang-gitlab-ianbruene-kommandant-devel.sha256sum] = "a319754a1fe5791331b820c6a3ccaf688f157c72e56a7b405583e6ec52e1fa8b"

URI_aarch64_golang-gitlab-ianbruene-kommandant-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-gitlab-ianbruene-kommandant-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_golang-gitlab-ianbruene-kommandant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-gitlab-ianbruene-kommandant-devel}"
SRC_URI[aarch64_golang-gitlab-ianbruene-kommandant-devel.sha256sum] = "a08a5db1e6e9a97915a6fd7a5c809156ff80ca175b8fe1af78bf8823f7772273"

RDEPENDS:golang-gitlab-ianbruene-kommandant-devel = " \
 go-filesystem \
 golang-github-chzyer-readline-devel \
 "
