# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-des0.8"
PV = "0.8.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-des0.8+default-devel \
 rust-des0.8+zeroize-devel \
 rust-des0.8-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-des0.8-0.8.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eff334d0c7b7910c862ef29fe1b2906c13200f0c6ecfab3182e07fd8844aae31"

URI_x86_64_v2_rust-des0.8+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-des0.8+default-devel-0.8.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-des0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-des0.8+default-devel}"
SRC_URI[x86_64_v2_rust-des0.8+default-devel.sha256sum] = "178be8ec11ebf84ff6ad94baef99480a5b7aea9554586b903b96a7bf66ce8fe4"

URI_x86_64_v2_rust-des0.8+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-des0.8+zeroize-devel-0.8.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-des0.8+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-des0.8+zeroize-devel}"
SRC_URI[x86_64_v2_rust-des0.8+zeroize-devel.sha256sum] = "35b8c774ff2deb1d3e290afbae1a68d1e758c2d8dcff905d45ad8473b761c2d3"

URI_x86_64_v2_rust-des0.8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-des0.8-devel-0.8.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-des0.8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-des0.8-devel}"
SRC_URI[x86_64_v2_rust-des0.8-devel.sha256sum] = "0cf9fe0b5b4ee2c40b030563448e432533f5068f3d698ec14831e40df6be1f64"

URI_aarch64_rust-des0.8+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-des0.8+default-devel-0.8.1-1.el10_3.noarch.rpm;name=aarch64_rust-des0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-des0.8+default-devel}"
SRC_URI[aarch64_rust-des0.8+default-devel.sha256sum] = "bb1258addb2e6101818fd0d3ccad2db5a9a39f9215e4c3ea7e5221d3e050d452"

URI_aarch64_rust-des0.8+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-des0.8+zeroize-devel-0.8.1-1.el10_3.noarch.rpm;name=aarch64_rust-des0.8+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-des0.8+zeroize-devel}"
SRC_URI[aarch64_rust-des0.8+zeroize-devel.sha256sum] = "1d0776c07224687ee1d4be3bac505ed6fece764fdb822770141095ff3a55c974"

URI_aarch64_rust-des0.8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-des0.8-devel-0.8.1-1.el10_3.noarch.rpm;name=aarch64_rust-des0.8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-des0.8-devel}"
SRC_URI[aarch64_rust-des0.8-devel.sha256sum] = "b600eab85486a3117ab63bf4d0a5f4b556d3188df900a7ea36d6cc6d2aac848d"

RDEPENDS:rust-des0.8+default-devel = " \
 cargo \
 rust-des0.8-devel \
 "
RDEPENDS:rust-des0.8+zeroize-devel = " \
 cargo \
 rust-cipher0.4+zeroize-devel \
 rust-des0.8-devel \
 "
RDEPENDS:rust-des0.8-devel = " \
 cargo \
 rust \
 rust-cipher0.4+default-devel \
 "
