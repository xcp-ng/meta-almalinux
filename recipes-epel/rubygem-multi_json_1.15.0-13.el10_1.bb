# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-multi_json"
PV = "1.15.0"
PR = "13.el10_1"
PACKAGES = " \
 rubygem-multi_json \
 rubygem-multi_json-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-multi_json-1.15.0-13.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b000f4c3f237d6b818d54c42cba7ec509c15bf4637745508c52d054e357f90a"

URI_x86_64_v2_rubygem-multi_json = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-multi_json-1.15.0-13.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-multi_json;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-multi_json}"
SRC_URI[x86_64_v2_rubygem-multi_json.sha256sum] = "513e60e1446b11182dd9a92e7941b5ebd2455cc0f622ebe2b39282bd66178eef"

URI_x86_64_v2_rubygem-multi_json-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-multi_json-doc-1.15.0-13.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-multi_json-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-multi_json-doc}"
SRC_URI[x86_64_v2_rubygem-multi_json-doc.sha256sum] = "6dea285ef45356abc5dbf9a6633cd874ce9b157769a4b5c092668c8ab8fae0e8"

URI_aarch64_rubygem-multi_json = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-multi_json-1.15.0-13.el10_1.noarch.rpm;name=aarch64_rubygem-multi_json;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-multi_json}"
SRC_URI[aarch64_rubygem-multi_json.sha256sum] = "1b484d8f808ecb2212a1d694c979884ffc84a93f05417a32e8cd35edfd566bd4"

URI_aarch64_rubygem-multi_json-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-multi_json-doc-1.15.0-13.el10_1.noarch.rpm;name=aarch64_rubygem-multi_json-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-multi_json-doc}"
SRC_URI[aarch64_rubygem-multi_json-doc.sha256sum] = "ace68a366de11ac0830a5f9f67ccf0a50fd90aa4fd9fb5fa8923df7469327aad"

RDEPENDS:rubygem-multi_json = " \
 rubygems \
 "
RDEPENDS:rubygem-multi_json-doc = " \
 rubygem-multi_json \
 "
