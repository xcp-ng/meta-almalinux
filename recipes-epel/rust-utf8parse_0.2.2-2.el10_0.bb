# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-utf8parse"
PV = "0.2.2"
PR = "2.el10_0"
PACKAGES = " \
 rust-utf8parse+default-devel \
 rust-utf8parse+nightly-devel \
 rust-utf8parse-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-utf8parse-0.2.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e78dd7a831096f9aff837a79b8cd3c5d0ed1e797db58754d84f252eebacb0926"

URI_x86_64_v2_rust-utf8parse+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-utf8parse+default-devel-0.2.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-utf8parse+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-utf8parse+default-devel}"
SRC_URI[x86_64_v2_rust-utf8parse+default-devel.sha256sum] = "3fcffeb2191f8a98a50e6fb55b0d8a4b08d088c25ccf7fd617f91a3be3886e4c"

URI_x86_64_v2_rust-utf8parse+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-utf8parse+nightly-devel-0.2.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-utf8parse+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-utf8parse+nightly-devel}"
SRC_URI[x86_64_v2_rust-utf8parse+nightly-devel.sha256sum] = "a8636f24e8f6fd2520d31a380ebef7cdcb4c01b7fc089ea4274f59306561ab29"

URI_x86_64_v2_rust-utf8parse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-utf8parse-devel-0.2.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-utf8parse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-utf8parse-devel}"
SRC_URI[x86_64_v2_rust-utf8parse-devel.sha256sum] = "118f87d944f9c453f96e786761fa77e7b622902f44c5c1536b6ac6fb5c4ad8f3"

URI_aarch64_rust-utf8parse+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-utf8parse+default-devel-0.2.2-2.el10_0.noarch.rpm;name=aarch64_rust-utf8parse+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-utf8parse+default-devel}"
SRC_URI[aarch64_rust-utf8parse+default-devel.sha256sum] = "794f739acedfb70aa19c1976c7a95f556daa8277a8e9da43a94b5f05a53c39b6"

URI_aarch64_rust-utf8parse+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-utf8parse+nightly-devel-0.2.2-2.el10_0.noarch.rpm;name=aarch64_rust-utf8parse+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-utf8parse+nightly-devel}"
SRC_URI[aarch64_rust-utf8parse+nightly-devel.sha256sum] = "5b70e44798dd90fbb8ea0d6eeb62314cb6555d7e5ce11855112a834c78a9322e"

URI_aarch64_rust-utf8parse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-utf8parse-devel-0.2.2-2.el10_0.noarch.rpm;name=aarch64_rust-utf8parse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-utf8parse-devel}"
SRC_URI[aarch64_rust-utf8parse-devel.sha256sum] = "b25577aa41ab2ba83beb986e276ff3577090a1932dc4cbe99b8025d61b1b9a95"

RDEPENDS:rust-utf8parse+default-devel = " \
 cargo \
 rust-utf8parse-devel \
 "
RDEPENDS:rust-utf8parse+nightly-devel = " \
 cargo \
 rust-utf8parse-devel \
 "
RDEPENDS:rust-utf8parse-devel = " \
 cargo \
 "
