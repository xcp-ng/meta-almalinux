# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "p11-kit"
PV = "0.26.4"
PR = "1.el10_2"
PACKAGES = " \
 p11-kit \
 p11-kit-client \
 p11-kit-devel \
 p11-kit-server \
 p11-kit-trust \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/p11-kit-0.26.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6e351c2e3d2ae1fa40fda9dc18c220446666b03978588cdd037076aa03291d7"

URI_x86_64_v2_p11-kit = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/p11-kit-0.26.4-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_p11-kit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_p11-kit}"
SRC_URI[x86_64_v2_p11-kit.sha256sum] = "1025e8abd13be6d7fe955361722e3f6847829bd75739b30e8d0833ecb0215727"

URI_x86_64_v2_p11-kit-client = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/p11-kit-client-0.26.4-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_p11-kit-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_p11-kit-client}"
SRC_URI[x86_64_v2_p11-kit-client.sha256sum] = "bcc86b65a5cd06b3f950d6e4104920e421476aa42c9a6e1430ae08cf29fdd56f"

URI_x86_64_v2_p11-kit-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/p11-kit-devel-0.26.4-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_p11-kit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_p11-kit-devel}"
SRC_URI[x86_64_v2_p11-kit-devel.sha256sum] = "ef000e3ceaaa52759e9c27cc329f8fbd7fbbd18e10f8a6b277d1ca7962adea84"

URI_x86_64_v2_p11-kit-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/p11-kit-server-0.26.4-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_p11-kit-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_p11-kit-server}"
SRC_URI[x86_64_v2_p11-kit-server.sha256sum] = "13964f71af7f99be1964e864d033624432327bf82e62a52b337a8f20695dd205"

URI_x86_64_v2_p11-kit-trust = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/p11-kit-trust-0.26.4-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_p11-kit-trust;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_p11-kit-trust}"
SRC_URI[x86_64_v2_p11-kit-trust.sha256sum] = "8d99edaa5dd8248a33d0f4649483eb2537ebd8a59f28d9f15fd9d4ca9730b296"

URI_aarch64_p11-kit = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/p11-kit-0.26.4-1.el10_2.aarch64.rpm;name=aarch64_p11-kit;unpack=0"
SRC_URI:append = " ${URI_aarch64_p11-kit}"
SRC_URI[aarch64_p11-kit.sha256sum] = "c3c1289a58fac0c91996f6fb78b1ec0f35c8748f25fabb9e78d965db218e1cad"

URI_aarch64_p11-kit-client = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/p11-kit-client-0.26.4-1.el10_2.aarch64.rpm;name=aarch64_p11-kit-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_p11-kit-client}"
SRC_URI[aarch64_p11-kit-client.sha256sum] = "912d68a5c4beeeb8496184177916ed0600477974dc27f79ebc4acc718758de32"

URI_aarch64_p11-kit-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/p11-kit-devel-0.26.4-1.el10_2.aarch64.rpm;name=aarch64_p11-kit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_p11-kit-devel}"
SRC_URI[aarch64_p11-kit-devel.sha256sum] = "7c9fda1e3dfad5d1797ed50b587e6a9d06fa952930d89165dc0dc2f8b7c37486"

URI_aarch64_p11-kit-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/p11-kit-server-0.26.4-1.el10_2.aarch64.rpm;name=aarch64_p11-kit-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_p11-kit-server}"
SRC_URI[aarch64_p11-kit-server.sha256sum] = "14336768dfa1cef4b3c6cee8bd259d88eb2cb719f0ae9d715c024c52c232036d"

URI_aarch64_p11-kit-trust = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/p11-kit-trust-0.26.4-1.el10_2.aarch64.rpm;name=aarch64_p11-kit-trust;unpack=0"
SRC_URI:append = " ${URI_aarch64_p11-kit-trust}"
SRC_URI[aarch64_p11-kit-trust.sha256sum] = "e9e3245e6600d93e7a3e82be70a0597ddb5dab23bfbf7db00b3e9543281a1fce"

RDEPENDS:p11-kit = " \
 glibc \
 libffi \
 libtasn1 \
 "
RDEPENDS:p11-kit-client = " \
 glibc \
 libffi \
 p11-kit \
 "
RDEPENDS:p11-kit-devel = " \
 p11-kit \
 pkgconf-pkg-config \
 "
RDEPENDS:p11-kit-server = " \
 glibc \
 p11-kit \
 "
RDEPENDS:p11-kit-trust = " \
 alternatives \
 bash \
 glibc \
 libtasn1 \
 p11-kit \
 "
