# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wnaf"
PV = "0.14.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-wnaf+alloc-devel \
 rust-wnaf+default-devel \
 rust-wnaf-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-wnaf-0.14.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "18f0df33684f689f0c21cad2440ecbb55d74c3ddc026796d4d6595942fce3adf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wnaf+alloc-devel-0.14.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wnaf+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wnaf+alloc-devel.sha256sum] = "67961ed020c4e76084a918bbc71b30820ad6ad48a935ada7a9107be6e11c910b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wnaf+default-devel-0.14.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wnaf+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wnaf+default-devel.sha256sum] = "a780114d59e845955f097cff0ef197837b2e375c3fcb8c9ebf15dd6981da2f27"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wnaf-devel-0.14.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wnaf-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wnaf-devel.sha256sum] = "16ee7dea060d19240421052ae188fe9ad2b0fa26513707a3b40e98ee631e3676"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wnaf+alloc-devel-0.14.1-1.el10_3.noarch.rpm;name=aarch64_rust-wnaf+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-wnaf+alloc-devel.sha256sum] = "fea4824f2abafbe5fcc7988a3a12a09530d7b8f89a161ac8741a5e633135f80b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wnaf+default-devel-0.14.1-1.el10_3.noarch.rpm;name=aarch64_rust-wnaf+default-devel;unpack=0"
SRC_URI[aarch64_rust-wnaf+default-devel.sha256sum] = "ac4b2b2b0ae530eda7d13680e4e2009fecd884cf28e35c15e434310044bc83f5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wnaf-devel-0.14.1-1.el10_3.noarch.rpm;name=aarch64_rust-wnaf-devel;unpack=0"
SRC_URI[aarch64_rust-wnaf-devel.sha256sum] = "4303872d27b8ca975cd6c0b80a5018c2913b7ff3038b22f61094d464b1954da5"

RDEPENDS:rust-wnaf+alloc-devel = " \
 cargo \
 rust-ff+alloc-devel \
 rust-group+alloc-devel \
 rust-hybrid-array+alloc-devel \
 rust-wnaf-devel \
 "
RDEPENDS:rust-wnaf+default-devel = " \
 cargo \
 rust-wnaf+alloc-devel \
 rust-wnaf-devel \
 "
RDEPENDS:rust-wnaf-devel = " \
 cargo \
 rust \
 rust-ff-devel \
 rust-group-devel \
 rust-hybrid-array+default-devel \
 rust-primefield-devel \
 "
