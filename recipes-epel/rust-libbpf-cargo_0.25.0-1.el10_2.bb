# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libbpf-cargo"
PV = "0.25.0"
PR = "1.el10_2"
PACKAGES = " \
 libbpf-cargo \
 rust-libbpf-cargo+default-devel \
 rust-libbpf-cargo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libbpf-cargo-0.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "14427a30eff0ccbe00e8305cbab37131990d745274de36bea23d83e10de3f5cb"

URI_x86_64_v2_libbpf-cargo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbpf-cargo-0.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libbpf-cargo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbpf-cargo}"
SRC_URI[x86_64_v2_libbpf-cargo.sha256sum] = "d0ef2efe1e514cfa53f09ba3508c8742c97feb69b4b51691d7a7389606818182"

URI_x86_64_v2_rust-libbpf-cargo+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-cargo+default-devel-0.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-cargo+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-cargo+default-devel}"
SRC_URI[x86_64_v2_rust-libbpf-cargo+default-devel.sha256sum] = "ed13e3b0cf583c5084d929b27eed6a626a80840c33eb21536dcfa6c0c9ed4fd7"

URI_x86_64_v2_rust-libbpf-cargo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-cargo-devel-0.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-cargo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-cargo-devel}"
SRC_URI[x86_64_v2_rust-libbpf-cargo-devel.sha256sum] = "78eaabd752954cf6068aba7b6e7df0af6d875c7121b1036adb544f9d99a82d46"

URI_aarch64_libbpf-cargo = "${EPEL_MIRROR}/aarch64/Packages/l/libbpf-cargo-0.25.0-1.el10_2.aarch64.rpm;name=aarch64_libbpf-cargo;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbpf-cargo}"
SRC_URI[aarch64_libbpf-cargo.sha256sum] = "10ec5207cc81d25d6661a89c1694a827cc463cc5c6769e984ccd67f63a576db1"

URI_aarch64_rust-libbpf-cargo+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-cargo+default-devel-0.25.0-1.el10_2.noarch.rpm;name=aarch64_rust-libbpf-cargo+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-cargo+default-devel}"
SRC_URI[aarch64_rust-libbpf-cargo+default-devel.sha256sum] = "88d0bd5b862daf4d01e23ffdc786aca8c54bf4e554a5535d77f9f95883b3f94a"

URI_aarch64_rust-libbpf-cargo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-cargo-devel-0.25.0-1.el10_2.noarch.rpm;name=aarch64_rust-libbpf-cargo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-cargo-devel}"
SRC_URI[aarch64_rust-libbpf-cargo-devel.sha256sum] = "c973fccc9c130343c12f9dca71b87845dca9ecb2436fad467f711d68312ab7c1"

RDEPENDS:libbpf-cargo = " \
 clang \
 elfutils-libelf \
 glibc \
 libgcc \
 rustfmt \
 zlib-ng-compat \
 "
RDEPENDS:rust-libbpf-cargo+default-devel = " \
 cargo \
 rust-libbpf-cargo-devel \
 rust-libbpf-rs+default-devel \
 "
RDEPENDS:rust-libbpf-cargo-devel = " \
 cargo \
 clang \
 rust \
 rust-anyhow+default-devel \
 rust-cargo_metadata0.19+default-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-libbpf-rs-devel \
 rust-memmap2_0.5+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-tempfile+default-devel \
 rust-tracing-devel \
 rust-tracing-subscriber+ansi-devel \
 rust-tracing-subscriber+chrono-devel \
 rust-tracing-subscriber+fmt-devel \
 rust-tracing-subscriber-devel \
 rustfmt \
 "
