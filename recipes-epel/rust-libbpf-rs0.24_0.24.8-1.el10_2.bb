# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libbpf-rs0.24"
PV = "0.24.8"
PR = "1.el10_2"
PACKAGES = " \
 rust-libbpf-rs0.24+default-devel \
 rust-libbpf-rs0.24+dont-generate-test-files-devel \
 rust-libbpf-rs0.24+generate-test-files-devel \
 rust-libbpf-rs0.24+libbpf-sys-devel \
 rust-libbpf-rs0.24+static-devel \
 rust-libbpf-rs0.24+vendored-devel \
 rust-libbpf-rs0.24-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libbpf-rs0.24-0.24.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c5bf93ed774bd33bf467505ebd88616e233b1af793c9a01b1e5aa154142aa62a"

URI_x86_64_v2_rust-libbpf-rs0.24+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-rs0.24+default-devel-0.24.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-rs0.24+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-rs0.24+default-devel}"
SRC_URI[x86_64_v2_rust-libbpf-rs0.24+default-devel.sha256sum] = "ae73a7479139dc2906362830c30a407f640b11878bd81435a6df413c69ef4ee1"

URI_x86_64_v2_rust-libbpf-rs0.24+dont-generate-test-files-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-rs0.24+dont-generate-test-files-devel-0.24.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-rs0.24+dont-generate-test-files-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-rs0.24+dont-generate-test-files-devel}"
SRC_URI[x86_64_v2_rust-libbpf-rs0.24+dont-generate-test-files-devel.sha256sum] = "c23082f71c1cee7cb59cda60ee6e3886a1b2a0deaccf3fd389c0f26e3f162a42"

URI_x86_64_v2_rust-libbpf-rs0.24+generate-test-files-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-rs0.24+generate-test-files-devel-0.24.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-rs0.24+generate-test-files-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-rs0.24+generate-test-files-devel}"
SRC_URI[x86_64_v2_rust-libbpf-rs0.24+generate-test-files-devel.sha256sum] = "9ee71210c8a2c9534a6ffac3646397355346d13fffaf651df416842889f72309"

URI_x86_64_v2_rust-libbpf-rs0.24+libbpf-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-rs0.24+libbpf-sys-devel-0.24.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-rs0.24+libbpf-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-rs0.24+libbpf-sys-devel}"
SRC_URI[x86_64_v2_rust-libbpf-rs0.24+libbpf-sys-devel.sha256sum] = "0dbb3154af9b7d0fb1762775876ef7d7ebff3dbad24f72c5c979ba18c3bef174"

URI_x86_64_v2_rust-libbpf-rs0.24+static-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-rs0.24+static-devel-0.24.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-rs0.24+static-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-rs0.24+static-devel}"
SRC_URI[x86_64_v2_rust-libbpf-rs0.24+static-devel.sha256sum] = "1f80fc5793b25d3ffd35f2c5f48f30b8ac071380612e123ceb4f7aa742776a6b"

URI_x86_64_v2_rust-libbpf-rs0.24+vendored-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-rs0.24+vendored-devel-0.24.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-rs0.24+vendored-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-rs0.24+vendored-devel}"
SRC_URI[x86_64_v2_rust-libbpf-rs0.24+vendored-devel.sha256sum] = "b71bdd7dfd13e9e6dd6427e28dc025c95c4f1d3b36db2ba2d800a4fd8e42f1de"

URI_x86_64_v2_rust-libbpf-rs0.24-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-rs0.24-devel-0.24.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-rs0.24-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-rs0.24-devel}"
SRC_URI[x86_64_v2_rust-libbpf-rs0.24-devel.sha256sum] = "058f294ac9dc9b5f1b55646f1ff1e3cf91b63a3e3e7eb46ddc580c9e5184833e"

URI_aarch64_rust-libbpf-rs0.24+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-rs0.24+default-devel-0.24.8-1.el10_2.noarch.rpm;name=aarch64_rust-libbpf-rs0.24+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-rs0.24+default-devel}"
SRC_URI[aarch64_rust-libbpf-rs0.24+default-devel.sha256sum] = "29947e9e208ec51917b74925b3ad0201bf19632ae8cc010df27a284e815ec728"

URI_aarch64_rust-libbpf-rs0.24+dont-generate-test-files-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-rs0.24+dont-generate-test-files-devel-0.24.8-1.el10_2.noarch.rpm;name=aarch64_rust-libbpf-rs0.24+dont-generate-test-files-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-rs0.24+dont-generate-test-files-devel}"
SRC_URI[aarch64_rust-libbpf-rs0.24+dont-generate-test-files-devel.sha256sum] = "6c481ddd6621be299ed7e0ff9eedecbe45b11191b416cbdc61dedb7378386dc1"

URI_aarch64_rust-libbpf-rs0.24+generate-test-files-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-rs0.24+generate-test-files-devel-0.24.8-1.el10_2.noarch.rpm;name=aarch64_rust-libbpf-rs0.24+generate-test-files-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-rs0.24+generate-test-files-devel}"
SRC_URI[aarch64_rust-libbpf-rs0.24+generate-test-files-devel.sha256sum] = "bb551d44d1f1445a8f48259e25daf558914b58e9aa159ef9b09cdd01ef67e986"

URI_aarch64_rust-libbpf-rs0.24+libbpf-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-rs0.24+libbpf-sys-devel-0.24.8-1.el10_2.noarch.rpm;name=aarch64_rust-libbpf-rs0.24+libbpf-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-rs0.24+libbpf-sys-devel}"
SRC_URI[aarch64_rust-libbpf-rs0.24+libbpf-sys-devel.sha256sum] = "e488e3f966f90815af546289c27d20196169a04b878f203f6b6875bb43447394"

URI_aarch64_rust-libbpf-rs0.24+static-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-rs0.24+static-devel-0.24.8-1.el10_2.noarch.rpm;name=aarch64_rust-libbpf-rs0.24+static-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-rs0.24+static-devel}"
SRC_URI[aarch64_rust-libbpf-rs0.24+static-devel.sha256sum] = "9b51d588918004b27c633da66b55f885403b5e73e251ba8fc4b4ad5eb9be9fdd"

URI_aarch64_rust-libbpf-rs0.24+vendored-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-rs0.24+vendored-devel-0.24.8-1.el10_2.noarch.rpm;name=aarch64_rust-libbpf-rs0.24+vendored-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-rs0.24+vendored-devel}"
SRC_URI[aarch64_rust-libbpf-rs0.24+vendored-devel.sha256sum] = "f15650cff6497224d0f03d33a8d53dec1aaadf98e562709013e4b72c7a7c504e"

URI_aarch64_rust-libbpf-rs0.24-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-rs0.24-devel-0.24.8-1.el10_2.noarch.rpm;name=aarch64_rust-libbpf-rs0.24-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-rs0.24-devel}"
SRC_URI[aarch64_rust-libbpf-rs0.24-devel.sha256sum] = "8e51593d9b93454ceaa93c436d79d568adb901170bd0166a6cb9d81be1235a3c"

RDEPENDS:rust-libbpf-rs0.24+default-devel = " \
 cargo \
 rust-libbpf-rs0.24-devel \
 rust-libbpf-sys+vendored-libbpf-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-rs0.24+dont-generate-test-files-devel = " \
 cargo \
 rust-libbpf-rs0.24-devel \
 "
RDEPENDS:rust-libbpf-rs0.24+generate-test-files-devel = " \
 cargo \
 rust-libbpf-rs0.24-devel \
 rust-libbpf-sys+vendored-libbpf-devel \
 rust-libbpf-sys-devel \
 rust-tempfile+default-devel \
 "
RDEPENDS:rust-libbpf-rs0.24+libbpf-sys-devel = " \
 cargo \
 rust-libbpf-rs0.24-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-rs0.24+static-devel = " \
 cargo \
 rust-libbpf-rs0.24-devel \
 rust-libbpf-sys+static-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-rs0.24+vendored-devel = " \
 cargo \
 rust-libbpf-rs0.24-devel \
 rust-libbpf-sys+vendored-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-rs0.24-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-libbpf-sys-devel \
 rust-libc+default-devel \
 rust-vsprintf+default-devel \
 "
