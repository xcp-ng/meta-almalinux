# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opencsg"
PV = "1.6.0"
PR = "2.el10_0"
PACKAGES = " \
 opencsg \
 opencsg-devel \
 opencsg-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/opencsg-1.6.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0417f74494738f67221c14300a1d8360fe3f38c976803b43211f1a2a1a9e6759"

URI_x86_64_v2_opencsg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencsg-1.6.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencsg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencsg}"
SRC_URI[x86_64_v2_opencsg.sha256sum] = "10784dff267559c39f69024586259d520dff073dc81a4769339f225a2dd74440"

URI_x86_64_v2_opencsg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencsg-devel-1.6.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencsg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencsg-devel}"
SRC_URI[x86_64_v2_opencsg-devel.sha256sum] = "1d89e109009b954361641ea54ba94a72f2ae1fcd4f60f83000fa198549c88ea1"

URI_x86_64_v2_opencsg-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencsg-doc-1.6.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencsg-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencsg-doc}"
SRC_URI[x86_64_v2_opencsg-doc.sha256sum] = "4b4c53daced042d88627d14b1aeec62f4565aa81123981c57d98e3d4ccabd5ff"

URI_aarch64_opencsg = "${EPEL_MIRROR}/aarch64/Packages/o/opencsg-1.6.0-2.el10_0.aarch64.rpm;name=aarch64_opencsg;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencsg}"
SRC_URI[aarch64_opencsg.sha256sum] = "74e49732cb3564e0c303e8ed58b97a37888fb333bc7bbc8813b8de4bf8a379a9"

URI_aarch64_opencsg-devel = "${EPEL_MIRROR}/aarch64/Packages/o/opencsg-devel-1.6.0-2.el10_0.aarch64.rpm;name=aarch64_opencsg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencsg-devel}"
SRC_URI[aarch64_opencsg-devel.sha256sum] = "b5b7937e3dbc228245ef9d1b4c83de7ac7bf606b922c8ed19daae7108e41ec34"

URI_aarch64_opencsg-doc = "${EPEL_MIRROR}/aarch64/Packages/o/opencsg-doc-1.6.0-2.el10_0.aarch64.rpm;name=aarch64_opencsg-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencsg-doc}"
SRC_URI[aarch64_opencsg-doc.sha256sum] = "5e46b6deafdfb3cf728252f35f533d14be3c5f1dec57d15a6dd8847f9602be17"

RDEPENDS:opencsg = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:opencsg-devel = " \
 opencsg \
 "
RDEPENDS:opencsg-doc = " \
 "
