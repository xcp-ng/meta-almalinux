# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sha-1"
PV = "0.10.1"
PR = "6.el10_0"
PACKAGES = " \
 rust-sha-1+asm-devel \
 rust-sha-1+compress-devel \
 rust-sha-1+default-devel \
 rust-sha-1+force-soft-devel \
 rust-sha-1+oid-devel \
 rust-sha-1+sha1-asm-devel \
 rust-sha-1+std-devel \
 rust-sha-1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sha-1-0.10.1-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c13505b95c78833051c1746d2123a67c42027ab771c9b81eda94a7828994073b"

URI_x86_64_v2_rust-sha-1+asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha-1+asm-devel-0.10.1-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha-1+asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha-1+asm-devel}"
SRC_URI[x86_64_v2_rust-sha-1+asm-devel.sha256sum] = "08d2d3e48272da202c7e9522554865aae7a0a50103ee6fdb1b1f63850f697d3c"

URI_x86_64_v2_rust-sha-1+compress-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha-1+compress-devel-0.10.1-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha-1+compress-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha-1+compress-devel}"
SRC_URI[x86_64_v2_rust-sha-1+compress-devel.sha256sum] = "eb366dca731c93392f142ff910d322a11ffbf350110fb47692384b612c89a391"

URI_x86_64_v2_rust-sha-1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha-1+default-devel-0.10.1-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha-1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha-1+default-devel}"
SRC_URI[x86_64_v2_rust-sha-1+default-devel.sha256sum] = "ecccb22640e02276da1565c8672a86012c4b2e1d9dad19272cda57f8f440365a"

URI_x86_64_v2_rust-sha-1+force-soft-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha-1+force-soft-devel-0.10.1-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha-1+force-soft-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha-1+force-soft-devel}"
SRC_URI[x86_64_v2_rust-sha-1+force-soft-devel.sha256sum] = "defec88cb4036975b1bc0b89267b5a8b7beb7aa717c3871b1bdcd5881d12a84c"

URI_x86_64_v2_rust-sha-1+oid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha-1+oid-devel-0.10.1-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha-1+oid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha-1+oid-devel}"
SRC_URI[x86_64_v2_rust-sha-1+oid-devel.sha256sum] = "e351c36c5a990c7c16d44a2f0cabdf2aaa30b43f8533ec77a460da5f3e8fdc53"

URI_x86_64_v2_rust-sha-1+sha1-asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha-1+sha1-asm-devel-0.10.1-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha-1+sha1-asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha-1+sha1-asm-devel}"
SRC_URI[x86_64_v2_rust-sha-1+sha1-asm-devel.sha256sum] = "a188af5a9ec03d9d968ed4b79cb8664672ef90c72de7270df1352a594632f5d4"

URI_x86_64_v2_rust-sha-1+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha-1+std-devel-0.10.1-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha-1+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha-1+std-devel}"
SRC_URI[x86_64_v2_rust-sha-1+std-devel.sha256sum] = "3c394356db921ce1253060be6191d27f26cff5bd6854c90cf8621afa842568cd"

URI_x86_64_v2_rust-sha-1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha-1-devel-0.10.1-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha-1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha-1-devel}"
SRC_URI[x86_64_v2_rust-sha-1-devel.sha256sum] = "ed2664bebea8dd7ec1e56cfc25921dfe5c3372cad26019a5f09c2640d73f6bbc"

URI_aarch64_rust-sha-1+asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha-1+asm-devel-0.10.1-6.el10_0.noarch.rpm;name=aarch64_rust-sha-1+asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha-1+asm-devel}"
SRC_URI[aarch64_rust-sha-1+asm-devel.sha256sum] = "d12712f598ab70827dda14b07ac121c899414aa9a8066164558f1bc6dd7824bf"

URI_aarch64_rust-sha-1+compress-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha-1+compress-devel-0.10.1-6.el10_0.noarch.rpm;name=aarch64_rust-sha-1+compress-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha-1+compress-devel}"
SRC_URI[aarch64_rust-sha-1+compress-devel.sha256sum] = "5953b52b4f7b6d5d0fd38c71e82da5346a8b94827c155b855970b4a17d6f6e59"

URI_aarch64_rust-sha-1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha-1+default-devel-0.10.1-6.el10_0.noarch.rpm;name=aarch64_rust-sha-1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha-1+default-devel}"
SRC_URI[aarch64_rust-sha-1+default-devel.sha256sum] = "e88d92407b4673a8442b13626aa54052f5e909ebec17bdbd5a072899a79e001d"

URI_aarch64_rust-sha-1+force-soft-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha-1+force-soft-devel-0.10.1-6.el10_0.noarch.rpm;name=aarch64_rust-sha-1+force-soft-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha-1+force-soft-devel}"
SRC_URI[aarch64_rust-sha-1+force-soft-devel.sha256sum] = "2c762ae49e29372670caba6c6b9d15158ddde668e8267a3e26985a7ce5ffdb98"

URI_aarch64_rust-sha-1+oid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha-1+oid-devel-0.10.1-6.el10_0.noarch.rpm;name=aarch64_rust-sha-1+oid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha-1+oid-devel}"
SRC_URI[aarch64_rust-sha-1+oid-devel.sha256sum] = "3f9ba33d14aa94e12bb3fe184f24b821a899776595d975db3bc9d8675f6de70b"

URI_aarch64_rust-sha-1+sha1-asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha-1+sha1-asm-devel-0.10.1-6.el10_0.noarch.rpm;name=aarch64_rust-sha-1+sha1-asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha-1+sha1-asm-devel}"
SRC_URI[aarch64_rust-sha-1+sha1-asm-devel.sha256sum] = "2c66d8cf6cf5df25a2bf01ffb59ea085e22e8e5c075c8f0884c368ad0aa865ab"

URI_aarch64_rust-sha-1+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha-1+std-devel-0.10.1-6.el10_0.noarch.rpm;name=aarch64_rust-sha-1+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha-1+std-devel}"
SRC_URI[aarch64_rust-sha-1+std-devel.sha256sum] = "bad180455b33bd47f5557c39c663f6a05ae85b42a43905214895ff744f967186"

URI_aarch64_rust-sha-1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha-1-devel-0.10.1-6.el10_0.noarch.rpm;name=aarch64_rust-sha-1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha-1-devel}"
SRC_URI[aarch64_rust-sha-1-devel.sha256sum] = "bf162b886fcd7e394b97991d9a07e2e12e57891380c2da9b2e978698793120c6"

RDEPENDS:rust-sha-1+asm-devel = " \
 cargo \
 rust-sha-1+sha1-asm-devel \
 rust-sha-1-devel \
 "
RDEPENDS:rust-sha-1+compress-devel = " \
 cargo \
 rust-sha-1-devel \
 "
RDEPENDS:rust-sha-1+default-devel = " \
 cargo \
 rust-sha-1+std-devel \
 rust-sha-1-devel \
 "
RDEPENDS:rust-sha-1+force-soft-devel = " \
 cargo \
 rust-sha-1-devel \
 "
RDEPENDS:rust-sha-1+oid-devel = " \
 cargo \
 rust-digest+oid-devel \
 rust-sha-1-devel \
 "
RDEPENDS:rust-sha-1+sha1-asm-devel = " \
 cargo \
 rust-sha-1-devel \
 rust-sha1-asm+default-devel \
 "
RDEPENDS:rust-sha-1+std-devel = " \
 cargo \
 rust-digest+std-devel \
 rust-sha-1-devel \
 "
RDEPENDS:rust-sha-1-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 rust-cpufeatures0.2+default-devel \
 rust-digest+default-devel \
 "
