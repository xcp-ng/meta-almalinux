# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyphen-es"
PV = "2.3"
PR = "19.el10"
PACKAGES = " \
 hyphen-es \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyphen-es-2.3-19.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2dc8fb0eb6349deb77502021b3425fa2136f4817a28b1545b4a999abddf283f3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-es-2.3-19.el10.noarch.rpm;name=x86_64_v2_hyphen-es;unpack=0"
SRC_URI[x86_64_v2_hyphen-es.sha256sum] = "9a9c67b9e849d4a94d19f122de37b7a0a214765a1284cf01c439a953a3a8efa5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-es-2.3-19.el10.noarch.rpm;name=aarch64_hyphen-es;unpack=0"
SRC_URI[aarch64_hyphen-es.sha256sum] = "9a9c67b9e849d4a94d19f122de37b7a0a214765a1284cf01c439a953a3a8efa5"

RDEPENDS:hyphen-es = " \
 hyphen \
 "
