# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Tie-Handle-Offset"
PV = "0.004"
PR = "22.el10_1"
PACKAGES = " \
 perl-Tie-Handle-Offset \
 perl-Tie-Handle-Offset-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Tie-Handle-Offset-0.004-22.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a4322ebc179a11f9f498eb75586f40506ae567e0c1210cc655e6f3fb5a3407d"

URI_x86_64_v2_perl-Tie-Handle-Offset = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Tie-Handle-Offset-0.004-22.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Tie-Handle-Offset;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Tie-Handle-Offset}"
SRC_URI[x86_64_v2_perl-Tie-Handle-Offset.sha256sum] = "cfe1228cf6fa64ddee175f63866605751b915554de1a66dc9a0c6f4843ef5eef"

URI_x86_64_v2_perl-Tie-Handle-Offset-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Tie-Handle-Offset-tests-0.004-22.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Tie-Handle-Offset-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Tie-Handle-Offset-tests}"
SRC_URI[x86_64_v2_perl-Tie-Handle-Offset-tests.sha256sum] = "41917c08c708c430d99268b1f57789ae9c8ccd546a3c33c7da49c33f732a9002"

URI_aarch64_perl-Tie-Handle-Offset = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Tie-Handle-Offset-0.004-22.el10_1.noarch.rpm;name=aarch64_perl-Tie-Handle-Offset;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Tie-Handle-Offset}"
SRC_URI[aarch64_perl-Tie-Handle-Offset.sha256sum] = "9cdf0ec507157eaa0bc42e43be30164fcd73d77204b359d89ddc11c1f3dbc376"

URI_aarch64_perl-Tie-Handle-Offset-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Tie-Handle-Offset-tests-0.004-22.el10_1.noarch.rpm;name=aarch64_perl-Tie-Handle-Offset-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Tie-Handle-Offset-tests}"
SRC_URI[aarch64_perl-Tie-Handle-Offset-tests.sha256sum] = "608b34a344acc82b220513cc16365f819284eff7546af5ea760a999749caa494"

RDEPENDS:perl-Tie-Handle-Offset = " \
 perl-Tie \
 perl-Tie-Handle-Offset \
 perl-libs \
 "
RDEPENDS:perl-Tie-Handle-Offset-tests = " \
 bash \
 perl-ExtUtils-MakeMaker \
 perl-PathTools \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Tie-Handle-Offset \
 perl-interpreter \
 perl-libs \
 "
