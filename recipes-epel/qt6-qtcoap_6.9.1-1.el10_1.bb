# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtcoap"
PV = "6.9.1"
PR = "1.el10_1"
PACKAGES = " \
 qt6-qtcoap \
 qt6-qtcoap-devel \
 qt6-qtcoap-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt6-qtcoap-6.9.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ef8be0bbc29a4fea8386e94cf0c238f541b6cda83df70f03b3d464ff48f75f69"

URI_x86_64_v2_qt6-qtcoap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtcoap-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtcoap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtcoap}"
SRC_URI[x86_64_v2_qt6-qtcoap.sha256sum] = "8ade58bbda8bdabc04b2728a609e03c2b2308bdc86ebbfc0aba5cc498465561d"

URI_x86_64_v2_qt6-qtcoap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtcoap-devel-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtcoap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtcoap-devel}"
SRC_URI[x86_64_v2_qt6-qtcoap-devel.sha256sum] = "55a74b2f3f21f4a4ea11cf9d9688a9e3ca3353aff81169ef8cb985c23f1d9122"

URI_x86_64_v2_qt6-qtcoap-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtcoap-examples-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtcoap-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtcoap-examples}"
SRC_URI[x86_64_v2_qt6-qtcoap-examples.sha256sum] = "c2a55ed3d3e07533cdb1e80bded9cd3d8cd3d9910b53a4b5f84aae220c24b564"

URI_aarch64_qt6-qtcoap = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtcoap-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_qt6-qtcoap;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtcoap}"
SRC_URI[aarch64_qt6-qtcoap.sha256sum] = "fe7f56bdef0547840839a98152be40dd8e79c2184ed0401df2580143d159f066"

URI_aarch64_qt6-qtcoap-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtcoap-devel-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_qt6-qtcoap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtcoap-devel}"
SRC_URI[aarch64_qt6-qtcoap-devel.sha256sum] = "9c7930e33dc75f008d3e272c2e0431ed6a12403d07f1eba84e3536ddda5faf6f"

URI_aarch64_qt6-qtcoap-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtcoap-examples-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_qt6-qtcoap-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtcoap-examples}"
SRC_URI[aarch64_qt6-qtcoap-examples.sha256sum] = "53914b2b3e61d3dc6e2007573bab82dcf8eb2736b5eecaca02a8b29a2e78ef18"

RDEPENDS:qt6-qtcoap = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:qt6-qtcoap-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtcoap \
 "
RDEPENDS:qt6-qtcoap-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtcoap \
 qt6-qtcoap-devel \
 qt6-qtdeclarative \
 "
