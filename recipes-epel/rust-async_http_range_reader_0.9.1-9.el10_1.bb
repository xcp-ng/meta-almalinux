# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async_http_range_reader"
PV = "0.9.1"
PR = "9.el10_1"
PACKAGES = " \
 rust-async_http_range_reader+default-devel \
 rust-async_http_range_reader-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async_http_range_reader-0.9.1-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e33904d05e8c17b8ac00a524649b2c4f01c001cada620e69aa7410e813d7ef8e"

URI_x86_64_v2_rust-async_http_range_reader+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async_http_range_reader+default-devel-0.9.1-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async_http_range_reader+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async_http_range_reader+default-devel}"
SRC_URI[x86_64_v2_rust-async_http_range_reader+default-devel.sha256sum] = "4da3fa6bc6d31ece65f0080c69c136721968bfe76b73dd16a00686556ec9d779"

URI_x86_64_v2_rust-async_http_range_reader-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async_http_range_reader-devel-0.9.1-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async_http_range_reader-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async_http_range_reader-devel}"
SRC_URI[x86_64_v2_rust-async_http_range_reader-devel.sha256sum] = "311feb5ec97d3b6fabc5e957bd8ca3c257fbfd3f00f9defe814ad4cf1794ff3b"

URI_aarch64_rust-async_http_range_reader+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async_http_range_reader+default-devel-0.9.1-9.el10_1.noarch.rpm;name=aarch64_rust-async_http_range_reader+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async_http_range_reader+default-devel}"
SRC_URI[aarch64_rust-async_http_range_reader+default-devel.sha256sum] = "bdd38f132525b62e02ef400bcd408d142eac539f5cbf01ac9516be16afe763b9"

URI_aarch64_rust-async_http_range_reader-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async_http_range_reader-devel-0.9.1-9.el10_1.noarch.rpm;name=aarch64_rust-async_http_range_reader-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async_http_range_reader-devel}"
SRC_URI[aarch64_rust-async_http_range_reader-devel.sha256sum] = "477e6f6f0758cef532a3a06ada4121374fe522718e6177a545365e42e7c0e80b"

RDEPENDS:rust-async_http_range_reader+default-devel = " \
 cargo \
 rust-async_http_range_reader-devel \
 "
RDEPENDS:rust-async_http_range_reader-devel = " \
 cargo \
 rust-bisection+default-devel \
 rust-futures+default-devel \
 rust-http-content-range+default-devel \
 rust-itertools0.13+default-devel \
 rust-memmap2+default-devel \
 rust-reqwest-middleware0.4+default-devel \
 rust-reqwest0.12+stream-devel \
 rust-reqwest0.12-devel \
 rust-thiserror1+default-devel \
 rust-tokio-devel \
 rust-tokio-stream+default-devel \
 rust-tokio-stream+sync-devel \
 rust-tokio-util+default-devel \
 rust-tracing+default-devel \
 "
