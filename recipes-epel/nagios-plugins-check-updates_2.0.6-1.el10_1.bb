# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nagios-plugins-check-updates"
PV = "2.0.6"
PR = "1.el10_1"
PACKAGES = " \
 nagios-plugins-check-updates \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nagios-plugins-check-updates-2.0.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0073428d0087281a6800002ac202d8295d060d6180a8ed907a0a099903d7737d"

URI_x86_64_v2_nagios-plugins-check-updates = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-check-updates-2.0.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-check-updates;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-check-updates}"
SRC_URI[x86_64_v2_nagios-plugins-check-updates.sha256sum] = "5b886401796279ac11fa69c51f284bd2d3d505188f2635f89fdfe6a7a80a0da4"

URI_aarch64_nagios-plugins-check-updates = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-check-updates-2.0.6-1.el10_1.aarch64.rpm;name=aarch64_nagios-plugins-check-updates;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-check-updates}"
SRC_URI[aarch64_nagios-plugins-check-updates.sha256sum] = "76f0916d9eb4076634e2553ff0c21fc133b775d1d5849f3d01c8fb9459a50deb"

RDEPENDS:nagios-plugins-check-updates = " \
 nagios-plugins \
 perl-Carp \
 perl-English \
 perl-Monitoring-Plugin \
 perl-POSIX \
 perl-Readonly \
 perl-interpreter \
 perl-libs \
 perl-vars \
 which \
 "
