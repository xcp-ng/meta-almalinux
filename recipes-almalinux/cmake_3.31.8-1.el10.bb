# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cmake"
PV = "3.31.8"
PR = "1.el10"
PACKAGES = " \
 cmake \
 cmake-data \
 cmake-doc \
 cmake-filesystem \
 cmake-gui \
 cmake-rpm-macros \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cmake-3.31.8-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e0d9e72682530043d423b9bbd28415f2cb0103e507d4e9c40c0e9971e9726b5"

URI_x86_64_v2_cmake = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cmake-3.31.8-1.el10.x86_64_v2.rpm;name=x86_64_v2_cmake;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cmake}"
SRC_URI[x86_64_v2_cmake.sha256sum] = "f51580f9c781f99380d45f34d5abec7958678edae53617f186f42aee6d325f9f"

URI_x86_64_v2_cmake-data = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cmake-data-3.31.8-1.el10.noarch.rpm;name=x86_64_v2_cmake-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cmake-data}"
SRC_URI[x86_64_v2_cmake-data.sha256sum] = "157396ea7f30dfd5b297a9370ae429e8031e3c45fc6ea98f8e7bc2fdcdef6b56"

URI_x86_64_v2_cmake-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cmake-doc-3.31.8-1.el10.noarch.rpm;name=x86_64_v2_cmake-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cmake-doc}"
SRC_URI[x86_64_v2_cmake-doc.sha256sum] = "eb71fce54c5dd039e053dbcc1ec803d32fcaec3cbeb4fedd385ded725f7f46da"

URI_x86_64_v2_cmake-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cmake-filesystem-3.31.8-1.el10.x86_64_v2.rpm;name=x86_64_v2_cmake-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cmake-filesystem}"
SRC_URI[x86_64_v2_cmake-filesystem.sha256sum] = "26a3541d2dd2f3b5be59bce0e4e7b68def680cb830e3fca999585cb50d305100"

URI_x86_64_v2_cmake-gui = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cmake-gui-3.31.8-1.el10.x86_64_v2.rpm;name=x86_64_v2_cmake-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cmake-gui}"
SRC_URI[x86_64_v2_cmake-gui.sha256sum] = "8a1ec60dcc5c8d24c197be5f6f3d8b6e62e9c4b2ef1eb04f5c608faa9f659f7a"

URI_x86_64_v2_cmake-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cmake-rpm-macros-3.31.8-1.el10.noarch.rpm;name=x86_64_v2_cmake-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cmake-rpm-macros}"
SRC_URI[x86_64_v2_cmake-rpm-macros.sha256sum] = "e31de66ec746b5ec6a44a8e5aae8f69c59637094cd6fe9049891584fea905074"

URI_aarch64_cmake = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cmake-3.31.8-1.el10.aarch64.rpm;name=aarch64_cmake;unpack=0"
SRC_URI:append = " ${URI_aarch64_cmake}"
SRC_URI[aarch64_cmake.sha256sum] = "94e3923cba24e01053a9005747db060ca9502fbe07991024986a451a43e194b6"

URI_aarch64_cmake-data = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cmake-data-3.31.8-1.el10.noarch.rpm;name=aarch64_cmake-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_cmake-data}"
SRC_URI[aarch64_cmake-data.sha256sum] = "157396ea7f30dfd5b297a9370ae429e8031e3c45fc6ea98f8e7bc2fdcdef6b56"

URI_aarch64_cmake-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cmake-doc-3.31.8-1.el10.noarch.rpm;name=aarch64_cmake-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_cmake-doc}"
SRC_URI[aarch64_cmake-doc.sha256sum] = "eb71fce54c5dd039e053dbcc1ec803d32fcaec3cbeb4fedd385ded725f7f46da"

URI_aarch64_cmake-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cmake-filesystem-3.31.8-1.el10.aarch64.rpm;name=aarch64_cmake-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_cmake-filesystem}"
SRC_URI[aarch64_cmake-filesystem.sha256sum] = "1bab3f3876d9ff7df87d8028b8da9abe24f04545244d920ac97c7774974ab01e"

URI_aarch64_cmake-gui = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cmake-gui-3.31.8-1.el10.aarch64.rpm;name=aarch64_cmake-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_cmake-gui}"
SRC_URI[aarch64_cmake-gui.sha256sum] = "c5bf8cd14f03b62b325b284c8f7aebad0a95dc281da1b1f73c6af2d4fd31abd0"

URI_aarch64_cmake-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cmake-rpm-macros-3.31.8-1.el10.noarch.rpm;name=aarch64_cmake-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_cmake-rpm-macros}"
SRC_URI[aarch64_cmake-rpm-macros.sha256sum] = "e31de66ec746b5ec6a44a8e5aae8f69c59637094cd6fe9049891584fea905074"

RDEPENDS:cmake = " \
 cmake-data \
 cmake-filesystem \
 cmake-rpm-macros \
 expat \
 glibc \
 libarchive \
 libgcc \
 libstdc++ \
 libuv \
 make \
 ncurses-libs \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:cmake-data = " \
 cmake \
 cmake-filesystem \
 cmake-rpm-macros \
 emacs-filesystem \
 vim-filesystem \
 "
RDEPENDS:cmake-doc = " \
 "
RDEPENDS:cmake-filesystem = " \
 "
RDEPENDS:cmake-gui = " \
 cmake \
 glibc \
 hicolor-icon-theme \
 libarchive \
 libgcc \
 libstdc++ \
 libuv \
 qt6-qtbase \
 qt6-qtbase-gui \
 shared-mime-info \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:cmake-rpm-macros = " \
 python3 \
 rpm \
 "
