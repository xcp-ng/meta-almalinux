# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "containers-common"
PE = "6"
PV = "5.8"
PR = "2.el10"
PACKAGES = " \
 containers-common \
 containers-common-extra \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/containers-common-5.8-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a5361392eb0e6c9ef798cb13a20b58bf7bfe841682f60ec73f3eb4c1350e069b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/containers-common-5.8-2.el10.noarch.rpm;name=x86_64_v2_containers-common;unpack=0"
SRC_URI[x86_64_v2_containers-common.sha256sum] = "2eb481da5d592d7464354098b26266768ee947b1b2fa42047614d620688abbb9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/containers-common-extra-5.8-2.el10.noarch.rpm;name=x86_64_v2_containers-common-extra;unpack=0"
SRC_URI[x86_64_v2_containers-common-extra.sha256sum] = "116a59b44e0aa9952cc05bc579d5744500fb852f452a416d0548de76e8e3d418"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/containers-common-5.8-2.el10.noarch.rpm;name=aarch64_containers-common;unpack=0"
SRC_URI[aarch64_containers-common.sha256sum] = "2eb481da5d592d7464354098b26266768ee947b1b2fa42047614d620688abbb9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/containers-common-extra-5.8-2.el10.noarch.rpm;name=aarch64_containers-common-extra;unpack=0"
SRC_URI[aarch64_containers-common-extra.sha256sum] = "116a59b44e0aa9952cc05bc579d5744500fb852f452a416d0548de76e8e3d418"

RDEPENDS:containers-common = " \
 container-selinux \
 netavark \
 "
RDEPENDS:containers-common-extra = " \
 containers-common \
 netavark \
 nftables \
 passt \
 virtual/oci-runtime \
 "
