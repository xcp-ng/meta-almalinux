# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kamera"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kamera \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kamera-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d1cb736bfb3d959bb7a6b7ecddba626605473dd9cbcfe7e85b632792d9c29293"

URI_x86_64_v2_kamera = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kamera-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kamera;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kamera}"
SRC_URI[x86_64_v2_kamera.sha256sum] = "a885c430bbd0749b72b5750ed356e45e813b245a8c21c85359f2ad429b2eb021"

URI_aarch64_kamera = "${EPEL_MIRROR}/aarch64/Packages/k/kamera-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kamera;unpack=0"
SRC_URI:append = " ${URI_aarch64_kamera}"
SRC_URI[aarch64_kamera.sha256sum] = "df00da9bbfb8da639dc401b8bb6436e39c10c29fc82ad39e5d7ad5baae68ef3f"

RDEPENDS:kamera = " \
 glibc \
 kde-cli-tools \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgphoto2 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
