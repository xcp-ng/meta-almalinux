# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-zope-testrunner"
PV = "6.6"
PR = "2.el10_0"
PACKAGES = " \
 python-zope-testrunner-doc \
 python3-zope-testrunner \
 python3-zope-testrunner+subunit \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-zope-testrunner-6.6-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e90ca74a6170fdbbd34f3ad3d16e5d599c53ae4e9efe62ac6c53373b59dd16d0"

URI_x86_64_v2_python-zope-testrunner-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-zope-testrunner-doc-6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-zope-testrunner-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-zope-testrunner-doc}"
SRC_URI[x86_64_v2_python-zope-testrunner-doc.sha256sum] = "6f17837251315e229174fb82c4281c9ea3297a03091ceea0a7e0606d9a76fb42"

URI_x86_64_v2_python3-zope-testrunner = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-zope-testrunner-6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-zope-testrunner;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-zope-testrunner}"
SRC_URI[x86_64_v2_python3-zope-testrunner.sha256sum] = "11a498a98a345c0f8bd4b15ddd511f1ef78d0f0bff1526c162ed84ffcf656d31"

URI_x86_64_v2_python3-zope-testrunner+subunit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-zope-testrunner+subunit-6.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-zope-testrunner+subunit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-zope-testrunner+subunit}"
SRC_URI[x86_64_v2_python3-zope-testrunner+subunit.sha256sum] = "cd37a3f6af0d46d7dbc2bf666e286572f86a4182549351c9bcab4a443a42adab"

URI_aarch64_python-zope-testrunner-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-zope-testrunner-doc-6.6-2.el10_0.noarch.rpm;name=aarch64_python-zope-testrunner-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-zope-testrunner-doc}"
SRC_URI[aarch64_python-zope-testrunner-doc.sha256sum] = "7ea54eab472898b16ee3235c4861dd8cca5904af94ac56c121e43e9bd9d36c19"

URI_aarch64_python3-zope-testrunner = "${EPEL_MIRROR}/aarch64/Packages/p/python3-zope-testrunner-6.6-2.el10_0.noarch.rpm;name=aarch64_python3-zope-testrunner;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-zope-testrunner}"
SRC_URI[aarch64_python3-zope-testrunner.sha256sum] = "4d2695ae354033934b0da7b84d1a6561b48015a99a701fb84c6fc79c0182ef11"

URI_aarch64_python3-zope-testrunner+subunit = "${EPEL_MIRROR}/aarch64/Packages/p/python3-zope-testrunner+subunit-6.6-2.el10_0.noarch.rpm;name=aarch64_python3-zope-testrunner+subunit;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-zope-testrunner+subunit}"
SRC_URI[aarch64_python3-zope-testrunner+subunit.sha256sum] = "75cc46b8fdea57ca784bf8058ef6cb8915b71c719dd922d967db4d928969ffd1"

RDEPENDS:python-zope-testrunner-doc = " \
 "
RDEPENDS:python3-zope-testrunner = " \
 python3 \
 python3-setuptools \
 python3-zope-exceptions \
 python3-zope-interface \
 "
RDEPENDS:python3-zope-testrunner+subunit = " \
 python3 \
 python3-subunit \
 python3-testtools \
 python3-zope-testrunner \
 "
