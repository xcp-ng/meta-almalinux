# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bcrypt"
PV = "0.17.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-bcrypt+alloc-devel \
 rust-bcrypt+default-devel \
 rust-bcrypt+getrandom-devel \
 rust-bcrypt+std-devel \
 rust-bcrypt+zeroize-devel \
 rust-bcrypt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bcrypt-0.17.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b202db1a006ca5735e25f258c9ab92b0e87683bb6e2dfea08dab9c99857853f3"

URI_x86_64_v2_rust-bcrypt+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bcrypt+alloc-devel-0.17.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bcrypt+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bcrypt+alloc-devel}"
SRC_URI[x86_64_v2_rust-bcrypt+alloc-devel.sha256sum] = "2b7ccbecc520751c7496f392ea37db54c5a2564e9dc5665c434ddd0b79cad6d0"

URI_x86_64_v2_rust-bcrypt+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bcrypt+default-devel-0.17.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bcrypt+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bcrypt+default-devel}"
SRC_URI[x86_64_v2_rust-bcrypt+default-devel.sha256sum] = "7c15b243da5931e34952f550c60433cf531d1daf82aef47be04c265cbdfe8c0f"

URI_x86_64_v2_rust-bcrypt+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bcrypt+getrandom-devel-0.17.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bcrypt+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bcrypt+getrandom-devel}"
SRC_URI[x86_64_v2_rust-bcrypt+getrandom-devel.sha256sum] = "cd89a4e6fc136fd5f58bbb59b9bf9924aa9c26dc5a28bbab5cb6c19ca21791f0"

URI_x86_64_v2_rust-bcrypt+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bcrypt+std-devel-0.17.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bcrypt+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bcrypt+std-devel}"
SRC_URI[x86_64_v2_rust-bcrypt+std-devel.sha256sum] = "39268f468eeb5249d5369c4500402536e4c1cff280766df0068d81abd4b169a7"

URI_x86_64_v2_rust-bcrypt+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bcrypt+zeroize-devel-0.17.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bcrypt+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bcrypt+zeroize-devel}"
SRC_URI[x86_64_v2_rust-bcrypt+zeroize-devel.sha256sum] = "b4f318d2df9edc2898ca925ccfc7b06182f716355b3285fe6abf6590b4ae2387"

URI_x86_64_v2_rust-bcrypt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bcrypt-devel-0.17.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bcrypt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bcrypt-devel}"
SRC_URI[x86_64_v2_rust-bcrypt-devel.sha256sum] = "27fd3e8c369c6ada9d83f94550d06eba6dcdd9e901af876069dbc9ce5141816f"

URI_aarch64_rust-bcrypt+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bcrypt+alloc-devel-0.17.1-1.el10_1.noarch.rpm;name=aarch64_rust-bcrypt+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bcrypt+alloc-devel}"
SRC_URI[aarch64_rust-bcrypt+alloc-devel.sha256sum] = "2aece9d2129d2a3be74b979e7374329fc738791323e1f6673f638580f5fa7e03"

URI_aarch64_rust-bcrypt+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bcrypt+default-devel-0.17.1-1.el10_1.noarch.rpm;name=aarch64_rust-bcrypt+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bcrypt+default-devel}"
SRC_URI[aarch64_rust-bcrypt+default-devel.sha256sum] = "c4ab5ebe4519a095f399e5a47ee73c8394b7e884ed198576d8e306e25e001429"

URI_aarch64_rust-bcrypt+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bcrypt+getrandom-devel-0.17.1-1.el10_1.noarch.rpm;name=aarch64_rust-bcrypt+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bcrypt+getrandom-devel}"
SRC_URI[aarch64_rust-bcrypt+getrandom-devel.sha256sum] = "ffd27ff5be7aece845434b734f6b73c80297e3f4f00ee691dd55621a3f0ef00b"

URI_aarch64_rust-bcrypt+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bcrypt+std-devel-0.17.1-1.el10_1.noarch.rpm;name=aarch64_rust-bcrypt+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bcrypt+std-devel}"
SRC_URI[aarch64_rust-bcrypt+std-devel.sha256sum] = "3424af029565ae131fc483a151ef849ea032d6c870c94b88954b767d466f71e6"

URI_aarch64_rust-bcrypt+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bcrypt+zeroize-devel-0.17.1-1.el10_1.noarch.rpm;name=aarch64_rust-bcrypt+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bcrypt+zeroize-devel}"
SRC_URI[aarch64_rust-bcrypt+zeroize-devel.sha256sum] = "26aefbed4386fc7f3ba6474e903b6ea674f3567ff1632496729c85c73cecd9ab"

URI_aarch64_rust-bcrypt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bcrypt-devel-0.17.1-1.el10_1.noarch.rpm;name=aarch64_rust-bcrypt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bcrypt-devel}"
SRC_URI[aarch64_rust-bcrypt-devel.sha256sum] = "339e9695f72e885ff6bdf97075b67cc309a886b434675f5085c3461b8d41bdb1"

RDEPENDS:rust-bcrypt+alloc-devel = " \
 cargo \
 rust-base64+alloc-devel \
 rust-bcrypt+getrandom-devel \
 rust-bcrypt-devel \
 "
RDEPENDS:rust-bcrypt+default-devel = " \
 cargo \
 rust-bcrypt+std-devel \
 rust-bcrypt+zeroize-devel \
 rust-bcrypt-devel \
 "
RDEPENDS:rust-bcrypt+getrandom-devel = " \
 cargo \
 rust-bcrypt-devel \
 rust-getrandom-devel \
 "
RDEPENDS:rust-bcrypt+std-devel = " \
 cargo \
 rust-base64+std-devel \
 rust-bcrypt-devel \
 rust-getrandom+std-devel \
 rust-getrandom-devel \
 "
RDEPENDS:rust-bcrypt+zeroize-devel = " \
 cargo \
 rust-bcrypt-devel \
 rust-zeroize+default-devel \
 "
RDEPENDS:rust-bcrypt-devel = " \
 cargo \
 rust-base64-devel \
 rust-blowfish+bcrypt-devel \
 rust-blowfish+default-devel \
 rust-subtle-devel \
 "
