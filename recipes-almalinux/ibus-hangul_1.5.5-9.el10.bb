# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ibus-hangul"
PV = "1.5.5"
PR = "9.el10"
PACKAGES = " \
 ibus-hangul \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ibus-hangul-1.5.5-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ec0bcdac11c9f5b274dedcb22ca21a013a2ae378ed4b54d126ee6fdb3d540ff"

URI_x86_64_v2_ibus-hangul = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-hangul-1.5.5-9.el10.x86_64_v2.rpm;name=x86_64_v2_ibus-hangul;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-hangul}"
SRC_URI[x86_64_v2_ibus-hangul.sha256sum] = "71e81f395b7806f86bc1fa69d6d969af3f9b2b2d1346b415de2df3777155d3f4"

URI_aarch64_ibus-hangul = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-hangul-1.5.5-9.el10.aarch64.rpm;name=aarch64_ibus-hangul;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-hangul}"
SRC_URI[aarch64_ibus-hangul.sha256sum] = "db98ab1ff3b77f2902738e50c58d925e380840fe0033a73e075dca354dbbd9b1"

RDEPENDS:ibus-hangul = " \
 bash \
 glib2 \
 glibc \
 ibus \
 ibus-libs \
 libhangul \
 python3 \
 python3-gobject \
 "
