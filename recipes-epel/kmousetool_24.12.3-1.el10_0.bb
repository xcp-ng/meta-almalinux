# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmousetool"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kmousetool \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmousetool-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc9a8f1aae220aacc3e07c08c59a94da09e5827a514cca112fd9641608fcfabb"

URI_x86_64_v2_kmousetool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmousetool-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmousetool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmousetool}"
SRC_URI[x86_64_v2_kmousetool.sha256sum] = "022dad979d9e58f1816f6463407c72b5937565aee5651a5347b57057fd09794d"

URI_aarch64_kmousetool = "${EPEL_MIRROR}/aarch64/Packages/k/kmousetool-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kmousetool;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmousetool}"
SRC_URI[aarch64_kmousetool.sha256sum] = "c38e67e7a55c585b674921d3d0ba26a7e425daa0c02841f42045216b73687329"

RDEPENDS:kmousetool = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libX11 \
 libXtst \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 "
