# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-verilog"
PV = "1.0.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-tree-sitter-verilog+default-devel \
 rust-tree-sitter-verilog-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-verilog-1.0.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "469b4d7ae53da876a5689200012928c09e8a5e945f245879ab50e84e7d126917"

URI_x86_64_v2_rust-tree-sitter-verilog+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-verilog+default-devel-1.0.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-verilog+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-verilog+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-verilog+default-devel.sha256sum] = "37a552876ee50f117a92e6a6d58d36ab3fb6252fd07b633c3c489930241f5bd7"

URI_x86_64_v2_rust-tree-sitter-verilog-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-verilog-devel-1.0.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-verilog-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-verilog-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-verilog-devel.sha256sum] = "2b0b373d7386f4e0b6a649740a49d4b0a95ec9c13c9e2da080ddb48c404caf90"

URI_aarch64_rust-tree-sitter-verilog+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-verilog+default-devel-1.0.3-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-verilog+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-verilog+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-verilog+default-devel.sha256sum] = "2c75010830bd1238000102fe2a97ec3d50908f5cd7815c9789e2c03248d71736"

URI_aarch64_rust-tree-sitter-verilog-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-verilog-devel-1.0.3-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-verilog-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-verilog-devel}"
SRC_URI[aarch64_rust-tree-sitter-verilog-devel.sha256sum] = "43377e2fea1fa08794d13fa51e72b5a3a822b5ddc1518402b2b929c14f798a5e"

RDEPENDS:rust-tree-sitter-verilog+default-devel = " \
 cargo \
 rust-tree-sitter-verilog-devel \
 "
RDEPENDS:rust-tree-sitter-verilog-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
