# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-GSSAPI"
PV = "0.28"
PR = "48.el10"
PACKAGES = " \
 perl-GSSAPI \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-GSSAPI-0.28-48.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5bccfb428130aa21b653d1a8dcff406896782f5755666509a5c17dceaec7524e"

URI_x86_64_v2_perl-GSSAPI = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-GSSAPI-0.28-48.el10.x86_64_v2.rpm;name=x86_64_v2_perl-GSSAPI;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-GSSAPI}"
SRC_URI[x86_64_v2_perl-GSSAPI.sha256sum] = "67b7234ff841714a330854c4b64ee8a102d6950d177530382b51f23b75267c5a"

URI_aarch64_perl-GSSAPI = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-GSSAPI-0.28-48.el10.aarch64.rpm;name=aarch64_perl-GSSAPI;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-GSSAPI}"
SRC_URI[aarch64_perl-GSSAPI.sha256sum] = "7f8a90b6560391a4ee183eb04c6b6318a3cd5724fca5715bd13ffe2d01fdd5d9"

RDEPENDS:perl-GSSAPI = " \
 glibc \
 krb5-libs \
 perl-Carp \
 perl-Exporter \
 perl-constant \
 perl-libs \
 perl-overload \
 "
