# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "f42-backgrounds"
PV = "42.0.0"
PR = "4.el10_1"
PACKAGES = " \
 f42-backgrounds \
 f42-backgrounds-base \
 f42-backgrounds-budgie \
 f42-backgrounds-gnome \
 f42-backgrounds-kde \
 f42-backgrounds-mate \
 f42-backgrounds-xfce \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/f42-backgrounds-42.0.0-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be6783007db3c3bce5a11bdac1706e640ee1f4478532d6e241fa2c86c0140686"

URI_x86_64_v2_f42-backgrounds = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f42-backgrounds-42.0.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_f42-backgrounds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f42-backgrounds}"
SRC_URI[x86_64_v2_f42-backgrounds.sha256sum] = "8b26fa7cfdd652fd6c93bea699d8e5e53b71a9cd51117132f015a2ed9d9384eb"

URI_x86_64_v2_f42-backgrounds-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f42-backgrounds-base-42.0.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_f42-backgrounds-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f42-backgrounds-base}"
SRC_URI[x86_64_v2_f42-backgrounds-base.sha256sum] = "ca7dfd746b9d638c218037debad87240e9abce3f27f8b939fe9b4251944e1dbe"

URI_x86_64_v2_f42-backgrounds-budgie = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f42-backgrounds-budgie-42.0.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_f42-backgrounds-budgie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f42-backgrounds-budgie}"
SRC_URI[x86_64_v2_f42-backgrounds-budgie.sha256sum] = "82c6c2b3464c1768a34d793e0b52b0534374b97317508be380c18833543d0f18"

URI_x86_64_v2_f42-backgrounds-gnome = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f42-backgrounds-gnome-42.0.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_f42-backgrounds-gnome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f42-backgrounds-gnome}"
SRC_URI[x86_64_v2_f42-backgrounds-gnome.sha256sum] = "d4d490ac7d3349c4734b2840d6bc28b5ec281f3f0a2960b5163aa32491ae9849"

URI_x86_64_v2_f42-backgrounds-kde = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f42-backgrounds-kde-42.0.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_f42-backgrounds-kde;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f42-backgrounds-kde}"
SRC_URI[x86_64_v2_f42-backgrounds-kde.sha256sum] = "8aa4a0f40297bb9770edd495d9c945b764e5a59a35a39b1148875900a4ee448c"

URI_x86_64_v2_f42-backgrounds-mate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f42-backgrounds-mate-42.0.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_f42-backgrounds-mate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f42-backgrounds-mate}"
SRC_URI[x86_64_v2_f42-backgrounds-mate.sha256sum] = "94fe45b0995014ef67d96b2e9d76e0feb3f88824b301421df1954e90bcec1f47"

URI_x86_64_v2_f42-backgrounds-xfce = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f42-backgrounds-xfce-42.0.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_f42-backgrounds-xfce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f42-backgrounds-xfce}"
SRC_URI[x86_64_v2_f42-backgrounds-xfce.sha256sum] = "d03bc725d5443b31f74fdcad6a6f4820e6ba3af4ec0e4921cd018ce273ea7613"

URI_aarch64_f42-backgrounds = "${EPEL_MIRROR}/aarch64/Packages/f/f42-backgrounds-42.0.0-4.el10_1.noarch.rpm;name=aarch64_f42-backgrounds;unpack=0"
SRC_URI:append = " ${URI_aarch64_f42-backgrounds}"
SRC_URI[aarch64_f42-backgrounds.sha256sum] = "d09c9857d726e09e6e8dbb038b12e7a99309505cf8393c59b3552862ceea779a"

URI_aarch64_f42-backgrounds-base = "${EPEL_MIRROR}/aarch64/Packages/f/f42-backgrounds-base-42.0.0-4.el10_1.noarch.rpm;name=aarch64_f42-backgrounds-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_f42-backgrounds-base}"
SRC_URI[aarch64_f42-backgrounds-base.sha256sum] = "30ae91721187b2c3222d36a4c20aed7778cadd6832d966b460787ecb5c622478"

URI_aarch64_f42-backgrounds-budgie = "${EPEL_MIRROR}/aarch64/Packages/f/f42-backgrounds-budgie-42.0.0-4.el10_1.noarch.rpm;name=aarch64_f42-backgrounds-budgie;unpack=0"
SRC_URI:append = " ${URI_aarch64_f42-backgrounds-budgie}"
SRC_URI[aarch64_f42-backgrounds-budgie.sha256sum] = "d16d653382914d8dc448c7bbda275aba366adc45e403c62391e9d03b6a3b1378"

URI_aarch64_f42-backgrounds-gnome = "${EPEL_MIRROR}/aarch64/Packages/f/f42-backgrounds-gnome-42.0.0-4.el10_1.noarch.rpm;name=aarch64_f42-backgrounds-gnome;unpack=0"
SRC_URI:append = " ${URI_aarch64_f42-backgrounds-gnome}"
SRC_URI[aarch64_f42-backgrounds-gnome.sha256sum] = "1339361c1329a3a133e049cb575a0c59a57aa2056654a9d874d75743cfc4f274"

URI_aarch64_f42-backgrounds-kde = "${EPEL_MIRROR}/aarch64/Packages/f/f42-backgrounds-kde-42.0.0-4.el10_1.noarch.rpm;name=aarch64_f42-backgrounds-kde;unpack=0"
SRC_URI:append = " ${URI_aarch64_f42-backgrounds-kde}"
SRC_URI[aarch64_f42-backgrounds-kde.sha256sum] = "7c58c75803e427ccffd7e03ff1f956d7526b861a43d5386d2b9a5072d5351a3b"

URI_aarch64_f42-backgrounds-mate = "${EPEL_MIRROR}/aarch64/Packages/f/f42-backgrounds-mate-42.0.0-4.el10_1.noarch.rpm;name=aarch64_f42-backgrounds-mate;unpack=0"
SRC_URI:append = " ${URI_aarch64_f42-backgrounds-mate}"
SRC_URI[aarch64_f42-backgrounds-mate.sha256sum] = "2d9cd86273bebe36f7fee2a04b0253391276deeb3ea5846e6e1cf6e98d7b749d"

URI_aarch64_f42-backgrounds-xfce = "${EPEL_MIRROR}/aarch64/Packages/f/f42-backgrounds-xfce-42.0.0-4.el10_1.noarch.rpm;name=aarch64_f42-backgrounds-xfce;unpack=0"
SRC_URI:append = " ${URI_aarch64_f42-backgrounds-xfce}"
SRC_URI[aarch64_f42-backgrounds-xfce.sha256sum] = "008dd88bc8bf2eb4e8b7ab3247e357f1067662c5c19fd0967c51a3bdd60cbc0b"

RDEPENDS:f42-backgrounds = " \
 f42-backgrounds-budgie \
 f42-backgrounds-gnome \
 f42-backgrounds-kde \
 f42-backgrounds-mate \
 f42-backgrounds-xfce \
 "
RDEPENDS:f42-backgrounds-base = " \
 jxl-pixbuf-loader \
 kf6-kimageformats \
 "
RDEPENDS:f42-backgrounds-budgie = " \
 f42-backgrounds-base \
 "
RDEPENDS:f42-backgrounds-gnome = " \
 f42-backgrounds-base \
 "
RDEPENDS:f42-backgrounds-kde = " \
 f42-backgrounds-base \
 kde-filesystem \
 "
RDEPENDS:f42-backgrounds-mate = " \
 f42-backgrounds-base \
 "
RDEPENDS:f42-backgrounds-xfce = " \
 f42-backgrounds-base \
 "
