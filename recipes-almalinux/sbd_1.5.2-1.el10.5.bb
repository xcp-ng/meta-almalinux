# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sbd"
PV = "1.5.2"
PR = "1.el10.5"
PACKAGES = " \
 sbd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/sbd-1.5.2-1.el10.5.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ee905b192911bdb909c69a39bb546149f17783ba149b0f74afe02f4cc5b8965"

URI_x86_64_v2_sbd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sbd-1.5.2-1.el10.5.x86_64_v2.rpm;name=x86_64_v2_sbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sbd}"
SRC_URI[x86_64_v2_sbd.sha256sum] = "6f37642ae3cc2cb9b597e43d2fe4cfef1289c99fbe55f3574000b8f377c6a423"

URI_aarch64_sbd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sbd-1.5.2-1.el10.5.aarch64.rpm;name=aarch64_sbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_sbd}"
SRC_URI[aarch64_sbd.sha256sum] = "9c35b2d4bb79439077f5b308f0191fac6a290f254df3bbe6190093b62d4ad62b"

RDEPENDS:sbd = " \
 bash \
 corosynclib \
 glib2 \
 glibc \
 libaio \
 libqb \
 libuuid \
 pacemaker-cluster-libs \
 pacemaker-libs \
 pkgconf-pkg-config \
 systemd \
 "
