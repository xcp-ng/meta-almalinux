# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkcompactdisc"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 libkcompactdisc \
 libkcompactdisc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkcompactdisc-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78090da026bc0f7d8f835ea37ddf9846f0bd44eadcd41154eb756a66b20bf567"

URI_x86_64_v2_libkcompactdisc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkcompactdisc-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkcompactdisc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkcompactdisc}"
SRC_URI[x86_64_v2_libkcompactdisc.sha256sum] = "6390657404da7fcbb3e215ebd77822c095398d231904fe87d1cdb3b604fbcc43"

URI_x86_64_v2_libkcompactdisc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkcompactdisc-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkcompactdisc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkcompactdisc-devel}"
SRC_URI[x86_64_v2_libkcompactdisc-devel.sha256sum] = "b3ae3ada0f3bc7dd6ae4de3caee6b34874f176560a0a7e2d25b02db4165ade81"

URI_aarch64_libkcompactdisc = "${EPEL_MIRROR}/aarch64/Packages/l/libkcompactdisc-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_libkcompactdisc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkcompactdisc}"
SRC_URI[aarch64_libkcompactdisc.sha256sum] = "96a077cc0b3586b04e18ad0d1307b392fd78a58688ffbfd1678ab651738e9126"

URI_aarch64_libkcompactdisc-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkcompactdisc-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_libkcompactdisc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkcompactdisc-devel}"
SRC_URI[aarch64_libkcompactdisc-devel.sha256sum] = "6f00e33b6cc93f09376b068c84c2cb4a7342c733f4dfd68c23d8bb823d4f0339"

RDEPENDS:libkcompactdisc = " \
 alsa-lib \
 glibc \
 kf6-ki18n \
 kf6-solid \
 libstdc++ \
 phonon-qt6 \
 qt6-qtbase \
 "
RDEPENDS:libkcompactdisc-devel = " \
 cmake-filesystem \
 libkcompactdisc \
 "
