# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-brotli-decompressor"
PV = "5.0.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-brotli-decompressor+alloc-stdlib-devel \
 rust-brotli-decompressor+default-devel \
 rust-brotli-decompressor+disable-timer-devel \
 rust-brotli-decompressor+ffi-api-devel \
 rust-brotli-decompressor+pass-through-ffi-panics-devel \
 rust-brotli-decompressor+seccomp-devel \
 rust-brotli-decompressor+std-devel \
 rust-brotli-decompressor+unsafe-devel \
 rust-brotli-decompressor-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-brotli-decompressor-5.0.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3dc1b60e6cd44dd551604948b5cad1eaa125d9c2b8794f00341ccb2907b2af45"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+alloc-stdlib-devel-5.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+alloc-stdlib-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli-decompressor+alloc-stdlib-devel.sha256sum] = "46c054c9ebd8ad327c986b988cee4d5ffff8e9a943e24ba51445423ae4bd0ecb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+default-devel-5.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli-decompressor+default-devel.sha256sum] = "a0606ff5ec07649ebafd07ba44e0677ec9d7b17e6e9c114d2f49a7a896e708a6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+disable-timer-devel-5.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+disable-timer-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli-decompressor+disable-timer-devel.sha256sum] = "c9c765d854b13ecdeb63960dd7f94cb74915463b72378203e47aa1a29aa445fd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+ffi-api-devel-5.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+ffi-api-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli-decompressor+ffi-api-devel.sha256sum] = "63038575490425c51e56d73a60c15e1e70fe4e0b0d429f731dfbfe748bbaa497"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+pass-through-ffi-panics-devel-5.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+pass-through-ffi-panics-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli-decompressor+pass-through-ffi-panics-devel.sha256sum] = "202e6b5054de42c79e94b56611db825b4a78adfcfdbe7a5b13acd3672d67e1f2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+seccomp-devel-5.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+seccomp-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli-decompressor+seccomp-devel.sha256sum] = "322c00e670815321c46f5c36c8a710c49df0862a0781f1db93bf4865c245904b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+std-devel-5.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli-decompressor+std-devel.sha256sum] = "428ad5d92fa6fa6514c1ed23203a2e1600209618a24be5c08d2b45da52ac39f0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+unsafe-devel-5.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+unsafe-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli-decompressor+unsafe-devel.sha256sum] = "b878b4df6fa9379c3f8c9209515ae0df491bab122c9274c24526e96b3346d973"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor-devel-5.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli-decompressor-devel.sha256sum] = "bf03728a7d7efd5b8b767c506975ea3bb7d59bb7c2d89d687554857a39e36c31"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+alloc-stdlib-devel-5.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-brotli-decompressor+alloc-stdlib-devel;unpack=0"
SRC_URI[aarch64_rust-brotli-decompressor+alloc-stdlib-devel.sha256sum] = "96e56581ef1f16a51ce347b19422823bda659611bc8de96c65bfb158d086fb0b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+default-devel-5.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-brotli-decompressor+default-devel;unpack=0"
SRC_URI[aarch64_rust-brotli-decompressor+default-devel.sha256sum] = "6919a55991e94f3989d8a8926683cb08326c927e81014348df35d5c0427a373d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+disable-timer-devel-5.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-brotli-decompressor+disable-timer-devel;unpack=0"
SRC_URI[aarch64_rust-brotli-decompressor+disable-timer-devel.sha256sum] = "7f166bed54cf065f344561966eb6fe3755b38b79fb391333f167d3d6626f5bdb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+ffi-api-devel-5.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-brotli-decompressor+ffi-api-devel;unpack=0"
SRC_URI[aarch64_rust-brotli-decompressor+ffi-api-devel.sha256sum] = "84ec805d4a84f3f6a14be9dc16c7f34a538efdb444bec00cc9b9e7290a2abfea"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+pass-through-ffi-panics-devel-5.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-brotli-decompressor+pass-through-ffi-panics-devel;unpack=0"
SRC_URI[aarch64_rust-brotli-decompressor+pass-through-ffi-panics-devel.sha256sum] = "71a2335947a759f9449de8480644fd72415d6e38ddc3375d47048f8340567375"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+seccomp-devel-5.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-brotli-decompressor+seccomp-devel;unpack=0"
SRC_URI[aarch64_rust-brotli-decompressor+seccomp-devel.sha256sum] = "efa0dbd5f5e4a2419c93ed993554e8d891b21291b855152f11ff18951659802a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+std-devel-5.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-brotli-decompressor+std-devel;unpack=0"
SRC_URI[aarch64_rust-brotli-decompressor+std-devel.sha256sum] = "93a79e6eb9a523d638be135017559830eb5d33f337fcb156f8945dccff7cde43"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+unsafe-devel-5.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-brotli-decompressor+unsafe-devel;unpack=0"
SRC_URI[aarch64_rust-brotli-decompressor+unsafe-devel.sha256sum] = "1ce4ffcda507a5c53e3b9f1cd7a627a56e8721628e9f973003fe6c8b3b8dfad8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor-devel-5.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-brotli-decompressor-devel;unpack=0"
SRC_URI[aarch64_rust-brotli-decompressor-devel.sha256sum] = "b4b2a9fb18bae05464c887f68b03b1ee319434846c8e964d22fe615131ca7c96"

RDEPENDS:rust-brotli-decompressor+alloc-stdlib-devel = " \
 cargo \
 rust-alloc-stdlib+default-devel \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+default-devel = " \
 cargo \
 rust-brotli-decompressor+std-devel \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+disable-timer-devel = " \
 cargo \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+ffi-api-devel = " \
 cargo \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+pass-through-ffi-panics-devel = " \
 cargo \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+seccomp-devel = " \
 cargo \
 rust-alloc-no-stdlib+unsafe-devel \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+std-devel = " \
 cargo \
 rust-brotli-decompressor+alloc-stdlib-devel \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+unsafe-devel = " \
 cargo \
 rust-alloc-no-stdlib+unsafe-devel \
 rust-alloc-stdlib+default-devel \
 rust-alloc-stdlib+unsafe-devel \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor-devel = " \
 cargo \
 rust-alloc-no-stdlib+default-devel \
 "
