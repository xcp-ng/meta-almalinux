# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pnet_sys"
PV = "0.35.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-pnet_sys+default-devel \
 rust-pnet_sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pnet_sys-0.35.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c5525c485515e2765b820dcb67ec0ff033fbd4c6978fd50af72b2b4dbaf0982b"

URI_x86_64_v2_rust-pnet_sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pnet_sys+default-devel-0.35.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pnet_sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pnet_sys+default-devel}"
SRC_URI[x86_64_v2_rust-pnet_sys+default-devel.sha256sum] = "87610d507fad2b1494fc17b6e0bb56dbf7b01ae46eb39051b1c696a4e5926b6f"

URI_x86_64_v2_rust-pnet_sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pnet_sys-devel-0.35.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pnet_sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pnet_sys-devel}"
SRC_URI[x86_64_v2_rust-pnet_sys-devel.sha256sum] = "e65cb556c46d615c1dc2a1e0b377ebe9da9c76ac1d41bda095d9a997cb89a72a"

URI_aarch64_rust-pnet_sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pnet_sys+default-devel-0.35.0-1.el10_1.noarch.rpm;name=aarch64_rust-pnet_sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pnet_sys+default-devel}"
SRC_URI[aarch64_rust-pnet_sys+default-devel.sha256sum] = "8dec0d9d47e33fbb710343497890402be74eeaad90c87e9b8571dc309aa3c459"

URI_aarch64_rust-pnet_sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pnet_sys-devel-0.35.0-1.el10_1.noarch.rpm;name=aarch64_rust-pnet_sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pnet_sys-devel}"
SRC_URI[aarch64_rust-pnet_sys-devel.sha256sum] = "545bf313a9d43d17d90cffb52797cb84dfcee91c402e64c7ae1642cc95b8b7f8"

RDEPENDS:rust-pnet_sys+default-devel = " \
 cargo \
 rust-pnet_sys-devel \
 "
RDEPENDS:rust-pnet_sys-devel = " \
 cargo \
 rust-libc+default-devel \
 "
