# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ngtcp2"
PV = "1.22.1"
PR = "1.el10_3"
PACKAGES = " \
 ngtcp2 \
 ngtcp2-crypto-gnutls \
 ngtcp2-crypto-gnutls-devel \
 ngtcp2-crypto-ossl \
 ngtcp2-crypto-ossl-devel \
 ngtcp2-devel \
 ngtcp2-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/ngtcp2-1.22.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a1e3b17ed3a41824d85937b05f388a6595fd77f0d8de050d4d5a7a01af3b2e31"

URI_x86_64_v2_ngtcp2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ngtcp2-1.22.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ngtcp2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ngtcp2}"
SRC_URI[x86_64_v2_ngtcp2.sha256sum] = "3310613e0a6aa9774ed7240adcf89e7452856cc40f6d94a70dcdda94b9e5e24d"

URI_x86_64_v2_ngtcp2-crypto-gnutls = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ngtcp2-crypto-gnutls-1.22.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ngtcp2-crypto-gnutls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ngtcp2-crypto-gnutls}"
SRC_URI[x86_64_v2_ngtcp2-crypto-gnutls.sha256sum] = "a00c997a0800432ab881a65f533610c61f1bb107cb196acb2cc9ccd1c6ff15a3"

URI_x86_64_v2_ngtcp2-crypto-gnutls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ngtcp2-crypto-gnutls-devel-1.22.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ngtcp2-crypto-gnutls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ngtcp2-crypto-gnutls-devel}"
SRC_URI[x86_64_v2_ngtcp2-crypto-gnutls-devel.sha256sum] = "ca2aa8ae1a3c698075c454bb5959ff78eb479553c6b7542328adc11f42cf71ce"

URI_x86_64_v2_ngtcp2-crypto-ossl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ngtcp2-crypto-ossl-1.22.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ngtcp2-crypto-ossl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ngtcp2-crypto-ossl}"
SRC_URI[x86_64_v2_ngtcp2-crypto-ossl.sha256sum] = "30610f5d2454a51dd31e93e51addade49c3da83057419af46316033bdf95fd82"

URI_x86_64_v2_ngtcp2-crypto-ossl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ngtcp2-crypto-ossl-devel-1.22.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ngtcp2-crypto-ossl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ngtcp2-crypto-ossl-devel}"
SRC_URI[x86_64_v2_ngtcp2-crypto-ossl-devel.sha256sum] = "e407e7d4e1e892846cf236a1f0850d5ed61921133e954f4a0d08e2df9fdda878"

URI_x86_64_v2_ngtcp2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ngtcp2-devel-1.22.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ngtcp2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ngtcp2-devel}"
SRC_URI[x86_64_v2_ngtcp2-devel.sha256sum] = "95a901781ed6614930b8ff30b9ada1c652fc445b6c1070ce2a3b3632894aa2e3"

URI_x86_64_v2_ngtcp2-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ngtcp2-doc-1.22.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ngtcp2-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ngtcp2-doc}"
SRC_URI[x86_64_v2_ngtcp2-doc.sha256sum] = "ddb37ec655c2e12a5be24ff0ea018c6f85f7abab00a4abb4bee2e598b243a2ee"

URI_aarch64_ngtcp2 = "${EPEL_MIRROR}/aarch64/Packages/n/ngtcp2-1.22.1-1.el10_3.aarch64.rpm;name=aarch64_ngtcp2;unpack=0"
SRC_URI:append = " ${URI_aarch64_ngtcp2}"
SRC_URI[aarch64_ngtcp2.sha256sum] = "34f9a4f60696e6f25253ec7f6c6947c8ec3be9d66f01c2f9cae25df7864d72dc"

URI_aarch64_ngtcp2-crypto-gnutls = "${EPEL_MIRROR}/aarch64/Packages/n/ngtcp2-crypto-gnutls-1.22.1-1.el10_3.aarch64.rpm;name=aarch64_ngtcp2-crypto-gnutls;unpack=0"
SRC_URI:append = " ${URI_aarch64_ngtcp2-crypto-gnutls}"
SRC_URI[aarch64_ngtcp2-crypto-gnutls.sha256sum] = "9f27679818ebcdbe071040e3e8b7acea00c88dd233e2e87f73f35f7fcf17ab02"

URI_aarch64_ngtcp2-crypto-gnutls-devel = "${EPEL_MIRROR}/aarch64/Packages/n/ngtcp2-crypto-gnutls-devel-1.22.1-1.el10_3.aarch64.rpm;name=aarch64_ngtcp2-crypto-gnutls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ngtcp2-crypto-gnutls-devel}"
SRC_URI[aarch64_ngtcp2-crypto-gnutls-devel.sha256sum] = "19d41d6c44ea91bd83518216ed021097d293941cae49dbd2c2e7313066651f62"

URI_aarch64_ngtcp2-crypto-ossl = "${EPEL_MIRROR}/aarch64/Packages/n/ngtcp2-crypto-ossl-1.22.1-1.el10_3.aarch64.rpm;name=aarch64_ngtcp2-crypto-ossl;unpack=0"
SRC_URI:append = " ${URI_aarch64_ngtcp2-crypto-ossl}"
SRC_URI[aarch64_ngtcp2-crypto-ossl.sha256sum] = "d46d45980cccc2d66cdda6dc5232fb0c3e2dfefab09f81080db0fd3d5e7a618e"

URI_aarch64_ngtcp2-crypto-ossl-devel = "${EPEL_MIRROR}/aarch64/Packages/n/ngtcp2-crypto-ossl-devel-1.22.1-1.el10_3.aarch64.rpm;name=aarch64_ngtcp2-crypto-ossl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ngtcp2-crypto-ossl-devel}"
SRC_URI[aarch64_ngtcp2-crypto-ossl-devel.sha256sum] = "914331dd76f868d3e54ab9dadc6e1312ccbb7e9e2b823a8303d63f2d79d199bc"

URI_aarch64_ngtcp2-devel = "${EPEL_MIRROR}/aarch64/Packages/n/ngtcp2-devel-1.22.1-1.el10_3.aarch64.rpm;name=aarch64_ngtcp2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ngtcp2-devel}"
SRC_URI[aarch64_ngtcp2-devel.sha256sum] = "bb0ae8fc8f6fc709f90adda1c0ba21bc128ef2624f3e6dc1c01cc3ab2cb6e302"

URI_aarch64_ngtcp2-doc = "${EPEL_MIRROR}/aarch64/Packages/n/ngtcp2-doc-1.22.1-1.el10_3.noarch.rpm;name=aarch64_ngtcp2-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ngtcp2-doc}"
SRC_URI[aarch64_ngtcp2-doc.sha256sum] = "e9e65f13eac77c64666c31fcdd94821971ae141dd681955e510ec8569aafe858"

RDEPENDS:ngtcp2 = " \
 glibc \
 "
RDEPENDS:ngtcp2-crypto-gnutls = " \
 glibc \
 gnutls \
 ngtcp2 \
 "
RDEPENDS:ngtcp2-crypto-gnutls-devel = " \
 gnutls-devel \
 ngtcp2 \
 ngtcp2-crypto-gnutls \
 ngtcp2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:ngtcp2-crypto-ossl = " \
 glibc \
 ngtcp2 \
 openssl-libs \
 "
RDEPENDS:ngtcp2-crypto-ossl-devel = " \
 ngtcp2-crypto-ossl \
 ngtcp2-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:ngtcp2-devel = " \
 ngtcp2 \
 pkgconf-pkg-config \
 "
RDEPENDS:ngtcp2-doc = " \
 ngtcp2 \
 "
