# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ocean-sound-theme"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 ocean-sound-theme \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/o/ocean-sound-theme-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3ed3a9204dbfef06bac03d40db7e2f43e18a0d195be4567553494cb3fde85f85"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ocean-sound-theme-6.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ocean-sound-theme;unpack=0"
SRC_URI[x86_64_v2_ocean-sound-theme.sha256sum] = "6ce2472a60bc9de6d512a6bd4dac41e81ce73faa0512a6972d04e0a883f659d2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/ocean-sound-theme-6.7.5-1.el10_3.noarch.rpm;name=aarch64_ocean-sound-theme;unpack=0"
SRC_URI[aarch64_ocean-sound-theme.sha256sum] = "00f24dd6c900158cc2ff246e533c178e79501d917fb36b1705ce1da3bd5a921a"

RDEPENDS:ocean-sound-theme = " \
 kf6-filesystem \
 "
