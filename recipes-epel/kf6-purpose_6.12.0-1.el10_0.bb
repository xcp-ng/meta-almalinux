# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-purpose"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-purpose \
 kf6-purpose-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-purpose-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4d0464e76960c7009e24c72522fe06d9fa410896e64e5d9637e228e73ffc7c3d"

URI_x86_64_v2_kf6-purpose = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-purpose-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-purpose;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-purpose}"
SRC_URI[x86_64_v2_kf6-purpose.sha256sum] = "40e66b26618840a7cc042ad485135ed1f4a568a4926710d4eb1e8caee1b7c7a1"

URI_x86_64_v2_kf6-purpose-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-purpose-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-purpose-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-purpose-devel}"
SRC_URI[x86_64_v2_kf6-purpose-devel.sha256sum] = "0ab417c55d04c8141215c053b816aaae5d8bf25d376f6e7ab48e6c121605c57a"

URI_aarch64_kf6-purpose = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-purpose-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-purpose;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-purpose}"
SRC_URI[aarch64_kf6-purpose.sha256sum] = "22c6009cd743cee17a2619bd799ccdb8e97810b506d6df4b5ed7bd0bd4d4d92a"

URI_aarch64_kf6-purpose-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-purpose-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-purpose-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-purpose-devel}"
SRC_URI[aarch64_kf6-purpose-devel.sha256sum] = "4c6b97b832ed01291b7c61072e558318fc24c35b36662370b57af31982bf11e5"

RDEPENDS:kf6-purpose = " \
 accounts-qml-module-qt6 \
 glibc \
 hicolor-icon-theme \
 kaccounts-integration-qt6 \
 kf6-bluez-qt \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdeclarative \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-kservice \
 kf6-prison \
 libaccounts-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-purpose-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kf6-purpose \
 "
