# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "PEGTL"
PV = "2.8.3"
PR = "11.el10_2"
PACKAGES = " \
 PEGTL-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/PEGTL-2.8.3-11.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6896a3c74ca649ec8c37ded3a85d84119f24ec6f263e2df7ee1235aa8fcc128"

URI_x86_64_v2_PEGTL-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/PEGTL-devel-2.8.3-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_PEGTL-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_PEGTL-devel}"
SRC_URI[x86_64_v2_PEGTL-devel.sha256sum] = "35ef65357adeff383cb9d2f412d21a0dab2d4a4d0c302e937a7fbc555598ab2f"

URI_aarch64_PEGTL-devel = "${EPEL_MIRROR}/aarch64/Packages/p/PEGTL-devel-2.8.3-11.el10_2.aarch64.rpm;name=aarch64_PEGTL-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_PEGTL-devel}"
SRC_URI[aarch64_PEGTL-devel.sha256sum] = "d6254055c4ba29becdaa0815d38c69362a33ed4786518f3edefa3b8366e5932c"

RDEPENDS:PEGTL-devel = " \
 cmake-filesystem \
 libstdc++-devel \
 "
