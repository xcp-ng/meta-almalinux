# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-File-Copy-Recursive-Reduced"
PV = "0.008"
PR = "2.el10_0"
PACKAGES = " \
 perl-File-Copy-Recursive-Reduced \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-File-Copy-Recursive-Reduced-0.008-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b69a3dc70d6d7fc3b8f3e763a938fa899a4a9e149275e44cbf92c01bb5611aa"

URI_x86_64_v2_perl-File-Copy-Recursive-Reduced = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-File-Copy-Recursive-Reduced-0.008-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-File-Copy-Recursive-Reduced;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-Copy-Recursive-Reduced}"
SRC_URI[x86_64_v2_perl-File-Copy-Recursive-Reduced.sha256sum] = "f884cdf316d03c1d75fd0f36b4352ebd2569f455bf91117c8c63059c356991fb"

URI_aarch64_perl-File-Copy-Recursive-Reduced = "${EPEL_MIRROR}/aarch64/Packages/p/perl-File-Copy-Recursive-Reduced-0.008-2.el10_0.noarch.rpm;name=aarch64_perl-File-Copy-Recursive-Reduced;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-Copy-Recursive-Reduced}"
SRC_URI[aarch64_perl-File-Copy-Recursive-Reduced.sha256sum] = "5f76a1f6edca97cde118d8171a318d301692f0f984cff785558ef012276225c9"

RDEPENDS:perl-File-Copy-Recursive-Reduced = " \
 perl-Exporter \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-PathTools \
 perl-libs \
 perl-parent \
 "
