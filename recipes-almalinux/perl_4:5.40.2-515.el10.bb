# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl"
PE = "4"
PV = "5.40.2"
PR = "515.el10"
PACKAGES = " \
 perl \
 perl-Attribute-Handlers \
 perl-AutoLoader \
 perl-AutoSplit \
 perl-B \
 perl-Benchmark \
 perl-Class-Struct \
 perl-Config-Extensions \
 perl-DBM_Filter \
 perl-Devel-Peek \
 perl-Devel-SelfStubber \
 perl-DirHandle \
 perl-Dumpvalue \
 perl-DynaLoader \
 perl-English \
 perl-Errno \
 perl-ExtUtils-Constant \
 perl-ExtUtils-Embed \
 perl-ExtUtils-Miniperl \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Compare \
 perl-File-Copy \
 perl-File-DosGlob \
 perl-File-Find \
 perl-File-stat \
 perl-FileCache \
 perl-FileHandle \
 perl-FindBin \
 perl-GDBM_File \
 perl-Getopt-Std \
 perl-Hash-Util \
 perl-Hash-Util-FieldHash \
 perl-I18N-Collate \
 perl-I18N-LangTags \
 perl-I18N-Langinfo \
 perl-IO \
 perl-IPC-Open3 \
 perl-Locale-Maketext-Simple \
 perl-Math-Complex \
 perl-Memoize \
 perl-Module-Loaded \
 perl-NDBM_File \
 perl-NEXT \
 perl-Net \
 perl-ODBM_File \
 perl-Opcode \
 perl-POSIX \
 perl-Pod-Functions \
 perl-Pod-Html \
 perl-Safe \
 perl-Search-Dict \
 perl-SelectSaver \
 perl-SelfLoader \
 perl-Symbol \
 perl-Sys-Hostname \
 perl-Term-Complete \
 perl-Term-ReadLine \
 perl-Test \
 perl-Text-Abbrev \
 perl-Thread \
 perl-Thread-Semaphore \
 perl-Tie \
 perl-Tie-File \
 perl-Tie-Memoize \
 perl-Time \
 perl-Time-Piece \
 perl-Unicode-UCD \
 perl-User-pwent \
 perl-autouse \
 perl-base \
 perl-blib \
 perl-debugger \
 perl-deprecate \
 perl-devel \
 perl-diagnostics \
 perl-doc \
 perl-encoding-warnings \
 perl-fields \
 perl-filetest \
 perl-if \
 perl-interpreter \
 perl-less \
 perl-lib \
 perl-libnetcfg \
 perl-libs \
 perl-locale \
 perl-macros \
 perl-meta-notation \
 perl-mro \
 perl-open \
 perl-overload \
 perl-overloading \
 perl-ph \
 perl-sigtrap \
 perl-sort \
 perl-subs \
 perl-utils \
 perl-vars \
 perl-vmsish \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-5.40.2-515.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "67f2a4b29715367bb909f8a496935341901707b761047410bc68e139e0f33a32"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-5.40.2-515.el10.x86_64_v2.rpm;name=x86_64_v2_perl;unpack=0"
SRC_URI[x86_64_v2_perl.sha256sum] = "f8546e41bfef5d31e46fc8a41a8e291ab5dba6136696ef63d102cadb639af90d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Attribute-Handlers-1.03-515.el10.noarch.rpm;name=x86_64_v2_perl-Attribute-Handlers;unpack=0"
SRC_URI[x86_64_v2_perl-Attribute-Handlers.sha256sum] = "359d38984ff9a0795be3a44f3c0c9b619c63b6a69c346f76248c3b8413f78cdc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-AutoLoader-5.74-515.el10.noarch.rpm;name=x86_64_v2_perl-AutoLoader;unpack=0"
SRC_URI[x86_64_v2_perl-AutoLoader.sha256sum] = "414300808ed9a3b617b4f3c09ade73d6e8cd0ab2c560753acf73305f24d8910b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-AutoSplit-5.74-515.el10.noarch.rpm;name=x86_64_v2_perl-AutoSplit;unpack=0"
SRC_URI[x86_64_v2_perl-AutoSplit.sha256sum] = "37f413964e1fbe92ad64ebafe4fd4d974c0d8af90294fdb2e14838070ad56594"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-B-1.89-515.el10.x86_64_v2.rpm;name=x86_64_v2_perl-B;unpack=0"
SRC_URI[x86_64_v2_perl-B.sha256sum] = "46643aa7768d467c2ce5ae900790f258c1b1dbd0a7efb9f7f22b05ac3de55a88"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Benchmark-1.25-515.el10.noarch.rpm;name=x86_64_v2_perl-Benchmark;unpack=0"
SRC_URI[x86_64_v2_perl-Benchmark.sha256sum] = "590a5fd3185b16315e95141c968046d40e0cb1a55729f42299a5e771329a5253"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Class-Struct-0.68-515.el10.noarch.rpm;name=x86_64_v2_perl-Class-Struct;unpack=0"
SRC_URI[x86_64_v2_perl-Class-Struct.sha256sum] = "a188af2accd5302d4022be6373c9e5bb4d0e7cb3c9a830156cbb987b1569f4ad"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Config-Extensions-0.03-515.el10.noarch.rpm;name=x86_64_v2_perl-Config-Extensions;unpack=0"
SRC_URI[x86_64_v2_perl-Config-Extensions.sha256sum] = "bed12ab20561e35257dfdc739f600579014988f5ddd053840918b6af4a78999d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-DBM_Filter-0.06-515.el10.noarch.rpm;name=x86_64_v2_perl-DBM_Filter;unpack=0"
SRC_URI[x86_64_v2_perl-DBM_Filter.sha256sum] = "9e646dcd54c6dec017fe9be5d661463c12cb24bf7f9eeb12aa36fb06151517df"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Devel-Peek-1.34-515.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Devel-Peek;unpack=0"
SRC_URI[x86_64_v2_perl-Devel-Peek.sha256sum] = "d2e3a971d45182fd42ae35b811efe4aebad0fc661661feefd4fa4fe929ef46c4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Devel-SelfStubber-1.06-515.el10.noarch.rpm;name=x86_64_v2_perl-Devel-SelfStubber;unpack=0"
SRC_URI[x86_64_v2_perl-Devel-SelfStubber.sha256sum] = "6a9686cb89b0768290fb49c70a97fdfdb75601f7be93e04e9f8d8f66974b2074"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-DirHandle-1.05-515.el10.noarch.rpm;name=x86_64_v2_perl-DirHandle;unpack=0"
SRC_URI[x86_64_v2_perl-DirHandle.sha256sum] = "cbcea6168766c354327557d606fdb4814fea3a71380f2d98d892aa383bf0e055"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Dumpvalue-2.27-515.el10.noarch.rpm;name=x86_64_v2_perl-Dumpvalue;unpack=0"
SRC_URI[x86_64_v2_perl-Dumpvalue.sha256sum] = "c214b0f92471721e2acaa54c95b2cdcb99b99589c06cb7c47af5e5b4cd02f40a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-DynaLoader-1.56-515.el10.x86_64_v2.rpm;name=x86_64_v2_perl-DynaLoader;unpack=0"
SRC_URI[x86_64_v2_perl-DynaLoader.sha256sum] = "7e55b9664010bff366ae70558983c3fa7a7405336ff43cfb329d4d590b2f2511"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-English-1.11-515.el10.noarch.rpm;name=x86_64_v2_perl-English;unpack=0"
SRC_URI[x86_64_v2_perl-English.sha256sum] = "bd5c764ac0fd67547ac0b83677b8a79e37affe7180d6dec5e0a9f95b0f1751ac"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Errno-1.38-515.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Errno;unpack=0"
SRC_URI[x86_64_v2_perl-Errno.sha256sum] = "0ca1d47e69f2b572eda285b56b4269402dd163f8bf731d6c435ec2c82641f089"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-ExtUtils-Constant-0.25-515.el10.noarch.rpm;name=x86_64_v2_perl-ExtUtils-Constant;unpack=0"
SRC_URI[x86_64_v2_perl-ExtUtils-Constant.sha256sum] = "90f242d825565e8392ac968fd6ee88ef34e9228b26cb4c10626f001a699326c8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-ExtUtils-Embed-1.35-515.el10.noarch.rpm;name=x86_64_v2_perl-ExtUtils-Embed;unpack=0"
SRC_URI[x86_64_v2_perl-ExtUtils-Embed.sha256sum] = "8a0ba2799bb6d76ae3a4014a7471bab18ffa5699f5d1fc18549a3dc474f21dfb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-ExtUtils-Miniperl-1.14-515.el10.noarch.rpm;name=x86_64_v2_perl-ExtUtils-Miniperl;unpack=0"
SRC_URI[x86_64_v2_perl-ExtUtils-Miniperl.sha256sum] = "81579a96839bee747e94f089bdeec893668b9a213586bcdb6bf96f81271270e7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Fcntl-1.18-515.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Fcntl;unpack=0"
SRC_URI[x86_64_v2_perl-Fcntl.sha256sum] = "f1b38be7cfbad424970d74789c86b8475926e9bc4ddb75ee00c6bdb20d3c8e76"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-File-Basename-2.86-515.el10.noarch.rpm;name=x86_64_v2_perl-File-Basename;unpack=0"
SRC_URI[x86_64_v2_perl-File-Basename.sha256sum] = "38096d3e54e33a8a0d91f3bdd4a965c63b0c6a8edfb22db583e0cc2e4983e01b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-File-Compare-1.100.800-515.el10.noarch.rpm;name=x86_64_v2_perl-File-Compare;unpack=0"
SRC_URI[x86_64_v2_perl-File-Compare.sha256sum] = "eba6a5da6d3e33f7d1bc710733969265f751b65bc1ea3006dab12817ce610362"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-File-Copy-2.41-515.el10.noarch.rpm;name=x86_64_v2_perl-File-Copy;unpack=0"
SRC_URI[x86_64_v2_perl-File-Copy.sha256sum] = "8c37e19c16def237f2dc7858d0a010c53902286ac0af34d218fb7aa7329ed538"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-File-DosGlob-1.12-515.el10.x86_64_v2.rpm;name=x86_64_v2_perl-File-DosGlob;unpack=0"
SRC_URI[x86_64_v2_perl-File-DosGlob.sha256sum] = "d70e18735d6c2e697eb369549f4fde593c939e5d177aa9c2fe07debc06563a39"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-File-Find-1.44-515.el10.noarch.rpm;name=x86_64_v2_perl-File-Find;unpack=0"
SRC_URI[x86_64_v2_perl-File-Find.sha256sum] = "5a3d540373a0956797aa7a5928311f70676d2c00a74a51edaa42e4a11f46f96f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-File-stat-1.14-515.el10.noarch.rpm;name=x86_64_v2_perl-File-stat;unpack=0"
SRC_URI[x86_64_v2_perl-File-stat.sha256sum] = "8422e8e65be3c542c5f58de6303d988595400a6f444d01773f663e14bd5267a5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-FileCache-1.10-515.el10.noarch.rpm;name=x86_64_v2_perl-FileCache;unpack=0"
SRC_URI[x86_64_v2_perl-FileCache.sha256sum] = "7336ac36f60cd3a01bdc6a13a8ba5eb3bdd8d1cfe2e3ad49b5cfafdb733b1d3c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-FileHandle-2.05-515.el10.noarch.rpm;name=x86_64_v2_perl-FileHandle;unpack=0"
SRC_URI[x86_64_v2_perl-FileHandle.sha256sum] = "3bc687766811ae72d9d11f541fdaed076b006d4fead333593abe5b2acd5580d4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-FindBin-1.54-515.el10.noarch.rpm;name=x86_64_v2_perl-FindBin;unpack=0"
SRC_URI[x86_64_v2_perl-FindBin.sha256sum] = "ba3303a11544212ee28beaf73d7af0b68bce97f97d9dd46abebb5d4b2b443389"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-GDBM_File-1.24-515.el10.x86_64_v2.rpm;name=x86_64_v2_perl-GDBM_File;unpack=0"
SRC_URI[x86_64_v2_perl-GDBM_File.sha256sum] = "e6d3427fba072f529e99e1926389a19709d96ba751e6c9de8276940e33a963e2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Getopt-Std-1.14-515.el10.noarch.rpm;name=x86_64_v2_perl-Getopt-Std;unpack=0"
SRC_URI[x86_64_v2_perl-Getopt-Std.sha256sum] = "3605568682759202fb40765654af6308932662329d74306c9c4e76741a49c153"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Hash-Util-0.32-515.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Hash-Util;unpack=0"
SRC_URI[x86_64_v2_perl-Hash-Util.sha256sum] = "8b58a9fccb5d453a2358e7e00bbaa28fc74dec301ee62aecb5a59a5fa73e41ef"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Hash-Util-FieldHash-1.27-515.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Hash-Util-FieldHash;unpack=0"
SRC_URI[x86_64_v2_perl-Hash-Util-FieldHash.sha256sum] = "2678eecd2b6a6c652527aad72749c6fb7b63c88c25bde291d865216f2aa22116"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-I18N-Collate-1.02-515.el10.noarch.rpm;name=x86_64_v2_perl-I18N-Collate;unpack=0"
SRC_URI[x86_64_v2_perl-I18N-Collate.sha256sum] = "6fdbc6c8a8d83f3f6b992dd888de5c30663c3d5bd9219e33bbd82db17fcccbef"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-I18N-LangTags-0.45-515.el10.noarch.rpm;name=x86_64_v2_perl-I18N-LangTags;unpack=0"
SRC_URI[x86_64_v2_perl-I18N-LangTags.sha256sum] = "c777a750b670124b95bce8454307128d4e4a09a6dbcc4bf9f450f2546ef3e1af"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-I18N-Langinfo-0.24-515.el10.x86_64_v2.rpm;name=x86_64_v2_perl-I18N-Langinfo;unpack=0"
SRC_URI[x86_64_v2_perl-I18N-Langinfo.sha256sum] = "eeef538e007ac111518eafed969c9d1dc1396aeb96dad1aec62de474a264039c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-IO-1.55-515.el10.x86_64_v2.rpm;name=x86_64_v2_perl-IO;unpack=0"
SRC_URI[x86_64_v2_perl-IO.sha256sum] = "c86b440361476661b70f7cb8b639e370a4076b61ebfa00b82403cf5871bb8264"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-IPC-Open3-1.22-515.el10.noarch.rpm;name=x86_64_v2_perl-IPC-Open3;unpack=0"
SRC_URI[x86_64_v2_perl-IPC-Open3.sha256sum] = "e58451315f0f2c86312764517ebe34e9a2632d09eab082599aae93d9e25a6be1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Locale-Maketext-Simple-0.21-515.el10.noarch.rpm;name=x86_64_v2_perl-Locale-Maketext-Simple;unpack=0"
SRC_URI[x86_64_v2_perl-Locale-Maketext-Simple.sha256sum] = "f3b1f682c65d1656029a8fcf3c05f22938f67222faabf9c4cbd714d78caf4f0b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Math-Complex-1.62-515.el10.noarch.rpm;name=x86_64_v2_perl-Math-Complex;unpack=0"
SRC_URI[x86_64_v2_perl-Math-Complex.sha256sum] = "b456150448bfb0681b49a2caac4b14b05239affdc3409b9b81f6de37b2def0ba"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Memoize-1.16-515.el10.noarch.rpm;name=x86_64_v2_perl-Memoize;unpack=0"
SRC_URI[x86_64_v2_perl-Memoize.sha256sum] = "953b8565571aab37b7d92921ce90d3f078ba38a755873aaf228108204ca9579f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Module-Loaded-0.08-515.el10.noarch.rpm;name=x86_64_v2_perl-Module-Loaded;unpack=0"
SRC_URI[x86_64_v2_perl-Module-Loaded.sha256sum] = "dfd8c94b1d148b7589ee9f68e2e8f0f74b8ead8d8071516950106f88f6df4ba1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-NDBM_File-1.17-515.el10.x86_64_v2.rpm;name=x86_64_v2_perl-NDBM_File;unpack=0"
SRC_URI[x86_64_v2_perl-NDBM_File.sha256sum] = "54d6081881854ac8cac95ccd7b4caafb1ee8d0f5f66e8f91bca2336de7c26d39"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-NEXT-0.69-515.el10.noarch.rpm;name=x86_64_v2_perl-NEXT;unpack=0"
SRC_URI[x86_64_v2_perl-NEXT.sha256sum] = "2ffb4d99f80289bcdecef9594ab2fcd39a3379dca4979eee834fe103e6411f70"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Net-1.04-515.el10.noarch.rpm;name=x86_64_v2_perl-Net;unpack=0"
SRC_URI[x86_64_v2_perl-Net.sha256sum] = "7372d592542d1173d8e24cce5760161a89d2ab418cee0f0451f6ffe015b02c97"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-ODBM_File-1.18-515.el10.x86_64_v2.rpm;name=x86_64_v2_perl-ODBM_File;unpack=0"
SRC_URI[x86_64_v2_perl-ODBM_File.sha256sum] = "237ee1d596d1edb4c3bc7e31c19ad6a058927a78a6122c6e52b6b59292751b77"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Opcode-1.65-515.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Opcode;unpack=0"
SRC_URI[x86_64_v2_perl-Opcode.sha256sum] = "031e91e469c187cf28fa16ca8dc519cd44abcfba8fdd04b28d431fe39254488e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-POSIX-2.20-515.el10.x86_64_v2.rpm;name=x86_64_v2_perl-POSIX;unpack=0"
SRC_URI[x86_64_v2_perl-POSIX.sha256sum] = "10337f7f3cce9b32dad45f8611933d9123e82e73bfebaf8a330e6ed5739fe835"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Pod-Functions-1.14-515.el10.noarch.rpm;name=x86_64_v2_perl-Pod-Functions;unpack=0"
SRC_URI[x86_64_v2_perl-Pod-Functions.sha256sum] = "783decf8b3d21d9439cafd67620a821f193560a88b1902eb39f32f91f333562a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Pod-Html-1.35-515.el10.noarch.rpm;name=x86_64_v2_perl-Pod-Html;unpack=0"
SRC_URI[x86_64_v2_perl-Pod-Html.sha256sum] = "539019929d026e2fe9be762702c697d34969de43cd18b6ccab64950db94cf3e9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Safe-2.46-515.el10.noarch.rpm;name=x86_64_v2_perl-Safe;unpack=0"
SRC_URI[x86_64_v2_perl-Safe.sha256sum] = "4995619e0334cfe1ad526a1936157d40270b9d7f8a0fbaed4a9f1d778cbac8c9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Search-Dict-1.07-515.el10.noarch.rpm;name=x86_64_v2_perl-Search-Dict;unpack=0"
SRC_URI[x86_64_v2_perl-Search-Dict.sha256sum] = "6945e6596214ec6daa20eb88f91a6dfa40cfa995857b2733df32a6661b3dfb8d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-SelectSaver-1.02-515.el10.noarch.rpm;name=x86_64_v2_perl-SelectSaver;unpack=0"
SRC_URI[x86_64_v2_perl-SelectSaver.sha256sum] = "ae09e78423389e1c41f4463d20267f82172c8fa5949a71375f3f02651d5cd969"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-SelfLoader-1.27-515.el10.noarch.rpm;name=x86_64_v2_perl-SelfLoader;unpack=0"
SRC_URI[x86_64_v2_perl-SelfLoader.sha256sum] = "30101e563b0e0e112a91799e86d5040d086fdc30c2caf62974392ebdab8a93b0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Symbol-1.09-515.el10.noarch.rpm;name=x86_64_v2_perl-Symbol;unpack=0"
SRC_URI[x86_64_v2_perl-Symbol.sha256sum] = "f83c9cea60775f647c517a4e93516ef0417f10300a6486d61d21ca40aa515181"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Sys-Hostname-1.25-515.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Sys-Hostname;unpack=0"
SRC_URI[x86_64_v2_perl-Sys-Hostname.sha256sum] = "c6bf0c16cfbe6a6a53c92acf056d90215cf95d0ed63780f8fdd4be3f6e5cd9b3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Term-Complete-1.403-515.el10.noarch.rpm;name=x86_64_v2_perl-Term-Complete;unpack=0"
SRC_URI[x86_64_v2_perl-Term-Complete.sha256sum] = "962744a5d30d40b20e549c511c593b61a2f4ec3be944786bc833e111f036eb13"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Term-ReadLine-1.17-515.el10.noarch.rpm;name=x86_64_v2_perl-Term-ReadLine;unpack=0"
SRC_URI[x86_64_v2_perl-Term-ReadLine.sha256sum] = "8f6a053a5148946dc2834548115621706a50d6fbda8090af7d9a0d378e33708f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Test-1.31-515.el10.noarch.rpm;name=x86_64_v2_perl-Test;unpack=0"
SRC_URI[x86_64_v2_perl-Test.sha256sum] = "cc64b270488efe44cd359848e169ef36280917a553b0bc7e549a41da778bf5eb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Text-Abbrev-1.02-515.el10.noarch.rpm;name=x86_64_v2_perl-Text-Abbrev;unpack=0"
SRC_URI[x86_64_v2_perl-Text-Abbrev.sha256sum] = "f4160791258158383a909db6418566c8b1c69c655087e6405360097e8a2a7e4b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Thread-3.05-515.el10.noarch.rpm;name=x86_64_v2_perl-Thread;unpack=0"
SRC_URI[x86_64_v2_perl-Thread.sha256sum] = "e930cd6e321e4ac15a0c05ced4df295d6e65519af94dcfa4720284a73c0eca9e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Thread-Semaphore-2.13-515.el10.noarch.rpm;name=x86_64_v2_perl-Thread-Semaphore;unpack=0"
SRC_URI[x86_64_v2_perl-Thread-Semaphore.sha256sum] = "55bf104f73906d481a5cae938d710938f736c26ace6e8184ba7cd43d0140221d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Tie-4.6-515.el10.noarch.rpm;name=x86_64_v2_perl-Tie;unpack=0"
SRC_URI[x86_64_v2_perl-Tie.sha256sum] = "78f6f52ed2a072e1367732ac2ffce062505ba1fa57882a22f9cf40ce6f0ed784"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Tie-File-1.09-515.el10.noarch.rpm;name=x86_64_v2_perl-Tie-File;unpack=0"
SRC_URI[x86_64_v2_perl-Tie-File.sha256sum] = "c98f2db2c5ab1b9836ab712b249fdb02755a2686f55545c9a4f89eb892c16ac2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Tie-Memoize-1.1-515.el10.noarch.rpm;name=x86_64_v2_perl-Tie-Memoize;unpack=0"
SRC_URI[x86_64_v2_perl-Tie-Memoize.sha256sum] = "9022c79d366addf6ac62fedc8abadf239ca5ae8995ce10bbed41c14aa71dae60"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Time-1.04-515.el10.noarch.rpm;name=x86_64_v2_perl-Time;unpack=0"
SRC_URI[x86_64_v2_perl-Time.sha256sum] = "d729cee6c092456cb7f7b243a157f7cff30a40224b3d498234625c0a10614244"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Time-Piece-1.3401-515.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Time-Piece;unpack=0"
SRC_URI[x86_64_v2_perl-Time-Piece.sha256sum] = "614547437729f25c49bf6f59dfbb7133d567ab7fcd9478c1427a251f7fc723f3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Unicode-UCD-0.78-515.el10.noarch.rpm;name=x86_64_v2_perl-Unicode-UCD;unpack=0"
SRC_URI[x86_64_v2_perl-Unicode-UCD.sha256sum] = "1c4d0a15bd55d10f4a79d271121c41a717225c7b288f677e6991f92121ad921e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-User-pwent-1.05-515.el10.noarch.rpm;name=x86_64_v2_perl-User-pwent;unpack=0"
SRC_URI[x86_64_v2_perl-User-pwent.sha256sum] = "4c5a56a9f7f0928e25eda1390b2c5cb257620322768c44ce8eb0ed972532909d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-autouse-1.11-515.el10.noarch.rpm;name=x86_64_v2_perl-autouse;unpack=0"
SRC_URI[x86_64_v2_perl-autouse.sha256sum] = "7b7a9dddd0c924428be9d088acab994f587a70ffe3e6d177687284b70ab9ff84"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-base-2.27-515.el10.noarch.rpm;name=x86_64_v2_perl-base;unpack=0"
SRC_URI[x86_64_v2_perl-base.sha256sum] = "21e1bd16ad68873bca71ecd120e6bccde5971f3dfea00156748db14f1f0cdfd3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-blib-1.07-515.el10.noarch.rpm;name=x86_64_v2_perl-blib;unpack=0"
SRC_URI[x86_64_v2_perl-blib.sha256sum] = "9de1aeeb7d0c48691bac0a02b4a364167172bc698a9d76e17b02b955529360de"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-debugger-1.60-515.el10.noarch.rpm;name=x86_64_v2_perl-debugger;unpack=0"
SRC_URI[x86_64_v2_perl-debugger.sha256sum] = "e347334b0847c7d989a2f7c739ce9208cb26d19b8e575e2f0792facebc509257"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-deprecate-0.04-515.el10.noarch.rpm;name=x86_64_v2_perl-deprecate;unpack=0"
SRC_URI[x86_64_v2_perl-deprecate.sha256sum] = "5bbeb33e133015889e2a6f331907d4ea6623178de22df6fa39bbd11a411b1d69"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-devel-5.40.2-515.el10.x86_64_v2.rpm;name=x86_64_v2_perl-devel;unpack=0"
SRC_URI[x86_64_v2_perl-devel.sha256sum] = "ba1fb0720ca6f941e3e02a12dcc26ad576619a199e50c19602438725025810de"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-diagnostics-1.40-515.el10.noarch.rpm;name=x86_64_v2_perl-diagnostics;unpack=0"
SRC_URI[x86_64_v2_perl-diagnostics.sha256sum] = "901066a74f4da7a3b2e318f17863cec0ffd708ae8a79a7333f3f38506570aaf9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-doc-5.40.2-515.el10.noarch.rpm;name=x86_64_v2_perl-doc;unpack=0"
SRC_URI[x86_64_v2_perl-doc.sha256sum] = "44eac26dac770ebe22a7c96f93a66283ffe183693e120e913c02c210eceec4cf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-encoding-warnings-0.14-515.el10.noarch.rpm;name=x86_64_v2_perl-encoding-warnings;unpack=0"
SRC_URI[x86_64_v2_perl-encoding-warnings.sha256sum] = "a74bd3a91d386f0fdcccb792cee096b3d1eaac9fbfe65cd203b12b8996048920"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-fields-2.27-515.el10.noarch.rpm;name=x86_64_v2_perl-fields;unpack=0"
SRC_URI[x86_64_v2_perl-fields.sha256sum] = "2b98e005ffa59890a2671e1a46269291b6462b1c8a1c32024845ea8d47860a10"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-filetest-1.03-515.el10.noarch.rpm;name=x86_64_v2_perl-filetest;unpack=0"
SRC_URI[x86_64_v2_perl-filetest.sha256sum] = "43fc7e17761c30318998643c9c003c95c129b226c5987c07d21b6f1dc75c0841"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-if-0.61.000-515.el10.noarch.rpm;name=x86_64_v2_perl-if;unpack=0"
SRC_URI[x86_64_v2_perl-if.sha256sum] = "920a821bbecf38a067856e81a42a4f21ebed7816096d22f3e7df8770a7a0c597"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-interpreter-5.40.2-515.el10.x86_64_v2.rpm;name=x86_64_v2_perl-interpreter;unpack=0"
SRC_URI[x86_64_v2_perl-interpreter.sha256sum] = "6411ae539c483fc3bb1c1727bbcd13e11fd349eb488dd8460c7c18b5d761dcf3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-less-0.03-515.el10.noarch.rpm;name=x86_64_v2_perl-less;unpack=0"
SRC_URI[x86_64_v2_perl-less.sha256sum] = "e18716d25c132f04f9d848217fef1bbfc1b0969f4ae45e7a6eda7e293a7f05f6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-lib-0.65-515.el10.x86_64_v2.rpm;name=x86_64_v2_perl-lib;unpack=0"
SRC_URI[x86_64_v2_perl-lib.sha256sum] = "34e50a457225bad72955a6ebe80405429ff1d448bd92c63a59302c75fda3004d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-libnetcfg-5.40.2-515.el10.noarch.rpm;name=x86_64_v2_perl-libnetcfg;unpack=0"
SRC_URI[x86_64_v2_perl-libnetcfg.sha256sum] = "92745bfb21a79dfe3bac433d51cf7116a31c359948160779bca7426a2ddae1f0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-libs-5.40.2-515.el10.x86_64_v2.rpm;name=x86_64_v2_perl-libs;unpack=0"
SRC_URI[x86_64_v2_perl-libs.sha256sum] = "c92337e978eadb773e76703819baa178c4dd22724d07b2aab7ec2aa782ed2f42"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-locale-1.12-515.el10.noarch.rpm;name=x86_64_v2_perl-locale;unpack=0"
SRC_URI[x86_64_v2_perl-locale.sha256sum] = "a7ef1dbb1fd9e91fbdb60dc72718f223cc8e7ae231e538a5338af6046b4c4e8d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-macros-5.40.2-515.el10.noarch.rpm;name=x86_64_v2_perl-macros;unpack=0"
SRC_URI[x86_64_v2_perl-macros.sha256sum] = "c30e1547efe99f43c4f79ad7d1e226fa2c2f6a3373763b8652461b058c162b9c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-meta-notation-5.40.2-515.el10.noarch.rpm;name=x86_64_v2_perl-meta-notation;unpack=0"
SRC_URI[x86_64_v2_perl-meta-notation.sha256sum] = "e2c88d57a9f1fb0ff3b468ee49b7b78972498fa7f1c9ea362200912ce3abdaf1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-mro-1.29-515.el10.x86_64_v2.rpm;name=x86_64_v2_perl-mro;unpack=0"
SRC_URI[x86_64_v2_perl-mro.sha256sum] = "7805933b8707310ac87dddbb4ed1d4e44b02564378cf05e87fadde8d642f590e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-open-1.13-515.el10.noarch.rpm;name=x86_64_v2_perl-open;unpack=0"
SRC_URI[x86_64_v2_perl-open.sha256sum] = "8f50c96bed7e2012eb367c66506a79f872eeddda97fe1f2c4f032d6b9cc5dfd8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-overload-1.37-515.el10.noarch.rpm;name=x86_64_v2_perl-overload;unpack=0"
SRC_URI[x86_64_v2_perl-overload.sha256sum] = "26b0124502a0c4eb5a8d368c60e6ef095a3ecd201cfd55abff8b0e620cff7ab5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-overloading-0.02-515.el10.noarch.rpm;name=x86_64_v2_perl-overloading;unpack=0"
SRC_URI[x86_64_v2_perl-overloading.sha256sum] = "80a34ea581e1b7af9eb7140ed01ac6fa9209143cf831887425b1984d4b79fb34"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-ph-5.40.2-515.el10.x86_64_v2.rpm;name=x86_64_v2_perl-ph;unpack=0"
SRC_URI[x86_64_v2_perl-ph.sha256sum] = "001119422774529d7b41732cc37f3acc07af555a8772e6f886569280329cc094"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-sigtrap-1.10-515.el10.noarch.rpm;name=x86_64_v2_perl-sigtrap;unpack=0"
SRC_URI[x86_64_v2_perl-sigtrap.sha256sum] = "1af0b549a2d3cc3e7e37f71be452886ab7cb3c9325fe7b4a711c69cdac938b13"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-sort-2.05-515.el10.noarch.rpm;name=x86_64_v2_perl-sort;unpack=0"
SRC_URI[x86_64_v2_perl-sort.sha256sum] = "a72a8904b4baa61e5da529bbbcde011936e56747aea42f832ccb7694f9d01289"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-subs-1.04-515.el10.noarch.rpm;name=x86_64_v2_perl-subs;unpack=0"
SRC_URI[x86_64_v2_perl-subs.sha256sum] = "9d6a3c6ccc0088ff6ec3f16eb080c58cd995d16c1407d49b2343b26f132d26c8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-utils-5.40.2-515.el10.noarch.rpm;name=x86_64_v2_perl-utils;unpack=0"
SRC_URI[x86_64_v2_perl-utils.sha256sum] = "8c72dbdaf84091d766b53874bd24bd7ad6e40606e7196c38fcd9a7a52e0f6519"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-vars-1.05-515.el10.noarch.rpm;name=x86_64_v2_perl-vars;unpack=0"
SRC_URI[x86_64_v2_perl-vars.sha256sum] = "e863b8f7625b74e117d81a720db28488566ab7a8e27ea9da30db6092b5e5c34e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-vmsish-1.04-515.el10.noarch.rpm;name=x86_64_v2_perl-vmsish;unpack=0"
SRC_URI[x86_64_v2_perl-vmsish.sha256sum] = "979a7f0cf388e0b0902a6311b94b0d2698bd11c626126141caa57e50e0a830f9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-5.40.2-515.el10.aarch64.rpm;name=aarch64_perl;unpack=0"
SRC_URI[aarch64_perl.sha256sum] = "46cf2bc3324bb91e420f7f3057f91a45c87a3e91c730992e3c89f2ad095cdd61"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Attribute-Handlers-1.03-515.el10.noarch.rpm;name=aarch64_perl-Attribute-Handlers;unpack=0"
SRC_URI[aarch64_perl-Attribute-Handlers.sha256sum] = "359d38984ff9a0795be3a44f3c0c9b619c63b6a69c346f76248c3b8413f78cdc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-AutoLoader-5.74-515.el10.noarch.rpm;name=aarch64_perl-AutoLoader;unpack=0"
SRC_URI[aarch64_perl-AutoLoader.sha256sum] = "414300808ed9a3b617b4f3c09ade73d6e8cd0ab2c560753acf73305f24d8910b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-AutoSplit-5.74-515.el10.noarch.rpm;name=aarch64_perl-AutoSplit;unpack=0"
SRC_URI[aarch64_perl-AutoSplit.sha256sum] = "37f413964e1fbe92ad64ebafe4fd4d974c0d8af90294fdb2e14838070ad56594"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-B-1.89-515.el10.aarch64.rpm;name=aarch64_perl-B;unpack=0"
SRC_URI[aarch64_perl-B.sha256sum] = "72b2a17edfd8505acc91eb73a696087cee5b55c9f8f83cedefb2a11bc59989b4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Benchmark-1.25-515.el10.noarch.rpm;name=aarch64_perl-Benchmark;unpack=0"
SRC_URI[aarch64_perl-Benchmark.sha256sum] = "590a5fd3185b16315e95141c968046d40e0cb1a55729f42299a5e771329a5253"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Class-Struct-0.68-515.el10.noarch.rpm;name=aarch64_perl-Class-Struct;unpack=0"
SRC_URI[aarch64_perl-Class-Struct.sha256sum] = "a188af2accd5302d4022be6373c9e5bb4d0e7cb3c9a830156cbb987b1569f4ad"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Config-Extensions-0.03-515.el10.noarch.rpm;name=aarch64_perl-Config-Extensions;unpack=0"
SRC_URI[aarch64_perl-Config-Extensions.sha256sum] = "bed12ab20561e35257dfdc739f600579014988f5ddd053840918b6af4a78999d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-DBM_Filter-0.06-515.el10.noarch.rpm;name=aarch64_perl-DBM_Filter;unpack=0"
SRC_URI[aarch64_perl-DBM_Filter.sha256sum] = "9e646dcd54c6dec017fe9be5d661463c12cb24bf7f9eeb12aa36fb06151517df"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Devel-Peek-1.34-515.el10.aarch64.rpm;name=aarch64_perl-Devel-Peek;unpack=0"
SRC_URI[aarch64_perl-Devel-Peek.sha256sum] = "e5696b72f3ce8a008fcf38b50b31b8cbb8bdbb0a803cccbbbed0cb16a83c0a97"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Devel-SelfStubber-1.06-515.el10.noarch.rpm;name=aarch64_perl-Devel-SelfStubber;unpack=0"
SRC_URI[aarch64_perl-Devel-SelfStubber.sha256sum] = "6a9686cb89b0768290fb49c70a97fdfdb75601f7be93e04e9f8d8f66974b2074"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-DirHandle-1.05-515.el10.noarch.rpm;name=aarch64_perl-DirHandle;unpack=0"
SRC_URI[aarch64_perl-DirHandle.sha256sum] = "cbcea6168766c354327557d606fdb4814fea3a71380f2d98d892aa383bf0e055"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Dumpvalue-2.27-515.el10.noarch.rpm;name=aarch64_perl-Dumpvalue;unpack=0"
SRC_URI[aarch64_perl-Dumpvalue.sha256sum] = "c214b0f92471721e2acaa54c95b2cdcb99b99589c06cb7c47af5e5b4cd02f40a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-DynaLoader-1.56-515.el10.aarch64.rpm;name=aarch64_perl-DynaLoader;unpack=0"
SRC_URI[aarch64_perl-DynaLoader.sha256sum] = "b6e4c6ce4e87ac2ec546e812f3faef463a31da291c82ea2793f260023f0149a0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-English-1.11-515.el10.noarch.rpm;name=aarch64_perl-English;unpack=0"
SRC_URI[aarch64_perl-English.sha256sum] = "bd5c764ac0fd67547ac0b83677b8a79e37affe7180d6dec5e0a9f95b0f1751ac"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Errno-1.38-515.el10.aarch64.rpm;name=aarch64_perl-Errno;unpack=0"
SRC_URI[aarch64_perl-Errno.sha256sum] = "a6946a1122ff1bff989f435efef4358ad0ba3fab1f793230042fc70cc48f8dab"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-ExtUtils-Constant-0.25-515.el10.noarch.rpm;name=aarch64_perl-ExtUtils-Constant;unpack=0"
SRC_URI[aarch64_perl-ExtUtils-Constant.sha256sum] = "90f242d825565e8392ac968fd6ee88ef34e9228b26cb4c10626f001a699326c8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-ExtUtils-Embed-1.35-515.el10.noarch.rpm;name=aarch64_perl-ExtUtils-Embed;unpack=0"
SRC_URI[aarch64_perl-ExtUtils-Embed.sha256sum] = "8a0ba2799bb6d76ae3a4014a7471bab18ffa5699f5d1fc18549a3dc474f21dfb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-ExtUtils-Miniperl-1.14-515.el10.noarch.rpm;name=aarch64_perl-ExtUtils-Miniperl;unpack=0"
SRC_URI[aarch64_perl-ExtUtils-Miniperl.sha256sum] = "81579a96839bee747e94f089bdeec893668b9a213586bcdb6bf96f81271270e7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Fcntl-1.18-515.el10.aarch64.rpm;name=aarch64_perl-Fcntl;unpack=0"
SRC_URI[aarch64_perl-Fcntl.sha256sum] = "b352e69ff9bce7fc4ee4f3222b5d107d3e45e261e68d683d818b828782845782"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-File-Basename-2.86-515.el10.noarch.rpm;name=aarch64_perl-File-Basename;unpack=0"
SRC_URI[aarch64_perl-File-Basename.sha256sum] = "38096d3e54e33a8a0d91f3bdd4a965c63b0c6a8edfb22db583e0cc2e4983e01b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-File-Compare-1.100.800-515.el10.noarch.rpm;name=aarch64_perl-File-Compare;unpack=0"
SRC_URI[aarch64_perl-File-Compare.sha256sum] = "eba6a5da6d3e33f7d1bc710733969265f751b65bc1ea3006dab12817ce610362"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-File-Copy-2.41-515.el10.noarch.rpm;name=aarch64_perl-File-Copy;unpack=0"
SRC_URI[aarch64_perl-File-Copy.sha256sum] = "8c37e19c16def237f2dc7858d0a010c53902286ac0af34d218fb7aa7329ed538"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-File-DosGlob-1.12-515.el10.aarch64.rpm;name=aarch64_perl-File-DosGlob;unpack=0"
SRC_URI[aarch64_perl-File-DosGlob.sha256sum] = "38d67e73e08e89221f387d64f97b413e5e7f736077800afdb0a0726d078bbbc7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-File-Find-1.44-515.el10.noarch.rpm;name=aarch64_perl-File-Find;unpack=0"
SRC_URI[aarch64_perl-File-Find.sha256sum] = "5a3d540373a0956797aa7a5928311f70676d2c00a74a51edaa42e4a11f46f96f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-File-stat-1.14-515.el10.noarch.rpm;name=aarch64_perl-File-stat;unpack=0"
SRC_URI[aarch64_perl-File-stat.sha256sum] = "8422e8e65be3c542c5f58de6303d988595400a6f444d01773f663e14bd5267a5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-FileCache-1.10-515.el10.noarch.rpm;name=aarch64_perl-FileCache;unpack=0"
SRC_URI[aarch64_perl-FileCache.sha256sum] = "7336ac36f60cd3a01bdc6a13a8ba5eb3bdd8d1cfe2e3ad49b5cfafdb733b1d3c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-FileHandle-2.05-515.el10.noarch.rpm;name=aarch64_perl-FileHandle;unpack=0"
SRC_URI[aarch64_perl-FileHandle.sha256sum] = "3bc687766811ae72d9d11f541fdaed076b006d4fead333593abe5b2acd5580d4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-FindBin-1.54-515.el10.noarch.rpm;name=aarch64_perl-FindBin;unpack=0"
SRC_URI[aarch64_perl-FindBin.sha256sum] = "ba3303a11544212ee28beaf73d7af0b68bce97f97d9dd46abebb5d4b2b443389"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-GDBM_File-1.24-515.el10.aarch64.rpm;name=aarch64_perl-GDBM_File;unpack=0"
SRC_URI[aarch64_perl-GDBM_File.sha256sum] = "f3e8f8747ca231c3d935d7d347c4bc4da3e8d0c09b8585aa6e14d581e9c432ad"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Getopt-Std-1.14-515.el10.noarch.rpm;name=aarch64_perl-Getopt-Std;unpack=0"
SRC_URI[aarch64_perl-Getopt-Std.sha256sum] = "3605568682759202fb40765654af6308932662329d74306c9c4e76741a49c153"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Hash-Util-0.32-515.el10.aarch64.rpm;name=aarch64_perl-Hash-Util;unpack=0"
SRC_URI[aarch64_perl-Hash-Util.sha256sum] = "dbf8ed6f0afaf880f3fb012f4ad5ad5f4a53b95825744f9f301d9796d0a9060b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Hash-Util-FieldHash-1.27-515.el10.aarch64.rpm;name=aarch64_perl-Hash-Util-FieldHash;unpack=0"
SRC_URI[aarch64_perl-Hash-Util-FieldHash.sha256sum] = "c3c23ca71dcf4c37c065744b86f3da08141e131da3d374f7ef77a2443c9483bb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-I18N-Collate-1.02-515.el10.noarch.rpm;name=aarch64_perl-I18N-Collate;unpack=0"
SRC_URI[aarch64_perl-I18N-Collate.sha256sum] = "6fdbc6c8a8d83f3f6b992dd888de5c30663c3d5bd9219e33bbd82db17fcccbef"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-I18N-LangTags-0.45-515.el10.noarch.rpm;name=aarch64_perl-I18N-LangTags;unpack=0"
SRC_URI[aarch64_perl-I18N-LangTags.sha256sum] = "c777a750b670124b95bce8454307128d4e4a09a6dbcc4bf9f450f2546ef3e1af"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-I18N-Langinfo-0.24-515.el10.aarch64.rpm;name=aarch64_perl-I18N-Langinfo;unpack=0"
SRC_URI[aarch64_perl-I18N-Langinfo.sha256sum] = "3ae172aa73b66da4da25c6c3b2db0efac31c4b63337ad3087857682b76ad543d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-IO-1.55-515.el10.aarch64.rpm;name=aarch64_perl-IO;unpack=0"
SRC_URI[aarch64_perl-IO.sha256sum] = "35bc5fceeb8558bd99561ff399c661b54610cbdfa5a37d4af942a2f7589955d7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-IPC-Open3-1.22-515.el10.noarch.rpm;name=aarch64_perl-IPC-Open3;unpack=0"
SRC_URI[aarch64_perl-IPC-Open3.sha256sum] = "e58451315f0f2c86312764517ebe34e9a2632d09eab082599aae93d9e25a6be1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Locale-Maketext-Simple-0.21-515.el10.noarch.rpm;name=aarch64_perl-Locale-Maketext-Simple;unpack=0"
SRC_URI[aarch64_perl-Locale-Maketext-Simple.sha256sum] = "f3b1f682c65d1656029a8fcf3c05f22938f67222faabf9c4cbd714d78caf4f0b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Math-Complex-1.62-515.el10.noarch.rpm;name=aarch64_perl-Math-Complex;unpack=0"
SRC_URI[aarch64_perl-Math-Complex.sha256sum] = "b456150448bfb0681b49a2caac4b14b05239affdc3409b9b81f6de37b2def0ba"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Memoize-1.16-515.el10.noarch.rpm;name=aarch64_perl-Memoize;unpack=0"
SRC_URI[aarch64_perl-Memoize.sha256sum] = "953b8565571aab37b7d92921ce90d3f078ba38a755873aaf228108204ca9579f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Module-Loaded-0.08-515.el10.noarch.rpm;name=aarch64_perl-Module-Loaded;unpack=0"
SRC_URI[aarch64_perl-Module-Loaded.sha256sum] = "dfd8c94b1d148b7589ee9f68e2e8f0f74b8ead8d8071516950106f88f6df4ba1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-NDBM_File-1.17-515.el10.aarch64.rpm;name=aarch64_perl-NDBM_File;unpack=0"
SRC_URI[aarch64_perl-NDBM_File.sha256sum] = "91677b5433eba276a9caf8596714b35f92c37bc2bff58a7826f4e505af8e6989"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-NEXT-0.69-515.el10.noarch.rpm;name=aarch64_perl-NEXT;unpack=0"
SRC_URI[aarch64_perl-NEXT.sha256sum] = "2ffb4d99f80289bcdecef9594ab2fcd39a3379dca4979eee834fe103e6411f70"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Net-1.04-515.el10.noarch.rpm;name=aarch64_perl-Net;unpack=0"
SRC_URI[aarch64_perl-Net.sha256sum] = "7372d592542d1173d8e24cce5760161a89d2ab418cee0f0451f6ffe015b02c97"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-ODBM_File-1.18-515.el10.aarch64.rpm;name=aarch64_perl-ODBM_File;unpack=0"
SRC_URI[aarch64_perl-ODBM_File.sha256sum] = "20b99bc0bc679d8c1e5279237d0ffb6dcf5e038a7008ba63bf770e233710d1be"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Opcode-1.65-515.el10.aarch64.rpm;name=aarch64_perl-Opcode;unpack=0"
SRC_URI[aarch64_perl-Opcode.sha256sum] = "65c352d240defd430a4d837e04adfe6dba7948a95424e91b167b1e2f911cd14a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-POSIX-2.20-515.el10.aarch64.rpm;name=aarch64_perl-POSIX;unpack=0"
SRC_URI[aarch64_perl-POSIX.sha256sum] = "759162b18328e3f55038c3c531399e67d8f5ffb6c7034e3f89b74c759eb06098"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Pod-Functions-1.14-515.el10.noarch.rpm;name=aarch64_perl-Pod-Functions;unpack=0"
SRC_URI[aarch64_perl-Pod-Functions.sha256sum] = "783decf8b3d21d9439cafd67620a821f193560a88b1902eb39f32f91f333562a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Pod-Html-1.35-515.el10.noarch.rpm;name=aarch64_perl-Pod-Html;unpack=0"
SRC_URI[aarch64_perl-Pod-Html.sha256sum] = "539019929d026e2fe9be762702c697d34969de43cd18b6ccab64950db94cf3e9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Safe-2.46-515.el10.noarch.rpm;name=aarch64_perl-Safe;unpack=0"
SRC_URI[aarch64_perl-Safe.sha256sum] = "4995619e0334cfe1ad526a1936157d40270b9d7f8a0fbaed4a9f1d778cbac8c9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Search-Dict-1.07-515.el10.noarch.rpm;name=aarch64_perl-Search-Dict;unpack=0"
SRC_URI[aarch64_perl-Search-Dict.sha256sum] = "6945e6596214ec6daa20eb88f91a6dfa40cfa995857b2733df32a6661b3dfb8d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-SelectSaver-1.02-515.el10.noarch.rpm;name=aarch64_perl-SelectSaver;unpack=0"
SRC_URI[aarch64_perl-SelectSaver.sha256sum] = "ae09e78423389e1c41f4463d20267f82172c8fa5949a71375f3f02651d5cd969"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-SelfLoader-1.27-515.el10.noarch.rpm;name=aarch64_perl-SelfLoader;unpack=0"
SRC_URI[aarch64_perl-SelfLoader.sha256sum] = "30101e563b0e0e112a91799e86d5040d086fdc30c2caf62974392ebdab8a93b0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Symbol-1.09-515.el10.noarch.rpm;name=aarch64_perl-Symbol;unpack=0"
SRC_URI[aarch64_perl-Symbol.sha256sum] = "f83c9cea60775f647c517a4e93516ef0417f10300a6486d61d21ca40aa515181"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Sys-Hostname-1.25-515.el10.aarch64.rpm;name=aarch64_perl-Sys-Hostname;unpack=0"
SRC_URI[aarch64_perl-Sys-Hostname.sha256sum] = "11674d4589c468c9cb7e78b4806495191252bb64db96ebadb39e5254430aa65d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Term-Complete-1.403-515.el10.noarch.rpm;name=aarch64_perl-Term-Complete;unpack=0"
SRC_URI[aarch64_perl-Term-Complete.sha256sum] = "962744a5d30d40b20e549c511c593b61a2f4ec3be944786bc833e111f036eb13"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Term-ReadLine-1.17-515.el10.noarch.rpm;name=aarch64_perl-Term-ReadLine;unpack=0"
SRC_URI[aarch64_perl-Term-ReadLine.sha256sum] = "8f6a053a5148946dc2834548115621706a50d6fbda8090af7d9a0d378e33708f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Test-1.31-515.el10.noarch.rpm;name=aarch64_perl-Test;unpack=0"
SRC_URI[aarch64_perl-Test.sha256sum] = "cc64b270488efe44cd359848e169ef36280917a553b0bc7e549a41da778bf5eb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Text-Abbrev-1.02-515.el10.noarch.rpm;name=aarch64_perl-Text-Abbrev;unpack=0"
SRC_URI[aarch64_perl-Text-Abbrev.sha256sum] = "f4160791258158383a909db6418566c8b1c69c655087e6405360097e8a2a7e4b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Thread-3.05-515.el10.noarch.rpm;name=aarch64_perl-Thread;unpack=0"
SRC_URI[aarch64_perl-Thread.sha256sum] = "e930cd6e321e4ac15a0c05ced4df295d6e65519af94dcfa4720284a73c0eca9e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Thread-Semaphore-2.13-515.el10.noarch.rpm;name=aarch64_perl-Thread-Semaphore;unpack=0"
SRC_URI[aarch64_perl-Thread-Semaphore.sha256sum] = "55bf104f73906d481a5cae938d710938f736c26ace6e8184ba7cd43d0140221d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Tie-4.6-515.el10.noarch.rpm;name=aarch64_perl-Tie;unpack=0"
SRC_URI[aarch64_perl-Tie.sha256sum] = "78f6f52ed2a072e1367732ac2ffce062505ba1fa57882a22f9cf40ce6f0ed784"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Tie-File-1.09-515.el10.noarch.rpm;name=aarch64_perl-Tie-File;unpack=0"
SRC_URI[aarch64_perl-Tie-File.sha256sum] = "c98f2db2c5ab1b9836ab712b249fdb02755a2686f55545c9a4f89eb892c16ac2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Tie-Memoize-1.1-515.el10.noarch.rpm;name=aarch64_perl-Tie-Memoize;unpack=0"
SRC_URI[aarch64_perl-Tie-Memoize.sha256sum] = "9022c79d366addf6ac62fedc8abadf239ca5ae8995ce10bbed41c14aa71dae60"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Time-1.04-515.el10.noarch.rpm;name=aarch64_perl-Time;unpack=0"
SRC_URI[aarch64_perl-Time.sha256sum] = "d729cee6c092456cb7f7b243a157f7cff30a40224b3d498234625c0a10614244"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Time-Piece-1.3401-515.el10.aarch64.rpm;name=aarch64_perl-Time-Piece;unpack=0"
SRC_URI[aarch64_perl-Time-Piece.sha256sum] = "4afa465bcf8cc12ace53cb99a84f96280db8aa2ba942846719fbc402965a8392"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Unicode-UCD-0.78-515.el10.noarch.rpm;name=aarch64_perl-Unicode-UCD;unpack=0"
SRC_URI[aarch64_perl-Unicode-UCD.sha256sum] = "1c4d0a15bd55d10f4a79d271121c41a717225c7b288f677e6991f92121ad921e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-User-pwent-1.05-515.el10.noarch.rpm;name=aarch64_perl-User-pwent;unpack=0"
SRC_URI[aarch64_perl-User-pwent.sha256sum] = "4c5a56a9f7f0928e25eda1390b2c5cb257620322768c44ce8eb0ed972532909d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-autouse-1.11-515.el10.noarch.rpm;name=aarch64_perl-autouse;unpack=0"
SRC_URI[aarch64_perl-autouse.sha256sum] = "7b7a9dddd0c924428be9d088acab994f587a70ffe3e6d177687284b70ab9ff84"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-base-2.27-515.el10.noarch.rpm;name=aarch64_perl-base;unpack=0"
SRC_URI[aarch64_perl-base.sha256sum] = "21e1bd16ad68873bca71ecd120e6bccde5971f3dfea00156748db14f1f0cdfd3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-blib-1.07-515.el10.noarch.rpm;name=aarch64_perl-blib;unpack=0"
SRC_URI[aarch64_perl-blib.sha256sum] = "9de1aeeb7d0c48691bac0a02b4a364167172bc698a9d76e17b02b955529360de"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-debugger-1.60-515.el10.noarch.rpm;name=aarch64_perl-debugger;unpack=0"
SRC_URI[aarch64_perl-debugger.sha256sum] = "e347334b0847c7d989a2f7c739ce9208cb26d19b8e575e2f0792facebc509257"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-deprecate-0.04-515.el10.noarch.rpm;name=aarch64_perl-deprecate;unpack=0"
SRC_URI[aarch64_perl-deprecate.sha256sum] = "5bbeb33e133015889e2a6f331907d4ea6623178de22df6fa39bbd11a411b1d69"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-devel-5.40.2-515.el10.aarch64.rpm;name=aarch64_perl-devel;unpack=0"
SRC_URI[aarch64_perl-devel.sha256sum] = "32dad306326a2f915eed7b5bb6ae4bc20450662ae97d91ca43a7bd96cd87c3c5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-diagnostics-1.40-515.el10.noarch.rpm;name=aarch64_perl-diagnostics;unpack=0"
SRC_URI[aarch64_perl-diagnostics.sha256sum] = "901066a74f4da7a3b2e318f17863cec0ffd708ae8a79a7333f3f38506570aaf9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-doc-5.40.2-515.el10.noarch.rpm;name=aarch64_perl-doc;unpack=0"
SRC_URI[aarch64_perl-doc.sha256sum] = "44eac26dac770ebe22a7c96f93a66283ffe183693e120e913c02c210eceec4cf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-encoding-warnings-0.14-515.el10.noarch.rpm;name=aarch64_perl-encoding-warnings;unpack=0"
SRC_URI[aarch64_perl-encoding-warnings.sha256sum] = "a74bd3a91d386f0fdcccb792cee096b3d1eaac9fbfe65cd203b12b8996048920"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-fields-2.27-515.el10.noarch.rpm;name=aarch64_perl-fields;unpack=0"
SRC_URI[aarch64_perl-fields.sha256sum] = "2b98e005ffa59890a2671e1a46269291b6462b1c8a1c32024845ea8d47860a10"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-filetest-1.03-515.el10.noarch.rpm;name=aarch64_perl-filetest;unpack=0"
SRC_URI[aarch64_perl-filetest.sha256sum] = "43fc7e17761c30318998643c9c003c95c129b226c5987c07d21b6f1dc75c0841"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-if-0.61.000-515.el10.noarch.rpm;name=aarch64_perl-if;unpack=0"
SRC_URI[aarch64_perl-if.sha256sum] = "920a821bbecf38a067856e81a42a4f21ebed7816096d22f3e7df8770a7a0c597"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-interpreter-5.40.2-515.el10.aarch64.rpm;name=aarch64_perl-interpreter;unpack=0"
SRC_URI[aarch64_perl-interpreter.sha256sum] = "bf595c2fbe9df5a3634faa03c5e08461ed9f7bd018e2dc2f863b0d35e4dbac13"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-less-0.03-515.el10.noarch.rpm;name=aarch64_perl-less;unpack=0"
SRC_URI[aarch64_perl-less.sha256sum] = "e18716d25c132f04f9d848217fef1bbfc1b0969f4ae45e7a6eda7e293a7f05f6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-lib-0.65-515.el10.aarch64.rpm;name=aarch64_perl-lib;unpack=0"
SRC_URI[aarch64_perl-lib.sha256sum] = "74c084c82a0abcfee7c4e1db48d679e0510b72a763661b9d84d198d9c4d77961"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-libnetcfg-5.40.2-515.el10.noarch.rpm;name=aarch64_perl-libnetcfg;unpack=0"
SRC_URI[aarch64_perl-libnetcfg.sha256sum] = "92745bfb21a79dfe3bac433d51cf7116a31c359948160779bca7426a2ddae1f0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-libs-5.40.2-515.el10.aarch64.rpm;name=aarch64_perl-libs;unpack=0"
SRC_URI[aarch64_perl-libs.sha256sum] = "72b9b3cc4e4025749fe7833ffa5f368f1597d9b948b68fb4c06fd0ba44a552fa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-locale-1.12-515.el10.noarch.rpm;name=aarch64_perl-locale;unpack=0"
SRC_URI[aarch64_perl-locale.sha256sum] = "a7ef1dbb1fd9e91fbdb60dc72718f223cc8e7ae231e538a5338af6046b4c4e8d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-macros-5.40.2-515.el10.noarch.rpm;name=aarch64_perl-macros;unpack=0"
SRC_URI[aarch64_perl-macros.sha256sum] = "c30e1547efe99f43c4f79ad7d1e226fa2c2f6a3373763b8652461b058c162b9c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-meta-notation-5.40.2-515.el10.noarch.rpm;name=aarch64_perl-meta-notation;unpack=0"
SRC_URI[aarch64_perl-meta-notation.sha256sum] = "e2c88d57a9f1fb0ff3b468ee49b7b78972498fa7f1c9ea362200912ce3abdaf1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-mro-1.29-515.el10.aarch64.rpm;name=aarch64_perl-mro;unpack=0"
SRC_URI[aarch64_perl-mro.sha256sum] = "f91eee9b2659fc8f3343a6e940dc7962a7d49e9e3003987ddd190d6515b2c9b2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-open-1.13-515.el10.noarch.rpm;name=aarch64_perl-open;unpack=0"
SRC_URI[aarch64_perl-open.sha256sum] = "8f50c96bed7e2012eb367c66506a79f872eeddda97fe1f2c4f032d6b9cc5dfd8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-overload-1.37-515.el10.noarch.rpm;name=aarch64_perl-overload;unpack=0"
SRC_URI[aarch64_perl-overload.sha256sum] = "26b0124502a0c4eb5a8d368c60e6ef095a3ecd201cfd55abff8b0e620cff7ab5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-overloading-0.02-515.el10.noarch.rpm;name=aarch64_perl-overloading;unpack=0"
SRC_URI[aarch64_perl-overloading.sha256sum] = "80a34ea581e1b7af9eb7140ed01ac6fa9209143cf831887425b1984d4b79fb34"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-ph-5.40.2-515.el10.aarch64.rpm;name=aarch64_perl-ph;unpack=0"
SRC_URI[aarch64_perl-ph.sha256sum] = "bd3a936f54b89dfff83d5019eef3491ef3cc048b103c3db9b2116c7cccea264b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-sigtrap-1.10-515.el10.noarch.rpm;name=aarch64_perl-sigtrap;unpack=0"
SRC_URI[aarch64_perl-sigtrap.sha256sum] = "1af0b549a2d3cc3e7e37f71be452886ab7cb3c9325fe7b4a711c69cdac938b13"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-sort-2.05-515.el10.noarch.rpm;name=aarch64_perl-sort;unpack=0"
SRC_URI[aarch64_perl-sort.sha256sum] = "a72a8904b4baa61e5da529bbbcde011936e56747aea42f832ccb7694f9d01289"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-subs-1.04-515.el10.noarch.rpm;name=aarch64_perl-subs;unpack=0"
SRC_URI[aarch64_perl-subs.sha256sum] = "9d6a3c6ccc0088ff6ec3f16eb080c58cd995d16c1407d49b2343b26f132d26c8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-utils-5.40.2-515.el10.noarch.rpm;name=aarch64_perl-utils;unpack=0"
SRC_URI[aarch64_perl-utils.sha256sum] = "8c72dbdaf84091d766b53874bd24bd7ad6e40606e7196c38fcd9a7a52e0f6519"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-vars-1.05-515.el10.noarch.rpm;name=aarch64_perl-vars;unpack=0"
SRC_URI[aarch64_perl-vars.sha256sum] = "e863b8f7625b74e117d81a720db28488566ab7a8e27ea9da30db6092b5e5c34e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-vmsish-1.04-515.el10.noarch.rpm;name=aarch64_perl-vmsish;unpack=0"
SRC_URI[aarch64_perl-vmsish.sha256sum] = "979a7f0cf388e0b0902a6311b94b0d2698bd11c626126141caa57e50e0a830f9"

RDEPENDS:perl = " \
 perl-Archive-Tar \
 perl-Attribute-Handlers \
 perl-AutoLoader \
 perl-AutoSplit \
 perl-B \
 perl-Benchmark \
 perl-CPAN \
 perl-CPAN-Meta \
 perl-CPAN-Meta-Requirements \
 perl-CPAN-Meta-YAML \
 perl-Carp \
 perl-Class-Struct \
 perl-Compress-Raw-Bzip2 \
 perl-Compress-Raw-Zlib \
 perl-Config-Extensions \
 perl-Config-Perl-V \
 perl-DBM_Filter \
 perl-Data-Dumper \
 perl-Devel-PPPort \
 perl-Devel-Peek \
 perl-Devel-SelfStubber \
 perl-Digest \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-DirHandle \
 perl-Dumpvalue \
 perl-DynaLoader \
 perl-Encode \
 perl-Encode-devel \
 perl-English \
 perl-Env \
 perl-Errno \
 perl-Exporter \
 perl-ExtUtils-CBuilder \
 perl-ExtUtils-Command \
 perl-ExtUtils-Constant \
 perl-ExtUtils-Embed \
 perl-ExtUtils-Install \
 perl-ExtUtils-MM-Utils \
 perl-ExtUtils-MakeMaker \
 perl-ExtUtils-Manifest \
 perl-ExtUtils-Miniperl \
 perl-ExtUtils-ParseXS \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Compare \
 perl-File-Copy \
 perl-File-DosGlob \
 perl-File-Fetch \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-File-stat \
 perl-FileCache \
 perl-FileHandle \
 perl-Filter \
 perl-Filter-Simple \
 perl-FindBin \
 perl-GDBM_File \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-HTTP-Tiny \
 perl-Hash-Util \
 perl-Hash-Util-FieldHash \
 perl-I18N-Collate \
 perl-I18N-LangTags \
 perl-I18N-Langinfo \
 perl-IO \
 perl-IO-Compress \
 perl-IO-Socket-IP \
 perl-IO-Zlib \
 perl-IPC-Cmd \
 perl-IPC-Open3 \
 perl-IPC-SysV \
 perl-JSON-PP \
 perl-Locale-Maketext \
 perl-Locale-Maketext-Simple \
 perl-MIME-Base64 \
 perl-Math-BigInt \
 perl-Math-BigInt-FastCalc \
 perl-Math-Complex \
 perl-Memoize \
 perl-Module-CoreList \
 perl-Module-CoreList-tools \
 perl-Module-Load \
 perl-Module-Load-Conditional \
 perl-Module-Loaded \
 perl-Module-Metadata \
 perl-NDBM_File \
 perl-NEXT \
 perl-Net \
 perl-Net-Ping \
 perl-ODBM_File \
 perl-Opcode \
 perl-POSIX \
 perl-Params-Check \
 perl-PathTools \
 perl-Perl-OSType \
 perl-PerlIO-via-QuotedPrint \
 perl-Pod-Checker \
 perl-Pod-Escapes \
 perl-Pod-Functions \
 perl-Pod-Html \
 perl-Pod-Perldoc \
 perl-Pod-Simple \
 perl-Pod-Usage \
 perl-Safe \
 perl-Scalar-List-Utils \
 perl-Search-Dict \
 perl-SelectSaver \
 perl-SelfLoader \
 perl-Socket \
 perl-Storable \
 perl-Symbol \
 perl-Sys-Hostname \
 perl-Sys-Syslog \
 perl-Term-ANSIColor \
 perl-Term-Cap \
 perl-Term-Complete \
 perl-Term-ReadLine \
 perl-Term-Table \
 perl-Test \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Test2-Suite \
 perl-Text-Abbrev \
 perl-Text-Balanced \
 perl-Text-ParseWords \
 perl-Text-Tabs+Wrap \
 perl-Thread \
 perl-Thread-Queue \
 perl-Thread-Semaphore \
 perl-Tie \
 perl-Tie-File \
 perl-Tie-Memoize \
 perl-Tie-RefHash \
 perl-Time \
 perl-Time-HiRes \
 perl-Time-Local \
 perl-Time-Piece \
 perl-Unicode-Collate \
 perl-Unicode-Normalize \
 perl-Unicode-UCD \
 perl-User-pwent \
 perl-autodie \
 perl-autouse \
 perl-base \
 perl-bignum \
 perl-blib \
 perl-constant \
 perl-debugger \
 perl-deprecate \
 perl-devel \
 perl-diagnostics \
 perl-doc \
 perl-encoding \
 perl-encoding-warnings \
 perl-experimental \
 perl-fields \
 perl-filetest \
 perl-if \
 perl-interpreter \
 perl-less \
 perl-lib \
 perl-libnet \
 perl-libnetcfg \
 perl-libs \
 perl-locale \
 perl-macros \
 perl-meta-notation \
 perl-mro \
 perl-open \
 perl-overload \
 perl-overloading \
 perl-parent \
 perl-perlfaq \
 perl-ph \
 perl-podlators \
 perl-sigtrap \
 perl-sort \
 perl-subs \
 perl-threads \
 perl-threads-shared \
 perl-utils \
 perl-vars \
 perl-version \
 perl-vmsish \
 "
RDEPENDS:perl-Attribute-Handlers = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-AutoLoader = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-AutoSplit = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Path \
 perl-PathTools \
 perl-libs \
 "
RDEPENDS:perl-B = " \
 glibc \
 perl-B \
 perl-Carp \
 perl-Data-Dumper \
 perl-Exporter \
 perl-if \
 perl-libs \
 perl-overloading \
 "
RDEPENDS:perl-Benchmark = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Class-Struct = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Config-Extensions = " \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-DBM_Filter = " \
 perl-Carp \
 perl-Encode \
 perl-IO-Compress \
 perl-libs \
 "
RDEPENDS:perl-Devel-Peek = " \
 glibc \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Devel-SelfStubber = " \
 perl-PathTools \
 perl-SelfLoader \
 perl-libs \
 "
RDEPENDS:perl-DirHandle = " \
 perl-Carp \
 perl-Symbol \
 perl-libs \
 "
RDEPENDS:perl-Dumpvalue = " \
 perl-libs \
 "
RDEPENDS:perl-DynaLoader = " \
 perl-Carp \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-English = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Errno = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-ExtUtils-Constant = " \
 perl-Carp \
 perl-Data-Dumper \
 perl-Exporter \
 perl-ExtUtils-Constant \
 perl-Text-Tabs+Wrap \
 perl-constant \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-ExtUtils-Embed = " \
 perl-Exporter \
 perl-PathTools \
 perl-devel \
 perl-libs \
 "
RDEPENDS:perl-ExtUtils-Miniperl = " \
 perl-Exporter \
 perl-ExtUtils-Embed \
 perl-devel \
 perl-libs \
 "
RDEPENDS:perl-Fcntl = " \
 glibc \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-File-Basename = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-File-Compare = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-File-Copy = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Basename \
 perl-PathTools \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-File-DosGlob = " \
 glibc \
 perl-Text-ParseWords \
 perl-libs \
 "
RDEPENDS:perl-File-Find = " \
 perl-Exporter \
 perl-File-Basename \
 perl-PathTools \
 perl-libs \
 "
RDEPENDS:perl-File-stat = " \
 perl-Carp \
 perl-Class-Struct \
 perl-Exporter \
 perl-Fcntl \
 perl-Symbol \
 perl-constant \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-FileCache = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 perl-parent \
 "
RDEPENDS:perl-FileHandle = " \
 perl-Exporter \
 perl-IO \
 perl-libs \
 "
RDEPENDS:perl-FindBin = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Basename \
 perl-PathTools \
 perl-libs \
 "
RDEPENDS:perl-GDBM_File = " \
 gdbm-libs \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Getopt-Std = " \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Hash-Util = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-Hash-Util-FieldHash \
 perl-libs \
 "
RDEPENDS:perl-Hash-Util-FieldHash = " \
 glibc \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-I18N-Collate = " \
 perl-Exporter \
 perl-POSIX \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-I18N-LangTags = " \
 perl-Exporter \
 perl-I18N-LangTags \
 perl-libs \
 "
RDEPENDS:perl-I18N-Langinfo = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-IO = " \
 glibc \
 perl-Carp \
 perl-Errno \
 perl-Exporter \
 perl-Fcntl \
 perl-File-stat \
 perl-IO \
 perl-PathTools \
 perl-SelectSaver \
 perl-Socket \
 perl-Symbol \
 perl-libs \
 "
RDEPENDS:perl-IPC-Open3 = " \
 perl-Carp \
 perl-Exporter \
 perl-Fcntl \
 perl-IO \
 perl-IPC-Open3 \
 perl-POSIX \
 perl-Symbol \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-Locale-Maketext-Simple = " \
 perl-Locale-Maketext \
 perl-base \
 perl-libs \
 "
RDEPENDS:perl-Math-Complex = " \
 perl-Exporter \
 perl-Math-Complex \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-Memoize = " \
 perl-Carp \
 perl-Exporter \
 perl-NDBM_File \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-libs \
 "
RDEPENDS:perl-Module-Loaded = " \
 perl-Carp \
 perl-Exporter \
 perl-base \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-NDBM_File = " \
 gdbm-libs \
 glibc \
 perl-libs \
 "
RDEPENDS:perl-NEXT = " \
 perl-Carp \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-Net = " \
 perl-Class-Struct \
 perl-Exporter \
 perl-Socket \
 perl-libs \
 "
RDEPENDS:perl-ODBM_File = " \
 gdbm-libs \
 glibc \
 perl-libs \
 "
RDEPENDS:perl-Opcode = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-Opcode \
 perl-libs \
 perl-subs \
 "
RDEPENDS:perl-POSIX = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-Fcntl \
 perl-libs \
 perl-locale \
 "
RDEPENDS:perl-Pod-Functions = " \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Pod-Html = " \
 perl-Exporter \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-PathTools \
 perl-Pod-Html \
 perl-Pod-Simple \
 perl-Text-Tabs+Wrap \
 perl-interpreter \
 perl-libs \
 perl-locale \
 perl-parent \
 "
RDEPENDS:perl-Safe = " \
 perl-B \
 perl-Carp \
 perl-Opcode \
 perl-Scalar-List-Utils \
 perl-libs \
 "
RDEPENDS:perl-Search-Dict = " \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-SelectSaver = " \
 perl-Carp \
 perl-Symbol \
 perl-libs \
 "
RDEPENDS:perl-SelfLoader = " \
 perl-Carp \
 perl-Exporter \
 perl-IO \
 perl-libs \
 "
RDEPENDS:perl-Symbol = " \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Sys-Hostname = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Term-Complete = " \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Term-ReadLine = " \
 perl-Term-Cap \
 perl-libs \
 "
RDEPENDS:perl-Test = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Temp \
 perl-libs \
 "
RDEPENDS:perl-Text-Abbrev = " \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Thread = " \
 perl-Exporter \
 perl-libs \
 perl-threads \
 perl-threads-shared \
 "
RDEPENDS:perl-Thread-Semaphore = " \
 perl-Carp \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-threads-shared \
 "
RDEPENDS:perl-Tie = " \
 perl-Carp \
 perl-Tie \
 perl-libs \
 "
RDEPENDS:perl-Tie-File = " \
 perl-Carp \
 perl-Fcntl \
 perl-POSIX \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-Tie-Memoize = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-Time = " \
 perl-Class-Struct \
 perl-Exporter \
 perl-Time \
 perl-libs \
 perl-parent \
 "
RDEPENDS:perl-Time-Piece = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-Scalar-List-Utils \
 perl-Time-Local \
 perl-Time-Piece \
 perl-constant \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-Unicode-UCD = " \
 perl-Carp \
 perl-Exporter \
 perl-PathTools \
 perl-Storable \
 perl-Unicode-Normalize \
 perl-if \
 perl-libs \
 "
RDEPENDS:perl-User-pwent = " \
 perl-Carp \
 perl-Class-Struct \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-autouse = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-base = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-blib = " \
 perl-PathTools \
 perl-libs \
 "
RDEPENDS:perl-debugger = " \
 perl-IO \
 perl-PathTools \
 perl-Term-ReadLine \
 perl-libs \
 perl-meta-notation \
 perl-mro \
 perl-threads \
 perl-threads-shared \
 perl-vars \
 "
RDEPENDS:perl-deprecate = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-devel = " \
 libxcrypt-devel \
 perl-Devel-PPPort \
 perl-ExtUtils-Constant \
 perl-ExtUtils-Install \
 perl-ExtUtils-ParseXS \
 perl-File-Compare \
 perl-File-Path \
 perl-Getopt-Long \
 perl-PathTools \
 perl-Text-Tabs+Wrap \
 perl-interpreter \
 perl-libs \
 perl-vars \
 redhat-rpm-config \
 systemtap-sdt-devel \
 systemtap-sdt-dtrace \
 "
RDEPENDS:perl-diagnostics = " \
 perl-Carp \
 perl-Getopt-Std \
 perl-Text-Tabs+Wrap \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:perl-doc = " \
 perl-libs \
 "
RDEPENDS:perl-encoding-warnings = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-fields = " \
 perl-Carp \
 perl-Hash-Util \
 perl-base \
 perl-libs \
 "
RDEPENDS:perl-filetest = " \
 perl-libs \
 "
RDEPENDS:perl-if = " \
 perl-libs \
 "
RDEPENDS:perl-interpreter = " \
 glibc \
 perl-libs \
 "
RDEPENDS:perl-less = " \
 perl-libs \
 "
RDEPENDS:perl-lib = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-libnetcfg = " \
 perl-ExtUtils-MakeMaker \
 perl-Getopt-Std \
 perl-IO \
 perl-PathTools \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-libs = " \
 glibc \
 libxcrypt \
 perl-Carp \
 perl-DynaLoader \
 perl-Encode \
 perl-Exporter \
 perl-PathTools \
 perl-libs \
 "
RDEPENDS:perl-locale = " \
 perl-Carp \
 perl-POSIX \
 perl-libs \
 "
RDEPENDS:perl-macros = " \
 perl-interpreter \
 "
RDEPENDS:perl-meta-notation = " \
 perl-libs \
 "
RDEPENDS:perl-mro = " \
 glibc \
 perl-libs \
 "
RDEPENDS:perl-open = " \
 perl-Carp \
 perl-Encode \
 perl-encoding \
 perl-libs \
 "
RDEPENDS:perl-overload = " \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-mro \
 perl-overloading \
 "
RDEPENDS:perl-overloading = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-ph = " \
 perl-libs \
 "
RDEPENDS:perl-sigtrap = " \
 perl-Carp \
 perl-Symbol \
 perl-libs \
 perl-meta-notation \
 "
RDEPENDS:perl-sort = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-subs = " \
 perl-libs \
 "
RDEPENDS:perl-utils = " \
 perl-File-Basename \
 perl-File-Path \
 perl-Getopt-Std \
 perl-PathTools \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-vars = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-vmsish = " \
 perl-libs \
 "
