# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-search"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 akonadi-search \
 akonadi-search-devel \
 akonadi-search-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akonadi-search-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d6724e010c0fb270e7e6d599d361985de1536f6138b9d828672ae58de381f2ba"

URI_x86_64_v2_akonadi-search = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-search-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-search;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-search}"
SRC_URI[x86_64_v2_akonadi-search.sha256sum] = "531c8cb01ea2a96d2c9b1f504d734c7ef3c401d4dae5f44afd3e5b02b5dd67fe"

URI_x86_64_v2_akonadi-search-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-search-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-search-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-search-devel}"
SRC_URI[x86_64_v2_akonadi-search-devel.sha256sum] = "9cd8892f27cfcdfd7a33f9f1a2c7ed2beeba82f5eb6a1ce0600b21be261c6465"

URI_x86_64_v2_akonadi-search-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-search-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_akonadi-search-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-search-doc}"
SRC_URI[x86_64_v2_akonadi-search-doc.sha256sum] = "c7ab8e02893905eee79134088ce27ce37469842eca32048f1f281ccbb7978a31"

URI_aarch64_akonadi-search = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-search-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_akonadi-search;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-search}"
SRC_URI[aarch64_akonadi-search.sha256sum] = "7cd0e20a0c422a202bcfb8a61d46dafdc5e4cac4a5b6f2e2237c3bb15fd142c2"

URI_aarch64_akonadi-search-devel = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-search-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_akonadi-search-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-search-devel}"
SRC_URI[aarch64_akonadi-search-devel.sha256sum] = "83bd2d13bd737e853e4b5c13253c3934ff1ae4ec854d0ddd4a4c81e3e677d719"

URI_aarch64_akonadi-search-doc = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-search-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_akonadi-search-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-search-doc}"
SRC_URI[aarch64_akonadi-search-doc.sha256sum] = "2c48d4b9d80aa828216f2ced7ea4de264988a742d7fc86c841fa5dcf7a9ce09a"

RDEPENDS:akonadi-search = " \
 akonadi-mime \
 akonadi-server \
 glibc \
 kf6-kcalendarcore \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-krunner \
 kf6-kwidgetsaddons \
 kmime \
 ktextaddons-qt6 \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 xapian-core-libs \
 "
RDEPENDS:akonadi-search-devel = " \
 akonadi-mime-devel \
 akonadi-search \
 akonadi-server-devel \
 cmake-filesystem \
 kf6-kcalendarcore-devel \
 kf6-kcontacts-devel \
 kf6-kcoreaddons-devel \
 kmime-devel \
 qt6-qtbase-devel \
 "
RDEPENDS:akonadi-search-doc = " \
 "
