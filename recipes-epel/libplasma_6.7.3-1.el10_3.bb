# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libplasma"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 libplasma \
 libplasma-devel \
 libplasma-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libplasma-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9efc1e868ca60f4b3f04219ff91b66d2658c396a68d3c43721a3e3ba09cfdaa9"

URI_x86_64_v2_libplasma = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libplasma-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libplasma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libplasma}"
SRC_URI[x86_64_v2_libplasma.sha256sum] = "773ac74b42accd3adece83bf7080358a654f102297b6a2809902b4d7c4de6954"

URI_x86_64_v2_libplasma-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libplasma-devel-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libplasma-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libplasma-devel}"
SRC_URI[x86_64_v2_libplasma-devel.sha256sum] = "0a5f51ffe9aaebcf7f22a1ebf322989b8ba82dab238303a30b81682ee21c4077"

URI_x86_64_v2_libplasma-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libplasma-doc-6.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_libplasma-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libplasma-doc}"
SRC_URI[x86_64_v2_libplasma-doc.sha256sum] = "4abafcee1212c1c0b37d23cb9b8c63f6d3b8586dcdc435d04016267e6d9d33e1"

URI_aarch64_libplasma = "${EPEL_MIRROR}/aarch64/Packages/l/libplasma-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_libplasma;unpack=0"
SRC_URI:append = " ${URI_aarch64_libplasma}"
SRC_URI[aarch64_libplasma.sha256sum] = "ca3541674999393b942ec28ef80c8d98dbfc5fe61ce832fac1524962da5f7436"

URI_aarch64_libplasma-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libplasma-devel-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_libplasma-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libplasma-devel}"
SRC_URI[aarch64_libplasma-devel.sha256sum] = "c885b84b0972e719294e812fd64150280664f568acbe0647d0dee0f126a3f058"

URI_aarch64_libplasma-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libplasma-doc-6.7.3-1.el10_3.noarch.rpm;name=aarch64_libplasma-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libplasma-doc}"
SRC_URI[aarch64_libplasma-doc.sha256sum] = "6c4e9a184f1ae8290b6b915cdcf184c99ae46af32ee546005bb66cb64e49c93b"

RDEPENDS:libplasma = " \
 glibc \
 kf6-filesystem \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-knotifications \
 kf6-kpackage \
 kf6-ksvg \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libX11 \
 libglvnd-egl \
 libglvnd-glx \
 libglvnd-opengl \
 libstdc++ \
 libwayland-client \
 libxcb \
 plasma-activities \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:libplasma-devel = " \
 cmake-filesystem \
 kf6-kirigami-devel \
 kf6-kpackage-devel \
 kf6-kwindowsystem-devel \
 libplasma \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 "
RDEPENDS:libplasma-doc = " \
 "
