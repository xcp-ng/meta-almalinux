# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-indexmap"
PV = "2.13.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-indexmap+arbitrary-devel \
 rust-indexmap+default-devel \
 rust-indexmap+quickcheck-devel \
 rust-indexmap+rayon-devel \
 rust-indexmap+serde-devel \
 rust-indexmap+std-devel \
 rust-indexmap+test_debug-devel \
 rust-indexmap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-indexmap-2.13.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6bedf5c7da6397c83a4974dc1d03ee5d55f328193a2f7018c2852e49d0ca0216"

URI_x86_64_v2_rust-indexmap+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+arbitrary-devel-2.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-indexmap+arbitrary-devel.sha256sum] = "eaba18c02c9e58a095fd9d495fdcd33c43af9960f47745c530696298bf4693c2"

URI_x86_64_v2_rust-indexmap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+default-devel-2.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap+default-devel}"
SRC_URI[x86_64_v2_rust-indexmap+default-devel.sha256sum] = "8477e5e3514272d1ca0c5bc5a47bf9a88c519c7ecadacf10d70280dbae161e8d"
RPROVIDES:rust-indexmap+default-devel:x86_64_v2 = "virtual/crate_indexmap/default__ge_1.6.0_with_crate_indexmap/default__lt_3.0.0~"

URI_x86_64_v2_rust-indexmap+quickcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+quickcheck-devel-2.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap+quickcheck-devel}"
SRC_URI[x86_64_v2_rust-indexmap+quickcheck-devel.sha256sum] = "3fdbb2d6877b661f5bf930d6521baee19e3f0f2f7f1da3618eae45568376828d"

URI_x86_64_v2_rust-indexmap+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+rayon-devel-2.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap+rayon-devel}"
SRC_URI[x86_64_v2_rust-indexmap+rayon-devel.sha256sum] = "ebe0151cf6394666da5831e5ba6dfbb35b742211c8252ec5be731073c49adc7e"

URI_x86_64_v2_rust-indexmap+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+serde-devel-2.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap+serde-devel}"
SRC_URI[x86_64_v2_rust-indexmap+serde-devel.sha256sum] = "956847e9412ea3b1844deaefd0f7787a30c0d7737ef27819ef09db9266c779e1"

URI_x86_64_v2_rust-indexmap+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+std-devel-2.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap+std-devel}"
SRC_URI[x86_64_v2_rust-indexmap+std-devel.sha256sum] = "2928244b714c90447b8c3e0be1d17566dcedccc10ec9e18483b1298587b9fdba"

URI_x86_64_v2_rust-indexmap+test_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+test_debug-devel-2.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+test_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap+test_debug-devel}"
SRC_URI[x86_64_v2_rust-indexmap+test_debug-devel.sha256sum] = "2c17a2a651ab2cd6a55a392b8bfd4f65971bd39695a81efa0eb67f1e4808f8f0"

URI_x86_64_v2_rust-indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap-devel-2.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap-devel}"
SRC_URI[x86_64_v2_rust-indexmap-devel.sha256sum] = "2840b685f99a9cef4e2e9ca830d8dd8eeffe54c2e44f62a89062ad18517df9fa"

URI_aarch64_rust-indexmap+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+arbitrary-devel-2.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-indexmap+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap+arbitrary-devel}"
SRC_URI[aarch64_rust-indexmap+arbitrary-devel.sha256sum] = "a80d2f37c9b6772ef09731414f449f0ad29ca67a202053f922cc690f37c31af5"

URI_aarch64_rust-indexmap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+default-devel-2.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-indexmap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap+default-devel}"
SRC_URI[aarch64_rust-indexmap+default-devel.sha256sum] = "1604d3b10e1855c3dc6fd64d61835bd6e35afe71575512386f4636b14f8dd057"
RPROVIDES:rust-indexmap+default-devel:aarch64 = "virtual/crate_indexmap/default__ge_1.6.0_with_crate_indexmap/default__lt_3.0.0~"

URI_aarch64_rust-indexmap+quickcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+quickcheck-devel-2.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-indexmap+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap+quickcheck-devel}"
SRC_URI[aarch64_rust-indexmap+quickcheck-devel.sha256sum] = "1419c11947b6a5e31411c331467b84ca13d765b6bb218c56f525812bbce6a6ac"

URI_aarch64_rust-indexmap+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+rayon-devel-2.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-indexmap+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap+rayon-devel}"
SRC_URI[aarch64_rust-indexmap+rayon-devel.sha256sum] = "c69ffe3157fe607746e70ad9f7302c221f5e9a460165415f235a6b214c6b0525"

URI_aarch64_rust-indexmap+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+serde-devel-2.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-indexmap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap+serde-devel}"
SRC_URI[aarch64_rust-indexmap+serde-devel.sha256sum] = "cbcb19fa062d31d7bad7dc009c949c89019478361c8249ab7758a2d01c5461ca"

URI_aarch64_rust-indexmap+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+std-devel-2.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-indexmap+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap+std-devel}"
SRC_URI[aarch64_rust-indexmap+std-devel.sha256sum] = "3756cf6e7f5c1d0caf579d5a8982e0957d3b64cf6c1ccf757e76fb2a1165e1b7"

URI_aarch64_rust-indexmap+test_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+test_debug-devel-2.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-indexmap+test_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap+test_debug-devel}"
SRC_URI[aarch64_rust-indexmap+test_debug-devel.sha256sum] = "b57b66117624ee283d5be9162b8036ff633daaa7a324fb106513eb0eadcd7d1b"

URI_aarch64_rust-indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap-devel-2.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap-devel}"
SRC_URI[aarch64_rust-indexmap-devel.sha256sum] = "c622ea12e508c2ca819682692792cd85d2972571c543d94f090d1e6160f3ebff"

RDEPENDS:rust-indexmap+arbitrary-devel = " \
 cargo \
 rust-arbitrary-devel \
 rust-indexmap-devel \
 "
RDEPENDS:rust-indexmap+default-devel = " \
 cargo \
 rust-indexmap+std-devel \
 rust-indexmap-devel \
 "
RDEPENDS:rust-indexmap+quickcheck-devel = " \
 cargo \
 rust-indexmap-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-indexmap+rayon-devel = " \
 cargo \
 rust-indexmap-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-indexmap+serde-devel = " \
 cargo \
 rust-indexmap-devel \
 rust-serde-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-indexmap+std-devel = " \
 cargo \
 rust-indexmap-devel \
 "
RDEPENDS:rust-indexmap+test_debug-devel = " \
 cargo \
 rust-indexmap-devel \
 "
RDEPENDS:rust-indexmap-devel = " \
 cargo \
 rust \
 rust-equivalent-devel \
 rust-hashbrown-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_indexmap/default__ge_1.6.0_with_crate_indexmap/default__lt_3.0.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_indexmap/default__ge_1.6.0_with_crate_indexmap/default__lt_3.0.0~"
