# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-wayland-protocols"
PV = "1.18.0"
PR = "1.el10_1"
PACKAGES = " \
 plasma-wayland-protocols \
 plasma-wayland-protocols-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-wayland-protocols-1.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b971f8d39658c13ed9a9bd07d88302d854f86e0642423ce0fc2fe83768855523"

URI_x86_64_v2_plasma-wayland-protocols = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-wayland-protocols-1.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-wayland-protocols;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-wayland-protocols}"
SRC_URI[x86_64_v2_plasma-wayland-protocols.sha256sum] = "e0f4109b964279421642cc65c28d355f755a2428c235b6536a0d936d6028735a"

URI_x86_64_v2_plasma-wayland-protocols-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-wayland-protocols-devel-1.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-wayland-protocols-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-wayland-protocols-devel}"
SRC_URI[x86_64_v2_plasma-wayland-protocols-devel.sha256sum] = "e93d7c4ef981d371baef4a1a6c7b07bc9e2c91e99363a251e6f65277e1d16a32"

URI_aarch64_plasma-wayland-protocols = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-wayland-protocols-1.18.0-1.el10_1.aarch64.rpm;name=aarch64_plasma-wayland-protocols;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-wayland-protocols}"
SRC_URI[aarch64_plasma-wayland-protocols.sha256sum] = "9e32f6b808dcfa86559ed7967644f24321c863f2dc62c134333f82b7e8d31236"

URI_aarch64_plasma-wayland-protocols-devel = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-wayland-protocols-devel-1.18.0-1.el10_1.aarch64.rpm;name=aarch64_plasma-wayland-protocols-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-wayland-protocols-devel}"
SRC_URI[aarch64_plasma-wayland-protocols-devel.sha256sum] = "e45f0d5559a65c2aa8db0046072ae59db1aa0bcb0e1e8a38c1b42156001a3804"

RDEPENDS:plasma-wayland-protocols = " \
 "
RDEPENDS:plasma-wayland-protocols-devel = " \
 cmake-filesystem \
 plasma-wayland-protocols \
 "
