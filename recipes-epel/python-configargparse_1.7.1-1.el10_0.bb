# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-configargparse"
PV = "1.7.1"
PR = "1.el10_0"
PACKAGES = " \
 python3-configargparse \
 python3-configargparse+yaml \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-configargparse-1.7.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0070ec0523676a7aeced47129708ee96cd2868e1d85e9af928b96a95918e8577"

URI_x86_64_v2_python3-configargparse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-configargparse-1.7.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-configargparse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-configargparse}"
SRC_URI[x86_64_v2_python3-configargparse.sha256sum] = "e2fa728b730d61082fc7a9f465044da5eb38fbb4481296ce38aa04026c1f7f17"

URI_x86_64_v2_python3-configargparse+yaml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-configargparse+yaml-1.7.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-configargparse+yaml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-configargparse+yaml}"
SRC_URI[x86_64_v2_python3-configargparse+yaml.sha256sum] = "44736be40fb28694de5d984a7ca4f4135a1c2de0776665169d54021b6fe55318"

URI_aarch64_python3-configargparse = "${EPEL_MIRROR}/aarch64/Packages/p/python3-configargparse-1.7.1-1.el10_0.noarch.rpm;name=aarch64_python3-configargparse;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-configargparse}"
SRC_URI[aarch64_python3-configargparse.sha256sum] = "d1d07c08399cebe88bbab98fb902037890342a74fc1a61cd0cebac379141eaaf"

URI_aarch64_python3-configargparse+yaml = "${EPEL_MIRROR}/aarch64/Packages/p/python3-configargparse+yaml-1.7.1-1.el10_0.noarch.rpm;name=aarch64_python3-configargparse+yaml;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-configargparse+yaml}"
SRC_URI[aarch64_python3-configargparse+yaml.sha256sum] = "e2503ec29c9744b52f3078153ba33963abb1786220901232eb4a8bc00d5d8d6c"

RDEPENDS:python3-configargparse = " \
 python3 \
 "
RDEPENDS:python3-configargparse+yaml = " \
 python3 \
 python3-configargparse \
 python3-pyyaml \
 "
