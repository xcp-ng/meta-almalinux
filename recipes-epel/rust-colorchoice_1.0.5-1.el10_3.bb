# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-colorchoice"
PV = "1.0.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-colorchoice+default-devel \
 rust-colorchoice-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-colorchoice-1.0.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a58b9db4ded773c1c67d50344b4c456262cf6ebb306e2240d4fe91d2bcc862cf"

URI_x86_64_v2_rust-colorchoice+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-colorchoice+default-devel-1.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-colorchoice+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-colorchoice+default-devel}"
SRC_URI[x86_64_v2_rust-colorchoice+default-devel.sha256sum] = "f9aef0833c481678e70cd54e53064926df106350c9ab664da4924e01709e14b2"

URI_x86_64_v2_rust-colorchoice-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-colorchoice-devel-1.0.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-colorchoice-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-colorchoice-devel}"
SRC_URI[x86_64_v2_rust-colorchoice-devel.sha256sum] = "ced8014b8abbb71de4bca7832fd947ae944ea5c20d4498f04feb3eb7f42d8b5d"

URI_aarch64_rust-colorchoice+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-colorchoice+default-devel-1.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-colorchoice+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-colorchoice+default-devel}"
SRC_URI[aarch64_rust-colorchoice+default-devel.sha256sum] = "efaddb6b772db558d2f28387eaf91532570204a8cd94967a27c7a51dcfe297c3"

URI_aarch64_rust-colorchoice-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-colorchoice-devel-1.0.5-1.el10_3.noarch.rpm;name=aarch64_rust-colorchoice-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-colorchoice-devel}"
SRC_URI[aarch64_rust-colorchoice-devel.sha256sum] = "b1bada05b2044f3fcf15087f7b9d869244c800e0a785e293a0fa2e245cef2d6c"

RDEPENDS:rust-colorchoice+default-devel = " \
 cargo \
 rust-colorchoice-devel \
 "
RDEPENDS:rust-colorchoice-devel = " \
 cargo \
 rust \
 "
