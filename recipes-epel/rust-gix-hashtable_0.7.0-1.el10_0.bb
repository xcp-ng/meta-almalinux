# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-hashtable"
PV = "0.7.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-hashtable+default-devel \
 rust-gix-hashtable-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-hashtable-0.7.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a78e9f18052ca1696878b425eeeec3b415c92355039f3bcdc46579b03bcfd54"

URI_x86_64_v2_rust-gix-hashtable+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-hashtable+default-devel-0.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-hashtable+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-hashtable+default-devel}"
SRC_URI[x86_64_v2_rust-gix-hashtable+default-devel.sha256sum] = "1f75cb82ca6541caaa3c277af5b9fb409d84e3d4e0e1fbd5a7dbcdcec0260657"

URI_x86_64_v2_rust-gix-hashtable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-hashtable-devel-0.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-hashtable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-hashtable-devel}"
SRC_URI[x86_64_v2_rust-gix-hashtable-devel.sha256sum] = "eba4e3733487665945d55be96afa816ff8f3e354619fff547fe0868ea6611dd3"

URI_aarch64_rust-gix-hashtable+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-hashtable+default-devel-0.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-hashtable+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-hashtable+default-devel}"
SRC_URI[aarch64_rust-gix-hashtable+default-devel.sha256sum] = "abbc77772e6b26d3194cde2d6980bcafd8a72853685e3d82078badc25ae5a53e"

URI_aarch64_rust-gix-hashtable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-hashtable-devel-0.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-hashtable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-hashtable-devel}"
SRC_URI[aarch64_rust-gix-hashtable-devel.sha256sum] = "c16fbdf3025295b2094065301ce484513b9ccf907a3c2a103b655103b08acf69"

RDEPENDS:rust-gix-hashtable+default-devel = " \
 cargo \
 rust-gix-hashtable-devel \
 "
RDEPENDS:rust-gix-hashtable-devel = " \
 cargo \
 rust \
 rust-gix-hash+default-devel \
 rust-hashbrown0.14+inline-more-devel \
 rust-hashbrown0.14+raw-devel \
 rust-hashbrown0.14-devel \
 rust-parking_lot+default-devel \
 "
