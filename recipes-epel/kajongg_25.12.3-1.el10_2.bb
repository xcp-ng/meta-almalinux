# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kajongg"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kajongg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kajongg-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d35db7b861d1f563941432386407c36581362ea269f97a39779a233ae6ce6f4"

URI_x86_64_v2_kajongg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kajongg-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kajongg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kajongg}"
SRC_URI[x86_64_v2_kajongg.sha256sum] = "bd78acf7fd8b7df7ceb535e5f899f71f73c3b99d81b902b7f58c945d7c46df4f"

URI_aarch64_kajongg = "${EPEL_MIRROR}/aarch64/Packages/k/kajongg-25.12.3-1.el10_2.noarch.rpm;name=aarch64_kajongg;unpack=0"
SRC_URI:append = " ${URI_aarch64_kajongg}"
SRC_URI[aarch64_kajongg.sha256sum] = "813744c32fc8b34cc606990bcef2d7a34a17f27205ec6f75e74b2844441a2dae"

RDEPENDS:kajongg = " \
 libkmahjongg-data \
 python3 \
 python3-QtPy \
 python3-pyqt6 \
 python3-twisted \
 vorbis-tools \
 "
