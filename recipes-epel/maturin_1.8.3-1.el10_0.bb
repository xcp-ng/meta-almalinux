# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "maturin"
PV = "1.8.3"
PR = "1.el10_0"
PACKAGES = " \
 maturin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/maturin-1.8.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b7c1cfbdcdf0ff79140e07f79fcddee8c07e6799f6bdfd9135984322f906aa83"

URI_x86_64_v2_maturin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/maturin-1.8.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_maturin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maturin}"
SRC_URI[x86_64_v2_maturin.sha256sum] = "e9affcabbbb036788c62dabd190534f197d3b8a18a042a4a487d93111e8790e6"

URI_aarch64_maturin = "${EPEL_MIRROR}/aarch64/Packages/m/maturin-1.8.3-1.el10_0.aarch64.rpm;name=aarch64_maturin;unpack=0"
SRC_URI:append = " ${URI_aarch64_maturin}"
SRC_URI[aarch64_maturin.sha256sum] = "47c4c0e4ed1da1db3d76150749a3ebc760fa0c8efcd8df165887c652d51742b3"

RDEPENDS:maturin = " \
 bzip2-libs \
 glibc \
 libgcc \
 python3 \
 "
