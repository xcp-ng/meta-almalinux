# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyasn1"
PV = "0.6.4"
PR = "1.el10"
PACKAGES = " \
 python3-pyasn1 \
 python3-pyasn1-modules \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-pyasn1-0.6.4-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df7b03e3e8f093505a997d7a9403c313a82ace683026a476efd60fc38d615c85"

URI_x86_64_v2_python3-pyasn1 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pyasn1-0.6.4-1.el10.noarch.rpm;name=x86_64_v2_python3-pyasn1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyasn1}"
SRC_URI[x86_64_v2_python3-pyasn1.sha256sum] = "92e39138a35fff67373a97130e7bc1cf1116b6dd66a7518844f5e4422f932788"

URI_x86_64_v2_python3-pyasn1-modules = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pyasn1-modules-0.6.4-1.el10.noarch.rpm;name=x86_64_v2_python3-pyasn1-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyasn1-modules}"
SRC_URI[x86_64_v2_python3-pyasn1-modules.sha256sum] = "87f76e6dc4643199b5dcbbe59fd2205e7c21053fc21e7d05f378d774e5e145d5"

URI_aarch64_python3-pyasn1 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pyasn1-0.6.4-1.el10.noarch.rpm;name=aarch64_python3-pyasn1;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyasn1}"
SRC_URI[aarch64_python3-pyasn1.sha256sum] = "92e39138a35fff67373a97130e7bc1cf1116b6dd66a7518844f5e4422f932788"

URI_aarch64_python3-pyasn1-modules = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pyasn1-modules-0.6.4-1.el10.noarch.rpm;name=aarch64_python3-pyasn1-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyasn1-modules}"
SRC_URI[aarch64_python3-pyasn1-modules.sha256sum] = "87f76e6dc4643199b5dcbbe59fd2205e7c21053fc21e7d05f378d774e5e145d5"

RDEPENDS:python3-pyasn1 = " \
 python3 \
 "
RDEPENDS:python3-pyasn1-modules = " \
 python3 \
 python3-pyasn1 \
 "
