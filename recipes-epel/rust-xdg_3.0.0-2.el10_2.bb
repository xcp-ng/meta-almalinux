# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-xdg"
PV = "3.0.0"
PR = "2.el10_2"
PACKAGES = " \
 rust-xdg+default-devel \
 rust-xdg+serde-devel \
 rust-xdg-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-xdg-3.0.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "941f500216a6be89d5e10d849688d4c7224dfc2848ce117820d421f067681e5a"

URI_x86_64_v2_rust-xdg+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xdg+default-devel-3.0.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xdg+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xdg+default-devel}"
SRC_URI[x86_64_v2_rust-xdg+default-devel.sha256sum] = "3ef030edda2d39c0e9bebfa0ba6519a1ac46649d2951c402f1fbb456f6bc7b02"

URI_x86_64_v2_rust-xdg+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xdg+serde-devel-3.0.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xdg+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xdg+serde-devel}"
SRC_URI[x86_64_v2_rust-xdg+serde-devel.sha256sum] = "a049dd9366e5a3241d610279ce26abf92d9d53ece1b31c318984d67031bc999f"

URI_x86_64_v2_rust-xdg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xdg-devel-3.0.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xdg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xdg-devel}"
SRC_URI[x86_64_v2_rust-xdg-devel.sha256sum] = "81448619c135920addefec73c6aad8e88628e998592f725f4431d4f4e2b0fa98"

URI_aarch64_rust-xdg+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xdg+default-devel-3.0.0-2.el10_2.noarch.rpm;name=aarch64_rust-xdg+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xdg+default-devel}"
SRC_URI[aarch64_rust-xdg+default-devel.sha256sum] = "e19c2a89779d6bd8ea2adc11265606505003cdb431c3f577e4a86ba20c8dd477"

URI_aarch64_rust-xdg+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xdg+serde-devel-3.0.0-2.el10_2.noarch.rpm;name=aarch64_rust-xdg+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xdg+serde-devel}"
SRC_URI[aarch64_rust-xdg+serde-devel.sha256sum] = "10c1ac47b58c7dc78a4e40e58a881c20441c652559d8cd834f519291067953d7"

URI_aarch64_rust-xdg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xdg-devel-3.0.0-2.el10_2.noarch.rpm;name=aarch64_rust-xdg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xdg-devel}"
SRC_URI[aarch64_rust-xdg-devel.sha256sum] = "2e5baad8aa4803fd9de4bf081104c399ff1d50be636667a7f395e6b033348cb9"

RDEPENDS:rust-xdg+default-devel = " \
 cargo \
 rust-xdg-devel \
 "
RDEPENDS:rust-xdg+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-xdg-devel \
 "
RDEPENDS:rust-xdg-devel = " \
 cargo \
 rust \
 "
