# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-matrixcompare"
PV = "0.3.0"
PR = "14.el10_1"
PACKAGES = " \
 rust-matrixcompare+default-devel \
 rust-matrixcompare+proptest-devel \
 rust-matrixcompare+proptest-support-devel \
 rust-matrixcompare-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-matrixcompare-0.3.0-14.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4976c774e3d0348987fec20589351354dd0c1124486ca199f2984f0525c7c8b6"

URI_x86_64_v2_rust-matrixcompare+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matrixcompare+default-devel-0.3.0-14.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matrixcompare+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matrixcompare+default-devel}"
SRC_URI[x86_64_v2_rust-matrixcompare+default-devel.sha256sum] = "c89e7cfc5d1c33a772b4d1eca02140e05b68e20df7e618e69d2a1a80a7b55c30"

URI_x86_64_v2_rust-matrixcompare+proptest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matrixcompare+proptest-devel-0.3.0-14.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matrixcompare+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matrixcompare+proptest-devel}"
SRC_URI[x86_64_v2_rust-matrixcompare+proptest-devel.sha256sum] = "76d4309f2b1c1870da36437d9fef5701cde860221cd83fd65fd885aabb5e3084"

URI_x86_64_v2_rust-matrixcompare+proptest-support-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matrixcompare+proptest-support-devel-0.3.0-14.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matrixcompare+proptest-support-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matrixcompare+proptest-support-devel}"
SRC_URI[x86_64_v2_rust-matrixcompare+proptest-support-devel.sha256sum] = "d45d8adc39be1773f9e40337a6cab5f5ba386933c95532fd87a2748672ee4010"

URI_x86_64_v2_rust-matrixcompare-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matrixcompare-devel-0.3.0-14.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matrixcompare-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matrixcompare-devel}"
SRC_URI[x86_64_v2_rust-matrixcompare-devel.sha256sum] = "09fa67cb45c6a38b2e14bd7e9f02c56a727e50529563dadeb7bc61993aee4e23"

URI_aarch64_rust-matrixcompare+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matrixcompare+default-devel-0.3.0-14.el10_1.noarch.rpm;name=aarch64_rust-matrixcompare+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matrixcompare+default-devel}"
SRC_URI[aarch64_rust-matrixcompare+default-devel.sha256sum] = "7684c00fa66ba9a667e45e0bc1108707faa027dd8fe8b3d3b5a7603b17978d4c"

URI_aarch64_rust-matrixcompare+proptest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matrixcompare+proptest-devel-0.3.0-14.el10_1.noarch.rpm;name=aarch64_rust-matrixcompare+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matrixcompare+proptest-devel}"
SRC_URI[aarch64_rust-matrixcompare+proptest-devel.sha256sum] = "e3402ba835bcda94b420ac79bdef76ae7bd0a77336364d281f7a5635e04a8d3b"

URI_aarch64_rust-matrixcompare+proptest-support-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matrixcompare+proptest-support-devel-0.3.0-14.el10_1.noarch.rpm;name=aarch64_rust-matrixcompare+proptest-support-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matrixcompare+proptest-support-devel}"
SRC_URI[aarch64_rust-matrixcompare+proptest-support-devel.sha256sum] = "50d4820d9f00e535b0243c80ab77f24ff1a773d99eea925575e1b52040ba997a"

URI_aarch64_rust-matrixcompare-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matrixcompare-devel-0.3.0-14.el10_1.noarch.rpm;name=aarch64_rust-matrixcompare-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matrixcompare-devel}"
SRC_URI[aarch64_rust-matrixcompare-devel.sha256sum] = "c84a360b968ee4f5124daa13b9091d89c368e97d3503a9f3c5515dc518e51f17"

RDEPENDS:rust-matrixcompare+default-devel = " \
 cargo \
 rust-matrixcompare-devel \
 "
RDEPENDS:rust-matrixcompare+proptest-devel = " \
 cargo \
 rust-matrixcompare-devel \
 rust-proptest+default-devel \
 "
RDEPENDS:rust-matrixcompare+proptest-support-devel = " \
 cargo \
 rust-matrixcompare+proptest-devel \
 rust-matrixcompare-devel \
 "
RDEPENDS:rust-matrixcompare-devel = " \
 cargo \
 rust-matrixcompare-core+default-devel \
 rust-num-traits-devel \
 "
