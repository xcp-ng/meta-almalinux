# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-probe"
PV = "0.5.1"
PR = "5.el10_0"
PACKAGES = " \
 rust-probe+default-devel \
 rust-probe-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-probe-0.5.1-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f2dbe7085e3cac701f531d1d5032d42b2b8bbe71490a773b26e56e83d28358c3"

URI_x86_64_v2_rust-probe+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-probe+default-devel-0.5.1-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-probe+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-probe+default-devel}"
SRC_URI[x86_64_v2_rust-probe+default-devel.sha256sum] = "129d3c568070e7d1883035c238671031c7c59582d819918471a31f060c7af8e2"

URI_x86_64_v2_rust-probe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-probe-devel-0.5.1-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-probe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-probe-devel}"
SRC_URI[x86_64_v2_rust-probe-devel.sha256sum] = "99d0c1945919421becae38dca861eb750598e90f99edef715df754da8787b8aa"

URI_aarch64_rust-probe+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-probe+default-devel-0.5.1-5.el10_0.noarch.rpm;name=aarch64_rust-probe+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-probe+default-devel}"
SRC_URI[aarch64_rust-probe+default-devel.sha256sum] = "824a29ffd808b1097b6ed37ac64b739bc1ea93b29556e8321b808b9b63cca6b6"

URI_aarch64_rust-probe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-probe-devel-0.5.1-5.el10_0.noarch.rpm;name=aarch64_rust-probe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-probe-devel}"
SRC_URI[aarch64_rust-probe-devel.sha256sum] = "0f9a98bf3a5dec90f2c38381c8e4ffb54c19190f2d5f9144e4425844aaf40921"

RDEPENDS:rust-probe+default-devel = " \
 cargo \
 rust-probe-devel \
 "
RDEPENDS:rust-probe-devel = " \
 cargo \
 rust \
 "
