# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-HTML-Selector-XPath"
PV = "0.28"
PR = "1.el10_0"
PACKAGES = " \
 perl-HTML-Selector-XPath \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-HTML-Selector-XPath-0.28-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c602051fe465476993a72bdf2e57b5d2394f7ec1c3320bc3b0e6953c6e8a2a45"

URI_x86_64_v2_perl-HTML-Selector-XPath = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-HTML-Selector-XPath-0.28-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-HTML-Selector-XPath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-HTML-Selector-XPath}"
SRC_URI[x86_64_v2_perl-HTML-Selector-XPath.sha256sum] = "a44e1e3f926e53fdc7afe53c70ec092d280cc3c57119d0142db566e9cf128d58"

URI_aarch64_perl-HTML-Selector-XPath = "${EPEL_MIRROR}/aarch64/Packages/p/perl-HTML-Selector-XPath-0.28-1.el10_0.noarch.rpm;name=aarch64_perl-HTML-Selector-XPath;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-HTML-Selector-XPath}"
SRC_URI[aarch64_perl-HTML-Selector-XPath.sha256sum] = "61b568b1c27060dba6b41d11a7b8383e08d3f228c768f202a01fffce49e39b8c"

RDEPENDS:perl-HTML-Selector-XPath = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
