# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "psacct"
PV = "6.6.4"
PR = "25.el10"
PACKAGES = " \
 psacct \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/psacct-6.6.4-25.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d087b197becf051773800579152ec890c67115d5299267c121676988b09f0ef9"

URI_x86_64_v2_psacct = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/psacct-6.6.4-25.el10.x86_64_v2.rpm;name=x86_64_v2_psacct;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_psacct}"
SRC_URI[x86_64_v2_psacct.sha256sum] = "d9235e473ed0ba74d64ac5ee2c1c3b5274f08b146354bfe2615decadd13a0fc7"

URI_aarch64_psacct = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/psacct-6.6.4-25.el10.aarch64.rpm;name=aarch64_psacct;unpack=0"
SRC_URI:append = " ${URI_aarch64_psacct}"
SRC_URI[aarch64_psacct.sha256sum] = "fc1a43a0f3f8210f37c24c27869834ee3595b3ca152ea01722d0cbecf54ecec4"

RDEPENDS:psacct = " \
 bash \
 glibc \
 systemd \
 virtual/coreutils \
 "
