# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aqute-bnd"
PV = "6.3.1"
PR = "11.el10"
PACKAGES = " \
 aqute-bnd \
 aqute-bnd-javadoc \
 aqute-bndlib \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/aqute-bnd-6.3.1-11.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4462ec46938821d7b4269ea5b06fcaf1cadcb07874559a06f357adc0053eba5b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/aqute-bnd-6.3.1-11.el10.noarch.rpm;name=x86_64_v2_aqute-bnd;unpack=0"
SRC_URI[x86_64_v2_aqute-bnd.sha256sum] = "7e9fbdcbea0cb65a39125a89dda614f3c538c3517206a99fd7b40a089f708ee3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/aqute-bnd-javadoc-6.3.1-11.el10.noarch.rpm;name=x86_64_v2_aqute-bnd-javadoc;unpack=0"
SRC_URI[x86_64_v2_aqute-bnd-javadoc.sha256sum] = "73cac28a410a3c6386e23e3fa24671d8fc0723fb3567e5d82625d0b21b80ddac"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/aqute-bndlib-6.3.1-11.el10.noarch.rpm;name=x86_64_v2_aqute-bndlib;unpack=0"
SRC_URI[x86_64_v2_aqute-bndlib.sha256sum] = "d4fd269de309e3ba56aa470a75ee80aa87ee156aa1175d3faf6970f533714b37"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/aqute-bnd-6.3.1-11.el10.noarch.rpm;name=aarch64_aqute-bnd;unpack=0"
SRC_URI[aarch64_aqute-bnd.sha256sum] = "7e9fbdcbea0cb65a39125a89dda614f3c538c3517206a99fd7b40a089f708ee3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/aqute-bnd-javadoc-6.3.1-11.el10.noarch.rpm;name=aarch64_aqute-bnd-javadoc;unpack=0"
SRC_URI[aarch64_aqute-bnd-javadoc.sha256sum] = "73cac28a410a3c6386e23e3fa24671d8fc0723fb3567e5d82625d0b21b80ddac"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/aqute-bndlib-6.3.1-11.el10.noarch.rpm;name=aarch64_aqute-bndlib;unpack=0"
SRC_URI[aarch64_aqute-bndlib.sha256sum] = "d4fd269de309e3ba56aa470a75ee80aa87ee156aa1175d3faf6970f533714b37"

RDEPENDS:aqute-bnd = " \
 ant-lib \
 aqute-bndlib \
 bash \
 javapackages-filesystem \
 javapackages-tools \
 osgi-annotation \
 slf4j \
 "
RDEPENDS:aqute-bnd-javadoc = " \
 javapackages-filesystem \
 "
RDEPENDS:aqute-bndlib = " \
 aqute-bnd \
 javapackages-filesystem \
 osgi-annotation \
 osgi-compendium \
 osgi-core \
 slf4j \
 "
