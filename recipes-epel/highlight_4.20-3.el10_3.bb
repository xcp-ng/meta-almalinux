# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "highlight"
PV = "4.20"
PR = "3.el10_3"
PACKAGES = " \
 highlight \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/highlight-4.20-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69721527005753c9255995b7ae4f714ed67f44ddfbe23cf14c174b5099c7664c"

URI_x86_64_v2_highlight = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/highlight-4.20-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_highlight;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_highlight}"
SRC_URI[x86_64_v2_highlight.sha256sum] = "98c0407065ff3d8196696249951284dc6fa5d85135d8c2372bc86a45c2423c70"

URI_aarch64_highlight = "${EPEL_MIRROR}/aarch64/Packages/h/highlight-4.20-3.el10_3.aarch64.rpm;name=aarch64_highlight;unpack=0"
SRC_URI:append = " ${URI_aarch64_highlight}"
SRC_URI[aarch64_highlight.sha256sum] = "c5cdd22aa90ad5b515046861f3801cbcd2621c8cb1d4d9b71663560f900b4241"

RDEPENDS:highlight = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 lua-libs \
 "
