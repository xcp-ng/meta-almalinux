# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "khard"
PV = "0.19.1"
PR = "4.el10_0"
PACKAGES = " \
 khard \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/khard-0.19.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eb9c389c1cbdde4970669e6fca24510b6ec43d18aeda72d8efcf5cfd86f6174a"

URI_x86_64_v2_khard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/khard-0.19.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_khard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_khard}"
SRC_URI[x86_64_v2_khard.sha256sum] = "d0cc679438d7f73037e7d17df7539c50ec19274d5bc155ad4b2fd14d12dcd749"

URI_aarch64_khard = "${EPEL_MIRROR}/aarch64/Packages/k/khard-0.19.1-4.el10_0.noarch.rpm;name=aarch64_khard;unpack=0"
SRC_URI:append = " ${URI_aarch64_khard}"
SRC_URI[aarch64_khard.sha256sum] = "8cbec4d2695fe43e74596f2e44d0d701b5656ecb4d8b0c19c14baf598c7d6214"

RDEPENDS:khard = " \
 python3 \
 python3-atomicwrites \
 python3-configobj \
 python3-ruamel-yaml \
 python3-unidecode \
 python3-vobject \
 "
