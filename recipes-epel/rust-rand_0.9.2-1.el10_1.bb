# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand"
PV = "0.9.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-rand+alloc-devel \
 rust-rand+default-devel \
 rust-rand+log-devel \
 rust-rand+os_rng-devel \
 rust-rand+serde-devel \
 rust-rand+small_rng-devel \
 rust-rand+std-devel \
 rust-rand+std_rng-devel \
 rust-rand+thread_rng-devel \
 rust-rand+unbiased-devel \
 rust-rand-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand-0.9.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2ea9fd013578d317b2e356740e62c94f9ae4de1a2430d5078a33c20c2951ded4"

URI_x86_64_v2_rust-rand+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+alloc-devel-0.9.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+alloc-devel}"
SRC_URI[x86_64_v2_rust-rand+alloc-devel.sha256sum] = "7cc29efd18fc1e5ec617a0a68264ced70c807b35c1cefe6595847a574cdb5572"

URI_x86_64_v2_rust-rand+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+default-devel-0.9.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+default-devel}"
SRC_URI[x86_64_v2_rust-rand+default-devel.sha256sum] = "dc31bff952b0d9dc3885e94c2ffec55d95c26ee97ad9be52c813c6cca7740e4a"

URI_x86_64_v2_rust-rand+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+log-devel-0.9.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+log-devel}"
SRC_URI[x86_64_v2_rust-rand+log-devel.sha256sum] = "12c0e307330cec7a4c7ff6569f2f685da3436d14161a7f8ffaadeeba548a5db6"

URI_x86_64_v2_rust-rand+os_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+os_rng-devel-0.9.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+os_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+os_rng-devel}"
SRC_URI[x86_64_v2_rust-rand+os_rng-devel.sha256sum] = "0188d1f86bcca6d44e63ecfcb34291a4f19092daa13f047dd9f6280da5b17838"

URI_x86_64_v2_rust-rand+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+serde-devel-0.9.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+serde-devel}"
SRC_URI[x86_64_v2_rust-rand+serde-devel.sha256sum] = "75e04d6cfe666b2557d2f237ff0ba9249449da0dfaedaaaae71303426fc98ebd"

URI_x86_64_v2_rust-rand+small_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+small_rng-devel-0.9.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+small_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+small_rng-devel}"
SRC_URI[x86_64_v2_rust-rand+small_rng-devel.sha256sum] = "9c4c5ebae8d280a1bb16e94af1c799862103fbcec7c6d667f607d5b36d9fdac4"

URI_x86_64_v2_rust-rand+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+std-devel-0.9.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+std-devel}"
SRC_URI[x86_64_v2_rust-rand+std-devel.sha256sum] = "993a8ce828dad1e897b350ba67a5ae412afa13d4c78a9f7c6d153fcbf2078918"

URI_x86_64_v2_rust-rand+std_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+std_rng-devel-0.9.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+std_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+std_rng-devel}"
SRC_URI[x86_64_v2_rust-rand+std_rng-devel.sha256sum] = "d0340fd81ebc749297f68c55a5359c12145e89235eb16f03cff3c98b01da8d9c"

URI_x86_64_v2_rust-rand+thread_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+thread_rng-devel-0.9.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+thread_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+thread_rng-devel}"
SRC_URI[x86_64_v2_rust-rand+thread_rng-devel.sha256sum] = "0ddc759e76e0abbcf1ec1fe19f1eef7a99bfc678bf4f6a32177abb34454705ad"

URI_x86_64_v2_rust-rand+unbiased-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+unbiased-devel-0.9.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+unbiased-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+unbiased-devel}"
SRC_URI[x86_64_v2_rust-rand+unbiased-devel.sha256sum] = "5be24cc611a4f205d76662b7b172c4801ddf29188d1e01d37f2d83d1a1ba44e2"

URI_x86_64_v2_rust-rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand-devel-0.9.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand-devel}"
SRC_URI[x86_64_v2_rust-rand-devel.sha256sum] = "02988366ed8a9ad42776bb77085f85b5d2ba095115e069c457f2a3dda528e87d"

URI_aarch64_rust-rand+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+alloc-devel-0.9.2-1.el10_1.noarch.rpm;name=aarch64_rust-rand+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+alloc-devel}"
SRC_URI[aarch64_rust-rand+alloc-devel.sha256sum] = "c567070a493bede69824652202b2bfa919642458198cfc07fc993d144eef93b6"

URI_aarch64_rust-rand+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+default-devel-0.9.2-1.el10_1.noarch.rpm;name=aarch64_rust-rand+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+default-devel}"
SRC_URI[aarch64_rust-rand+default-devel.sha256sum] = "3e803b4c23b332d03db7871676c534854ba8ff44630cc4fa7a81dd6356df6126"

URI_aarch64_rust-rand+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+log-devel-0.9.2-1.el10_1.noarch.rpm;name=aarch64_rust-rand+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+log-devel}"
SRC_URI[aarch64_rust-rand+log-devel.sha256sum] = "3c4c185219dcdf68bf137df827e6eb0801369c4d9c5f8831277c80809a488f93"

URI_aarch64_rust-rand+os_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+os_rng-devel-0.9.2-1.el10_1.noarch.rpm;name=aarch64_rust-rand+os_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+os_rng-devel}"
SRC_URI[aarch64_rust-rand+os_rng-devel.sha256sum] = "4faa3cb3ecb58529303213c28e2d47bcc476b1874e797264a2790b43d8ee71f5"

URI_aarch64_rust-rand+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+serde-devel-0.9.2-1.el10_1.noarch.rpm;name=aarch64_rust-rand+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+serde-devel}"
SRC_URI[aarch64_rust-rand+serde-devel.sha256sum] = "a2a96b3e786a66d9b5fc2bef8c188f05a955f6c263ca3a4dd76f96db507d399d"

URI_aarch64_rust-rand+small_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+small_rng-devel-0.9.2-1.el10_1.noarch.rpm;name=aarch64_rust-rand+small_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+small_rng-devel}"
SRC_URI[aarch64_rust-rand+small_rng-devel.sha256sum] = "849ce3e416d3a59f906fa4f169c9e9d769b430f0677bb28a89efea7e76bb1488"

URI_aarch64_rust-rand+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+std-devel-0.9.2-1.el10_1.noarch.rpm;name=aarch64_rust-rand+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+std-devel}"
SRC_URI[aarch64_rust-rand+std-devel.sha256sum] = "b31780b94b86c2c956f9b6cd90f7ecc08d42b69bdf7ba43c72a39676c4abdd38"

URI_aarch64_rust-rand+std_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+std_rng-devel-0.9.2-1.el10_1.noarch.rpm;name=aarch64_rust-rand+std_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+std_rng-devel}"
SRC_URI[aarch64_rust-rand+std_rng-devel.sha256sum] = "d76c92023d9333f79616ea702c44b7b534082fe6620d9c059f0d6fc76eddd99c"

URI_aarch64_rust-rand+thread_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+thread_rng-devel-0.9.2-1.el10_1.noarch.rpm;name=aarch64_rust-rand+thread_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+thread_rng-devel}"
SRC_URI[aarch64_rust-rand+thread_rng-devel.sha256sum] = "2f81c4927a7083a9e567e0d8aa091b102e401db2cbbedac9667b09f1247928a1"

URI_aarch64_rust-rand+unbiased-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+unbiased-devel-0.9.2-1.el10_1.noarch.rpm;name=aarch64_rust-rand+unbiased-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+unbiased-devel}"
SRC_URI[aarch64_rust-rand+unbiased-devel.sha256sum] = "95d35266225fb2dc8d2534576dc2df2214c7dcc986ddae6b4b351ced94a8530b"

URI_aarch64_rust-rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand-devel-0.9.2-1.el10_1.noarch.rpm;name=aarch64_rust-rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand-devel}"
SRC_URI[aarch64_rust-rand-devel.sha256sum] = "8af051273e916ce43bcfcfa5cf11a44bf999c00003cf4198b8ae7609c5348bf4"

RDEPENDS:rust-rand+alloc-devel = " \
 cargo \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+default-devel = " \
 cargo \
 rust-rand+os_rng-devel \
 rust-rand+small_rng-devel \
 rust-rand+std-devel \
 rust-rand+std_rng-devel \
 rust-rand+thread_rng-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+os_rng-devel = " \
 cargo \
 rust-rand-devel \
 rust-rand_core+os_rng-devel \
 "
RDEPENDS:rust-rand+serde-devel = " \
 cargo \
 rust-rand-devel \
 rust-rand_core+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand+small_rng-devel = " \
 cargo \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+std-devel = " \
 cargo \
 rust-rand+alloc-devel \
 rust-rand-devel \
 rust-rand_chacha+std-devel \
 rust-rand_chacha-devel \
 rust-rand_core+std-devel \
 "
RDEPENDS:rust-rand+std_rng-devel = " \
 cargo \
 rust-rand-devel \
 rust-rand_chacha-devel \
 "
RDEPENDS:rust-rand+thread_rng-devel = " \
 cargo \
 rust-rand+os_rng-devel \
 rust-rand+std-devel \
 rust-rand+std_rng-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+unbiased-devel = " \
 cargo \
 rust-rand-devel \
 "
RDEPENDS:rust-rand-devel = " \
 cargo \
 rust \
 rust-rand_core-devel \
 "
