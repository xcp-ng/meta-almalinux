# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xmodmap"
PV = "1.0.11"
PR = "5.el10_1"
PACKAGES = " \
 xmodmap \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xmodmap-1.0.11-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b22a9751f8ee3e69e352b4338405a0b61023558edd0a57e3fc04b08699c301e0"

URI_x86_64_v2_xmodmap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xmodmap-1.0.11-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xmodmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmodmap}"
SRC_URI[x86_64_v2_xmodmap.sha256sum] = "2061b7557c371e2b8a337e571faa085948248c8cc4c1f02757fb150a998af75a"

URI_aarch64_xmodmap = "${EPEL_MIRROR}/aarch64/Packages/x/xmodmap-1.0.11-5.el10_1.aarch64.rpm;name=aarch64_xmodmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmodmap}"
SRC_URI[aarch64_xmodmap.sha256sum] = "bf86e6c4e3cbe16517ac54c221f37c1b5f0fb2262839e86fdcb95018d66a7f7c"

RDEPENDS:xmodmap = " \
 glibc \
 libX11 \
 "
