# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtgraphs"
PV = "6.8.1"
PR = "2.el10_0"
PACKAGES = " \
 qt6-qtgraphs \
 qt6-qtgraphs-devel \
 qt6-qtgraphs-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt6-qtgraphs-6.8.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c711357e7e33e4b84b6ad14a5daa5aeae1e117c3a3f59d93e3719383ba1167f3"

URI_x86_64_v2_qt6-qtgraphs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtgraphs-6.8.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtgraphs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtgraphs}"
SRC_URI[x86_64_v2_qt6-qtgraphs.sha256sum] = "f823cf41a45413736761f11645604b9442ca9a33f85b09699fc7891f4678aa91"

URI_x86_64_v2_qt6-qtgraphs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtgraphs-devel-6.8.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtgraphs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtgraphs-devel}"
SRC_URI[x86_64_v2_qt6-qtgraphs-devel.sha256sum] = "6e782fe42fb0929d44e9ce7492f0a967615c508ae2a990470079fb6206aa8fa8"

URI_x86_64_v2_qt6-qtgraphs-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtgraphs-examples-6.8.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtgraphs-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtgraphs-examples}"
SRC_URI[x86_64_v2_qt6-qtgraphs-examples.sha256sum] = "192c7be074352dad46560eaec7e3e5777a971ddcd7f650620e339e7ed245b2ab"

URI_aarch64_qt6-qtgraphs = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtgraphs-6.8.1-2.el10_0.aarch64.rpm;name=aarch64_qt6-qtgraphs;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtgraphs}"
SRC_URI[aarch64_qt6-qtgraphs.sha256sum] = "0ec5ece9310eb453ecb3fbf77c0891f58e7ae2fd39d42d6b6d960f05871e4f21"

URI_aarch64_qt6-qtgraphs-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtgraphs-devel-6.8.1-2.el10_0.aarch64.rpm;name=aarch64_qt6-qtgraphs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtgraphs-devel}"
SRC_URI[aarch64_qt6-qtgraphs-devel.sha256sum] = "982699375031a8a07df286d39297b3a390db54f29b8af4406e15a869521f5759"

URI_aarch64_qt6-qtgraphs-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtgraphs-examples-6.8.1-2.el10_0.aarch64.rpm;name=aarch64_qt6-qtgraphs-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtgraphs-examples}"
SRC_URI[aarch64_qt6-qtgraphs-examples.sha256sum] = "c0abd27c9221c98f62d7f11adbf3db25d447a4170e93a31391c2acc4097143e0"

RDEPENDS:qt6-qtgraphs = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtquick3d \
 "
RDEPENDS:qt6-qtgraphs-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtgraphs \
 qt6-qtgraphs-devel \
 qt6-qtquick3d-devel \
 "
RDEPENDS:qt6-qtgraphs-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtgraphs \
 "
