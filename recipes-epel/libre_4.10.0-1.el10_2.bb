# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libre"
PV = "4.10.0"
PR = "1.el10_2"
PACKAGES = " \
 libre \
 libre-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libre-4.10.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5cd732cbd8dc1fda8f945668e6ddf35022034e464712b65b3542dc440d2e6337"

URI_x86_64_v2_libre = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libre-4.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libre;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libre}"
SRC_URI[x86_64_v2_libre.sha256sum] = "490389d336bf8856740e5495b0703f295516d76760547c26d595e3a0f6507738"

URI_x86_64_v2_libre-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libre-devel-4.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libre-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libre-devel}"
SRC_URI[x86_64_v2_libre-devel.sha256sum] = "c2c318f0de1247442c53a6a9891cc9ea22ddb0e582ca27c244fa5c0f9dfb4c44"

URI_aarch64_libre = "${EPEL_MIRROR}/aarch64/Packages/l/libre-4.10.0-1.el10_2.aarch64.rpm;name=aarch64_libre;unpack=0"
SRC_URI:append = " ${URI_aarch64_libre}"
SRC_URI[aarch64_libre.sha256sum] = "ad3313b22ee256a08c499a08cd27996fbf87734f41be21d6f820b8f190f10220"

URI_aarch64_libre-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libre-devel-4.10.0-1.el10_2.aarch64.rpm;name=aarch64_libre-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libre-devel}"
SRC_URI[aarch64_libre-devel.sha256sum] = "a8a0d412425a1000a223571408904285f1a54ce52e0b6c4e9f66e9a49e47c2e3"

RDEPENDS:libre = " \
 glibc \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:libre-devel = " \
 cmake-filesystem \
 libre \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
