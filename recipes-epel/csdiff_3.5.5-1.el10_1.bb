# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "csdiff"
PV = "3.5.5"
PR = "1.el10_1"
PACKAGES = " \
 csdiff \
 csdiff-static \
 python3-csdiff \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/csdiff-3.5.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb5505280061f70d3cfd5515a3da87a811dd4d153edddef8118573e2d8f18e04"

URI_x86_64_v2_csdiff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csdiff-3.5.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_csdiff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csdiff}"
SRC_URI[x86_64_v2_csdiff.sha256sum] = "3ee0333fdf6b8de81ec739336ee983acb331baf440f1c13e609169b288409869"

URI_x86_64_v2_csdiff-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csdiff-static-3.5.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_csdiff-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csdiff-static}"
SRC_URI[x86_64_v2_csdiff-static.sha256sum] = "13f59125e4ea73e3cc5c22ce6de2a15f730d48acb0cce1996ed136e2fc0c2aed"

URI_x86_64_v2_python3-csdiff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-csdiff-3.5.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-csdiff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-csdiff}"
SRC_URI[x86_64_v2_python3-csdiff.sha256sum] = "e4cb91781bc9dfc13bd6b7060dc0ffebbc280fdf3c59b9e973f6889d2529b119"

URI_aarch64_csdiff = "${EPEL_MIRROR}/aarch64/Packages/c/csdiff-3.5.5-1.el10_1.aarch64.rpm;name=aarch64_csdiff;unpack=0"
SRC_URI:append = " ${URI_aarch64_csdiff}"
SRC_URI[aarch64_csdiff.sha256sum] = "4af29a931d65f0023580acbedad5a88c14d5ae75ef365f786d905e98c266304d"

URI_aarch64_csdiff-static = "${EPEL_MIRROR}/aarch64/Packages/c/csdiff-static-3.5.5-1.el10_1.aarch64.rpm;name=aarch64_csdiff-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_csdiff-static}"
SRC_URI[aarch64_csdiff-static.sha256sum] = "3aca2735fdff31db65e7f751e8c32a6c0452f9c5a8f58e71b1dc27084d53795c"

URI_aarch64_python3-csdiff = "${EPEL_MIRROR}/aarch64/Packages/p/python3-csdiff-3.5.5-1.el10_1.aarch64.rpm;name=aarch64_python3-csdiff;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-csdiff}"
SRC_URI[aarch64_python3-csdiff.sha256sum] = "ff70854d9a97771ca85d0cd442f057161d4545a7ff34912e1ea846a6f196d8dc"

RDEPENDS:csdiff = " \
 boost-filesystem \
 boost-program-options \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
RDEPENDS:csdiff-static = " \
 "
RDEPENDS:python3-csdiff = " \
 boost-filesystem \
 boost-python3 \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
