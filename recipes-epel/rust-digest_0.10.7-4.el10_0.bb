# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-digest"
PV = "0.10.7"
PR = "4.el10_0"
PACKAGES = " \
 rust-digest+alloc-devel \
 rust-digest+blobby-devel \
 rust-digest+block-buffer-devel \
 rust-digest+const-oid-devel \
 rust-digest+core-api-devel \
 rust-digest+default-devel \
 rust-digest+dev-devel \
 rust-digest+mac-devel \
 rust-digest+oid-devel \
 rust-digest+rand_core-devel \
 rust-digest+std-devel \
 rust-digest+subtle-devel \
 rust-digest-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-digest-0.10.7-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9fa43d873595c8dc7162cb238d517441eba9c8c571fca606f7d940b1b43ca4c"

URI_x86_64_v2_rust-digest+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest+alloc-devel-0.10.7-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest+alloc-devel}"
SRC_URI[x86_64_v2_rust-digest+alloc-devel.sha256sum] = "787eb770159dd4ec5c1abfd1fec4b02a9479c67bc14c113f613510be9a32154f"

URI_x86_64_v2_rust-digest+blobby-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest+blobby-devel-0.10.7-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest+blobby-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest+blobby-devel}"
SRC_URI[x86_64_v2_rust-digest+blobby-devel.sha256sum] = "96f1c2d3ff14445b0d2a8ef9fa3309433cd3b698ef70610fea436b93263fc272"

URI_x86_64_v2_rust-digest+block-buffer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest+block-buffer-devel-0.10.7-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest+block-buffer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest+block-buffer-devel}"
SRC_URI[x86_64_v2_rust-digest+block-buffer-devel.sha256sum] = "a4d56e45bad001c3571cb29d4c7bc472e38cad9b512dc589cc61eb4bbce58e94"

URI_x86_64_v2_rust-digest+const-oid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest+const-oid-devel-0.10.7-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest+const-oid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest+const-oid-devel}"
SRC_URI[x86_64_v2_rust-digest+const-oid-devel.sha256sum] = "12ddecf960687293552b3f90af1b03ac3040e13af4fc19f3085207653f178d2f"

URI_x86_64_v2_rust-digest+core-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest+core-api-devel-0.10.7-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest+core-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest+core-api-devel}"
SRC_URI[x86_64_v2_rust-digest+core-api-devel.sha256sum] = "b8ad13cb2de5e8d25dbeda5f547139f36bcd1edf65b3974ae40f529d76dc74a2"

URI_x86_64_v2_rust-digest+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest+default-devel-0.10.7-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest+default-devel}"
SRC_URI[x86_64_v2_rust-digest+default-devel.sha256sum] = "b5626e0dc6decc8649860ea057f72594c9fa5c301815f06dc89dee849f5634e6"

URI_x86_64_v2_rust-digest+dev-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest+dev-devel-0.10.7-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest+dev-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest+dev-devel}"
SRC_URI[x86_64_v2_rust-digest+dev-devel.sha256sum] = "c545ce6c2acffb0f0550dccca1351d55fb3dba46cea6cfef4ebc484b216da1f9"

URI_x86_64_v2_rust-digest+mac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest+mac-devel-0.10.7-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest+mac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest+mac-devel}"
SRC_URI[x86_64_v2_rust-digest+mac-devel.sha256sum] = "8487b55dc34df93620b8525e306ba1f2925f926c409cbf1a228a9077820bd632"

URI_x86_64_v2_rust-digest+oid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest+oid-devel-0.10.7-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest+oid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest+oid-devel}"
SRC_URI[x86_64_v2_rust-digest+oid-devel.sha256sum] = "cf820ac38696f25b0b132399a82c73bfdb6fb8c72dbabe30b344ac58e2326459"

URI_x86_64_v2_rust-digest+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest+rand_core-devel-0.10.7-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest+rand_core-devel}"
SRC_URI[x86_64_v2_rust-digest+rand_core-devel.sha256sum] = "57565fbd4a9da22c368e008e5fbdfa970c8b225c61e0602148363baae125eae7"

URI_x86_64_v2_rust-digest+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest+std-devel-0.10.7-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest+std-devel}"
SRC_URI[x86_64_v2_rust-digest+std-devel.sha256sum] = "370fcabbffbae2cc1a08ad6308e6d36e12b658a2828c56ea9804e1b28dbb7103"

URI_x86_64_v2_rust-digest+subtle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest+subtle-devel-0.10.7-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest+subtle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest+subtle-devel}"
SRC_URI[x86_64_v2_rust-digest+subtle-devel.sha256sum] = "e91b1ff70336cdd0f14120ad13538133146b91c5ed13aabf4c877ccc36ec594b"

URI_x86_64_v2_rust-digest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-digest-devel-0.10.7-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-digest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-digest-devel}"
SRC_URI[x86_64_v2_rust-digest-devel.sha256sum] = "6569c8c4a3868371e3f9f55de78b81acddb11187774dc642e796ecaa3318aad1"

URI_aarch64_rust-digest+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest+alloc-devel-0.10.7-4.el10_0.noarch.rpm;name=aarch64_rust-digest+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest+alloc-devel}"
SRC_URI[aarch64_rust-digest+alloc-devel.sha256sum] = "b1439b9735ccfeff60cf98c0f08ca905431c5d4864c7386de0b91744b5517c9c"

URI_aarch64_rust-digest+blobby-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest+blobby-devel-0.10.7-4.el10_0.noarch.rpm;name=aarch64_rust-digest+blobby-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest+blobby-devel}"
SRC_URI[aarch64_rust-digest+blobby-devel.sha256sum] = "0832b2be0ebc7fcd35050b4dbd24a78fec5c73911715f9209ec22d8e6502f55e"

URI_aarch64_rust-digest+block-buffer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest+block-buffer-devel-0.10.7-4.el10_0.noarch.rpm;name=aarch64_rust-digest+block-buffer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest+block-buffer-devel}"
SRC_URI[aarch64_rust-digest+block-buffer-devel.sha256sum] = "c8d1dbd0221c2d25c69464e24c10d52c6085ed20c84cc965581e4af719a1515e"

URI_aarch64_rust-digest+const-oid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest+const-oid-devel-0.10.7-4.el10_0.noarch.rpm;name=aarch64_rust-digest+const-oid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest+const-oid-devel}"
SRC_URI[aarch64_rust-digest+const-oid-devel.sha256sum] = "8a28099bfa64f6dab9c7262127f65cebab318cddedcabca5632c82f68585aeec"

URI_aarch64_rust-digest+core-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest+core-api-devel-0.10.7-4.el10_0.noarch.rpm;name=aarch64_rust-digest+core-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest+core-api-devel}"
SRC_URI[aarch64_rust-digest+core-api-devel.sha256sum] = "35fc094e1b24a6951e98d5f97a71cb67c0ca437a4559788c86a55de1f64758f1"

URI_aarch64_rust-digest+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest+default-devel-0.10.7-4.el10_0.noarch.rpm;name=aarch64_rust-digest+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest+default-devel}"
SRC_URI[aarch64_rust-digest+default-devel.sha256sum] = "ca37d3e3d1fd42071b1fde7312f62870a74eb6d628a3b8acf4c5710295f1531e"

URI_aarch64_rust-digest+dev-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest+dev-devel-0.10.7-4.el10_0.noarch.rpm;name=aarch64_rust-digest+dev-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest+dev-devel}"
SRC_URI[aarch64_rust-digest+dev-devel.sha256sum] = "3a637e777e00a541299cc8af9d19d382c99bfa6d2cf60c57b0695619187412a0"

URI_aarch64_rust-digest+mac-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest+mac-devel-0.10.7-4.el10_0.noarch.rpm;name=aarch64_rust-digest+mac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest+mac-devel}"
SRC_URI[aarch64_rust-digest+mac-devel.sha256sum] = "20a7e078b5cc701fe82a01a707706cafbfb859a47c62ba67f36096111e752002"

URI_aarch64_rust-digest+oid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest+oid-devel-0.10.7-4.el10_0.noarch.rpm;name=aarch64_rust-digest+oid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest+oid-devel}"
SRC_URI[aarch64_rust-digest+oid-devel.sha256sum] = "040488071075bd31dcd935a12edbac2282b00a8db6da7447f36cef5c73a536ef"

URI_aarch64_rust-digest+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest+rand_core-devel-0.10.7-4.el10_0.noarch.rpm;name=aarch64_rust-digest+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest+rand_core-devel}"
SRC_URI[aarch64_rust-digest+rand_core-devel.sha256sum] = "44f9f07fb2aa5913e5827c97ac81d906b236e426cf8ad63f3d5daed1e1f8e0d6"

URI_aarch64_rust-digest+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest+std-devel-0.10.7-4.el10_0.noarch.rpm;name=aarch64_rust-digest+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest+std-devel}"
SRC_URI[aarch64_rust-digest+std-devel.sha256sum] = "b918a5d406577adb435ee6362a9d527cda05a4a9b44fd54c7f1ae55d69821b31"

URI_aarch64_rust-digest+subtle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest+subtle-devel-0.10.7-4.el10_0.noarch.rpm;name=aarch64_rust-digest+subtle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest+subtle-devel}"
SRC_URI[aarch64_rust-digest+subtle-devel.sha256sum] = "d36ce2e5bb62eaf66e51bc203bf1764cc706b62d263a2a997386540549319c90"

URI_aarch64_rust-digest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-digest-devel-0.10.7-4.el10_0.noarch.rpm;name=aarch64_rust-digest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-digest-devel}"
SRC_URI[aarch64_rust-digest-devel.sha256sum] = "642ea0f414746b29d9630773fc5d0b2a9373b1f17b6d40d12ed1f5408c770a7e"

RDEPENDS:rust-digest+alloc-devel = " \
 cargo \
 rust-digest-devel \
 "
RDEPENDS:rust-digest+blobby-devel = " \
 cargo \
 rust-blobby0.3+default-devel \
 rust-digest-devel \
 "
RDEPENDS:rust-digest+block-buffer-devel = " \
 cargo \
 rust-block-buffer0.10+default-devel \
 rust-digest-devel \
 "
RDEPENDS:rust-digest+const-oid-devel = " \
 cargo \
 rust-const-oid+default-devel \
 rust-digest-devel \
 "
RDEPENDS:rust-digest+core-api-devel = " \
 cargo \
 rust-digest+block-buffer-devel \
 rust-digest-devel \
 "
RDEPENDS:rust-digest+default-devel = " \
 cargo \
 rust-digest+core-api-devel \
 rust-digest-devel \
 "
RDEPENDS:rust-digest+dev-devel = " \
 cargo \
 rust-digest+blobby-devel \
 rust-digest-devel \
 "
RDEPENDS:rust-digest+mac-devel = " \
 cargo \
 rust-digest+subtle-devel \
 rust-digest-devel \
 "
RDEPENDS:rust-digest+oid-devel = " \
 cargo \
 rust-digest+const-oid-devel \
 rust-digest-devel \
 "
RDEPENDS:rust-digest+rand_core-devel = " \
 cargo \
 rust-crypto-common0.1+rand_core-devel \
 rust-digest-devel \
 "
RDEPENDS:rust-digest+std-devel = " \
 cargo \
 rust-crypto-common0.1+std-devel \
 rust-digest+alloc-devel \
 rust-digest-devel \
 "
RDEPENDS:rust-digest+subtle-devel = " \
 cargo \
 rust-digest-devel \
 rust-subtle-devel \
 "
RDEPENDS:rust-digest-devel = " \
 cargo \
 rust-crypto-common0.1+default-devel \
 "
