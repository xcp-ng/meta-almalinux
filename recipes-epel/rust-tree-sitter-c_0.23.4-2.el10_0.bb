# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-c"
PV = "0.23.4"
PR = "2.el10_0"
PACKAGES = " \
 rust-tree-sitter-c+default-devel \
 rust-tree-sitter-c-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-c-0.23.4-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bab0bcb8c54c36b9c8d050229b0835b3c934074e7a92016d1aa34f85b6f0d5d4"

URI_x86_64_v2_rust-tree-sitter-c+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-c+default-devel-0.23.4-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-c+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-c+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-c+default-devel.sha256sum] = "89a59acdeb13e1bb7a141f728e6b738368ea4b11185a2ecb6fe19094c6008689"

URI_x86_64_v2_rust-tree-sitter-c-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-c-devel-0.23.4-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-c-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-c-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-c-devel.sha256sum] = "740c58fb1b617dcbc09aecf686d64bc49b0a1c1e282e6799ab43855821be0169"

URI_aarch64_rust-tree-sitter-c+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-c+default-devel-0.23.4-2.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-c+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-c+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-c+default-devel.sha256sum] = "05025877e63a0f97e2756d5fc7858c9907164d4f926761355b0dd92c35b96135"

URI_aarch64_rust-tree-sitter-c-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-c-devel-0.23.4-2.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-c-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-c-devel}"
SRC_URI[aarch64_rust-tree-sitter-c-devel.sha256sum] = "f6b0af5c6be9d97ff089c852fa8b068599f4138c6af44e4c6d769bc550217d22"

RDEPENDS:rust-tree-sitter-c+default-devel = " \
 cargo \
 rust-tree-sitter-c-devel \
 "
RDEPENDS:rust-tree-sitter-c-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
