# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "checkpolicy"
PV = "3.9"
PR = "1.el10"
PACKAGES = " \
 checkpolicy \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/checkpolicy-3.9-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f9a19447da5209344bd5dca2bd2ba5e8c052505284c3b28d386b95483b8bd811"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/checkpolicy-3.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_checkpolicy;unpack=0"
SRC_URI[x86_64_v2_checkpolicy.sha256sum] = "f4ebbe28b42c476ccd97b9c52424908ba58b7d6193ebacfbc46299bea834c6c4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/checkpolicy-3.9-1.el10.aarch64.rpm;name=aarch64_checkpolicy;unpack=0"
SRC_URI[aarch64_checkpolicy.sha256sum] = "79154ccce08881bdfc4b07110f41813a64b80eaa102744ae17f5ee42f20982cb"

RDEPENDS:checkpolicy = " \
 glibc \
 "
