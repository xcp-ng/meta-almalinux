# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gram-job-manager-fork"
PV = "3.4"
PR = "1.el10_2"
PACKAGES = " \
 globus-gram-job-manager-fork \
 globus-gram-job-manager-fork-setup-poll \
 globus-gram-job-manager-fork-setup-seg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gram-job-manager-fork-3.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a5506db4aa1fd7ded81f37a1513b9129d3f595372178d4e5c8932bfdd7f672bb"

URI_x86_64_v2_globus-gram-job-manager-fork = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-fork-3.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-job-manager-fork;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager-fork}"
SRC_URI[x86_64_v2_globus-gram-job-manager-fork.sha256sum] = "a704b01ba737c00d04291c97901e03f067a6f26781e514b591a97a2eedfb660c"

URI_x86_64_v2_globus-gram-job-manager-fork-setup-poll = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-fork-setup-poll-3.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gram-job-manager-fork-setup-poll;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager-fork-setup-poll}"
SRC_URI[x86_64_v2_globus-gram-job-manager-fork-setup-poll.sha256sum] = "7ea2129b5f5b08cb6350e4602309af85b6fd57987705fe2b0dad78148e07d4d2"
RPROVIDES:globus-gram-job-manager-fork-setup-poll:x86_64_v2 = "virtual/globus-gram-job-manager-fork-setup_eq_3.4-1.el10_2.alma_altarch"

URI_x86_64_v2_globus-gram-job-manager-fork-setup-seg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-fork-setup-seg-3.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-job-manager-fork-setup-seg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager-fork-setup-seg}"
SRC_URI[x86_64_v2_globus-gram-job-manager-fork-setup-seg.sha256sum] = "df97fadefa56f2e2da7f150e1b66c044cd9100a876a3a6130b6cc9b181b61740"
RPROVIDES:globus-gram-job-manager-fork-setup-seg:x86_64_v2 = "virtual/globus-gram-job-manager-fork-setup_eq_3.4-1.el10_2.alma_altarch"

URI_aarch64_globus-gram-job-manager-fork = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-fork-3.4-1.el10_2.aarch64.rpm;name=aarch64_globus-gram-job-manager-fork;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager-fork}"
SRC_URI[aarch64_globus-gram-job-manager-fork.sha256sum] = "a0780888f39b0705569174b6d3c1450f50b87df0902a9216fe9601e500bf33b2"

URI_aarch64_globus-gram-job-manager-fork-setup-poll = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-fork-setup-poll-3.4-1.el10_2.noarch.rpm;name=aarch64_globus-gram-job-manager-fork-setup-poll;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager-fork-setup-poll}"
SRC_URI[aarch64_globus-gram-job-manager-fork-setup-poll.sha256sum] = "6ebac9691d9e36c8c8d600a0c4d7692a60104105922848c017920e8b790b0643"
RPROVIDES:globus-gram-job-manager-fork-setup-poll:aarch64 = "virtual/globus-gram-job-manager-fork-setup_eq_3.4-1.el10_2"

URI_aarch64_globus-gram-job-manager-fork-setup-seg = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-fork-setup-seg-3.4-1.el10_2.aarch64.rpm;name=aarch64_globus-gram-job-manager-fork-setup-seg;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager-fork-setup-seg}"
SRC_URI[aarch64_globus-gram-job-manager-fork-setup-seg.sha256sum] = "ab294016694fb99cc379399093733971f464424ac304d991a270b7266b1e5787"
RPROVIDES:globus-gram-job-manager-fork-setup-seg:aarch64 = "virtual/globus-gram-job-manager-fork-setup_eq_3.4-1.el10_2"

RDEPENDS:globus-gram-job-manager-fork:x86_64_v2 = " \
 globus-common \
 globus-gass-cache-program \
 globus-gatekeeper \
 globus-gram-job-manager-scripts \
 globus-gram-protocol \
 perl-IPC-Open3 \
 perl-libs \
 virtual/globus-gram-job-manager-fork-setup_eq_3.4-1.el10_2.alma_altarch \
"
RDEPENDS:globus-gram-job-manager-fork:aarch64 = " \
 globus-common \
 globus-gass-cache-program \
 globus-gatekeeper \
 globus-gram-job-manager-scripts \
 globus-gram-protocol \
 perl-IPC-Open3 \
 perl-libs \
 virtual/globus-gram-job-manager-fork-setup_eq_3.4-1.el10_2 \
"
RDEPENDS:globus-gram-job-manager-fork-setup-poll = " \
 bash \
 globus-gram-job-manager-fork \
 globus-gram-job-manager-scripts \
 "
RDEPENDS:globus-gram-job-manager-fork-setup-seg = " \
 bash \
 glibc \
 globus-common \
 globus-gram-job-manager-fork \
 globus-gram-job-manager-scripts \
 globus-gram-protocol \
 globus-scheduler-event-generator \
 globus-scheduler-event-generator-progs \
 globus-xio \
 systemd \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/globus-gram-job-manager-fork-setup_eq_3.4-1.el10_2.alma_altarch"

PROVIDES:append:aarch64 = " rpm/virtual/globus-gram-job-manager-fork-setup_eq_3.4-1.el10_2"
