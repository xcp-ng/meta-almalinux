# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libz-ng-sys"
PV = "1.1.29"
PR = "1.el10_2"
PACKAGES = " \
 rust-libz-ng-sys+default-devel \
 rust-libz-ng-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libz-ng-sys-1.1.29-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "062815fce6d4ec583820b687efb83b228f53896ba6cc1fde13de5a19baf0c5bc"

URI_x86_64_v2_rust-libz-ng-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-ng-sys+default-devel-1.1.29-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-ng-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-ng-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libz-ng-sys+default-devel.sha256sum] = "35d0350d49b67ce393dc0bcb82505d82883357ff23b008f16926009582791d15"

URI_x86_64_v2_rust-libz-ng-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-ng-sys-devel-1.1.29-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-ng-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-ng-sys-devel}"
SRC_URI[x86_64_v2_rust-libz-ng-sys-devel.sha256sum] = "da155865efe38619952324cddbca84a8c6e9fe8b454230b69582f30150e7195b"

URI_aarch64_rust-libz-ng-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-ng-sys+default-devel-1.1.29-1.el10_2.noarch.rpm;name=aarch64_rust-libz-ng-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-ng-sys+default-devel}"
SRC_URI[aarch64_rust-libz-ng-sys+default-devel.sha256sum] = "594fbe6464771e736a1874c79074c6c5db3efed5962bb9f1d3241bd37ad4cec0"

URI_aarch64_rust-libz-ng-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-ng-sys-devel-1.1.29-1.el10_2.noarch.rpm;name=aarch64_rust-libz-ng-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-ng-sys-devel}"
SRC_URI[aarch64_rust-libz-ng-sys-devel.sha256sum] = "be5a8e2ecdd40bc512029060e73f635e955bc596127095ecaee5415a3542a21a"

RDEPENDS:rust-libz-ng-sys+default-devel = " \
 cargo \
 rust-libz-ng-sys-devel \
 "
RDEPENDS:rust-libz-ng-sys-devel = " \
 cargo \
 rust-libc+default-devel \
 zlib-ng-devel \
 "
