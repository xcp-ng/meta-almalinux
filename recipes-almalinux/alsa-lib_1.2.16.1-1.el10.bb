# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "alsa-lib"
PV = "1.2.16.1"
PR = "1.el10"
PACKAGES = " \
 alsa-lib \
 alsa-lib-devel \
 alsa-ucm \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/alsa-lib-1.2.16.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5c4e39ab06cfbfb9f6576bf63c8317e77a26db805102897bdff16061cd329c12"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/alsa-lib-1.2.16.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_alsa-lib;unpack=0"
SRC_URI[x86_64_v2_alsa-lib.sha256sum] = "36c1cec306e21aab64970c3f018e5777cde6837cd81dd390dad46fe3dcea9a08"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/alsa-lib-devel-1.2.16.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_alsa-lib-devel;unpack=0"
SRC_URI[x86_64_v2_alsa-lib-devel.sha256sum] = "b4a69ada18087b6c523b325c7129503b55cd4f0b893ce0caa3e2ca34ad7bd378"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/alsa-ucm-1.2.16.1-1.el10.noarch.rpm;name=x86_64_v2_alsa-ucm;unpack=0"
SRC_URI[x86_64_v2_alsa-ucm.sha256sum] = "a1edde1b625260ee20ab328b5251532b24ef97243aa50f6fe20c146beadcfb90"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/alsa-lib-1.2.16.1-1.el10.aarch64.rpm;name=aarch64_alsa-lib;unpack=0"
SRC_URI[aarch64_alsa-lib.sha256sum] = "6c3534db6d53c203d6da780c4fa19835f443c785cd8a3d333a4157d6a78485d4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/alsa-lib-devel-1.2.16.1-1.el10.aarch64.rpm;name=aarch64_alsa-lib-devel;unpack=0"
SRC_URI[aarch64_alsa-lib-devel.sha256sum] = "0f0f06e9d1db3d775e2600a6a5b0e3ed1f4d7c97929477cce923a31a91d7eb6f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/alsa-ucm-1.2.16.1-1.el10.noarch.rpm;name=aarch64_alsa-ucm;unpack=0"
SRC_URI[aarch64_alsa-ucm.sha256sum] = "a1edde1b625260ee20ab328b5251532b24ef97243aa50f6fe20c146beadcfb90"

RDEPENDS:alsa-lib = " \
 glibc \
 "
RDEPENDS:alsa-lib-devel = " \
 alsa-lib \
 alsa-lib-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:alsa-ucm = " \
 alsa-lib \
 "
