# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-tlv8"
PV = "0.10.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-tlv8 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-tlv8-0.10.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a431fcacd55e424786892bd4d2801d21bfd39ed8420ccf8b29c5730414784120"

URI_x86_64_v2_python3-tlv8 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-tlv8-0.10.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-tlv8;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tlv8}"
SRC_URI[x86_64_v2_python3-tlv8.sha256sum] = "f010edbce135694ea042f2f9ef0a1c431852f0fc4a12b62694fc4b279533690d"

URI_aarch64_python3-tlv8 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-tlv8-0.10.0-1.el10_3.noarch.rpm;name=aarch64_python3-tlv8;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tlv8}"
SRC_URI[aarch64_python3-tlv8.sha256sum] = "f845e59c9b48d78a01171c92c75be49d76b57e4775f7cc01d462696e5aaebd4f"

RDEPENDS:python3-tlv8 = " \
 python3 \
 "
