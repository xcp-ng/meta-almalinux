# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zeroize_derive"
PV = "1.4.3"
PR = "3.el10_1"
PACKAGES = " \
 rust-zeroize_derive+default-devel \
 rust-zeroize_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zeroize_derive-1.4.3-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8af0a9fcd516fc640c0a543342e3749efcc0663d88dc28ea980eb98f2f7cb37"

URI_x86_64_v2_rust-zeroize_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize_derive+default-devel-1.4.3-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize_derive+default-devel}"
SRC_URI[x86_64_v2_rust-zeroize_derive+default-devel.sha256sum] = "d1a8e61ce94077a2f42cd267df208b28c3757e152d53e8f22b9dbe43d08cb4bd"

URI_x86_64_v2_rust-zeroize_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize_derive-devel-1.4.3-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize_derive-devel}"
SRC_URI[x86_64_v2_rust-zeroize_derive-devel.sha256sum] = "f62df7c58b1d0fdb6f06d858a56b63e8e2d6793d3bfc2e50b43989806b2a0644"

URI_aarch64_rust-zeroize_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize_derive+default-devel-1.4.3-3.el10_1.noarch.rpm;name=aarch64_rust-zeroize_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize_derive+default-devel}"
SRC_URI[aarch64_rust-zeroize_derive+default-devel.sha256sum] = "8ae2ca52b02f8583dd77e84c6b2ea7a6c35b833c81a9b527534815286778867a"

URI_aarch64_rust-zeroize_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize_derive-devel-1.4.3-3.el10_1.noarch.rpm;name=aarch64_rust-zeroize_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize_derive-devel}"
SRC_URI[aarch64_rust-zeroize_derive-devel.sha256sum] = "ffa20355c9da7fd465c60c85874de44dda6485029fcff6482837f51b3109561d"

RDEPENDS:rust-zeroize_derive+default-devel = " \
 cargo \
 rust-zeroize_derive-devel \
 "
RDEPENDS:rust-zeroize_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-syn+visit-devel \
 "
