# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dracut"
PV = "107"
PR = "9.el10"
PACKAGES = " \
 dracut \
 dracut-caps \
 dracut-config-generic \
 dracut-config-rescue \
 dracut-live \
 dracut-network \
 dracut-squash \
 dracut-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/dracut-107-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe03790475f93b7bb0248466ee384166cf41c83dad6fd3dd543afdb9eda6bd80"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - dracut-caps: libcap

URI_x86_64_v2_dracut = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dracut-107-9.el10.x86_64_v2.rpm;name=x86_64_v2_dracut;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut}"
SRC_URI[x86_64_v2_dracut.sha256sum] = "0fa2469f05c2a5c2ee76af122bb8f3d33c625e7cfe9becad460dd4989db9264f"

URI_x86_64_v2_dracut-caps = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dracut-caps-107-9.el10.x86_64_v2.rpm;name=x86_64_v2_dracut-caps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-caps}"
SRC_URI[x86_64_v2_dracut-caps.sha256sum] = "f97990b8a6a67a2da4b7209fe61087c4cbc7ab60df6264683e9d44e5d1895f6e"

URI_x86_64_v2_dracut-config-generic = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dracut-config-generic-107-9.el10.x86_64_v2.rpm;name=x86_64_v2_dracut-config-generic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-config-generic}"
SRC_URI[x86_64_v2_dracut-config-generic.sha256sum] = "5334d5cd84c1cf6fdd2ab6bd968d35c0d454ed5f667a8573b358e435efd6cfb1"

URI_x86_64_v2_dracut-config-rescue = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dracut-config-rescue-107-9.el10.x86_64_v2.rpm;name=x86_64_v2_dracut-config-rescue;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-config-rescue}"
SRC_URI[x86_64_v2_dracut-config-rescue.sha256sum] = "52071480a5e854f93295497a66145e8d75378596f0d8d7ec2914eb63e89ba7eb"

URI_x86_64_v2_dracut-live = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dracut-live-107-9.el10.x86_64_v2.rpm;name=x86_64_v2_dracut-live;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-live}"
SRC_URI[x86_64_v2_dracut-live.sha256sum] = "003d9fb9a23cfc14cc75e78fcf32f6e11274e7dd0daea8586028fe1c897c23ea"

URI_x86_64_v2_dracut-network = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dracut-network-107-9.el10.x86_64_v2.rpm;name=x86_64_v2_dracut-network;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-network}"
SRC_URI[x86_64_v2_dracut-network.sha256sum] = "95fe8bae886778828cea3b5938c775bd1a3777375503e0dc5dbe45d0266d07ed"

URI_x86_64_v2_dracut-squash = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dracut-squash-107-9.el10.x86_64_v2.rpm;name=x86_64_v2_dracut-squash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-squash}"
SRC_URI[x86_64_v2_dracut-squash.sha256sum] = "08d3f695d1a1e79af497108b96e60aeef93bd64a1f78725affd9670fc3040eb5"

URI_x86_64_v2_dracut-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dracut-tools-107-9.el10.x86_64_v2.rpm;name=x86_64_v2_dracut-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-tools}"
SRC_URI[x86_64_v2_dracut-tools.sha256sum] = "2c53b91269bd59fb454fc911876e74ce94e44bfe63fb4d6e45ec5b6a96b7bfa1"

URI_aarch64_dracut = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dracut-107-9.el10.aarch64.rpm;name=aarch64_dracut;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut}"
SRC_URI[aarch64_dracut.sha256sum] = "77d8ce2aa8af5fc53801c552f93b69f6fe6f982eaeeb5ca00e3e49a0d9670462"

URI_aarch64_dracut-caps = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dracut-caps-107-9.el10.aarch64.rpm;name=aarch64_dracut-caps;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-caps}"
SRC_URI[aarch64_dracut-caps.sha256sum] = "26ddd871a93832b5a400fa1857619f2440ff23ce42d9330776a2b4d324e3f4e9"

URI_aarch64_dracut-config-generic = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dracut-config-generic-107-9.el10.aarch64.rpm;name=aarch64_dracut-config-generic;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-config-generic}"
SRC_URI[aarch64_dracut-config-generic.sha256sum] = "7e199a80e1b4b635ea08acaef74dbce20777619d185c0ff1bbaadbb00b1e07f7"

URI_aarch64_dracut-config-rescue = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dracut-config-rescue-107-9.el10.aarch64.rpm;name=aarch64_dracut-config-rescue;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-config-rescue}"
SRC_URI[aarch64_dracut-config-rescue.sha256sum] = "0fc1d41c3ea5d95b4cbefa48a3fea73d496d0621888cfc52f68d2f9b18b8fcd5"

URI_aarch64_dracut-live = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dracut-live-107-9.el10.aarch64.rpm;name=aarch64_dracut-live;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-live}"
SRC_URI[aarch64_dracut-live.sha256sum] = "a2652d750441efa4d63e1385202cdf995b2143cfba789fab92594a6642cc83e5"

URI_aarch64_dracut-network = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dracut-network-107-9.el10.aarch64.rpm;name=aarch64_dracut-network;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-network}"
SRC_URI[aarch64_dracut-network.sha256sum] = "f5368a19d186c0fdc169e9650164f9ebc11d205734ede2b94aef59bac3f5f554"

URI_aarch64_dracut-squash = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dracut-squash-107-9.el10.aarch64.rpm;name=aarch64_dracut-squash;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-squash}"
SRC_URI[aarch64_dracut-squash.sha256sum] = "051a270f9552a356a2d80064a115f6971fde19773d81d082428bfa23e82f2c22"

URI_aarch64_dracut-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dracut-tools-107-9.el10.aarch64.rpm;name=aarch64_dracut-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-tools}"
SRC_URI[aarch64_dracut-tools.sha256sum] = "5c7b0d1648b1ce3579f0f52379e71f788a0bf7d1f4087245907faa481151e85d"

RDEPENDS:dracut = " \
 bash \
 cpio \
 filesystem \
 findutils \
 glibc \
 grep \
 gzip \
 kmod \
 kmod-libs \
 libgcc \
 libkcapi-hmaccalc \
 openssl-libs \
 procps-ng \
 sed \
 systemd \
 systemd-udev \
 tpm2-tools \
 util-linux \
 util-linux-core \
 virtual/coreutils \
 xz \
 "
RDEPENDS:dracut-caps:x86_64_v2 = " \
 bash \
 dracut \
 libcap \
"
RDEPENDS:dracut-caps:aarch64 = " \
 bash \
 dracut \
"
RDEPENDS:dracut-config-generic = " \
 dracut \
 "
RDEPENDS:dracut-config-rescue = " \
 bash \
 dracut \
 "
RDEPENDS:dracut-live = " \
 bash \
 curl \
 device-mapper \
 dracut \
 dracut-network \
 gzip \
 parted \
 tar \
 virtual/coreutils \
 "
RDEPENDS:dracut-network = " \
 NetworkManager \
 bash \
 dracut \
 iproute \
 iputils \
 jq \
 "
RDEPENDS:dracut-squash = " \
 bash \
 dracut \
 erofs-utils \
 "
RDEPENDS:dracut-tools = " \
 bash \
 dracut \
 "
