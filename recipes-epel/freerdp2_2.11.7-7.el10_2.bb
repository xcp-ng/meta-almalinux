# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "freerdp2"
PV = "2.11.7"
PR = "7.el10_2"
PACKAGES = " \
 freerdp2-devel \
 freerdp2-libs \
 libwinpr2 \
 libwinpr2-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/f/freerdp2-2.11.7-7.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6b554e405938be48e09fe449050dc577d58ab16bf752c5ca3124d28bf0a66802"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/freerdp2-devel-2.11.7-7.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_freerdp2-devel;unpack=0"
SRC_URI[x86_64_v2_freerdp2-devel.sha256sum] = "e671fdb3ee9ccc0b2b43daf9f1f89cea4f1f29591b6e1833b8edd0d2184bf1cf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/freerdp2-libs-2.11.7-7.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_freerdp2-libs;unpack=0"
SRC_URI[x86_64_v2_freerdp2-libs.sha256sum] = "b7e78ef0326930cd6a85416ce38c3d3ec0f0dcc4b16455d955aef4fdb1971c4e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libwinpr2-2.11.7-7.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libwinpr2;unpack=0"
SRC_URI[x86_64_v2_libwinpr2.sha256sum] = "bc2159bd14a5064d6a2417e0bb7f60406c3a256f86dba1236e8ccfc039868866"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libwinpr2-devel-2.11.7-7.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libwinpr2-devel;unpack=0"
SRC_URI[x86_64_v2_libwinpr2-devel.sha256sum] = "aa5ccbcc316bd8974e4662f2b17a6c7afbb8ec828a2c923e08485aa307902ea4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/freerdp2-devel-2.11.7-7.el10_2.aarch64.rpm;name=aarch64_freerdp2-devel;unpack=0"
SRC_URI[aarch64_freerdp2-devel.sha256sum] = "dbe87edc080a7c0cd79248be61a179c52a5286db05c2d0e2245b128b1cd170b0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/freerdp2-libs-2.11.7-7.el10_2.aarch64.rpm;name=aarch64_freerdp2-libs;unpack=0"
SRC_URI[aarch64_freerdp2-libs.sha256sum] = "831ee1c30a93cf37e6239f263d8d7af5137e91243f89c6e4a50bb4bad9f74287"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libwinpr2-2.11.7-7.el10_2.aarch64.rpm;name=aarch64_libwinpr2;unpack=0"
SRC_URI[aarch64_libwinpr2.sha256sum] = "7bc2b2f3bf49288fccb3249985fb55ef0a44820e1a5e48b009a55e65e6065f20"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libwinpr2-devel-2.11.7-7.el10_2.aarch64.rpm;name=aarch64_libwinpr2-devel;unpack=0"
SRC_URI[aarch64_libwinpr2-devel.sha256sum] = "69465a7e611e0c426c4cd20e31259741f7fb8725d783677dec7769dcf479325a"

RDEPENDS:freerdp2-devel = " \
 cmake \
 cmake-filesystem \
 freerdp2-devel \
 freerdp2-libs \
 libwinpr2-devel \
 libxkbcommon-devel \
 openssl-devel \
 pkgconf-pkg-config \
 wayland-devel \
 "
RDEPENDS:freerdp2-libs = " \
 alsa-lib \
 cairo \
 cups-libs \
 glibc \
 gsm \
 lame-libs \
 libX11 \
 libXdamage \
 libXext \
 libXfixes \
 libXinerama \
 libXtst \
 libjpeg-turbo \
 libusb1 \
 libwayland-client \
 libwayland-cursor \
 libwinpr2 \
 libxkbcommon \
 libxkbfile \
 noopenh264 \
 openssl-libs \
 pam-libs \
 pulseaudio-libs \
 "
RDEPENDS:libwinpr2 = " \
 glibc \
 libicu \
 openssl-libs \
 systemd-libs \
 "
RDEPENDS:libwinpr2-devel = " \
 cmake \
 cmake-filesystem \
 libwinpr2 \
 libwinpr2-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
