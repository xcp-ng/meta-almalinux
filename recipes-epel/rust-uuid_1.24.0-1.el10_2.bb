# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uuid"
PV = "1.24.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-uuid+arbitrary-devel \
 rust-uuid+atomic-devel \
 rust-uuid+bytemuck-devel \
 rust-uuid+default-devel \
 rust-uuid+fast-rng-devel \
 rust-uuid+md5-devel \
 rust-uuid+rng-devel \
 rust-uuid+rng-getrandom-devel \
 rust-uuid+rng-rand-devel \
 rust-uuid+serde-devel \
 rust-uuid+sha1-devel \
 rust-uuid+slog-devel \
 rust-uuid+std-devel \
 rust-uuid+v1-devel \
 rust-uuid+v3-devel \
 rust-uuid+v4-devel \
 rust-uuid+v5-devel \
 rust-uuid+v6-devel \
 rust-uuid+v7-devel \
 rust-uuid+v8-devel \
 rust-uuid-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uuid-1.24.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "473b3b3258f2c757b33c0447c7a1df4d8f91b056ddf6db99b976029f75074fe0"

URI_x86_64_v2_rust-uuid+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+arbitrary-devel-1.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-uuid+arbitrary-devel.sha256sum] = "ddb9fc9ac0f746f5256809ad7e960c9e845c116ff80eb8c285f56cb49419f4f4"

URI_x86_64_v2_rust-uuid+atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+atomic-devel-1.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+atomic-devel}"
SRC_URI[x86_64_v2_rust-uuid+atomic-devel.sha256sum] = "7532975c6b51329c19f4a44a197db10eb87b5e1392e87a4a775917c4ab9ce4c0"

URI_x86_64_v2_rust-uuid+bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+bytemuck-devel-1.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+bytemuck-devel}"
SRC_URI[x86_64_v2_rust-uuid+bytemuck-devel.sha256sum] = "138ce0af64731e5225dcece7b9d94cad952a2df2c141ee03fde0c80a7fcaeec4"

URI_x86_64_v2_rust-uuid+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+default-devel-1.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+default-devel}"
SRC_URI[x86_64_v2_rust-uuid+default-devel.sha256sum] = "2d5c26ba2098182e5a9841527c444da320c5d47eb79d5cf0413a7bed1c8640ae"

URI_x86_64_v2_rust-uuid+fast-rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+fast-rng-devel-1.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+fast-rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+fast-rng-devel}"
SRC_URI[x86_64_v2_rust-uuid+fast-rng-devel.sha256sum] = "c0ec48520d3c344eb9eb7fd4352506ad72c7d90a1d635fa17d6f8faee47be48a"

URI_x86_64_v2_rust-uuid+md5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+md5-devel-1.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+md5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+md5-devel}"
SRC_URI[x86_64_v2_rust-uuid+md5-devel.sha256sum] = "0b3ca0188293456ce84b61523c7af5acf2c8fa6a9b0c120d3fcaed7857c36795"

URI_x86_64_v2_rust-uuid+rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+rng-devel-1.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+rng-devel}"
SRC_URI[x86_64_v2_rust-uuid+rng-devel.sha256sum] = "50d95889a85379c9f8c1eefc41488394c53cfb08a4ef9f518f70855c52bddad2"

URI_x86_64_v2_rust-uuid+rng-getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+rng-getrandom-devel-1.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+rng-getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+rng-getrandom-devel}"
SRC_URI[x86_64_v2_rust-uuid+rng-getrandom-devel.sha256sum] = "3db45fb68489319f810b526ee21c36f807b3f21ef2a35359708d31fa5389981f"

URI_x86_64_v2_rust-uuid+rng-rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+rng-rand-devel-1.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+rng-rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+rng-rand-devel}"
SRC_URI[x86_64_v2_rust-uuid+rng-rand-devel.sha256sum] = "eb9059fb7d87f7a85cfdf195a8b3d174b2976948660965575d81fe36acc2fe7f"

URI_x86_64_v2_rust-uuid+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+serde-devel-1.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+serde-devel}"
SRC_URI[x86_64_v2_rust-uuid+serde-devel.sha256sum] = "381595df71563c70a28c2bbb0690e47340166de80200cfe4c6182f929b6e012a"

URI_x86_64_v2_rust-uuid+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+sha1-devel-1.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+sha1-devel}"
SRC_URI[x86_64_v2_rust-uuid+sha1-devel.sha256sum] = "a827f7658c7d1da7290e272eff8f4e62adbd65ff62de609a2e8bc0e09928532f"

URI_x86_64_v2_rust-uuid+slog-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+slog-devel-1.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+slog-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+slog-devel}"
SRC_URI[x86_64_v2_rust-uuid+slog-devel.sha256sum] = "997dd195d37efa85e544b8c25d44f8ff753830fe415361deef4d68ad7008d54a"

URI_x86_64_v2_rust-uuid+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+std-devel-1.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+std-devel}"
SRC_URI[x86_64_v2_rust-uuid+std-devel.sha256sum] = "e18a00e3610ed3b570a6ea57e73b071b98a42545cb350056b8f2c4d1e4f63d8e"

URI_x86_64_v2_rust-uuid+v1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v1-devel-1.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+v1-devel}"
SRC_URI[x86_64_v2_rust-uuid+v1-devel.sha256sum] = "87456aa521fd6ea408ddd80d976655b3d505fa8f4c4531a7b377b9a23d41c882"

URI_x86_64_v2_rust-uuid+v3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v3-devel-1.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+v3-devel}"
SRC_URI[x86_64_v2_rust-uuid+v3-devel.sha256sum] = "24a71b60e4af89fca55dfc5192894254a0cfa21573195a16dd1d44fa0fbe0814"

URI_x86_64_v2_rust-uuid+v4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v4-devel-1.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+v4-devel}"
SRC_URI[x86_64_v2_rust-uuid+v4-devel.sha256sum] = "94654f833fdc092e0f3e1a7492a132fb6c80732c8074cf20e573b145f72cb10f"

URI_x86_64_v2_rust-uuid+v5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v5-devel-1.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+v5-devel}"
SRC_URI[x86_64_v2_rust-uuid+v5-devel.sha256sum] = "351b93171153e48b9ee3447e2c530886381aae1998e20923acb9c8375b298f76"

URI_x86_64_v2_rust-uuid+v6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v6-devel-1.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+v6-devel}"
SRC_URI[x86_64_v2_rust-uuid+v6-devel.sha256sum] = "1241b5b1b72ab0fbe1c75b56bb7fb41b4778f1659a93c96d6191baedbd8c109d"

URI_x86_64_v2_rust-uuid+v7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v7-devel-1.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+v7-devel}"
SRC_URI[x86_64_v2_rust-uuid+v7-devel.sha256sum] = "aee3e109ca62d21afcda7b4202aa38f057572e2216254185a2e29c5d2221eba7"

URI_x86_64_v2_rust-uuid+v8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v8-devel-1.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+v8-devel}"
SRC_URI[x86_64_v2_rust-uuid+v8-devel.sha256sum] = "70eab1bcaaca6aab7e655ee4e5ba421cc9f5db0818c61484fd937cd7660e9eef"

URI_x86_64_v2_rust-uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid-devel-1.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid-devel}"
SRC_URI[x86_64_v2_rust-uuid-devel.sha256sum] = "1d3c59e3d5b15b78ce69bae814c0a7f87ff0b9e91c8303ff6c8dc29609f970c1"

URI_aarch64_rust-uuid+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+arbitrary-devel-1.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+arbitrary-devel}"
SRC_URI[aarch64_rust-uuid+arbitrary-devel.sha256sum] = "7af6f340ff22ec012772c92d20f0b73ebac2c131ef11a3f26af319422f7b4c2a"

URI_aarch64_rust-uuid+atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+atomic-devel-1.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+atomic-devel}"
SRC_URI[aarch64_rust-uuid+atomic-devel.sha256sum] = "ddecc4036f142b4f41248d62cef8117471ecc26da68b1ce9cbe3a4fb9dd7c0ea"

URI_aarch64_rust-uuid+bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+bytemuck-devel-1.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+bytemuck-devel}"
SRC_URI[aarch64_rust-uuid+bytemuck-devel.sha256sum] = "f6802a8e4aaacfb2f966709c90235f81e5ff1ead5c543efaa2aceb2faf1ed600"

URI_aarch64_rust-uuid+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+default-devel-1.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+default-devel}"
SRC_URI[aarch64_rust-uuid+default-devel.sha256sum] = "716e489f2b61f5087d780a62d99aecd6a0e63ce412a48af0c5900d83a2123f08"

URI_aarch64_rust-uuid+fast-rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+fast-rng-devel-1.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+fast-rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+fast-rng-devel}"
SRC_URI[aarch64_rust-uuid+fast-rng-devel.sha256sum] = "309e779367a25fd075ccd7fbcadde64ba394ea1a967f7bac8eb848042272ed3d"

URI_aarch64_rust-uuid+md5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+md5-devel-1.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+md5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+md5-devel}"
SRC_URI[aarch64_rust-uuid+md5-devel.sha256sum] = "52553982de193ea0dc0e19c3d13b39c9b233c7ae4f05a783a17c458b2ac9bdec"

URI_aarch64_rust-uuid+rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+rng-devel-1.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+rng-devel}"
SRC_URI[aarch64_rust-uuid+rng-devel.sha256sum] = "b9f44bdf3c09349137cd1924d7a7a13e89040bdddb1ad7f6fa4fd84699d062a5"

URI_aarch64_rust-uuid+rng-getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+rng-getrandom-devel-1.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+rng-getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+rng-getrandom-devel}"
SRC_URI[aarch64_rust-uuid+rng-getrandom-devel.sha256sum] = "6b5511a14c0d93cf3476f23d03045acca1cfd3f567f56bc5cccec307aa413be4"

URI_aarch64_rust-uuid+rng-rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+rng-rand-devel-1.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+rng-rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+rng-rand-devel}"
SRC_URI[aarch64_rust-uuid+rng-rand-devel.sha256sum] = "7a855becf643aa4d99045b31fdcbc2cbca89b750c6dbf554d6c0459b95c7634c"

URI_aarch64_rust-uuid+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+serde-devel-1.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+serde-devel}"
SRC_URI[aarch64_rust-uuid+serde-devel.sha256sum] = "0982927da93a1c2c9805ff1082df430c6e0a7973090536f86e035fb0b3ef8a25"

URI_aarch64_rust-uuid+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+sha1-devel-1.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+sha1-devel}"
SRC_URI[aarch64_rust-uuid+sha1-devel.sha256sum] = "1db8b48ec305b349519c3752da74bd868383b0b8856e1617e050d5a97365f5b0"

URI_aarch64_rust-uuid+slog-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+slog-devel-1.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+slog-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+slog-devel}"
SRC_URI[aarch64_rust-uuid+slog-devel.sha256sum] = "0189453d6697916230235521286209ba02b924276e67ba343d0e464f5c5e7b61"

URI_aarch64_rust-uuid+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+std-devel-1.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+std-devel}"
SRC_URI[aarch64_rust-uuid+std-devel.sha256sum] = "c961ef4c08e194e5077836ec5d29579a3ea8038ae416f80b3de0c6c3ca834457"

URI_aarch64_rust-uuid+v1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v1-devel-1.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+v1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+v1-devel}"
SRC_URI[aarch64_rust-uuid+v1-devel.sha256sum] = "a655948109a1d0b9991ed39c747cb00c9f63d53479070fbf3d304d7eb64f94c5"

URI_aarch64_rust-uuid+v3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v3-devel-1.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+v3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+v3-devel}"
SRC_URI[aarch64_rust-uuid+v3-devel.sha256sum] = "62166d7c8700e1c03b30d00607658cc12831b2cb71826bacabe4605449b1721c"

URI_aarch64_rust-uuid+v4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v4-devel-1.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+v4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+v4-devel}"
SRC_URI[aarch64_rust-uuid+v4-devel.sha256sum] = "e8976d08fdf7bfad8da61c91df84f5493d5f682ad1d0d1c093b16ab9e3c9d770"

URI_aarch64_rust-uuid+v5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v5-devel-1.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+v5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+v5-devel}"
SRC_URI[aarch64_rust-uuid+v5-devel.sha256sum] = "880865c05d0469a02545768018f92b85d7cfddf209936b86610efbb88509c446"

URI_aarch64_rust-uuid+v6-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v6-devel-1.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+v6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+v6-devel}"
SRC_URI[aarch64_rust-uuid+v6-devel.sha256sum] = "57fd94e32533f77fe60a6d4e6d864091a1613edfa4aaf88ba002ce0e25fdeff2"

URI_aarch64_rust-uuid+v7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v7-devel-1.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+v7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+v7-devel}"
SRC_URI[aarch64_rust-uuid+v7-devel.sha256sum] = "053f20252a1c04bf240f94a0047a9fa544ccb1bac58b330ef3f28d53ff54feea"

URI_aarch64_rust-uuid+v8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v8-devel-1.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-uuid+v8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+v8-devel}"
SRC_URI[aarch64_rust-uuid+v8-devel.sha256sum] = "c59900d2d8f6d4b32733d4b7952a5587ca1d00a0878df8c61af47cf002995638"

URI_aarch64_rust-uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid-devel-1.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid-devel}"
SRC_URI[aarch64_rust-uuid-devel.sha256sum] = "583ba887715e870adcf93bc4faa291dd878ac2b170a289effe3e753d07911dde"

RDEPENDS:rust-uuid+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+atomic-devel = " \
 cargo \
 rust-atomic-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+bytemuck-devel = " \
 cargo \
 rust-bytemuck+default-devel \
 rust-bytemuck+derive-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+default-devel = " \
 cargo \
 rust-uuid+std-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+fast-rng-devel = " \
 cargo \
 rust-rand+default-devel \
 rust-uuid+rng-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+md5-devel = " \
 cargo \
 rust-md-5-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+rng-devel = " \
 cargo \
 rust-getrandom+default-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+rng-getrandom-devel = " \
 cargo \
 rust-getrandom+default-devel \
 rust-uuid+rng-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+rng-rand-devel = " \
 cargo \
 rust-rand+default-devel \
 rust-uuid+rng-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+serde-devel = " \
 cargo \
 rust-serde_core-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+sha1-devel = " \
 cargo \
 rust-sha1_smol-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+slog-devel = " \
 cargo \
 rust-slog+default-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+std-devel = " \
 cargo \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v1-devel = " \
 cargo \
 rust-uuid+atomic-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v3-devel = " \
 cargo \
 rust-uuid+md5-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v4-devel = " \
 cargo \
 rust-uuid+rng-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v5-devel = " \
 cargo \
 rust-uuid+sha1-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v6-devel = " \
 cargo \
 rust-uuid+atomic-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v7-devel = " \
 cargo \
 rust-uuid+rng-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v8-devel = " \
 cargo \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid-devel = " \
 cargo \
 rust \
 "
