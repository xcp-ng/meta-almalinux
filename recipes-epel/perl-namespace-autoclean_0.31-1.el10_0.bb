# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-namespace-autoclean"
PV = "0.31"
PR = "1.el10_0"
PACKAGES = " \
 perl-namespace-autoclean \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-namespace-autoclean-0.31-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb39b39a5347b5229abe6b8161a78626b9482cb6dc5c1ea2b9e6ce61a4244ceb"

URI_x86_64_v2_perl-namespace-autoclean = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-namespace-autoclean-0.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-namespace-autoclean;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-namespace-autoclean}"
SRC_URI[x86_64_v2_perl-namespace-autoclean.sha256sum] = "eae44831f069a321d1cf3f151df4dbe460d6db02e625dfd7239b395473415c3f"

URI_aarch64_perl-namespace-autoclean = "${EPEL_MIRROR}/aarch64/Packages/p/perl-namespace-autoclean-0.31-1.el10_0.noarch.rpm;name=aarch64_perl-namespace-autoclean;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-namespace-autoclean}"
SRC_URI[aarch64_perl-namespace-autoclean.sha256sum] = "9e3644b285afff9b7b4131289e13457f58a92b746a10b6f9e0d603dcff769b81"

RDEPENDS:perl-namespace-autoclean = " \
 perl-B-Hooks-EndOfScope \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-namespace-clean \
 "
