# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-test-tag"
PV = "0.1.6"
PR = "1.el10_2"
PACKAGES = " \
 rust-test-tag+default-devel \
 rust-test-tag-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-test-tag-0.1.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eef741d10c7af5f97ba62f004d001a7455a3bad2c7d39e256238203f053bc7a3"

URI_x86_64_v2_rust-test-tag+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-tag+default-devel-0.1.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-tag+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-tag+default-devel}"
SRC_URI[x86_64_v2_rust-test-tag+default-devel.sha256sum] = "e7202f9f924f9baeb871c46a8ea5a0fcb729757d6d3bdd52c02a7d494798fd8a"

URI_x86_64_v2_rust-test-tag-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-tag-devel-0.1.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-tag-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-tag-devel}"
SRC_URI[x86_64_v2_rust-test-tag-devel.sha256sum] = "3abafbcbff9793ed3954affe082728bf9196408898fad8c58563eae148942478"

URI_aarch64_rust-test-tag+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-tag+default-devel-0.1.6-1.el10_2.noarch.rpm;name=aarch64_rust-test-tag+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-tag+default-devel}"
SRC_URI[aarch64_rust-test-tag+default-devel.sha256sum] = "dc753fed10cfa9dbd39ad9451c523812f760968ade27380081b8782e38cf5701"

URI_aarch64_rust-test-tag-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-tag-devel-0.1.6-1.el10_2.noarch.rpm;name=aarch64_rust-test-tag-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-tag-devel}"
SRC_URI[aarch64_rust-test-tag-devel.sha256sum] = "e97aaf3f2392f27b41a3f7ec6ae177aadde81caedac24c9b05a89cec269eccf9"

RDEPENDS:rust-test-tag+default-devel = " \
 cargo \
 rust-test-tag-devel \
 "
RDEPENDS:rust-test-tag-devel = " \
 cargo \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
