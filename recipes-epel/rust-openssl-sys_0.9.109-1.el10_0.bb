# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-openssl-sys"
PV = "0.9.109"
PR = "1.el10_0"
PACKAGES = " \
 rust-openssl-sys+bindgen-devel \
 rust-openssl-sys+default-devel \
 rust-openssl-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-openssl-sys-0.9.109-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3865932c13d31ade4ef7d4c63e72cbda91f142a4a7cce8f186a02f84846732e0"

URI_x86_64_v2_rust-openssl-sys+bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl-sys+bindgen-devel-0.9.109-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl-sys+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl-sys+bindgen-devel}"
SRC_URI[x86_64_v2_rust-openssl-sys+bindgen-devel.sha256sum] = "711b5bcbc3d29673a22b18c331f14da2b00110a9cf5b8d823a57049ff202d52b"

URI_x86_64_v2_rust-openssl-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl-sys+default-devel-0.9.109-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl-sys+default-devel}"
SRC_URI[x86_64_v2_rust-openssl-sys+default-devel.sha256sum] = "e3352fae7547329929176ec877be3c1b9b8791f18f6aff1969d4d305240212ce"

URI_x86_64_v2_rust-openssl-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl-sys-devel-0.9.109-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl-sys-devel}"
SRC_URI[x86_64_v2_rust-openssl-sys-devel.sha256sum] = "ff79a8e25fc0b8c23a353c99514ac9a0a49484d41bb934b0dbc32ced54ac45ab"

URI_aarch64_rust-openssl-sys+bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl-sys+bindgen-devel-0.9.109-1.el10_0.noarch.rpm;name=aarch64_rust-openssl-sys+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl-sys+bindgen-devel}"
SRC_URI[aarch64_rust-openssl-sys+bindgen-devel.sha256sum] = "e67c17d32a31ff2a0b425cffcbb9fafd9c3e8f2f18313ec684aa858c0f1fdfc1"

URI_aarch64_rust-openssl-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl-sys+default-devel-0.9.109-1.el10_0.noarch.rpm;name=aarch64_rust-openssl-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl-sys+default-devel}"
SRC_URI[aarch64_rust-openssl-sys+default-devel.sha256sum] = "8727fe98f6bd1d686e4c874421ec180b06993e38fec73156cd94397daf759505"

URI_aarch64_rust-openssl-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl-sys-devel-0.9.109-1.el10_0.noarch.rpm;name=aarch64_rust-openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl-sys-devel}"
SRC_URI[aarch64_rust-openssl-sys-devel.sha256sum] = "20ee9707810920e6359b613d5cc81e3e901607ee71e401b86a06dc129d820620"

RDEPENDS:rust-openssl-sys+bindgen-devel = " \
 cargo \
 rust-bindgen+default-devel \
 rust-bindgen+experimental-devel \
 rust-openssl-sys-devel \
 "
RDEPENDS:rust-openssl-sys+default-devel = " \
 cargo \
 rust-openssl-sys-devel \
 "
RDEPENDS:rust-openssl-sys-devel = " \
 cargo \
 openssl-devel \
 rust \
 rust-cc+default-devel \
 rust-libc+default-devel \
 rust-pkg-config+default-devel \
 "
