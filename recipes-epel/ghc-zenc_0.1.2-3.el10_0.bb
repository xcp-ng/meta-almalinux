# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-zenc"
PV = "0.1.2"
PR = "3.el10_0"
PACKAGES = " \
 ghc-zenc \
 ghc-zenc-devel \
 ghc-zenc-doc \
 ghc-zenc-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-zenc-0.1.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "165728f2a594c9aaf6f1f60cc94fe4f2e1bf11673d2915c24957fb624a09d834"

URI_x86_64_v2_ghc-zenc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-zenc-0.1.2-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-zenc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-zenc}"
SRC_URI[x86_64_v2_ghc-zenc.sha256sum] = "24d26619fb991d31a42907b23bd3cb7a33fac147ba378206612ce9f36057f1d4"

URI_x86_64_v2_ghc-zenc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-zenc-devel-0.1.2-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-zenc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-zenc-devel}"
SRC_URI[x86_64_v2_ghc-zenc-devel.sha256sum] = "0839d3cd302fd9326c22d1e32e8d14a87260e680c02ede570a008d3ba3925500"

URI_x86_64_v2_ghc-zenc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-zenc-doc-0.1.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-zenc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-zenc-doc}"
SRC_URI[x86_64_v2_ghc-zenc-doc.sha256sum] = "a3ab7c116bcb5cba25947919ebd5638523cbc9994468f417681480be88e0fc32"

URI_x86_64_v2_ghc-zenc-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-zenc-prof-0.1.2-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-zenc-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-zenc-prof}"
SRC_URI[x86_64_v2_ghc-zenc-prof.sha256sum] = "c9e32e35b78273819575033400bfe0027e5fd338f04295efd0e04ef0ac7ad046"

URI_aarch64_ghc-zenc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-zenc-0.1.2-3.el10_0.aarch64.rpm;name=aarch64_ghc-zenc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-zenc}"
SRC_URI[aarch64_ghc-zenc.sha256sum] = "fbd8cafd16168d2cae165b0add9386b95b871c12b202a9af5cd4a6e92ef006e3"

URI_aarch64_ghc-zenc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-zenc-devel-0.1.2-3.el10_0.aarch64.rpm;name=aarch64_ghc-zenc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-zenc-devel}"
SRC_URI[aarch64_ghc-zenc-devel.sha256sum] = "0602e225d360313a006b5b97323f0e9cd1713dbe617e4201df3ca3288ce92c78"

URI_aarch64_ghc-zenc-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-zenc-doc-0.1.2-3.el10_0.noarch.rpm;name=aarch64_ghc-zenc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-zenc-doc}"
SRC_URI[aarch64_ghc-zenc-doc.sha256sum] = "40995e04f8e9403da2d2fa8ec14bfc6b9c1dc92099e7edd3ba38af7612f7a2f2"

URI_aarch64_ghc-zenc-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-zenc-prof-0.1.2-3.el10_0.aarch64.rpm;name=aarch64_ghc-zenc-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-zenc-prof}"
SRC_URI[aarch64_ghc-zenc-prof.sha256sum] = "bdb80342b52f3e423abbc7259786fe383d568b2bab4f63d68648650cb91b89ff"

RDEPENDS:ghc-zenc = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-zenc-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-zenc \
 "
RDEPENDS:ghc-zenc-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-zenc-prof = " \
 ghc-base-prof \
 ghc-zenc-devel \
 "
