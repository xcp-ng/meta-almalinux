# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nfs-utils"
PE = "1"
PV = "2.8.2"
PR = "3.el10"
PACKAGES = " \
 libnfsidmap \
 libnfsidmap-devel \
 nfs-utils \
 nfs-utils-coreos \
 nfsv4-client-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/nfs-utils-2.8.2-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0f7e7076b92a2a5acc343b1d1d04205e9b2e37271da887e703feb8a7e138106"

URI_x86_64_v2_libnfsidmap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libnfsidmap-2.8.2-3.el10.x86_64_v2.rpm;name=x86_64_v2_libnfsidmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnfsidmap}"
SRC_URI[x86_64_v2_libnfsidmap.sha256sum] = "30b7c1b79e23d5eda75a15465513a697d958e4040b0603afa9ca5ed314026444"

URI_x86_64_v2_libnfsidmap-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libnfsidmap-devel-2.8.2-3.el10.x86_64_v2.rpm;name=x86_64_v2_libnfsidmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnfsidmap-devel}"
SRC_URI[x86_64_v2_libnfsidmap-devel.sha256sum] = "1430ddb19915334f5fda45f56dbcb4c580aa7e10b90be8e51abb12330a676e8c"

URI_x86_64_v2_nfs-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/nfs-utils-2.8.2-3.el10.x86_64_v2.rpm;name=x86_64_v2_nfs-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nfs-utils}"
SRC_URI[x86_64_v2_nfs-utils.sha256sum] = "89f0c889afb87524268549f7b4837d5c62a7f0a957dacfcbaec0524d1bc6cec1"
RPROVIDES:nfs-utils:x86_64_v2 = "virtual/nfs-utils_or_nfsv4-client-utils"

URI_x86_64_v2_nfs-utils-coreos = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nfs-utils-coreos-2.8.2-3.el10.x86_64_v2.rpm;name=x86_64_v2_nfs-utils-coreos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nfs-utils-coreos}"
SRC_URI[x86_64_v2_nfs-utils-coreos.sha256sum] = "6f1e55cfb4b380198854dda148455c44b8c00f220772af1182fa97349326090d"

URI_x86_64_v2_nfsv4-client-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nfsv4-client-utils-2.8.2-3.el10.x86_64_v2.rpm;name=x86_64_v2_nfsv4-client-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nfsv4-client-utils}"
SRC_URI[x86_64_v2_nfsv4-client-utils.sha256sum] = "7a477d4863cb0a4817024287f0a5fafe9556b43a56068f66c1f954d09922674a"
RPROVIDES:nfsv4-client-utils:x86_64_v2 = "virtual/nfs-utils_or_nfsv4-client-utils"

URI_aarch64_libnfsidmap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libnfsidmap-2.8.2-3.el10.aarch64.rpm;name=aarch64_libnfsidmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnfsidmap}"
SRC_URI[aarch64_libnfsidmap.sha256sum] = "427601dd753ad9675fd14e04301817525f961b1083458eb3a593ea83f414d5e0"

URI_aarch64_libnfsidmap-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libnfsidmap-devel-2.8.2-3.el10.aarch64.rpm;name=aarch64_libnfsidmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnfsidmap-devel}"
SRC_URI[aarch64_libnfsidmap-devel.sha256sum] = "18f046eb649c99cab5e27ca8a89c1c8bd400ecd4476bd12ba331e2fd46f1bb90"

URI_aarch64_nfs-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/nfs-utils-2.8.2-3.el10.aarch64.rpm;name=aarch64_nfs-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_nfs-utils}"
SRC_URI[aarch64_nfs-utils.sha256sum] = "815efb9c525e477f5832f41a098d046741677c294eb2c130ffc017712ab6a198"
RPROVIDES:nfs-utils:aarch64 = "virtual/nfs-utils_or_nfsv4-client-utils"

URI_aarch64_nfs-utils-coreos = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nfs-utils-coreos-2.8.2-3.el10.aarch64.rpm;name=aarch64_nfs-utils-coreos;unpack=0"
SRC_URI:append = " ${URI_aarch64_nfs-utils-coreos}"
SRC_URI[aarch64_nfs-utils-coreos.sha256sum] = "cae69ce1ebcd33846b8938e51d92a38ff02d8398edd851a7f101d7d3a41e3a63"

URI_aarch64_nfsv4-client-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nfsv4-client-utils-2.8.2-3.el10.aarch64.rpm;name=aarch64_nfsv4-client-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_nfsv4-client-utils}"
SRC_URI[aarch64_nfsv4-client-utils.sha256sum] = "41b64f948fc808ce435ad7a747deae640451ff10821cb9e13a2b48e35ab3070a"
RPROVIDES:nfsv4-client-utils:aarch64 = "virtual/nfs-utils_or_nfsv4-client-utils"

RDEPENDS:libnfsidmap = " \
 glibc \
 krb5-libs \
 openldap \
 "
RDEPENDS:libnfsidmap-devel = " \
 libnfsidmap \
 pkgconf-pkg-config \
 "
RDEPENDS:nfs-utils = " \
 bash \
 device-mapper-libs \
 gawk \
 glibc \
 grep \
 gssproxy \
 keyutils \
 keyutils-libs \
 kmod \
 krb5-libs \
 libblkid \
 libcap \
 libcom_err \
 libevent \
 libgcc \
 libmount \
 libnfsidmap \
 libnl3 \
 libtirpc \
 libuuid \
 libxml2 \
 python3 \
 quota \
 readline \
 rpcbind \
 sed \
 shadow-utils \
 sqlite-libs \
 systemd \
 util-linux \
 virtual/coreutils \
 "
RDEPENDS:nfs-utils-coreos = " \
 bash \
 glibc \
 keyutils-libs \
 krb5-libs \
 libcap \
 libcom_err \
 libevent \
 libgcc \
 libmount \
 libnfsidmap \
 libtirpc \
 rpcbind \
 systemd \
 "
RDEPENDS:nfsv4-client-utils = " \
 glibc \
 gssproxy \
 keyutils-libs \
 krb5-libs \
 libcom_err \
 libevent \
 libgcc \
 libmount \
 libnfsidmap \
 libtirpc \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/nfs-utils_or_nfsv4-client-utils"

PROVIDES:append:aarch64 = " rpm/virtual/nfs-utils_or_nfsv4-client-utils"
