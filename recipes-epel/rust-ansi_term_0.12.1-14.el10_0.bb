# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ansi_term"
PV = "0.12.1"
PR = "14.el10_0"
PACKAGES = " \
 rust-ansi_term+default-devel \
 rust-ansi_term+derive_serde_style-devel \
 rust-ansi_term+serde-devel \
 rust-ansi_term-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ansi_term-0.12.1-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9895c9914749110828ba6d31ee961550cbce799b3ec3e4c7dce34123eabdf95a"

URI_x86_64_v2_rust-ansi_term+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ansi_term+default-devel-0.12.1-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ansi_term+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ansi_term+default-devel}"
SRC_URI[x86_64_v2_rust-ansi_term+default-devel.sha256sum] = "c3283b9ce6061fd0beb05ad3e42710561b5607c66561d5a101de77fefa5566a5"

URI_x86_64_v2_rust-ansi_term+derive_serde_style-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ansi_term+derive_serde_style-devel-0.12.1-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ansi_term+derive_serde_style-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ansi_term+derive_serde_style-devel}"
SRC_URI[x86_64_v2_rust-ansi_term+derive_serde_style-devel.sha256sum] = "e2203cee5169a6066f9beaedab68d91296c42b887f1a0df9198e25c50f297d7a"

URI_x86_64_v2_rust-ansi_term+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ansi_term+serde-devel-0.12.1-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ansi_term+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ansi_term+serde-devel}"
SRC_URI[x86_64_v2_rust-ansi_term+serde-devel.sha256sum] = "6ac5abd67410ef491b73c8799e7150bf4bdf79bc3e55a84e9499548ac0c22f52"

URI_x86_64_v2_rust-ansi_term-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ansi_term-devel-0.12.1-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ansi_term-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ansi_term-devel}"
SRC_URI[x86_64_v2_rust-ansi_term-devel.sha256sum] = "afffba49854896910e48a28a7346ffd55cd2dc6e579e9977fa78980960240282"

URI_aarch64_rust-ansi_term+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ansi_term+default-devel-0.12.1-14.el10_0.noarch.rpm;name=aarch64_rust-ansi_term+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ansi_term+default-devel}"
SRC_URI[aarch64_rust-ansi_term+default-devel.sha256sum] = "47cf632ce8293619211679504440af14d5866f303cadf1a6328c7679be9fa78c"

URI_aarch64_rust-ansi_term+derive_serde_style-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ansi_term+derive_serde_style-devel-0.12.1-14.el10_0.noarch.rpm;name=aarch64_rust-ansi_term+derive_serde_style-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ansi_term+derive_serde_style-devel}"
SRC_URI[aarch64_rust-ansi_term+derive_serde_style-devel.sha256sum] = "904b8d7fdfdf6ad1e18e4aa7945d6772a51b42bd4b01fd4c4324c805b873c640"

URI_aarch64_rust-ansi_term+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ansi_term+serde-devel-0.12.1-14.el10_0.noarch.rpm;name=aarch64_rust-ansi_term+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ansi_term+serde-devel}"
SRC_URI[aarch64_rust-ansi_term+serde-devel.sha256sum] = "18bac90c408900fb02d57b113034b727363ff8fcb6c5511eb8833c08cb7505e7"

URI_aarch64_rust-ansi_term-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ansi_term-devel-0.12.1-14.el10_0.noarch.rpm;name=aarch64_rust-ansi_term-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ansi_term-devel}"
SRC_URI[aarch64_rust-ansi_term-devel.sha256sum] = "4a7ea0ca727a4439d5931d6e077028db302a6ff4aaaec63507210c7d2ed9303b"

RDEPENDS:rust-ansi_term+default-devel = " \
 cargo \
 rust-ansi_term-devel \
 "
RDEPENDS:rust-ansi_term+derive_serde_style-devel = " \
 cargo \
 rust-ansi_term+serde-devel \
 rust-ansi_term-devel \
 "
RDEPENDS:rust-ansi_term+serde-devel = " \
 cargo \
 rust-ansi_term-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-ansi_term-devel = " \
 cargo \
 "
