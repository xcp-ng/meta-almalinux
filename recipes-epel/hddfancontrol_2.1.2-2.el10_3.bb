# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hddfancontrol"
PV = "2.1.2"
PR = "2.el10_3"
PACKAGES = " \
 hddfancontrol \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/h/hddfancontrol-2.1.2-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f7057c65f5bd7f243ccc168bd1150d1e9739582e0c917de63421f98643afbe53"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hddfancontrol-2.1.2-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hddfancontrol;unpack=0"
SRC_URI[x86_64_v2_hddfancontrol.sha256sum] = "d06fc48f787ddacdcf10cf31aa65168ac2e82b71f8f3e132720d8e6d5ced9a79"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hddfancontrol-2.1.2-2.el10_3.aarch64.rpm;name=aarch64_hddfancontrol;unpack=0"
SRC_URI[aarch64_hddfancontrol.sha256sum] = "cc8d64acc61ece17c3a875c6f5d4a8c1c732d5e0c4508cff7c73dec244ce4c87"

RDEPENDS:hddfancontrol = " \
 bash \
 glibc \
 hdparm \
 libgcc \
 smartmontools \
 "
