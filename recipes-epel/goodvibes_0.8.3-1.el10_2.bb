# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "goodvibes"
PV = "0.8.3"
PR = "1.el10_2"
PACKAGES = " \
 goodvibes \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/goodvibes-0.8.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ed37915d6b093c244e8d41b46f9797f61ded99c67e3d977dc4be9010bd1f560"

URI_x86_64_v2_goodvibes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/goodvibes-0.8.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_goodvibes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_goodvibes}"
SRC_URI[x86_64_v2_goodvibes.sha256sum] = "5cb42e7acb3422243a8926fa21411e32e3032735a4b460671600b20385ba5aab"

URI_aarch64_goodvibes = "${EPEL_MIRROR}/aarch64/Packages/g/goodvibes-0.8.3-1.el10_2.aarch64.rpm;name=aarch64_goodvibes;unpack=0"
SRC_URI:append = " ${URI_aarch64_goodvibes}"
SRC_URI[aarch64_goodvibes.sha256sum] = "e5fb7044cf2a7e3f6b2feab083b000d427583947d14354cdb05cd8f8b3a709b4"

RDEPENDS:goodvibes = " \
 dconf \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 gstreamer1-plugins-ugly-free \
 gtk3 \
 hicolor-icon-theme \
 keybinder3 \
 libsoup3 \
 pango \
 "
