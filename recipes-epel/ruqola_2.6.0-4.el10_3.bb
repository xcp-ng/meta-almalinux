# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ruqola"
PV = "2.6.0"
PR = "4.el10_3"
PACKAGES = " \
 ruqola \
 ruqola-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/ruqola-2.6.0-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bdd39229e1c85adc4c70be6b988d73f122b1d0c21ac330a19f260846387618af"

URI_x86_64_v2_ruqola = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruqola-2.6.0-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ruqola;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruqola}"
SRC_URI[x86_64_v2_ruqola.sha256sum] = "34d25e4ff8681b3cb3c062d1f6297a67be6be8eeb6a2439473f1726cefa030c2"

URI_x86_64_v2_ruqola-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruqola-doc-2.6.0-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ruqola-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruqola-doc}"
SRC_URI[x86_64_v2_ruqola-doc.sha256sum] = "4f75f19dead0cce7ac3333535274b67bf295bfd2b0a0ba07733bd7c18e417807"

URI_aarch64_ruqola = "${EPEL_MIRROR}/aarch64/Packages/r/ruqola-2.6.0-4.el10_3.aarch64.rpm;name=aarch64_ruqola;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruqola}"
SRC_URI[aarch64_ruqola.sha256sum] = "32d177de2179f5ed100bd0606fc690d6e1c5d6a7d5d06f576a084c523926c20b"

URI_aarch64_ruqola-doc = "${EPEL_MIRROR}/aarch64/Packages/r/ruqola-doc-2.6.0-4.el10_3.noarch.rpm;name=aarch64_ruqola-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruqola-doc}"
SRC_URI[aarch64_ruqola-doc.sha256sum] = "dd80c68bf677ed2bf3f99c48bc713d638427506e658744fd9aa11c9c53df39a2"

RDEPENDS:ruqola = " \
 glibc \
 hicolor-icon-theme \
 kf6-karchive \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kidletime \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-ktextwidgets \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-networkmanager-qt \
 kf6-prison \
 kf6-purpose \
 kf6-sonnet \
 kf6-syntax-highlighting \
 ktextaddons-qt6 \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtnetworkauth \
 qt6-qtwebsockets \
 qtkeychain-qt6 \
 "
RDEPENDS:ruqola-doc = " \
 "
