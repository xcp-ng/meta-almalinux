# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "unbound"
PV = "1.20.0"
PR = "18.el10_1"
PACKAGES = " \
 python3-unbound \
 unbound \
 unbound-anchor \
 unbound-devel \
 unbound-dracut \
 unbound-libs \
 unbound-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/unbound-1.20.0-18.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a9dadf0b488b26f1ce294216353df26104b1e146295022b1e44d5714072ed8c8"

URI_x86_64_v2_python3-unbound = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-unbound-1.20.0-18.el10_1.x86_64_v2.rpm;name=x86_64_v2_python3-unbound;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-unbound}"
SRC_URI[x86_64_v2_python3-unbound.sha256sum] = "2c5f08f5b0a4e6d85e1a9b39ea400d4e17c58ca4a59021b4b2ca2a28eb717d5e"

URI_x86_64_v2_unbound = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/unbound-1.20.0-18.el10_1.x86_64_v2.rpm;name=x86_64_v2_unbound;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unbound}"
SRC_URI[x86_64_v2_unbound.sha256sum] = "1816b70a8225fb07f04142adeee235a61a8beb46969be46795c0b34cfe3ad67e"

URI_x86_64_v2_unbound-anchor = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/unbound-anchor-1.20.0-18.el10_1.x86_64_v2.rpm;name=x86_64_v2_unbound-anchor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unbound-anchor}"
SRC_URI[x86_64_v2_unbound-anchor.sha256sum] = "ff2c3c7658bf1c7f07514c27182d0975318f35845fbad3857d7d091eff7ede21"

URI_x86_64_v2_unbound-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/unbound-devel-1.20.0-18.el10_1.x86_64_v2.rpm;name=x86_64_v2_unbound-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unbound-devel}"
SRC_URI[x86_64_v2_unbound-devel.sha256sum] = "9992a5b9c9876c590d3e2feb67f6a5afc43b964a9ba69b5d1b6197d4ae3de4a6"

URI_x86_64_v2_unbound-dracut = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/unbound-dracut-1.20.0-18.el10_1.x86_64_v2.rpm;name=x86_64_v2_unbound-dracut;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unbound-dracut}"
SRC_URI[x86_64_v2_unbound-dracut.sha256sum] = "ab247a0e7e14902f84111c53bfb4cb7edfda4366ee25d125ba0b58ddaef95dc3"

URI_x86_64_v2_unbound-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/unbound-libs-1.20.0-18.el10_1.x86_64_v2.rpm;name=x86_64_v2_unbound-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unbound-libs}"
SRC_URI[x86_64_v2_unbound-libs.sha256sum] = "321c3022d6b3b0d7a86e35eea4abca14e5cd909321f6b597c07d0642f0596810"

URI_x86_64_v2_unbound-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/unbound-utils-1.20.0-18.el10_1.x86_64_v2.rpm;name=x86_64_v2_unbound-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unbound-utils}"
SRC_URI[x86_64_v2_unbound-utils.sha256sum] = "e6f526cd82f52631169829919efa5c55f815888af973098f03b9d1ae18139d78"

URI_aarch64_python3-unbound = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-unbound-1.20.0-18.el10_1.aarch64.rpm;name=aarch64_python3-unbound;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-unbound}"
SRC_URI[aarch64_python3-unbound.sha256sum] = "9986f66c1811b9dac91ad98e97f7cf33a9a01365fc00ec78d34ba8a424fb26b2"

URI_aarch64_unbound = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/unbound-1.20.0-18.el10_1.aarch64.rpm;name=aarch64_unbound;unpack=0"
SRC_URI:append = " ${URI_aarch64_unbound}"
SRC_URI[aarch64_unbound.sha256sum] = "96cf78e0bf81817dbd870bdd564b809e728251fefc38ef959a6f0987af04c024"

URI_aarch64_unbound-anchor = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/unbound-anchor-1.20.0-18.el10_1.aarch64.rpm;name=aarch64_unbound-anchor;unpack=0"
SRC_URI:append = " ${URI_aarch64_unbound-anchor}"
SRC_URI[aarch64_unbound-anchor.sha256sum] = "16d9f9fd3f27f38d1992c4a730e151de6f05f4a2e1e5ae541887023144c7c80a"

URI_aarch64_unbound-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/unbound-devel-1.20.0-18.el10_1.aarch64.rpm;name=aarch64_unbound-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_unbound-devel}"
SRC_URI[aarch64_unbound-devel.sha256sum] = "ff51185eb6f9317cd910a212017e910d49c0105a0fd1503effb7a1007bc65b4a"

URI_aarch64_unbound-dracut = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/unbound-dracut-1.20.0-18.el10_1.aarch64.rpm;name=aarch64_unbound-dracut;unpack=0"
SRC_URI:append = " ${URI_aarch64_unbound-dracut}"
SRC_URI[aarch64_unbound-dracut.sha256sum] = "7d03d4db9c2c34daad97a9b2317c76c31e9b0256079d041e00bb1233f37195e3"

URI_aarch64_unbound-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/unbound-libs-1.20.0-18.el10_1.aarch64.rpm;name=aarch64_unbound-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_unbound-libs}"
SRC_URI[aarch64_unbound-libs.sha256sum] = "03b3fa7e6788539e2ffb1359684ae695e8f78d2370a7be366d8d1e68b537dbf0"

URI_aarch64_unbound-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/unbound-utils-1.20.0-18.el10_1.aarch64.rpm;name=aarch64_unbound-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_unbound-utils}"
SRC_URI[aarch64_unbound-utils.sha256sum] = "227bc427497abb5c83c765213993b2e39bfdecd416751d0a9bbfe2ebbe79b50a"

RDEPENDS:python3-unbound = " \
 glibc \
 libevent \
 libnghttp2 \
 openssl-libs \
 protobuf-c \
 python3 \
 python3-libs \
 systemd-libs \
 unbound-libs \
 "
RDEPENDS:unbound = " \
 bash \
 glibc \
 libevent \
 libnghttp2 \
 openssl \
 openssl-libs \
 protobuf-c \
 python3-libs \
 systemd-libs \
 unbound-anchor \
 unbound-libs \
 "
RDEPENDS:unbound-anchor = " \
 bash \
 expat \
 glibc \
 openssl-libs \
 unbound-libs \
 "
RDEPENDS:unbound-devel = " \
 libevent-devel \
 openssl-devel \
 pkgconf-pkg-config \
 python3-devel \
 unbound-libs \
 "
RDEPENDS:unbound-dracut = " \
 bash \
 dracut \
 unbound \
 "
RDEPENDS:unbound-libs = " \
 bash \
 glibc \
 libevent \
 libnghttp2 \
 openssl-libs \
 protobuf-c \
 python3-libs \
 shadow-utils \
 systemd-libs \
 "
RDEPENDS:unbound-utils = " \
 glibc \
 libevent \
 libnghttp2 \
 openssl-libs \
 python3-libs \
 unbound-libs \
 "
