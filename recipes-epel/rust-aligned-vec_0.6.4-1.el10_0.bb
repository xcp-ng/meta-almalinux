# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-aligned-vec"
PV = "0.6.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-aligned-vec+default-devel \
 rust-aligned-vec+serde-devel \
 rust-aligned-vec+std-devel \
 rust-aligned-vec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-aligned-vec-0.6.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2568970176fd2bb77cf8705fa6b527d56272b73cf9e6ad26978fa12bbd687070"

URI_x86_64_v2_rust-aligned-vec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aligned-vec+default-devel-0.6.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aligned-vec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aligned-vec+default-devel}"
SRC_URI[x86_64_v2_rust-aligned-vec+default-devel.sha256sum] = "ef6dc15286be6eebbced57836ce4ae211de92e9458ba7f8aa1367e02da3c4561"

URI_x86_64_v2_rust-aligned-vec+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aligned-vec+serde-devel-0.6.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aligned-vec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aligned-vec+serde-devel}"
SRC_URI[x86_64_v2_rust-aligned-vec+serde-devel.sha256sum] = "26c91e4ee240601d5d6cec30c6bdff2b73b12a6ed13abe402cfa61771f055c67"

URI_x86_64_v2_rust-aligned-vec+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aligned-vec+std-devel-0.6.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aligned-vec+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aligned-vec+std-devel}"
SRC_URI[x86_64_v2_rust-aligned-vec+std-devel.sha256sum] = "067df70ebcbc3045580212614eb63fddd6e5dea8bce3ed9007b2c99dafea9936"

URI_x86_64_v2_rust-aligned-vec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aligned-vec-devel-0.6.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aligned-vec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aligned-vec-devel}"
SRC_URI[x86_64_v2_rust-aligned-vec-devel.sha256sum] = "0517c00c4f0f7a93b7f10360b845c5a90b3b97a4dcd29198564ba46b6e5d49e6"

URI_aarch64_rust-aligned-vec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aligned-vec+default-devel-0.6.4-1.el10_0.noarch.rpm;name=aarch64_rust-aligned-vec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aligned-vec+default-devel}"
SRC_URI[aarch64_rust-aligned-vec+default-devel.sha256sum] = "ce7b07217367bc807962e02a25ae952a721b660ea7edb42186cf017afcb46d6b"

URI_aarch64_rust-aligned-vec+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aligned-vec+serde-devel-0.6.4-1.el10_0.noarch.rpm;name=aarch64_rust-aligned-vec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aligned-vec+serde-devel}"
SRC_URI[aarch64_rust-aligned-vec+serde-devel.sha256sum] = "a5811593cc44caf1a0b35d61b2d8328f0fd0f2ff7f6f19aef32b1b65474cb1da"

URI_aarch64_rust-aligned-vec+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aligned-vec+std-devel-0.6.4-1.el10_0.noarch.rpm;name=aarch64_rust-aligned-vec+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aligned-vec+std-devel}"
SRC_URI[aarch64_rust-aligned-vec+std-devel.sha256sum] = "7afcafd69af29438e186dcab90510e0412c46afb0bca7946d2f142890772651c"

URI_aarch64_rust-aligned-vec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aligned-vec-devel-0.6.4-1.el10_0.noarch.rpm;name=aarch64_rust-aligned-vec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aligned-vec-devel}"
SRC_URI[aarch64_rust-aligned-vec-devel.sha256sum] = "e53ebc5dd704d137f3c91b778df91bb84090040a2c8c3ee93c8b6898d244f2a1"

RDEPENDS:rust-aligned-vec+default-devel = " \
 cargo \
 rust-aligned-vec+std-devel \
 rust-aligned-vec-devel \
 "
RDEPENDS:rust-aligned-vec+serde-devel = " \
 cargo \
 rust-aligned-vec-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-aligned-vec+std-devel = " \
 cargo \
 rust-aligned-vec-devel \
 "
RDEPENDS:rust-aligned-vec-devel = " \
 cargo \
 rust-equator+default-devel \
 "
