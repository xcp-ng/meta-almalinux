# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-blinker"
PV = "1.9.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-blinker \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-blinker-1.9.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec0334195b2ac56e802c934a196461c56022e295da35d4710ce3dad08bf600d1"

URI_x86_64_v2_python3-blinker = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-blinker-1.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-blinker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-blinker}"
SRC_URI[x86_64_v2_python3-blinker.sha256sum] = "2f13f8f6e0aede13ddc414cea10ca6dee68499502c94dd725c5913e8b6452cbe"

URI_aarch64_python3-blinker = "${EPEL_MIRROR}/aarch64/Packages/p/python3-blinker-1.9.0-1.el10_0.noarch.rpm;name=aarch64_python3-blinker;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-blinker}"
SRC_URI[aarch64_python3-blinker.sha256sum] = "65592511ff4756d5fdcf3531796f21c7e0deebe543275163c2704cf6c7beb96b"

RDEPENDS:python3-blinker = " \
 python3 \
 "
