# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libloading"
PV = "0.8.9"
PR = "1.el10_1"
PACKAGES = " \
 rust-libloading+default-devel \
 rust-libloading-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-libloading-0.8.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "13892e2dd9fbb3a0b353f8c295ed59a5c1b1141db61d58bbe2605b78d8c49dbf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libloading+default-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libloading+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libloading+default-devel.sha256sum] = "1270811524a0ab758575e756e1e23f855314e4c8960df83c0d4d579b7f991e35"
RPROVIDES:rust-libloading+default-devel:append:x86_64_v2 = " virtual/crate_libloading/default__ge_0.7.0_with_crate_libloading/default__lt_0.9.0~"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libloading-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libloading-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libloading-devel.sha256sum] = "46c021ca75041dabbff1bf241acaa701cc2905ae468e89acfa5a65961cf9c655"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libloading+default-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-libloading+default-devel;unpack=0"
SRC_URI[aarch64_rust-libloading+default-devel.sha256sum] = "4dc43665cbed4882b9eff33fdfee65aba4c6e95f80b8eb9ed1638f0c7aba4142"
RPROVIDES:rust-libloading+default-devel:append:aarch64 = " virtual/crate_libloading/default__ge_0.7.0_with_crate_libloading/default__lt_0.9.0~"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libloading-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-libloading-devel;unpack=0"
SRC_URI[aarch64_rust-libloading-devel.sha256sum] = "5ac1080e192d724ac38279ca2293eededa8fe0adc2dfee21104c801d0d035a28"

RDEPENDS:rust-libloading+default-devel = " \
 cargo \
 rust-libloading-devel \
 "
RDEPENDS:rust-libloading-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 "
